#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5945441160813183, 0.32172648529838976, -1.1722558300560044, 0.21734836626217513, 0.49918592670786155, -0.4252032271536244, -0.048526557419640695, -0.8224429725055689, 0.674496866382856, 0.2939894147735983, -0.5761670742515941, -0.9727314094065473, -0.5626672442252236, -0.776053752960479, 0.7639080567127723, -0.15133406453162482, -0.7003708720689528, -0.9535390503681239, 0.3544194794699933, -0.017995054220474198, -0.08448799161831949, 0.6137871194123437, 0.5759300619355106, 0.3180740800331562, 0.20895106808593455, -0.7861299100368155, 0.5101327730145692, -0.23624343409972245, -0.8200828945682911, -0.8305088778029904, -0.8936562465083194, 0.1317859822841602, -0.12549130900731265, -1.0543529377934768, -0.4705582872778884, -0.7384737617236896, -0.8586381645901406, 0.333720653176084, 0.6114009657395258, -0.34841763318220503, 0.7281024075323893, 0.09037190205743413, -0.10588755832780912, -0.8958281361300366, -0.8358941289064985, 0.09753362790981125, -0.7953698378073643, -0.7028610181801512, -0.19006840999636415, 0.3399512673723935, -0.6747791506622333, -0.1908215928106791, -0.05118387148842103, 0.34214841387004463, -0.7759805001194781, -0.38421719859122344, 0.911593594581704, -0.39780638191094203, -0.5101040984942848, 0.20792027872321953, 0.4709716042968607, -0.6239560891014139, -0.12346862918996024, -1.006945768343812},
    {-0.024473393885314637, -0.49898380469635883, 0.09512272567637692, -0.7153816321568411, -0.7022460495392592, -0.36586916846381595, -0.4028606070285773, 0.34541774159965094, -0.6937403705583952, -0.7549504618434746, 0.150932051279386, 0.1297839803992653, 0.4720078771882487, 0.46535379248761916, -0.6645073174383269, 0.24505934114164674, -0.06563962902732175, 0.7487094830432154, -0.4636940342893731, -0.14901675317103305, -0.345523731975664, -0.8123323315445701, -0.6116557343301919, -0.17793892823648771, 0.15062956971311625, 0.3346614690595682, -0.4572660387324732, 0.1382680818250791, -0.043942713082342474, 0.14517937754685917, 0.760470222058495, 0.24249015797441406, -0.04548787797908118, 0.16686666985116214, -0.22952113938464952, 0.11274936145959487, 0.730694537678484, 0.3371149351327157, -0.544225821527257, -0.4719958199872402, -0.2621689237717432, 0.41214520000844573, 0.22414951904497146, -0.005458465647091281, 0.3601045683412973, -0.7018331157321098, -0.05544188947226026, 0.037418527933397366, 0.25601086980131815, -0.12167600069943661, 0.12411241452956476, -0.23602986565698683, -0.24604430883116526, 0.08105685758338153, 0.6568398935971291, 0.6794454620744029, -0.4295070805078688, -0.08446869719071548, 0.30962211283101465, -0.24530316486501194, -0.7246900493181239, -0.07939809694820343, -0.25025897929539953, 0.5100974439140399},
    {-0.06840895508419387, 0.38529573357839214, 0.5933731296030359, -0.813857207132365, -0.19946118595283766, -0.12310165816131553, -0.30670475202105096, 0.47393199948665254, 0.40572502118654763, -0.6907521707477097, 0.22783561058935686, 0.6125727415713835, -0.00833102326226941, 0.1957164244155554, 0.26232518258968535, 0.15898136182136194, -0.3232293342600339, -0.4508188634329571, -0.22278375344595677, -0.72829588392275, 0.17736290261239435, -0.04873828617505325, -0.4381292049296406, -0.8130054179329703, -0.4795189273015188, -0.4076500182687521, -0.02511050894294076, 0.22620685975495985, -0.22025295675886017, 0.7020806091503303, -0.08385055515893025, -0.44852880381246196, -0.7550482451749463, -0.1738152484203791, 0.6703498143216278, 0.23296802174809078, 0.6483107722323195, 0.27563066204678743, -0.0718651852547049, 0.277161362256109, -0.1553403740074349, -0.44963187120060094, 0.21801666434601205, 0.605200149034053, -0.13318278929451932, -0.09476743988502997, 0.1611751034215865, 0.49285389996359047, -0.6195502723755802, 0.10490516860695587, 0.4585540072788914, -0.15661233457156404, -0.5808338920583782, -0.01037298519740443, -0.07477785610509717, 0.7011803767477062, 0.19850402710002926, -0.1531366817767568, 0.04695398025518404, 0.1572240067304813, -0.17707236433740142, -0.06527428898975396, -0.018669711345734034, 0.29003678025784047},
    {0.083585764419236, 0.6774772406329604, 0.5891406295445366, -0.6951511453499091, 0.6066934628872725, 0.19903970768649445, 0.11776507583592659, 0.36952883345134274, 0.7279389530263192, 0.16116136343932605, 0.5933583946081998, 0.7046008387063265, 0.3458551274878613, 0.9256749231383126, 0.6793262135952777, 0.5284909139834675, -0.1142021753670418, 0.06309309953086628, 0.38859731140311854, -0.3326010104487364, 0.5864247978654616, 0.1590187305994169, 0.4252993795945739, -0.6348007618255821, -0.5521745505553969, -0.39683157474541475, 0.0818911959020871, 0.10745226151023558, -0.03497097043612285, 0.7543330488861185, 0.6504566073066174, -0.7914155453423221, -0.2994822904873588, -0.28660562818252755, 0.8511543154522269, 0.3657979552936127, 0.28589938583372, -0.21871203451827292, 0.14881432621732102, 0.5153922798853641, 0.17797232572955496, -0.9053006031300013, 0.5190355949795231, 0.568116629017394, 0.4909659599948136, 0.6009665742521283, 0.776254364554619, 0.37575993555264864, -0.2583400299480591, 0.4804119289226323, -0.146970678296595, 0.26085299590857247, -0.2236912122804391, -0.2586864420379583, -0.36538099496992604, 0.09922418188671006, 0.4379633657188879, 0.24239061532228243, -0.2901742999475559, 0.37248365837597674, 0.3228636087884618, 0.34462005542261387, -0.24413994535099848, 0.46587984257672704},
    {-0.43055807232966303, -0.14044976131738074, 0.9362851021989119, -0.566707954921444, 0.39669126902398344, 0.3353100973822948, -0.6209792016794543, 0.46837710382941355, -0.01845702719209239, 0.006726430335661629, 0.4445360125316846, 0.788253276441997, 0.08259902853883164, 0.5063134898374598, 0.025337363077758242, 0.04863989988113219, 0.6333816315741111, 0.4010785188216718, -0.06985425830649561, -0.5885885056686307, 0.02689619870141387, -0.1537710381435499, -0.08483779686654389, -0.7980356538704018, -0.21047521494861193, -0.363990626225148, 0.2542761309317776, -0.37394529331404325, 0.44353555722625326, 0.7745426058036217, 0.27078505067620723, -0.2963685467432103, -0.676275594373469, 0.6115567303164514, 0.6169095215112557, 0.33494875699776844, 0.8024132391620147, 0.10702427834905244, -0.4947723389884643, 0.49951425070625477, -0.5682263328351016, -0.4499254779541501, 0.20208869615969055, 0.9378122422322287, 0.40512885451492825, 0.10588003439951899, 0.48212842594666505, 0.6088501279485669, -0.6740852577829021, 0.02817826543541807, 0.5166659559396047, 0.3588723696799065, -0.3130147442248116, -0.62724968583278, 0.3034095092177758, 0.34429259150724073, 0.26160730291286083, 0.09656154656613236, 0.44768842909402495, 0.14023197387792097, -0.4546824157365593, 0.04037734266460787, -0.3952936013092437, 0.6776880927235865},
    {-0.08963235700705935, -0.09298885769308997, 0.36068808760827503, 0.37198830785625825, 0.26366343366546285, 0.8787875333226602, 0.22964862963492594, 0.6868204594605267, -0.5141345599359234, 0.07905975825130773, 0.9028336078888787, 0.8390371345460237, 0.6265259592437721, 0.6231581544817261, -0.547587293429734, 0.7577273071854421, 0.4794052775486386, 0.5914182348627101, -0.04046112197250226, -0.4533389616714996, 0.6199404843634289, -0.3890191483649828, -0.31774381643290056, -0.3786264079280351, 0.18616356173322507, 0.030684152793482935, -0.13043193436973172, 0.3364336008386789, 0.7828382832541348, 0.9781559193998337, 0.37088645674644605, 0.1532950164527534, -0.31306426220777633, 1.1410130620752137, 0.6522817491511176, 0.6621826295525264, 1.063661437447765, -0.2695171059289343, -0.6425158819055627, 0.9838386217343713, -0.8262569909273461, -0.7088041751503618, 0.298486808451578, 0.9795850252829128, 0.7621532047176283, 0.5301064186803023, 0.6225174982968751, 0.8255252231326426, 0.04357577543365436, -0.5204355913726326, 1.018814445723137, 0.27987351477430705, 0.44109075334557424, -0.5104142741231679, 0.06198143874552014, -0.09240730501475933, -0.18589927204099438, 0.37649410847111014, 0.5568109023851244, 0.17720505591149088, -0.19230809052326178, 0.8050221683888091, 0.27553148532796684, 0.7363533441624127},
    {-0.04122682168853088, -0.15362062024686088, 0.6539119777868589, 0.028518437352504894, 0.26059585197503365, 0.9223601002075279, 0.30435043898236563, 0.9917334272340277, -0.4067852425925953, 0.11285085351167093, 0.7200115151034276, 1.0963034892291985, 0.7725239933510286, 0.7617924313528184, -0.40716184997926286, 0.8404920078822274, 0.33507474749658483, 0.38597622422650973, -0.10662045115081739, -0.20332580633197075, 0.7059282511245587, -0.48446719916543346, -0.3712125158754169, -0.5517536850569524, 0.4576563136815074, 0.15214302553026984, -0.07697682906180738, 0.3670366448080198, 0.8559446185656272, 0.7591440118877126, 0.6261486916131798, -0.10284641061184566, -0.41617927124474674, 1.181940357643786, 0.8710342307940887, 0.8243581249177554, 0.9897072165360539, -0.4531354773386545, -0.6422114906465187, 0.8336116708538326, -0.3420003747582794, -0.615853648773126, 0.35891979239926936, 1.0831939529594825, 0.9111749387935745, 0.5135271645679177, 0.8687968174447742, 0.8701496151864047, 0.22551827550939507, -0.09167082442759933, 0.8783513039361237, 0.7664830137746678, 0.24359453931687558, -0.6024126483975604, 0.23821460516369317, 0.15504372835450667, 0.08314909376193406, 0.4040703942355634, 0.5149178874377583, -0.031044255752118728, 0.10154707599332848, 0.7164810810362956, 0.30730218098527057, 0.6841190153859165},
    {-0.19589079042853402, -0.4114000306417503, 0.505787241346945, -0.7999789258496248, 0.24476431241576152, -0.03660641626357211, 0.1964785000227418, 0.3490427897244096, -0.3487298149099415, -0.17612505084447602, 0.38318189377699424, 0.36279444491575397, 0.2319782429878833, 0.6683880334625817, -0.13514711111949648, -0.013035060604951826, -0.013115317345769975, 0.28676041257448537, -0.016403874016425322, -0.2710816544562407, -0.21562931043796557, -0.5370252920085375, -0.22322760499457459, -0.2816904521819202, -0.4318789212646447, -0.21791876818101547, -0.44231637029568416, 0.21136019282007165, 0.056765502538534345, 0.8026449866785087, 0.16675178415104985, -0.44167140929298426, -0.4850792821496282, 0.25486471510366193, 0.47576185939530574, 0.374233663956728, 0.7731153259288214, 0.2328652473541354, -0.36984081646068206, 0.13911122470617548, -0.3249800299200484, -0.32018996677002504, 0.08461138501478885, 0.605000062238945, 0.34441415189730706, 0.12476558256790467, 0.20292007642512336, 0.4276275672478196, -0.7361640551597691, 0.29427039246733633, 0.03253149426702382, 0.49377747543535966, 0.11835464861039341, -0.6421447223383226, 0.2905920921523373, 0.31386335137819593, 0.3246123192907402, 0.26431961535346293, 0.23026315008654547, -0.22920108370575165, -0.9005655817614705, 0.2406216406005663, -0.20351221634242464, 0.5051742891798697},
    {-0.03205701841106663, 0.08730852865289809, 0.669851110731887, -0.2357598070350641, 0.2760461473106589, -0.3113163974409503, -0.5900258636800461, 0.7164616252664581, -0.3246753873122812, -0.4025008520230069, 0.2497167927049937, 0.48023393085259874, 0.27714954152073706, 0.432498208831126, -0.329635116764209, -0.3791343038080411, 0.24385839082288857, -0.20998798761884255, -0.0005419755265244767, -0.0911394960917773, -0.20086091442337822, -0.2540726697014208, -0.6235135112112885, -0.24138589658906595, -0.5240448712217254, -0.30851301995225494, -0.014492804305306395, 0.12089663407352472, 0.3197945898935571, 0.572402052296511, -0.016879004382128776, -0.7184907957272512, -0.2822319375092666, -0.04199889508449574, 0.8826811439238827, -0.046897769668123986, 0.581435743328432, -0.3792722738327379, -0.7090115159838126, 0.4510589351192115, -0.9325618488577628, -0.02885086984170162, -0.5833303835798598, 0.7043873451682705, 0.05148065339250451, -0.14296570994018906, 0.38318977156096584, 0.5506490043976058, -0.4125948138488984, -0.0979751759817539, 0.46493592275823387, 0.010256448277317387, 0.3409240324934656, -0.334070793474841, -0.14976058047240118, 0.3532720388247994, 0.060269879348236126, 0.2472136481376294, 0.9738859080485157, -0.28289972242244693, -0.7879715987029012, 0.18949030692922936, 0.019995878423988107, 0.3648272230159609},
    {-0.7342283879810139, -0.1357897035969311, 0.11130472209781439, 0.10166258110243122, -0.23604906309403237, -0.07755777934107974, -0.13061846975303723, 0.2561866186490395, -0.6277852551741674, -0.5243265515914021, -0.009887294775760877, 0.13779350839249468, 0.7547028258209467, -0.10135327265105927, -0.4455790519001078, 0.5049993065147311, 0.01851609956537633, 0.6130482897401878, -0.2083533982593863, 0.48145601592949083, -0.6262191080307251, -0.3557207873155813, -0.22359122204368964, 0.6016818708720214, 0.151755105468993, 0.34777021943170544, -0.7814570708264601, 0.7029101042967619, 0.1378772606785838, 0.03157047613809674, 0.07974832409305832, 0.051407225591585934, 0.5755413895756301, 0.4480401653829044, -0.6100664083765681, -0.20768804578680938, 0.3254911511831156, -0.07223331945679443, -0.015411058019905739, -0.37576705023141194, 0.28845500479153946, 0.439745036611753, -0.34215372269826627, 0.20310082469007318, 0.18748239810121992, 0.002126190644994317, -0.21001861037178562, -0.01970548886003493, 0.7375423281815322, 0.19946572715059765, -0.1432407634169891, 0.41557577305890314, 0.5621599050753275, 0.6333771109989753, 0.1359014027489953, -0.17612030176970864, -0.38850246339147204, 0.30670322510200904, 0.09739465688170733, 0.07567711706329341, -0.3931699317970584, 0.7439972307790408, -0.16029378522306958, 0.37255907929744464},
    {-0.8421151198404468, 0.30412678477274563, 0.40119993885886407, 0.19174014303140555, 0.11471236529060762, 0.5527402136282001, 0.45241035088121767, 0.2229849584296334, -0.7126719250252426, -0.370606872454741, 0.15454116147092636, 0.1620788265267138, 0.4311075995352338, 0.17593895944166707, -0.12305463465915646, 0.184829627242777, -0.11477729119057165, 0.6728358791000346, 0.06817923900739437, 0.7377086632436086, -0.07535050903335198, -0.1001418779019998, -0.1471182589602691, 0.14213030653001385, -0.41395214744055253, -0.09249923347798603, -0.6304665050609141, 0.24704753938228036, 0.1064351885614552, 0.36903132991295895, 0.22166989549841734, -0.01705730758097815, -0.09357893608892513, 0.4599999336183208, -0.06839978740866093, 0.35899020203974785, 0.15608479860771293, -0.422415358682906, -0.21809452831752896, -0.07545941256871214, -0.4023991735338957, -0.055156672984830964, 0.11221560399460431, 0.351981748384541, 0.5267740276291922, 0.18420154762885474, 0.30489515988353966, 0.14378973203926787, 0.9194019448323905, -0.4059661805350889, 0.442442470827702, -0.2852491262843245, 0.7420760839330721, -0.11182266245690405, -0.019600806945483544, -0.5682735052761523, -0.05425203352014887, 0.480107022708065, 0.19013624956226075, 0.36417640684774, 0.10542526297832198, 0.9456719769426903, 0.2135760749540682, 0.7961167613768647},
    {0.210022572472859, 0.8952931580829845, -0.2791941984452876, -0.12238914506534546, 0.031742447948573005, -0.4288007286885288, -0.529344693853461, 0.09725507845575705, 0.47642168194557455, -0.11350169622596837, -0.061391976258796915, 0.02488407692529368, 0.568993608038596, 0.03885397040422644, 0.49251559750961915, -0.5068230258109738, 0.023292575133815212, 0.16950753355682724, 0.27442959874955586, 0.19451244711929985, -0.3227325748887802, 0.4640900575889904, 0.2437561574786005, 0.20947315653901205, -0.7437258161097393, 0.5915978406891107, -0.166887438868457, 0.7461271214442039, -0.7349060559298551, -0.5811079733694521, 0.143367624214222, -0.08521929435097333, 0.3465610624442067, -1.086218590046004, 0.28215926652466966, 0.08341492487502068, -0.22356191168615686, 0.133266339853442, 0.4183731153176615, -0.46051508089302534, 0.6256035758745286, 0.4562956824663334, -0.05415234969829405, -0.19523598153285165, 0.08605621714964783, -0.11313932855117602, -0.19822601525977077, 0.16079101230475226, -0.24754270276190926, 0.6909132074266076, -0.6655674479171306, -0.45638548235766746, -0.13296807427641716, 1.1385631404254748, 0.1257086768833512, 0.3126832654108912, 0.30723815969601204, -0.2503249084762064, -0.06714844772838999, 0.007702097158853009, 0.11048675104160077, -0.36533613890683625, -0.40520907543039797, -0.5463118887583714},
    {0.06965866582788154, -0.4378928262603943, -0.48376563640839654, 0.38337384806942887, -0.8012881367169513, 0.42433822869799065, 0.05376421574006723, -0.7476356049123095, -0.8228455639375183, -0.8208586458412012, 0.11627827162795723, -0.0711607543959733, -0.07530377728663726, -0.2792947645265723, -0.5762406076456615, -0.2723121356475419, 0.38398921069297254, 0.08948248705871485, -0.8393515669614625, 0.1948378834975108, -0.1719119073286444, -0.706727294285628, -0.7647336331068226, -0.14641749731691472, 0.6076829126422582, 0.6251571472791402, -0.5011695062400795, 0.2864445724972976, 0.3063893494004905, 0.2055352040455633, -0.520217283134686, 0.4840859926323544, -0.40811434680706055, 0.24190513041335057, -0.46765872211261367, 0.5977638555651036, 0.10551941292045554, 0.21769774705126554, -0.512099297705094, -0.1864786985074083, -0.39851711464962986, 0.5355673653551587, -0.345589920768651, -0.1989919661554367, -0.4808633456570005, -0.3624739166414493, -0.3885577923679716, 0.3827848714494655, 0.4697999491399417, -0.6179349878370904, 0.42921579185695724, -0.13082439963098036, -0.21447289842389783, 0.12486999046572173, 0.7822514135356484, -0.11329538208001458, -0.535278199588095, -0.2991455784698139, 0.4343687448394567, -0.9244005883163933, 0.016018320350313, -0.07662825781773726, 0.2685313320449815, -0.3621508068264308},
    {-0.42571047679478813, 0.3941499132922684, 0.6511385802198175, 0.43980081836935053, 0.02168163776225211, 0.5177609523794614, 0.5493235935843366, 0.7650471813580466, -0.5207637596031605, 0.2479346095911863, 0.7446932241278315, 0.4909191959551405, 0.6487584916370764, 1.082697958776502, 0.2063745379245284, 0.31758544650788234, 0.4359703495431066, 0.37603726378598035, 0.5438511166382297, 0.8298199832886382, 0.7510824579166898, 0.4649053747872709, 0.025943498142743035, 0.6144796623492647, 0.04132901152559479, -0.003956163724357027, 0.036938451197201384, 0.5888518343095959, -0.39420780219838913, 0.319471212859884, 0.9011262969935995, 0.22078615316020037, 0.6381232054892582, 0.6747087437276554, 0.532667594596785, 0.9225854144469877, 0.1405705592534219, -0.9240259418430012, -0.45747763241789563, 0.44860186993679846, -0.011697768966748429, -0.45879548663251424, 0.7375825747194599, 0.647448155733705, 0.8814962894967201, 0.6817971953127477, 0.943436708996647, 0.09582994567135232, 0.9343274285627029, -0.5408453602295988, 0.29126082003123777, -0.20107072144406027, 0.8571780075725526, 0.5968769391369929, 0.2523652716076539, -0.17854330669986612, -0.246659305518475, 0.5755944559956402, 0.3460638605918539, 0.1257073128248619, 0.6213685237949296, 0.9628211380049526, 0.6662341730379373, 0.5566683946292598},
    {0.06611994418334363, 0.10666798541157761, -0.1071237453917659, 0.5037782885675816, 0.3911295337845073, 0.3919603509726926, 0.8221765850606316, 0.31915890086118076, -0.4970412025252439, 0.6101656807731043, 0.7614974689454655, -0.005481290992164045, 0.5427398607878812, 0.727228425019744, 0.05741875433070874, 0.01660031601571689, 0.81691407727435, -0.6397289783663189, 0.49973949503768716, 0.5562511580623729, 1.1795660363447777, 0.06887960015645862, -0.2344233729538315, -0.1595960584481555, 0.17995364247603093, 0.12700133646840697, 0.3597541606685636, -0.2912436390958342, 0.15364008170308627, -0.06351867723345567, 0.4440824964028299, 0.16495512255411632, 0.1527304162437418, 0.7363739158674478, 0.9091628243869707, 0.838972914646908, -0.23712255128713297, -0.558170177721538, -0.4110390203090855, 1.1308403107604132, -0.2045952477019196, -0.8267969788599464, -0.3374612684720135, 0.4497421696883925, 0.23335131892492528, 0.546279080100676, 0.7127254430345673, 0.2449984025443163, 0.5221870307027788, -0.392649918367581, 0.3871247500231485, -0.2377257837912825, 0.061759800228214805, 0.1280658744252717, 0.16419535173325928, -0.9654775316671874, -0.15548271619452908, 0.8348564435252869, 0.5331910444046493, -0.4634800166943005, 0.75078400955933, 0.6366001278525216, 0.6241173164432408, -0.28367253933185393},
    {0.568745401175443, 0.38804587365119225, -0.4676246730764804, 1.0705654324740685, -0.6595931816927271, -0.2451001253741355, 0.4197797363264808, -0.07900023667275494, -0.7669085021467082, 0.028125204223460105, -0.09587463652263876, -0.25986641850794734, 0.1467024013877841, 0.2830768010191949, -0.4627606373425442, -0.42197539319918576, 0.9292628747636535, -0.3190576065468121, -0.5531213152194325, 0.8499419780158813, 0.5289402666652165, -0.230052102569521, -0.4140939224887413, 0.33604709146277284, 0.6315200033028493, 0.5571964317330216, 0.05078723185011197, -0.06292067877513725, 0.39083569636632903, 0.5132764090759244, 0.1423781887511368, 0.6415729076061134, 0.1538734489467393, 0.6223706052778298, -0.04330844850628813, 0.7687078358600238, -0.15672354403395397, -0.45327528458231797, -0.6180782629594601, 0.7735025812098044, -0.27888515986140433, 0.41494286870443664, -0.7112121185294276, 0.044894505837574025, -0.09104821093709703, -0.15551569250100564, 0.2051948967179138, -0.30717890738055276, 0.5532962652788171, -0.7008800042326534, 0.8020166856229619, -0.6069520134437588, 0.2752409064340463, -0.11522711529986668, 0.7366133716087172, -0.518163628020604, -0.6904619953026899, -0.022153150076374462, 0.8039242782054484, -0.9901062260218071, 0.48712528361168284, 0.024577390274826957, 0.4306463540836111, -0.33653266815477334},
    {-0.016080935445161634, 0.4589892653758575, 0.5835982072033702, 0.5795808304460914, 0.5004278384681601, 0.6225054953090295, 0.9123203730772781, 0.8831916603971462, -0.4797667403093363, 0.7345734538646806, 0.6689557527836438, 0.5871414365693658, 0.8635371597832014, 0.8589626595861183, -0.23010575609395967, 0.5171499055077924, 0.36926689573927074, 0.34519098696038664, 0.3610972211246399, 0.8922713548238248, 0.8432692514917038, -0.014943990454116688, 0.03472161758109341, 0.5514200484363141, 0.3165983524371277, 0.44322549006003537, -0.041413242268440474, 0.48863088897222334, 0.12856548213320326, 0.8535879689812523, 0.7684132346011452, 0.1962672146497493, 0.7895892559422761, 0.4589333383744492, 0.9600688893327441, 1.0206594748355151, 0.4341576510046795, -0.8933231200347137, -0.38359933331951845, 0.826710085542366, 0.13681125093407792, -0.4555109826816596, 0.17239936170387982, 0.7782075799533374, 0.9405040290539665, 0.48221576873552424, 0.8050469342163394, 0.6519543906296038, 0.8414611901661287, -0.28368105913436076, 0.5697233800524083, 0.5200326179068279, 0.8433000853401815, 0.03028344382309138, 0.24962855115301757, -0.39933370947707914, -0.035824725830411776, 0.8670832936608742, 0.5253169171718539, -0.061561048352497386, 0.287469041376367, 0.938854011347946, 0.21217628236051214, 0.5062451333619414},
    {-0.040261083670513016, 0.8945785313830749, 0.34980343359643845, 0.21833584120613775, 0.22373423239445137, 0.5828744326275412, 0.645663267134845, 0.8319734602543454, -0.40749197144596244, 0.5883675252236156, 0.7465346539729294, 0.6398631719431722, 0.9050147333220541, 0.5766999535964932, 0.007604232712790444, 0.36120550922060696, 0.4025231573356516, 0.6710121679011009, 0.3923747819810435, 0.812487696684381, 0.6605739076267663, 0.1867545053078947, 0.11924874248881981, 0.3176810986749047, 0.37765058374855254, 0.5685778326681583, -0.024026709222234578, 0.751123819627639, 0.30942822467813524, 0.20679912124269775, 0.4476238201202165, 0.6161906266074783, 0.41104591317352485, 0.6835475802487337, 0.5353557513105864, 0.8679442557597038, 0.2652326892154863, -0.5721873205505115, -0.46349788706593814, 0.7328564134647633, 0.08339773944100486, -0.6927080913607938, -0.4895147394078745, 0.6338289959188916, 0.3281233518140137, 0.5482281255400482, 0.6106202499988836, 0.24053584631334549, 0.5578293808697031, -0.40743810110371026, 0.32044654294197666, -0.21459463749772345, 0.5985409792450462, 0.4187438615711178, 0.0019833170078683558, -0.49681076654552736, -0.5095788132725156, 0.42081727732808955, 0.3776873953353082, 0.23567828254261466, 0.4966763934351994, 0.8496435742521466, 0.6682961789279575, 0.5255530278168082},
    {0.7530315205355554, 0.6643257542749641, -0.0005563079988225498, 0.5506296240675517, 0.3092878733368221, 0.01653011503303199, 0.39967038642680364, 0.30675888306495347, -0.017570257784579758, 0.8425817798628933, 0.4366012566965717, -0.16407150335308154, 0.11232399618887916, 0.2649932801080845, 0.3008127236897446, -0.23153952796674743, 0.17233734168524423, 0.6793579690277296, 0.3404593457590102, 0.3520475887722957, 0.9456354899954704, 0.479296700957796, -0.21863319475556792, -0.3700069962386076, -0.26658740766955585, 0.8687023225449192, 0.21707228399624906, 0.2671812804608807, 0.3166446305685766, 0.026431599332440173, 0.6352008354605903, 0.1838153851548066, -0.08204522484291356, -0.060533002976001074, 0.637742911824503, 0.2447377209888547, -0.1633979685962876, -0.1464842989550453, -0.06286056905984382, 0.4253644918339345, 0.3192152197624568, -0.08522012034699052, -0.14717243574150837, 0.21339209374846602, 0.14952292323846467, 0.3402139224424088, 0.4529015505690283, 0.19773026826357282, 0.05803812234974525, 0.3664442580260618, 0.0001540984762487668, -0.3606617213757357, -0.189651463445483, -0.22571035416044435, -0.04358292769602779, -0.40627699568167874, 0.009798276055117731, 0.16874932830428524, 0.054238166420019746, -0.4898464927601372, 0.5233239734283174, -0.1761909245923537, -0.10902353302282912, -0.3963728241952217},
    {-0.2501527043061729, 0.6134067708105558, -0.15045101452598936, -0.10070819381143956, 0.43166498861756997, 0.19034345708117167, 0.7377620003243808, -0.01083993926621897, 0.23090323789475617, 0.5212752948605187, 0.14546625810403066, 0.14605753721420622, 0.40328319590961026, 0.1937992074904135, 0.3938213633295965, 0.4584538764303139, -0.7049801631677202, 0.6411153620601279, 0.5961921217225973, 0.6876985290683391, 0.1957708450129984, 0.3117673033929628, 0.44913967002300564, 0.2552651091350704, -0.44128097553299894, -0.41685981993382176, -0.019350014616469582, -0.06898505279432476, -0.06918579534631292, -0.5347851811080498, 0.4566431654502132, -0.8268284272207799, 0.25035531622158, -0.2272079532302058, 0.28371267578447124, 0.26152921945712976, -0.14795193248160624, -0.41983455960464655, 0.15746583626202879, -0.3409528048590032, 0.3386106341129888, -0.21830473795897673, 0.9154221780582483, -0.0032501730017194773, 0.5681045125143552, 0.5463104230753272, 0.7272865419126651, -0.07065164309745883, 0.3640716465657543, 0.3081466656516916, -0.15061778774651996, 0.7478117394743101, 0.4197233514942707, -0.09951564975740068, 0.13221406328988597, -0.219682258394672, -0.004497023035233447, 0.6560371587976398, -0.905766993403561, 0.28905479545408874, 0.13952816594902362, 0.41563314039509575, -0.1381123675142822, 0.07009683816662661},
    {0.35589435783397444, 0.4528568243445521, 0.2361754847340772, 0.26535698749742864, 0.7955985819431064, 0.3457788038444638, 0.1270684260241971, 0.48547052651825673, 0.495824905945681, 0.5313412756757403, 0.6847207047382731, 0.41578412063771203, -0.07838900722021613, 0.4250698673188954, 0.6859265472128471, 0.037017080097407326, -0.08289461363947875, 0.2462082090706425, 0.8996363863443465, 0.4291023661928483, 0.6537659800589511, 0.9603321999689817, 0.3525245700519448, 0.04021118340007029, -0.03732088751953809, -0.26609294732505323, 0.7781014748511245, 0.23441844423932132, -0.35626761696576636, -0.12447250866006786, 0.732884788933653, -0.37686647098890813, 0.6018981382010444, -0.16617541109124595, 0.8435235198417111, 0.8925307533970346, -0.3025920918042094, -0.29972272528792265, 0.016290722420821985, 0.3480368992615028, 0.5094967132530027, -0.45977535924983054, 0.4523179983166049, 0.16145114523910628, 0.6627244329263299, 0.549308383815551, 0.6879988300023436, -0.09384617676044843, 0.4250235886558227, 0.3006555800674383, 0.28417059796454375, 0.6186598629721477, 0.14952850725695227, 0.01540733827789702, 0.2005869959409577, -0.2951205245961448, 0.09912344997092952, 0.5988924155036749, -0.1084409770845319, 0.17759483920798352, 0.8968380287111585, 0.21435985002983013, -0.06065649112084364, 0.2871261580247149},
    {-0.7137170022266919, 0.44272726377820193, 0.0036711223771855863, 0.46757116757510875, 0.29456849625691334, 0.49656916218199226, 0.6863789280287599, 0.24638176893185712, -0.1709522150865518, 0.8030756855573871, 0.4343210060363663, 0.1197586548165567, 0.2819894669743039, 0.6941573367639425, 0.3753682103811313, 0.3684044148916729, -0.23830878140936795, 0.34444102678054744, 0.6029562770003934, 0.5656735755082082, 0.663223120725015, 0.4672863314317801, 0.5137597918992769, 0.5788277577006615, -0.3948537253630306, -0.39739157716474555, -0.07258083727874816, -0.052963468722996544, -0.40701770327257286, -0.7577098392880122, 0.852861316711592, -0.007050287761770084, 0.8095120050593866, 0.3931727389797131, 0.47784408566488107, 0.2985774386478688, 0.0008556145468688851, -0.8578781299336374, 0.06765344867652227, 0.31963837482291807, 0.029186469547131225, -0.7006896432419093, 0.5357267711410065, 0.39984039041541847, 0.8410060077758026, 0.740496408709703, 0.6335771730746966, -0.1294289589676492, 0.78997305099816, -0.27537829579984063, -0.32774519892781456, 0.5116227537850556, 0.6047958660090059, -0.18250824843839955, 0.35887431787164187, -0.5664425151911515, -0.14456963161500044, 0.6341052109213501, -0.33258639773976445, -0.072817838972759, 0.42027503234903496, 0.5947280719968064, -0.15755633285443893, 0.39245042371933203},
    {0.4231588760311946, 0.2472985629540147, 0.19605927758640765, 0.07042009953033979, 0.28625941958939255, 0.4209520459776216, 0.49963331495264596, 0.23148945124201464, 0.2649768403551424, 0.8912216322248865, 0.03303527061286861, 0.23368228748167486, 0.5341790403210395, 0.6669200184647966, 0.8193114624580735, 0.29219139961230406, 0.014395739214680783, 0.5143059756995328, 0.7898416634310523, 0.5811401404287098, 1.160130693715706, 0.743600480035164, 0.11365789637301499, -0.2460821873949118, 0.0363150840484451, 0.8132095966834666, 0.7170273045222585, 0.3724432525704703, -0.043884702080771956, -0.5081248783738638, 0.5720966016081888, -0.33229558970421463, 0.5421781000004428, -0.1807080012828679, 0.7272707893428704, 1.0619846722316197, -0.6655246357996761, 0.10128749622349986, -0.05127680547428386, -0.06762881628415016, 0.7189701187934814, -0.14337795231295364, 0.7600957640778214, -0.09292241650794121, 0.19824984782561886, 0.47711747599144405, 0.7155582574337338, 0.3658560889851501, 0.12994047118574822, 0.4188873082120469, 0.034912258858539186, 0.6195499195035667, -0.33612197726343584, 0.4965337290904393, 0.1798393319434251, -0.04549452543149641, -0.0855796062386271, 0.8394752632887684, -0.25108169752845777, 0.21491780983016673, 0.8882468435963465, -0.07799262839013286, -0.3409071315299195, 0.6502449754700969},
    {-0.6622081482912874, 0.11394818558716682, 0.3792114311784623, -0.4472835488912428, 0.2891683806021718, 0.3907366272176819, 0.4288471636827937, -0.17909351238978044, 0.18012496846490336, 0.8342289141601685, -0.1386343048586957, -0.003748012924451659, 0.08147776490716443, 0.03350301964819957, 0.1673047449437399, 0.3182031472637464, -0.7394126194060688, 0.8289456521301859, 0.5003542186620691, -0.1730741128720351, 0.2705233322483004, 0.20960036272647425, 0.7299176034176017, -0.10032772950531296, -0.48099899584597905, 0.02488744748849024, -0.022874604294420942, 0.1805571847404523, -0.44622072435892574, -0.9913432419289545, 0.4192639357168538, -0.43663606512793796, 0.5608518332286269, -0.3472859191507328, 0.3246858248443861, 0.4026254824251327, -0.5399585887124315, 0.12594261009169727, 0.6519176354025511, -0.6461315804581168, 0.7208353152480254, -0.22176740090460717, 0.32663347195024905, -0.5448825222721712, 0.5329462244296208, 0.5310451186249516, -0.08795492413457925, 0.17880866973111198, 0.19464753691272982, 0.18882316804428095, -1.07486841687851, 0.7008379014578306, 0.06321708088061564, 0.14915387013913298, -0.09697081888355305, 0.20504942330606632, 0.25243254994148373, 0.44260442779024867, -0.9740228837450999, 0.602662086233569, 0.30347173202625394, -0.0300375037042633, -0.9276459465130092, 0.38999668561399914},
    {-0.5280715158066434, 0.9002371467087048, 0.4304529946881683, -0.7671475434992007, 1.0561591063780178, 0.44550589262610474, 0.6343049137017203, 0.6639931992850896, 0.8951559658040795, 1.0042463566318103, 0.32126258304463995, 0.7090168887815909, 0.5702054339288752, 0.3962718505940236, 0.9053364381287374, 0.4795075074752557, -0.9936677147084464, 0.7991520005308194, 0.6698985631119289, 0.3308521969339726, 0.23315712759221463, 0.8100826384659604, 0.8391000232433253, 0.5252845913457096, -0.4253599142838802, -0.14216735375352577, 0.7645663393250437, 0.6906541864372425, -0.6125216198578688, -0.8034378228992615, 0.6424958021457622, -0.9891164958382864, 0.6661879202480946, -0.3756279944865761, 0.5161383643938317, 0.24468812195231268, -0.05864258477912868, 0.08241614905975471, 0.7981595263627902, -0.17645125104866327, 0.7871340761030942, -0.022585556442155142, 0.7179270089693262, 0.07834147649422707, 0.8370705910898075, 1.0136240478703333, 0.5823437639947915, 0.37639505640038334, 0.55985419160342, 0.6579456123974614, -0.6176119079435152, 0.6317261549338948, 0.672492568655197, 0.10580073318564652, -0.6873074080164824, 0.4268419530631024, 0.6196253163299363, 0.8563780694202255, -0.6954639472237016, 0.8668986574780596, 0.5961515880242892, 0.7465325319785378, -0.25646979469563047, 0.1476937012060305},
    {-0.03362105108760654, 0.571154316676796, 0.18311500495567715, -1.0415076890255133, 0.9172675028924521, 0.3925133299550645, 0.33538201043397864, -0.24361278459582691, 0.9969419367916926, 0.4644348486005722, -0.2787517483752742, 0.3642771326003294, 0.005523067748390552, -0.3459547453174324, 0.7482156854277414, 0.7828178898535032, -1.052744959680925, 0.5500632061559183, 0.8076547738733384, -0.27144111193273696, -0.04749367330748422, 0.379063080908083, 0.6792976738201197, 0.2997576015278244, -0.57722993235302, 0.06037887475935866, 0.381905614695483, 0.3974271389325951, -0.5483235574280656, -0.5060454446165908, -0.2111181612974075, -0.6696520723377716, 0.5779207215175273, -0.8756685300709031, 0.49476012928842367, -0.35003708485833485, -0.521566711552588, 0.42969133202916965, 0.7828797444324427, -0.7392715745400258, 1.0349903006738064, -0.08036853163120658, 0.491809674138224, -0.6716883887718724, 0.15044847658273197, 0.39888593798998856, -0.049991183420169026, -0.15251860423507355, 0.014181192995537651, 0.751078074665421, -1.1151542174504414, 0.8842228116715789, -0.18650552259743794, 0.583452885255667, -0.55561313344726, 0.47158393886321703, 0.8048475079909295, 0.39153331448476053, -0.9002448189384428, 0.9123272815323333, 0.5521032734969713, -0.30141133982250146, -0.6141496324710166, -0.2485433897194072},
    {-0.3582786739380493, 0.15589139154746223, -0.4259589744630065, -0.18974352509986606, 0.4324149327217839, -0.021042017266850243, 0.49474364413674593, -0.6747688507740268, 0.5205244574395053, 0.6724286777400115, -0.5341170040188935, -0.5281342169736878, -0.020320093193479775, -0.10998090498276823, 0.4562572930163051, 0.09760687263834998, -1.0588017333947963, 0.6899557333981458, 0.586810333223228, 0.23327718025598268, -0.3200455408293043, 0.6513606952607217, 0.7548510704773393, 0.5034446062722272, -0.7017918533338366, -0.19252616560859576, 0.49428631047361155, 0.11328232386164332, -1.0406841943694412, -1.041117242718563, 0.1607271507007338, -0.699197938715769, 0.9596089437966848, -0.939603499486053, -0.1296403669814102, -0.03655512523592848, -0.8521463817595997, -0.1704119004527012, 0.6965386725844689, -0.7115730150834025, 0.9337986739930327, -0.08498779393782772, -0.10604818041333276, -0.49559010984709484, 0.16511049251663742, 0.6376764690053861, -0.19527425963090442, -0.8138485582531303, 0.20874874997647483, 0.09885807518466375, -0.9103791730762916, 0.6506734246376603, 0.5816203779690052, 0.3718072418342701, -0.42089322794698386, -0.19335301023380264, 0.35390686082352824, 0.8060793824172965, -0.8350938503703191, 0.6161218507973928, 0.7184959517741751, 0.18798724868413777, -0.06616105356118229, -0.020932937270682808},
    {-0.624285094409086, -0.13652366406600427, -0.018429538653110415, -0.6467901421102695, -0.10293100131251619, 0.3088998569070246, 0.007973711628283784, -0.36609010236505485, 0.3633066494945537, 0.6099319329933364, 0.028411929416373816, 0.20669508814483398, -0.3228155199630659, -0.5768315674550096, 0.7524229175719537, -0.13553493399670738, -0.8226857305854839, 0.6871430399681825, 0.17575488235390352, -0.7203362204947058, -0.13309595627542173, 0.0024174373879774064, 0.20994235028892386, -0.7518167517914226, -0.5390149867367736, 0.22446611763527685, 0.1994248698296711, 0.09162695299911008, -0.28463240095791753, -0.5425121027157738, 0.061773180348243424, -1.0009346340378646, 0.14514957128848865, -0.855510167374691, -0.20980327592753598, -0.13949573870014503, -0.4771060150811136, -0.14568788314595854, 0.02615923224886283, -0.7568266890098982, 0.35487187022689504, 0.15413680225023113, 0.45961543644304925, -0.9754821472413397, -0.028015100747276218, 0.5684639689442106, -0.3661610777871285, -0.3350440285082853, -0.5036674544087444, -0.41580618702584143, -0.384320001678897, 0.5900280519218815, 0.05392301219363681, -0.04230671404875274, -0.5598653876194385, 0.3890356643737222, 0.6117800727210497, 0.17543380225646354, -0.72014307905335, 0.3611576606655859, 0.5241820869960901, -0.20112235332200487, -0.6827373183522469, -0.344106772325862},
    {-0.6664559817277218, 0.4208326971680742, 0.5334925565772495, -0.2707070102779029, 0.6550662238577494, 0.44799799873015694, 0.6106055470446886, 0.5323837114512041, 0.3269617698923046, 0.8181445334084049, 0.2565180168661916, 0.6311094603209083, 0.31253380202753234, 0.3344027391066143, 0.6286526963937851, 0.5548255545181435, -0.6282610929303443, 0.7891598687994142, 0.6211673925392004, 0.4740654959303675, 0.15288006851524547, 0.7255186647583538, 0.36442551078901975, 0.2958399620325574, -0.5994990143022568, -0.18903985599345996, 0.20807147628787448, 0.7837178111872091, -0.22051559297659873, -0.6646574912092619, 0.5969083553656126, -0.5968024179539708, 0.6949853304799929, -0.4645760707782645, 0.6286370714474279, 0.5715628779554279, -0.20031285679756347, -0.6515287625610408, 0.7646369992806186, 0.018344542523760554, 0.7293166690004317, -0.36567403406022053, 0.8545800119691472, 0.15205994814554458, 0.9861062221388572, 0.7164604972429784, 0.6700135055926433, 0.3896586976306468, 0.43797224299815657, 0.22742241179884576, -0.6934651092461261, 0.9064047945898407, 0.7108249000904333, -0.12760873922097213, -0.34187509202669675, -0.5783115849887344, 0.3618260849771316, 0.724274322577343, -0.7435758097015968, 0.3551566607219448, 0.6164367412444741, 0.6313202767581105, -0.5959558257301647, 0.35331426621685286},
    {-0.5837579629901235, 0.14606727137660203, 0.3387771893643583, 0.1990648167798296, 0.5189220820647598, 0.19875734028070347, 0.10214546591844201, 0.02002980786583185, 0.033765006936401526, 0.6814049377874679, 0.44916303403519214, 0.14194792840562298, 0.3441842399617173, -0.0751505718025786, 0.029738641381384528, -0.5342745042761619, -0.16827118682562622, 0.3890779547422298, 0.6882695364383666, 0.2045312875469396, 0.3539797396385813, 0.21387782530498756, 0.32886189767372476, -0.06449138093587711, -0.6395008561947442, -0.14120386202388588, 0.08380785351479228, 0.2885599343660783, -0.1622483676720649, -0.5338385633107458, 0.33858851302370613, -0.250269538331599, 0.605094437321693, 0.07126589609592342, 0.9084594682980224, 0.24983643135409586, -0.5665811139475582, -0.21906463368028592, -0.5855104410032885, -0.01555315800862038, 0.13889525018436405, -0.26297028027663477, -0.35290567719994553, 0.5149029106661894, 0.19658615856303374, 0.46216450669256154, 0.14181643268329258, 0.017842475921039016, 0.030113726239692527, -0.3940792179514752, -0.29777907828744127, 0.3643917571315164, -0.07278307313401917, 0.2527711761301386, -0.3157798912463075, -0.4941616484629481, 0.4959520546787689, 0.36598694842394436, -0.3315140926194551, 0.1540163745170777, -0.07487825729129283, 0.3894763018707647, -0.3015414863850744, 0.18306761381250375},
    {-0.04023958079666216, 0.5847090933390671, -0.7925523973139105, 0.14018801014164753, 0.2814959659021591, -0.028076449328214622, 0.4914313127501758, -0.7016181159687601, 0.30580763194320043, 0.6059770567501899, -0.8336332425964562, -0.7193790403422425, 0.2651720477327755, -1.174936876111356, 0.39031261114743837, 0.377813130521645, -1.1657669433451925, -0.48383843721588093, -0.525570591828063, 0.13518413221219844, -0.5255745919768539, 0.18295353994548824, 0.2345674774989749, 0.5496544064026675, -0.19412011989535524, -0.9947461082546485, 0.257019236771284, 0.4365902196960999, -0.9422693349120371, -1.144087720169128, -0.7497745878999402, -0.6410160412363685, 0.4235408661283597, -0.863360778185142, -0.5587188175954144, -0.5847952664842337, -0.7055237334921319, -0.10767192727184767, 0.393720222387254, -0.8211767421087789, 0.16139947356569173, 0.017176531636069265, 0.04480650496177977, -0.6243780622295612, -0.34847552916747504, 0.41610099375036563, -0.8996310731816136, -0.6503544106216052, -0.02264407439386701, 0.26425728778885643, -0.8161301012425679, 0.5229410968176855, 0.2176589749073364, 0.1282939348112948, -0.9667554555418163, -0.758418345505717, 0.6738945619178067, -0.3396649832756032, -1.1830357961218037, 0.3741433948972431, 0.24480300169587474, 0.04895780547438028, -0.29853020069272734, -0.3240831497505616},
    {0.31426571264422276, 1.0752590657716523, -0.6978002397687562, -0.1877919276896722, 0.8338146327239934, -0.014511440866487027, 0.21995043337675263, -0.2611545918740479, 0.9103093716714811, 0.2684491310338401, -0.7747610089995137, -0.7253093277483056, 0.31318753705317687, -0.014795481344751563, 0.605688682820911, 0.7029981627005529, -0.9970490925377654, -0.4898748757131283, -0.0429724028923872, 0.22968652610527374, -0.36569244180215343, 0.8146743001591545, 0.375884155907785, 0.628366433806763, -0.7358841301720964, -0.9916905117543002, 0.35896998100921135, 0.2082353326700177, -1.2049290975246085, -0.6599122030523114, -0.5977126421152392, -0.6948651725242732, 0.2931836161523276, -1.091303234734248, 0.43379900800737026, -0.24363242540498198, -0.5567594591469065, 0.056771064919667484, 0.645975833243848, -0.7692977370820502, 0.7272250437123313, 0.02669788426228873, 0.24141102617759572, -0.21584504085074707, -0.23781492532789253, 0.36965416630195136, 0.016869631280929265, -0.5024772711240353, 0.34195524768358926, 0.7786751639460936, -1.0852191159485545, 0.5430564959388415, 0.3696151999724957, 0.7767955971187601, -0.7442782094761266, -0.3437914165041126, 0.7643569880285582, -0.5907582089071293, -0.881223247172554, 0.7761911805312517, 0.30299832366894475, 0.20126947527395195, 0.1973396880859471, 0.18056321152543658},
    {0.11439590501395311, 0.5141371148089974, -0.3642433789277758, 0.6047931235815551, 0.3848798919196944, -0.31640516489057174, 0.3033718294671796, -0.20606010822302662, 0.7557082659429517, -0.06816489318110966, -1.0787938877944543, -0.4322517838657906, -0.1037375978538581, -0.4058970202462758, 0.5453811437393182, 0.47862740951762095, -0.6938965128838078, -0.019475350984670115, 0.06920577179977885, 0.521605451290107, -0.533621477959958, 0.3443805827892195, 0.4316479507309667, 0.7281053383654653, 0.43732171914545215, -0.4407412409557101, 0.4378116545176738, 0.2911595314437482, -1.0245700100403323, -0.35860022457681145, -0.9720131332161385, -0.8180105512234591, 0.3119889178004415, -0.7670893080589597, -0.2376832867067232, -0.5649461557971522, -0.6852555841992457, 0.3059731725892071, 0.4266257803920924, -0.4117418828437935, 0.02153281394696882, 0.02654502112870388, 0.123818397444226, -0.39575488588151536, -0.2531485945924814, 0.5950483739360245, -0.5502792998785672, -0.5903989623128101, 0.4169437770392431, 0.7050782039617003, -0.2919731542115217, 0.3129739391827624, 0.3790755888170747, 0.3043496287011313, -0.5448558004046794, -0.1978841923293075, 0.200098194318313, 0.09275973020138305, -0.7843716229389849, 0.6629457382309349, -0.18741252062695615, -0.06326411701776263, 0.025014371989337262, -0.6331691358637278},
    {0.26105077465580256, 0.415296065987364, -0.3834835080583839, -0.3206155900742896, 0.19059108877037512, -0.32690234580385424, 0.12375581918522444, -0.20948799953255917, 0.7018197589393962, -0.19470990285588977, -0.31642600822212186, -0.24192527687631307, -0.016837747754068856, -0.4435406854336659, 0.880519586573936, 0.2795864296016466, -0.7428589354402528, -0.3252609606749837, -0.28033905420233146, -0.028928248582651476, -0.7888774945616674, 0.7605764400988491, 0.537964435993707, 0.4268294257538524, -0.030826072807511564, -0.6401162694467154, 0.629205832749547, 0.2985181957956493, -0.7250065525056435, -0.673132519419544, -0.936781414175237, -0.6139415121566683, 0.4403332383436657, -0.5649363897985626, -0.33213984947038183, -0.8608939550632926, -0.31161376048623984, 0.4529274155601424, 0.8667350681570372, -0.6086616116439024, 0.4587677311556685, 0.21008783981206622, -0.2241928122029442, -0.4219449907291613, -0.9147592732950389, -0.2095892790753057, -0.7544012492045674, -0.10909841254444248, 0.0005015869816263713, 0.49493523032427517, -0.25990144353807887, -0.38809438765581206, 0.14532303322312615, 0.5448106478753425, -0.9818148640375632, 0.13275145142364386, 0.5713056149154834, -0.5694233405422793, -0.5502629390145106, 0.26545799968668576, -0.007803541504686089, -0.17169074095023187, 0.3083331270719576, -0.8105326540469392},
    {0.6665112084910558, 0.8880846744318718, -0.3766300637655797, 0.14377899067511346, 0.7854380041728924, 0.029855165053000298, 0.8056087943015334, 0.07857150424166204, 0.604116451227159, 0.5250711934619686, 0.11794449103640713, -0.12013175926923113, -0.1963974481710517, -0.26288657421713074, 0.4492602579738278, 0.2275549451420652, -0.5812821537676622, 0.38662717667809016, -0.06984265596088722, -0.002253499481544141, -0.4124527527714495, 0.2233973382369949, 0.3280466591190497, 0.6627962397006503, -0.07673437670486011, -0.08719733683261448, 0.3094260437532298, 0.41477342340371065, -0.19492342511305977, -0.31418297377642396, -0.33578181283611563, -0.30541900944995587, 1.0377339553132474, -0.40437282411497244, -0.15152961391868291, -0.6962170146113035, -0.3559297406707674, 0.05053640778526441, 0.6188890597336664, 0.2156029054821422, 0.09468368439228701, 0.4303535027494667, -0.3801750523946718, -0.09979236866428992, 0.11317671451910903, 0.8640682816467051, -0.4672220880606937, 0.6843834997728204, -0.18634383863439655, 0.3913127334780479, -0.3562717181893769, 0.4177976906398923, 0.6580350579844261, 0.5091412626630588, -0.6428915040980822, 0.02366306209420044, 0.7521274289660428, -0.10668319064969109, -0.28065884274816016, 0.4721236083580732, 0.1483869961574315, 0.09733757371984969, 0.5625584633219938, 0.04828423784042151},
    {-0.13798032729668647, 0.44475825303088556, 0.3311718137433064, -0.6099795302686212, 0.515585810917789, 0.2968435524665759, 0.7562941265551951, -0.028715943788515844, 0.5985053059801185, 0.46044123407723947, -0.5808798006743043, 0.2503853486620935, 0.23762181135249438, -0.3934288023080769, 0.4124693007019339, 0.18405766699467815, -0.08042471283708905, 0.4197277366168061, 0.38542953365091254, 0.392402397000557, -0.5822119408818602, 0.6127214051666995, 0.45554008849673633, 0.8777067143831775, -0.44332543154757664, -0.454480311032364, 0.28674335317765065, 0.3111251748273432, -0.18414130490647923, 0.03493225727649613, -0.18998035599412957, -0.08435447655771852, 0.45452340603191027, -0.560579930740465, 0.3572572151063623, -0.7418994464259957, -0.1539077702593139, 0.7174007908565662, 0.8603383801209196, -0.39595197125545617, 0.4295782185726478, -0.08167848073524013, 0.3274332442928143, 0.020237265818429665, -0.12556609070604585, 0.2867509903868037, -0.7333857265024458, 0.23186098452998066, -0.4115500184175075, 0.5876280093176867, -0.1908242971808276, 0.28776157635306376, 0.33190587610193945, 0.37412514631775307, -0.8850677650701883, 0.16777728830150077, 0.40993752592551347, -0.32834924409029353, -0.30662625026645274, 0.7438659524810753, 0.11899617288723227, 0.345681235290853, 0.08630088898708237, -0.018192818578031452},
    {0.19755092418489997, 0.29487138305698907, -0.3353330472646596, -0.222014879332956, -0.019924771556242324, -0.4463796835442165, 0.43357242409009333, -0.14003444873177678, 0.47823826862086927, -0.46155544574758933, -0.2602460862084444, -0.24202514805130543, -0.2825562409461581, -0.3022397787909307, 0.4045629129849959, 0.01622527631969828, -0.19037719435725922, -0.26689403944627527, -0.12857347627702045, 0.3154334812832428, -0.15861594844240243, 0.14738644655920122, -0.1910465812742999, 0.3545025566451635, 0.30594752835212163, 0.20322216822061498, 0.27999498652260363, 0.5340852140287404, -0.3366920575724975, -0.6986627200011242, -0.4696560502391613, -0.38691425215278336, -0.392302954533713, -0.14804279129660577, -0.5645044222045627, -0.3809871513215548, -0.5084339152982388, 0.480621761691061, 0.48568683427515347, -0.1981953725439737, 0.0696997453827408, 0.2508311813984017, -0.16383821837726306, -0.16122085297081312, -0.5663123438811605, 0.2919020317922156, -0.17759677847286076, -0.07870002665119236, 0.2955807834984363, 0.6691056770282418, -0.28351119205240166, -0.3122926708320171, 0.42999312573578524, -0.0698070856040036, -0.71567574113195, -0.29287858421019214, 0.09027306490164048, -0.25031266767342997, -0.005502727324888283, 0.5216839739620894, 0.1442481873542989, -0.27085897465342, 0.18425097946652708, -0.606925727301614},
    {0.524613775684004, 0.5459028221310753, -0.08652041502481413, -0.3127252359995166, 0.17796117523400523, -0.2160797933344384, 0.5675254159975728, -0.24144148090605702, -0.2382198341744509, 0.3488342278630428, 0.07152905129615295, -0.6746576693082441, -0.375661484325744, -0.4346353946366436, 0.02328414998207819, 0.2626819498143766, -0.09671243404946418, 0.039677045399349416, 0.07235964879745689, 0.15458252029570455, 0.2093701102966576, 0.12281374083119899, 0.21226259027358627, 0.26078678590149873, -0.22213474607561, 0.18380059851883618, 0.39465448732756553, 0.39268045765409637, 0.011105818127949427, -0.4325350923037623, -0.4572640544481143, -0.6337657240747793, 0.31203447594601597, -0.17666927142897063, -0.5156624394884708, -0.16704966400606755, -0.5171789253298804, -0.19465542988275525, 0.1271118405126864, -0.3945614960082087, 0.38440965030929447, -0.12595010276078314, -0.24857309968939637, -0.4268287174913249, -0.10498132400293128, 0.49230840152748134, -0.4777310442411822, 0.3287321942867922, -0.1004997346849977, 0.605771759970893, -0.42011915909526526, -0.24973649078549362, -0.4278271026571875, -0.1885789744230399, -0.7052831083923713, -0.11723695291686854, 0.3230007822331401, -0.07539821484262559, -0.4824737483407303, 0.25741977817404516, 0.04837806715670769, 0.07725337027012538, -0.46074798438645437, -0.5967866786398056},
    {-0.036019839642459604, -0.01042830834353809, -0.540255211245479, 0.1168005013022645, 0.2517900372359984, 0.2663342084578804, 0.2912012783818969, -0.02301311655994094, 0.046377870299974006, 0.02369452429537056, -0.6915124340509631, -0.20129683902338463, 0.3705603748479908, -0.5001018694332228, -0.025551844983179837, -0.05845459742355155, -0.5004807900816943, -0.14756256778992607, 0.00764509702871272, -0.11862754854499463, -0.2894890342045303, 0.2122591730539216, 0.09317918199759133, 0.5881952312562952, -0.4617122853274502, -0.9158527509408434, 0.001318166006443511, 0.33280335383986354, -0.5976808926261757, -0.1709184447723585, -0.09670002802223682, -0.36804164716213855, 0.13111452826704992, -0.7518777688949115, 0.020856089397839884, -0.23812551699737652, -0.05088733439700808, -0.4723600712855309, 0.12590349007150106, -0.26797569461651705, 0.030399736349630148, -0.1361712758614729, 0.0038523051405858935, 0.22385118352629, -0.2126388235852315, 0.2565273322959225, -0.4043159596485665, -0.08903057149389945, 0.13476739410300395, 0.7392875901337997, -0.24191585050491982, -0.17551577580889702, 0.14295848875651204, -0.1137685444588748, -0.627082133087316, 0.1137017867460685, 0.08883592904691094, -0.28455635363567133, -0.3611750749994038, 0.756496943115786, -0.09512909167453096, -0.06331164057870825, 0.21064349336342747, 0.12899118726132278},
    {0.37458056951014346, 0.5521715405850591, -0.25570357393957194, -0.24255065264594042, 0.7036170754458205, 0.06768502679554293, -0.15431551653197711, 0.011053690706315117, 0.2840626141499296, -0.09320722415343051, 0.1874954005799284, -0.3518727726594368, 0.06600093749321403, -0.2641692923059592, 0.20173306826551388, 0.23648276951564476, -0.008453878325529811, -0.05737022987175324, 0.38676286037957414, -0.13885053254712137, -0.46129382373365235, -0.5668713953015551, -0.1533274355009282, 0.6323946413399848, -0.008492188702145307, -0.6923346573396901, -0.19930386233897956, 0.3057156994396259, 0.05645347352098225, -0.2957899398514267, -0.20940807746154502, -0.24665436114713152, -0.23984173091921054, -0.2586347560899251, -0.30749582322860336, -0.2177606023136758, -0.03932307391872746, -0.5273654368975462, -0.11774065322905285, -0.1868927344026669, 0.22082123213539553, -0.30182536033876445, -0.34086569619973905, -0.28726754373475544, -0.18445445956254392, 0.1653212051886468, -0.021712164040238142, 0.1277190131335929, 0.05648377046073751, 0.392579565185241, -0.1977909911142576, 0.06279074570223024, 0.6124319066034661, 0.1950093611392184, -0.13447991624726707, 0.02841175894588854, -0.4491818512909532, 0.4230498826537638, -0.514518547193065, 0.67592790387215, 0.29257346839909526, 0.41852189456692585, 0.31266732221998333, -0.18449873562895241},
    {0.5581167135990744, 0.20720919726815626, -0.12538191483607733, 0.28641891761201566, 0.010650079063431852, -0.14295073665382443, -0.03426300786190406, -0.28877136318764834, 0.5552969291768761, 0.13091756365408658, 0.2018419831041958, -0.12211199863989525, -0.027381356864471906, -0.561639555198819, 0.7915069003263808, -0.201813727983133, -0.25195869942639476, 0.3029530522476104, 0.0191005181577231, 0.26410984376801644, -0.4800550289283724, 0.6847875922811961, 0.3719037687076946, 0.6615817824320009, -0.6326038544018924, -0.16838245286796094, -0.05853080596336664, -0.18343919101363904, -0.20244192779628042, -0.08059144897186059, -0.5196356143714751, -0.14217263937782273, -0.2337412235481418, -0.3266860753091787, -0.5836419196791442, -0.10809704197064299, -0.7327338349894139, 0.3414335501443713, 0.34081847944596044, -0.4901676970162076, 0.5808350866563999, 0.5000395468613812, -0.16023040668631905, -0.3731211682386158, -0.06024087570016451, 0.2906477773903872, -0.6271548108934366, 0.3254189140154764, -0.5627860625727574, 0.5959839689034394, -0.03447314108771663, 0.42839629486814557, 0.4016182619027956, 0.32249585262249775, -0.1495645459758958, 0.09799326457894778, 0.5169767731791096, 0.15365068178241967, -0.12119944135712642, 0.35666967316224935, -0.5057223574692342, -0.15960787360533144, -0.1969364221343974, -0.37425002351780184},
    {0.25704938110816905, -0.181129918846193, 0.41025502000133984, -0.2997006604020874, 0.29075223676310086, 0.21993397236269033, -0.02664855060082051, -0.3363806111300151, 0.09266382742989202, -0.2270688233749261, 0.3143733713652986, -0.09731908836303435, -0.4653762143398155, -0.4400847193524162, 0.6736444659269524, -0.5058902302091052, -0.23113348014085183, -0.008833530561388608, 0.48974721048490877, 0.48119629939713005, -0.02023162839494677, 0.6254603622374848, 0.2121477048696378, -0.29000330550451914, -0.5567130480056355, -0.14773441881427973, 0.3901223336520885, 0.26262747117507107, 0.0864230714913289, -0.12221280568765779, 0.03957698941822936, 0.04224944738229088, 0.2821287704506956, -0.1811215733737786, -0.1357640932589549, 0.17094862333829922, -0.010293143800002614, 0.4679521234558887, 0.591802729416244, -0.31137850664637745, 0.7737143464383709, 0.10956318659091395, -0.1778897999719648, -0.34043178178636546, -0.15413288635844777, -0.21059111646098364, -0.41469369414266016, 0.018331173357258385, -0.1454437478346654, 0.10247606804162425, 0.286766609346883, 0.27426303069986024, -0.20748894441762436, 0.5334818984540347, 0.44830514949804046, 0.5345079265287653, 0.45038906714209775, -0.48832447134911666, -0.38868969859162944, 0.15106192207701746, -0.3563157814861255, 0.11852382744598168, -0.4170577349839853, -0.7068154132356549},
    {-0.0721599013498567, 0.3594262971121264, 0.25007362201493766, 0.14969210019627013, 0.156293357916057, -0.6791041857918663, 0.4106686127942592, 0.18093406561847172, -0.22062506985435063, 0.10727893281283535, 0.1192500410813829, -0.43589599857808137, 0.17579949215431137, 0.02094830702573583, 0.18312408399277877, 0.33423738669570113, -0.12280471005823654, -0.3437617909608786, -0.3036530972841102, 0.4071775728953435, -0.2308407071817036, 0.28012302786273807, 0.20922806758935747, 0.07461517457574915, -0.059819291292262614, -0.5443960123607622, -0.19804139111712812, -0.16724019171452517, 0.30034150932564563, -0.30305032988431396, 0.6786142128994832, -0.5273443257205053, 0.03246606940430235, -0.29808508565814545, -0.2552865111595021, -0.20876809933118629, 0.3807689879028025, -0.39895158370077005, 0.22817618560067507, -0.4650016326219037, 0.259916769205161, -0.38624232685352905, -0.09073599502505146, 0.4239496382404775, -0.2746085785974606, -0.24363065723180827, 0.017388672132562153, -0.1417774438183345, 0.05468359905046574, -0.039734718279188425, -0.14254988257578563, -0.05205488485922619, -0.012540902876620914, -0.03546163553130761, -0.4360738442530416, 0.37305487687927513, 0.4785320306373121, -0.5432739426403774, -0.004479229634575785, 0.3017620949061562, -0.271457367544066, -0.042080579630825066, -0.29231896655277884, 0.052376666068633},
    {0.5465900350034666, -0.2328111185842001, 0.26676893610571484, 0.10183845679034126, -0.4623748799508733, -0.5216533916583194, 0.39262490956138335, 0.03651799329635328, 0.26962571824630704, -0.06438375110904325, -0.29102115416081387, -0.38758881007738233, 0.011433440007131404, -0.1456739512161527, -0.03308043927682801, -0.11337264189948268, 0.5762619436142432, -0.8902727336448614, -0.3294779713507147, -0.16158013527482062, 0.04179671914883716, -0.09624762713770832, -0.04517409204310908, 0.42305166058680027, -0.3413676605346228, -0.10453395434915241, 0.033968215622701595, -0.2697727500011665, 0.022003754490971503, -0.3206008928117417, -0.4964742645532189, -0.301998704463272, 0.10414940554681235, -0.30290202073136807, -0.036303923800066966, -0.33573204956865565, -0.3411996140481598, -0.026675279052244448, -0.15545399326648435, -0.0977290091564072, -0.060651217686032405, -0.10529790979271361, 0.0463652137489547, -0.857011103731505, -0.5636050447389753, 0.6735264481082565, 0.5823776918760624, 0.06321039688609799, 0.28635493964445313, 0.5363861002834526, -0.32784170762507636, -0.43604006155934966, -0.4567562284905405, -0.2267399098817616, 0.07466305256794681, -0.1965874144313849, 0.12131868896569403, 0.18472089946815318, -0.0751047538937241, 0.05577810313488163, 0.0513822651560507, -0.5057058308660878, -0.5499225818247648, -0.48706452767109726},
    {-0.041627738495751285, -0.07635281930753655, 0.6987402351133658, -0.30771187552046386, 0.4606489336850937, 0.14889476562793494, 0.3852445535832586, 0.4978567911950184, 0.5098798492410856, 0.09777382369854319, 0.2414184234556828, 0.19544498508468652, -0.347325024286718, 0.3485484007737008, 0.3815647515615094, -0.0020999781266823783, 0.4681500023908911, -0.4537099122911044, -0.6575722560970108, 0.07068738921789267, 0.3014604600340091, 0.05814334910007835, 0.2273624733028195, 0.08421013869851446, 0.25830950355542054, 0.14047996582358088, -0.0845849702799803, 0.1628610478890191, -0.40292366046524597, 0.2701556652192543, 0.2727330077055323, -0.1917099629336119, -0.2453510264935463, -0.42219679153366824, 0.3074282165739001, 0.4431858318440051, -0.09615448505530959, 0.5767749919326418, 0.19223409986223605, -0.4750771244419373, 0.9072448866769304, 0.13176963985594364, 0.21583269429056842, -0.45866370708108384, 0.0428510900661553, -0.6678839340133299, -0.3722630493131488, 0.2848473599095023, 0.5528971578602023, 0.41640445806473314, -0.0719006396163009, 0.6969638905060516, -0.587609647257652, -0.0963762526352415, -0.2674363063156754, 0.4773390177055267, 0.2759569849587417, 0.3604157045751515, -0.36121376096433844, 0.5092719097866579, -0.46644696151722714, -0.07221703330275867, -0.17371003480939584, -0.10726746017006035},
    {-0.8843761398750654, 0.33933513930831755, 0.33780556702423536, -0.048360205821023405, 0.22946519711825672, 0.409929399579125, 0.2023518557922745, 0.28824525219275615, 0.33351653227281697, 0.38384635428814434, -0.03799637793306321, 0.1431300435407958, 0.13935740647288322, 0.4141004759091305, 0.4345087058715215, 0.4564039800078859, -0.23103894957807974, 0.5768024496461043, -0.06647383602230718, 0.22182415584399584, -0.5259616639966608, 0.24908638962415627, 0.20476879778971993, 0.07023058693846106, -0.49875531158014097, -0.01529467555947965, -0.11524089174685732, -0.0930487700463149, -0.32395890013712497, -0.2570321398496184, 0.43880799852889896, -0.5129969004457141, -0.18303068244163515, -0.402716000617888, 0.10536469796594095, 0.5401361261690337, 0.01980306692252154, -0.14915319498419313, 0.0662184580063461, -0.6590060982691404, 0.5479938689212213, -0.3479380080557408, 0.21201909184706322, -0.26459210660318006, -0.06364158308495708, 0.24199020687508296, 0.28564013105916475, 0.16988824178287246, 0.12976446431160502, 0.3679323323260148, 0.04133272556190507, -0.09006673481634402, 0.2622824457237263, 0.1267208867848916, -0.23245524716639598, 0.05462457137841334, 0.2605120397846298, -0.43761194143594273, -0.621003655137922, 0.25325878678243374, 0.13682765265001615, 0.6050717515338316, -0.2552999341188907, -0.21372415930015667},
    {0.4740844465895079, -0.2182492685003153, 0.05217037676589853, 0.22899969454438923, -0.5054368870651142, 0.06804495788943225, 0.1951119030985285, 0.157694644399018, -0.1990948167150412, -0.44974331192201056, -0.3240442497745323, -0.5630612764385093, -0.4583250004668005, 0.3751096497387657, 0.9525150660006223, 0.3155075399565186, 0.03519134687339088, -0.128448294328067, -0.05672420323143761, -0.34792254895423014, 0.08074694012200007, 0.26373557521216934, 0.31638635097617523, 0.11666540860856753, -0.258017750140825, -0.057044060501189604, 0.83735549464733, 0.08555760122318705, -0.5387573952300306, -0.29225470621887584, -0.11886950115870305, -0.730988423574578, -0.38989345572425643, 0.04779267804136806, 0.4127249031041042, -0.007849910787043769, -0.21283774815456277, 0.4057456942021901, 0.09158788374023448, 0.1729483834204311, -0.05161226540741339, -0.13401042068793673, 0.1053849566382302, 0.6870228869882296, -0.12312419234323208, -0.3437624928651133, 0.07064503875194114, -0.21538446460503735, -0.24136524807382542, 0.4528904210928918, -0.2977162245072882, -0.1995318067727232, -0.5447659489685475, 0.04109188127395352, 0.1990834658724841, 0.15710035351947738, 0.510662369593959, 0.11585982998783005, 0.17458245346951676, 0.5439030886592645, -0.273273727204641, -0.13461639741980094, -0.17805290268168572, -0.14735593415923237},
    {0.09443483356021905, 0.15903952875341842, 0.24240391769995773, -0.2260426577316826, 0.3129755340284053, 0.1789930922418638, -0.19689744543981733, 0.01136062347057006, 0.24452568693369764, -0.423865071591881, 0.03810858841287316, 0.11185119509894356, 0.007073712336620788, -0.027694759202449105, 0.5079625111152536, 0.4050478359667636, 0.1201381787912153, 0.18577845593448494, -0.5731839803898116, -0.04987332332066911, 0.17217561917190993, 0.6721366006372081, -0.08176497497734103, 0.344674699213738, -0.29541406875088255, -0.02647135908197902, -0.47593647244290965, 0.12130339548576194, -0.4265429814302953, 0.12374577418168403, -0.5747667909234743, -0.21381676216389384, -0.41345322108849236, -0.4729757679698443, 0.15268325110629408, -0.2713332430687304, 0.16369030894834138, -0.2375892984808342, 0.22358358170334974, -0.4086346400233017, 0.5207245727609553, 0.4808672457805984, 0.16306455059840522, 0.21229224937298163, 0.19817924627275146, -0.4305737549323229, 0.37471216901237175, -0.4053096268420225, -0.34619863313424004, 0.4138740993874558, -0.01300021382187701, 0.8334548782803893, -0.7007366005723819, 0.17768108153408124, 0.564051405561694, -0.0338865750680977, -0.0801281057419389, 0.10088501289113479, 0.3934151719582909, 0.1486796766746748, 0.6205437588901698, -0.3151013710965212, 0.15760730031289436, -0.5110151262450441},
    {0.39050503106857165, 0.41309486007027874, -0.27392574135759357, -0.5388994929594911, 0.39061633425132053, 0.04420975637720589, -0.046028741654986556, 0.28318778759685365, -0.07270586629684106, -0.7298865752318116, -0.3745884811907355, 0.2956357256380546, 0.07749501751189487, 0.07610378484770894, 0.24425291866804677, 0.3931297282292038, -0.0696654838069448, 0.26400016564245804, -0.9426568661300953, 0.3416360601608928, -0.019459035487991546, -0.25227183486381627, 0.11412789731521818, 0.018327412549022183, 0.20138930064962524, -0.1455141401426332, 0.0868047417638476, 0.015848675660173197, -0.1699249496225494, 0.26810190671647444, -0.1505988205375061, 0.30162543491733035, -0.20763040397561602, -0.3746686732452407, -0.052181009006265607, -0.3617326447829295, 0.4214764596182387, -0.03953448629463096, -0.06770716550377767, -0.6214989249773459, 0.5120811963695062, 0.5103698959242142, 0.09041072307356801, -0.1668762722048869, -0.07753387899759807, -0.42453379091641985, -0.23821646349059195, -0.11963758842413882, 0.3284198863092373, 0.16901853344511122, 0.2447903426161055, 0.324912325651416, -0.2986169629952948, -0.5831497744429013, -0.28492702225323147, 0.6126741945993964, 0.07904073244357308, 0.10748624044967751, -0.2660535296680365, 0.2841221737909549, 0.28375392184230364, 0.2734782547506896, 0.22024094541881362, -0.576825221965628},
    {0.48494125115057934, 0.26939482773881257, -0.08717595498154859, -0.4925723457410491, 0.3394271953893261, -0.1670601542976421, -0.09557755296453882, -0.18369158197497537, 0.2387477532516294, -0.6936365818185474, 0.3967423102444646, -0.2416947654675994, -0.154445284854923, -0.09359791212889775, 0.7074357108997787, 0.47827265538225755, -0.3833014069415645, -0.015854626861507733, -0.44243080783187644, -0.5408118494382758, -0.10033144055069193, -0.21094142354029036, -0.13295552922173898, 0.10142763096087538, 0.10300364074602915, 0.28507262438837455, 0.5087719023676569, -0.09123296371200847, -0.045270775946817055, 0.5020503895521218, -0.04988877237423589, -0.6431090601144208, -0.24763620928294106, -0.45595255688312686, -0.11242608671215507, -0.3150202685194035, 0.24584010484193272, -0.13707393022399367, 0.14327645768356892, -0.5341324901980959, -0.0512960642691418, 0.240973380923627, 0.12006355203224026, -0.2962720828016387, -0.3839017701798538, -0.3625882561183974, -0.06030836896062908, 0.3696503486641624, -0.16986249000183853, 0.8308505072310066, -0.04954478081765669, -0.10663843247816407, 0.08393008610344205, -0.2088854195180285, -0.36071082972619334, 0.6573958824524878, 0.13811156309411432, -0.050599359271064064, 0.24543533249279334, 0.316739950570076, -0.2954089830686601, 0.27707820167952735, 0.4446745755483202, -0.4646327432635637},
    {0.5509878614277925, 0.09529461619861937, -0.14317107660681516, -0.19664543233635606, 0.15410788109600645, -0.13853633442640734, -0.7604481987822812, 0.15554064485145025, 0.538061393542776, -0.3258391044870434, -0.12326296489248856, 0.07274647804941953, -0.02608167319909533, 0.08358452047516865, 0.3323396912331489, 0.6223791853347549, 0.18842581436546377, 0.1739680714369168, 0.20777327022416034, -0.22028386602833563, -0.03872725969105334, 0.17632080797807756, -0.03491733359049654, 0.11673523704255127, -0.5892783327882252, 0.10590281045937779, 0.3066528232937194, 0.32820452059661037, -0.01865680650510923, 0.3419615779171777, -0.0009713193170002633, -0.18310701141778152, 0.10522495678841771, -0.18995750829278107, 0.2463723197122733, -0.04355426928640814, 0.03839853414975509, 0.5134325620300514, 0.24190369318462815, -0.012591505466573288, -0.7119615981620393, 0.3758460980235974, 0.6293135662102306, 0.3182550433402975, 0.4687041890417623, -0.03390070476876541, -0.6529944213249597, -0.12793643576071456, -0.5966955170717624, 0.2072224415839322, 0.21194839222934064, -0.27132837052554765, -0.45802931264915164, 0.4608180764154994, 0.18128430363988562, 0.5493800512053617, -0.20865781753682253, -0.25097330692361763, 0.4575874328234726, 0.30884636773239316, -0.3995366819576675, -0.1075505869672713, 0.3215185796022987, 0.02420070480230429},
    {-0.04100879942392683, 0.45833610964779614, 0.4003760030932804, -0.16265634230710047, -0.04032861453738567, 0.1533668172023124, 0.08269820214839003, -0.17758526596843582, 0.32530033072959763, -0.1384007352625386, 0.3112968586600268, -0.09294172826795759, 0.7994024727133995, 0.321231864068863, 0.2708660578505014, 0.3255492378484097, 0.1639687042927436, 0.5760590571106773, -0.06783521392043154, 0.08163081484442737, -0.008536948355326935, 0.12215783303010883, 0.13844813204012069, 0.5207832466135436, -0.3832698617746293, -0.11577208101430374, -0.8413736257376533, 0.5345393017052223, 0.4733588605880754, 0.2332402921405781, -0.1355139575336427, -0.19319615435423182, 0.07896165366028589, -0.10334492297505982, 0.26605092049672063, 0.19988260073229533, 0.2524599223141546, -0.12519066007262367, 0.2514860608000316, -0.047757611128361604, 0.5505077727983825, 0.06642895461162665, 0.44455026313371787, 0.03565205919748038, 0.07758898411009704, -0.45445717830623844, -0.021330763141129274, 0.43801232189710554, -0.17974117764449815, 0.041165366022138224, 0.21018656133637317, 0.24773041749628893, -0.22781916613316094, 0.43445248907479295, 0.22450186574295164, 0.15196007510745016, 0.40332695738794755, -0.33864910692062616, -0.2723404402430076, 0.042858991209219884, -0.4349975827180451, 0.31125621594334607, 0.42073191028367735, 0.06276605843878799},
    {0.47401233049638253, 0.01981313585275557, 0.4580019507821058, -0.05897848887773325, -0.1810128570764874, -0.24528398196066262, 0.17654830611675815, 0.67487065059534, 0.40152264899884227, -0.18138401388095715, 0.41733563880812913, 0.6730477560491605, 0.3484070360747996, 0.03366078025508686, -0.11509490725745648, 0.17270481440782104, 0.18968888930403466, 0.42956620062480894, -0.09683431236657182, 0.46805319425397546, 0.1975610978636766, -0.10414066350126969, 0.45277716916183625, 0.02523334031552433, 0.020856330216489485, -0.0553443324708159, 0.1005148488104125, -0.22709215161013127, 0.11852416480619346, 0.07487876810000083, -0.3237103503125563, -0.2656645155281102, -0.32534393764470076, 0.16258370091520052, 0.12834942784993814, -0.10055474656556534, 0.02221093372874849, 0.13142486925301305, 0.04915678535730884, 0.15439376918239242, 0.3259221573801039, -0.13631166815820736, 0.14664455302729373, 0.26693922439551987, -0.486108657818569, -0.5423285461984532, 0.20173537821402152, 0.6547090196316789, 0.08349951692554308, 0.2610671183218391, 0.4178069049883777, -0.3200152248776408, 0.2236868793839188, 0.4272296415722781, -0.10808240953770025, 0.5091227079992192, -0.03443689724910384, -0.5212492548091653, -0.03071606444242552, 0.6657081368236186, -0.15300065245891342, 0.16477815676021984, -0.05173343308740826, 0.47397590618585644},
    {-0.5000456569640487, -0.3257013681293377, -0.3071604561823672, -0.2672911761191316, -0.2912126360881409, 0.021330618266455433, -0.5728972206105294, 0.20651309625417677, -0.3682493917254626, -0.2775460553538228, 0.2854520633051707, 0.3841396721848317, 0.5056524563100019, 0.7147628331882224, -0.19176535608698844, 0.5190471641737936, -0.17566367184111012, 0.24883385199392774, 0.3943471055683172, 0.4804531169280264, -0.1809643043681913, -0.45346278456487626, -0.4738174331809207, 0.33321658367215323, 0.38952341302941446, 0.7087498970039948, 0.027163963405826337, 0.15120441921712666, 0.07503459149723904, -0.30648774699264114, 0.3447573550885549, 0.07946664201605483, 0.5306256533113141, -0.15256928652120905, -0.09583948242803493, 0.7560847487641332, -0.3543225599621, -0.24348775777361878, 0.00623274568643668, -0.33325133100701004, 0.1520114613074898, 0.15812855644146026, -0.5114169277223577, 0.6656072699570488, 0.047215874950337314, 0.2574832483893283, -0.10071941312478955, -0.05754853628788648, 0.5603622926634, 0.5367965562079946, -0.049830818454336595, 0.4776873314866495, 0.5164058686225927, 0.7781661379782738, 0.5976802386242742, -0.17169992040133544, 0.1897261963767333, 0.2472455063289538, 0.22744396036358716, -0.4726283137226692, -0.22505640074433952, 0.6961343373724583, -0.23762100912090428, -0.3003188011019702},
    {-0.8417765958883764, 0.22599013375506402, -0.019519523070083485, 0.41303707196793565, -0.45997717514179365, 0.6499079361834577, -0.3709650567559537, 0.654361166155121, -0.2168057581678132, 0.39443329270427396, 0.018770083836745326, 0.41113975137823294, -0.064223175650284, 0.6019436869048925, -0.18858194670061404, -0.12612038325425817, 0.6042507772398525, -0.08238083032560073, -0.07676513776741146, 0.09381314026742153, -0.3411684374354, 0.30119260218016175, -0.26908613158267225, 0.1039272796039963, -0.20181717650935513, -0.6675508633428935, -0.2861524617526794, 0.07422969367112718, 0.3614725052689602, -0.24950056795472045, 0.03102269181054543, -0.43287698215753845, 0.11038220522390987, 0.6448424630409398, 0.6447207709987177, 0.1743835600792559, 0.1004479351655038, -0.7096609911998978, -0.030163382888041355, 0.2086752012961356, -0.013474729394853332, -0.23038690906959058, -0.5771178563473224, -0.1007010586489491, -0.013125639110687847, 0.5543890594021155, 0.2259070547198688, -0.21177561582447138, 0.03195021627645091, -0.1347594150812505, 0.21780983804788057, 0.5009200414697786, 0.10239611304407216, 0.4856500855433953, 0.34565230667852065, -0.04969320162035098, -0.46312075070849845, 0.19153290550904445, 0.17087475846598896, -0.39905288111148174, -0.49610654963306405, -0.018946395258122112, 0.24094989814729323, 0.2864968141609395},
    {0.00842493375030559, 0.00965722271180567, 0.07280994997893979, -0.5081150728740736, -0.18345564674326648, 0.5482194373033458, 0.22538075334362623, 0.39056642109233314, -0.18365068598273732, -0.19817895997250468, -0.0174519079012678, -0.38662216757368323, -0.2633655317966939, 0.5488860159369929, -0.02625282302419507, 0.6390876806748574, -0.057666676146018434, 0.37040094227982173, 0.4334129295557913, -0.16972459409087148, -0.09796859900463378, -0.17505445805512, 0.0228294931434069, 0.01254084667586308, -0.07428035642916596, 0.334428986230063, -0.26348731266373954, -0.3760028046137313, -0.49573906493406167, 0.189818565887518, 0.5291539837278958, 0.18441882208184443, -0.25265436004407943, -0.1755231326092275, -0.6528808810053504, -0.020810986755285706, 0.7123691610261939, 0.42999827393890483, 0.3755495411720558, -0.11882703339790525, 0.31993110374831446, 0.008551011693683759, 0.6332694520696854, -0.5608234659679833, -0.09323386679202583, -0.043942662894447225, 0.5044595936513173, 0.4159527694608713, 0.10430365147753164, -0.14056154457747388, 0.05181413190452348, 0.10451206894413047, -0.18851802889720135, -0.04448755336953892, 0.3449739874913657, 0.4300419327283952, -0.1986573857373055, 0.2617713623218458, -0.05754159040433242, 0.43880020064288644, 0.2802599996979597, 0.5768452799355553, 0.13112472788031632, 0.005990541356064159},
    {-0.009569630261903142, -0.041150533361023076, 0.03315501357518611, 0.6779721906343636, 0.2962098051386557, 0.6056481500870114, 0.5686011541685376, -0.45361974624519735, -0.19699910951877433, -0.09438037557551161, 0.18740780686640138, -0.8695606478858539, -0.07031421071994474, 0.04822039315016577, 0.09879867220584818, -0.2114047362028768, 0.3859799981829487, 0.5102698384893259, -0.17862652756870412, 0.12708840152993914, -0.285032421073516, -0.10885928471398683, 0.04253819288939058, 0.42494777491954633, -0.3140712054425545, 0.10791258979262498, 0.17453765001249827, 0.6280915481967814, -0.09807145856384646, -0.6424453989011065, -0.0317074204273443, 0.1379487564064481, 0.2790397296609802, 0.0656646045719269, -0.05423920642774991, 0.2618620134439173, -0.48038830083516837, -0.2620045412229154, 0.48413580779246446, 0.5258031996536778, 0.13329031033289704, -0.4325583842347197, -0.43557136267483476, -0.08693753872781505, 0.10748706091464681, -0.07308710068725159, -0.0015219512267066813, -0.01414762143945498, 0.4681903237696496, 0.3403631704494875, -0.4599324752817767, 0.01217603156617754, 0.6458968473560798, 0.26031247094107546, -0.7499873220771816, -0.6399876769370905, -0.21257330056314513, 0.1318286887480843, -0.0020697796912208946, 0.06968832787022934, -0.2527930362475765, 0.1815685138338655, -0.4065472344038984, 0.062309755376775425},
    {-0.7582273224222896, 0.5004276873474379, -0.38129629648360736, -0.2119475112303935, 0.41808341202060223, 0.4148521073911743, -0.397136817151091, -0.09271655593751131, -0.061093870169842364, 0.24097988386377706, -0.16030180359713522, -0.056978443233503075, 0.07334969525450405, -0.019267540617451773, 0.20609059512051547, -0.16639512782575627, -0.06870991207382764, 0.394719103597152, -0.1211195538179679, -0.47925901451129954, 0.20037626917174808, 0.5227086046755147, -0.20846399315121558, 0.2229599967360197, -0.2733893043760173, 0.0033780507327142773, 0.35699806104234094, -0.2365814648672716, 0.008352945521733478, -0.13726819766287165, -0.018073124903243382, 0.13034088387659903, 0.5594161269981717, -0.1446960020643152, 0.23724542718607772, 0.15026013606023203, -0.3758893405762458, -0.6770350015627656, 0.2889934377832597, 0.04339054623260732, 0.23828402780729266, -0.07121948527360922, 0.037180575855281006, 0.1415215008031345, -0.14459129328740683, 0.16179222306241675, -0.2761900795491349, -0.3302945157862079, -0.2187845358858254, 0.2611057958592679, -0.24400757460214456, 0.7312538842087488, 0.11112145554935796, 0.843976492383932, 0.28873946349820684, -0.24347596867133375, 0.3078801174081011, 0.8165989827653887, 0.024672048017305416, 0.018268508351468527, 0.7921043099695019, 0.4733363558866714, -0.008136772437103838, -0.10944901422587361},
    {0.125370798214997, 0.15549618177875582, 0.5345309739047829, -0.23919828078338734, 0.6865422050005787, -0.04434641555719643, -0.18687901893691097, 0.62958937579403, 0.3663335865490964, 0.45166775133939613, -0.5406159821212477, 0.21414702480008455, 0.6621068033654771, 0.7223075653796674, -0.21450455418262665, 0.5721734623099871, 0.08112442499551575, 0.4613599619447574, 0.16533096656117185, -0.1833034788077907, 0.10489528768754774, -0.1646701104663343, 0.6975933492921251, 0.028769296190065765, -0.4870751826931208, -0.11124568997462876, 0.5548595260229946, 0.8317095980643159, 0.4526198222619921, -0.07475544953831657, 0.4906265212133051, -0.5975284168869602, 0.2475222179255473, 0.3285696225664658, 0.5799991233439515, 0.6190666094387843, -0.05120095192589352, 0.4158579625982409, 0.6546523996018982, -0.03683107212848795, 0.4768166990906844, -0.1823118842416293, 0.10618146347867334, 0.33027405103770685, -0.06802614885770804, -0.2212675854236691, 0.35826653501904115, 0.39781985030281203, 0.6852479931193121, 0.34709884304051986, 0.26495145781048246, 0.30539877410558236, -0.14841185125798667, -0.3730093749512381, -0.6655829538054755, 0.398522155117202, 0.6775387770947454, 0.20327195492996694, 0.012184348612976363, 0.513097984028387, 0.30222964112203077, 0.3379194441829125, -0.3628424233944828, 0.06639163268534518},
    {-0.33386864554568835, 0.27417378475347487, 0.18176878125464216, -0.26085102493827417, 0.35517654450105457, -0.09563314514089546, -0.13958580714516713, 0.23523491538193256, 0.4180641209570411, 0.20988018594612118, -0.03463562310985217, -0.0794356480837075, 0.3935773086423959, 0.1814311970968432, -0.27007133543102446, 0.28223412894776506, -0.09304216293580361, 0.10071679736777664, 0.2691749413773833, 0.01517409308421191, -0.0499612716425995, -0.13048744425864575, -0.3594501406806299, -0.019537096993530966, -0.4280394674687261, 0.5694450792085546, -0.5019555482978412, 0.37026595587886196, 0.11867358279243449, 0.26009270255664985, -0.04694483965824608, 0.010148653634928338, 0.0021120137619660036, -0.21271523574218115, 0.4981758794185414, 0.06854829278697376, -0.22461284478252305, 0.4305786858418522, -0.07246087554651966, 0.3920451834572167, -0.058510521841912175, 0.26979775373838566, 0.07532274245697412, 0.4361586288477765, 0.3839114927630341, -0.010393298438403876, 0.5388238055380098, 0.13475368741583052, -0.33488809040643586, 0.04997126002014614, 0.1813681754138895, 0.3160738832030519, -0.0570465640170077, -0.34261548185720214, -0.2924861898049453, -0.18762676831720937, -0.5188600097150198, 0.3860621079211379, 0.10662259596641935, -0.1368402990367324, -0.1932724638638666, 0.10605340706992715, -0.07108449855963508, 0.3445630965644523},
    {-0.21301793831565158, -0.36948362558163356, 0.348068650389694, -0.07989557826340801, -0.21909701534572815, -0.175414973207877, -0.235037186761693, 0.23972541333478678, -0.2348472147220718, -0.10177045202171843, 0.16766586803549918, 0.06852160385759028, -0.2523687464329994, 0.3871694388337027, 0.05406929344805354, -0.3191333091787812, 0.4395896431096345, -0.14633881458689688, 0.33802052465870863, -0.5615976431871188, 0.299489473376986, -0.21449006848418223, -0.11485610962870578, 0.03837655484568488, -0.4122260737648265, 0.17486663670141056, 0.21381671997828047, 0.40659182870943533, 0.05039151738523918, 0.1914865441712263, -0.04167406839973652, 0.24212354639332392, 0.2856533242805002, 0.48985403957825846, 0.11479072110809893, 0.14237368076632395, 0.2437206751587783, -0.35816661599657035, -0.3991830553339655, 0.30543508081153675, -0.3474995912614934, -0.5532158535449554, 0.5639155059754591, -0.4913221003425738, 0.554948570641434, -0.18911267906269602, 0.10387494932221607, 0.31574363563292024, -0.019702151791113794, -0.13379741342755355, 0.5033637340564147, 0.058212772088947165, 0.09630362893777251, 0.060371510206076916, -0.061454004823335705, 0.19121177786112575, -0.21767700929689013, 0.4256287013827839, 0.28928735781945597, 0.35493799216323385, -0.18298711449506005, 0.27338155821556803, 0.1901463574838139, -0.1830518349298311},
    {0.5711768356073581, 0.32478008525643987, -0.5026353598915253, -0.32779028484008726, 0.03783540440147583, -0.10691716745774636, 0.2904493850375413, -0.18222648656613696, -0.22575071803234525, 0.19072213858350007, 0.10911235711124545, 0.15334456321816572, 0.07950737047633255, 0.2384391853283196, -0.36174410580671545, -0.23254408712896424, -0.04669714815905566, -0.38781245282850213, -0.11051572268005094, -0.3736494887070092, -0.6580982694843565, 0.21911224842028848, -0.2872143158371074, 0.10646040587408194, 0.287804461910201, 0.6119897899497985, 0.35550640488254587, -0.1070523819010299, 0.3120183772675004, 0.23951859789441796, -0.28371888694823677, 0.1823005664796208, 0.17246884899720752, -0.04092425999919224, 0.3217250251211305, 0.014284989138172274, -0.5091910050114719, 0.5490486394369231, 0.44159289700274074, -0.21732069657726363, -0.4785311993883524, 0.14420271831014184, 0.16018036960677884, -0.16027799958210254, 0.11068040164186733, -0.26218426940854733, -0.12638448424693655, -0.23493957786528763, -0.6439811220480326, -0.0872595784719314, -0.1816319352089197, -0.11672515479967682, 0.2993485260413065, 0.20434304201111964, 0.0948230974751493, -0.45482236657501646, -0.255360737611681, -0.0691248645962738, 0.6089143552907752, -0.42904725225760393, -0.09818947998210222, -0.33011504728480484, 0.034181135023786904, 0.0590418219071654},
    {0.33360142409871946, 0.40172769938719627, -0.37183298033103157, 0.38762354640384383, 0.5040104941930835, -0.6873553004215731, 0.30343870663835953, 0.12565070302706033, -0.03928463795419834, 0.13579903722434392, 0.5551755571154968, -0.07524162245954509, -0.15295330975293425, 0.14321079157795874, -0.1226719403850478, -0.14794139094571682, -0.04365645694126938, 0.34664042758447305, 0.1228280946857045, -0.1473971378382779, -0.23129108106864832, 0.3328011495312521, -0.25688125918020593, -0.09500366773812002, -0.33060654531082406, -0.15629829383301375, 0.19157252058809926, 0.3174464388244051, 0.36202378408948377, 0.2740645596931043, -0.1656080843425758, 0.07123874948708181, 0.31224360337008916, -0.044664245840036323, 0.06876917953455208, -0.08697856746645975, -0.2530316135856457, 0.7506914861139873, 0.05297681954048133, -0.26512144293638035, 0.045069547716699, -0.3808422955856114, -0.08268922441896821, -0.30347124458514174, -0.3908960206782604, 0.18360286107988788, -0.20152349572562545, 0.05946820641203408, 0.001340105539703706, -0.3387190101314594, -0.14334555934722382, -0.14490091808372682, 0.14262219882588298, 0.10611128013786858, 0.11606466358381391, -0.3460681810807869, -0.029619990056012773, -0.48524011370378883, -0.46565404746998607, -0.06861506129578726, 0.22635191256011758, -0.24418595499367984, -0.1472764560121717, -0.09730515897817159},
    {0.07268197730638323, 0.6649492393479336, 0.20571974942449925, 0.3116400549900298, 0.3602001185439, 0.34970543283202876, 0.4069676300384289, 0.16235538816246922, 0.15933724455016948, 0.011779139984929516, 0.1604005510778068, -0.19041953777766846, -0.16990451166391968, -0.08241859493838367, 0.25580088888362695, -0.21095010227598707, 0.35721343719898546, -0.21435138816273583, -0.20812541514640193, -0.03841147369303821, 0.3602680529104113, -0.008829609174121466, 0.019201225360633904, -0.16210507600674604, 0.08380590673354892, 0.13314353080110958, 0.015544272672083337, 0.10128786476751314, -0.3168268356198687, 0.24565989829427728, -0.6566688477270862, -0.3615925028621224, -0.25706778397264174, -0.5188779979210575, -0.06618978464182347, 0.14397791605007246, -0.14774068706233118, 0.2621528359324758, 0.15194866608928792, -0.36676582471842056, 0.17947771132823692, -0.420341695468848, 0.04687009590203608, -0.3143006527792906, -0.5838313207037953, 0.543528023698708, 0.40785884605111905, -0.031159175135213362, 0.4954112256077541, -0.3654325413446822, 0.1287029551326568, 0.07519669857634523, -0.25197331617839164, 0.33111230376637973, -0.4194184960042883, -0.10013670136751464, 0.056000553983024226, -0.17638406795299705, 0.06681913625011739, 0.04111186792836109, 0.3020716771035004, -0.5633456090123979, -0.024724821333117222, 0.6226290220620084},
    {-0.22394857755400593, 0.2562415415172698, -0.346040770428571, 0.035625302974411334, 0.23082964797832053, 0.23767871517790873, -0.0992978079725197, 0.14492657164497577, -0.1439501304214547, -0.5297581398572461, 0.25105797173687616, -0.4956053351764103, 0.10292894996996685, -0.47854531492905306, 0.036431464796153674, 0.08527000907080573, -0.0832561344271206, -0.14468249443079875, -0.06928293651921016, 0.3749294224856462, -0.2504594852192001, -0.18247377945086796, 0.21737594564946924, -0.24863929562103396, 0.009357241197937712, -0.043288926209638125, -0.38632140448908303, -0.4511403252938555, -0.08742308290507617, -0.38367354011494054, -0.4010193478514662, -0.5492526812356674, -0.38447623203374254, -0.5083329493573086, -0.08677629683708532, -0.007495775831163093, 0.24235787378701507, -0.4141033579513971, 0.04878510036725411, 0.17398360835893875, 0.15499437843297628, 0.30132456779734124, -0.4167278981861258, -0.21960658595044458, -0.7858903664567489, -0.07584671095957089, -0.2687638973649412, -0.10173557501454283, 0.5433405833438919, 0.11231954931929992, 0.012450588334597907, 0.2355980214055953, -0.5736929406655772, -0.21331425321278016, -0.26033177461654894, 0.23639409286603183, 0.3558176531454545, -0.33841249690368286, 0.04074104171450707, -0.18743354439756266, 0.10581790847419739, 0.213094345877607, -0.25995317026989206, 0.09168762344841333},
    {-0.3303017188983982, -0.2770291518441653, 0.45706536334089026, -0.3839145150018282, 0.33416912858387765, 0.14458725598750488, -0.6935496656145149, -0.21454520701638102, 0.17957044205361083, 0.098421974126948, -0.5807593923397908, -0.055235787881892186, 0.4075833302312023, -0.3304347968175334, -0.3274247725448859, 0.16140904451799834, -0.15025535112010793, -0.110874706135775, 0.36014196490182393, 0.49185891297335654, -0.4961036399551111, -0.006344645919068862, 0.09797985803637452, -0.04759510196566475, 0.2349765279287934, 0.012716316528235152, 0.01202868225808083, -0.23703122942835983, 0.5567580665745234, -0.0189939421902305, 0.6488503212933867, -0.08252164950884225, 0.04938952756361405, -0.2686435426735945, -0.0633357455862317, 0.0573303262211266, 0.5045906310830699, 0.05808557280318166, 0.12676103727278965, -0.0014558094282090882, 0.159279298127746, 0.21697921057050965, 0.1809772226229185, 0.13444746074997566, 0.3205999634473744, 0.24005767168447972, -0.2559762715558094, -0.23613177222827378, 0.2182451903690273, 0.11062067120988026, 0.5832552844336322, 0.2682891138016779, -0.5800024519920021, -0.2769286697549957, 0.18587378677828623, -0.12235647998419483, 0.6472098270819953, -0.19358818045279585, -0.30908326165596545, 0.017392638161131374, 0.0308742541648664, -0.05320977036704701, -0.2297559428021957, -0.2497908449470246},
    {0.1411143829685075, -0.4917186150055385, 0.33330900127208235, -0.4438722239141044, -0.03112113284172283, -0.29994445788396595, -0.012231520542517726, -0.314795588122357, 0.09876648595104748, 0.036143488859379146, 0.028365468629828826, 0.02397897608608023, -0.0020240620301666965, -0.6418730276968203, -0.04709012143135638, -0.0398451293532657, -0.6566638411795814, -0.08135821867090735, 0.4032748309158596, -0.015545849349805069, 0.1635409447697018, 0.47068547938823685, 0.1767956857860048, 0.3833620867136525, 0.7306434941335884, -0.2073573615090455, 0.07475747007023677, -0.0627089515311088, 0.5077044821852323, -0.4622885336655414, 0.3442934358034392, -0.2369659760964615, 0.27318581514546725, 0.02939370312862488, -0.18512146602031065, 0.5216416567547241, 0.4549367980686625, -0.3315965165237835, 0.058404548492878246, -0.377409016128052, 0.45533518430335435, 0.5230710273900145, -0.41804161875032236, 0.2901415502727742, 0.532807997690645, 0.33325893767056636, -0.4462800580557587, 0.5245462743470322, 0.22896708341841865, 0.3632955351351714, 0.18359142308385318, 0.09301001240025727, 0.20943302978364692, -0.545776546270524, -0.1725107062554018, -0.34856939377702123, -0.149237187739578, 0.10799073181824094, -0.121143884328375, 0.3153949369972875, 0.1872761953626554, -0.3722919800378095, -0.1771398190945369, -0.19113539831257678},
    {-0.0551429945540354, 0.06334369863538794, 0.10179764489754259, -0.14542990467624628, -0.12685810568744435, -0.4113053383937522, 0.4518336913585012, 0.04616216682359412, 0.059534360119978064, 0.07653229151540399, -0.02687410534897015, -0.09092362158914497, -0.24141536251629162, -0.5370829077985252, 0.5938395285002409, -0.06673690165892443, -0.6314387536129519, 0.06975628771223126, -0.07061351723139421, 0.17971002483155235, 0.09310888955773838, -0.0034207032376072075, 0.20891702761320716, 0.2132743685965288, 0.37628298216120454, -0.22641871118841542, 0.30808228986099134, 0.08839217537176662, 0.04097257899939177, -0.407295784388563, -0.3796396311487801, -0.5044964534386543, -0.25115472141572304, -0.04184323085100829, -0.18564160652979894, 0.31724432839224864, 0.0766697884792861, -0.5744647703226718, -0.3261351638893277, -0.5466989642136669, 0.08009079464557554, 0.19071599969774944, -0.3056034166789476, -0.3630116358798057, -0.11991762582099544, -0.31635713156838, 0.1560556940878867, 0.6499192895688347, -0.2057524366072586, 0.5891786153730355, -0.21969911343446172, 0.4342081221548593, -0.11464885911042784, -0.37334861982329715, -0.20455936885382453, -0.3762024242862697, -0.46711235707420345, -0.010127311026367913, 0.04931321241344965, 0.4743326386195498, -0.32148093360997987, -0.573448231072733, 0.3343141427182399, -0.1156634816041805},
    {-0.4975816582754836, -0.08060238087331441, 0.6475087184627818, -0.24157706018811667, -0.06474634317679084, -0.11121794587045392, 0.42601040313653055, -0.34976708851578925, 0.20170648063899002, -0.14207548266000436, -0.4335487576760576, -0.5544241410524682, 0.09991048684839135, 0.1225161790507341, 0.43800795817871396, 0.01615738388073189, -0.23581446597687394, 0.04149431765339951, -0.30866955966818393, -0.07724570978305895, -0.034851930011676115, -0.5543964995551819, 0.2214336585858862, 0.09019464972035328, 0.2659794796208671, -0.22278408581302603, 0.05950422574477436, -0.5533223055851719, -0.08778894733486499, -0.1793999022263768, -0.3401995447506266, -0.4545955159459111, -0.25085710852326054, 0.1227726102593803, 0.02350200210179182, 0.11681333552112086, -0.08982709237353166, 0.09508534408953292, -0.1087415336204598, -0.1460066368861357, 0.21292071115190742, -0.06646373685555529, -0.39534980726001634, 0.3550328104869109, -0.010548788484361027, 0.12480500108722209, 0.5136804948277366, -0.10382147167970641, 0.6980318379444928, 0.3114050920735821, -0.28077046648567633, 0.20854615288163778, -0.5439198563622288, -0.1358216636794361, -0.5099212694347701, 0.04266916984958329, -0.5830927862933051, -0.27323466544056385, -0.1847505950273137, 0.18211557720708135, -0.06948931355747946, 0.09819878679551149, 0.6134367556734042, -0.28302537814366874},
    {0.47974326473618234, 0.09421366472640219, 0.3872975451694446, -0.21278546775213047, -0.07969201781491901, -0.015253978977522356, -0.017802837636120214, -0.05185089038662165, 0.018104395929791572, -0.26323578533132297, -0.6380311984432466, -0.31220444300792516, 0.4331259057787215, -0.24610175678116633, 0.3888435235867388, -0.09322316841461224, 0.01782032918278893, -0.0038064012075710546, -0.0737636283878719, -0.19337563785490222, 0.1350208340977951, -0.32842247906180067, -0.10603470029402688, -0.24143980055449116, -0.2912776208475158, 0.033840159224975644, 0.052242525616668145, -0.32562788331420484, 0.034371201217372395, -0.04442890724699293, 0.15656967433609936, 0.4060396282151213, -0.534888376429007, 0.07423665936835139, -0.11457415776500915, -0.08928730044158459, -0.3913778652663079, 0.3451395588845004, -0.008024961555334718, 0.027072940228869403, -0.2594042201750535, -0.27567895187862446, -0.5986918935262576, 0.057397606821809916, -0.17291569430160403, 0.4849045179404635, 0.07444170663462704, -0.6049322759382282, 0.010765309730722589, -0.12557666484887703, 0.10357888159953028, -0.3281709937187963, 0.18680785098244423, -0.3997413758144752, -0.2107592081435509, 0.5628076018305319, 0.04945440244139428, -0.49918014001831856, -0.2997559968223084, -0.7691339597944151, 0.08228715799551149, -0.12407629032893308, 0.33806474588272145, -0.10938897671435226},
    {-0.000994919905764676, -0.2906695844576475, -0.4013877783273573, 0.06573599457770876, -0.4234452633166576, 0.19062058717102237, -0.0003832807075429171, -0.23855585015672334, 0.45719324553537605, -0.0526888993887523, -0.05689595220679626, -0.24234468863075956, 0.14510326475646604, -0.203770671672705, -0.2186027147523244, 0.5956133598436796, 0.0021279677016714273, 0.08732704579378497, 0.07809770455574772, -0.24403997779710085, -0.10901730380012765, -0.4753169829156015, -0.4847461240998388, 0.10149525715571055, 0.06748124562252913, -0.2108516455243228, -0.5623055512866849, 0.11757437232618725, 0.17608922695224316, -0.07137514302798569, 0.18702158270378103, 0.37891737796459746, -0.19314341970949908, 0.33971886347461727, -0.39296863626960354, -0.368654298348117, 0.10304215102467508, 0.13477297377815275, 0.2633606803582227, -0.0979936633287885, -0.3998857578658502, -0.5020228724636783, -0.10677516809262343, -0.28461022871672265, -0.6137527571412328, 0.22043530124020727, -0.4303099957160574, -0.37877813823131695, -0.08155054290720996, -0.2037600368206667, -0.19518915908528253, -0.3411001003873551, -0.023252988150935485, -0.2762899889327916, 0.06265682980105898, 0.003582817476525739, 0.22621186184294595, -0.019038019397682484, -0.5268896553050948, -0.23542099997141708, -0.28912204922119633, -0.1656821942556538, 0.3460631044355457, -0.27757971534801046},
    {0.007116891575544216, -0.3240365050524825, 0.274031499589132, 0.12457388832032021, -0.4701844122073851, 0.4427572120762571, -0.07549747014113188, 0.10819220352678913, 0.3923113628419311, -0.18989552389288714, -0.20013550722587348, -0.02550026633256198, 0.19698615581646703, -0.3922690382275978, 0.022105306302352152, 0.21768669721396505, 0.38162529602840956, 0.2572099372166863, 0.47729471263096124, -0.31912780382731504, -0.20456430158818859, 0.17189913261884618, -0.08237917867818963, 0.5749269360864998, 0.09918921793142164, 0.34580198860566924, -0.4391656470795446, -0.39771781140438833, 0.19408888774781005, -0.055721940266977056, 0.12806357039098276, -0.19639114531031743, -0.12261032144382812, -0.4201221898471643, 0.03592850666417765, -0.19112572937474778, 0.6256215882219868, 0.2573498806266324, 0.4076946955928395, -0.09292582591520733, -0.0313643737227825, -0.19190129132987369, 0.2568978478382993, 0.07346179605655444, 0.014478744740503235, 0.4163547720893832, 0.03578253550503618, -0.5144027958303722, 0.0670155406966805, 0.07602701791965533, 0.33969445269170023, 0.04976023497941992, -0.6952751792928187, 0.05552376399985574, 0.2626633230553975, -0.13643302735864155, 0.42767798471280966, 0.22950447863174714, -0.25332089278312875, -0.15358916456830377, -0.1264309866197704, 0.024881851714988426, -0.4818236350597661, 0.06326210845524703},
    {0.009166518540155577, -0.37643093061292443, -0.25117730496353774, 0.193114689934284, 0.06432922552592078, -0.3919446648931825, -0.09872671982755173, 0.1533318179392152, -0.09388952587437298, -0.01405153518610929, -0.07816109042996845, 0.5838662460235352, -0.018336984529025657, -0.3062895569603804, 0.24847168064482722, -0.4736236361384494, -0.013932502650792508, -0.053620897119353035, -0.2549967536391114, -0.022735936059755112, -0.2089802019746079, -0.31546895611873055, 0.23725652374663003, -0.26361835311941173, -0.36114519436972564, -0.060071114940071176, -0.30633186383528704, -0.7887418462457119, 0.07616272119805344, 0.22426015617722775, -0.22403477927719243, -0.5633808314230583, -0.15977479922467186, 0.13231064123976558, 0.07512820146734242, -0.190061431701459, -0.36172065105229284, 0.2035289004763705, -0.28457463106281555, 0.39961488293972497, 0.18888819725121023, 0.41803944704292495, 0.4862369017138561, 0.1554761445861903, -0.24180859787172737, -0.20646530889926087, 0.18016669363545262, 0.29772021633708035, 0.009818603559579519, 0.06921947047598656, 0.203154937172306, 0.030824174875899234, -0.23686537788725315, -0.07836274474577638, 0.10313162171142125, -0.27077717328956435, -0.1140515622872462, 0.1824384109399029, -0.22081037495752678, -0.018487622574975132, -0.13931976349304467, 0.5454052601255106, -0.5647915724002124, 0.01367115237992551},
    {-0.009469996542683835, -0.4008872206091723, -0.1988610539889718, 0.1201055784102102, 0.0006351822286653746, 0.07005366355074771, 0.1624056982609471, -0.1807128512892157, -0.4222850404168566, 0.1809608081141799, 0.11902581924742109, 0.06030535822453501, 0.03130263350982586, 0.4553892786449619, -0.19313692728243975, -0.04914260675057786, 0.10737543650780094, -0.152927273916503, -0.2912055185872658, -0.08028032195918379, -0.5348649985428664, 0.5828915061506358, 0.21574704538467582, -0.07284607850137591, -0.2010477822112719, 0.0936791818318682, -0.07994721856533431, 0.07220381588992555, 0.007493785132583472, -0.17712706988626797, -0.14194185429505102, -0.13447197817423798, -0.02552969405665495, 0.013181367025053372, 0.08551329179495085, 0.3938467466158911, -0.34015833791414557, 0.4211970589625693, -0.29582924286909446, -0.13854055242858782, -0.15111042918853915, 0.36743860882303836, 0.10373440698820607, 0.013869822998152913, -0.1164934312176773, -0.18809298183041326, -0.37192807337779066, -0.17375919241985682, 0.005546141339875985, 0.10666703447120796, 0.29816082784851816, -0.005622583298849965, -0.006408594265740694, -0.08293639506656618, 0.33428706434778654, -0.11391787546702888, 0.13377227545687778, 0.25512231147046244, 0.28545471080826046, -0.30062091626650045, -0.1796635579954205, -0.049397429099081035, -0.08253725038341335, -0.15373010987978192},
    {0.44769208353419904, -0.005848144529371886, 0.09780996952463654, -0.1305884309644977, -0.07342517360855615, 0.2875419906041592, -0.07689993905810806, 0.1768552580155833, -0.0434883878772445, 0.2905396687179324, 0.21797856241631006, 0.6407416083910571, 0.20929093894110073, 0.4167350148995563, 0.32591049757177415, -0.147440518602192, 0.27135352352567493, -0.2740555568319122, -0.011357215015559426, -0.1556582697816698, 0.3792811174583892, 0.09631293341848005, 0.11966358156733338, -0.03502332649446468, 0.05770254476875958, -0.10126916509432722, 0.8725975905629905, 0.3857050418711107, 0.15978368492609976, 0.06360300190315134, 0.11156895289378987, -0.027429171131763463, -0.048487162352310334, 0.2641204265698796, 0.5979327073242333, -0.1009174755273974, -0.038544904649964275, 0.08749340081513235, 0.0103306718337763, 0.1276879566926876, 0.16063689268913522, 0.11804231058451725, -0.510840004249153, 0.2649032873767572, -0.3309708821231265, -0.05484287289006632, -0.18537397743117634, 0.2983583670079543, -0.13124318381517755, 0.370581016014183, 0.11090857107409022, -0.1584800328327366, -0.009083164041622046, 0.34601567426668506, -0.06526548366346298, 0.020089635144557257, 0.34697625310908947, -0.07201052856106681, 0.045482305830956755, 0.06790555940958681, 0.11599923956406984, 0.05038232418877417, -0.3014508545487369, 0.4063425480634661},
    {0.1488372782754393, 0.4749989055921147, -0.07571636150676983, 0.05008291702801565, 0.6180214888106457, -0.4508614377733419, -0.42480011742788343, 0.3139270924103307, 0.25051711632147117, 0.10600802440534594, 0.09303495870197902, -0.19968254041952008, -0.1435025505213433, 0.4573865408317171, -0.013611972516325819, -0.2478132792042058, 0.23741364066357237, -0.25169418470796384, -0.5347829229003407, 0.16537918831594586, 0.10860064994585508, 0.09309540985070307, -0.015746060115111746, -0.48474693558056625, 0.18128894539515625, -0.0906133221789813, 0.6176178514704185, -0.3118657405368742, 0.24083064312730001, 0.17986751937824214, 0.12801217125472839, -0.214686821563413, 0.11088349809175006, 0.18217945975609048, -0.11741977241895016, 0.21987025883074202, 0.0936796202160509, 0.31162534072644554, 0.5437410379284212, 0.4588687541726362, -0.06357030389874191, -0.07190345972775225, -0.43588425245528095, -0.01895572662893065, 0.010913052510961403, -0.07690740735262848, 0.09397876797241489, 0.5852640245837577, -0.43073636639976165, -0.24850381476566938, -0.20953981790345078, 0.16819154523039268, 0.09763984723441442, -0.014445037979980419, -0.03923455431776763, 0.2613339559213, 0.3195816882304947, -8.507138656014916e-05, 0.30147983127705846, 0.2891347253171585, 0.7293759746611425, 0.3320389756281668, 0.17714320604977019, -0.006332143973530629},
    {-0.26832973327242415, -0.2882504650126677, -0.06732659194205842, 0.042127902855498375, -0.15766793509283486, 0.008012833718770441, 0.07968833476647195, -0.29295482333611716, -0.26160193962426614, -0.13421278310895118, -0.1584684449539971, -0.0915906406991602, 0.008227674437820723, -0.4174812693476775, -0.04409089125948007, -0.06007436747392675, 0.08455495403624572, 0.5786642259251907, -0.7593436469438782, 0.28947948618769975, -0.3361882111310951, -0.17767447693486058, -0.010184906859572969, -0.028365245512765255, -0.27619970569404184, 0.32038480728933155, -0.06049048762157605, -0.09434516994996922, -0.5133459617383744, -0.19295766310239176, -0.20493554209958909, 0.053401999605125997, 0.04912351444244618, 0.053330766236489226, -0.19763730922556694, -0.26925481342490554, -0.20531693201524048, -0.08663726916944861, -0.28932300485722273, 0.11263787540540615, -0.24452724661674996, -0.23751522931389546, 0.05015840871611012, 0.04953297200187279, -0.026814071610474662, -0.1512561455608892, -0.0335227492003305, 0.2427978196126579, -0.3889495104641737, -0.22465817209915895, -0.1431196470247817, 0.08500195432931743, -0.15377822686757459, 0.4435443405345891, -0.029800027718366037, -0.33817422279714043, -0.1701707446392402, 0.2792758441047878, 0.46298629434901073, -0.196861109548957, -0.05764263170085149, 0.37045472362141924, -0.21621920935638317, 0.15801204775199254},
    {-0.015538382363702877, -0.24280115178122622, -0.19775595860987777, -0.1572381007084486, -0.4851522148178668, -0.04212747796278674, 0.038187284301632776, 0.27303609584385347, -0.25633709689638434, -0.27157280545376067, -0.2417628379132755, 0.3811586791171444, 0.1869168611928701, -0.18164543973404998, 0.3163131214991447, 0.6522968869783666, 0.3110348770781905, -0.1121070885302205, 0.21821563528978197, 0.45077453682759766, -0.10377339764990523, 0.06800764383080815, 0.055061435970509234, -0.0829692324517423, -0.5939102744351729, -0.15205761940814277, 0.0653993280874153, 0.14792761622515377, -0.8643309912983879, -0.19617154521626554, -0.27037948011210455, 0.15034468979249238, -0.19811438484999647, -0.06673288795225397, -0.16203338358808164, 0.02642619142859664, 0.24110240740613656, -0.22494410815193006, -0.06088887717281789, -0.06070302243089482, -0.21874261441815987, -0.04539973639542545, -0.47885067211251453, 0.4805839637777775, 0.2648343461594, -0.46845561064501345, 0.023493750044941652, 0.4516071140806244, 0.16921831528282305, -0.240558357734902, -0.0949625565723686, -0.05491581931746349, 0.06507532645656224, 0.042626171059098675, -0.26196126549818344, -0.009343300983853518, -0.28774750470382815, -0.0488805356877752, 0.39521008306161687, 0.40683912457373905, 0.04045683693914296, -0.0472433300881693, -0.1745884860989038, 0.3817069833894478},
    {0.5536712212190071, 0.3282061797066891, -0.29741537354946557, -0.15958906954296642, 0.65398080473345, 0.07296080686604826, -0.21524199507160377, 0.007649836355900321, -0.24506431122659655, -0.2905954618014105, 0.25320609064447147, 0.3416053738286903, 0.3584233432269896, -0.40569920754916916, 0.3409757727860254, 0.738038109696161, 0.05307437957068235, 0.5432498797618779, 0.15740305724881362, 0.5373136724368851, -0.04316990454598894, -0.20554045590542305, 0.1395389449652426, 0.03258739695653505, 0.3125997439495025, -0.4060329560722627, 0.5245241326765914, 0.2445744369194375, -0.22697662942264551, 0.10130346806672219, 0.031960048020450486, 0.07380168247718635, -0.09277832876408774, 0.2187725503443238, 0.42093148496052807, -0.11271311617387386, -0.0927676424140829, 0.13499772932602438, 0.05470006529423932, -0.005564329607041223, 0.3724776784446815, -0.320641620491684, -0.33759681691719623, -0.11796636755155347, -0.19722571932954813, 0.38823528803729423, 0.15249111808522203, 0.49502434254010347, 0.02785895910982307, -0.3810741580108802, 0.20675029829955566, 0.38319894603911714, 0.708814683908617, -0.13956987115399908, 0.0927723029246006, 0.049452714412940794, -0.21367215303098275, 0.30940812561867403, 0.0068114642185963465, 0.0789573746566577, 0.3086425264159141, 0.4408654193369069, 0.11370188576021777, -0.039066473710865524},
    {0.763621333822738, -0.04651534849416929, 0.07723513763115926, -0.03748578000573952, 0.35990021435838854, -0.02678328500248767, 0.16258181227983162, -0.1365795296371986, -0.052084127130186744, 0.31826556027753694, 0.3134918201433954, 0.26802953038359456, -0.049353001279136506, -0.16989398052658303, 0.18280479665959687, 0.10498415412278722, 0.057868619907829474, 0.15488433300559026, -0.39996498688459703, -0.28949664812657944, 0.24897642298868838, -0.2380184075356133, 0.08265785624643097, -0.07262585826225727, -0.15638720543530954, -0.015728813149101416, -0.5333282231153341, 0.37187845798548197, 0.43722123362799126, 0.030547761039370288, 0.13811660049235783, -0.008551116893672472, 0.4052855292897896, -0.594759162441659, 0.1749400504632939, 0.33186929299787354, -0.10621161608329606, 0.22364330270806365, 0.3097576225101642, -0.20079822074467207, 0.6424473556596437, 0.014903108068077002, 0.08306910398323358, -0.09171939751576529, -0.2518507902592562, 0.4328367693664712, 0.3953740355148933, -0.15822991410116863, 0.2083157461184979, -0.36486931048621773, -0.21748253994690636, 0.2800125656888579, 0.6506133151581237, -0.03391454903843515, -0.041433655104593035, 0.21653575390348956, 0.21949489694613972, -0.07505849284071228, -0.00046051291121632906, 0.47193315967983557, 0.22003616735657489, -0.20980225654894205, 0.18749246800786834, 0.28055459026291585},
    {-0.12539616854613403, -0.09099324340621831, 0.1989521307229645, 0.10266831942784747, -0.20469065159074706, 0.08606901530358585, 0.24101142374755113, -0.08606933456150574, -0.07991788354403757, -0.07248710540084226, -0.02954093444760154, -0.048360640281618045, 0.24512097642044064, 0.08288429427496947, -0.4479799163649488, 0.4912704342599747, -0.5376885683339332, -0.2840206253828944, -0.07226699400298801, -0.3415685925351653, 0.22949295449077217, -0.009530465497585927, -0.5582064547006694, -0.36743444586977814, -0.3951093167703562, 0.3751012026914019, 0.024193772703991808, -0.33161763166688896, -0.14619332428341567, 0.03452351701713516, 0.28631943642245117, -0.02176558249552121, 0.3344527903039462, 0.007885427759740538, -0.024212191296490514, -0.2657329315978273, -0.06810656657979311, 0.024236633533580788, -0.1439080678990108, -0.20515742446104823, 0.020840399965847217, -0.16011140496150394, -0.016257199691398317, 0.2881354785613087, 0.31850285364666536, 0.4656387112269561, 0.21870047594724693, -0.6462287628388403, 0.11327393427837353, 0.38108353104935433, 0.11528808165049882, 0.1689645930106309, -0.0800009785533009, -0.058681703558528836, -0.2673551741307358, 0.4018819162764801, 0.008089794637423136, 0.32243647105963225, -0.12983532574699785, 0.4074817078234846, -0.010367219918853574, -0.4955060673308277, 0.3141631908799204, 0.05288356075783212},
    {-0.5503449101137018, 0.12530022930195403, -0.16726701162681265, -0.05315112354610297, -0.16622214008008876, -0.023591924199070472, 0.3209475150015372, 0.37784543264335885, 0.23574916500260593, 0.26033462666886764, -0.27778957953257355, 0.008076150858333912, -0.02768438740732289, 0.22396697595218074, -0.3484918508949495, 0.051850606780911225, 0.007259548249682836, -0.10462586737849387, 0.0866054391022038, -0.2626143444537564, -0.12276983815873609, -0.28049874054540075, 0.04443057306218327, 0.1514853995747566, 0.029401960758937383, -0.37130605816809237, 0.3835257244672648, -0.4191971760987884, 0.2613538611093719, 0.01980665865125739, -0.02769749682551213, -0.15480425520013016, -0.5404300016348651, 0.21109139127307677, 0.25702870557787266, -0.1371624915197988, 0.2686089232205233, -0.05408176758159151, -0.19473679199104174, 0.3067666114148009, 0.16303800949608233, -0.1999838151092641, 0.45395843778178036, 0.13383023418870615, 0.16529106979579897, 0.08957396703614605, -0.13512301044533453, 0.051192990997620785, 0.5418466037409442, 0.19893800300904385, -0.039761325595412976, 0.291547428381689, -0.29387565302190677, 0.0450843788112247, -0.4032303519812949, -0.09362690517698362, 0.01931669483989122, -0.09155809110354068, -0.13302220837584433, 0.24738013050854837, 0.15079584425384093, 0.5191486295864192, 0.640169363413425, -0.051926551822442525},
    {-0.4778434313718862, 0.02529475235014581, -0.02201140473947122, 0.11945917650627161, -0.22799795810479961, 0.34088499791000676, -0.20919934515013383, 0.32517944594063825, -0.003927774356709278, -0.10061149790388563, 0.3373502845562997, 0.01590298109537813, -0.2769351675691366, -0.20490919722374468, 0.11365604108735287, -0.10138275650736546, 0.059987017056562994, -0.18434990693154296, 0.36069477598511185, -0.39382854586321636, 0.09510857051005416, -0.31118039101522244, 0.15283880760172605, 0.24418869264537274, 0.11131744725741889, -0.37992050626178286, -0.40176511326488695, -0.3685620460357253, 0.4591343212015366, 0.3571382360592688, 0.33366195394194564, 0.3397359313407984, -0.05916888796073787, 0.153782291309578, 0.2601560580552321, 0.23778497661157283, 0.2802764695161697, -0.05025291204202602, 0.4549618727996904, -0.08459259706634313, 0.6248349779403661, 0.5645004012483817, 0.10203938070694495, -0.03452817269200749, 0.07808041790902873, 0.058063816996652945, 0.040346045349070485, -0.2911107665416268, -0.004160780733498093, -0.5417245021864052, -0.1847809692346037, -0.19306098562314067, -0.13756920826399402, -0.016043050090873593, -0.2128161498743985, -0.251571434518189, -0.41020030494043447, 0.11829846773396398, -0.3146555412891453, 0.045721917732479876, 0.262300003279386, 0.25572829303918054, 0.087639452625258, -0.19788868662737866},
    {0.3530419436811369, -0.13105070683020578, 0.08930260279723021, -0.25358884309905405, -0.3466188904461878, 0.03029692451366342, 0.2560549054402569, -0.4257649381582327, -0.011334173613113346, 0.27030085293300543, -0.1773009775123992, 0.4054656839271844, -0.1326148241964818, 0.10742046778619864, -0.1674801802712747, -0.576733815891186, 0.4017477830388571, -0.3431317026263234, -0.32354581016978756, -0.281947999566097, -0.01183231624573503, -0.2766868101150814, 0.06996772656799095, -0.06716813839428451, 0.16404225492205698, -0.09737494650561515, -0.32972034795988275, -0.1773426121436528, 0.04058308667945286, 0.05184927484198295, -0.2548645514347328, 0.6235983474433168, 0.4128244464332594, -0.01765749584616817, 0.30798177678338706, -0.10804792416019958, -0.09087820619376287, -0.5082914054130749, 0.2897614844418698, -0.12456576724699155, 0.20542498322047445, 0.6077364141871371, -0.22381927676438496, -0.22036056860211314, 0.26596390459214186, -0.38827359724396143, -0.295413987135825, 0.3240555538341113, -0.16214817288651873, -0.5152087970617285, 0.468046491902024, -0.15691718492141682, -0.2932796757248746, -0.18173967792741152, 0.12143807990319345, 0.0687012954744143, -0.3932940100319333, 0.12098054477551932, -0.245203464372279, -0.006961395680019629, -0.33172405662807974, 0.0010637133422785772, -0.3105864686127195, 0.5287465768969051},
    {0.27261139822071545, -0.43584021282727564, -0.0008107971926162777, -0.600184372126969, -0.33011480414621047, 0.38514378381685327, -0.12964280543991977, -0.1725317402668048, -0.18868204845670716, -0.1376031345202938, -0.30912722415244953, -0.26212905209505777, -0.31857120644773873, 0.09178607005394464, -0.04534600061619428, 0.15414734316035028, -0.07903363686127267, -0.016210787545699577, -0.41699545964375023, 0.05043240666345583, -0.4446977630120451, 0.15303297335422147, 0.364516259054598, 0.23625250025554279, -0.18016133291271114, -0.15140303945544098, -0.7203044041036347, -0.19026475120279285, 0.0055558294502768705, 0.2169773777554076, -0.40835629634767273, 0.0025391366474786865, 0.3419454513761895, 0.12125708941788804, -0.4440360725445996, -0.2291313439705471, -0.14086396754182465, -0.34814817734685155, 0.04891104473773991, 0.012394304074287973, 0.08714152370950931, -0.048694590208824745, -0.38078796836337386, -0.20962008255421175, -0.20483830845442647, 0.34513669530138774, -0.3999917904611694, -0.16470827234251018, -0.16736916328547566, -0.29787155691619677, -0.29186478355747153, 0.14944183233839758, -0.15229043708967496, -0.18526376134020456, -0.17217150206249004, -0.08750859524351119, 0.09192223403114155, -0.36118646291210366, -0.16248651652854273, -0.09396568643499942, -0.33775324419466346, 0.329202916828285, -0.2442095012417073, -0.04250041215655822},
    {-0.2019962862954369, -0.18595719931700938, -0.20426391166067742, -0.17120350694320446, -0.12554720651077075, 0.06256301281488143, 0.044059933488146914, 0.08711272476151447, -0.16691546429444729, -0.12401092063253073, 0.10782037742050761, 0.3063634466701647, 0.1625903343210598, 0.13899035448001237, 0.32350593961909513, 0.10552387338330789, -0.30332080702139513, 0.18662055931631344, 0.13403771777340798, 0.27584247764978104, -0.6750959145552462, 0.28497352976124257, -0.06715994669177382, 0.525044578161999, 0.3004935072693383, -0.11416688290218946, -0.23482306477876166, 0.09827495119299165, -0.13422601866979392, 0.25429575582875086, 0.34495607221367186, -0.2496170751686795, 0.4141894879025231, -0.49399620530345495, -0.5180322384660215, -0.43659425796141277, 0.39966330948481105, -0.07654648969059671, -0.39476666697504803, -0.2901044126773841, 0.31410569983772235, 0.29571701332715394, -0.07570284403619845, 0.030193750608579917, -0.35853063307534794, -0.2214019349182702, -0.15776857936997613, -0.560571989257386, -0.04742319512090383, 0.10907113825820822, -0.6672439310209745, -0.09526076365374277, 0.5249963303775467, -0.6091935256697929, -0.20062021961609997, -0.32729445061088375, -0.1966446529686523, -0.253872462095969, -0.1207783954640063, -0.1358053830866564, 0.24446178408031974, 0.18675877739046842, 0.28808790147020136, 0.06680453156343491},
    {0.2515823854266072, 0.2058889839433986, 0.2749606877052245, 0.29909836376041193, 0.13124243736720556, -0.04591257290994311, -0.654300720199243, 0.11676032346702558, 0.5407181833623123, -0.055958193950941565, -0.35857869459340574, 0.35058133169444766, -0.2446082402910402, 0.5266046953585044, 0.7147517677684385, -0.33021052639278603, -0.048281159256698694, -0.1018183675079056, -0.233104823580123, -0.28248505863756607, 0.5541858024108405, 0.3215738653674796, 0.5545145195523102, -0.08047330289333118, -0.3801587418808807, 0.48671746002502686, -0.10291041630659162, 0.1575707485019065, -0.7462249998059635, 0.08462343589321665, 0.40467380584640195, -0.011089213214440436, 0.17040429997289094, -0.12688773425736374, -0.004817976917584685, 0.11874827644410121, -0.6439345894621533, 0.8369132522951274, -0.3868268043559739, -0.170492347402277, 0.46487051618038094, 0.1308057139712117, -0.5121277309434185, 0.0709588071479843, -0.4877089175243892, -0.4803570154465022, 0.3260825369240395, -0.2866630741144028, -0.19014569715667137, 0.3216156080264359, -0.37855422378486225, -0.13297693685219003, -0.03496172795658093, 0.16046128719331992, 0.0813070481023282, -0.2531236741687288, 0.009407034019342007, 0.15307344873733852, -0.20582398235674326, -0.34478406950281126, 0.19433526191250486, -0.018152026497782126, -0.14203867007270748, 0.5356565745079154},
    {0.2506987359767516, 0.01636025551478817, -0.39405623723057054, -0.024081092472333702, -0.39214120511533657, -0.07118014777378256, 0.24651301379754484, 0.2088088201645406, -0.39779887811826886, -0.2259506284079402, 0.5662473516223422, -0.40031378543111545, 0.03426732386243407, 0.18539578181112312, 0.19729990056561594, 0.36853465739548996, 0.0777026583455891, -0.10010448017911994, 0.22459008787908624, -0.3971839251490784, 0.20914918272480737, 0.5208871473041966, 0.17868372583152042, 0.06569959955197147, -0.37327362220561755, -0.04766044384370222, -0.03557743115515258, -0.06027493457195118, 0.28924276305379437, 0.002863817696576831, 0.26716855028147873, -0.34111880199628547, -0.40572068347203427, -0.1725513631668981, 0.5064734025731386, 0.3763656743815571, 0.3396768462885143, -0.0820813874484855, -0.2182074296272369, 0.48533120535567087, -0.4699415776402933, 0.18000368907460781, -0.5673515380370278, 0.27789703677960226, 0.14243334230937935, -0.05387576253781211, -0.0833399307999124, -0.03668264647961295, -0.03396225010972527, -0.3670472015820523, -0.1363345592402923, 0.1811038991235877, 0.5636811854480682, 0.41182886669827246, 0.036255107007200464, 0.5105573872169401, 0.02029247522985605, 0.636730499386702, 0.07861693918084973, -0.19055925161368814, 0.09696814575638676, -0.18612054658624455, -0.4477637327540777, -0.23063823587834523},
    {-0.12048481015127924, -0.21920786332058043, -0.1389155656188658, -0.06860797420305402, -0.2896459617180769, -0.42131623756584746, -0.1945657777917793, -0.11393508025158013, 0.2198574999714412, -0.45258565551026597, -0.3313834587463499, -0.20921319026429205, 0.1432082993645583, -0.4299739160456462, 0.053527633064395515, 0.08490308739166202, 0.17271842411670188, -0.4489732650192512, 0.5318716782372914, 0.02877343993576618, -0.21885490706694663, 0.11668347213970044, -0.270580813094499, 0.20587022308386602, -0.24609274340547715, -0.22760398439874707, 0.09713995904856931, -0.04208004632894019, -0.2184843510615051, 0.09322698056786663, -0.13437634938941706, -0.2839803600004777, 0.18192502312787168, -0.196809956290449, -0.4922270994825882, -0.0028670722721774416, 0.062324568270035345, -0.3243567714411577, 0.3844669932484752, 0.20854359834704334, -0.1449796648023156, -0.055689348152994235, -0.3584306006716282, 0.2283595121318321, -0.05742516428615992, -0.4897466611966745, -0.26263543757254226, 0.12163610837455315, 0.09819101981884151, -0.27656057661937195, -0.2954033087627065, -0.19646948135186917, 0.23571398240765934, -0.346678528676417, 0.30042037046547665, 0.14999741404294026, -0.4162538338734728, -0.6181009298148519, 0.021414530654124415, 0.30554946784630616, -0.2895172303769168, -0.13109062934558577, -0.15959977870143688, -0.5060775239619426},
    {0.24645472443931807, 0.022038962830708785, 0.07046603922360276, 0.004448026585012857, 0.37823464520536276, -0.22902665007085207, -0.08671002334117262, -0.3100599831990271, -0.09045244296062027, -0.21439473732522202, 0.11893635281648476, -0.2064126133138072, 0.07177563888224398, 0.08435575041415894, 0.2409292083863016, 0.003176448483874462, -0.22693991302059016, -0.026640273384736707, -0.26450786609347404, 0.021851425020608075, -0.1633466537771904, -0.3755401661790908, -0.31222708167306606, -0.058897469226840464, -0.4022458787936356, 0.3718769323203408, 0.2572540068820581, 0.19134989161460164, -0.569750164921164, 0.04997801463724672, -0.416095434131411, 0.014807905274171307, 0.14009517510101424, 0.46912182656359747, -0.13240566165026751, -0.455534505385682, -0.07171440444511495, 0.2158671247121172, -0.17904659785344715, -0.0698783279444581, 0.14424491664899602, 0.23546434111748288, 0.08166437631666504, -0.3593977968142014, -0.3555517349775594, 0.4843091465379556, 0.1289171935528393, 0.0061160837320234415, 0.49812422238120585, 0.2485993381957123, -0.005749929580228195, -0.44178836531392457, 0.37236886765381216, -0.16834803675861829, -0.04653182369466621, 0.16354098353721136, -0.350168903497641, 0.1783490632021427, -0.18985896796397994, 0.38118560860246326, 0.3470708163123215, -0.3483300933763011, -0.17847042856887074, -0.20690719079140715},
    {-0.09159324553207888, 0.5280646531748652, -0.9050194204515352, 0.21751802013490504, 0.6997370660931292, 0.17860180303617787, 0.5426450953877254, -0.3147696306552829, 0.4172957444828556, 0.3289431923791834, -0.6703261069717008, -0.5196105019647079, 0.08930721227008587, -0.9845513494342117, 0.5109755534788137, 0.3112084173169024, -1.0018172986973388, 0.0719253588244271, -0.3836255745397932, 0.37689598219127196, -0.5425380110966609, 0.362473102782487, 0.6335743336323549, 0.5510686128454367, -0.13723172651118162, -1.048442432129324, 0.17199973749985786, 0.20576467020620354, -0.8746877284094658, -0.5299481981634077, -0.28650743534073064, -0.8157952224436675, 0.42561949805853994, -0.3070216854036788, -0.6373794378824774, -0.5006860738739167, -0.9326901946191433, -0.1465316921827264, 0.4050140221464697, -0.7473050048743208, 0.7615207080736818, -0.40492792225771945, -0.028099256170550063, -0.43521760125052616, 0.276926412816562, 0.5012978259849764, -0.40080909532416636, -0.6525455876387133, 0.35309792921642436, 0.13402631621158367, -1.05278462883929, 0.5353609786079178, 0.2739977885753858, 0.25323798032758, -0.8639639604670171, -0.7644986331053213, 0.6524455179023987, 0.10637138909012331, -1.1770241998704336, 0.6393764145212765, 0.10119621447548177, 0.06128831612516697, -0.2573097295895347, 0.008500030349614041},
    {0.0836934526472697, 0.566659711292763, -1.0475716600952814, -0.49378415669284453, 0.6323920116286825, -0.3957475794454805, 0.321760287250656, -0.8243276696313256, 0.44578874832503457, 0.40636556684153075, -0.46435474681415395, -0.6744869721022005, 0.38180360476683106, 0.05394073887309952, 0.34965680879461186, 0.29556241164163616, -1.0562819175263403, 0.16041655919305284, -0.18038673956870768, 0.16120339953342652, -0.4235042399164727, 0.5282037382955245, 0.4222234811688768, 0.8182022177748627, -0.6855419712809693, -1.0729639236275719, 0.06561457066282544, 0.5783229080523304, -0.837863622830487, -0.817706613883664, -0.24382541805007138, -0.7864873310935993, 0.3499642015845906, -0.8346995430434911, -0.20129988565831933, -0.15538187817307955, -0.7041893308554381, -0.26073509333756034, 0.8066533784185183, -0.9949943402962939, 0.5309359224801413, -0.4087500609459403, 0.16828985659229673, -0.20886169531816137, 0.31504321760868703, 0.48927511982104016, 0.05066043572309489, -0.6225812829434962, 0.3481017418773489, 0.8341925662390968, -1.3835100717813529, 0.308554794192861, 0.37310199607299777, 0.5405927509913884, -0.9525219245345841, -0.7139644213388688, 0.13245044646200071, -0.1571587939910846, -0.6488228594580518, 0.6372107637935894, 0.010401061804795424, 0.3881414302998851, -0.36644213285776683, 0.19465771819252342},
    {-0.1608201161209649, 0.34298189024258086, -0.3302198247392635, 0.26036454366374223, -0.026118202584795597, 0.12704372075976786, 0.3437778931614626, -0.1663471897361224, 0.3032052091772689, -0.13507581530406929, -0.8234883213946597, -0.6839702960592308, -0.14991589011744264, -0.41632156417176225, 0.8568874208334494, 0.497076562629981, -0.5524450310736302, -0.13744259864352035, 0.04199885845728539, 0.5994083164335339, -0.7140853483151166, 0.15511947654900446, 0.1702151966277417, 0.3970247295357011, 0.12546534946841806, -0.634027190574113, 0.4745214975456744, 0.3510143240676732, -0.9891446911655478, -0.39352789896909657, -0.5676626493080162, -0.259100170393715, 0.48987766324491183, -0.6154876203063718, -0.49417824086590284, -0.4260699085052819, -0.2996632809496965, 0.2566183604849944, 0.28706155824223123, -0.5406595156154665, 0.2990975453823699, -0.05730545640071378, -0.1735575438147569, -0.41112945191401007, -0.33152996124104334, -0.07077856619336212, -0.42988455936098807, -0.7734488660278865, 0.4618788585313387, 0.5758516736638928, -0.42687402026182475, 0.0009776233898826855, 0.5293919559999194, 0.10007391991749336, -0.6052916378897119, -0.21941251338631795, 0.4267074712903076, -0.1457708031855804, -0.37117395154213867, 0.42513988571870326, -0.12273729385201539, 0.14466556528203336, -0.28642055467688676, -0.6362369869273213},
    {0.5736562749944841, 0.48084293409197654, -0.47975571718610277, -0.1514518956191247, 0.17978797289003123, -0.3303350456999959, -0.04689092008430906, -0.2694796471470628, 0.3561920251573799, -0.23484292494949177, -0.5376105359480019, 0.19165345895960215, -0.35524432345210816, -0.39533427873859733, 0.5784084074356203, 0.41765303553291927, -0.492823017513628, -0.11743117913382937, -0.2181628674349483, -0.35324833383716286, -0.6727320149694269, 0.5508409339730289, 0.3984093327563525, 0.492847496916258, -0.374310311838287, -0.21024287552418766, 0.42011990782587205, 0.251381199659341, -0.3784513732762092, -0.610630751583292, -0.38711897559607233, -0.3167812452201753, 0.36783642237363123, -0.40397521056435576, -0.2915648685695135, -0.6515386012774282, -0.013097052918361204, 0.5585899712488701, 0.5436942759803843, -0.3838408014582055, 0.014100171326044842, 0.3437483985724295, 0.3794064871545388, -0.15252665919025013, -0.5481456956091855, -0.16184624465398312, -1.1430410283077548, -0.1216488890961067, -0.19252422574397118, 0.3333298487160456, -0.34972207979778325, -0.056121345889868425, 0.05222972438001123, 0.2934810068854179, -0.7785305359165448, 0.21002061093638402, 0.43298484194002157, -0.3990169365438696, -0.4835211252002824, 0.40051979017099515, 0.008174993907136597, 0.3280952689831281, 0.5879563420583028, -0.38158647983661903},
    {0.4146034752965903, 0.5994781891645293, -0.38395285606942675, -0.02440283648090607, 0.18820913591974356, -0.049993169763823175, 0.4296570663162399, -0.05316951372621248, 0.24609111398234526, 0.6599487655840834, 0.11156926850910212, -0.33769420692304614, -0.48275569009777286, -0.3963219703231411, -0.041661360688744875, -0.05887901063775154, -0.70352824508516, -0.14575298732779543, -0.1502735429768725, 0.0883979067265685, -0.5002702428973215, 0.07050606582698388, 0.16520538922256484, 0.542783319656365, -0.3903469121262121, -0.10996443413067969, 0.4245911903622773, 0.4003022540501123, -0.6463309280315391, -0.6096441043780542, -0.43876939044481933, -0.35679673522469024, 0.6656583013531097, -0.31470009076210814, -0.2438410881577644, -0.5791217112784262, -0.8245961391870217, 0.21126140675490657, 0.2515866378888052, 0.017426886555853272, -0.3293561616298174, 0.3470398940553353, -0.06985330199105859, -0.3087653222392316, 0.3257799021191771, 0.3402782171899396, -0.5408820390390309, 0.2312857101540102, -0.40813507847338437, 0.48371027982935727, -0.5087855173182453, 0.24657147611695848, 0.633799544655864, 0.5766733868291084, -0.46726693263445007, -0.0039039964048883176, 0.2482143823793732, 0.21556267522823735, -0.3273429357563335, 0.3227142690308258, 0.5760290665922433, -0.0029969048340588106, 0.2710236263247573, -0.3599080830956964},
    {-0.0602027837860664, 0.5512051587607579, -0.03735821021675967, -0.16548245107306284, 0.34427915545456006, 0.12701610229905072, 0.7916599706755194, 0.08563257457085462, 0.5089998087801689, -0.048076231251593396, -0.3300322475469328, -0.13550664674890844, 0.1546626871851413, 0.2924231733172164, 0.20006570251974176, 0.5087825429201929, -0.21561344816248734, 0.7815923681097403, 0.19215182913869913, 0.42878604153650046, -0.26322937155143505, 0.3367179646414651, 0.5632081622986265, 0.873198472225762, -0.16925257195211105, -0.32185583104209853, 0.04507242284617408, 0.25398182564846417, -0.339413216937666, -0.055351405847404785, -0.5591171743649725, -0.11468997260711175, 0.5210849762487896, -0.5478058227574343, 0.15567317362823244, -0.27711859991243415, 0.05563819218794292, 0.3072309401945897, 0.7609285713443098, -0.3850132805011892, 0.5662672736238872, -0.17951714974191044, 0.13351425059067257, 0.19709701867902985, -0.5541503366626959, 0.17982541991997578, -0.2292349265504232, 0.2916584941124547, -0.4882568115369835, 0.41710956655104636, -0.44581500072359714, 0.0011888530353380063, 0.2084173978837085, 0.30432003548923775, -0.9666341244859449, 0.014037105389485861, 0.32580437297870235, 0.23869464660833237, -0.1721598254651358, 0.770899853923586, 0.28902555039563305, 0.5946064882474965, -0.044508803376805205, 0.018747717671524583},
    {0.2787951194510006, 0.34293739504844695, -0.13844067444068137, 0.09436716288309378, -0.1742413931714588, -0.7516877104156986, 0.614961760056747, -0.025498366629678446, 0.3908162107688717, -0.12714959315888943, -0.1889314346484374, -0.45746757340106053, -0.2854332605238013, -0.15478208853383754, 0.026724839026962443, 0.15250879574274057, -0.08665905623896318, 0.019362613259633683, -0.08683550404874246, 0.6461530565706934, 0.015533283785921937, -0.14269472459257654, -0.47103278240477364, 0.07479275415479054, -0.07001920711766599, 0.15180921960929813, 0.4720895372630107, 0.615197851465826, -0.3237545110205423, -0.527589133165173, -0.1356162937404137, 0.03585699741038274, -0.2641465220040973, 0.07791464904570136, -0.2160069754730348, -0.4888153231753834, -0.0553135745087145, 0.137628590200576, 0.28108041478760204, 0.20794108843249298, 0.04723745133401878, -0.20357240875453206, -0.474329125495584, 0.04926041476514434, -0.30611375936620827, 0.22876863393892238, -0.2895171341594918, 0.10359711295106291, 0.05004883186013681, 0.24601406643348608, -0.09952201292374684, -0.3643631887183785, 0.40838452156872934, 0.23204926308828294, -0.537505373884964, -0.43838347660786453, 0.14102624119645, -0.3418072596204612, -0.22241784303855575, 0.4831172759639678, -0.17829367276226313, -0.2175690544882808, 0.14660464368223838, -0.5053850122324811},
    {0.4988094027046125, 0.7562313725031291, 0.29429846787560865, -0.2763551626995385, 0.23225792755221072, 0.16580053006561027, 0.23946368207685986, -0.3773043461109517, -0.4180036817661604, 0.09351802601813171, 0.2899224466826418, -0.6758089359505338, -0.4353381263970598, 0.01600972923872835, 0.10083848229310972, 0.5383788348579313, 0.20239275048709848, 0.033653665990532086, -0.33736699527600056, 0.6313861094250254, 0.01611936592884656, 0.01883822740191288, 0.5351647234157133, 0.466199597222597, -0.3585399665743774, -0.09103234913083416, -0.04355045483584379, 0.5874427531421142, -0.017541254463427094, -0.30964359243358475, -0.27676666127513544, -0.00950698977887027, -0.02279347061552466, -0.010309605890442754, 0.013689907493350088, -0.03939600667160185, -0.09543745846702326, -0.299906385727682, 0.24713172590717344, 0.10639072032967307, 0.2847092851323255, 0.08409679031007314, -0.20070711022125276, -0.10708203676689328, -0.546985862083213, 0.7674909112998887, 0.19178487049831744, 0.6164753001520968, 0.16914569482935934, 0.20979864577897636, -0.16718323923589562, -0.16498325190563828, -0.1340154686771113, -0.09591812984696427, -0.508474892581203, -0.18021613582127408, 0.2478989449081127, 0.3039923383659082, 0.020200347200053, 0.3735204052486837, -0.1570971758845182, 0.4979256966258534, -0.29167764819286607, -0.33527699521879056},
    {-0.19778771195221287, 0.2102115775772386, -0.12709155478709203, -0.19556499507075376, 0.41146575405877955, 0.1723136954504923, 0.47063921107216794, -0.253869762710523, 0.0460428862052363, -0.06544677551824848, -0.6655041996499764, -0.3770849699981382, 0.3737492779850056, 0.04785481129724547, 0.34311801067069087, -0.2718236449505476, -0.5061988019676619, -0.17136369288050168, -0.18296896109190847, -0.144997554231463, -0.4131823063557991, 0.0073805420292633135, 0.1291764044261849, 0.2917010545947516, -0.5855711549141375, -0.8093970749668841, 0.06039943130646466, 0.2453986235140325, -0.7700617582289833, -0.11291143905961686, 0.10401011540232928, -0.5462791063041247, 0.10835349576069266, -0.7246774036057279, 0.06190545712018334, -0.2267002774084653, -0.18727465488620496, -0.6020511395129824, 0.27645901893418323, -0.005732375237927834, 0.3535674238649557, -0.10429500843017714, 0.16348920206398576, 0.2869215020835015, 0.1619551202281137, 0.21121731491144857, -0.14931437033749254, -0.012791341552299832, 0.5122513608913236, 0.5855515247786562, -0.6577796550064525, -0.0699446071096086, -0.004271155114755443, -0.1529050829799231, -0.6101648335043229, -0.24698613835062036, -0.023193145742874594, -0.3027772280768852, -0.4166847453389975, 0.4335437437736591, 0.042140709122345715, 0.3868929258875397, 0.12434242863583853, -0.38577310879455873},
    {0.08985979415552184, 0.5525326402863358, -0.24218775183919483, -0.2887106784696124, 0.44380094358122507, -0.496763005544319, -0.2716366439123997, 0.266361061165715, 0.4099783116136985, -0.051886448765529405, -0.11413876248099322, -0.2600568872717293, 0.03478999038765982, -0.030259948162459683, 0.013044253860525332, 0.16352542150205457, -0.5131836711031296, -0.0721405902851169, 0.13176202050446248, 0.09012030395836845, -0.606454722778848, -0.2988034079500526, -0.2768779776733608, 0.39546343501452297, 0.0723849864125821, -0.679572703420891, -0.20873564215598198, 0.47868868622558136, -0.22012718919812765, -0.4346956568384558, 0.1671750666773567, -0.24612002538988104, 0.1774100776381808, -0.23172824884893395, -0.24041854893180487, -0.6423038794182946, 0.21382222627790226, -0.586809705617221, -0.44737371923214625, 0.24111788024555628, 0.13492142071942775, -0.280861949447847, -0.21207419101651126, -0.547274362696692, -0.15805248601118263, -0.035748018203713136, -0.14054358074251636, -0.08296139843004936, -0.16013197083344602, 0.0647725508345324, -0.4000450560820031, -0.031054511001294728, 0.41995874822138346, 0.41688427158659563, -0.32234424121689215, 0.18146853240615785, -0.3212617723834684, 0.55699559187943, -0.6195386756782413, 0.5129074744498751, -0.04863833077065109, 0.5612643095089916, -0.04927716958699187, -0.09149028575545678},
    {0.5733034347086042, 0.2394299427546217, -0.16549473944436835, -0.1718407194832419, 0.26105642113191524, 0.334211891751562, 0.17967588316700792, -0.3422111297411111, 0.5012265743498534, 0.27553443805527467, 0.13048901208320451, 0.11554550811106858, 0.3919495470285213, -0.23897314030459563, 0.6083968925205456, 0.3511024737219171, 0.16194693835716373, 0.5260836970661743, -0.40497373231972855, 0.08830277941262425, -0.35807178308285303, 0.2412022952520504, 0.5092755483055101, 0.4439230236055445, -0.4307071919179539, -0.07572790333774435, -0.35464022290909714, 0.0795432452363323, 0.20210440715156114, 0.020800064690265064, -0.14749446800058014, -0.059940211049370105, 0.06217470484841379, -0.13956715499888006, -0.25662993005775864, -0.049959724545043264, -0.25445322002258547, 0.3089412926637162, 0.4451340910714378, -0.5339464758300313, 0.5743656091569623, 0.08914598156741622, -0.18076761687158582, 0.4096858703929114, 0.08803796366228522, 0.44880254915128265, -0.5386430899357956, 0.7007841673477059, -0.5694315108494493, 0.2736027132417491, 0.017039122788580156, 0.3858844247697036, 0.21570601347873936, 0.28728868493708737, -0.16062691838030163, 0.03223755343733697, 0.3174495411848612, 0.7302369032722518, -0.14255528756432093, 0.23199004565682416, -0.21889658494474307, 0.20970837747631207, -0.5483287968602283, -0.23364582266328476},
    {-0.09161190205283215, 0.21576652390355203, 0.5564958473693083, -0.42192448480493394, 0.2763519700517159, 0.3061988333275685, 0.2603913940567447, 0.1476309479428444, 0.3925748167825732, -0.3077708080542531, 0.08012082898845352, 0.07415733316121846, -0.1994548998425399, -0.17468132388889382, 0.6015701640515525, -0.2796337586613719, -0.3337913511065452, 0.381490607919819, 0.7322069270275685, 0.4179311063739034, 0.03233710317815021, 0.6198149576129368, 0.3216595776087158, -0.41200522943477863, -0.278855482390802, -0.26298165812778795, 0.7062664078747173, 0.2672564300539829, 0.02627672599938127, 0.10707095128148157, -0.22321575428414062, 0.03603519821581872, 0.32757970592420077, -0.11765247281356787, -0.26284949685975545, 0.15647339215627756, -0.10236152617798625, 0.21709590194910836, 0.6387017966568824, -0.281404229430335, 0.8521866754864936, -0.025885955363190053, -0.16065318278618365, -0.40362539708714457, 0.1916111895787552, 0.2502229200284369, 0.011274054203563753, -0.22415150514961782, 0.30994475559973667, 0.15117304205620538, 0.1998287614291644, 0.05898056098541024, 0.013311290944964537, 0.27330214259121105, 0.2628320212129691, 0.054056119129973546, 0.5036938495203583, -0.1800510715456857, -0.20494977109575663, 0.25457859948694844, -0.11283841162844646, 0.40304611727711515, -0.5022831343398068, -0.5819824103977782},
    {0.20036144161983455, 0.3403014357166543, -0.06766265338268954, 0.3645846579295155, 0.3490541115513983, -0.42122075609333437, -0.05537129049756112, -0.0834910263649549, 0.012934259593486664, 0.12215109922808469, 0.3083297981922692, -0.4769891643563746, 0.14222720958915339, -0.48630723284820354, 0.13192968147960285, 0.4066168774421679, 0.01294582653580476, -0.4103918019047165, 0.07424805100822222, 0.45989599794495384, 0.10071561273480893, 0.2968544517929819, 0.40498232047131566, 0.4089513091936754, -0.4202136168873906, -0.3635168271941822, -0.38637081867048023, -0.21946582602614434, 0.033641099532702806, -0.5051734798750976, 0.737713417724889, -0.35075162245134955, 0.15716333626297307, -0.5332908343396187, -0.2790189685189976, -0.139028741917034, 0.2782251037488361, -0.2785254528260186, 0.5049310299899205, -0.47787944635371804, 0.10431614118199073, -0.5574645169850012, 0.19763190724858626, 0.1230343618360903, -0.0036345437681869442, 0.15161300060803115, -0.32776103087455655, 0.2479504131341589, 0.30391431449345435, 0.19599010200942488, -0.27975079385153284, 0.18584880524094471, -0.14245297901373222, -0.20518857793517606, -0.49849984194223207, -0.4570875694745107, 0.4000162253300494, -0.41099985046292176, -0.13620280493150871, 0.03779321365908142, -0.13708083089690323, 0.16235141999749772, -0.46985939713591074, -0.22096178383516318},
    {0.27974344850026955, -0.1874934003402676, -0.1303378301335972, 0.08861777603072075, -0.14543674456190853, -0.1486182536283982, 0.29983142389662626, 0.0009289603223597013, 0.15351205332174003, -0.4928883629721984, -0.21008890105247469, -0.6635546488034048, -0.1660100303706825, 0.03533337981509739, -0.0068852198026943525, -0.1922884380967143, 0.30625281504127577, -0.6005548159927983, -0.49315121817365165, -0.393524674373553, -0.2403615160233357, 0.37156784412278687, 0.3942972456399417, 0.38995713519198827, -0.10443411633880073, -0.09435309868571375, 0.11253709368719049, -0.1255485840890713, 0.404725939264917, 0.2003539433264181, -0.3474157838926757, -0.2726420031364122, 0.16321417239178934, -0.5309006865260015, 0.13465483686601265, -0.0007163512256709416, -0.46364617526747204, -0.4053524518330672, -0.11856330520638998, -0.5032372749137095, 0.0037731417947057047, -0.09107956553989459, 0.1031481877518396, -0.5524677414186118, -0.5081324758603205, 0.43290513423969745, 0.4662518033395579, -0.2602863456133889, 0.18098395294191696, 0.1737194339053587, -0.6373909593311856, -0.2594039663505867, -0.48798809627008083, -0.3627512260954549, 0.03369673703105364, 0.06170965783726965, 0.5510174973140665, -0.2558272186063459, 0.20288558794263017, 0.24766660300891796, -0.2719934666879044, -0.38311710463858717, -0.5722354170178198, -0.4026923787855136},
    {0.01337258864189505, -0.05827833554668877, 0.08007435621361327, -0.08615552675615293, 0.47589216374543747, -0.06685302923067872, 0.28663410322128774, 0.1391125844535176, -0.019257384088553757, 0.32642692950037394, -0.08756432112436514, -0.11869595700792916, -0.5384528214786478, -0.013233615868138454, 0.21002648528922466, -0.14528944157804247, 0.2400605665953885, -0.2363366908592813, -0.8578831101651195, 0.2968965504433609, -0.09895939539433013, -0.2232584353549729, 0.12653291750687795, 0.15327560345021723, -0.021556011663451512, 0.49448595271808926, -0.2330983506255301, 0.2659948686002624, -0.4541856879014861, -0.021962017845164168, 0.47611919067459824, 0.10913390468924222, -0.09940472970669276, -0.17161145256000873, 0.4474163175018575, 0.41672589525864934, -0.3278659158229914, 0.48872379528373355, 0.5546869579814175, -0.2069505716686939, 0.4269343404803102, 0.4249609817218282, 0.057459661020229195, -0.5233438382882816, -0.0463226476430525, -0.49730733761825535, -0.33478302390704445, 0.18503014641249796, 0.44842668467264934, 0.06564219317353173, -0.06300966428801191, 0.6444066118504557, -0.7127052113046208, -0.2570018332689243, -0.3918562938435186, -0.28319946990718126, -0.1326304421777271, -0.08932608910248568, -0.2196192032619842, 0.6162548232935421, -0.3571008218711099, 0.09546246471147983, -0.5365635214773766, -0.1342442072322548},
    {-0.40130624726018793, 0.05521701927141789, 0.2462469358120766, 0.21890521217163442, 0.054071011468840934, -0.006279683518811283, 0.4139469828245128, 0.1312005802964079, 0.13184327414736735, 0.23858442488891418, -0.22973189827394686, 0.06982439066442758, 0.13974635649216327, 0.17820816002401133, 0.04602730713444233, 0.24552143543820593, -0.08881965062508884, 0.4218735103828715, -0.10925103127375352, 0.2423166242809996, -0.3850533632479974, 0.393021647203185, 0.24788757583058688, -0.007793806287880058, -0.439845459229759, -0.21026936167030982, -0.0755481797257592, 0.2655875099149293, -0.5511654729572518, 0.08299804806690919, 0.48986108674935896, -0.6903052449425946, 0.32675932417616077, 0.06210811069541438, 0.4653652862760392, 0.4780196467750541, -0.3059930456418302, 0.14175542037300562, -0.05868164624868838, -0.01572193368919166, 0.5224153637430654, 0.017327909278028145, -0.016797827455901217, -0.2333075991082856, -0.27165421909787035, 0.08840086643098297, 0.426788706014439, 0.2791679557787901, 0.3336060879400922, 0.2760879709509306, 0.008385177521986597, -0.1802332267996649, 0.5866870584620484, -0.18471939853340985, -0.30999066968203143, -0.12849084308425598, -0.24067388420595923, 0.09403962362909792, -0.31365669752026937, 0.47991958488663694, -0.17766568624293483, 0.35861454763369527, -0.3380282826118837, 0.11916362230739802},
    {0.10621176595615256, -0.1318195168791545, -0.34292100793325386, 0.03955799592111046, -0.3363710711745789, -0.2587629149679062, 0.2030679706143195, 0.10389463775853722, -0.21937672243372405, -0.5487700103322483, -0.38715881429408894, -0.6391363173526885, -0.4039325806606138, 0.14855732083539913, 0.3904639230610574, 0.2989590985034446, -0.3021911670405974, -0.10772297501869814, -0.3569017561194522, -0.16754976606896052, -0.2375798842029058, -0.06444478421875632, -0.1129891490930105, -0.016628890231466308, -0.5581929904508592, -0.08197828509960021, 0.4153045109350556, -0.17797775059077098, -0.8176816218484297, -0.095735042075805, -0.32053464334756115, -0.8700534371715141, -0.1175850466369168, -0.2975948790821058, 0.27314904862512374, 0.11761745958197622, -0.519658136166805, -0.06342266110943497, 0.261870111421371, -0.5208477797140522, -0.09421847507981312, 0.05159537183784318, -0.28950524508257786, 0.1682245197595871, -0.1906669466122525, -0.33524481235279946, -0.01042404841464777, -0.8301647366759467, -0.17763237196485893, 0.13963374424365013, -0.2827878534176381, -0.2222656532154684, -0.010298501447721724, -0.39120984492712063, -0.24442069561067656, -0.16169075106553724, 0.02160676873681436, 0.2434843570836295, -0.3244292488158326, 0.4770252597102603, -0.2542398485982893, 0.18779283280852269, 0.322268159617662, -0.056115616628825575},
    {0.26940700305658966, 0.05433401279178885, -0.21352308755709531, -0.20432883570377097, 0.0780185616085639, -0.146270397412054, 0.016831037945513973, -0.14006534668606954, 0.015081027604729054, -0.4629547835050371, -0.23522122799884868, 0.1690674011648398, -0.4804454885680959, -0.3004505065780844, 0.4815762952518501, 0.21028180239670827, -0.2945330946892655, 0.020198707780321498, -0.5433855057482765, -0.1766546524355635, 0.21720410363122886, 0.40542752328381754, -0.16150068802967577, 0.3615623111965441, -0.5018772607911819, 0.5535921122242333, -0.6011621918685391, 0.31450897882663476, -0.42416758650356995, 0.14324737402994933, -0.22311332256785887, -0.26044602715226606, -0.09246072189656182, -0.518164587986478, -0.23762389431190536, -0.54318219086265, -0.27476593538335636, -0.6351995167679749, 0.4560916196452254, -0.6621844158006566, 0.2496467189706026, 0.26529379552645976, 0.32996106486463983, 0.3113758482072817, -0.20914152471279665, -0.48308531543521693, 0.36902036839583724, -0.4817087903875274, -0.07968611342969042, 0.3933323467643075, -0.2885016462504976, 0.34199804500434744, -0.46838013707254733, -0.21631114273365096, 0.03626575083961959, -0.5182940480579667, -0.25169383002050827, -0.02420468072091122, -0.02307048039007753, 0.31631413502491296, 0.17858278825397106, -0.28503092147150183, 0.03826335637346405, -0.46205927089136},
    {0.3548330623683154, 0.23238820556717993, -0.08276475744463913, -0.5805735749870524, 0.40937320005422867, 0.33282937741865143, -0.10533220452262083, -0.2902916831991976, 0.06532940329232981, -0.302460656922442, -0.21747886252428072, 0.4227714311416807, 0.13543760966722612, -0.421594012352881, 0.009490384658120311, 0.19234580565770912, 0.25387262103498076, 0.2768320470617642, -0.49752561580220933, 0.4652343915174703, 0.055464716179866924, -0.13034668840554395, 0.7749683268661605, -0.28548169838264986, 0.01574486620684538, 0.03597279241635531, -0.23978771955152484, 0.26400228872224946, -0.08543457810609278, -0.24583542731751212, -0.2784654376799574, 0.10929700161791302, -0.03522851176581017, -0.12719003232411147, -0.3520418678780321, -0.11525596371746517, 0.10728404450097838, -0.6259347842815769, -0.22874635888886313, -0.19950321785363279, 0.3266585964798174, 0.6375116374944269, 0.1533240768248549, -0.2334848457161362, 0.010325863303727749, 0.112541099966304, -0.09499719059867985, -0.09137878648055381, -0.0006243065000896481, 0.48456766200573004, -0.08473742628930243, 0.12760218798274278, 0.1959283279242816, -0.38715915381191224, 0.043407268199384896, 0.29069057507058993, -0.12975558460632475, -0.3637113832461455, -0.20490929798357121, 0.36515391272580044, -0.05452418592751463, -0.0941291682008369, 0.22790846341561014, -0.8757703940247809},
    {-0.21399604751007026, 0.2702714838543072, -0.3479623807234666, -0.2797693807280633, 0.1443109480670971, -0.26279281682213224, 0.118063057423726, -0.3111962964719273, 0.2925838644559921, -0.31600264868818223, 0.1573648654205757, -0.4401509925660074, 0.23913331847520553, -0.025583647403903197, 0.7449169646532812, 0.4384509260692884, -0.5377164486524132, 0.04828817416347458, -0.1882383106521649, -0.2751673584120328, 0.017680475458434125, -0.08200894853562254, 0.049306021186160384, 0.5663986465133072, -0.4246897849784247, 0.1483995015715913, 0.6868406923791692, -0.45565343559095406, -0.24598480316296267, -0.10273087939892128, 0.36273830787606937, -0.4256074471926432, 0.2541265962880183, -0.6041546923476947, -0.14924136067483745, -0.5400333845560872, -0.37187726161206996, -0.4408766653502994, 0.2694938813609927, -0.6392860104300011, -0.1307739752464448, -0.02506698518066442, 0.10997894473695372, -0.5414644135345105, -0.21605021631055585, -0.12880174120404028, -0.01971310004949101, -0.06495093203886668, 0.24036033472473092, 0.6719773872041683, -0.4718763442844154, 0.020425540724509056, 0.059657970729223075, 0.1586951198406051, -0.3241250976672181, 0.4054129400629354, 0.1846878750110938, -0.0390970876923247, -0.1273744386160117, 0.3149164248176024, -0.08978112156133648, 0.20703173543473555, 0.4278406731780953, 0.07217931978191051},
    {0.4594625374750445, -0.14372059314510002, -0.529536054334389, -0.36760062945461935, -0.0827269610014937, -0.3825988797907577, -0.6671587295434838, 0.026850020590002768, 0.6983435956217167, -0.3896979080275793, -0.5973919867095636, -0.3156092449932944, -0.21982048045145375, -0.04801795913441759, 0.604828367110102, 0.38143609729748623, -0.23274244446901304, 0.07451574411012064, -0.3779989809284834, -0.6181521082252697, -0.8123374307620541, 0.05267325523874418, 0.12339363217115754, -0.0758753925220712, -0.7307308931977373, -0.2720922595897065, 0.3845438065708051, 0.37625092144750755, -0.28692127969941805, -0.12778562849180872, -0.4507495452500393, -0.1434776288855878, 0.21958958087186808, -0.44452691939120753, 0.20072741696085453, -0.5583238008244176, -0.12921406182026451, 0.11865462202964135, 0.35781383690382834, 0.06708853733726286, -0.46370543797744274, 0.29935618341624814, 0.5853936404134666, -0.45203143077181623, 0.1870316665015133, -0.003385920827792089, -0.46349598355838634, -0.24604843747609814, -0.24039978731163078, 0.5058431940862829, -0.041098705642274316, -0.22327715975049992, -0.27213861136215123, 0.08064322683865541, -0.5174812049766053, 0.7632218792361305, -0.005206937985677995, -0.2658082310538481, 0.3361420699571621, 0.1671007231295289, -0.02237653144352662, -0.49678221077228474, 0.13753989377102246, -0.14822682954716632},
    {0.01016651857994863, -0.08619202230430825, 0.06696848835554199, -0.6650564874898844, -0.10023945972843497, 0.29514193596111615, 0.11868240276577137, 0.03589582665015619, 0.07911279138131391, -0.33438963077963957, -0.29274812092163577, -0.29280767099186855, 0.7060765162951566, 0.5520477156317068, 0.25086205015150015, 0.546652037572952, 0.058579815852305296, 0.6228260042136112, -0.2943369781679972, 0.13467075567367368, 0.0150268179940843, 0.1205153754691625, 0.1784918789095233, 0.28151656294465727, -0.7419948892519731, -0.15536029503378734, -0.6366951308160725, 0.24590017902841946, 0.5039009144998197, 0.2663734444080364, -0.3464302889268387, -0.05937562508978117, 0.10315658915461527, 0.05816377928964498, 0.08426694263948871, -0.3465343596705272, -0.14598936666852494, -0.0038910380204542246, 0.33346400715090097, -0.21319668353172558, 0.6637092433372802, 0.30006018522431116, 1.007465584623434, -0.5948991656058993, -0.08312723506664631, -0.2919999036471893, 0.245737517590212, 0.14295472958078542, -0.26222297679393597, 0.055717202335079485, -0.13297547715830574, 0.4541520712267731, -0.17925881035702035, 0.607937070703578, 0.24408821183214868, 0.47755665292558896, 0.30946517226584624, -0.273975543990415, -0.18238611951676204, 0.2335006873828136, 0.10971288693725637, 0.23470595125845833, -0.003864153139227084, 0.031100584955105502},
    {0.32801041081407495, 0.3272036098537693, 0.18867951110591966, 0.270978593982745, -0.2906506700664368, -0.12064584571799418, 0.21109796094732375, 0.29491949853682, 0.34512091591410504, -0.18721967043766427, 0.1616121197458719, 0.025847504943238866, 0.6692103907609745, -0.28674867672601173, -0.012728977585194607, -0.018746275597867467, 0.1044906065312093, 0.2849205040107652, 0.26436137459170217, 0.3613038626980477, 0.3378546564272338, 0.26776336716895427, 0.43602594711808157, -0.09017963726618998, -0.17601530451029623, -0.05160740303807374, 0.35643874693078215, -0.5493156639684331, 0.19299210252925517, -0.4275091574389787, -0.35430686888532426, -0.4758890074695946, 0.17693096731179472, -0.25808312687549706, 0.048200017387808713, 0.34989623605954173, 0.2611109566309326, 0.01787269772360551, 0.5414148259718756, 0.30371452161493084, 0.36549637762590403, -0.1859984067707738, 0.23686441051709142, -0.060403745424901706, -0.5420490621950917, -0.5401042015890107, 0.15923718743786588, 0.14689894817342553, 0.09002274030257572, 0.08130591580850162, 0.11000175338101138, -0.6296729209587375, -0.15727278791921875, 0.199269772304519, 0.56050162402343, 0.013411120313168719, -0.061961083047054624, -0.3488272382720001, 0.2748114692106048, 0.16259883910818335, -0.21782465808152737, 0.15395422368912398, -0.10021391726492304, 0.28700996092194847},
    {-0.6879567342112742, -0.20876391806918246, -0.24009990808259987, -0.3300274354828369, -0.3989697457553944, 0.388762957910184, -0.24009408504890603, 0.04467910646796879, 0.02599134345686212, -0.3246758840342324, 0.3147637867116047, 0.7907696696747151, 0.0027359847412002955, 0.9671728498605056, 0.10194051391483844, 0.2896857181366118, -0.3406378659840799, 0.5119528195983991, 0.14401472636663443, 0.1394560480348944, -0.2948102713232293, -0.49390948502541987, 0.18076173791223105, 0.00456517093850313, 0.16750131172467936, 0.3931810953001924, -0.149204944482753, 0.19623509842371867, -0.012074104775365054, -0.30244072244914894, 0.5590471455549971, 0.14775919963376846, 0.24795451949399686, 0.088297559581941, -0.06274004383743102, -0.2185690548342372, -0.21885467485289176, 0.12924894608935422, -0.29114622206043567, -0.09957024294046213, 0.09501614249244174, 0.040548643657964886, -0.22370561141192402, 0.5793932153491551, 0.21087189516809832, 0.4831873986925284, -0.1918604704849912, -0.19131705493456402, 0.34525077906097806, 0.6779287805996737, -0.3331376434691879, -0.2022541477304295, 0.8804833677852688, 0.7666189139254267, 0.31079021006440116, -0.27721428837336604, 0.42564161286862323, 0.15319640846759705, 0.1741738122003511, -0.5137482363968198, -0.1723735283555305, 0.46158477442324586, -0.058913148755990165, 0.37558933844958237},
    {-0.5344531330884336, -0.10787743921447494, 0.46546239306751575, 0.164398259984984, -0.48578618561954096, 0.5023830934938095, -0.016697308476252747, 0.44858347084853184, 0.1113835967386063, 0.05679349223438069, 0.07890205054997788, 0.3292894114922367, -0.46726288846512815, 0.5413427346870742, 0.03507214712654499, -0.1839570715269197, 0.5752294350664642, 0.030136501061510095, -0.3271739814128766, 0.16801172893692226, -0.45389860413662725, 0.2417614278903764, 0.4361583614480756, 0.08513793636553646, -0.6355100235731153, 0.06663652250155165, -0.25169963457969363, 0.17622782632325978, 0.3732137524354559, 0.07003278771451495, 0.22579789778082976, -0.4069188062035875, 0.7624208416165454, 0.39054297254711734, -0.1907879336891334, -0.09484731843828986, 0.09197306465367687, -0.6101270140568604, -0.02641215262979697, -0.03649670406824862, 0.019016751232935693, -0.16467829959310284, -0.5241914394303608, -0.4634675506441697, -0.295878022870267, 0.17738906048029937, -0.06199623651433523, -0.21510872747936807, -0.23435669865926717, 0.06384466461648017, -0.03478212439495951, 0.47955160370270217, 0.3426496403781545, 0.6236457936318763, 0.1428628536646796, -0.3162884353468788, -0.3579001032482803, 0.2428314707214427, -0.47859949887724224, -0.2350696243073314, -0.08867458161202524, 0.22513231035004688, -0.054710131638422886, 0.28870025192844295},
    {-0.24835954335908506, 0.3050129772126892, 0.04599586698446856, -0.6790414729597118, -0.08527806873317027, 0.689695751955274, 0.17108373218262868, 0.3273885013146201, -0.20254030055809097, 0.008721941923969238, -0.2043388374743415, -0.22007898682391336, -0.3358538763144721, 0.6964988896757464, 0.14306898918537905, 0.567013255675831, 0.161391231815886, 0.4022533920176926, 0.18553193256091755, 0.03195418678593344, 0.013511627781499773, 0.2043885293308374, 0.2580085632177576, 0.4824346333801157, 0.4160086674295967, 0.5885386966626636, -0.48171386049697784, -0.11517182664858426, -0.36277795077607733, -0.49792276353214227, 0.4173372097605837, 0.2689161685600195, -0.05578505274448075, -0.08745724173937061, -0.5882920477543706, -0.2559028524577345, 0.4674317985517748, 0.27193330822699857, 0.3101617929550599, -0.3063233430534006, 0.4006391150496047, 0.05236014907300697, 0.14204273868658224, 0.12967994079876072, -0.3810579199292719, -0.37374675757717446, 0.24745545650368425, 0.20063079058108213, 0.227270266090386, -0.06911504302456814, -0.2877715057905734, 0.11614602361691968, -0.25491877006755714, -0.08743844490377572, 0.21284181691596116, 0.07676957069191626, -0.055007595053151045, 0.2904131051568574, -0.35701064020297807, 0.15821276759825006, 0.11849397037214081, 0.51863069112623, 0.0024848577327037783, 0.051854829910839555},
    {-0.22621593433038087, -0.15900626841283744, 0.08838779116662969, 0.33270507059703597, 0.010466720851465352, 0.23280831520029344, 0.6198065820333766, -0.09688055288329361, 0.2184750713994796, -0.27468299360520715, -0.056644107904931545, -0.7486339652334996, -0.06125150025477618, 0.32132060149191494, -0.11560437931624962, -0.13109349693329028, -0.15557909658555288, 0.22012842917503664, -0.23681899328620037, 0.03563493819817773, -0.25940010485961645, -0.08871199426552645, -0.02581590284147032, 0.28164136115544314, -0.7979293099372219, 0.15417461154075635, 0.18627906374973724, 0.40916397525698184, 0.03901782746282902, -0.3553783363722717, -0.08994243681072145, 0.01288016805343924, 0.08919742083737886, 0.035101839818250186, -0.37774333098717533, -0.009864754352489681, -0.516383442820992, -0.44085739039810445, 0.6250024311257202, -0.04072954043960061, 0.07400678174684225, -0.614660780251403, -0.20384537645033363, 0.10775756768697213, 0.32307561793578216, -0.2668679781151922, 0.15807442997135798, -0.3016296813610429, 0.3272268976061309, -0.15734364735287912, -0.49114714440388413, -0.1636161581964409, 0.3538052331818924, 0.2514744219109715, -0.665701225639478, -0.5305479544966799, 0.17062194437279604, -0.3044161231705115, 0.12143564143591586, 0.11050423462193444, -0.4272914033816046, -0.0700679104098897, -0.1723760151474772, -0.2348649946753947},
    {-0.482743526640791, 0.06712058353742398, -0.5633033339412354, -0.7860342626674288, 0.49810511520475614, 0.05365929350798186, -0.6976625776661111, -0.17706472055957673, 0.27263849445628807, 0.20298731450392213, -0.2893659716519504, -0.3572744042296628, 0.0170963282687095, -0.2834942490156369, 0.34498760604954626, -0.41369905694746895, -0.1665841045733222, 0.289204537990765, -0.37471053139146654, -0.1574403606910632, -0.043125210433621816, 0.5245254622237882, 0.1997370555942556, -0.38013688249260924, -0.44717191476491197, -0.34223750825346283, -0.04027973519837596, -0.22625947624435688, -0.5069843910136983, -0.15564942210465918, 0.3150100868602912, -0.1338919770003209, 0.4153749642945067, -0.36605954302623345, 0.16966879187906478, -0.37589871386451057, -0.47796217237574606, -0.02101561595242283, 0.4596313447971005, 0.10145150134067224, 0.3873973758305216, 0.2074097782053456, -0.12930734128330063, 0.018757475705062747, -0.300278605600743, 0.09694530545584669, -0.42687791281482096, -0.788095106252749, -0.14866949130625412, 0.33291785857863976, -0.5599741879186485, 0.47832156591887354, 0.4202391578919755, 0.7749778378253364, 0.5419808845122125, 0.025253452388546132, 0.15943036472608813, 0.04270476715708379, -0.2828622492422211, 0.12978331469658244, 0.4211677870380927, -0.14527319696401764, 0.1703182247273332, -0.08318380445387093},
    {-0.03793393810182205, -0.2715732678246797, 0.3618861882454711, 0.0880483364471061, 0.21122284461828678, -0.25784855874750606, 0.04852565974554429, 0.35506439998654143, 0.41490033744395005, 0.35187077728726524, -0.5907485425367293, -0.32689623085076996, 0.3815018128186968, 0.2993670030745403, -0.5182901701093505, 0.3423310693156137, -0.07740230438648088, 0.08606297969680374, 0.2547535367893174, -0.06485399645144073, 0.1773386933440533, -0.17715706789438493, 0.6395866878120406, -0.15102187375172701, -0.35121018476061544, -0.4353231866460116, 0.00435597882953531, 0.32024634704797283, -0.05155537388289306, 0.1371150273724823, 0.37035142948991906, -0.7900036079426861, 0.5274483406079679, 0.48717903656992356, 0.3485849991067007, 0.49623721323856496, -0.038295126395295344, 0.45489021248974115, 0.5991351015938292, 0.04766665511537096, -0.08980456404638498, -0.41786933810476173, 0.38632090405889086, 0.3462402246973499, -0.04813528317456205, -0.16747561095017208, 0.43451522577033713, 0.075534170495954, 0.31271688645623513, 0.2717168259721007, 0.5334523100706153, -0.26556388300630385, -0.12174866659003566, -0.11342477938965431, -0.1294796731735989, 0.33223049382019737, 0.3945692420787982, 0.033706199794900825, -0.10226949204160268, 0.5819091341566033, 0.2802911391921518, 0.3580047257387683, -0.31846062837276357, 0.19448389348968698},
    {0.5219423513051238, 0.4714210315436982, 0.13354915960269634, -0.17575103912747114, 0.6002871281699755, 0.21343177015850084, -0.10546410138429999, 0.10852038328971868, 0.2993596191734966, 0.3327423594928364, -0.10920676610521525, -0.26029814757594577, 0.2949755865421162, 0.05723055784880483, -0.36575253928663487, 0.0668664464934733, -0.45314270785994326, 0.3118319962175633, -0.0016880480452570997, 0.11310409547908022, -0.2000742208105806, -0.4639768069855982, -0.4125652639077982, -0.054912202162870474, -0.10347082034276818, 0.6659276286841896, -0.6854293532570997, 0.3878837409322497, 0.1509469016285454, -0.08911360099089112, -0.36048554889884, -0.0996616849308234, 0.24638255650988047, 0.0030336068462476135, 0.5928272300497486, -0.22065187856139548, -0.1080169840698592, 0.0001606564751781168, -0.203334041370323, 0.2138847357474094, 0.16065296249420452, 0.29849602572849354, -0.2432114248466282, 0.030537670509765306, 0.04430586434575747, -0.010426565999357804, 0.2606936064086741, 0.02761064442701565, -0.20616866328709232, -0.0684914172961124, 0.21810914600850162, 0.23789470548139463, 0.06503864011739363, 0.010559662969546824, -0.17633025729385068, -0.37023142961421796, -0.919002667775419, 0.27093945922961343, 0.1144805656744881, 0.23903815446303, -0.703357437740183, 0.19842508907342735, -0.7388282314666986, 0.18159777372598307}
};

static const float b1[64] = {1.0969122317819209, 1.0518481949474967, 1.1334454741551139, 1.062849984792198, 1.0784663333546756, 0.8972212283777359, 1.062421057301137, 0.9396024703868509, 1.0747387319956467, 1.0388113489544752, 0.9846927257628467, 1.1525431601296938, 0.9406912537013921, 1.1497812766272544, 1.1129811254976303, 1.120751456143175, 1.1693232458334497, 1.1558219335297297, 1.137208964130826, 1.0296741699521377, 1.1265189643242968, 1.0519969928775463, 0.905297864980906, 1.0739639977117204, 1.1210380206097885, 1.1880426607236574, 1.1633289529529371, 1.0137139926478358, 1.180677632443674, 1.128324371571978, 1.107525082740688, 1.0988768742822823, 1.0818214079423358, 1.0574217916234478, 1.1084986444124632, 1.102716809765169, 1.0494524102459732, 1.1258775416992997, 1.1043104194527162, 1.118975341343875, 1.12880032832083, 0.9011492611310544, 1.135133202417896, 1.0954329570664483, 1.1508241238796786, 1.0843640881074013, 1.1135461953294814, 1.0308046516441194, 1.0510266658422118, 1.1610329853563763, 1.1439597029266904, 0.9748258330575181, 1.095621865721534, 1.1412462865015196, 1.0993983264730978, 0.9734856181540897, 1.1330414477978794, 1.0084662689916604, 0.9891420824091313, 1.0768681493174224, 1.1693697394901343, 1.0744348006728084, 0.938787162016751, 1.0994427904876007};

static const float w2[64][32] = {
    {1.2479731835244425, 0.9273748813899256, 0.9092056259814402, 1.016564341241984, 0.868414841887457, -0.2289058706537518, 0.7681120504927463, 0.6323817020694691, 1.0990395674899611, 0.8956881119003924, -0.1964762158682315, 0.9493616287470539, 0.9845346105181823, 0.9221345801606672, 1.4115740737903815, 1.0059051390776803, 0.37882619359895237, 0.8322610663924245, 0.883236272292684, 1.267521388704168, 1.155626418064476, 0.7831143427866974, 0.8762911994289528, -0.18983963605255952, -0.25008215753745106, 0.6495980574792695, 0.9612643917484938, 0.899263468158431, 0.944788952262364, 0.5496520401153471, 0.8683433752491396, 1.079211125782511},
    {0.6745192196066451, 1.194287108271339, 0.9665849022171575, 1.3214555847904936, 1.2156286373073388, 0.08446006709083179, 0.9625346959272967, 0.8567044206906185, 0.9541333216309121, 0.9419610988551856, -0.061625928267107326, 0.8165688184973178, 0.6524864536534367, 0.9368350074512845, 1.1326071386855556, 0.9990138726381124, 0.5289606196947592, 1.0294168089858715, 0.821144135330579, 1.0706466299568418, 1.1753879422033908, 0.8189551138273208, 0.9493772785069093, -0.25980071526097936, 0.2710422918885951, 0.7029562456665682, 0.8021437569283956, 0.9276718333103892, 1.081880304892015, 0.653080616918716, 0.8714093279784232, 0.9298254117239628},
    {0.861059033411577, 1.299329082952562, 0.9602194020625685, 0.9237258557004552, 0.8969534697806258, -0.18409004663957515, 0.9158910171557645, 0.5027731521574811, 0.8981927632830942, 0.9350193900564053, 0.08978055040580722, 1.404816168320977, 1.5435392831044104, 0.8706487687099027, 1.1571365009865813, 0.892097152514074, 0.5353918714919501, 1.2643658853980908, 1.1638805510439854, 0.9800727729372074, 1.1224797893402467, 0.9804831863269802, 1.021707042533591, -0.0874514662258597, -0.5675277121704561, 0.7694127070058386, 0.9621003937405115, 1.1657967418885324, 1.0962386327812397, 0.6225095601226942, 0.8625836737308782, 0.682171653535989},
    {0.8962640776965769, 1.086507191785885, 0.8477289158179233, 1.1555187975383714, 1.1833260122800726, -0.5524404649131355, 0.9558201538252366, 0.34842081007001835, 0.9461932333734282, 0.8448740839035778, -0.03458456278334134, 0.6563266158564398, 0.973472093112198, 1.2752759144098917, 0.9737534391857697, 0.8784014345090256, 0.7886751441744796, 0.8723627533741879, 0.9224425587687852, 1.2987436942950772, 1.136473254828617, 0.8544702166547641, 1.056993047270288, -0.053622299763840864, 0.07245763516430706, 0.27272274802622487, 0.885432955406603, 0.5311791733635056, 0.9150636662602543, 1.2191286290848462, 1.1330107129054867, 1.0418277007849441},
    {1.159913637750102, 1.0972266952916023, 1.2338510083465588, 1.0107473508219338, 0.6787095500762113, 0.056641717492800774, 0.9182047173440152, 0.8492686311898646, 1.0650907680324568, 1.0837080086115076, -0.1469364268399336, 0.9926285545147553, 1.2162199173940464, 0.9369859538189194, 1.1564367598726881, 1.0864419113779966, 0.7038561745094217, 0.848324048903729, 1.064695756601756, 0.9316069341879166, 0.9998185030972554, 1.120985039007411, 0.8317911141045023, -0.08715098912071964, -0.04416623157975647, 0.570917517194956, 0.7236823150062385, 0.9121647050752366, 0.9554711164176268, 0.580966414632568, 0.8243658603241828, 0.9104411632608505},
    {1.2218675682849878, 0.7664521633037388, 0.822481560521959, 1.0393627042225062, 0.9868258850958498, -0.3456762111913199, 0.7047298170468252, 0.5606774947552249, 0.9166496410895576, 1.0998871585206422, -0.056216953759384576, 0.8457029311463858, 0.9415572962937506, 0.9512382069358517, 1.0174000866002233, 1.072179037834452, 0.8745446272319178, 0.9118260141926608, 0.5553668541188099, 1.078900714166613, 1.045447006710807, 0.9171631188020637, 1.192029728347726, 0.1586275890174813, 0.07136846423684859, 0.6640054477654095, 0.6309716102464317, 0.5710804238635149, 0.9423837065344778, 0.6457059863763602, 1.0793124209224225, 0.7643741093575086},
    {0.8551557505304238, 1.0238715125092315, 1.2647378596537227, 1.210232943847948, 1.0676636328305236, 0.20923675266958547, 0.8554292059658454, 0.8977487898619325, 0.9424581637312462, 1.0156745936798384, -0.16623846874331505, 0.9644193841985433, 0.9248449621170299, 0.7468802443660901, 0.8537174997077227, 1.1314570079772057, 0.4247138815616899, 0.7674184632590794, 1.3094720531002288, 0.9270002262500648, 1.1340787766058265, 0.8383914664156874, 0.9802861177389398, -0.3636820798361616, -0.02358976003955455, 0.6910098599445822, 0.4955446463505812, 0.7605474008829763, 1.1528969667975832, 0.6568653656784166, 1.1631702269395359, 0.8742137149441698},
    {0.8035532889339627, 0.7952466953502559, 1.0302831253352938, 0.9148331373140469, 0.9954269494656338, 0.06173057629268346, 0.733071091278373, 0.8381772606856223, 1.287327575316448, 1.011155608329957, -0.29396146381010424, 1.2320866769833707, 0.927711252286173, 0.7977218369409438, 0.8393113791130183, 0.9643600263883862, 0.5898841115118587, 0.915015034885527, 0.8329239725104849, 0.8329333405363696, 1.0534252920170382, 0.9845347429069254, 0.6519916558484814, -0.2982789782285629, 0.3068814281924998, 0.8860849322986799, 1.1348860827350506, 1.0986031499902922, 1.0534067067469877, 0.6905961121554381, 1.047853111429756, 0.7917934286027482},
    {0.8983476941139541, 0.7713051804283196, 0.8719251585314578, 0.9146187493776331, 0.9004351195343623, -0.004995857896773815, 1.0103846911944765, 0.7220172076536387, 0.9414629329981671, 1.4949204038030992, 0.1670314893955283, 0.9877333094086035, 1.03258670687907, 0.8642241695026396, 0.7455143024604607, 0.9130914632862737, 0.9109472896498738, 0.8520555490571947, 1.1611567426193088, 0.5225737754322312, 0.8886393916088687, 0.8212077503006372, 0.9178787379879301, -0.06600323358055164, -0.05668656410580071, 0.5911452492609411, 1.0416093972480491, 0.8152859552442112, 1.037333207432589, 0.7385513546469329, 0.8377875985749358, 1.1965111367255823},
    {0.8545499949719095, 0.8830257622524328, 0.866894679115241, 0.8674196955090884, 0.898660206504281, -0.0162901245015902, 0.75721266357499, 0.7010412329095895, 1.286552869808088, 0.90908721864455, 0.11361873916519426, 1.141637490958205, 1.057399535581132, 1.0260999911481097, 1.004543081143462, 1.02340029220184, 0.4841197114043974, 0.7939889661761381, 0.9874096765573627, 0.7923992726845808, 0.9081425160572457, 1.0114266792658444, 0.8519791682407944, -0.20800419641679152, -0.20859611043179926, 0.6734122510880841, 0.6033997680537747, 0.9165486459394686, 0.851980738675611, 1.0304153414956563, 0.7965632037202882, 0.9348502513495459},
    {0.9456040010523068, 0.812393536490213, 0.8885131669331576, 0.9824162190548948, 1.2095567657679023, 0.0953179476627614, 1.075030042251491, 0.7616311997072917, 0.9362909471050884, 0.9238499200020973, -0.05850780261147717, 1.0649702193895496, 0.8664756691404201, 0.9577758065663035, 0.9873016665316954, 1.0332870718158647, 0.96407899170897, 1.1323507853113408, 0.9386644891163625, 0.6987591611969485, 1.1467940265652714, 1.0887761735567552, 0.9380602439946744, 0.18784043738258538, 0.10460142948491565, 0.6662572581820775, 0.6154989700365379, 1.070739527117306, 0.5563783130969426, 0.7664863321797079, 1.172776521991754, 0.9476320190020858},
    {1.2468462470634574, 1.0641763879015824, 1.3226066136877024, 1.009918831741758, 0.6937106304175052, -0.16860913226771906, 0.8291121357207666, 0.3108073914463741, 0.7577942305545894, 1.1113380922662122, -0.1481116320082275, 1.1094912506323826, 1.0207673918252644, 0.8144642575264763, 1.1798926520243718, 0.9318757675946392, 0.5399491078984963, 0.9744484286376256, 1.3988826322769854, 0.8457985553429206, 1.0824194746580813, 1.0090291860255844, 0.799799906736874, 0.08654110721336124, -0.3556018392540555, 0.754261071509513, 1.0673579180102684, 0.5441430449424188, 0.6898285846299111, 0.9875629622131893, 0.7110137372540952, 1.041158598030907},
    {1.2806986532095486, 1.2226249167834617, 1.2344466753937318, 0.7138513756716902, 1.049430226477578, 0.010887963622267635, 0.7183805888969239, 0.5202681382711283, 0.9028043891352139, 0.7498203545414214, -0.2027308533685103, 1.0455289492221849, 0.47902215085907596, 0.8263476262327488, 0.6946288089087718, 0.9398168169671121, 0.6031415706378888, 0.8865791222978004, 0.7390727153490586, 0.8427068731377126, 0.9920603821498005, 0.9350568569789024, 0.9931508910569276, -0.05316454188847693, 0.16304432759779844, 0.5899365195442642, 0.8509317047191216, 0.9005267425448361, 0.8202327500804951, 0.5682953648304477, 0.9452453412986591, 1.0782431908896979},
    {0.9644257473974511, 0.8558070815001518, 0.8815159346997442, 0.879753597850581, 0.8008770282305675, -0.23030432890538233, 0.608319260679644, 0.6001094858712902, 0.9407967558304828, 1.0054527319472253, 0.059523364670198156, 0.8622871416362999, 1.172689292547892, 0.6476760883894302, 0.9889447981446643, 0.9255094404885215, 0.47827344282264084, 1.0049426769745873, 1.0206756995050243, 0.9859741543563391, 1.2380449098988002, 1.2916361174652407, 1.0646780332329324, -0.26985914680393924, -0.3287927405230306, 0.6522033174346785, 0.8759589859788027, 0.8648594866431576, 0.9039356549891399, 0.92546238444989, 0.9367141896816098, 1.1403703449981701},
    {0.6582286553956829, 0.8286246189913486, 1.3018216688289417, 1.1513303087690816, 0.9228214249743328, -0.20276201833556579, 1.007657472333153, 0.6238790810334885, 0.8827263375468122, 1.0315558495429045, -0.1198569872797601, 1.189976361491957, 1.1359454044613524, 0.7175290390008465, 0.9181379288533831, 1.0977346793444471, 0.5864771608848679, 0.7318981397297106, 0.8860600478196518, 0.8277202569745993, 1.1594338508261106, 0.9720974017594531, 1.1164019490725143, -0.162150107299658, -0.11551812538167648, 0.6505713290400702, 1.0282864306303097, 0.8144042089109631, 1.169064306140843, 0.5611248218451483, 1.0208166134417473, 0.8826069906295104},
    {0.7704853129897001, 0.816089883214182, 0.9284921681629899, 1.1178920083747124, 0.9346937178472338, -0.0003255632692455623, 1.224000892021139, 0.5046949206569231, 1.3505137676755572, 1.124655972569096, -0.3248339433255473, 0.8736446645296103, 0.8621042934420459, 1.039080315619334, 1.0366335560596025, 1.0185121091758296, 0.5750667610154552, 0.8169703457533913, 0.8117179492313437, 0.7442145851013559, 1.2896701452379171, 0.9299962875228717, 0.6246451706138355, -0.10514511685273877, -0.1542012404048534, 0.8000703413064715, 1.2034979696827832, 0.6518681975698282, 1.1944557806386311, 0.9169775108121999, 0.7625975629813598, 0.880915403156824},
    {0.7782419678480369, 1.1424373010166298, 1.025327307680951, 0.8635087673278254, 1.1059500747883384, 0.019196739380839486, 1.1012128063758528, 0.42392884917722906, 0.8708042257799321, 1.0878977547227777, -0.403218306752099, 1.121266719377305, 1.2884776358908145, 0.7081298603926092, 1.1197186816371338, 1.1128567138827203, 0.7125530357199785, 1.0375461582231795, 0.9818551353383743, 1.0826753802475153, 1.1864178394629512, 1.1393131514128674, 1.1014155873292484, -0.20563150655267262, -0.06838249441861681, 0.9519525171492823, 0.8557429039118468, 1.023993944732234, 0.8620043332200181, 0.8889816737967036, 1.1906709557753659, 1.1140416434289362},
    {0.7180954695082002, 0.7381857952166764, 0.8891493155814946, 1.0709201587371562, 0.9521019234789619, 0.09126915114147748, 0.6876394384202477, 0.7781595249448525, 0.8732271962366884, 0.8230908499510101, -0.2987124027723738, 0.9420131963914996, 0.8473764371145309, 0.8529886085756024, 0.6901867785980689, 0.9453774049967375, 0.5502265480192231, 1.1976081681946573, 1.4991965329718473, 0.9008721416360344, 0.9184918360634438, 0.9022115242514626, 0.933717218957176, -0.11849701452480689, -0.22858605467284748, 0.8124762693936624, 0.7292291835173464, 0.9288321264895779, 0.9679559084217433, 0.7168760895960888, 0.8464873810711963, 0.9000842349892328},
    {0.6820741909344857, 0.9646376056291446, 1.1100411202638523, 0.8202580766942302, 0.5812984572044743, 0.003762719866185519, 1.011854822275424, 0.494121803636332, 1.1571917224679762, 1.0373643705646303, -0.002134742104325745, 0.8996347719044185, 1.4074337804535626, 0.8125188430680734, 1.480813166400091, 0.6435246120127222, 0.5267861042823445, 0.8872118121862248, 1.030387549573481, 1.0232266126555465, 1.0808925642110676, 1.1917283187309868, 1.1073578697923265, -0.4101746155456445, 0.0333337125035953, 0.4675846711347149, 0.9953329984459585, 0.7544693447970734, 0.8617369295114737, 0.6387296513923262, 1.1059175333415603, 0.8099778692821916},
    {0.681774774350548, 0.7597181170158666, 0.7925169159343531, 0.8704430213950413, 0.6514679823652793, -0.025292389438689097, 0.852044478451372, 0.6035973171993989, 0.9455309780570091, 0.8230904052385184, 0.11963620662461823, 0.8609917510056916, 1.0271221942778093, 0.8860243749780994, 1.0218971095976934, 0.8568922413148852, 0.6822118399300922, 1.1794121921399372, 0.8563789712656492, 0.8030811626666644, 1.320966688007732, 1.3766759328129388, 1.0356997731186968, 0.04007725050273123, 0.08716394575464294, 0.9414802939215693, 0.8009574621241555, 0.7963358697792017, 0.7160410079299874, 1.1124424136801792, 0.9810807479903486, 1.2500921066028723},
    {0.7783639103621922, 1.1253151043090919, 0.9149108213283925, 1.138720302547854, 0.857528410375135, -0.36885498541950146, 1.087163387896983, 0.7521024863274283, 1.0812887748013453, 1.0398588680269025, 0.32353904579608667, 0.8826699362437659, 0.8726551151228666, 0.7051758579668987, 1.010989321619851, 0.750104953372748, 0.6200829871320722, 0.7558727245674971, 1.086984700884357, 0.8492980215292112, 0.9717092835581538, 1.138754692753947, 1.037079229870856, -0.22661792117325838, 0.013811081077359464, 0.6750099612772005, 0.4222228946462519, 0.684966474512361, 0.9117620245661494, 0.5791933291797353, 1.1563914665292603, 0.9548893736875893},
    {0.6303721043176915, 0.8555602396417012, 0.8910249363823254, 0.996340089468367, 0.7928502617923489, -0.02833231127865565, 1.2107169958440396, 0.7655257813258373, 1.2075347956571858, 1.2587705856558127, -0.12436836983615379, 0.9090963571337441, 0.7750368158823139, 0.8402728923342331, 0.6743017562764805, 0.8279843655697359, 0.6606764634052744, 1.193470514755151, 0.9286119642644769, 0.5576505385946665, 1.0667773793917725, 1.2737738009110002, 1.1195110137002617, -0.014773836778120799, -0.0208069247854735, 0.4600368015805339, 1.0229731601276957, 0.9827865928437717, 1.1518911288486735, 1.1241065050608754, 1.1470265835676883, 0.7463614694491189},
    {0.6845597150999809, 0.9240148162298684, 1.2440305665545515, 0.7403659799811905, 1.0006670456841515, -0.27876885557737047, 0.9056134382124881, 0.6145834945323657, 1.059881712113967, 0.9399869085308845, 0.049704423786147964, 0.8501576301708574, 1.015744934739696, 0.9190211124043476, 0.9184071657559656, 0.9987592559631271, 0.7627662095723408, 0.9666488067621525, 0.7673065520747564, 0.628496691080244, 0.9133789459565309, 1.0456036673671896, 0.9472937374519298, -0.2044951832790341, 0.005194080929831354, 0.41520734543203636, 0.8957608573211725, 0.8348211886744442, 1.0045890134065794, 0.8975955147947655, 0.726924897769862, 0.9321397407168751},
    {0.873545632161635, 0.7970890562021864, 1.084620455410641, 1.1161057235521088, 0.6562777321820785, -0.13456006881131755, 0.6975002128157353, 0.5452216799135436, 0.7719937808442341, 1.1146072812442045, -0.06001841976426455, 0.7523201575366114, 0.7761875855738722, 0.9476859599446258, 0.9747803722390651, 0.6751899528498865, 0.051149810379628624, 0.855979539851885, 0.9729928514391699, 0.8627171727442176, 0.8958150494315019, 0.7267123033693469, 1.070139050582163, 0.009659450060795204, 0.020736067725973285, 0.706446964426171, 0.9029838078985791, 0.8543647458960585, 0.6194319491103183, 0.7309227001016876, 0.7949110013665156, 0.8001552280033478},
    {0.9060446513307735, 1.2161554672920096, 0.9353373525497244, 0.9044393436040916, 0.8172835007375552, -0.14121904617638836, 1.1013611071469038, 0.7881206086200143, 1.1165850738714858, 0.6426375345260211, 0.000933113111616088, 0.9675344993424634, 1.3291766426924727, 1.089604812370742, 1.1640401988071734, 1.0447462632333415, 0.8673562725949512, 0.7361523876332982, 1.0696829104968502, 0.808145176095228, 1.3461728270404008, 1.0255775594361098, 0.9023154455856849, -0.16780768104749966, -0.0835650715455569, 0.9740261440723338, 0.8215298112918309, 0.8112201614063164, 0.7703814604492526, 0.9569579766811659, 1.300499355929394, 1.0151770188108713},
    {0.8393522258731955, 0.8500630972206762, 1.3361820175046502, 1.2186905748334924, 0.37647712033367453, 0.02562351382471733, 1.0805356560628427, 0.6169914403360777, 0.9382413327631268, 0.8642681564740776, -0.12911002591026732, 1.1729330341280004, 0.8293041996280247, 0.6514561444114524, 1.1777381688314947, 0.888949923379681, 0.6783986779740049, 1.0431063075890359, 1.1561528499453058, 0.890450156780261, 0.9413244662900355, 1.0586381451877687, 0.769094942090624, -0.11877698344058223, -0.039510027210919355, 0.5645927940387464, 0.7835499274580399, 0.9414109364110571, 0.94595803221126, 0.6261650678438997, 0.9564133075619513, 0.9258443999989493},
    {0.505179645210598, 1.1704323404969679, 0.9938399923884612, 0.9528476113315594, 0.8702623330164901, -0.15141116919345887, 1.0007499880195307, 0.6744955000050912, 0.6743069756061505, 1.2214116177174537, 0.07264085932166757, 1.2532747976786562, 1.3561107889091732, 0.7083636719963237, 1.2007375294364586, 1.066431336106432, 0.778916519742225, 0.9725251679341904, 1.042392685312855, 0.815330064655736, 0.9761667579882607, 0.7737278847573132, 1.2406219959330862, 0.17095074985270162, -0.03229168567425435, 0.5372025103110519, 0.7718678310636019, 0.703729536791641, 0.722345745439091, 0.6753488335164182, 0.8255079276281068, 1.1252364356778144},
    {0.9158736648347218, 1.1253251892465266, 1.224607550815295, 1.2602252369975036, 0.9074866415078661, -0.017348379592213997, 0.7772613588100599, 0.9449406246650128, 0.7431442856944416, 1.1755342997510765, -0.2798941057891096, 0.7140656762516224, 0.7673733807216636, 0.9210164725569465, 0.7305300344876203, 0.9402633193397418, 0.8904735213093115, 1.1369498626234962, 0.8873123410241016, 0.8622613681693307, 0.9553628772354809, 0.974240183525838, 0.8095660906692153, 0.0011044260502966455, 0.12018435885756418, 1.0693744707963289, 0.7134979401365236, 0.751083536739347, 0.9968574033619676, 0.8299678836006044, 1.0729735065443362, 1.1321680127046767},
    {0.6855941492626219, 1.20190448274459, 1.145975397929934, 1.0385186665817892, 0.777658840310605, -0.049945842622547205, 0.9367475458296258, 0.5264285460813746, 1.018431984248198, 1.2615544084278387, 0.055328680523782744, 1.017093872460332, 0.9473411298154538, 0.7791559563419479, 1.0834427310830432, 0.840957346974654, 0.8974248331733572, 1.0889846140024766, 1.4428385595653028, 1.1600517462474282, 1.251416708788242, 1.063694107610891, 1.2133558517627894, 0.009665065922638296, -0.05225591986300252, 0.5471974393525283, 1.0351558902389433, 0.43690898233404285, 0.7597217415777178, 0.9724707716903482, 0.9837958105138341, 1.0024658449700312},
    {0.8653643800850047, 1.0533584995297263, 1.1096781348274154, 1.4911923631270392, 1.1506976254933092, 0.05267034756616787, 0.866385784657796, 0.6198183115391827, 0.7368712984256454, 1.1740747745686886, 0.018439184261630336, 1.1948541129604813, 1.3281662256833715, 1.2933200078679656, 1.2725899480787448, 0.8402473110873597, 0.6671906218991093, 0.8474588383987957, 0.9560916652918182, 0.9257187963997948, 1.4716137415159691, 1.1885302484948332, 0.7377089648040833, 0.20654413714084058, -0.27200838984186415, 0.7980366318995578, 0.8958960317425326, 0.6416500677087964, 0.7794109597481189, 0.9654863696616697, 1.3213536512789217, 1.0131225414035516},
    {1.1182838377344193, 1.092360024098614, 0.9418651462626122, 1.0733684919608255, 1.0783528348516944, 0.1586951694751078, 1.0452885669189576, 0.6277869228942252, 1.0998193260374816, 1.0523762280083695, -0.2907074554448085, 0.9840316347071382, 1.0499497345394462, 0.7165655040217375, 0.7198133119358034, 1.0113222800276107, 0.507687336249897, 0.9804069562038265, 1.391453553744924, 0.7951726493201773, 1.0386910672590943, 0.882756871522653, 0.8392615264153019, 0.16369340930315796, 0.08348713103039081, 0.959342988324384, 0.7169439828060027, 0.7776125220244757, 1.1757916998652307, 0.6536428233434258, 1.0387471801997357, 0.9095660641694137},
    {1.089326846857855, 1.0977788524772163, 1.0700984658691373, 1.2291809258658952, 0.7137862098419796, -0.09859763019617032, 0.9633021769598403, 0.6951987118916679, 1.3996289362548546, 0.8214774975112152, -0.19501337880441091, 1.0998122014984717, 1.3695820138953918, 1.2154662497778101, 1.2610279353128615, 0.8126458425838958, 0.5240577252860155, 1.2270005412507867, 0.8808014152835747, 1.2449802461319701, 0.9438258680862581, 1.2323712072879187, 1.081856262135024, -0.09754588955055252, -0.00596158607032793, 0.7444348607007165, 1.205372094456423, 0.8431703043477148, 0.8789384317096895, 0.7034731567505632, 0.7307538347270303, 0.9051179754068495},
    {1.2632088659317287, 1.1558687912010444, 1.1960067417076832, 0.9824606742511975, 1.1512934373755148, 0.1034421890754614, 0.9836653643901881, 0.4297353437162094, 1.1537142865674757, 0.9913798745640559, -0.11235144958309642, 1.15240545390772, 1.1826823138802254, 0.7004929044230547, 0.6454008662903947, 0.7541331983051329, 0.7510668454792029, 1.0596943661249663, 0.8644011061628117, 0.18674955083547268, 0.9492165632967265, 1.3134744533600664, 0.6223617679658175, -0.13576838974707212, 0.06839113519891382, 0.5562214175104249, 0.66520585128278, 0.5842626541685126, 0.7241071648628206, 1.1506107639786027, 1.0091191428539528, 0.9144529967740394},
    {1.1295426476744437, 0.9073503160839815, 0.9653173361200291, 0.6334678387501104, 0.7020405378610921, 0.3652723814903552, 0.8218828597892054, 0.7277131486521626, 0.859986129105948, 0.8616395588715351, -0.32947569629580276, 1.126883852009314, 1.1348309597182547, 0.9359874108957951, 0.9937990542476703, 0.8906165782570576, 0.5541075190217416, 0.627575950484875, 1.0835985466670361, 1.1628868856099293, 1.1343219310246233, 0.8865645319554062, 1.2317522898853843, -0.14965383801958532, 0.009010087952045522, 0.8530850562075547, 0.6233546442107439, 1.0847929390147153, 1.3505295605031387, 0.888060629027994, 0.8320206237267501, 1.0317594294425312},
    {0.9749265613186553, 1.1051209666777515, 1.2152710270327527, 1.0899560844522376, 0.8449054621412138, 0.11585765938489583, 0.582251999291114, 0.8170546048696343, 0.8917935836153669, 0.8105775302627225, -0.12256038210938007, 0.7946500869765976, 1.1283737871336013, 1.0111614727663583, 0.6935384414043874, 0.9284099504885055, 0.5213295362495526, 0.8548582345797634, 1.0051844760117954, 1.0095449364928386, 1.1385246998559286, 1.2169240037831182, 0.9415292326676484, -0.03450878544878228, 0.022458567343291134, 0.6952527193640368, 0.7914411033476554, 0.8069856564791672, 0.7654321432230045, 0.6990586645267439, 0.9372904198236396, 1.020497049814276},
    {0.9710695983797335, 1.1547450718943406, 1.1331686307794888, 1.185933251638535, 0.8189485287184565, -0.10057184820726169, 0.6712385418241891, 0.5423272250971279, 1.1033380071855727, 1.171941414944818, -0.045858123612632105, 1.0247866010351565, 1.1421700375994328, 1.1745132550906345, 0.9619319007551548, 0.9613459425279292, 0.6558344684111799, 0.7166812902736465, 0.7745818921797757, 0.8631816364731499, 0.9167457753978789, 0.8904668462149957, 1.1636275756927765, -0.1226748648003987, -0.1582990211698424, 1.1620653264659297, 1.0102782166095583, 0.6501652297490029, 0.9557466762340532, 0.5982106441627842, 0.7884942618313928, 1.3286856461111838},
    {0.8972515038114579, 0.7871580590185207, 0.7883732485111277, 1.2900667331200426, 0.6023636361643594, -0.01526848058552349, 0.5935402950494867, 1.1856533764863404, 1.126737626741375, 1.0613473127392379, 0.18087439204036418, 1.0454701123927694, 0.9349657784093002, 1.0830656829673904, 0.6251894679189971, 0.9309177883785497, 0.9049320629638578, 0.9136718907761994, 1.268170191877371, 1.2072600044060915, 0.9014579261914026, 0.9763510853544345, 1.1020938739578836, -0.2617276787553786, -0.17828372349794827, 0.7240838288521886, 0.8793602461805838, 0.9300410970923976, 1.1172609523080261, 0.9454560316201299, 0.8859650923588289, 1.2133018968073934},
    {0.7030218182370193, 1.3854857960455416, 1.3375098188871242, 1.0216041537787894, 0.7256006966797884, -0.0736094819762899, 0.8734568444259089, 0.7150800578985154, 0.5539609396834069, 0.917027518872681, -0.06677690518125476, 0.9728540249901029, 1.298379077938956, 0.7895163332615284, 1.1140565206633082, 1.1980478596807707, 0.9311419491147572, 0.9540047902755773, 1.2298767700479694, 1.031352106593423, 0.9724086691090488, 1.0100810896052632, 0.9710726504485054, 0.026064177136125584, -0.07124952533739641, 0.5140874260571027, 0.7741102472236671, 0.9036510089477848, 0.830317525140015, 0.700551190394148, 1.0014977700549859, 0.6394416986549444},
    {0.759228979321913, 1.1800489500799671, 1.0643501147862817, 0.8142181416058052, 0.8552813569706896, -0.36289727434057795, 0.957048978296069, 0.7863133657114006, 0.7972217309588285, 0.9431213434008744, 0.14976985270541907, 1.2696774177690748, 1.2709784677770504, 0.6677072154314992, 1.008757796701659, 0.5043220274440582, 0.5277193923709449, 0.5746422211004915, 1.0645713755590471, 1.055314507704827, 1.0324956815527038, 0.9666557939050253, 1.1558688270705773, 0.019414465717954472, -0.05586300842072989, 0.7677878741533565, 0.7164069078257946, 0.8046319691673768, 0.7519722214919491, 1.2353631442679753, 0.7803171854854851, 0.8490039739078117},
    {0.9968459184007549, 1.2917674429016726, 1.176635809375924, 1.1159769446552636, 1.07277598655602, -0.19915378301982006, 0.9976318588613964, 0.7354879600482351, 0.9969791425517126, 0.8246843397063248, -0.42475205891310325, 0.9561177414364173, 1.250213381510177, 1.1695969343170662, 1.1937170900779162, 0.7879788235626682, 0.767533796583807, 0.9412274344140931, 1.1080611550548005, 0.9716586781701025, 0.950550227171695, 1.180841688200594, 0.9435096799356985, 0.0513976014581401, -0.3262207318784015, 0.7600224477125356, 1.2480619260339374, 0.7310472716897851, 1.0457914929329135, 0.986551367574542, 0.8967242585460854, 1.3025696646348002},
    {1.056035209970099, 0.8473329682527442, 1.1170466456406263, 1.1729786726729745, 0.5380272445685225, -0.2913357436872905, 1.0977242626573025, 0.8727798528273624, 0.9212013931252483, 0.9656631405831632, -0.19539979637143365, 1.0388666562930855, 0.9317676426177509, 0.9584422394771195, 1.0582724431882158, 0.8028616332461784, 0.8432542237871679, 0.683862217712232, 1.1623107154581742, 1.0347520382436919, 1.1059870688621778, 1.1003059843087564, 0.914699259132985, -0.08817823268051811, 0.1505547212571366, 0.754333059034198, 1.0751612645800417, 0.6909808472086175, 0.49781750613702525, 0.9664233822094336, 0.8420453905151994, 0.9619251049452792},
    {0.819370798513724, 1.0446359593884953, 1.0366919029443713, 1.0003455676810757, 1.0734466670328022, -0.0007545164509659159, 0.6995348149775457, 0.7031385181781966, 0.7895984279235507, 0.8384288602568379, -0.3584689509110975, 0.867284480521192, 1.093912932911807, 1.067927653240316, 0.8687741107347924, 1.0738498390482532, 0.5426450045740884, 1.0967912015762527, 0.9049047760838657, 1.069208249898473, 0.779369337040255, 1.0194541564602146, 0.6414605550020758, 0.15688431872475905, -0.2720468835279155, 0.7074358138809815, 0.9020931795802275, 1.2568766278751171, 1.130510094451277, 0.7471240632406413, 0.9927549041738654, 1.182083164043717},
    {0.8543245668762208, 0.8425225665611981, 0.8113157047010904, 1.1688953485821176, 0.6302860614125828, -0.10680457971278384, 0.9936062679888389, 0.7167664501956724, 1.0847609435075904, 1.025131607220133, 0.14890090031386513, 1.0044541848934347, 0.8718724295984169, 1.0466822838906649, 0.9011036294796368, 0.6703381047440161, 0.7087709217339038, 1.3712962297240368, 1.2349445190745412, 0.5449543382282841, 1.1754717234569616, 1.1513893562017832, 0.838253785893264, 0.2577974208612015, -0.009895573033761844, 0.9348272825246924, 0.9346613668939231, 0.8306192967703582, 1.1341459653578743, 0.9370075481914679, 0.8453364588830286, 0.6734392418445602},
    {0.9907523999601408, 0.9428718325656177, 1.0317021748036406, 1.0210915745895572, 0.9326230992732498, -0.2198427289986912, 0.7566437527638477, 0.40490880974807936, 1.1075449126531118, 1.203336351547551, -0.09378646937687107, 1.1415935023391084, 1.0462377403143088, 0.7860816773082056, 1.022963231063684, 0.9912622118351853, 0.939937949932119, 0.807717890032354, 0.8364100265679519, 0.8139218227391322, 0.9227775855742453, 0.8690337570483732, 0.9307561381573427, -0.0684463087530469, 0.28483684339447635, 0.7257560668269496, 1.188199343357118, 0.9414179751574094, 0.9410325541492328, 0.8587717125400367, 0.7508616618649867, 1.220150417633226},
    {0.9311121866374518, 0.950059157818614, 0.9746189176465299, 1.43778500393172, 0.8824992204603416, -0.16561108695173324, 0.6533322134703019, 0.7063283261089305, 1.083866228015453, 1.1707882205542492, 0.030922713496091547, 1.072726815499724, 1.1029089861314056, 0.9272671585056462, 0.282186158744856, 0.9798540453748513, 0.8479604246563459, 0.8861672760597922, 1.3019780823697518, 0.6784217061276776, 1.293641973178526, 0.8809541005204473, 0.9405747169888662, -0.08867068145890193, -0.33482631428632864, 0.4463234444294682, 1.0672785711624364, 0.7732617045795281, 0.9415993633080081, 0.963216117108152, 1.1422975999691878, 1.1903285082236186},
    {0.74058833432407, 1.2742032320118226, 1.3717839930355797, 1.0032108093673948, 0.6985581271277574, 0.02324019022445933, 0.9543011129473532, 0.8259638391143572, 0.9034101421721429, 1.2171922914282605, 0.12825683220830048, 0.9436844870603686, 1.1490775402438669, 0.8796884316593246, 1.065103595512524, 1.0408109302110249, 0.8579802154604246, 0.8133716147336251, 0.995920493548704, 0.6497707692593222, 1.0594759589192309, 0.9770993502550882, 0.8246816692626725, -0.1753153194073311, 0.10655649134525332, 1.0295035270434738, 1.0543448442278145, 0.9501103617445101, 0.6821308081306034, 0.6196448701958706, 0.8214976261726539, 0.9335740328945111},
    {0.8433336283697517, 1.152074685236857, 0.7971444322254662, 1.189680606507249, 1.0257249501344297, -0.044265257317115336, 0.8225129613580671, 0.8993508611534322, 1.1100298880783006, 0.9544367523649173, -0.050664555363364144, 1.0499199235636076, 1.024139569971482, 1.2324719352167206, 1.1905305901444492, 1.2697148334234107, 0.6988141935559706, 1.0025107479489883, 1.0771180704117818, 0.657522747047441, 0.8842059304765478, 1.120761881715116, 0.9716250571026702, 0.11145752804705979, -0.2054026129895997, 0.365082214763992, 0.958424157449751, 0.932761669952415, 0.4886464792053808, 1.0934071583799148, 0.7706321090805245, 0.6903739153917382},
    {0.574925356910534, 0.9112425250662695, 1.0742712682818132, 0.8544256047485346, 0.7404816566188203, -0.09385591809965278, 1.1979656308136883, 0.5664169388159619, 0.8421319195237182, 0.9140590428749853, -0.12458125286717638, 1.0916693935881976, 1.2656221824524858, 0.9400152655813915, 1.1077041006380481, 0.8152651208052025, 0.6271414149651728, 1.195750213991433, 0.9265270272838658, 0.9677091859484842, 0.8318354258235144, 1.0776688526964178, 0.9618736566908055, -0.14059491447851874, 0.0977048608163208, 0.48335773366689255, 0.6047559643187773, 0.5471707018552828, 1.0941147810404297, 1.027150675070843, 1.0402615748786306, 1.202336258406723},
    {0.5585658734086254, 0.8866744575225486, 0.7678429392865731, 0.9330014966504849, 0.9295187680524531, -0.24016782227916728, 0.5412810994707171, 0.8073655989470936, 0.8054262847812428, 1.267443245369616, -0.20241251346259057, 0.9527910418839463, 1.4327743647258342, 1.140592452532672, 0.8602331498601442, 1.0927439831132713, 0.7408813347156827, 1.2613548109315618, 0.9961661128037816, 1.15337567638183, 0.924476199510343, 0.8988321182664389, 1.267711798683219, -0.18121206979201754, -0.1304386370289534, 0.7710486979490846, 0.637935952327339, 0.7963595340886982, 1.0954375520570905, 0.9686908101626954, 0.8994711138290732, 0.8793048913343574},
    {1.0822298259833736, 1.0923515074121428, 0.8800541635451625, 1.0222875493446977, 1.1236929396373911, 0.07257134165265292, 0.8135327338241751, 0.4422477801169645, 0.6629767953513258, 1.1618627143159574, -0.40416550289776837, 1.0259520717743387, 1.032546388410179, 0.9315919651551458, 0.9805112307316173, 0.8137975592755811, 0.8860060705613271, 0.7165058127257522, 1.0301669799450952, 0.9077628671029438, 1.0624283206933771, 1.0827333352057986, 0.8767629387117419, 0.13006344805081385, -0.23743588265678486, 0.45539622779198485, 0.6538622750737014, 0.8758197514455155, 1.0521090538807976, 1.0627003300528806, 0.9697565027316731, 1.0855853917470226},
    {1.0328529173221264, 1.206676197924994, 1.0116763807404685, 1.0163218663213218, 1.1239294369561468, -0.21967753536882473, 0.5756257874950631, 0.7127197107992268, 0.9426837884119171, 0.8488734466756578, 0.06716949234689178, 0.8764017233835988, 0.8567576215285367, 0.9184668196961598, 1.1213419592209601, 1.125183996620064, 0.5295493831793328, 0.8278732070594188, 1.157585449340098, 0.6021421297673417, 0.9096995817078867, 1.2876132649777512, 0.9017679074520426, -0.02922015413757477, -0.20043626147627217, 0.7112348996603673, 0.8031689538689388, 0.97127101122001, 0.9256589750441601, 0.9114116099302877, 1.0800959096315326, 1.1581768505371688},
    {0.8212333166120803, 1.0142248093762023, 0.9884368356582175, 0.8983001492926481, 0.7084035609420082, 0.19146230749054166, 0.9027380997780746, 0.6647247922047846, 0.9544233099766528, 1.0284034691749713, -0.16289789456159756, 0.9060387885191266, 0.9634817286649484, 0.9100617292852459, 0.7439782267216064, 1.079674810274014, 0.5448448712527337, 1.1884297205129404, 0.9807753585322909, 0.8529498495856608, 0.7203345298482425, 1.0232777122093444, 0.8678480712381594, -0.1505497310423523, -0.010444715331104557, 0.776317961793512, 1.0189755143742396, 0.9053450073664007, 0.7781218798407766, 0.6169161009858971, 0.8672051788724408, 0.6939446294807436},
    {0.7321196190830944, 1.2984113263262194, 0.8801288329033095, 1.1235568260552042, 0.9917530917723377, -0.30405730738797154, 0.6830775107675756, 0.6124099020621884, 1.105768563320507, 1.3488378850233922, 0.09807497245804761, 0.8207173274327385, 1.0838661235417049, 0.7448570798556993, 0.633450964548701, 0.9022786958497755, 0.667606741240539, 1.0563624050751617, 1.0917110218485042, 0.6245758416924794, 0.9584132836358761, 1.0976138837849208, 0.9578609837331713, 0.07640481881061391, -0.07484850808165235, 0.5515499125196124, 1.001712915338703, 0.6873556303586855, 1.1944759645749283, 0.7663122322606675, 0.8270186088044796, 1.0577068643899976},
    {0.9196439339087493, 1.1319132592733214, 0.6186345240329609, 1.0890351805798906, 0.8206483440485907, 0.057049857571159344, 1.0224644910742737, 0.8225502752484927, 1.3578957110528882, 1.0983306472018717, 0.1577225298720906, 0.6636010002367557, 1.0069822704239852, 0.9569982384565767, 1.3535160554572525, 0.6898036284365009, 0.5988283889328733, 1.1319110990920132, 1.1708262186666265, 0.8285282193946821, 1.1694509904409753, 0.9123682247868744, 0.7912199592625029, -0.07995248740901524, 0.007158712783965523, 0.6347814229878406, 0.9694109117296219, 0.9812569345970729, 0.87984444750524, 0.8632162914469348, 1.029100247771502, 1.1677632611129218},
    {1.2326270110195496, 1.166119795588354, 1.0647199841439328, 1.328077086849776, 0.6039345354174634, -0.12087435790555821, 1.0218251822610114, 0.718802848124936, 0.8867636400562153, 1.3446919410725087, 0.11058548579127217, 1.111727527363982, 0.5429416746394737, 1.2190538766131103, 1.0336744482656595, 0.7776542636966878, 0.6039462662648584, 1.3810083717107007, 1.1187637583505883, 0.7686774033724462, 0.8753922751733624, 1.038523041315872, 0.8320078466647776, -0.2535092302935759, 0.1575339320775571, 0.9559849941397328, 0.8732624519394698, 0.9009237154518952, 1.0408261250434407, 0.7637433027012697, 1.15371728016775, 1.2106243994014454},
    {0.8477980201178112, 0.9358966767490473, 0.9959510169823774, 0.7858683566827376, 1.035889033178829, -0.2913453230552057, 1.065730892502041, 0.514898650567572, 0.9039324926161412, 0.923994599882362, -0.4580624569138656, 1.050441888905296, 1.1305247338252342, 1.0948252888669832, 0.8738383908234907, 0.9396741852583628, 0.6576451044297245, 1.207833765539515, 1.020633201522538, 0.94921195342196, 0.8474905776077217, 0.867089446745377, 1.0375448688769013, -0.2692464308647178, 0.07331869598623678, 0.8782888974210823, 1.1828747069334251, 1.0200321891581614, 1.1389333485185549, 0.7707413383680186, 0.8797530812337587, 0.9601789698491601},
    {0.9238743617285106, 1.114364751836567, 0.5936879585625001, 1.1495700688571957, 0.8470080398383282, -0.03360071281945645, 1.0276711808823757, 0.7681593830923529, 0.798853705102013, 1.2692197241959766, -0.12757666297503178, 0.9682726040209356, 0.8683482613112891, 0.5739326219837689, 0.8324547571409946, 1.0238746408809003, 0.7476668408319899, 0.9137313562822243, 1.0015139286421946, 0.918588906849613, 0.8364849696939505, 0.9358074348571481, 0.8316500857572188, -0.14664646280048405, -0.19974461010479308, 0.5018387213576694, 0.9967491659004913, 0.857176406635219, 1.0084427358330568, 0.7472166174376418, 1.119941289919131, 0.9590563992655968},
    {1.0798942741118092, 0.8014786496417144, 0.9568525498285847, 1.097318090348606, 1.2002872486556082, -0.2064266901255316, 1.0128230465749584, 0.6055141398758824, 1.1428105743172348, 1.0046729475686196, -0.08205052288268085, 1.0135092163759487, 0.8829578232416329, 0.9626447840325407, 0.8218465379968055, 0.9001377083990664, 0.7747637848288339, 1.0631229212593616, 1.0892390144271922, 0.9996076738766584, 0.8323113416383344, 1.1356234506496947, 1.011022098776329, -0.11634107168101546, 0.15061264971608412, 0.8488324607302231, 0.6775105388216054, 1.0757701869777863, 1.0428737129928802, 0.5976065823138244, 0.9493999015266432, 0.6730029585276016},
    {1.1911785425586152, 0.6691952892776107, 0.828751654518235, 1.0570069091278176, 0.6814244701278525, 0.11942827407240603, 1.0657724155130286, 0.6013899221185918, 1.2265092906438455, 0.8148008386794829, 0.11612268599936217, 1.0246236298352702, 1.0994465304436567, 1.246067813898425, 1.1653745528063695, 0.7141405957758572, 0.6268650371229599, 1.066478669361933, 0.9061164272145846, 1.267029075137147, 1.0408096879611877, 1.1535329880286211, 1.1085008156090623, -0.19108499785645905, -0.253368794494018, 0.7731183769311116, 1.0031952818605814, 0.7977486173024438, 0.9913411761680508, 0.7485425233224536, 0.9141660542212767, 1.3144451928277996},
    {0.8225646474256955, 1.0332557509882847, 1.0105993580188146, 0.958389128046514, 0.5082512595450422, 0.36938057100750776, 0.9422703690132472, 0.39868857868043106, 1.2821940806838166, 0.9633920516607084, 0.015347037596477198, 0.6890509002952507, 0.9436423263425577, 0.8064989108248235, 0.8558553904239476, 1.0156516614562277, 0.4743984704408063, 0.8063283392423334, 0.9274835087494868, 0.8483908028642563, 0.9592773925026354, 0.6798658556732435, 0.9145012537186351, -0.2528726141752997, -0.21822670983801304, 0.6555412837001013, 1.0626806847071102, 1.0137099856817375, 0.6423721277893332, 0.6267283247804081, 1.1685920689341365, 0.7455289359442487},
    {0.7490439096998925, 0.9256912391340276, 1.3893670227884987, 0.9492779712364036, 0.7721233559894118, 0.13378535030993505, 1.045528502192012, 0.5485682298600837, 0.7230691237390727, 1.1579629272400613, 0.009552440418376017, 0.9272102244495842, 1.0890060200500375, 0.9375578295925148, 1.1488645234579662, 0.8751290196076078, 0.6335774112550989, 0.8687348989351806, 1.2492144203611022, 0.6703912939203993, 0.8407203060620391, 1.0917021750225515, 0.9549693766178333, 0.10229316279924923, -0.25550074725755634, 0.4826886532489973, 1.0149804012680184, 0.7930651601594685, 0.6268577307529222, 0.7323347883803801, 0.9172837970566017, 1.0068453558744452},
    {0.9887202023884488, 0.9806950375611839, 0.8773470851728247, 1.18878279594806, 0.7731310640727369, 0.3419454649429306, 0.809136647894325, 0.44160016281137204, 0.8044940551505207, 0.860921063378373, 0.3107312777133046, 0.9465634362731901, 0.7786176289256042, 1.072727944311876, 0.9318402200316138, 0.877877691101252, 0.9202080966844801, 0.4906493474366998, 1.0018321155119543, 1.0605760964916688, 1.2398124469002372, 0.9032204586863039, 1.2093617019816976, -0.013217250421351906, -0.34494413704980587, 0.7840200059977384, 0.9260228007936919, 1.0367608057821471, 0.8028057564892225, 0.5468838616334851, 0.5913466132286547, 0.9702175575433281},
    {1.1482346028172559, 0.7845920303640103, 1.0914124735942248, 0.9768613510596708, 0.936683816815843, -0.24988016298968588, 1.0608575996099103, 0.9019363929073823, 0.6288800549673413, 0.9431171427862047, 0.2463107282012373, 0.8531547487737453, 1.2536020273067972, 0.6244981854874135, 1.082245631267622, 0.9773264846144712, 0.792622016238283, 0.748006281038364, 0.8958217190644124, 0.8918366028629525, 0.9194119106909272, 1.0566850161585806, 1.0934811807009017, 0.20270939666889148, -0.16222054740231323, 0.8569416274975572, 0.7170366696964747, 0.9109651540554151, 1.0301088780748124, 0.7100669037310381, 1.081584577430348, 1.0535730933410685},
    {0.9814638387513459, 0.919171901835228, 1.1482531975169472, 1.0072261885080263, 1.0164955766725927, -0.18284926955074932, 1.0227187816292422, 0.6857789356482854, 0.910800332690532, 0.7802284730286472, -0.21643170736328587, 1.1534936233696633, 0.8129518568540516, 0.9163152119566113, 0.7309208967256375, 0.6202664258138062, 0.6807631239527049, 1.2169217914978123, 1.332988522687174, 1.0965037295071771, 0.951067597502528, 1.0092078540944627, 0.8951672334805818, -0.18802782183949704, -0.006537390377923721, 0.5497017737889816, 0.802055231293637, 0.8559242987757765, 1.09241583724652, 0.7544767393615256, 1.0511668715032787, 0.8253989753157237}
};

static const float b2[32] = {0.8876175891120114, 0.948387525124103, 0.8531387880847249, 0.9620091962696443, 0.8070478897175992, -0.05466522774680443, 0.8672552655916461, 0.5943473659230788, 0.9410813082372881, 0.9425477977236942, -0.09267699077797792, 0.9456494980060702, 0.9701516857854494, 0.844997333960303, 0.9579842406338945, 0.864060768097593, 0.6586872207411087, 0.8898847805831821, 0.9499730740999817, 0.8172888492417241, 0.9494986722062889, 0.9415824443454072, 0.9338453723501403, -0.07444893717146046, -0.0952531736087912, 0.7006980598127865, 0.8880394280649995, 0.854015462945974, 0.8687189728182476, 0.8461138333023662, 0.8626400454057895, 0.9546695710223309};

static const float w3[32][16] = {
    {1.4240287552838535, 0.9132512192230731, 0.47845962315547497, 1.3772949886574313, -0.08369726808450914, 0.21179767808666758, -0.0967585086056248, 0.8611546849882582, 0.9578262142450238, 0.6648450012782913, -0.2326478394605199, 0.7341155895912236, -0.4850609089792904, 1.3125100818788562, 1.1085026464351715, 0.8994772035605135},
    {1.4599152548973058, 1.0906727261009708, -0.04038715143382651, 0.8607214857327392, -0.3407150761081449, -0.2648449356736064, 0.3993955007582231, 1.4170815015431133, 1.3197280570962853, -0.0926513030172695, -0.06190462448076522, 1.1658694456750616, -0.052052188547514956, 1.3293231814456778, 1.276192427339449, 1.2968455477524494},
    {1.4069580708719127, 1.0054637634560744, -0.2556446910015766, 1.4514836695959783, 0.317026557852957, 0.040325633192440424, -0.02843160131254741, 1.1930793560157806, 1.008566503335713, 0.40286379472512557, 0.10519529038447022, 0.35858526051384515, -0.12550745599385163, 1.1773668389548553, 0.9160807517896503, 0.8243019394249471},
    {1.4280658139015123, 0.8813260692727852, 0.15033364453486436, 1.0150566796404215, -0.16782955362280147, 0.2037385853921482, -0.24241012681017257, 1.2504218311241109, 0.9988923166181392, 0.49727607352449715, -0.14139588459256616, 0.7515599943518447, -0.20980276702145811, 1.3330433806707653, 1.5371090510472079, 1.102775187776053},
    {1.348168944392132, 1.0135899867345115, 0.3593451898337586, 1.335773427220633, -0.04667191576822249, 0.028848981325122314, 0.07241086914395957, 1.0660322804035138, 0.6343365095974688, 0.6571106885171406, 0.15875574353216196, 1.140302622665933, 0.3472601137553099, 0.7372692892183191, 0.9300831068255305, 1.0888743035821156},
    {0.4299700470264896, -0.41266684203772547, 0.0072253605369947994, 0.1378429102765609, 0.23178385111063526, 0.07359927751071048, -0.030792103732506338, 0.25727847253346, -0.3498028351209678, 0.3616832187911627, -0.17746542580038324, 0.20120323569980017, 0.3442124534047354, -0.26000473171993566, -0.05751334963411466, -0.06556148529674384},
    {1.2273328962258458, 1.447142262090624, 0.1124233929127255, 0.680671406002552, 0.13568544514902983, -0.5238900108111397, -0.21742735043733022, 0.9166408325735156, 0.6056837793382744, 0.6927636093401566, -0.31241317640108746, 1.0459979826132988, -0.10690019249801665, 1.1976313742324762, 1.2246507758903498, 1.0320417406243825},
    {0.6798551333641772, 0.4170250965514036, 0.17040425046982516, 1.2064960320391132, 0.09362754634157551, -0.21934022245252566, -0.1150275672693675, 0.9487941611176819, 0.7499952478066574, 0.7708979481969036, 0.19382577935289808, 1.0593959469879153, -0.17446455125255003, 0.9343622143037161, 0.7153126156566968, 0.6296830061313216},
    {1.262416704366873, 1.1794295417935536, 0.09838010603596085, 1.2376970485562415, -0.1462287682667498, -0.3789177885427066, 0.34224455200393494, 0.5774711837667963, 1.3659269963693483, 0.46501240262849686, -0.44815238677489516, 0.676324883235927, -0.1992689348411216, 0.9146622373083743, 0.7770258909224949, 1.3937707482423396},
    {1.2627994172778803, 1.1396316752570692, -0.285653342681168, 1.0911469826915687, 0.11730125316709365, -0.008180779747756146, -0.3968788554965533, 1.1727485288549873, 0.75690167853715, 0.7110036621989374, -0.10575932949654678, 0.6717197126777249, -0.1460329655200834, 1.2500358264404128, 0.7817788498622251, 1.301419765501353},
    {-0.2367379419826001, 0.11236188819636359, -0.12945743671569426, 0.045291177965803744, 0.4077743319724265, -0.0722802090531028, 0.247834266253095, -0.12295975317884625, 0.16971834099631172, 0.03713448738643937, 0.005142659834414938, -0.26576741120444497, -0.2939141507352843, -0.19538392752650627, -0.03848804282021319, -0.2234451667147374},
    {1.73378856138303, 0.6776798385208427, -0.1753201973350569, 0.7652854484096617, -0.15334359968114428, 0.3667487904644571, -0.41611424769990485, 0.6990499982867635, 1.2952559039727813, 0.8298947787613791, -0.13353269077856225, 0.8541281054103462, -0.27100504230935313, 0.9634310152453247, 1.17237301532455, 1.057184667847942},
    {0.7813711921178316, 1.0649758879833273, 0.03362019621674419, 0.784424558349873, -0.12107528072262878, 0.13906500759121523, -0.002695975336548048, 0.9028182615863133, 1.211591836776204, 0.35987757495806, -0.2866899610319094, 0.6061825883611687, 0.13193291857578743, 0.8541135054615991, 1.1017555950007607, 1.2846141516130185},
    {1.095833266625118, 1.3742955094333966, -0.23711154440382776, 0.9926096131987034, 0.1690378913922217, -0.08844960157883892, 0.1770188067240883, 0.8241259229226018, 1.150138864089075, 0.8850919219946106, 0.16561299917275057, 0.82862967674768, 0.23051527000845817, 1.36256014526674, 1.5363871528172608, 1.1198850359221104},
    {1.0956407092883553, 1.4555400847729458, -0.32992642140980477, 1.0431758127919304, 0.14402336038715818, 0.14513118409236586, -0.27045011301186533, 1.0153066817940433, 0.718881800031756, 0.7513869216394965, -0.04896871314249363, 0.5533915351813407, 0.2950289263031971, 1.2543328027277685, 0.8564848881622332, 1.3326025385804754},
    {1.3858677095165461, 1.0284481511454582, -0.0455452350781232, 0.8415109670374188, 0.34686893516536893, -0.23719354300478063, -0.052268094434650095, 1.1809457233461598, 0.5174537975919723, 0.8785069591801737, 0.08598588824663568, 0.7445384937859754, 0.13321762307352475, 1.4926538770762083, 0.9501253512978637, 1.3723829679575659},
    {0.9424826237466064, 1.1838600652340552, 0.0948014861765099, 0.4989763338342586, 0.0845645043356222, 0.014478189663161176, -0.25433362755116456, 0.6905335774904372, 1.135491816602189, 1.303202107164, 0.03726129876671471, 0.9808990997657265, 0.5217613603604006, 0.38580417336906725, 1.0186056357555557, 0.9573551982600081},
    {1.1696668415638602, 0.7224431920234042, -0.05772060900142714, 1.047903382029281, -0.2461013085028925, -0.017006978143104486, -0.04774179813921544, 1.4823717566248351, 1.6429070422560637, 0.9625919230165586, 0.2044461342845338, 0.8305908826744863, -0.23439015584334194, 0.9499607341477365, 1.358680638795846, 0.8885940169069305},
    {1.323633408953357, 1.4709483443401197, 0.03772567781561856, 0.9544317540910274, -0.4867311253246976, -0.5115588659406335, -0.10543626397300511, 1.298458187145282, 1.0065320120608843, 0.6560048914598531, -0.2053305563702755, 0.4908007135908145, 0.10624015717736053, 1.3722319697563752, 1.011631926705815, 1.2465640741572455},
    {1.409043156894085, 1.112734136441563, 0.06410853374355648, 1.0099936677520969, 0.26555265798376254, -0.21406686630394642, -0.12990087922836047, 0.6445790403565311, 1.0169720833672207, 0.8875570342288654, -0.017673572887326617, 0.7648872535023854, -0.028871480887923084, 1.5219025428162214, 1.2184363967045848, 0.775434398225298},
    {1.6787918706809721, 1.0807349222466147, -0.10396930094246255, 1.3480038416759001, -0.12366168544620698, -0.05054743116253482, -0.06703064477998277, 0.894006948866849, 1.0051221659299656, 0.6897339615546508, -0.4777548600906196, 0.8059195911742539, -0.23673539760905668, 1.310736010189518, 0.9777884514430115, 1.1415628160585798},
    {0.8520790383552528, 1.429337065362363, -0.06272036308381425, 1.1967976629984023, -0.06154707757862251, -0.26646298816596165, 0.25166457606775594, 0.8996010053238118, 0.9794452673880554, 0.5949151532648859, -0.11181310265541777, 0.47797123748472337, 0.09469072132353927, 1.0412893068037046, 1.0868028253662911, 1.2167399036297013},
    {1.0127906664311312, 1.1462832798219378, 0.08346265624432885, 0.9878877260489534, -0.25946864981088796, -0.2735404825872539, 0.14682604533259555, 1.8109349307243046, 0.9612924905686536, 0.7322459677711589, -0.5075025519687979, 0.28910123377827984, 0.1536584651179049, 1.0179498666045217, 1.1579734366443533, 1.2804297937042797},
    {-0.781503805269449, 0.1629350908192225, 0.33031000754634615, 0.20538734094011019, -0.0952478289571753, -0.42995659347528564, -0.12922168928478167, 0.3420840408747451, 0.28269420815443275, -0.3022475923714744, 0.49596738899692794, 0.1109024974781733, 0.3552030742562751, 0.18285160279480273, -0.3692315492201876, -0.25502143735976496},
    {-0.38037361685600696, -0.035096630795793254, -0.14876258004934334, -0.2193283909455391, -0.3174492233900641, 0.1597569900440999, -0.04869360488394731, -0.043076001066086785, 0.14534257879594728, 0.27477655391063205, 0.29758057999185666, -0.28185722777511807, 0.18481128707502348, -0.057598564107053205, -0.17536933960368678, -0.1921776890437859},
    {0.6053116968953409, 0.874318988400225, 0.1743505967728147, 1.3132766321844063, -0.1852043176300941, -0.43078611965368807, 0.37220970751011284, 0.606902017570922, 1.1120693419229286, 0.992233299224597, 0.058824252218558824, 0.654594667360686, -0.04019417448272342, 0.8858124304279963, 1.1895907293922452, 0.6909560903584038},
    {1.3025101756557507, 0.5989775615496219, 0.16625706212206529, 0.7430268679818558, 0.2791917268742767, -0.1853081577626559, 0.12745533083944968, 1.2843395103605963, 1.4140995005626067, 0.8830068061280439, -0.01669515759994403, 0.7917719968683892, -0.5511854672565385, 0.9355774064696989, 1.1780235466550906, 1.087091501028623},
    {1.3882336547388885, 0.9274637726904468, 0.010126437191252004, 1.0562309332799877, 0.04033269122966586, -0.20662078993792568, -0.08525782860429387, 1.066496403265248, 1.0447521770647514, 0.6629117915387023, -0.18029093102527263, 0.7600728168168325, -0.11640692463304927, 0.564212770160511, 1.0173597880361742, 1.007870224007483},
    {1.3286057005280463, 1.182299841631403, -0.029133442763912373, 0.8480617011695492, 0.12801177404532887, -0.027607919915459914, -0.19686398930266294, 1.2489257525658761, 1.1605338415085753, 0.6317918055368137, -0.08351276750874398, 0.866009331634831, 0.38426953836655087, 1.0342025795262444, 1.0934157728699254, 1.0606948575336195},
    {1.1150909043193318, 0.712261224553338, -0.4373113276608151, 1.2276014772756896, -0.031642333996885985, 0.10154240460210515, 0.5147719231587825, 1.0654482859808359, 0.8903859585376036, 0.8530480133633375, 0.1047828804204639, 0.8021848247760276, -0.4410746738575116, 1.348334767116979, 0.7736514747873745, 0.8930830536742164},
    {0.9558751554981568, 1.0034168164415904, 0.06499002067418087, 1.1883021521959976, 0.23657885243133295, 0.15419717008603923, -0.14875332234711738, 1.3711982135936667, 0.7285396713034491, 0.5752740136491723, -0.07724366236901524, 0.38296579728174496, 0.025699430582328882, 1.0710684531817727, 1.0299658499063336, 1.11999153082884},
    {1.1553925267263285, 1.171398926279018, -0.2602128357644251, 1.1647495395580039, 0.042085505447264714, 0.16388189001235862, -0.43692426227186554, 1.067521538382164, 0.7847208050859864, 0.7385199629567963, -0.27695413436529226, 0.9184622380396754, -0.42376379645723755, 1.5838286884682333, 1.2231211804065607, 1.1340387615098708}
};

static const float b3[16] = {0.7344814719258725, 0.6827009108608922, -0.04666581943617504, 0.6749432923634688, -0.04804110200026951, 0.011268707620298623, -0.053096856792892624, 0.6140129534951391, 0.6675641012002708, 0.40350214984321453, -0.03769599825464155, 0.3889227426390391, -0.031520568357523426, 0.7014058959979909, 0.7840789022172547, 0.6372882423225822};

static const float w4[16][12] = {
    {-0.9847586493869651, -1.0969171164994551, -0.6877767715768598, -0.7600654290095319, -0.9096761741165644, -0.8550572749388043, -0.9603719115276604, -1.3413512377356638, -1.2290763292704185, -0.9869703756764939, -0.4930472552527303, -0.4998455252501514},
    {-0.8043410335853854, -0.635916390137667, -0.5516223866549842, -0.8822025193652839, -1.3714786041609903, -1.2878333206201957, -1.1368323593730032, -0.6587550819844487, -1.2296010579691787, -0.3551264589701688, -0.7532795449631382, -1.0970045549174843},
    {-0.22957501998755236, -0.31396815207771867, -0.6758834737849784, 0.600022658560695, 0.5076617018234311, 0.20585791184363023, -0.7511632071044735, -0.21698314919041922, 0.327791953603826, -0.4014603385961281, 0.12048794360675726, -0.3335060712908632},
    {-0.7970775819496527, -1.4800518081194143, -0.8085281368363896, -1.2694970205463734, -0.5860843812901708, -0.6836034489643922, -0.5789687654689016, -0.7412856997756395, -0.3046031592669393, -0.9212979345718091, -0.9596536223361033, -0.5350603851466899},
    {0.28655621563703654, 0.02760529975910099, -0.19503284914853167, 0.31783119360692585, 0.0635280561356178, 0.07265247273596118, -0.09733005199872077, 0.2184667899177995, 0.06709235211824345, 0.5770203513645128, -0.45335176084867307, 0.44541082696955236},
    {-0.3799612388245922, 0.3220456805656389, -0.3684163924349232, -0.01715480125597774, 0.24904898863575886, -0.4939055966785355, -0.40910227653557063, -0.07431523339957825, 0.636072794554128, 0.5621637451205286, 0.008996631404981465, -0.33949177409730374},
    {-0.23774227341494814, 0.5902783666010142, 0.7188580107043303, -0.27691247476886827, 0.11146687869000754, 0.2296011478062684, -0.1687051686352947, 0.12840141329096613, -0.30513711570281277, 0.353997355102028, 0.17358904156421312, 0.00044769485405242985},
    {-0.8934755406197156, -1.0847120797512833, -1.3493166602727737, -0.3503624823744198, -1.6841790056061923, -1.2482070217191255, -0.8077862645625804, -1.123456001569249, -0.390603972971481, -0.45800516610627257, -0.3969829644559169, -0.8113637950639154},
    {-0.9378893626318643, -0.7941262290475959, -0.2596688982799608, -0.6860025437658885, -0.44108398476747124, -1.3292687269527415, -0.45817448333112615, -0.7546693280470768, -0.9490406668732135, -1.007291652138704, -0.8229871371531658, -0.6896665443193157},
    {-0.4766564445603417, -0.4622239735970031, -1.5283585642757958, -0.33560798635591965, -0.9498975448366543, -0.33873450355357665, -0.6760600577109378, -0.9645727899935299, -0.5150275606442338, -0.4247879773169725, -0.9915698999320053, -0.2508603705715332},
    {-0.2785921184109324, 0.22252998725623402, 0.3312803994780126, 0.33199235292506724, -0.07775619800786711, 0.08766442808984436, -0.250557856399142, 0.14700288847667572, 0.45995133038337777, -0.022556413385541336, 0.21196894640344394, -0.03609748401087265},
    {-0.8377375689479947, -0.3143057919958717, -0.23024961717963374, -0.9977750998595655, -0.5299827475210874, -0.14934593102451613, -0.17264639201989, -0.7993569397339334, -1.0045498792867085, -0.723044005222535, -0.71520406526002, -0.3865122676129602},
    {-0.3203135208406736, -0.0975790835272652, -0.2784711186982447, 0.21194680031649324, 1.026135065280946, 0.019354324921326275, -0.1298743446835155, -0.0576725746214395, -0.2896406918355199, 0.635145489070954, 0.7854392927826058, -0.35417738898944323},
    {-0.5936607013977183, -1.0414066967494373, -1.3642678623759246, -1.1633186400258528, -0.9961726699635511, -0.6618718465643005, -1.3250963984499602, -0.3067478595216654, -1.2332606077321677, -0.795232853227424, -0.9266453569786348, -1.3144342117006553},
    {-1.245954726653373, -0.341504054697812, -1.0955153760335408, -0.4728714986364611, -0.4894187726002297, -0.8552084397721422, -1.189595009726448, -0.9158075654720423, -0.8451034305396149, -1.1604931786822739, -1.2477935932962925, -1.1759245682063706},
    {-0.7663867237689443, -0.9320834532990208, -0.6827010672911202, -1.4541206608125898, -0.5229369186080094, -0.7672441136322234, -0.906123308603932, -0.9414957324992321, -0.7086475196869518, -1.473306684930316, -1.2792322343947424, -1.4342592292800262}
};

static const float b4[12] = {-0.24958073101777417, -0.32196407697945295, -0.44162999994607505, -0.3460953080390076, -0.31205020673659506, -0.2930515805708479, -0.3398732061384353, -0.3313590658223878, -0.3616453950025544, -0.294069336476976, -0.23217330959820054, -0.2770490418898038};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
