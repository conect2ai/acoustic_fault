#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5663438652011834, 0.0755055705631191, 0.7680999503872242, -0.6983733238300106, 1.3722824170675514, -0.43953572708746597, -0.939479815159785, -0.2562433990306446, 0.9313600917556158, 0.7257381409298288, -0.6252028646622773, -0.2146465650731285, 0.0704813199407367, -0.8266934919038484, -0.6246490687171994, 1.3682311177642554, -0.23827514148675968, -1.2558920697921938, -0.9947615679604604, -0.4075931088625441, -0.7922765754829239, -0.8174889942890794, -0.4611921376190085, 0.16187947056739713, 0.8515928100858907, -1.103552258230861, 1.1351181155288823, 0.35859112481527355, -0.22560413913728355, 1.0687513730917721, 0.6112056745148795, -0.3856808837899397, -0.11697326050302836, 0.4140398328968125, 0.028633197942602273, 0.7540326055869249, 0.1252875418500338, 0.223674625927982, -0.4540943499545219, -1.0427656442084368, -0.7764066138681388, -0.2999055436709161, 0.12936684833502632, -0.09580645836798367, -0.2405057533908379, 0.5511225492255797, 0.7616884332590855, -0.3166562784945774, 0.7219890859109147, 0.2291826920358603, 0.8105679036871335, 0.0990749648001841, -0.8362586394937852, -0.18748606720944153, -1.2031914907993206, 0.8246987895665657, 1.3034570112411303, 0.3579676587994192, 0.5666481947126562, 0.17595288829994327, 0.18521249630080275, -0.3237572610027682, 0.5950627524532874, -0.8103812284849201},
    {1.2021734099976593, 0.600573631264898, -0.7368757361649355, 0.11720561468548443, 0.36041967542774717, -0.31880698676788316, 0.3167892227957113, -0.8166942343617352, -0.09147196186781138, 0.8256525286274593, 1.0246543731378273, -0.7569066703346162, 0.8514600631345393, -1.4824242534079648, 0.37235134344488535, 1.2636392410616222, 0.5873741808592567, -0.9986029827533877, 0.28111929774520733, -0.7825537872227716, -0.3299758098027785, -1.2517094337764398, -0.5240132373648879, -0.7928452527938145, 0.01178455559126216, 0.2523495137541861, 1.0186400304210688, -1.0145447612792946, 0.8331936920807934, 1.2473268152014372, 1.1879072734050398, -0.8977159687224181, 0.3651112665921282, -0.2914780874791109, -1.4505812155695343, -0.5611445200553906, -0.756348195255823, -0.8154726329669852, 0.5646926391790579, -0.4218244597332502, 0.422046871050619, 0.8632889159850016, -0.37599007563443637, -0.4881912186466525, 0.3440995436884975, -0.9589998733726588, -0.22079492821407007, -1.1945109888825463, 0.9307125233668766, 0.8509334981241533, 1.095850319841882, -0.28683864787646746, 0.8184347309341204, -0.5881334289620602, -1.2287656574127197, 0.08528442989936601, 1.0506732416343285, 1.107954142794098, -0.6749085737232539, -0.9508750062920924, 1.3209163543712934, 0.5866091514688603, -0.418121677191848, 0.3327802423266134},
    {0.002806162675400205, -1.364851112115869, 0.021054718227950735, -0.6885548444865576, -0.1321937625066759, -0.3602698772503001, -0.24281700667826936, 0.9047465539490508, 0.5076714408318621, -0.01996799290285539, 0.8057710623114747, -0.4240172558482327, 0.2919992136299786, -1.1443115603188239, 0.42056877994240693, 0.3401578544784702, -0.04292146820982625, -0.2837021949764065, 0.5109422152139331, 0.9589030308116143, -0.3513287958653494, -1.0720859499500857, -0.8414343678964489, -0.9221886810138927, -0.09430687077022387, 0.600707746484961, -0.7014251312665967, 0.6226532061551688, 0.4069692817942264, 1.1329101778589081, 1.3059755584070794, 0.36272842065100475, 0.6226949864090969, -0.6479315555566817, -0.025105698614856557, -0.1993386984090872, -0.23446480485101096, 0.540401278633898, -1.4592806068409794, 0.02631142823744542, 0.06617567480062346, 0.8855664792306396, 0.2645717997118015, -1.093285811638069, 0.08845408070259028, -1.2757366340957217, 0.6406554216246545, -0.698825137355939, 0.19455298400568416, -0.4516811383793526, 0.9065133807093811, 0.1441513498407269, -0.5315234532475052, -0.43448151026892645, -0.3123676626444072, -1.1004251644353564, -0.6343112683928397, -0.16063732920681975, 1.5069218305020253, -1.0775927583754596, 0.34554509678965173, 0.6440582938386163, -0.9200477163451861, 0.7279107755472686},
    {0.32796438318406196, 0.2679331729895207, -1.2691344605574852, 0.991849009105162, 0.47643583635797854, -0.957838563699788, -1.105112093130855, 0.1471405343822693, 0.8301154449481124, 0.6722677883139483, 0.4255286049202627, 0.962933460003767, -1.100993133663008, -0.6508981451269645, 1.0234045774951919, 0.16004589038553574, -1.2029642421717022, -0.9346553615263857, 0.6332659886735613, 0.4861843188651235, -0.07706934017915444, -0.12902718315875386, 0.5132622946613484, -0.4283459520662752, 0.34160787632369166, 0.36321506466510467, -0.2627861984113544, -0.940410978227147, 0.26626593217760336, 0.12820268899414433, -0.4699450425978509, -0.29710301433171005, 0.6289558168695141, 0.020277295853267343, -0.12052633823051845, 0.8451407845938189, -1.3025820932177217, 0.43098215451110344, -0.5352025549483792, -0.9736190382521291, -0.37718802671092455, 0.9073147194946404, -0.43369143052636855, -1.1298746698560163, -0.33634506390221275, 0.39242912612701514, -0.03405270918181246, -0.24056017465897128, 0.24001563751748298, 0.8150250115568933, -0.15813214676147797, -0.5082657402643335, -0.37178346516492966, -1.2371938186319793, 0.011602409021607366, -1.591537623251675, 0.10834686646074189, 1.2107328169628855, 1.0517753475678218, -1.4429860944222002, -0.5440505713605028, 0.7285539852589993, 0.26611851161342515, -0.05789077988084633},
    {0.14750085043975508, -0.7895497545818777, -1.0034007793831505, -0.31772079103578094, 0.5456878364778018, -0.8106798795728567, 0.06205502055027606, 0.4833538592670067, 0.8821059662956108, 1.1630072337627853, -0.3958516785425436, 0.3947894300994318, -1.1631219754500572, -0.08125123014873058, 0.5215766829547042, 0.023637370975869248, -0.123120607989759, -0.22998869959340215, 0.15255250507978588, 0.23738037780206434, -0.32591785899141523, 0.009770759521826858, 1.0811823888259835, -0.3616211176772861, -0.21679188399541646, -0.3418212666572101, 0.4828928528302757, -0.9145733386574529, -1.4020943881579857, 1.0945401825581316, -0.00815980133313931, 1.1012696937856656, 0.4096596179027168, -0.7873106375658818, -0.9663307215523342, -0.33751283459889075, -1.2214554193390454, 0.09370076340550926, -0.3378480911967334, -0.1275820477388872, -0.5320822057988284, 0.36598968736207693, -1.20081641553509, 0.4030880213817565, -1.4387234966064606, -0.5910709015702797, 0.7647553147234397, -0.88791461645081, 0.06918591491821763, 0.6557094764012281, 1.1440533800592219, -0.31281134089111445, 0.20994366700069966, -0.8614276912730462, -0.23034765536379706, 0.31934476680924767, 0.5416671768359794, -0.45745064305716415, -0.14494613430675896, -0.6442247558953572, -0.3270657136442856, 1.427692282364712, 0.7104405220119216, -0.24770485609019322},
    {-0.5547977997398352, -0.7651319116735076, -0.8980050706511924, -0.13228747186535889, 0.32093703859712824, -0.5839912254187339, 0.48900603985046365, 0.6537938944519727, 0.1193847267346373, 0.08460280955744684, 0.9845282473456153, -1.035944052311916, -0.8185471257099707, -1.2854461808939, 0.30796510298927604, -0.0865277475066819, -0.6359121304003921, -0.7622533794945785, 0.6075405066557807, 0.6444221087335502, -0.13539895083782072, 0.0009264688502284852, 0.3547531558623397, 0.07624603678858534, -0.4517021757233812, -0.4086575005239671, -0.018952075412528416, -0.5585819206663454, -0.42660698758776017, 0.19666937513852858, -0.9823236710142382, 0.26564798772652426, -0.305986818112465, -0.6605134469732393, -1.283735287446619, 0.48190147374047076, -0.2656847091172272, 0.9213264922831127, -1.37603757656436, -0.2624606603759192, 0.5376522370928338, -0.6259196396181725, 0.41629830691157904, -0.04663996389411935, 0.046210130440786104, -0.38478199017887693, -0.07025708242312828, -0.7106186287454135, 0.2141368940626047, -0.45283326628333453, 0.4956163615949156, 0.9397396461369614, -0.6630796239656079, -0.6524269751121862, -1.5642313488463955, -0.7371429090734335, 1.165948966754143, 0.14144081758447344, 0.24243638459550423, -0.7325958844501058, 0.6874322695011587, 1.0929750513405345, -0.6231217973851648, 0.4723395253372956},
    {-0.8112250408896702, -0.6910565843791281, -0.784520323274872, -0.5882700287281238, -0.5215038772434668, 0.12725422978718598, 0.19082166315915755, -0.5600087144222116, -0.19960095643492187, -0.3507859319417059, 0.6172373463926186, 0.3115800718055524, -0.9428559983808874, -0.046095827717401804, 0.5171121988617619, -0.08527311388640167, -0.46281094592041266, -1.1060764042820042, -0.3948580704846754, -0.8744946199839461, -0.56597719183786, -1.2989360196991613, 0.519971549119742, 0.028759022836034258, -1.047714980595226, 0.7864018791966687, -0.31358294943318893, 0.6786337053680831, -0.25973274233662264, -0.035273182851065496, -0.8478610846465007, -0.7426780082819627, -0.7286271601017412, -0.8854342469499776, 0.23351070673667465, -0.27178825591442174, -1.86576890311982, 0.8837211864676284, -0.8838635821777476, 0.6256232844840082, -0.0012072308478362627, 0.7889882401443794, 0.5879763232099844, -0.5765231182277586, 0.4980147099941937, -0.18636653711520765, 0.13800278701790758, -1.0722566552675579, 0.828292607699201, -0.07826342185319479, 0.7984572603435018, -0.1046465230313607, 0.1519739728965957, -1.2924903937872967, -0.4552387023946913, -1.5744840556670474, 0.07180674856476735, -0.20604629905266464, 0.07103784543749073, -1.16587453216372, 0.7534177596742961, -0.3910932088185739, 0.6162846595760503, -0.4416367538068557},
    {0.4477602324343014, -1.3265640883403877, -0.9373496284057796, -0.35753230235712047, -0.22705245405299793, -0.4231340755152389, -0.47965373521992805, -0.7584688036118509, 0.28536861841024075, 0.17197456790845317, -0.5495213709116418, 0.7457235846601782, -0.3064555095145368, -1.151928623515963, -0.15247162654868446, -0.446873369741183, -1.3338785713425296, -0.8992838627219968, 0.3692935186596157, -0.2534451398550879, -0.7614003708660295, -0.30775300510494047, 0.7405724692516885, -1.4992795918531074, -0.29538149319178125, 0.5228045823667621, 0.8871323227463601, -1.2112368297288132, -0.129706968800663, 1.1126516057877807, -0.5323008634998231, -0.5837108519934842, 1.0103273252834764, -0.7783804649491612, -0.2646624999366152, 0.3687182218710255, -2.1141808936379967, 1.0412813247333768, -0.733611116801184, -0.012279329948381618, -0.010679847432200287, -1.0761299563216775, 0.5741443032209649, -0.6486592738123982, -0.9425538253343876, 0.4442778022221149, -0.5798334124089717, 0.46585793660875713, -0.7873222943326005, -0.7469199938858336, 0.3633388903433394, -1.0321682813747635, 0.4813619388282783, 0.26643446226195416, -0.7516740224404053, -0.27046874385612607, 0.2721400890098069, 0.5866033222810364, -0.7526711953267942, 0.21923695123409065, 0.052992695697883285, 1.27034287169797, 0.03132882652351958, 0.7211950305196962},
    {-0.5395430019852969, -1.7306729419206606, -1.7027272215647566, 0.027493073783113206, -0.02699146215554831, -1.2635228239300358, -0.9016403707069162, -0.6335974444042822, 0.9098927097041245, 1.360947181186576, -0.8637961214716695, 0.6131880756674636, 0.23756105625732976, 0.16289312352166224, 0.40432506892844877, 0.15625296217575357, 0.29324325804777335, -0.35014616726605513, 0.7216579964004172, 0.18156077152646696, 0.05027604117812876, -0.02180205471483617, 0.4243697182949364, -1.157285308085855, -0.7742352805041999, 0.4367365641561749, 0.9691585007223097, -0.572297539944101, -0.7772400132524488, 0.8953683532430569, -0.13098322068359838, -0.5072059104290266, 1.0720204410544782, -0.1169572387009072, -1.1829755704122973, 0.44943296137533756, -1.4742353128549657, 1.0851000560792539, -1.9669081159239536, 0.7476984156316014, -0.4086203217171651, 0.7132992706865732, 0.5778158753140037, -0.22658945112781095, 0.3279891180576779, -0.12862206951645683, 0.2655392383733378, 0.5613085404467508, -1.2316251571509822, 0.22435869777611722, 0.8374081084742121, 0.24522435764248418, -0.6974445652843424, -0.14508167549580836, -1.1668524389223458, -1.0693034425676304, -0.7460445739558628, -0.3737169300695221, 0.7051126563906808, -1.09694288186181, -0.14828497742756605, -0.5666238750783722, -0.119259901591055, -0.18375353209026696},
    {0.20464245920528665, -0.9392085661600124, -1.2188202313673426, 0.1992523514712541, -0.139532714503028, -0.49945810281274106, -0.8131684464885413, -0.44210988635606746, 0.6148405210048054, 0.29999465797127267, -0.638555180850783, 0.5851203537658947, -1.0822907695800583, -1.6062608117309716, 0.47610782929059314, 0.8116347773777528, -0.21189079740582029, 0.49416923669468105, 0.29468730930340936, 0.1229087543164952, 0.4760425820219942, -0.7735759238706954, 0.07638863743408816, -1.40616300800722, -1.7882374735864783, -1.1796849272915342, 0.6593072864732525, 0.5098829172153468, -1.092906834510559, 0.6262152743708156, 0.2034605133147593, -1.0020266009693488, -0.5593836823377023, -0.9530900274016518, -1.4508192763535517, 0.27318349189643704, -1.50063570870756, 0.38250932220702616, -0.4764664783372257, -0.3795274757004927, 0.1604536786427287, -0.1895599934470847, -1.180612608708534, -0.5565410335218968, -1.2271011989171297, -0.7650542654942812, 0.19647780977640003, -1.1615940826613762, 0.6239822176560677, 0.48643884590239544, -0.5402239754526948, 0.6193819603042304, -1.2392730902872233, -1.4418068089750955, -1.1093627350261188, -0.8860040369557427, -0.16204997161473267, 1.071408136616087, 0.928006948355464, -0.9267536470228309, -0.25030594289278746, 0.7217279150667378, 0.453861354742946, 0.391836527450161},
    {-1.0259762352291308, -1.6462758838300366, -0.6312208703860983, -0.23551426122903735, -0.826005559922656, -1.4670675012671304, 0.7619333635880502, -0.854467720443305, 0.5705041195622971, -0.4579514986233927, -0.5196572524035473, 0.9495715915116001, 0.15872658924634125, -0.8248779499688624, 0.8009853513178401, -0.21418962491652907, -1.1892681954250162, -0.41450450635925773, 0.00393972909496191, -0.2473626680854481, 0.22072117993530724, 0.23280714411881653, -0.4653796051297631, -0.9905982859823965, -0.56988352891978, -0.6645448479940363, 0.5449433003520144, -0.9923573200250232, -0.49710765163355175, 0.2291984991490407, 0.974924129090409, -0.09391452795188344, 0.6560854167576032, 0.30892512599421557, 0.24994814483274755, 0.9120776568016193, -1.686569858345184, -0.19308153888853444, -1.72131548925753, 0.552303195031332, -0.828683646116244, -0.8390937832889184, -1.1301146529370487, -0.08539110423443702, 0.07160157543927054, -1.2238470676360245, 0.3073454538548558, -0.32491874554154176, -0.8691593259094877, 0.09682942483843687, 0.6118820830615354, 0.8950015184168163, 0.13419130941017718, 0.04281297584275949, -1.2436750978557907, -0.31469065399637164, 0.7315962875930194, 0.8884110211467054, 0.31974660022195467, -1.0785590860230885, -0.10658590335780116, -0.46845622266947257, 0.9396355267805316, -0.12608068649622955},
    {-0.02440301223380411, -0.8565977424651479, -0.16905538664165554, -0.019241991704361926, -0.059072545034273685, -0.15222878157474135, 0.8458899209602204, 0.8915773300737176, 0.41438250688718486, 0.34322863732522507, -1.1282784413588027, 0.7427825098142665, -0.8437997415167788, -0.674411699926975, -0.4957110903421272, 0.3295976639166039, 0.12854811736920993, -1.2376379885472628, -1.1637878695486994, -0.9341526723203265, -1.0491284053387984, -0.08272792293626811, -0.32743948870889683, -0.8857721105175013, -1.659118386585187, -1.2981646682268686, -0.6805279567400686, 0.31273998298845884, -1.4044815202907137, 0.791695523361679, 1.2570314904868285, -0.12301740465826476, -0.15487803718438506, 0.4181503008427822, -1.5100534899934266, 0.01956849231853089, -1.3252849142467078, 0.4786928440210521, -0.0846210885145103, 0.3614900857295522, -0.3631467201928314, 0.2441690947543306, -1.2294159314232462, -1.2607747249984134, -0.5911049169126104, -0.9156076303348999, 0.3255260263895095, 0.3417778751993703, -1.236425029949134, 0.6679560474426751, 0.36002693213823356, 0.672941082833383, -1.065352712302257, -0.5855059358284492, 0.04517369278163132, 0.24978132366164998, 0.4750419940009607, 0.7116383543128899, 0.024834100372311922, -0.9943990426592668, -0.4844994298291941, -0.6364906194248799, -0.3562876443441485, -0.05388634651243699},
    {-0.5092882503845569, -0.6609238674846898, -1.7047055340003283, 1.086756175281681, -0.5984619506278155, 0.3228986184184321, -0.4286712535425499, 0.13583950318842936, 0.7412523365369132, 1.1320211406951777, -0.6314727716348053, 0.7085089419670836, -1.3141087006453644, -0.94084930789915, 0.7563958477196646, 0.8514422041558432, -0.896971309659193, -0.32987855194548515, -0.6419271180888428, 0.38514098897060633, 0.6250551264167912, -0.6151329386896776, 0.712014640676801, 0.3714834695232415, -1.6326381884644954, -1.1759562450945777, 1.1352559463296201, -0.6594850933671303, -0.5147613998183415, -0.2767478222357584, 1.1699812972473642, 0.08522950464678741, 1.2580776319039215, 0.272722680153517, -0.23662227707507005, -0.024737564934122613, -0.22854883385566807, 0.43493832467762916, -1.4527237684420296, -0.006063064499535482, -0.1231648622080955, -0.6855869970436756, -0.018588526367447445, -0.9006598044013431, -0.27415228998961333, -1.390350102034729, -0.2694852472353418, 0.6291762765542436, -1.2208990475064865, -0.9474117796614884, 0.5458745884360191, -0.885042219552699, 0.028054018197008125, 0.2808801383315856, -1.6377921674471152, -0.5108868737956026, -0.39287759526546884, 1.1516496464435435, -0.1514836065341127, -1.302552708016443, 0.5817252607534622, 0.010168347780681805, -0.733782778086011, -1.1527582811953188},
    {-0.2504721088343424, -1.4732061051219882, -1.4557805128200454, 0.05776130250020775, -0.5174277410478328, -1.346733335564116, 0.3951054406584525, -0.0023130836864964748, 1.0037550560372985, 0.5312755269231554, 0.09387847878964094, -0.6786842732447387, -0.16023961688408064, -1.6616996255054646, 0.8445015672362652, 0.13117209837488428, -1.1009114694505577, -0.3343529298086205, -0.566682783498981, -0.4036227043245593, 0.2573339705732911, 0.38096425621915253, 0.18215176512493245, -0.055977039571648936, -0.7958225037511324, -0.058662067384159126, 0.29637425041967086, -1.2169878051205916, -0.7036442621969542, 0.23846207775600978, 0.9032606697803491, -0.5301317993047147, 1.0065719694263153, 0.7831816086877021, -0.860955576037269, -0.1596693558881695, -1.9433849159931529, 0.05855478398493204, -1.8509651091353254, 0.7115572220482077, -0.21258362712774345, 0.7142063113607349, -1.3732171817386039, -0.3969176060864513, -0.3971153498762264, -0.041511922587080086, -0.0781768877710634, 0.5266317312641385, 0.37575606394151895, -0.43282629905740583, -0.13794548861750305, 0.593063063025202, 0.31338398180832566, -1.2919397611885135, -1.32549197646627, -0.6980076982692064, 0.3577170507755184, 0.6921006878766038, 0.6203330860991831, -0.21877108377678303, -0.8041066806459899, 0.4607804128017629, -0.3651167570715612, -0.9092464719029091},
    {0.47325739939523986, -1.7821093300287874, -0.1869478647202211, -0.4252486782973079, -0.2599333368134182, -1.6501518159207462, -0.4665679510166366, 0.8614871392161173, -0.03795411928133355, -0.5077910930242898, 0.598091790875948, -0.15707509957921867, 0.09517701604414165, -1.1935109042615049, -0.5197675039540569, -0.09322440707211001, -0.17471544000845468, -1.3865832313253552, -0.7179467099845384, 0.21665811153486803, 0.20672114173515999, -0.7572825770773686, 0.3159779430493399, -0.7863811227798018, -1.4793588685912906, 0.401132927625132, -0.7058538797795274, -1.0204584096502662, -1.4215468869343526, 0.6392673270338614, 1.020110058703198, 0.793821065757348, 0.5781423786333852, -0.43945806025975703, -1.2232919698128988, -0.96319901631299, -1.5617327279599622, 0.5969888385880286, -0.8440710553323206, -0.9708819979504395, -0.6666103672410097, -0.8830327869722963, -0.5781298978773425, 0.3416806117073722, -1.1653914332097592, -0.5545574274586845, 0.1878822218306978, -0.17004916956022514, -1.172605359438597, -0.7894189282163243, -0.4572305519867226, 0.638754369568638, -0.148531339338654, -0.10674983237519124, -0.9849277287094279, -0.6109343845247949, -0.1950583802639351, 0.498581992969831, -0.010150546704759188, -1.3661914546455494, -0.7661086738776913, -0.6571204013678177, 0.10655547123195848, -0.5235361868771953},
    {-1.047387581030217, -0.6444045953893793, -0.38613582903371807, -0.7669760123327923, 0.9916698967835388, -0.2947530040073028, -0.34201048163263215, -1.0107655229659502, -0.398094103352059, 1.0588983337298417, 0.5943273696787796, 0.2961054191043937, -1.3650129182122372, -0.3769694602960699, -0.44242388543674926, -0.6652997933831213, -0.21446615145948322, -0.5264290749493188, 0.6481063642525091, -0.049291490054679164, 0.6274621685661363, -1.0347814771304664, 0.22990981861850213, -0.4285741483724949, -1.9471431602131453, -0.06742577900546037, 0.003918711485148128, -0.8036721081790036, 0.18441689418002336, 0.34507173395054963, -0.5794251087861283, 0.8182549427957346, 1.1511069973271677, 0.14312882510823824, -1.147376841343081, 0.8511210617670006, -1.1822598522133712, 0.6116735820503063, -1.7152007640784397, -0.583907627791601, -0.9951653528454032, -0.7360297878465533, -1.2820458185141352, -1.0746115827054434, -0.7468158682138822, 0.15062991576984436, -0.5881722279028261, 0.542038438261585, -0.29661098454538676, 0.7674646115536999, 0.44182147579979525, -0.9272242842826794, -0.6598315110611985, -1.4577482624372973, -1.8266382478215173, -1.2793517071851268, 0.756699715490111, 0.10216951022763932, 0.023648142613523833, 0.14555829684333488, -0.4998094651627136, -0.18483109205726045, 0.7095549551438028, -0.5677014080308069},
    {-0.0933377805396327, -0.5113337218854624, 0.18069265594440376, -0.5037148517281411, 0.13473402015657154, -1.0750725090329873, 0.8768928060680258, 0.35004001230222004, -0.19366199720497018, -0.48549844450761753, -0.7434023165091064, 0.725308640453803, -0.558904738380842, -1.45614240788595, -0.5301804062977135, 1.2188206494343663, -1.5682644494745916, -0.9948885472988835, 0.6009382230983714, 0.5534311948999588, -1.224621822116915, -0.14152957727064933, -0.12215967082734751, -0.2813254059468647, -1.8733686964180074, -0.04083498184025208, 0.007220948622027904, -1.012400814578035, -0.4472584751422321, 0.6010150067922948, 0.18200410992454516, 0.2883856203312011, 1.0984391287537536, 0.48434918576564356, -0.59778652762176, 0.5566998636740945, -2.038704886157932, 0.2925705939658112, -1.16757808032449, -0.8318219666500386, 0.4136769251363993, 1.0975404975859366, 0.4298026393247411, -0.4857566777902841, -1.4053649523839182, -1.0582112082286166, 0.2770330300606712, -0.8056670000391859, -0.8677084327115886, 0.8929179726754615, 0.14664187626522993, -1.105054240072728, -0.6656538902153105, -0.7708801761732131, -1.446432494166809, -0.642561408882935, 0.8692417960587379, 1.2300375962654395, 1.22996403666158, -0.32162604584988963, 0.28536333200283037, 0.6414757187528187, 0.46451350933504276, -0.1156473427767458},
    {-0.03644695777253157, 0.19323008101593056, -1.1238641936861022, 0.5954550658323801, -0.1989468060279551, -0.2515792134136393, -0.40525110438065676, -0.5169916408342649, -0.07508560950623704, 1.3059580986466754, -0.2174986938981344, 0.5056951822919251, -0.11252166101349044, -0.726548960848214, 0.10167758127155391, 1.0333189868321269, -1.0133805875293578, -0.030918023152474605, 0.2972022922463982, 0.45433022335669837, -0.6451035419771816, -0.11147878250868666, -0.4688903721560233, -0.27588636168654307, -1.5554028847315693, -1.1652919299678552, 1.3129064932025907, -0.5057090118764594, 0.5290193452374841, 1.6562554974169224, 1.441318968601106, 1.2011130316135903, -0.1954573620458644, 0.8441713972001814, -0.419742182933189, -0.23768302972645985, -0.698384631423416, 0.5909871914606366, -1.709343889582705, 0.03453607959131969, -0.5459170846961956, 0.6517388959878311, 0.2018243981309297, -1.0724612965374385, -0.7202620221896975, -0.916531322931864, -0.8143081502233325, -0.8618892114280018, -0.1580770601107067, -0.49569896187821205, -0.7324472966376063, -0.5793891228688847, -1.3872574999191498, -0.8961592523296427, 0.3058220502436353, -1.2991901196403242, 0.2357674750539196, 1.370181420447138, 1.2458993301945582, -1.0093499082472361, 0.46089555828292655, 1.3920833123554457, -0.3671061825350612, 0.019581020295680946},
    {0.7353931515230618, -0.23699864123873665, -1.0404048450847256, 0.736087668632071, 0.9040716697426777, 0.35265948644290424, 0.5461460334421679, -0.42864392957308445, -0.5220623431931765, 1.18962775887971, 0.7196311954769516, -0.4321123924113739, -0.9230335546831759, -0.6987409804846513, 0.5917301433147709, 1.1269281062992058, -1.410387257306861, -1.3696788807073463, -0.3050707990633483, -0.669275466817462, 0.05612310282546232, -0.8520869179773832, -0.46543320660872134, -1.3606011483426206, -0.8405040302129082, 0.0042326918820077015, -0.6166000179128072, -0.5401827711204872, -1.26339819282371, 0.37108384321382143, -0.6111598885439762, 0.9234735849807423, 0.48525479567041085, -0.13314850345238374, -1.0549179839952374, -0.9249611288870565, -0.8466872661764029, 0.6363727073933609, -1.1948055986240005, -0.11556739994845296, 0.4025370731833062, 0.27878286658646706, -0.5503816365472908, -1.2087427485566904, -0.1418380512696128, -1.1103369616555372, 0.8044004144249373, -1.0476988811325354, 0.6882020302122481, -1.1806006658165271, 0.6032826639314903, -0.2769843893030586, -0.9081505051631876, -0.9194361963341189, -0.7188612312502332, -1.3966792050899732, 0.7696623710186518, 0.04433106374933115, 0.40637207858197066, -0.726496362107619, -0.1844856533954849, 1.230445056072591, 0.28511180024657373, -0.9149894119122401},
    {-0.7427634205146094, -1.4762568590518992, -0.09011968553929577, -0.5109961393483899, 0.2033618674253422, -1.0781593661409692, 0.262767125826703, 0.15720080687929283, 0.7813443433084296, 1.2543844008717893, 0.5556388422142998, 0.40765844976008636, -1.1008392313736506, -1.124741509328499, 0.5040868094852904, -0.4766980990217141, -0.9751820054016477, -0.20339147567356589, -1.0731233328815108, -0.2209694805296471, -1.180199290083585, -0.8778218516875657, 0.43532287553621746, -1.4980057418977513, -0.9455971656215009, 0.26570944239534644, 0.38410475137933076, -0.1497786501541956, -1.4924980885901165, 1.4537663807230286, -0.08072871175766566, 0.8277777878294076, 0.5123938586863838, 0.04297002852258997, 0.07270459444911401, -0.0009643351748708563, -1.355003249078631, 1.1678580971761352, -1.718978069051828, -1.0075681801805572, -0.7497844291460835, 0.771180329198921, -0.5335630449816233, -0.31035341333185534, -1.0662867119884214, -1.2964096048732954, -0.6416503021225644, -0.44964821698430585, 0.6253537643789618, 0.7251232503321998, -0.5153660799926653, 0.19008898620081757, -1.291992935332162, -0.9612222799238975, -0.44771909378729813, -0.5824499718947732, -0.706649584057762, 0.7002317311193983, 1.4461229808848182, -1.0822670508633963, 0.08603941852377103, 1.445422807921324, -0.3493654580393928, 0.35084109133428343},
    {0.10067536305813789, -1.1785738117272122, -0.824354912488192, -0.8516253873446984, 0.8758240402913966, -1.3105992032179616, 0.020200347819119502, 0.33813042883150984, -0.5628040687212091, 0.10007895918512431, 0.026756830889804312, 0.0669610908843337, -0.6502740819447275, -0.4495046457812533, 1.0593353559676584, -0.12713327401757127, -0.37215748111100483, -0.7627259610842004, -1.2653664650992755, -0.8102481975496991, 0.6465209356625073, -1.469107194762406, -0.7354618720593568, -1.2551179827585903, -1.716796712940044, -0.2009432072597825, -0.42330595183609215, -1.1345361494746158, -0.08185345135299342, 0.5574588744608244, 0.6541387882829404, -0.003060135804277477, -0.2828429762647944, 0.9582654267105826, -1.55240189354668, -0.15071613706484324, -1.5828318426500585, 0.6778465416188608, -1.489885853750057, 0.5944005190788367, -0.842370495804361, 0.1440934275245686, 0.6298552727389688, -1.3250114991522517, -0.3110212292368254, 0.40636066281143646, -0.6747789227372778, 0.7400930308679308, -0.593097255846219, 0.17705209447962209, -0.3959605803456456, 0.3106966531606636, -0.5060843809005262, -1.3870578470181993, -0.9658461048584207, -0.5537408396179897, 0.5078541049719387, 1.3711987226020717, 1.4459702781432824, -1.5788576586570655, -0.019547179371555336, 0.9675023093046926, 0.4362333812448845, -0.009766988247587812},
    {-0.24154711628340797, 0.038608287794934255, -0.6019024290987928, -0.1312597469274446, 0.5515403161543881, -1.41972613996015, 0.6081058609006922, 0.3108878119631353, 1.2986010568747428, 0.9532156657267156, 0.39834964338768375, -0.9078865128295472, 0.07593127017576096, -1.307021718912697, 0.030530588451272142, 1.2152790062737595, 0.4643559236839098, 0.39992014484608895, -0.05762924700027697, -0.9721550332349397, -0.34665260147024934, -0.3842078213347103, 0.4856299945426752, -0.056806396411970814, -0.5020218887785863, -0.7491755615763058, 1.0475740133016689, 0.5769564791686178, -1.1251179744802038, 1.4748904372581266, 1.4665603937108238, -0.21156386218655132, 1.5360526758381057, 0.42343173675416595, -1.6092765579739616, -0.3730248905022836, -1.310414208691921, 0.9538110415788887, -1.334560032173823, 0.3977601442152937, 0.8826497744320904, 0.5309505558930414, 0.6454305848013187, -0.17733083883506698, 0.25471207999839235, -0.3985970268209419, 0.25380800874870435, -0.7071435913364796, -0.9323098044776152, -0.41669110554396643, -0.4272039846221168, 0.27509387169456556, -0.25108778901475526, 0.3241416849344635, -0.4777119506015256, -1.286700819008209, -0.2790488112122976, 0.13402085679824308, 1.4494493616106106, -0.8017961042521758, 0.8937711429796177, 1.1485938335667198, -0.21255235840273487, -0.589228427000528},
    {0.2879398591541953, 0.13491865177634013, -1.0813200138334955, 0.9008668211206243, 0.6162644823771903, -0.8678239756752189, 0.06850212096505856, 0.04643602471550593, -0.6093789490317422, 1.1097603471957302, 0.5377000815449621, -0.15618169820122157, -0.743009623018418, -0.7750011535881708, -0.24446230516041914, 0.6195761600632242, -1.2052115307875013, -0.9455119663158563, 0.02403046089788873, 0.14768093006677402, -0.7219921994514216, -1.50641182578319, 0.871199307628186, -1.007072686547799, -0.03356911301972404, -0.6909887674309522, 1.11171308541223, -1.1481266598013762, 0.10899889699532775, 1.060105859993325, 0.6640668204027597, 0.9540189494670113, 0.20550438311991656, -0.6793469110968173, -1.3016243005257002, -0.6120107632125161, -1.3230603238106822, -0.3514262866393611, -0.013781711226983477, 0.4147891317318406, 0.06606106595842459, -0.07396795889672816, 0.3965150626929132, -0.7083562413358865, -1.203322466887084, -0.8659215763380969, 0.883061398875886, -0.6868189370821398, 0.21353108102667728, 0.48035220486201774, 0.5102122229839006, -0.27988532307375635, -0.05512301746294465, -0.5232383004011611, 0.23022309427229726, -0.8680288564628325, 0.8881295430918427, 1.2871183957750552, 1.6890664840894773, -0.8392706983038098, -0.9832751215668046, 0.019520092472777258, 0.1460122877157508, 0.8031939064567615},
    {0.44317360160985864, -0.059841564731041214, -1.396735152353548, 0.8364848980649353, 1.0438592730732328, -0.887265152093869, 0.791967040296883, -0.6327056248055482, 0.7776051095036911, -0.23851699660898062, 0.8422748890756222, 0.03860454602949172, -0.6016713308791014, 0.13908398001905276, -0.20234573351265966, 0.4663034274213396, -0.49651610147145875, -0.8902751680262933, -0.7434341034837025, -1.0782911026158304, -0.8955549232906358, -0.45437794641158313, 0.439475150204121, -1.025309665953457, -0.6787078800491637, -0.040981940877693, 1.1150360398173191, 0.562836312967271, 0.5094153558563259, 0.21184062914513704, 1.476931334459042, 0.40895612921380553, 0.028788716725415647, 0.1426782199379194, -1.509296712267104, 0.3272461815251973, -0.6118267490940111, 0.43681290565780906, -1.3222011315108768, 0.19796605953826066, -0.807565549540173, 0.5788406955467996, -0.48154739457366696, -0.06150695474160405, 0.00922897909582907, 0.7485790610021754, 0.4831931615053607, -0.4741434753876327, 0.20365027082988435, 0.18104553519782876, -0.7342065407064216, 0.9113215980208302, 0.24474844488731795, -0.6421109024862588, -0.4754510976154872, 0.3179199950188328, 0.2794133671063236, 0.41317808743562956, 1.5903430585196958, -1.187707339122728, -0.4262827483841705, -0.5139707460285492, -0.016240251012852373, -0.5574280753469343},
    {0.47481280443259233, -1.7102128403761598, -0.2368824473203501, 0.041602185651822395, -0.3337311702092847, -0.6539466803899999, 0.7057163163665265, -0.21663368829766866, -0.48037171759993263, -0.06578820117140446, -0.1478260852229965, -0.8504981026466871, 0.2995249675499894, -1.3885425901567836, 0.845656573452343, 0.8157786075632041, -0.35835643638070386, -0.18025123602350637, -1.1020046536109902, -0.3417112884570863, -0.3851508902546561, -0.9581197750620585, 0.691191800692002, -0.19536982965932925, -0.4752414273598277, -0.04909010500928673, 0.7614364527214295, -0.16688546036216811, 0.04453874064538693, 0.7938545873813713, 0.8866922851674398, 0.408414673416913, 1.3229283614016254, 0.5057468642757734, -0.1780309256861623, -0.31531193229067395, -0.5967534951606228, 0.8744026835181771, 0.18171156515423928, 0.7805980797687844, 0.6575110071608101, -0.20671898195244787, -0.3253325841202108, -0.9988278187805468, -0.05901941154638952, -0.5074117947793393, -0.02817435285172638, 0.6330083711423771, -0.1440327278668541, -0.8536716982280629, -0.22472758386971214, 0.8700351464502863, 0.14916501615042443, -0.8503101618772445, -0.5385991333494288, -0.7584905411846498, 0.6731730567638927, -0.19716093217742842, 1.268424410672565, 0.32019210042718993, -0.1551427244197184, -0.07321390249881829, 0.7660640497144097, -1.2423181591620998},
    {0.353022976347878, -0.08425193625628492, -1.3237861986543797, -0.5832601588200281, -0.3427296907380119, -1.105172683007861, 0.24391224949383142, 0.8191754497209573, 0.42367205981810857, 1.1670422074592284, 0.6583532560025228, -0.11036157296879662, -0.13651506069110653, 0.05231281070720794, -0.16645575340309252, 0.6673764238954895, -0.030208098277992694, 0.32834359248179645, -1.1773174133343514, 0.37789181117449605, 0.16486395960079764, -1.6296142020779272, 0.9110734834171901, -1.474137753056164, -0.06554928372740253, -1.417378060253343, 0.927380415755929, 0.15741409129041703, -0.7396552648178135, 1.150796363887982, 1.4866126695164033, -0.12654771750247817, 1.497450474619176, 0.06609575289876661, -0.49964594739754165, 0.008438442127799014, -0.922428675594524, 0.9321112829972688, -0.3168083733721032, -0.6736240305173254, 0.6341655560682419, -0.7752338426775209, -0.8438242052389666, -0.045117975900039985, -0.5001839011544691, -0.20410168989411398, 0.9112514579927505, 0.7579717581287211, -1.1934991882735346, 0.08479925302857522, -0.8779155784571362, -0.9572868963507575, 0.21999286510075605, -0.3469842675204425, -0.7766750827055784, -1.6314912143915945, 1.179176837675219, 0.2486042784279637, 0.9152371413362707, -0.8739107489931695, -0.4995891764591623, 1.3544507072313476, 0.5688321386973625, -0.5024407318047664},
    {-0.9030395988437643, -1.2146093986000084, -0.08986484763905124, -0.09474455081829271, 0.5637071968746841, 0.3315702796527029, -1.042263536489392, 0.6225070041917301, 0.8047777395863824, 0.864748560941349, 0.6121649641576117, -0.18541045388879204, -0.041985358992128116, 0.2710079306129939, -0.3398823610156121, -0.4342505767561721, -0.7207608611335192, 0.3128292353832403, 0.07137812574106824, 0.2659254488473145, -0.87859210027834, -0.8686957412412413, -0.9149343854665422, -1.254888560309594, -1.5593335547820735, 0.302148497616449, 0.5960036304509737, -0.3241836069655864, -0.655042720510684, 0.774715258202942, -0.015187306475260794, 0.762968390582795, 1.5889221893766237, 0.917485503276919, -1.44429277444525, -0.2893362237785202, -0.6702774572009577, 1.101606305351083, -1.6565621136343052, 0.5026668464198907, -0.18820643827054875, 0.15770306290294145, 0.2799427533452889, -1.1954230302826112, -0.6609974605772574, -0.9393274708676524, 0.7400917327196829, 0.07548559564212583, 0.5746139903184309, 0.2262972230580365, -0.23719318512636606, -0.6384808808307345, -0.2597959137233964, -0.767337831339493, -1.6244529326443666, -1.0500069023471765, 0.7929884648104291, 0.765452722645771, 0.42838392162029015, -0.5041856123409517, -0.22679045426271946, 0.6790585592334843, -0.9497670663441493, -1.1726346923098936},
    {-0.4873128896093568, -1.133199830584511, -1.2096180582490832, 0.452765567354047, 0.8747531292792764, -1.302478143607947, 0.7688403800637621, 0.012212012410879934, 0.7946161257778748, 0.9439418916265813, -0.8797178305452003, 0.5179065464599301, 0.4618897590561651, -1.1412831934843044, 0.21724933972210944, 1.412310156056607, -0.471057218832159, 0.4137563703881705, 0.023721432384950603, -1.095016026570726, -0.7119219981241693, -0.6261273098848396, 1.0240168177878586, -0.3671581814211754, -1.193227293765889, -0.1654486098197987, 1.3814933918395893, 0.7595118447221102, -1.035357746709124, 0.5513628482676779, 0.49467460436623184, 0.8240157113411127, 0.5117682719033684, -0.6762292644752212, -0.17357328648412942, -0.7371221498575123, -1.6734681754807992, -0.3033697412440355, -1.7836373620374864, -1.0015933459888824, -0.8572213854149978, -0.14779028812396725, -1.1615322816581537, -0.41956035813579, 0.2839556479103421, -0.043163854318911045, -0.9086582220573955, 0.18427043938645454, -0.6613979426213603, 0.6729327322458559, 0.5610237122417265, 0.0315257183365118, -1.3392449881223056, 0.19843342343825843, -0.4974380537899051, -0.6140635085152745, -0.5319755753278258, 0.9143810939345126, 1.274437606950141, -1.2510027168692042, -0.3712231143662095, 0.5679291735122616, 0.6707658670685952, -0.2787514683897205},
    {-0.13509669882089914, -1.2664924403544875, -0.9128829309235802, 0.6869524519602325, -0.4241805485659256, -0.5172971399919815, 0.8123606031384824, 0.16833799211719702, 1.0338515401293458, 1.4124761242141026, 0.6592137319478625, 0.33936092370875315, 0.4317575982736562, -0.7522202369952556, -0.1051335712790547, -0.5234990317462872, -1.2299339445270177, -1.0189487848089926, -0.8885380484213729, 0.6413047042844177, -0.5030304471071197, -0.7760995435784184, 1.0455307076703004, 0.3882290387041112, -1.4432902098375882, 0.0998744131790916, 1.3010859905602938, 0.055802866203456605, -0.7999558879807394, 0.6401158714628038, 1.133342888831531, 1.0206693004931011, 1.114536276836277, -0.36494909840836415, -0.9864687131888531, 0.21778487634879126, -0.3315486197580044, 0.5004026673973935, -1.3250573808663093, -0.005423348412423684, 0.888704084827094, 0.12812638894147785, -0.002258222829053242, -0.6985433418557949, -0.6919804267281976, -0.2944346042073882, 0.7530190574203988, -0.44944160536423383, -0.912875175186087, -0.5680389283269853, -0.8020121531030766, -0.1905966550393665, -0.4263715263598852, -0.08703717742873548, -0.5981388487269746, 0.21794821358887842, 0.7103412116392649, -0.5503791287143582, 0.45563308086171944, -0.7704824872495555, 0.2831004492641694, 0.7267726185175867, 0.4631569970580611, -1.1087043068266371},
    {0.3512102616028486, -0.7304552435327083, 0.07189561422072639, 0.3814180113458686, -0.6541212311087282, 0.01959672385316783, -0.1955620102861768, 0.7730339672477458, 0.494082975149312, 0.5615740603358792, -0.23493476118705606, 0.4066198394415397, 0.24622992145655156, -1.453748446697731, -0.6913983706583939, 1.2877722874699755, -1.1414701299152135, -0.9248590247000795, 0.4831766545531997, 0.8207167053867175, -0.5788840935934022, -1.2523440105597146, -0.48083822399118137, 0.33858529851565544, -1.066830374790802, -0.6411532046368114, -0.013241907137658424, -0.17036917252590758, 0.46231361713624874, 0.9585652248542351, 1.1232937387014295, 1.0386766401754224, 0.4631134632927744, -0.11991322997624922, -1.2409971362742038, 0.40244208868705433, -1.6683520734108446, -0.06618571526807789, -0.48183106766707595, -0.013022977718840773, 0.6747767716923736, 0.3068711217251306, -1.0092498128239622, -0.654917554809805, -1.1200383939056682, 0.5309986047925226, 0.24553841401688278, -0.9707261299979035, -0.03539284674135161, 0.9178423883665103, 0.8586458250423894, 0.24087175576357414, -1.0625892055217634, -0.6901805747815487, -1.5072387738626525, 0.26572673498936655, -0.27812517880805293, -0.13380915570819144, 0.3772133433244542, -0.21903758022768383, 0.18541875479541492, 0.7220766498257948, -0.9751946968500764, -0.9278912705917275},
    {0.28686111908159695, 0.055352982209649855, 0.7893232734187466, -0.5955072274560953, -0.6694367682402113, 0.8535159238404578, -1.1183855502535602, 0.5758169660549705, 0.4537154564114184, -0.13631442437473237, 0.0990626400693505, -1.0960003930502047, -0.9632864190680536, 0.3882034167113701, 0.01166987177163761, -0.40000351910046666, 0.2528970445274463, -0.5404880953463261, 0.762437939661251, -0.809329572770399, -1.0135298206177874, -0.40085696015776134, -0.8744082520682046, 0.5329829429673293, 0.26089012110675425, -0.3336989133006714, -0.7186927278304698, -0.37508406330773597, -0.9257164830580594, -1.390367689826973, -0.5738311759115725, 0.9878078418059878, -0.03477457335922684, -1.2028127552426722, 0.6294710601132919, -0.4419847072092812, 0.9383537058382473, -1.2370899559999582, 0.6450099575659959, -0.7342120942567326, 0.11504816931852142, -0.3816848189195433, 0.10479098732508481, -0.47368931996540525, -0.7297776419006544, -1.1409860764412463, -0.007318894803714593, 0.7037160711792334, -0.7454463672465188, -0.01605205463620453, 0.6759165572399378, -0.7502165370412842, 0.14532291779720719, -0.31221928694179907, 0.7444833088363368, 0.8658526128575855, -1.2385985662268986, -1.5975473296384564, -1.391092802414534, -1.039779097434333, -1.4849531623180017, -0.01898740820759115, 0.24803487602425603, 1.0031182695848277},
    {-0.7215640487416208, 0.2056422013462135, 0.618165015886364, -0.6693613357683962, 0.45633288715376197, -0.28831981214026675, -0.03674492232005554, -0.8099451679908655, 0.7765390004639913, 0.2875893827271511, -0.22572969845314275, 0.1360894320159355, -0.45081976587620554, -0.3105022594551458, 1.0054573009290746, -1.0803377995384473, -0.06450294447071545, -1.2379831512665158, 1.0778714543750536, -0.030478139468929733, -0.125022344149493, 0.8382081138957179, -0.8865396594307855, 0.466880021102972, 0.7667763755231491, 0.20668720263971505, -0.9548842622950167, 0.7210174136263594, 0.3901795847729796, 0.13753870193742732, 0.13562165995988357, -0.8717308726478697, 0.23897830109124027, 0.2805569159381343, -0.10986454919057821, 0.6348614928059065, -0.18138935142503726, 0.6131325588091217, 0.5790313420908018, 0.27223136402930925, -0.16591658985853033, -0.8028689696642919, -1.380404402037828, -0.24180911280188624, -0.24196700835504306, -0.33019080027190234, 0.14888943832412135, 0.5353083893005676, -0.5237233440280371, -1.3077464804169046, -0.35632042173286116, -0.46527640701728906, -0.1850233994040008, 0.49764952375074784, -0.24671480641864857, 0.04143331534494467, 0.5109293654870901, -0.7722747511795048, 0.00870216735196084, -0.02133500335769321, -0.9630400098894963, 0.08649315410906523, 0.7836363715189304, -0.06985637549254323},
    {0.31863133854417924, 0.2499921754558095, -0.8283268680669302, -0.09885407857215006, -0.4977150422989371, 1.0336135275185963, -0.6923803039602878, -0.8750786468936979, -0.13585134761423523, -0.5134831163346496, -0.7808272473304381, -0.9253191261824566, -1.5138273761749428, 0.5286187534810838, -0.1243144613964891, 0.49958190650407125, -1.1539730159260777, -1.4277437796605634, 0.922239046080134, 0.009849385070881752, -0.03616212992710022, 0.15002197568051848, 0.7750713966149545, 0.20087859232772232, 0.46993559720825107, -1.0845577922211254, 0.5293928650772008, -0.8944366282305032, 0.5221772567726498, -0.5855149447426776, 0.5287509470275639, 1.0108948601453147, -0.35241384757617533, 0.5318095329402909, -0.6225658283573993, -0.6084235697551702, 0.4413998777621061, 0.9620319038842916, 0.7088803550870838, -0.7891446986307384, -1.0617864793365608, 0.4028082153653327, -1.113120723415792, -0.30946525846688056, -0.37812300713511576, -0.36412188783416755, 1.144552501166641, 0.7894020312119042, -0.4610203498477667, 0.5193799396210896, -0.8904096372914715, 0.22068745077292215, 0.43352370312671196, 0.236331051796465, 0.5047894400819443, 0.06704391609137576, 0.4102258110195996, -0.522966763991258, -0.2306941476590698, 0.07232609492662236, -0.7838504132911369, 0.7009433268461447, 0.670515007387542, -0.03978184562154848},
    {0.2670744982102094, -0.867697399879301, 0.02453615513508321, 0.8096496886099428, -0.20443270880706282, -0.7714324444405167, -1.2452613700614816, 0.7430001013827575, 0.3254405367512784, 0.18705965084630655, -0.31870675054220154, 0.6475402474494493, 0.7776493701617364, -0.9424964757006309, 0.457013714108107, -0.8784508415684947, -1.168495976650578, -0.4505581679045933, -0.9748747332892045, 0.31399361278065296, -0.9192284859292936, -0.13482848206137246, -0.21779288274202868, 0.7991366572961988, -0.555479322884923, -1.2715453551034877, 0.7191923181508596, -0.8927547865641733, 0.7030382473896442, -1.060972922654589, 0.38427922951775384, 0.9928157138723, -1.1223101638854984, 0.5170424546393585, 0.7826559337426, -0.8117010317901895, -1.1371015645549936, -0.9829570848306386, -0.9381315379690163, 0.5004146301366033, -0.53743285917042, -0.9249830475446583, -0.8938139538281172, -0.544868576268764, -0.8368865671445909, 0.008848201439741715, 0.7573902767230015, 0.7082228640799697, -0.8476582763644521, -0.02302077107579018, -1.1525284846342994, 0.7109065478458169, -0.867699157856248, 0.44154127502945545, 0.0565247682963281, -0.10978607107872544, 0.7003284915681357, -1.2547451658393585, -0.7467144100911192, -1.2114524502116903, 0.031933265095819965, 0.27301793813409303, -0.23962777296873458, -0.31095101141055276},
    {0.10478385796006674, -0.8262259015314481, -0.24309140419024455, 0.38893074055933957, -0.6566704360014689, 0.5105966524661685, -0.7080520872932722, 0.4617307985127471, -0.11164290660082665, 0.5934350173021573, -0.7946669382930186, 0.674660729212079, 0.2219155120556085, -0.14805123371601564, -0.4612486089793785, 0.6665174026458321, 0.5275901875886011, -0.44967773536249195, -0.20614998867966364, -0.08474355190782284, -1.1972007652029202, 0.49376192410439407, 0.12312401161667695, -1.1255491066907128, -1.3880723222663698, -0.0794391006528507, -0.4853881892209533, -0.17553034544125917, 0.06329495213935671, 0.51686407166484, 0.8208355867800492, -1.1022553710937568, -0.3745341669063769, -0.6529867621471772, 0.027763721781062352, 0.7237592124783451, -0.18710124270059655, 0.5487216143003204, 0.07717230082034493, -0.14163391843598086, 0.7059776046030365, 0.5217263901980423, -0.3181346249427333, -1.4013201739872252, -1.1196221282932681, 0.7233466845460188, 0.8510175607809324, 0.20254043840429165, 0.1652666306275935, -0.897015149215505, -0.20101951963877973, 0.013293370030878274, -0.71147426456398, -0.032964439293079524, -0.4034118438379368, -1.3196111348025055, -0.6293222200581372, -0.19423117381303628, -0.3814374742704543, -0.1226924662904735, -0.9457997667887028, -0.47219649845009387, 0.8604901206647094, -0.5261811812021426},
    {0.8024047015366608, -1.245272199771437, -0.24432227977303925, 0.07742892142452569, 0.03536928723144502, -0.6680825563287174, -0.9025791935430044, 0.22024271123325834, 0.23991657075955003, 0.07703072402239342, -1.0645354944549783, 0.6393713736346631, -0.10313629214814565, 0.11652161150219269, -0.29988769851295594, -1.0311535412886097, -0.08698968883267538, -0.534879181278767, -1.0012590363856735, -0.9620799896096192, -1.0834268324141216, 0.49513475555594677, 0.6624331149003091, -0.3820946389254114, -0.8548498017627034, -0.12515379956470019, 0.07189183624650998, -0.08691262521751565, -0.9635818781952629, 0.20550358184660242, 0.5017877862962239, -1.3584413556804376, -0.7653596176093183, -0.5202248287834774, -0.18497496576760894, -1.094082246549408, -0.3371953144684836, -1.0248694836810763, 0.6678868706143238, 0.5203492277216832, 0.3481138519422264, -1.0692747132149343, -0.7183785621185372, -0.6600924413531719, -1.0226090361599973, -1.21723034651423, -0.06688394503018291, -0.2737349351042423, -0.041736736621448535, -1.1560117475584, -1.3365364953107077, -0.02458209483195775, -0.5497919656050414, -0.044914936738139136, 0.04120333359160345, 0.6747803546391227, 0.46027364419161365, -0.05742036547852616, -1.2164551442284666, -1.2636422449267235, -0.4074302141671589, 0.9700828154112101, 0.5341744346256637, -0.6088199062955686},
    {-0.010030664709146504, -0.5024956527816222, -1.0216774250268628, 0.5142112248127184, 0.46839863753731453, -1.0342732383278694, 0.10017664841876929, 0.7037132633258234, -0.525609331299323, 0.6879258925860581, -1.0867078360847762, -1.0090047300844929, -0.13164501564680017, 0.28697115274942514, 0.8054183553939555, -1.0698384683060458, -0.9650028189100731, -1.1845271195295979, 0.4901601969832795, -0.4501586391841697, 0.09209839994371537, 0.42127629281110945, -0.7584296070712502, 0.6370258509060049, -0.12107203455676908, -0.6896545669844634, -0.7447367683619758, 0.017880323990193434, -0.21570984213784772, -0.15239345743481197, 0.6444205202039379, -0.8826728834323063, -1.183686881742004, -0.22845470751852193, -0.3150235950225252, -0.7663161207763755, -0.1966976720177122, -0.9346849386139037, -1.0392321250926337, 0.7117800105469905, -1.2550919944754384, -0.30948045295430643, 0.21380379771237157, -0.1418688643622305, 0.21041353484462424, -0.9774007998952752, 0.004298424470810711, 0.0655541780148148, -0.4942317009881592, -0.024966983957034564, 0.041720167283832384, -0.0847683167489638, -1.3045919275339652, 0.00791995287255601, 0.03406410465963999, 0.5680209499991048, -0.052434822259148695, 0.637832345811602, -0.16186295233258208, 0.49803635684486514, -0.6424041401892282, -0.16514658719332068, -0.8764674467459773, -0.6568433770293725},
    {0.21505448740090505, -0.05091697430883647, -0.46862677649868256, 0.22544959622552752, 0.11550883662851201, -1.1022418975722201, -0.24973107198341116, -1.2793299565737388, -0.8503654113888505, 0.5699413853824821, -1.424148282728463, 0.26498356274874113, -1.0094578813769974, -0.7635196121850324, 1.09292965058889, -1.0236080204034956, 0.4251287412258163, -0.10282692077194036, 0.5993977212434493, 0.7832162611617592, 0.12244256900588107, 0.4553543042994617, -0.01896267651281469, -0.2209599829401646, -0.5503071549890556, -0.3492504173283134, 0.7955254106183002, 0.7349031858786785, -0.46923999667088206, -0.7533084256322657, -0.7879809711940592, -0.9577940837281506, 0.47137544927516883, 0.5003333085923716, 0.34597784824920225, -1.5889504811227366, -0.5169078467367635, -0.2930240766918647, -1.1733880862858197, -0.42101056470584813, -0.3780396529690137, 0.3346147461853407, -0.7514704639138868, 0.44673536508389594, -1.5861576713774441, 0.6139504093957963, -0.653078310564663, -0.6809154390998584, -0.2012268031082275, -1.430650264074397, -1.2381059047929799, 0.39079290206605793, 0.5212456201666146, 0.8510238140488552, -1.3721338079188894, -1.2036799478972633, 0.7906644613897562, -0.7091296393438263, 0.3243900483299343, -0.9455584717613912, -0.2091681203560358, -0.5108528113137059, -0.8343895077545724, 0.8760394868911326},
    {-1.0077830509636247, 0.4507228204858143, -0.8690320642871162, -0.639514516926644, -0.32218876310962, 0.25615544139052626, -1.1677046036762981, 0.18047990223009958, -0.8907930237394185, 0.9883039929335306, -0.21672477982877286, -1.0704064954900112, -0.3896506946844345, -1.0358118401279421, 0.35182154740833116, 0.745520774155148, 0.11316910555059752, -0.4287418603434663, 0.9963749169576254, 0.14519420953418993, -0.4349409629551424, 0.7862391780429461, 0.5784515284455809, 0.3566172801713743, -0.43398157138954574, 0.002933700937088095, 0.735028472393235, -1.1574907203550784, 0.641419320205605, -0.9038582022112206, -1.0388382833412095, 0.40608351861153735, -0.4936300087971717, -1.1778946096187934, -1.1449462329867923, 0.621775688157992, 0.27717808144142564, 0.6969599562663911, 0.25920732328551904, -0.21703892259681862, -0.7087926057134877, 0.04365199227643984, -0.8482627272216007, -1.20948497875277, -0.7824461887497574, -0.3066474863105229, 0.7339631162343496, -1.177743926980273, -0.6041608203439711, 0.39908542197298835, 0.5170167919066214, 0.6148968710461987, -0.5250716855397458, -0.12627631329728228, -0.18464434078128408, 0.467931423099048, -0.8908997853374041, 0.8547432164266798, -1.0162533280124906, -1.3854173903991032, 0.28473998551459284, -0.48617561825802963, 0.5787925401032424, -0.054827746690037905},
    {-0.8446150926891683, -1.1384392164964874, -0.9538458117013334, 0.9820896775805609, 0.32911952610514195, 0.33105493610630515, -1.6245108986940728, -0.4627365552564686, 0.26418112838170615, -0.23562878436011947, -0.635883744065903, -1.1419099595591717, -1.1441599364739694, 0.37564501921215987, 0.6734616114139559, -0.08434403315873447, 0.00562104839947994, -0.5658733756059176, -0.23561415403848915, 0.5358842057779689, -0.26987358571707015, 0.5973655765536653, -0.43539340733530446, -0.7601477548077423, -0.28740064743731575, -0.4264329344493151, -1.094993729027875, 0.4257996731292874, -1.5466157652984318, 0.5059440732451904, 0.3610821392288092, -0.8734695025149832, 0.7041030523728611, 0.3182083722423163, -0.9170850688000616, -0.7982703721763693, -0.9621886253032903, 0.5797803296055988, -1.0802574605478843, -0.5828241261361125, -1.3334268450742308, -0.6295458918157851, -0.9687940179038498, -1.2509529065525993, 0.1650806855726521, 0.25966991263975614, 0.6064173648614648, -0.7606259029046106, -0.3540248244347365, -0.49453639203808974, 0.5321893604651422, 0.7135999509920974, -1.4975705701936, -1.1805908457086467, -0.2770361565935651, -1.1713239990168915, 0.6941037951665606, -1.0743195117719389, -1.2987991203109817, -0.5345143769029475, 0.5645084696709727, 0.3379202903915956, 0.05932085064205657, 0.5357620518840073},
    {-1.0072250050772704, -0.6496100675081076, -1.3428719389855157, 0.9250520623989837, -0.5412971448386377, 0.6794613653473505, -0.655379928521292, -0.9232002295666814, -0.16644683679256417, -0.8590620625231424, -0.750699433045845, 0.030629847001330198, 0.2641446119756618, 0.19207606842756525, 0.9805154234250971, -0.13473682204248746, 0.6619091793662213, -0.056400106067466434, 0.6199013522414316, -1.1590082434979871, -0.3315099713841849, -0.7030128584212859, -0.7588596451004916, -0.5248887878618578, 0.15323149974996644, -0.5378088763247881, 0.5528796759878392, -1.0119508438884142, -1.075123321977677, 0.6582233698440618, 0.11253971339128639, 0.6915454386539616, 0.6689885015921726, -0.3060496675503467, 0.3983213763644724, -0.5547665695924027, -0.6150010033659452, 0.943936503283187, 0.29121680552493784, -0.18336647017117602, -1.2814026950211406, 0.26408563216750425, 0.6004376610380288, 0.5366687769566764, -1.2926042182681827, 0.5620037818021256, 0.5697303561294057, -1.039834316896708, 0.3740753615799098, -1.0158582841735804, -0.05231009754910504, -0.1411300266105363, 0.004592064341192828, 0.4957313646097228, -1.1019411894185638, 0.13763961258640822, 0.6101829096037397, -1.0197756438030094, 0.15179593321361814, -0.5226684905501264, -1.0233885402210046, 0.3984211411478067, 0.10197877331235518, 0.8119910499290931},
    {-0.9815648809704668, -1.0379624178701965, -0.7484924350702943, 0.14771743219179026, 0.03338075877773896, 1.0026062989875326, -0.7331954050440104, 0.4203558593342855, 0.7259575262395028, 0.44698144933133965, 0.14826713981131184, 0.8284408256786095, -0.11553142909650123, -1.1819898757737248, -0.7704688037139538, -0.14257907021835883, 0.3088530859954163, -0.7534189132511375, -0.20200516594871173, -0.8181227048790949, -0.7438994520755305, -0.13783175861189137, 0.3156563719934988, 0.2953545474633316, -0.6997426170610833, -0.5678602628618044, -0.8642854187448832, -0.8692191698442316, -1.435656188310335, 0.6905921418193328, 0.13187573461457275, -0.7440601472696952, -0.4777019447308721, -0.4224155983690977, -0.46254118019842205, 0.46439763564616543, -1.4503854273323908, -0.25742556526250404, -1.2882736746545334, 0.2329642162292772, -0.33193256248889924, -1.3136670746214498, 0.27815121457709163, 0.4473751946032136, -1.0727564409065782, -0.21869972240141455, -0.7991679175598999, -1.0308033310360263, -0.3921088781654253, 0.05192154996483826, -0.6474543634218489, 0.18661705498547357, -0.5769804382661876, 0.6603159554580034, 0.4660625658656524, 0.4683405920813166, -0.5516085275913822, -1.0411245236301059, -0.4081056729991434, 0.2938022057561757, -0.650658539020375, -0.669680870611692, -0.564692842229858, -0.003584408355643042},
    {-1.3992616011099919, -1.19065470659567, 0.463371356517157, 0.42356804531139464, -0.8126365546743444, 0.2405769469301298, -0.6980694856441914, 0.452804495552781, -0.4665938593157805, 0.9546300650114153, -0.6171046752860095, 0.27537245310075886, 0.33445661527114595, -0.5037034485918211, 0.30691239110788504, 0.17364484202073804, 0.6822214702122147, -0.31678006509700884, 0.19602668087121874, -0.6302624095041623, -0.6150898775766025, -0.44598503041960197, -0.5891670213737059, 0.49749476742832954, -0.1114967871873861, 0.48116992874040976, -0.4919686230680931, 0.612102241020341, -0.4201225012230921, 0.6488116972452416, -1.2726265254684828, -0.6747528370668853, -0.9504141607657988, 0.4022889280130307, -1.0690073341515576, -0.915388813342665, -0.17145179664823965, -0.8775782275441113, -1.2326019807557544, -0.20482697569366026, -1.3243826334691118, -1.217729631420808, -0.7723939212311081, -0.6866369395904097, -0.07564266430299443, -0.5236239211798429, -0.6785721435312837, 0.5207311758154454, -0.950437753675473, -1.298329930613403, -1.1921764962514136, 0.9829477551550634, -0.12021842241062652, 0.5107699001826659, -0.20017917185795744, -1.5061356845090144, -0.2496951191756458, 0.3949954632364856, -0.16278886002659607, -1.0920363924513972, 0.7058232420932691, 0.8018156209646697, 0.18677214531012198, -0.08098704147226123},
    {-0.3210805775796071, 0.3572460845065607, 0.052510317558732575, 0.9557704313166814, -0.9789382245206545, 0.6903976322534354, -0.9520166680825758, 0.2661742095789835, -0.07183360821961327, 0.02559664976034364, -1.3993435853435179, 0.09527191630576803, 0.4489057095076862, -0.5220099383661709, 0.3001428427332075, -0.02662457003310916, 0.39267606710727215, -0.3448661993681243, 0.44160846395300773, -0.3902718620234417, -0.5479474555053154, 0.11044451297376248, 0.64789412568915, -0.4558797487311051, -1.0735761247088096, 0.4801721601655018, -0.3574994755939627, -0.09456016128952122, -1.1658196482021637, -0.6727376153894717, -1.3972595849621285, -0.5146360415121563, -0.26290349473806357, -1.1869621177339948, 0.31823214009227335, -1.4279602119233377, -0.7374467293142213, 0.8142859549781023, -0.4753244656087844, -0.34730070704388355, -0.2811150208899811, -1.2032083758191572, 0.31404026040069855, -0.5069524140438957, -0.7516222295605572, -0.860910838885024, 1.0872972855673904, 0.6153555214466548, 0.0969355042693002, -0.2934958883106476, -0.2927710958949848, -0.8166423520036857, -0.016743149792325676, -0.3014969221725079, -1.4942800551937896, -1.2676711531992155, 0.7034054817722959, 0.05033983484852641, -0.6884082250735768, -0.16665203537642298, 0.2987316880603952, -0.23309530927066838, -0.27465786316099045, 0.5461956740420946},
    {-0.3890094810700101, -0.7723854785587074, -0.2917267382386242, 0.5087241978912955, 0.09177659273780892, 0.9454889854318803, -1.3577111123481218, 0.050072396394336915, -1.3931474573069893, -0.36257526436526505, 0.4264796142921806, -0.8491487365874968, -0.5621107701827924, -0.17484933772387953, -0.21164308676407198, 0.33348575446814965, -0.13403074547163504, -0.9663026457161927, -0.1789297553357037, -1.2095304710443835, 0.06095971170756335, -0.021609465427581374, -0.6860049910069994, -0.48893591261833236, -0.5724653676725558, 0.07321800141751222, 0.10047524324036466, -0.7363508128054481, -0.9114830490953356, -0.27255621761638954, -0.6265317993404371, 0.8932401362999958, -1.0969523495824935, -1.154637630064662, -0.1618309914808374, -1.2535847379531435, -1.1852029715794001, -0.2616259561490866, -0.00025895468698429355, -1.425395763549523, -0.5257680997471625, -0.35198096283836433, -1.0326895188093859, 0.5815208199640389, 0.2576283759350633, -0.03248156689204906, 0.3129549206365858, 0.395799812553071, -0.4881122741253625, -0.37921409052241656, -0.2530988325698158, -0.6227998496627056, -0.9781288625806388, -0.3542545710484435, -1.4035245757062942, -1.0689011941950537, 0.859632391087693, -0.24504333118624871, -1.1053711778002107, 0.41367963350537024, -0.5260211938774473, 0.04527416465810934, -0.7513485802320896, 0.6857590079050445},
    {-1.3331955778629305, 0.06224096408345549, -1.1942127298555896, 0.18306091493354687, 0.880825627778553, -0.6465815862338653, -0.6659378181252723, -0.7049094708828844, -0.043034937551234394, 0.4123760348542697, -1.263781353015137, -0.813476875880872, 0.24837543844413326, 0.3031481648238226, 0.4616846506368263, 0.6297170062803756, -0.9909893106459188, -1.4719803319311158, 0.2657147088450569, 0.5627449253517831, -0.7813971183944771, -0.016396909308605122, -0.08704280465233358, -0.3063668823319379, 0.5589231528862689, -0.3147898060454473, 0.3797993213069896, -0.059574318680950936, 0.032775049285347045, -0.6619132091146498, -0.7533047735146329, -0.5197951558954683, -0.5403179668283364, -1.1501767538923262, -0.5417719037898162, 0.152380824729956, -1.5132794939433667, -0.2915723940960376, -0.4770010695208501, -1.2515296044605133, 0.06381374239928535, -1.0258755264576331, 0.3681379502975215, -0.8941807571379119, -1.413862810870038, -0.20117088947984896, 0.667838717972168, -0.026163935303355708, 0.37296326277894337, -1.1564338709016373, 0.47493225511357484, -0.19972924007254284, -0.32034443428760156, 0.5309077684184307, -0.6453672285149542, -0.8033326042475998, 0.2877960978604874, -0.48552401310111476, -0.3603913680915704, -1.314467559623296, -0.6728847182549987, -0.2350764674036493, 0.13017564669330875, -0.3314672302824519},
    {-1.0584153977931758, -0.5004277840503074, 0.4188445691396896, 0.2698528574294883, 0.34305774179230925, 0.8085039948549572, -0.6414797922680099, 0.34590264256984204, -0.2853252140713109, 0.2874358950777504, -0.3104993993491792, -0.4782870439589839, -0.9225287743353118, -0.5330847899551371, -0.24039372327139527, -0.9220002440675771, 0.27186307279139615, 0.5509526230088634, -0.30462723692160737, 0.685636958720054, -0.05335397383022608, 0.37530377872193166, 0.5310847604516618, -0.5590075393716746, -0.849174503105299, 0.8093142389489609, -0.36984504385389977, 0.1239241553163981, -1.122085437965688, -0.4249347659510954, -1.4503604996153225, 0.14219479467851115, -0.04177205483204759, -1.3728261360606075, -1.3874565040711362, -0.10169554775114012, -1.5804135364495677, -0.1375734301933364, 0.20007615405610887, -0.5165758507041991, -1.5312595594510663, -1.2742219385429865, -1.3683087282788617, -0.6084855000379755, -0.7768757166130726, -0.7693455435855246, 1.0689889142748414, 0.4950647432034283, 0.4771428214272462, -0.42932211445698887, -0.663410007427938, 0.0811502232057922, -0.259407159973582, 0.2589229259633956, -1.493989572666308, -1.255391011730689, -0.07677649409435633, -0.9370808005205851, -1.3803648410541751, -1.2609687512134526, -1.1596163363204874, -0.9231640742013043, 0.8761136766564839, -1.138861657247016},
    {-0.2342540056375068, -1.2082852932614445, -1.3128912300040751, -0.7139626238642489, -0.12255486860387622, 0.7565720667699717, -0.5714641788789708, -0.8959080786238899, -0.10752403860454064, -0.493165935771768, -0.5935212143385482, -1.0294939104304515, -1.1694657037747591, -0.48170592178270716, 0.6644710027120736, 0.6841758816612578, 0.12223673164886623, -0.8205647949041526, -0.11166262228948835, 0.7430206604538625, 0.7287329472324949, 0.2603127893297664, -0.008571583316952885, -0.5368593145042242, -0.2030501914723166, -0.7293197611969229, -0.33861697237914906, -0.5352177393819272, -0.5031247145509616, 0.4768484635547571, 0.03362017199063147, -1.0655094855481115, -0.26169525792548476, 0.332934229129748, -0.2103963506033379, -0.4480817703394268, -1.4042925836182323, -0.1867018734210797, -1.1850284095427523, 0.11037658677652279, -1.4084504010429226, -0.76761524578378, -0.6858548874078744, 0.3245175945536394, 0.40454903480036175, 0.216448488276623, -0.4635958497742427, -0.8751656677968231, -0.33310081204721126, -0.09923847803351273, 0.5405196077158055, -0.21289130772908002, 0.19939007942949724, 0.6291643181547006, -1.3030588176895377, 0.2328316684653092, -0.6821962775347631, 0.10385640208940732, 0.39425164209172886, -0.4669676130800209, -1.2424241700221623, 0.6185822262836318, -0.7341877848018759, 0.7610217052557874},
    {-0.9317007390381272, 0.40696499259053676, -1.047870803016017, 0.019696994234153227, -0.7036826483464885, -1.0200046196133221, -1.0129575115992508, -0.5491832449145397, -0.2258281277299658, 0.5300054624273192, -0.9251912751639327, -0.19910139659949017, -0.37803705258962145, 0.3831405517826678, 0.3440483298676387, -0.5515739185716512, 0.5735451933871746, 0.11951636524746781, 0.6394996318680031, -0.19787192595525063, -0.42922623649693215, 0.26406830236997947, -0.06073039069681831, 0.3673212697000926, -0.07976437464142393, -0.30575927435271805, -0.6793170878343874, -0.7810645666584741, -1.4237630455368906, 0.18928981679146265, -1.176235346513056, -0.638412225180309, 0.40132714611092524, 0.11191420485872568, -1.1317078721612435, -1.349580349977763, 0.1948801397102999, -0.49640306512262883, -0.022976795308100838, -1.3145249116073852, -1.3835543491523195, -1.2110752189814706, 0.24022015793017656, -0.9403627469072948, -0.4441391345465497, -0.6221445177895925, -0.4881908488795314, -0.8635171392645369, 0.33702942944775377, -0.7248064226656397, -0.9776180226115035, -0.5102069719549744, -0.05397254269435972, -0.03736912581527532, 0.271074736936822, 0.6876749225433286, 0.5575160499879719, -0.6276289393017862, -0.6309184343900911, -0.9350719912444633, -0.3122304908124416, 0.7451838024034737, -0.5485955913590665, 0.8380817005069079},
    {-0.3091367987651176, 0.29616784252979667, -0.1599429865911593, 0.5458493833548932, -0.3554207097497762, 0.08746818557716822, -0.37706086050373316, -0.7468133836561677, -1.3088497142393543, 0.9460931703445983, 0.12322895183700502, -0.490965236220934, -0.36421664418936534, -1.320036840488885, 0.04385257675197494, -0.8976421380590843, -0.9567779224591374, -0.531920166070501, -0.6033483416233046, -0.9958348954752261, 0.8398901995529834, -0.5354712216339631, 0.07488490058820177, -0.3451240041316956, -0.5035667177517105, -0.08663316773372925, 0.567423512504885, -0.3597369407673048, 0.3039800410795711, 0.06368834728046181, -0.11448065517462867, -0.1764281296220536, -1.5411109773405556, 0.14375735155484085, -1.0177480278401525, -1.3782664038446084, -1.297796002372972, -0.05273173264394614, -0.3948025556236408, -1.5046736457724093, -0.9977625655869631, -0.9883635362207027, -0.9352380108411906, -0.8378834575093012, -0.8438937628589752, -1.42040374180527, 0.9359498739302147, -0.3159581390151194, 0.32018993119769856, -0.3306530405467573, -1.5206763103687397, 0.7878114783085772, -0.9777555927695754, -0.23653041600108676, -1.254976939154205, -1.018623896268927, -0.6883344760241927, 0.3697316886681479, -0.9720770796166588, -0.5889947429650815, 0.25134717978829946, -0.6783285824869529, -0.6950209748255998, 1.010095653542384},
    {0.4776015545309373, -0.08373457688047603, -0.8619429962139584, 0.7356292994548341, 0.49934837210722044, -0.26198257525228835, -1.1477206647333067, -0.0048167396281896665, -0.7895381431328256, -0.001958413264859478, 0.17242942445964782, -0.6503612395741818, -0.3745608672985343, -0.6610391746008581, -0.1891516309251489, -0.5057940379455989, -0.7194328379295162, -0.5583411800678367, 0.6947165837478073, -0.6382678796282737, -0.06326290795930674, 0.48945648973125255, -0.1363392749097875, -0.9376162130043794, 0.3830948890371503, -0.25243461453541444, -0.6593806103589801, 0.785235757066926, -0.9529442000465616, -0.16691026506449871, -0.21187071590040782, 0.3230091875555168, -1.0876134391220271, -0.7462512012784106, 0.3095394750905379, 0.19779176661116865, -0.1870932082200092, 0.7441242271143852, -0.08785952738005762, 0.3169249968422812, 0.3423103823073713, -1.2050153966423693, 0.28415950792387196, -0.4326819877925595, -0.23653614085059213, 0.06627626278677436, -0.3978321069115364, 0.2106660136151942, -0.28486900463533993, -1.5801682471742693, 0.18701197462355681, -0.060157931425025006, -0.26235631294167006, -0.606692847040869, -0.04325824965087277, 0.2823309501515857, -0.006130557860202941, -0.9174733890032392, 0.058548722898807505, -1.222379726074399, -0.06255261772143325, 0.12661248544765877, 0.7478211550893593, -0.041125192963565524},
    {-0.8908655392523873, -0.8440046485652622, -1.0958511337886079, 1.0454702715151873, 0.635490448058291, -0.04552735815067365, -1.1244734814177086, -1.5390162677059251, -0.30319955754502326, 0.3722144691218224, 0.7961980259724073, 0.4363549491210923, -1.2990055277813775, -0.343925874127667, 0.7488161847111601, -0.372044512030912, 0.6769280408253082, -0.6364520243117678, 0.9756812863854802, -0.10964033659506392, 0.49638076155147404, 0.20345148487465942, -1.050720491486723, 0.46260818027391476, 0.42601937051350147, -0.14139033224282263, -0.30875182242942156, -1.0203848962843143, -0.4310937078352352, 0.39931460416573433, -0.8517871855056479, 0.9033017487377903, -0.04520770912320037, -1.0008953966446135, -0.3340636337516667, -1.7403069034476988, -1.0765496288843865, 0.8027619115352002, -0.14521221820283206, -1.483431653613795, -0.2578307134793728, -0.12809803057449515, -0.5637853801586361, -0.22867170192476013, -1.5648979834148402, -0.5913841596546376, -0.5241345827101933, 0.3508150557062339, 0.14224392077759043, -0.7568107099208561, -1.092914925552125, 0.9654527535950868, -0.8031690772114042, 0.5913183303929909, -1.3036311968092396, -0.12387121422383493, -0.002122106342748466, -0.8453678740601728, -0.5142829685913981, -0.6439262838836246, -1.175999522863252, 0.17807998758490776, 1.016881128050214, 1.1062749625392236},
    {-0.2269798015796615, 0.8275419808066953, 0.1288679129359518, 0.8809622573065596, 0.4942139251281618, 0.9799601476899694, -1.2651378325324714, 0.21019753581112824, -1.1027196611960837, 0.9646629461167211, 0.9028666516482415, -1.5236762662224836, -0.5819784258334172, -0.9263175848416946, 0.3102503485113995, 0.17123410992406232, -1.1812080208331932, -1.1285344039404033, 0.8850460440412222, 0.688404686552623, 0.6144540128711149, -1.405569598680144, 0.3691020534884889, -1.0351223655241266, -0.5309513734907488, -0.37643184320172185, -0.0941674080970358, 0.17041871803526784, -0.9829933236389471, -1.192206052726321, -0.9751981857210984, 0.7675457297939206, -0.9752954751233173, -0.11805337763413352, 0.0882177821964093, -1.4122063452228757, 0.40195218597921534, -0.7362943954462262, -0.9184613567212564, -0.9041430050113579, -0.8392219353292861, 0.05454592425047162, -1.4379497523617366, -0.7915102931189296, -1.2098997109994412, 0.048208416856726666, -0.46528588268015375, -0.06369278919663333, -0.4243230770039985, 0.44817253094543813, -0.8557560624045615, 0.9498718382244227, -0.9745194467650701, -0.6452102634570908, -0.6918474223629968, 0.039995318175072146, -0.08577954691200945, 0.407643229041548, -1.0784626825872417, 0.05360881149554274, 0.14836693215332045, 0.3067240429648048, 0.9565868589093338, 0.3711822970415386},
    {0.016344335914208342, -0.5488954169128849, -1.4503562638026268, 0.2416422304497969, 0.2905081080624361, -1.009917669230834, -1.6699853634267032, -1.1461955713984269, -0.9430636781573287, -0.7940444092683384, -0.48076155046660685, -1.4905078223742285, -1.3385006600915628, -0.4285472560750175, 0.30157657890490736, -0.1452382649423311, -0.8727826562800544, -1.344854425674199, 0.5167079299797863, -0.4707998356197344, 0.5472990298876237, -0.7962611942676593, -1.0886435215441652, 0.4547074771852351, -0.8245585657121632, 0.6784557573966449, -0.9755142141066548, -0.39790044821865667, -1.639412219821142, -0.5263614458651675, 0.05379977032815909, 0.1795725602729103, -0.26083472537243363, -0.46895349494856614, -0.036568297488816716, -1.7187088894184575, 0.2903624930621473, -0.3701297733750027, -1.3363260820852674, -1.6072617647572636, -0.24230524743100965, -0.29500114373272734, -1.3347815256228777, -1.2817139255471601, -1.371628229342073, -1.0137663957521925, 0.5130051878020877, -0.1279313243125773, 0.5147601289956505, -1.415531404517099, -1.2339431320374028, 0.7063087729494405, -0.7291893060441604, -0.6312908220501756, -0.2058839798359474, 0.5279506867271615, 0.7812443645829109, 0.30348907067608805, -0.9746575418665718, 0.1717032182054131, -0.9473300201479624, -0.3616374647395465, 0.2113153158647584, 0.4799478498073615},
    {-1.2067556898017646, -1.0499447610478838, -0.7687952358111148, -0.49865275070765985, -0.9015435527354424, 0.5574640052688239, -1.1598354601883771, -0.6418659310995375, -1.0218542270830997, -0.20849539525263344, 0.14710073581659422, -1.5532330706050357, -1.2730484389781447, -0.12301670251843445, 0.18143737617825814, -0.18519417614460165, 0.3396719735099365, -0.1390415248921143, -0.522929019252315, -1.1701324944099996, 0.23897518018580438, -1.549592620079813, -0.26755292900481914, -0.2998036873667516, -0.520740337673135, -0.9262134700889164, -0.20688523875090692, -0.6350991050964823, -1.1292067364739027, 0.046526034992819446, -0.3421048720998821, -0.412575842057557, -0.5596768245928241, 0.0065647277270498555, 0.00660965419616923, -1.51619018485996, 0.1383732922994401, -0.5054542623179874, -0.6815455948154162, -1.1614367877148757, 0.03525138575792922, -0.1766420134294226, -1.0587044967112822, -0.1784363565703814, -1.191955612898563, -0.8629268737235463, 0.9218849322624593, -1.152275451619079, -0.8840290656833645, -1.2351205905917626, 0.2259079780324296, -0.44359781724725245, -0.05807985935197162, -1.0038997857574954, -1.1458694117680535, -0.14060156919976652, -0.1599184621745167, 0.21283409079914603, 0.2910871556918302, 0.28475099585162844, -0.1037822584377513, -0.48030026175568236, 0.03588458648651478, 0.9095511163360793},
    {-1.5205372161695905, 0.7616701045622738, 0.5813741379854909, 0.3621420639859749, 0.9724247349027872, -0.16852730661753107, -1.012371234769867, -0.5787712508989428, -1.1188949860738986, 0.956987425483672, -0.7137574470097636, -0.23460434025529003, -0.5867754382373409, 0.6987455522904918, -0.49104191842584416, -0.7721534014594069, 0.18290985596992942, -0.4567025308011103, 0.06661935075168149, 0.4354007252426095, 0.7643565555408057, -0.1288806219893848, -0.10015624361654209, 0.8688221298360044, -0.642256411039391, -0.017365802996877767, -0.7982654276667049, -0.003565621328796891, -0.77499454425951, -0.9095277226508591, -0.3765101702813918, 0.5539611648984528, -1.2584379465926476, -0.9248799545260252, 0.1462595808400009, -0.4645550317064777, 0.03307302305255464, -0.6647312507052587, -0.6454531345820232, -1.6961800608713424, -1.4578794019407246, -1.0888454303773802, -0.05315090058967822, 0.2344460610190416, -1.3598295157970561, -1.0551966469366163, 0.1731015999784817, -0.4892016426288532, -0.38624464780116025, -0.23535416068168624, 0.11674699723156289, 0.28991783678335165, -1.004071388918371, 0.14388375371224565, 0.07560582095916449, -1.1505650305589408, 1.299724089250159, -0.37936317896795463, -0.5984061107233111, -1.349445686928004, -0.877666076899854, 0.3195427698517697, -0.6466427473737616, 0.9515983966765496},
    {0.20729118979534028, -0.9730283485318275, 0.4129206114174421, -0.44684714916545554, 0.6766215164202071, 0.812514472709385, -0.9940937642094029, 0.2188619763841374, -0.22227033453673298, 0.24882392058229502, -0.26491700550260683, -1.0750499924004415, -0.30215495397385994, -0.01541125379467833, 0.5026884619188361, 0.08376815857841616, -0.06289870099553811, -1.221023332498643, -0.882333220524623, -0.018047393601549163, -1.073716908664483, -1.160732920295345, 0.4908018986015985, 0.2755268607953745, -0.7977949894236334, 0.045879009010898086, -1.1473612336459043, 0.40678968345274563, -1.746808529879003, -0.21469150569078682, 0.22221606941354768, 0.5906418655138435, 0.06129905151648153, -0.29911626245349526, -0.9095708636121154, 0.016806492080818365, -0.1646006696625097, 0.22282702733601276, -0.9995155539668791, 0.18536510605649933, -0.8341799115164135, -1.197583273218426, -1.5287752687794336, 0.5282560919552238, -0.7747954298468437, -1.4069232826409974, 0.39321829494546523, -0.8057452600260154, -0.27906297074644093, -0.8410605511450754, -1.436726504458913, 0.27851442452100755, -0.14900835015076647, -0.38711135923746703, -1.6274660311428455, -0.6338347159189547, 1.0150071740141295, -0.7377407066197168, -0.7671332763860317, -0.22903526365667032, -1.3439565979525216, -0.5443288964104466, 0.6487273753192102, -0.551589328749311},
    {-0.5999312895553794, 0.345791693303823, -0.23398248722885745, 0.5559975154759966, -0.08022080017979437, -0.1831611183840701, -0.1150793650974874, -0.8335714181400182, -1.050754143016157, 0.9782061972117772, -0.6490755830051405, -1.0565358723150162, -1.22828061171492, 0.6725772858032584, 0.9221802123648628, -0.12125990367439228, -1.1203213695937635, 0.2575350420904365, 0.43491372926211314, -0.3843880212749951, 0.011579974849058153, -0.849285860053464, 0.6294798504021272, -0.4015230473749572, -0.1124668648772782, 0.040403628444586226, -1.3521427980116474, 0.24590967896186988, -0.4418510399752683, 0.6146616847467253, -0.7934516426545088, 0.5220397695480331, -0.39058964248484657, 0.3830690094224182, 0.09578370229779555, -0.37598770879588167, -1.4050859521180614, -1.0563743443160858, -0.6372692281993068, -1.342140764671637, -0.037404070148916814, -1.120448922628658, 0.3476016224888793, -0.4832655601231515, -0.1781994372251247, -0.40092734624522997, -0.1507752099701767, -0.34079516603737087, 1.0449535083974137, -0.4038652571010868, -0.8246711354123298, 0.8204860429467694, -1.1774112421509737, 0.5483341628589752, -1.5616798201391613, -0.8068500471494391, 0.1533410422868671, 0.3806628517586817, -0.5149539471609599, -0.1466309506425142, -0.5680672185077218, -0.31044875886964907, 0.26824617316690275, 0.8433355624762181},
    {-1.5830049140662616, -0.37357675584116934, 0.36004335645613583, 1.1304052684837496, 0.9362653661677561, 0.9193713769155046, -1.5105469732991794, -0.027184280665376294, -0.03736250058520446, 0.4338123258025439, -0.689982034928745, -1.3950234308491298, -0.5387559558022587, -0.23922648229668464, 0.2909224000407179, -0.4404206914973421, -0.031785885141177264, 0.1334103614653998, 0.2415424015726129, 0.059833950262179796, -0.11688501487452006, -0.4064959355720576, 0.6598316996049594, -0.7265520342409233, -0.7491738977087519, 0.5980116727264495, -0.2722507382408877, 0.006208274358947029, -0.43087279629758635, -0.30782366788677606, -1.3291189182736969, 0.12010668750500436, -1.6417511864019485, 0.20008985867269158, -0.847085240162663, -0.9814017421950844, -0.007440201432277193, -1.119034109403265, 0.09033080582937071, -0.34858321950621574, -0.6389842620924153, -1.1755240174562254, -1.0466164646852398, -1.4691460078916856, -1.4525812636506172, -0.3244021239559705, -0.25243288461095154, 0.5618466282564071, 0.27011982548393154, -0.7235473396284539, -0.8545684447143768, 0.3127631149816391, -0.9561787697057158, 0.18586248681029663, -0.7706251945716808, -0.7901156330767753, 0.16639656615988874, 0.3398954467521214, -0.21553373824610098, -0.680936915213497, -0.19379351940191156, 0.5380374365926783, 0.06238209657044538, 0.37303865077111603},
    {-0.25980674793008796, -1.1349233985010956, -0.9532353489643478, 0.14606192447166347, -0.5607155231628049, 0.9570776859709482, -1.0451222828422444, -0.184689523065327, -0.1544550957195803, 0.8038831418021597, 0.68352095913823, -0.5879436975193515, -1.5706474487156554, 0.26985594941550833, 1.0698055325958704, 0.5556272046290979, 0.3500742391275398, -1.253987080273844, -0.09634724082153734, 0.2084281167599701, -0.286450345889622, -1.3073167026254866, -0.08300729827852611, -0.7038637112370083, -1.4393563680956978, -0.010241153396389051, -1.2371069728930424, -0.24928735501593038, -0.36699015898148446, -0.502428557760406, -0.520582481195581, 0.43103771195933505, 0.0133153860124067, -0.24420420559700734, -0.8296211538960321, -1.5264586710552825, -0.18731877236691813, 0.09728085390651273, 0.3838990627200398, -0.9410140309406497, 0.3245587360949448, -0.7427480951483202, 0.274956860013604, -0.12315791061910353, -1.6493809761490916, -1.4085183151561393, -0.07905795962230289, -0.3398856903021575, 0.9067936876607946, -1.499534715447326, -0.0806565553505643, 0.31029358243916705, -0.7472511986546257, -1.0468036339834603, -0.408292799975811, -0.8587740746311451, 0.30775364828553164, -0.7134324659687, 0.4562215715598981, -1.1827597492254098, -0.02010630232265679, 0.5185251838565808, 0.8998240861989788, 0.8889733552572628},
    {0.3040758937717239, 0.5222942958989599, 1.0519870868300545, -0.827860755242562, -0.7737105809596805, -0.07759127532561597, -0.3002167299263367, -0.3551818987345773, 1.1853871371567546, -0.5630707942723422, 0.6679975230155815, 0.47907046630917677, 1.1836933525409816, 0.4414393498185925, 0.8453111178419448, 0.48769041415412484, 0.10665857335531069, 0.20623568355342126, 0.08556522614855706, -0.7016347401421847, 0.5172473356576833, 0.45622900477724343, 0.5693085592803098, 0.5141931125189865, 0.2787504378616555, -0.2413996700374982, 0.39616579192009743, -0.5679558003016392, -0.6880315520902088, -0.19917899010349263, -0.599534872205189, 0.40965483803359837, 0.0214634278542485, 0.3479087942548284, 0.2585046266657705, -0.3296110654445624, 0.1233415206036111, 0.5861055168765655, 0.8235465520652946, 0.6153337938319007, 0.5271278601338564, 0.8797165358317158, -0.16341907434510605, -0.7906699089034961, 0.9229526192397736, 0.20236545093640787, 0.17296115293361947, -0.30260826040500277, -0.7153726564327318, 0.9682199512869194, 1.1116997535278872, -1.0046195242602851, -0.37925796213760166, -0.17856981406939082, -0.3846980189719571, -0.15269676484160483, -0.2401390193024193, -0.23923827514021728, 0.7713938289846468, 0.9155334630172665, -0.04259374802102187, 0.6006245006775534, 0.4894082332091783, -0.6029668167215458},
    {-0.17852872491932673, 1.258475465826872, 0.6178114533095189, -0.4850862418632472, -0.9308966281366363, 0.8230346182528288, 0.7308941075396376, -0.4995705653116603, -0.33851749018853955, 0.08648638456432996, 0.2808816785848882, 0.09093332935089997, -0.6734473109179002, 0.33610672832086563, -0.8444634754650454, -0.9849471256593598, 0.7548211327546707, 0.8970518196050978, 1.0554674555844985, -1.350780922518512, 0.27664960340898703, 0.8710436301664093, -0.22949136245037696, -0.35459225964649455, 0.6664236578394297, 0.7980915860629513, -1.1788273244558842, 0.14420833264603233, 0.4496721647423096, 0.3647821358913067, -1.212510211481005, -0.32843039462700324, 0.8254309554337532, 1.1530076902976198, -0.9084066806902819, -0.4675151374388618, 0.30968917283549396, 0.6932960364879017, 0.13347310019768963, -0.16008586613350254, 0.1536874464908646, -0.666321214209933, 1.186997401030159, -0.02336569321993906, 0.3479956596057826, 0.5844486999215448, 0.7944439077547187, -0.3288239098557799, 0.6686997473099289, -0.7710468279234836, -0.8321291596587824, 0.39919558151548784, -0.5351558422713419, 0.07532361777660108, 0.16468462442527138, 0.5700534597354351, 0.35422907213590843, -0.5750796548436683, 0.7101522273645665, 0.5085075955020313, -0.07341979835079497, 0.10721869777753847, 0.5146680728029953, 1.0473777302040272},
    {-0.19465301480455133, 0.28515140138724976, 0.7846243581193978, -0.8734321904553414, -0.19591013732650514, 1.2460867310273498, -0.27656010807000103, -0.37380805987444493, -0.4730694743428182, -0.17419036647513395, 0.9299781000605055, -0.9165268548237916, 0.32853072852780424, -0.5242710652359861, 0.7493217153498662, -0.6906333101387254, 0.6497565984357729, 0.15761044511548322, 0.8127959390651835, -1.1048990743898803, 0.4428901490329713, -0.5393212538927116, -1.1544110614006742, -0.26592811549048134, 0.8240568757382173, 0.578170858695538, -0.759840925841541, -0.0735330995349339, 0.9383865577564366, 0.20616930033618835, -1.1490846565097526, 0.11867581332445233, 0.7661654447154088, -0.5219853657741506, -0.03003038297652594, -0.40742168485260827, 0.25547829359496077, -0.5317133978184585, 0.5537959401561858, -0.5081972561929948, 0.6360118814011159, -1.0899969658612405, 0.4128480069076714, 1.0698287951537948, -0.3760597632318239, 0.9381262362658088, -0.3084523888150544, -0.8708812167251146, 0.555007051782068, 0.3345083996252593, -0.2715727254214965, -0.16091111959241394, 0.2585836329708897, 0.6554343370185638, -0.005391973223212295, 1.2142073051847855, -0.8346990587735452, 1.1774642581525279, -0.0802575112957858, 0.01605050537685784, 0.552419163986729, 0.513199798858751, 0.8484607844583921, -0.49205157436018454},
    {0.4654576861037448, 0.5414843693016809, 1.3676051156742344, -0.1922458287871763, 0.49684021996397, -0.754932583865763, 0.028412494336945985, -0.12515632487962405, -0.4680792376219342, -0.7577054100077166, -0.0765242658360926, -1.0602168279327637, 0.5990700718786313, -0.6039699876330821, -0.08440354737310238, 0.1819996583920574, 0.5994026594054984, 1.180112071405405, 0.4952696955828217, 0.3257569804815825, 1.284676790170611, -0.6757242165712077, -0.13188546218661676, 0.15259042006146228, -0.37634174657005, 1.186903298276281, 0.4023827609876333, -0.910371974225457, -0.46921986159107565, -0.8195869688494745, 0.09072159963905478, -0.14988700526399681, -0.7011743517696277, 1.379591914962834, -0.6638355636769615, 0.3307700939761344, 0.7386453462134352, 0.6681071820791493, -0.42263940405452866, 0.7324976291469734, 0.3949695046378926, -0.46429725286964857, 0.0524108016825449, -0.5341377304976754, 1.143088507266182, 0.9643512221364422, 0.9012786562798778, -1.2429826092485867, -0.3482244348411154, -0.18809852221744558, 0.9698017630080948, -0.16854818616876974, 0.5633538994999283, -0.1719256051082829, 0.21898331575537852, -0.07426797816181789, -0.8725303911629945, 0.5801945633047856, -1.0146129153515961, -0.43913674852989765, -0.9667612472389387, 0.6949225123316112, -1.1165967134322021, 0.6315609348154574},
    {-0.7328331657568888, -0.4154830224340514, 1.2857457265065908, 0.07372521237073709, -0.08775391334554442, -0.2845340099739377, 0.8596225348481581, 0.25717239660059793, 0.3255729564497299, -0.5652374486176656, 0.4128016966411465, 0.021268805821236948, 0.019781172792157648, -0.5193598320651811, -0.7931508480622789, 0.8768282143369268, -0.8944241043300886, 0.7472539993621272, 0.07153229168475923, 0.20179584442139173, 0.41882445963789616, -0.11249153632559562, -0.7305804786175286, -1.0102477300574946, -0.5953162527068113, 0.621032363420766, 0.3510927208870679, 0.3809159499279384, 0.56703787460393, 0.4839316827627583, -0.1487634706221317, -1.1062110287901767, 1.1131761738607135, -0.40025078290580735, -0.21332822035162163, 0.26371586944552233, -0.3985227904589227, -0.3487626070729485, 1.2228812573889467, -0.8616113734519929, -0.12194606764906568, 0.6091082396628084, -0.038536903955429073, -0.8532396109897031, 1.3580160039455915, 0.4514999080142899, -0.17922838257970783, -0.2030908405043887, 0.6640122825196296, -0.010081815164756777, -0.1302485094538021, -1.0054956063159493, 1.0240679361378102, -0.7271216524259464, 1.0305802065682672, -0.9393658106409115, 0.7262794671087682, 1.1821699940933037, -0.9391253140127903, 1.0573731809009472, -1.311340566689367, 0.9747034864006939, -0.6619184287211859, 0.6072594743209133},
    {1.1844115872838374, 0.48327682888592405, 0.2738473573296399, -0.7565381850224936, -1.122798218689642, 0.14110838516630803, 0.43096865967462095, -0.880937725446743, -0.8344890098820295, 0.3017877391114236, -0.03314944541823656, -0.979019246806525, 0.05137007332663119, 1.045682953105385, -0.37524590460616647, -1.0442044682033171, -0.32192722017231734, -0.038841709103648904, -0.3125564170698652, -1.503465388649788, -0.8104760543848942, -0.11336748475506327, 0.7471010827708748, 0.1564030559336901, 0.8014372322367859, 0.8153634367622998, -0.755821135842386, -0.5151711921649017, 1.0270005873140649, 0.7043390203162281, 0.3081671573437312, -0.14313603921518928, 0.724146638709586, 0.768362607345235, 0.19977349157285354, -1.2677648940161903, -0.3283867308756944, 0.5667095962604118, 0.997459647111577, 0.5527667879832833, -0.5407535435572215, -0.8872596594362226, 1.26513736472276, 0.7945665708674429, -0.1567304258306407, -0.10647929773271514, 0.6717069039016922, -0.9609168308119159, -0.5856397533843244, 0.42887558439582785, 1.1464118128662095, -0.3953888899118107, -0.19957171830789136, 0.29843830399886934, 0.5345368027255974, -0.4171288322265077, -0.3857932430937314, -0.5939413332206667, -0.18987826979835135, 0.32685712708682646, -1.01081304744827, 0.621655661193867, -1.084127833497112, -0.8049535927030411},
    {-0.6110552371735483, -0.28247855254590326, 0.7141553904862353, 0.5895175136126866, -1.2401516481532808, -0.3765135069573863, 1.0472383009499695, -0.7076046836272145, -0.0619327348438184, 0.2541419427234435, 0.5594828165729915, 0.1700473606634666, 0.14172341065991423, -0.643581226839449, -0.438846988413302, 0.5725940073422637, 0.5103454205542128, 1.1238634128088532, -0.5438658073861413, -1.5245638740210476, -0.4731916744736744, -0.9762289019117445, -1.191347240985485, -0.6256767668530382, 0.7665971759432041, 1.1991871960900538, -0.6428153000432724, 0.9887228510899505, 1.314328638347357, 0.36703718487625636, -0.35092604717444104, -0.41837461212052995, -0.2813628790311775, 1.1276194599754505, -0.6684312137174685, -1.2405144411150406, -0.13748064152429423, 0.4287344057122723, 0.6115236879615082, 0.06426939205950019, -0.2700303350008717, -0.7441312271804097, 0.7259391378089508, 0.4469422128371648, -0.08992941179829486, -0.35305891343722434, -0.3406979182316264, -0.00899155664364523, 1.1216039557898976, 0.2538193222015594, 0.9410480538187592, 0.33012307807814945, -0.7403537584957056, 0.05984934759105067, -0.8396198150290495, 0.6675730271976761, -0.2321323253744919, -0.9092366460830165, -0.9919840001611903, -0.2208796987452521, -0.6204060268076946, 0.8372625743675407, -0.8597638146820583, 0.9286958557247483},
    {-0.42137721675757717, 0.2078879131793179, 0.46274479558615367, 0.4224865297569485, -1.1404839222678387, -0.257861580791231, 0.9587047804867507, 1.0244465165515824, -0.8822272144704949, -0.44712967146416516, 1.0879866909293086, -0.5495812717549035, -0.2374584769017518, 0.8235233990530991, 0.5729451313620315, -0.7388251817496246, -1.0175527724433011, -0.05156826785459544, -0.9774695357677095, -1.2401027225615209, 1.2825668113499766, 0.113483456998291, -0.6565076456121822, -0.8724510723101148, 0.682540889598192, 1.0601435420893808, -0.8417230179633447, 0.349282701901474, 0.44698698084310423, -0.1887569430257031, 0.49221305235455437, -0.39972868023688574, -0.48952421241613553, 1.2170775196653867, 0.40872510429526654, -0.5924029552331012, -0.026958285427144315, -0.4584981403356333, -0.1943755266400396, -1.0272678172298102, -0.1951140564477401, 0.7483622752731464, -0.014554817733277377, -0.5392109685873622, 0.390677588172679, 0.9154348322408365, 0.5972795147859893, -1.1816291116308575, 0.6055914956079518, 1.1849313804246433, -0.47027184980909775, 0.08117190148834566, 0.8147272647063726, -1.1803915597232277, 0.20595381499160642, 0.7024395873648205, -0.9051456362025895, 0.47763520331900683, 0.20632740669823132, 1.2714025053356461, 0.18916033458688666, 0.1412001788915195, 0.761983017363135, 0.5667178120701807},
    {0.012717300429524406, -0.17456632699744407, -0.43198129431383775, 0.12025771097790117, -1.1908674785560647, -0.03771573575155743, 0.5191052300003778, -0.6735123212125819, -0.38161973792205867, 0.07701230430576743, -0.25040147926919837, 0.10261564137140727, -0.7163889655435046, 0.12844768879354243, -0.43049457223429444, 0.3887324673991792, -1.1470856588437655, 0.42537494366692286, 0.34296573545102865, -1.321775141995524, 1.1656040102010397, -1.0588836777667054, 0.4715875367317778, -0.18573509385524853, -0.08177896642964716, -0.2216430025967251, -1.1299285546435884, 0.21497047530807598, 0.7117400918209649, -0.7549057112663949, -0.9147245203947076, -0.43269921015836055, 0.3629305448112564, 0.22537509739668066, -1.184895939751291, -1.0064435901001165, 0.9694174483427348, -0.39586303899661335, -0.1688415469221941, -0.7623722927734107, -0.10618872671055199, -0.9789042404869829, -0.2486099333608197, -0.7159026221873959, 1.2745766166186927, 1.180053303448388, -0.5820081246840556, -0.15967437604626242, -0.40094200411485653, -0.46452292434912906, -0.810281474920221, -0.5306869262944413, 0.3334517563929181, -0.5509146928151134, 0.46970867902578683, 1.369501165359959, -0.7352667255476668, 1.4282439848127921, -0.3097975452337475, -0.564155668942183, -0.2532634977204734, 0.7800070930454037, -0.6704258577938654, -0.6625865173946989},
    {1.0592763025407572, -0.7525829939758271, 1.2003705988097557, 0.3459132646033082, -0.4581955885783612, 0.0934428454064914, -0.7215454840139288, 0.4922786876924166, 0.14944015892550946, -0.23530523072297577, 0.5327775676272388, -0.3907228169992972, 1.4026594582215295, 0.876698114651777, -0.8350916546558407, 0.21988762983486723, -0.8205184088890282, -0.22683152492765185, -0.9641900407955385, 0.4523024947816194, 0.8641194171225592, -1.0103106311186503, -0.02483194269021069, -0.7419143248530967, -0.5120371142854394, 1.289688987731836, -0.9353479168360096, -0.5985096071107051, 0.6717569009834536, 0.3348437211560191, 0.8479294936442733, -0.5097799755039497, -0.4947366636508732, 0.5569836974793037, -0.47904018562001527, 0.21633809373351456, 0.47388304972026896, 0.4832831406779564, 0.5030217956101874, -0.9917867331346362, 0.23227583085712813, -0.6571801767911012, 0.927326723253734, -0.2803418929371926, 1.1248504088261038, -0.10458816410702172, 0.4774555719256483, -0.39616600672688973, 0.8550605047337927, 0.23671749875149778, 0.7102516063107351, -0.8649902467850064, -0.5812124947437046, 0.8048727130248378, 0.5525251910302953, 0.36621494144567307, 0.7322352249451799, 1.1013977924673137, -0.05081842054683779, 1.2082084544405043, 0.15822123564734536, 0.9548748767649342, 0.8884047996523905, 0.6437448377358667},
    {0.10871753449122026, -0.4111738861705396, -0.5561379357923435, -0.2861607785651785, -0.20041357301572596, -0.6427355798371216, 0.7227826091182009, 0.9480528076427933, -0.22147233328185145, -0.4396122511589403, 0.4384609093739824, -0.9778191175009826, 0.3472661735391711, 1.2223635317340364, -0.8585387879616884, 0.9272146166245983, 0.49320153983912346, -0.7040017574426667, -0.3380124654314684, -0.6404826537408852, 0.13843685281933635, 0.24033961288482733, -0.7695801897170704, 0.04197257957445236, 0.6330911600023327, -0.0017422171459447766, 0.13733594365161775, 0.23234734111781888, -0.6122466204704015, -0.2456939141707945, 0.3561408119212928, -0.39958152744108205, 0.06099205650710367, 1.2637551787724943, 0.27156869799406275, -0.7195001082032222, -0.3514344792504906, -1.1105540952989397, 1.3129561359863706, 0.8283263346572507, -0.48220533934025417, -0.7725373325681886, 1.3307179954545045, -0.30550692176133953, 0.5145912016407257, 0.4110695564045789, -0.1383286051847688, 0.32229423317892225, -0.024535679904803463, 0.7949965600169795, 0.4702401003928862, 0.8731737175880503, 1.3717487962936188, 0.7795733593940503, 0.0328018487312938, 0.9009684831011182, -0.11312052669447817, -0.16441214619131544, 1.0500750810591688, 0.1620545545178877, -0.4432952272657678, -0.13284311475979385, -0.4755338878035025, 1.334513839785777},
    {1.4251545476704712, 0.62079663904816, 0.9467180840782786, -0.45842976869413293, -0.7883476904375545, 0.820589548215151, 0.967038549359369, 0.8872601769477453, -0.32549758327714234, 0.20452375107181175, 1.153396939935727, -0.15513348831515958, 0.1554005218842092, 0.7186740871176088, -0.106261148078424, -0.5628858899368014, -0.808629011518634, -0.4689567899135802, 0.8883491498173102, -1.121640311491518, 0.3109326709795658, -0.5108730772573339, -0.3830569340664602, 0.019609728899146386, -0.588591293124773, -0.59758468546201, -1.115121877637524, 0.6804059678850902, 1.378080523753481, -0.33560515369907973, 0.9203287015897974, -0.35834589569416725, 0.9860655937764666, 0.9608949308296096, -1.1977183613781042, -0.3761464589281807, 1.5916419369263386, -0.16080570639247518, 0.8419762812336589, -0.32360265401786187, 0.7354791322700501, -0.6105581671134521, 1.4049254449288364, 0.15332603747787313, 0.9928824503315143, 0.7579341631181602, 0.8334095880242343, 0.1374737898103989, 0.9069921085786854, 0.6445216819018511, 1.2161516822517435, -0.26676115620147683, 1.5383862941954354, -0.9658937951988686, 0.20166878675304176, -0.2630019373050638, 1.0346583907430105, -0.5917615052252038, -0.3683059220049263, 0.7641680669070591, 0.8995476957074365, 0.3777008072369216, -0.34479979493739066, 1.3363867962088365},
    {-0.1571850955655034, 0.9495950752511891, 1.045918878665442, -0.1901544844528644, -0.8639036954025991, 0.9470812521131746, -0.6975147110989741, -0.34243747015806675, -0.6318170641644498, -0.2782685573887352, -0.7167443941285345, 0.6269064217245338, 0.03325274894142494, 0.6909863366536874, 0.7948448585085848, 0.6302986097691634, -0.7375386778517092, 0.14464436706108508, -0.11370439826390194, 0.35218853580189985, 0.9566330007910129, 0.16001725636036865, -0.7997003737974688, -0.45930878899630156, 0.27261945809334315, -0.5538701740054761, -1.1127085872854674, 0.21895854522756075, 1.101299957566494, -0.524896689186152, -0.8333641045864721, 0.9383990345387058, 1.1725235348791336, 0.43240971862715694, -1.20174185125525, -0.5054795721909658, 0.5827751940971112, -1.1118607299894299, -0.5783064588220771, 0.0407837446880188, -0.7945654141359657, -0.8438478375153302, 0.31649713853245615, 0.467878313700037, 1.0309446645167204, 0.15623943544371294, 0.7916015816985599, -1.1974768220776946, 1.1972471867120413, -0.12878333208591464, 0.07634321539161114, -0.3940059492361898, -0.4930072311627128, -0.6376526408344888, -0.7765020632413381, 1.4045629366927708, 1.0058386140283677, -0.07136382016008706, -0.0956458508377685, -0.6364291319252012, -0.9739137799725875, 0.825651206153024, -0.8269754168116553, 0.8013232100516573},
    {1.425444508360521, 0.059151041758194065, 0.17187648752195536, -0.4573102559268414, -0.15618422803398482, 1.392934821678985, -0.8447708720305905, 0.25034146224654547, 0.2910059805215306, -0.8653405743433543, -0.5391931628059039, -0.5954053417701728, 1.2168315383053647, 0.5936461641647587, 0.40134505030809137, -0.9520350672773499, 0.03733657300215586, 0.8346246723971829, -0.1902866797177152, 0.4662295448452187, 0.9397099779778111, -0.4631124918345218, -1.2278291907415066, -0.17192028053113328, -0.1566883547607375, -0.6635926329328978, 0.43302897278539065, -0.768475407580283, 1.008996055706408, 0.4467981214714277, -0.251073157844036, 0.44633726687848546, -0.38212693059791225, 0.1348793138836917, -0.24651062330416965, -0.7918026906462531, 0.14944670655683612, -0.6368021281937811, 0.06831467422030557, 0.36933605377376366, 0.6251017848186503, -0.0021877275257994274, 1.381078838090114, 0.3323081274968185, 1.0615860674946778, 0.870829161221163, -0.12823724264288774, 0.31594497886326717, -0.28595247006843827, 1.490107632233037, 0.990825890398532, -0.6922735631248234, 0.17092741883517978, 0.029745731621893295, 0.5034203977854967, 0.2870395496069595, 0.2908532718942278, 0.28519028021596043, 0.22572196771110759, -0.028237531192319466, -0.4921042741144323, -0.4500959251109933, -0.7626415468416268, 0.4784947793481172},
    {0.9166956168579128, 0.02983231130015778, 1.4835652383031157, -0.7503299018363043, -0.7750961146178496, 1.220013727358033, 0.1805933040265327, -0.15298201448183327, 0.24874106874127033, -1.1207929294818906, -0.2903654335777816, -1.1644282388578358, 0.6967364070725242, -0.5503897807597633, -0.48110091507761366, -1.066377120163415, -0.3482105992493005, 0.19949126286925536, -0.008473203706460545, 0.3914979018817012, -0.21115506638977005, -0.2833617980316026, 0.6728626999064711, -0.9217463594998462, 0.4934772095767517, -0.1857933104539493, -0.05022533854161701, -1.1228857901559295, 0.8127826841273657, 0.8150774559530106, -0.7149396914561568, 0.24004629574120875, -0.30320812371515016, 1.2012674127483363, 0.02011930006425791, -0.4227992751858817, 0.3619837631446611, -0.5143839465064319, 1.3167277459058249, -0.9487104623660103, 0.5751216674580332, 0.5495603511115723, 1.2318212547984744, -0.48737761008828395, 0.6943144402042501, 0.5428877226326282, -0.2642428182795636, -0.7303976478299387, 1.1073819544514272, 0.8767135065535802, -0.023040741214038464, -0.5452659588719643, -0.46532251118107026, -0.19856056641227507, -0.4308644222036058, 0.2771265526857598, 0.6831040566354334, 0.6383723529804729, -0.15337685659100805, 0.5284712819836652, -0.2806934261393073, 0.7645025348657212, -1.0850297559352728, -0.05038278413301513},
    {0.22575867334007524, 1.208947523104465, 0.8631381063630982, 0.45619508640343676, 0.14232499584056488, 0.7806839453237326, -0.055644299933470566, 0.044559628313562916, -0.8649272060360356, 0.398731455706397, 0.4013696449371434, -0.4228677924581532, -0.16414888589693286, -0.5447037570094762, 0.6560789278095218, 0.5233905839926247, 0.6333157603800461, -0.824050983641869, 0.08123255434141141, -0.5906373656327638, 1.4079748245965362, -0.20509280673516625, -0.2790448283178249, -1.0562398578330932, 0.7105203365634443, -0.6800628570817596, -0.7433463670944351, 0.7861005207749295, 0.555137714248143, 0.45043966901123556, 0.9054323086933924, -1.074213643902467, 0.14030518364840802, 0.08178261175679286, -0.053171569344794896, 1.0410619015655427, -0.2579024052316805, 0.6571766785150119, 0.5134783812163719, -0.9624908473372427, -0.4466403736523432, 0.13452622055620592, 0.9794678436142831, 1.0714787705310163, 1.462421145367745, -0.3959601460755915, -1.015071292939903, -1.345568950719546, 0.192569803202912, -0.5751822412601111, 0.10452039086003388, -0.7417020290744785, -0.5227992050656725, -0.33153202478880667, -0.16587656922436603, 1.0910334511832576, 0.6714653208936296, 1.1045414549724588, 0.9017146945410488, -0.6982787915881171, -0.11493305498707733, -0.39417825663254863, -0.7193179510626597, 1.0367638870006926},
    {0.7293410742103832, -0.43888899194984493, -0.5702515078056304, -0.012734880115505089, -0.7183399576974611, 0.05766653173669129, -0.9062366148754046, -0.18569089600330613, -1.1672191435338983, -0.7803884182340007, 0.855842449014178, 0.5822265977473101, 1.259684136770329, 0.8031242278862966, -1.2303904160194739, -0.44717168186487827, 0.24416164033258533, 1.1594523420165082, 0.25894996347619753, -1.176589128473714, 1.1301112076726771, 0.3473384228257817, 0.1270880384558157, -0.7142457648770021, 0.00476598511665061, 1.0521945394736314, -0.8783764258601714, 0.7559035285206502, 0.8917967192183229, 0.19670377650605772, 0.37005852926575566, 0.20740134619781989, 0.06691030811996686, -0.4618062730567392, -0.33383399406291653, 0.9307094621185517, 0.3596808885820622, 0.5147724301296818, 0.6763430043558778, -0.817463817272558, 1.022578684695075, 0.5010969436340764, -0.08148364858686923, -0.06975516584457396, 0.7592501976069294, 0.8324679039725515, -0.060802517058045014, -0.9425721777408723, 0.5326496574238015, 0.7606923494512522, -1.047181075042255, -0.7969280058022439, 0.15159896867626782, 0.25922551203853, -0.5636666030143184, 0.49124199373432204, -0.8526786782479785, 0.81637699741019, 0.8030077709359296, 0.48966843989137737, -0.3202766112250091, 0.8450048646800351, -0.4879419068223517, 0.2573188607547224},
    {0.8675226705581841, -0.5791850359383695, -0.3017052359559914, 0.0786586127771313, -0.4767539016796445, 0.7185968834787534, -0.3630676047678008, -1.0248982700252625, -0.12029589364021097, -0.10843159395815073, 0.4005672803139784, 0.1525042860460575, 0.6490941958533454, -0.5145586520330343, -0.8072734555845638, -0.7948068491768028, -1.0285506351105649, 0.0831897505343356, 0.37957558914746276, -0.5251776462628022, 0.7343589561600093, 0.4235789926512907, 0.04851761305185837, 0.9544094142044605, -0.6467050182129895, -0.46702248899434984, 0.35897408166449307, -0.5097577406919879, 0.8194813092154214, 0.1257868243187269, -0.6775369777901091, -0.39329555421980317, 1.1706341029827756, 1.196070827474257, 0.12291324482338936, 0.4670767597723965, -0.11907712598890345, -0.8422823369929527, 0.3268018760927028, 0.536142773647726, -0.47697282767650234, -0.302660789679079, 1.195183303088603, -0.8590192647113247, 0.12226653500263682, 0.4289094424967797, 0.675413039051555, -0.00813022487387902, -0.7384577496519623, -0.5643389934051303, -0.5752206704049457, -0.6908263951591916, -0.2026245720299098, -1.1522900595341605, -0.40369653041240194, 0.5180203533820217, -0.7598339162963258, 0.9892196941536954, -0.7823251889112743, -0.6057855081844468, -1.167771043443093, 0.8149435813797278, 0.15814500572211723, -0.15323515428276596},
    {-0.22751121403908262, 0.7897424608356234, -0.39248049260906226, 0.18799912449876782, -0.9448591695522222, -0.267006222478599, -1.0786784606288446, -0.6123315620671286, -0.37951274618100894, 0.8567103796124368, 0.5747473836010395, -0.23902626191028592, 1.2440847193281501, 0.09382999480328993, -0.8644463770756008, 0.3198604036919788, -0.054344170367916785, -0.49685247765826274, 1.051991337780267, -0.47096788462335576, -0.12307800063347629, 0.14534591115223058, -0.22677643445174073, -0.2524408773530314, 0.42511852433253816, 0.8702272013518222, -1.2248427534342667, -0.5127955715451784, -0.30681198331156834, 0.6567944986922911, 0.7132077391406175, -0.890253503782206, -0.44106756887773674, -0.5818720712050793, 0.04109960885787407, -1.0047518438216931, 0.8077828551073298, 0.4618857010396564, 0.8066221732289892, -0.9235338495010696, -0.35027725095173007, -0.998076083363083, 0.30064300499116986, -0.20892304896006023, 0.009111544444955018, 0.12950576698692204, 0.5893394112346223, -1.0934291436387529, -0.5701039898140244, -0.1750505924939679, 0.9096222696893453, -0.5089188594047498, -0.04319471327927907, -0.011144485555692283, 0.8353136619376501, -0.49085346352090026, 0.17040789971498452, 0.7299901354757135, -0.9700787725051406, 0.7574626878955246, -1.0796232064899072, 0.43915383463780056, -0.5899606771049518, 1.0555706127767364},
    {0.6741378353601011, 0.7327716213180367, 1.2457467789029473, -0.8973159099657968, -0.7738584058438543, -0.5450585588352688, -1.1954679276243338, -0.7881249688946526, -0.7345789711124149, -0.3878774398983658, -0.49289868079426735, -0.5222444312247949, 0.42115065929402346, 0.032330905569295236, 0.5769757014831046, 0.3947823152306385, -1.0040415779303007, -0.32277140553943307, 0.6772931822268944, -0.8915460791300321, 1.0428855112947892, 0.27660493658005536, 0.5487642873100904, 0.5616927627532899, -0.40608873501285886, 1.071562771510368, 0.6782594312719971, -0.9033644848633058, 0.7536849015354893, -0.11878880466599125, -0.37404082196479, -1.2378350430191856, 1.2878276149261951, 1.2712293849808067, -0.5304553382814808, -0.6643065639909422, 0.5691071575482393, -0.7179507503394735, 1.2201980318802546, -0.9852967356174842, 0.3305916906780032, 0.8313442771204259, 0.6451729417893732, 0.7158086543306629, -0.4344297360058448, 0.40718899160960076, 0.33574860502588727, -0.1770942055353009, 1.2238207790542357, -0.05553521545944203, 0.15689000151792815, -0.9368276465532881, 0.461101986523952, -0.36602313875469, -0.4392179741532379, 0.9458292587886644, -0.3827743720064537, 0.3066953014058138, 1.0620547937232423, -0.029268886937003913, 0.7204653125978444, 0.8166926735160044, 0.791062247515186, 0.6227374892368294},
    {-0.5026063408870053, 0.612690503326787, 1.3512288113149606, 0.7263520921896471, -0.3373219689834343, 1.0056758870717204, -0.6586879902586485, 0.007493087571554369, 1.0791080175460366, -0.5434499977380226, 0.38063313645374375, -0.7705582933628271, 0.46906792646441414, 0.83167801963861, 0.18867615629733744, -1.0477094034662335, -0.8307306779969842, 0.6737547847444283, -0.5530990132680575, -0.4406368883105376, -0.09552774958929765, -1.2795056921077612, -0.14412439348394848, 1.03626953798709, 1.0939777428419069, 0.8627903625460049, 0.3170950291844097, 0.766755491088254, 0.999989409284265, 0.77317142585097, 0.1914974200077361, -0.1460257069555114, -0.03266085075834872, -0.04054380464290789, -1.0833050953977263, -0.43262761126968585, 1.4227349189164762, 0.4996651735245806, 0.24923565500777103, 0.0014365128698940052, -0.6842127823188932, 0.38640237318228204, 1.247899596986397, 1.1545912949133768, 1.0956843001626537, 0.21887303212551168, -0.8695831110610613, -0.30240330917790936, -0.3401947506719779, -0.5295925519763349, 0.5947429991992899, 0.7693778454141224, 1.5412044330890744, 0.7907524638385798, 1.3017973247194305, 0.27173220862820907, 0.4463086363264024, 1.5584469201630398, -0.5824016466312684, 1.1992232993862917, 0.8679042132945839, -0.16095090985291868, 0.42275291302509677, -0.309187318494994},
    {0.7613940594362146, -0.8046696856287117, 0.8562652379464907, -0.34478097231683547, -1.073217653786565, 1.110331244768317, -0.8261099534839104, 1.1241536939904457, 0.4922287654793477, 0.626575537181305, 0.3318011390998961, -1.1041448879805469, 0.08709630485925603, 1.2476076036642754, 0.5490365287500768, -0.9019964169851956, 0.8036132056555412, 0.7192724068590713, -0.9784167008694298, -1.180956664698553, 0.6288994795616119, -0.9858672856649281, -1.2572136782449528, -0.0858633723297315, -0.41836448209552735, -0.4882535908458521, -0.5708679870465735, -0.643186852740656, -0.3287268040763004, -0.7658137339905644, -0.17507141715232805, 1.0569414890767834, 0.2848764434448389, 0.8750863046478901, -0.9308321072390556, -0.6246719212993478, 0.2962239729831209, -1.1577530781983811, 0.2534631390364477, -1.0043592751336272, 0.5854871040072386, 0.5050609096886461, 1.534417666383652, 0.8767563073865571, 0.6660359201331256, 1.2006776475172793, -0.287753512213474, -1.0081568444219666, 0.5125140786468004, 0.40907168136438377, -0.1455374099316646, 0.1380444541790639, 1.068157820800394, -0.4546447476506753, -0.6696185760973904, 0.9838733149404881, -0.1720724374822891, 0.3455825351755185, 0.00188128165656672, 0.04252605417996121, 0.36143930091054755, -1.0284165040415683, 0.7198236410880589, 0.6279611279104566},
    {-0.46191896624600287, -0.04244865842398889, -0.26392456843893863, -0.08850726624328971, -0.20970175073890684, -0.5470525961556821, -1.0302549900832894, -1.0310954927142972, -0.03347017469026855, -1.0096775353116856, 0.9774253358491561, -0.5986080075250859, 0.652412500264089, 0.8219052801259416, -1.069281119344079, -0.8479637524666503, 0.003623689377052203, 1.152706059639148, 1.0692278061377596, -0.033390582226524, -0.3232294051535282, -1.0650401490522632, -1.3124121920540623, 0.3170626862815376, 1.3775208527809477, 1.2713554854415405, 0.3106107946803354, -1.1482811000450097, -0.1161422925670768, -0.07462661233107937, -0.1559505300550887, -0.23580214120989493, 0.9098632564047254, 1.236129459410347, -1.0009307684957234, 0.13287883965914024, 0.9218551251703571, -1.2105385628250789, 0.5387828353507963, -1.0848617252611077, 0.5171840088962874, 0.2801412046081271, 1.4621400543786889, 1.2099341605678409, -0.52791674993372, -0.6288112503934162, -0.9547378458327151, 0.34709771831046043, 1.0362889212603237, 1.4485919108579535, -0.6630230775722323, 0.42180947352052245, 1.5843996760573607, -0.8828400106821283, 0.3542824545928144, 0.3825878664372808, 0.48035299809452514, 0.43747615923416233, -0.5777877786594569, 0.3305525421872824, 0.904579531788996, -0.7922344266255509, -0.9039800144995523, 0.7615594223063729},
    {0.2649394033592238, -0.03242059218049174, -0.4785821092670037, 0.28393179700493737, -1.0667740875965521, -0.5971406234411653, 0.4303169453259199, 0.8042038232908489, -0.5149832007322053, -0.5133795121783444, 0.03160806248403015, -0.3946571338941668, 0.3940298071230406, 0.9639253318787555, -0.6564086537869916, 0.2995244457641241, 0.2240292606634819, 0.5865005635003522, 0.3909372963230962, -0.7421664266982958, -0.5560371230321187, -0.3857424682236306, -0.6227847319854161, -0.19856004173051714, 1.2501908612257255, 0.1609338660743584, -0.6374843729386405, -0.7519054851681265, -0.7454263740535558, -0.9376731654969753, -0.335317486992888, 0.10592814242516378, -0.891072885043575, 0.8764694248746137, 0.4091440463931231, 0.8301297532745313, -0.34130289856762275, -1.2489712382079263, 0.6490760917450763, -0.32980750301307066, 1.2799111716107987, 1.1383306173884524, 0.5870186529669297, 1.2025730898942861, -0.20753498858643446, 0.7507892806355995, -0.041421160113413, -1.1034249166162642, 1.3943944340420589, -0.6394389926178385, 0.00970490022459835, 0.5025871833510555, 0.8616325383076475, 0.4892117622374926, -0.5169161521089066, 0.4018548835781525, -0.7705182433699124, 0.5312657881861023, 0.3104169008567857, 1.1098809433603434, 0.03406207254776369, 1.0186047315733058, -0.3548167236416209, 0.9626433727024007},
    {1.4422091697926565, -0.806810423536106, 1.4886656441798618, 0.38612415744583845, -0.37916186863882334, 0.4868289369664858, 0.07515893721810386, 0.3650844709314727, 0.33645222630651483, 0.3230228384002923, -0.29942774483139084, 0.7725072752255502, -0.433246903184633, 1.0553419586019792, 0.08423448327825582, -1.2107626281848636, 0.056498711314534926, -0.5792913998939231, 0.4726331278459015, 0.13841461210407113, 0.9230157559941278, 0.8735265019086949, -1.3391458236941012, 0.12272197833162996, 0.21811301513989645, 0.8729608541741993, -0.266189968937572, -0.12515061400250233, 0.42633452175141195, -0.11493763917197523, -0.724028107183587, -0.02870108532409877, 0.8963950141107649, 0.9934079677145619, -0.21098921108175483, -1.0281936011766017, -0.2122057015417265, -1.0193983884169402, 1.2816922793324352, -0.6423812853757278, -0.6055425309795909, 0.019893880087493286, 0.18976166103677858, 0.044688770763113596, 0.03620129445083927, 0.23015832177707943, -0.9465654670636333, -0.23762670975771938, 0.43741134984432634, 1.1386986069247564, 0.10241077723509384, -0.5654844469346036, 1.4709406792076911, -0.8887951486799166, -0.5534675047914394, 0.4808175311116043, 0.6715783313922281, 1.4638607467266265, -0.266524771597111, -0.12744133909925517, -0.8821857737647322, -0.27394378007903974, -0.9319950144395773, 1.0404564621719574},
    {1.0773067135224468, 1.0420587369936922, 1.2945426326387022, -0.7767572754045002, -0.06415762085661156, 0.9880173617815416, 0.6664621124695633, 0.10008302219530513, -0.41988202610773845, 0.5117069437995745, 0.9435887648354906, -1.1712069171768824, -0.3589856165431007, 1.0115824508448885, -1.2757290305150006, -0.6106537289518403, -0.5471761342634479, 0.951663104065288, -0.04676249490552457, -0.888907892138063, -0.5985084107999548, -1.3421232105023113, 0.10523917664694667, 0.2752187969335102, 0.09117004193705519, 0.9816016953930615, -0.42252432468305035, -0.5350763682908578, 0.04956989253410974, 0.5550778786247139, 0.6155886112115313, -0.645741020764767, 0.1386860469054705, 1.5106931362825964, -0.20079919115579462, 0.26642980464778104, -0.5423769285749832, 0.6705407718583324, 0.39790115118473457, 0.6602421430849961, -0.35957631157539244, -0.28979672004218, 0.5400694528429081, 1.171796779834393, -0.3401363287336275, 0.22663587132761723, 0.49436160584640115, -0.6722512214017923, 1.1981524740048577, 1.4521731519222405, -0.40762963656997714, -0.5144562359622907, 1.2934345314207134, 0.17647971828660608, 1.1228906990966292, -0.35632391877789316, 0.6352407861278642, 0.005664342181679353, -0.7587511557626323, 0.9898552434747326, -0.4108641184634807, -0.12387238170561281, -0.021576002605777148, -0.7608829457370863},
    {-0.039462065884103587, 0.34797496135584566, -0.302659628502263, -0.5229971015400177, -1.1162790566673202, 0.07439100672389225, 0.8806931249596676, -0.17475193094420738, -0.1466441131789498, 0.45383126527999273, 0.5387226987523165, -1.0295477631243999, 1.1031846753394792, -0.06727830251103185, 0.027568574145973475, 0.23939814008466956, -0.3447872316975629, -0.3383425530535893, 0.4606628502874726, -0.0327641425523471, 0.3837934053143543, -0.7257803434170885, -0.6776697154378172, -0.41933860430500863, 0.5658230519704034, 1.0307970143770675, -0.9158042279363142, -0.5212418271772069, 0.8991921774965062, -0.4402538349664154, 1.3477374881708937, 0.4585177426664449, 0.847540581312115, 0.5229195655668206, -0.9941283686334142, -0.945788995091583, 0.7531482909589321, -1.223470933109225, 0.8775638342517242, -0.6088822806957861, 1.2238662632916921, 0.21525210839013195, 1.0140175971408667, 0.1511697143889345, 0.44267457747063943, 0.8914938214665757, -1.0369321928613244, -1.3053913391014553, 0.8284488452601445, 0.2806435125285527, -0.7866466378366846, -0.20409538904693095, 0.13659053627558007, 0.9276871119173163, 0.7406240408873433, 1.172602207128831, -0.3837131393897949, 0.14729314832148288, 0.9375808930439562, 0.8074687479377389, 0.2673887038564415, -0.06992028043631536, -0.1782644015582239, 0.44367335081171533},
    {-0.08532710050628435, 0.11907238667278422, 0.613405656772816, 0.7314851159252905, -0.9315342359366975, 0.6742466296917579, -0.9945616582629949, -0.5405324328700606, -0.8833358939645786, -0.07686282957147395, -0.7068151045394827, -0.37495063234042697, 0.1961840956315631, 1.2291799806764718, -0.7527780335805594, -0.22594431220642328, 0.619083667009181, 1.284827609848155, -0.060104167625270065, -1.2710264949376162, 1.2873767773123685, -0.800804368158502, -0.6662786770588245, -0.5062025030366537, 1.0597926026050355, -0.13109904728825447, 0.23277513278753642, 0.6741634476490249, -0.13403502868143943, -0.6549871120813723, 0.9605085111226285, -0.5447388045286677, -0.11657081702732651, 0.3209941243931298, 0.883171771008969, -0.9511479886593011, 0.4303826723599428, -0.43380956917321567, 1.515924813487097, -1.0120238289924819, 0.33672952082156976, 0.3003133103674007, -0.422596542821698, -0.2842231132956723, 0.9661981983504567, -0.2014992061113481, 0.041906498620954614, 0.37574037447636555, 0.11828709466041198, 0.33916332677192085, 0.3053066214329578, -0.8006506693493645, 1.3455962905390877, 0.012627937953595052, 1.2494848255397328, 0.5227939038927788, 0.36635512447503615, 1.2752127090885028, -0.7587553050382058, 0.8502931797244256, -0.6579593478075871, 0.6859953564895883, -0.13478685532790788, -0.29496347343727103},
    {-0.39293084842068204, -0.6302503193537325, 0.4319005114634593, -0.32370831315002774, 0.5211038948663698, 0.41265999124516806, -0.05210611493585689, -1.2222272645511185, 0.5333427678563409, 0.45583816719807535, 0.7750469506416386, 0.5616429450418868, -0.5260651973104264, -0.48858965515411706, -0.5558693036915663, -1.3813117227619462, 0.26678909430637837, 0.0019117748214345026, -0.724104861953374, -0.30161619327726086, 0.33130143226675035, 0.449090525016022, 0.09331731839246618, -0.5321356151176057, 0.24808411546161593, 1.018735696232019, -0.07904831668987597, -0.5345144899967743, 0.315538953858097, -0.36193817840693504, -0.6597440900757965, -0.10004004731350885, -0.5632735073689469, -0.36786463416159265, -1.099056825312186, -0.7878635837258561, 0.616721514498403, 0.5251878480256663, 0.9923874287459561, -0.7862783812950597, 0.23270729352074018, 0.7464751539623851, 1.209951974906406, 1.3443798728037528, 0.3712396493059612, 1.1844163975590394, -0.8797329654594087, -0.8944682061407939, 0.3731672443522206, 1.351603547225792, -0.4594807223454885, -1.0766854296815624, 0.01938607076263385, -0.4642784877353578, 0.3623432392892636, 0.8778625969246158, -0.06295472360254495, 0.18459629389489485, -0.009929216038857148, 1.1754212554766688, 0.7736270002289595, 0.8601526652641592, 0.8229729706405725, 0.6543019545936457},
    {0.7487012049348638, -0.7322641491502672, -0.27591139457229324, -0.3456146663447009, -0.04236123770434154, 1.103318072749412, -0.9677744958714835, -0.9885866327179148, 1.0771635349526576, 0.2222201259970231, -0.03269196038197309, -1.3736902743080541, -0.17511748592594342, 0.6171754045033985, -1.0879048208259885, -1.4135711862680955, -0.18369224074542648, 1.1937096789233417, -0.27982087637234204, -1.0229669119754021, 0.5715125150683056, -0.9760474623173988, -0.6838917356890074, 0.46192629796189405, 1.2247358182361756, -0.36206601986785136, 0.3237316271725443, -1.1761049488698416, -0.6229853972532419, 0.25496158884273346, 0.8018601643156096, -0.34690630496148545, -0.8664223195909678, 0.9672944537423589, 0.35589000788965786, 0.35625167900760984, -0.46334959173550433, 0.17482287513155204, 0.16613415194486594, -1.3375117656470166, 0.5019825623006693, 1.0107382580038475, 0.43855666847294517, 1.4600144203308008, -0.6613967434210114, -0.02532348724583949, 0.47935902166182504, -1.2530774467194625, -0.5826432137120392, 0.41293820856956237, -0.8431685457534096, -0.38437557443775483, 0.5430070258302025, 0.8735511065946859, -0.358809873993171, 0.8993678015715806, 0.588283523663018, 1.2612243772315133, 0.7402138747459571, -0.5771087315993738, -0.3242565389487441, 0.008413228731501953, -0.7095557042100069, 0.8213223191466692},
    {-0.652433330574629, 0.5204127288208905, -0.27447195861202606, 0.10606637224938176, 0.656880526204172, -0.3084437440302215, 0.5848026052035916, -0.5325378607934431, 0.18560291713350835, 0.29996787015892207, -0.5673822116178612, -0.19664625647159592, 0.022048087622683562, -0.091104789429511, 0.4615024169951088, -1.2839824529339068, 0.03403748082666216, -0.41230629942760294, -0.47352167999558487, -0.9133647527723978, -0.09769841485772449, 0.6707379428979628, -0.3023413181134999, 0.6706919659472357, 0.6191239584666607, 0.5589380684524922, -0.2876709485700733, 0.5837063745558317, 0.15983202320116963, -1.0449469092344517, -0.4012394757686633, -0.11008860298206195, -1.4511162261707409, -0.31819175004801753, 0.9145015843571581, -1.3269545230726918, -0.36579322226422845, -0.33556083877130594, -0.2200081939570006, -0.3176134392262505, -1.1241926072350235, -0.517036490597032, -0.8586764069296294, 0.630230135520177, -0.04434602435512056, 0.29737244932030127, -0.6678510541023713, -0.4302384354485572, 0.1927237777824572, -0.4893183258416662, -1.2813142622556914, -0.1699212816567013, 0.31741308337668017, 0.8546487759506851, 0.8989193355173757, 0.7246830688768628, -0.5197818641682023, -1.2229368167363293, -0.8520698028395789, -0.4966658039772821, -0.8592205196833985, 0.5691565067343228, -0.8877087721007005, 0.5625526748175341},
    {0.2370134738748945, 0.5273944488791216, -0.40390627358552006, 0.02494964675597398, 0.4176981943667408, 0.5778132422066165, 0.20559010491338786, -0.7498868634142976, -0.17109555179551306, -0.9291394968012029, -0.33309705390725636, -0.9264700302923942, -0.312804075687685, 0.5652942205815569, -0.8148092362012321, 0.2678706566558038, 0.5254292625030064, 0.5740606253831657, 0.4608621246818115, 0.31193669950733444, 0.30849456246391443, -0.5866709669394673, 0.8347431070208935, 0.5467563772092219, 0.04354572807440427, -0.5891762855794589, 0.02905822941564114, -0.43053437170143855, -0.5376026271198909, -0.9075021615074356, -0.46211524423392364, -0.40581065343513456, -0.5253723860014272, 0.7672975728266059, -0.3170878716762251, -0.8269264025062522, 0.20731032932287527, 0.8918205193297073, 0.37071473374180447, 0.8363295981110379, 0.6166593340971611, 0.6159958619661418, -0.12951954902954976, -0.6307734198530361, -1.1843251275753135, -0.7245649760917623, -0.725397617572597, 0.17249640190562449, -0.7704501235912093, 0.641469815251575, 0.03942982939550308, -0.7981420625055702, -0.6859350742490802, 0.820871574202498, -0.05260450401697655, -0.387507977634138, -0.01332340965981875, -0.7496977807925334, -1.0316760079633478, -0.15153532571138684, 0.5921717626813439, 0.3225165109890719, -0.7767601810591143, -0.8690105800040957},
    {-0.30384285888920537, -1.2614174707709673, -0.886714232331224, -0.13934135970113887, 0.537950419043335, 0.7466160244158778, 0.1832630442569189, -0.32740885140015713, 0.11228141899266895, 0.4196215769243929, -1.34765944752927, -0.3989126463063556, -0.23167086570322046, -0.10435610295309942, 1.0231165109827278, 0.8966126381009588, -0.5876731794346218, -1.1305939431717247, 0.31602088805769435, -0.9349002825558707, -0.12459745379687176, 0.9970034804340792, 0.05763642062302766, 0.2347554706474107, -1.2035232896540031, 0.15981913319997296, 0.02668908527092852, 0.0007310120710023755, 0.40292159008528866, 0.6482092973748674, -0.13531689615796927, 0.9381303966573327, -1.4439415148070542, -0.7736554488416301, 0.9330338968182185, -0.8538503649707007, 0.29365355100233503, 0.6514936653463955, -1.0268229880108999, 0.40625775907219297, -0.29377604395900503, 0.6496384952609736, -0.4933127615021794, -1.0909750861294452, -1.5304618234768412, -0.1503268034209613, -0.565332988581897, 0.04370151197740152, -0.5760629694473501, -1.4820133662188337, -1.1686684119876498, 0.4762190344497665, -1.4959584122530816, -0.709940747922952, 0.5412284495603498, -1.1712688736651946, -0.46533515504237166, -1.1500905893552504, -0.7333277179356723, -0.39592148469415134, -0.4815061764388288, -0.10600098472911917, -0.393783775039119, -0.08879032451961939},
    {-0.8159560895271546, -0.962359624282831, 0.782827548718, 0.9515886189158443, 0.4651644291594072, 0.6270344466487137, -1.5075627374802583, -1.2812050412546503, -1.0276212815186647, -1.0922367408860354, 0.4885996276602786, 0.9649357524930584, 0.3044660505492593, -1.0970250283339267, 0.38729341349960694, -0.06285043691204141, -0.9208430276538522, 0.09833835607210607, -0.7634717040415743, -1.1270479612052426, -0.7964487598312976, -0.8277654273437026, 0.14758810841900152, -0.6651821972683968, -1.2437189939644409, -1.1243098074647573, -0.7668511503669293, 0.33513696948836247, -0.6873056173216643, -1.385328730169441, -1.1606440600593517, 1.07602640058036, -1.4079301822539194, -0.6485739236234819, 0.7826791666494484, -0.05305570237210426, 0.2428269197074913, -0.302171068513597, -0.5546982985759262, -1.0535871940246537, 0.3158239207300618, -0.5221089075687539, 0.31476542535858726, -1.0451226593477714, 0.2749152296206046, -0.5441695827527994, 0.96229341008151, 0.7737270236944511, 0.08747149548547192, -1.5388171941409525, -1.0440370866075686, 1.0123236764813641, -1.3434503616727336, -0.9623907759276835, -0.49802850156971307, -0.8862373330173774, -0.4670963873990921, -0.9765627767255483, -0.7946464129166038, -1.1319002212705094, 0.2662162476354012, 1.0379458255093454, -0.7098348866787539, -0.7049946036244801},
    {0.5524623743385024, -1.256318612526738, -0.1557824329659636, 0.49807261692218463, 0.25994555459525276, 0.3604616667062476, -1.4488672232308002, 0.0557428570672668, -0.8456335987215664, -0.7049697360691608, 0.14774388220967805, 0.7633277342484525, 0.37652929207849345, 0.36446529356552737, -0.6683455652134719, -0.37821945371497206, -0.618125308934969, -0.2189042300488083, 0.42213307269982997, -0.6065363441794911, 0.49517174357242477, 1.0168077225106922, -0.06296919700612105, -0.8607049427653234, -0.3632131232345849, -0.22681825391020788, 0.3423869866312278, 0.46387685716835864, 0.4785071045994703, -1.0917338449513387, -0.7232141364023776, 0.03649489666562056, 0.4404023960502331, -1.2260816737793288, 0.33940332372704446, 0.7548564748670785, 0.3921264758749337, -0.9478659138060903, 0.6078962342124782, -0.16005751241368885, 0.451241256457747, -0.7679031674406832, 0.20501607117261403, -1.3387194694466877, -0.4158970058346732, -0.0614612921267307, 0.36531742310412507, 0.003641444215401338, 0.8417993701311812, -1.1252002280579858, -0.377102794636754, 0.6383132231516907, -1.0833000976639695, 0.6804992349125045, -1.1646266720011658, 0.1631641625638226, -0.5354030828241495, -0.0703847124600868, 0.44357902729238624, -0.8016866026756809, 0.8565569381765386, -0.42737502347674017, -0.8710746876377425, 1.0722003539670828},
    {0.8211828082629479, -1.1418676652962068, -0.08766212874042807, -0.5543117278482604, 0.8527777200702702, -0.8167020046836101, -1.1703084633912801, 0.1821767707661862, -0.19796503976319524, 0.011344037423987171, -0.04958851615092367, -0.7827584405437567, 0.19136845896715662, 0.28848871878778154, -0.1025440164135239, 0.4257620809031179, -0.7859371606047473, 0.5097583679082925, 0.24623251128218454, 0.6371132060466647, -0.9739189683389499, 0.296064200931724, 1.0266942976320899, -0.08559586157687593, 0.6301761955038053, 0.007643638316759754, -1.0003202128289497, 0.28242454219179536, -1.379095954363101, 0.7744486060183621, 0.5233427658242727, -0.6669782835496166, -0.11198574600929138, -0.001817210666074368, -0.23922914335805426, -0.2120761769276346, -0.3850060038613553, 0.262647407960877, -0.4462602115415714, -0.3104223895795569, -1.308431432934009, -0.6912597840664638, 0.5753940310674426, 0.14196020046016947, -0.9809954622636486, -0.9750131170987429, 0.413670678941737, 0.9396124859873813, -0.916658222201568, -0.07245065029287329, -0.22853485207105398, -0.0956890477149742, -0.6985733856182282, 0.7342880963136794, -1.3826186968657668, -0.03134796302928108, 0.847776039570055, -0.15419182315275692, 0.43703135320086567, 0.14490383343693192, -0.20495197561086825, 0.1909498453547236, -0.9575811992318306, -0.5207810595410989},
    {-0.9471648820787576, -0.4697682359129149, -1.4491707329418735, -0.4046891464707796, 0.9493846387105809, 0.16406998711944779, -1.3108257644780146, 0.4222335288649683, 0.5397238297234861, 0.09734651170394232, 0.4526974550810859, 0.23369466040384038, 0.0020605147575380465, -0.3139568645570887, -0.28123914765490066, -1.3920870653935729, -0.5716301065225844, -0.27933253520683476, -1.068448909153617, -1.0156627665768485, 0.5201048232646525, 0.626645222717995, -1.1715452339254342, -0.03919153113094809, 0.2986224017245903, 0.6855332567209342, -0.49930751520861927, 0.7435007629475148, 0.2963951862578553, -0.9076997937361364, -0.2425106051687989, -0.8507392765154214, 0.5528685347508204, -0.5391568712746072, 0.5787492664938494, -0.7812151387913271, -0.7215779382462476, 0.47247053952876067, -1.019196332762444, 0.37175326264233866, -0.6607734864763839, 0.719943099058217, -0.8885336630829522, 0.6131348195456696, -1.217320480089038, -1.3310204639310996, 0.639171477251029, -0.543646585984419, 0.9230935501643649, 0.2844793028125027, 0.6434069712542897, 0.47967869433794963, -1.5408144270333897, 0.6576608863236469, -1.0721467415772041, -1.0923841759068469, 0.37925548823799893, 0.22936753346988556, -0.48892681826440504, 0.7035859738757503, -0.00894096905777449, -0.4243546205478313, 0.3366519064011817, 0.8387821673390877},
    {0.5055314224179973, -0.3140944205086732, -0.936222719989377, -0.09710256924828813, 0.7850332737516549, -0.7455122819019697, -0.013129894461911179, 0.5126477646966906, -0.9327179456595522, 1.06804965935577, -0.73408515699472, -0.22786710287253978, -0.4811286088241697, -1.184247676758364, 0.9891934993066708, -0.8739436147403019, 0.4354410748598587, 0.045476952432506476, 0.29990501381564577, -0.21076466214144937, 0.9627634174751739, 0.7176387985203272, -0.25441880917937026, -0.08092088999283856, -0.5872986193799627, 0.01659592331713047, -0.23106225941712016, -0.33788590898885656, -0.4123321442331814, -1.2430738022399335, -0.2555555350529019, 0.8532305938078487, -0.8685942860557779, -0.3977614035279128, -0.36942970041326223, -1.177526141601082, 0.36265212078494236, 0.9311575906510188, -0.917084823713854, 0.21994949711062264, -0.6273702536877934, 0.39086487195734354, 0.22024382778880616, 0.45072577924403945, -0.8010420991304089, 0.07259967221729177, -0.35702851214259235, -0.8212963553577315, 0.2216937357338488, -1.1398666085120355, -0.8559615723009536, 0.12088597848910423, 0.46528178628883504, -0.8238509468082188, -0.04593895243096473, -0.37470444167730255, 0.5880757582183208, 0.6366094116584642, 0.05245075286361242, -0.72245804147162, -0.6117457635338543, -0.011077247701728105, -0.6929231255199332, 0.4475218850047444},
    {-0.0184748777376974, 0.02210224233792457, -1.1923093691924826, 0.3036073151240846, -0.4981653143729008, -0.5877299563786985, -1.0546048861831445, -0.5507383718399813, -0.08252162725383877, 0.9559630766359201, -0.3173562529141505, 0.9005941122106844, -1.24479704769545, 0.05119816082702043, -0.3276147477364698, -1.2020074084782897, 0.6000152494497829, -0.9951055427601797, 1.0660337660026036, 0.14940590420681857, -0.9286590162261195, -0.17037380369646946, 0.4491263561039748, -0.31593641606550854, 0.6903349365183571, 0.073415122381509, -1.0185424491755177, -0.7118561959303566, 0.290355262849197, -1.006762525698214, -0.7680390726170809, 0.1398049877845224, 0.9099485301680291, 0.6405754126291768, -0.7816735380666262, -1.1176175222721576, -0.5199808071976788, -0.04532556921004846, -0.6633704585419733, -0.6502694319977614, 0.2761746756960049, 0.6286064066393817, -0.4498199855692845, 0.6579380081561077, -1.1471912888861073, -0.4799785120580547, -0.578082301836424, 0.6170999349207417, 0.6642271056828931, 0.1493414335526082, -0.49294589885721707, -0.4501038426524158, 0.1182533483618633, -0.796365088492667, 0.35912297917999836, -1.1838902454344158, 0.2951309153498652, -0.49641850117351927, -1.1326202781377201, 0.5640740810723149, -0.41384534742920615, 0.2982031400537458, -0.9642597304381693, 0.22137736558363247},
    {-0.4551658590346632, 0.40042428264811275, -1.0792661858107884, -0.8104731190197161, 0.6844936498092747, -0.4345181061744405, -1.3263523951441263, -0.9804733385615374, -0.8638740092868716, -1.014707718039325, -0.028124636362273255, 0.19799708182529566, 0.07097047813048835, 0.5997334445423219, 0.9551317545179946, 0.6836663102809529, 0.6724381576409879, -0.6403976187735395, -0.3856385981012785, -1.1788843665491175, -0.38377857117791186, -0.8215147506742589, -0.5583439496352466, -0.49327870465775325, -0.17066028713152478, 0.9460937078412659, -0.3284782346694765, 0.9115808190891349, -1.0432563427220045, 0.8518503630957154, -0.3031099128285716, -0.5110014897671161, -0.7240919551003784, -0.16764082624389007, 0.49345022597396276, -0.6791789985291018, -0.25172404893658273, -0.6153556955180912, -0.16943583927800038, 0.07385142011953971, -0.4540783878270544, -0.3030250505401393, -0.3101516721930312, -0.6548636973833184, 0.5831780063068766, -0.11780314997521509, -0.3990657831457697, -0.7173449535231626, -0.0030959688124539094, -1.51198173106136, 0.4956972888006286, 0.6725131580041357, -0.05209849148412058, -0.8127485866407684, 0.6370325921441545, -0.8357559513844098, 0.8847510318960742, -0.6156908257804511, 0.5361813178601975, -0.6235683037047884, 0.5925388869270567, 0.24900882227060073, -0.19053735465581492, -0.6489754233841007},
    {0.1455129593105514, -1.0756952442263912, -0.9130973967985073, 0.7261752845110208, -0.7422585458368529, -0.8257899465784543, -0.8153758640378871, -0.5505904582882085, 0.08082739256373471, -1.077688794073608, -0.5627210725612832, -0.6903240799660284, 0.09351057132006671, 0.8194171275815022, 0.2606568575775901, -0.3793145493207104, -0.6351737772879898, -0.1813232635545291, -0.49793863254642, -0.8789256769364696, 0.9943210387236995, 0.35900495985655667, 0.3554439494745126, 0.8394924350237728, -0.64489134406896, 0.21062189047976604, 0.46857698880841037, -0.058141137577608096, -1.3726170081896545, 0.7161174457053615, 0.88297038866633, -0.9055169908372556, -1.0396986788717568, 0.573132888603357, 0.6668829457960761, -0.11477553759900051, -0.8257923568414941, 0.718853568532186, 0.6787771847546576, 0.349380340346435, -1.397911485098021, -0.0057247190608845895, -0.43589538169006714, -0.9333254972089653, 0.5083743488358605, 0.16562130501498193, 0.932797072049651, 0.2162900408937741, 0.37305568556465135, -0.6668313818972096, -1.0385604121319378, 0.5939942339878616, 0.48485188000027785, 0.7016615083381145, -0.6534069033477532, -0.10861505836487216, -1.0038272960560062, -1.2941148208982645, -0.7552046844551561, -1.149865759745924, -0.6714603044336513, -0.06880556009142688, -0.5703468440025327, 0.1717538324331489},
    {-0.3564461499221512, -1.1285751805741076, 0.4314002313928013, -0.2669983773020983, 0.8859099670200077, 0.9274867596544887, -0.027752501629835422, -1.1041515589457556, -0.14483373558695148, -0.8765246724520513, 0.44539614433239255, -0.701516641285856, -0.9067959568624702, -0.14344826732529878, 0.8040579233721287, -0.2878753645841841, -0.5908178836995491, -0.00893120468995626, 0.49884970466095857, 0.31311874807870305, 0.7860476336278488, -0.5591170386736403, 0.08241126243764382, -0.5906933844168831, 0.4528815081468744, -0.6260370013656738, 0.6634925035959441, 0.8988792594142334, -1.4463244294427386, 0.06600568204063685, 0.30465653279959015, 0.7949726536561645, -1.2768980156470768, 0.728506376755601, -0.9576075055559257, -0.49442499069778684, -0.3946323591518047, 0.27876216115344155, -1.3321423069897873, -0.10329440378152599, -0.5554271812107004, 0.05199051173458671, -0.9640137547132783, -0.1305762185300426, -1.383330994832495, 0.6152399774097189, 1.0733650762109026, 0.0964635918081442, -1.1346194399750198, -1.0453402806698122, 0.6573014006999788, 0.34522729063907115, -1.0863279228024403, -0.46397995278315896, -0.26444519955012835, -0.754789170617672, 0.9750890778378102, -1.4118323418720027, -0.06671203003881908, -1.3012727221097935, 0.33210434933852645, -0.22700558386438582, 0.23750441056839824, 0.18876082577443262},
    {-0.34065328520277866, -0.7896467640092294, -0.49281521571027126, -0.7043070852035371, -0.07400033085749488, 0.05993021286345155, -0.26094455620617313, 0.03741121539286775, -1.2316746260537954, 0.3994858775839875, -0.6787231881620791, 0.713337542651137, -0.42765870993285693, 0.552739115111295, -0.8194391880517053, -0.3064138041086351, 0.27557414713904443, -0.3650206851301967, 0.119363795724601, -0.12429336158986419, 0.33649973924447646, -0.112226268115515, 0.09958648342168783, -0.3058688866071094, -0.7613741610157855, 0.5135618566717973, 0.266374593468858, 0.8283810009576564, 0.47555359143510595, 0.2185314644023235, 0.07828864644526595, 0.818235860906757, -1.0729903064669093, -0.22715395096519644, 0.6329289057397433, 0.04813943477770025, -1.2001636267772455, 0.34528199019218886, -1.1020403770330731, -1.3899447823056366, -0.2255009814729734, -0.8030332447104835, 0.7351297355153712, 0.6637512103740896, -1.251724387097851, -0.5102930563988808, -0.7462874785645832, -0.7474528028148967, 0.9493790638255847, -0.672713707161678, 0.2069001097657983, -0.588234151612463, 0.610273625396287, -0.2804514913623485, -0.5605767977487712, -0.5717704437976071, 0.6770367108731832, -0.05382438174472268, -1.1593091863086236, 0.18874082859279392, 0.1882057564461711, -0.8684288034503199, 0.9778732337071164, 0.4124837271718606},
    {0.1511931124215195, 0.12016422907400473, -1.0724086235817434, 0.38515002199829407, 0.4659097442978129, 0.13626478441997222, 0.15662039220074042, -0.6621101628264485, 0.04884355944362817, -0.7848995458179613, -0.01592928338724205, -0.9524279475400462, -0.09827496028557715, 0.12107959767004771, 0.836351843436527, -0.09419220445738267, -0.3776191701796655, -0.9625120185765705, -0.11973130779871824, -0.12849954394585025, 0.606208498586715, 0.17227825539278632, 0.2413731550292022, 0.6530604991961904, -0.20061960938305465, 0.8118761387115353, -0.09104954318233338, 0.5046970910587174, -1.4576052743898364, 0.5081579358751555, -0.5302003233195473, -1.3272333069616176, 0.11226826665688937, -1.0276321502955172, -0.6540763031685056, 0.04109914115722879, -1.1471213783250302, 0.777890423546426, 0.28933010821075134, -0.5341162707028018, -0.23716442914218164, -1.1555129261499006, -0.5102521335046771, 0.010071211397102812, -0.6006313267013023, -0.10726543008352797, 0.8026947351429311, -0.995207710336066, 0.11532417387334613, -0.476955980045242, 0.3872839055824248, 0.4183348187969922, -0.03402141993735399, 0.7554289225343949, -1.3673086448396765, -1.2492342140730424, 0.8218610393077777, 0.22313358791480645, -0.6913876332272665, -0.15960196834356705, -1.229480085022087, -0.5556676613379642, 0.9369810528116188, 0.23818157004366944},
    {-0.9219161405138435, 0.49513996804085064, -0.3430672991919379, -0.1297278769573157, -0.3939582179027427, 0.5524131879354438, -0.027776863360552028, -0.8291686027334394, -0.9068837859861252, -0.5225939687193623, -1.036019423704957, -0.2177482279820376, 0.5807576639844656, 0.32922813662718053, -0.37374012691755804, -0.6171213000904602, 0.7998883506513721, 0.11821020273147846, -0.1589406860444436, -0.8167619697741849, 0.4975358595715336, -0.6856949554312741, -0.0782859492984697, 0.7571221623862358, 0.5629203731816118, -0.9384721955074666, -0.9708225349314485, -0.610392655280516, -1.2602952833321386, -0.6320712105054184, 0.10114838983814195, 0.2595966159762771, 0.4433427584204393, -0.3322044357454741, 0.5179043144802224, -1.0115906474630583, -0.15649350059746334, 0.9298186394699874, -1.0427954407636744, 0.5240515255413064, -1.2583094350841324, 0.11261763554969871, 0.26061180196173056, -0.781032580656705, -0.9255112334868976, -0.09589465326966408, 1.1572388215516856, -0.2302817507007798, 0.3342117468631109, -0.1771867706678386, 0.4454114664904823, -0.43553274929385405, 0.1057744035540357, 0.6671206836736284, -0.5435971766977089, -1.1017450406230986, -0.19261990533539286, -0.8997573653349898, 0.23049912590860075, -0.08166003534097928, -0.07953206947335377, 0.7504935751154908, -0.5575809839476072, 0.7554167117313136},
    {-1.1036351274687692, 0.25515107684742794, -0.6812820386627362, -0.6080859685852752, -0.7518017018606725, -0.7268817553286815, 0.19533113925943593, -0.6412572832242672, -0.30367967704752424, 0.8325489263505744, -1.1995097852284378, -0.39758296065210347, -0.9848340065049553, 0.24809919013971699, 0.7257555257663597, 0.27582317481797125, 0.6752290581680362, -0.747442126897714, -0.3116325115313331, 0.37047647102715997, -0.8194592479285903, -1.18497891336515, -0.2562855849172713, 0.5898175582556692, -0.40713353676736286, 0.862452152603246, -0.13622577737426692, -0.21714937313765192, -1.1045947084126324, 0.014854482978565217, -0.8636111263897984, 0.4834453401644969, -0.38264402515499885, -0.6996474488436869, 0.6504537875228128, -0.6794233849681843, -0.5555986320713112, 0.23404498471255725, 0.16847146418738485, -1.2652737629036113, -0.815715582325261, -1.196053645819618, -0.5850230269023837, 0.8328328634691111, -0.6350977371652197, -0.20652094449223468, 0.9789930498430798, -0.5561231915551141, -0.034470635774805164, -0.49850130519640873, -0.07213643827387925, -0.19000877008604292, 0.318942429971871, -0.9615556514607894, -1.0900089446894554, 0.7467283857656414, 0.5283051402091682, 0.5828767457736554, -1.2456596557024078, -0.27778070602508553, -0.983731963502698, 0.9982090438393373, -0.001681541880260705, 0.6867709825125158},
    {0.5773752659902666, -0.48969002483402896, -0.753041680080867, 0.31258770284103304, 0.7121638790366633, 0.886995534318793, -1.2117015879813018, 0.32161413289074653, -0.04934888219806398, -0.7374269351446616, -0.35678475498300627, -1.322109376791558, 0.5773350942977625, 0.07709623472276797, 0.34394272371751833, -0.4644443431908943, 0.07941629241638073, -0.5170697480652563, 0.1110579817744952, 0.21483545500877385, 0.7458756755597392, 0.23598186835593002, -0.22404353482497852, 0.508483959481813, 0.8449854748740266, 0.7517554115618861, -0.23620613182280273, 0.19844751368562263, -1.0330983343336857, 0.46467972736148155, -1.1316248595937581, -0.1719109591677851, -0.09954244394510829, -1.3562379612285616, -0.3761351764175764, -1.4278765813180059, 0.09119271957745066, -0.22891383302638196, -0.4501604591322706, -0.6478260165985332, -1.4646549641971525, 0.2306393876633745, 0.05465404048209229, 0.7452010905074181, -0.043747765603045996, 0.14614059440571242, 0.426175983037129, 0.8613937260419455, -0.8135705834510738, -0.8846229446737583, -0.2099890163015069, -0.322693438852087, 0.1675459940056338, 0.6733078455528742, -0.12458494369578264, 0.35089759834750356, -0.20950933850542033, -1.324199135060321, -1.408755897601007, -0.7561410920407057, -0.9577933194205982, -0.379727386456452, -0.644333257845486, -0.7108076642051706},
    {-0.5291032218739762, -1.243207362931899, -1.0886427839716482, 0.6377170179248033, 0.9415159868745664, 0.7512703731829663, -1.08073398365207, -0.5898732542287712, -0.27801919096003685, -0.5980988455250349, -0.12589919830293525, 0.022130995227802333, -0.5603186926299295, -0.5690391802441461, -0.16754190745444722, 0.39299493529468255, 0.3027219269925933, -0.012845819390235557, -0.9300586339436672, -0.5116397263852108, -0.20626845108549227, -0.8264730797295491, -1.0469180865637853, -0.22997564486864158, 0.26177406708892687, 0.814251300006925, 0.08715943214069759, 0.749080198508607, -1.3020120631260774, -0.13938448954449875, -0.13282469202065153, -1.1791392800003182, -0.8774672574949991, -0.696902450745094, 0.10246955581593276, -0.6312313000652088, 0.1607439264545873, -0.946806053955505, 0.4980385651321779, -1.5025949447786835, 0.6665080930725575, 0.5597056063634048, 0.5577104600275979, 0.5698542567010446, 0.0074660909531965945, -0.7245143894657985, -0.10384821849970106, 0.4223123737582824, -0.04528321122961177, -0.34993853011799153, -1.22210378238085, -0.7328412849875755, -0.6414109014181111, -0.061136441658629415, -0.3270441414421411, -1.0587485941951587, 0.3408141648865137, 0.43755469530347096, -0.6415220510656958, -1.2644561388268423, -0.6060639951508968, 1.028120921514379, 0.8514485268736145, 0.6960386479532493},
    {-0.816667278024601, -0.28384973625870535, -0.5304064735953057, 1.0002758445977735, 0.6927122748892324, -0.8794821467986634, -1.0405114866603375, -0.30690464888190117, -1.3803100484112503, 0.6207712566073164, -0.4028182422367843, -0.010471635733881622, -0.6905990912329301, -0.1644369256449581, 0.526820276862394, -0.16263959900119646, 0.8164227923925027, -0.31868796402027344, -0.8685085508916753, -0.042652705127829864, -0.935948700819081, -0.1298622453411326, -0.7636270825997022, -1.019487312805175, -0.6837240181376901, 0.14001391736781285, -0.7893824975784179, -0.5336585835289003, -0.35794754579389915, -0.7357190363206627, 0.36030536096325516, 0.19133847445139965, -0.6926497996452986, -0.7962969216932378, 0.19499696097518168, -0.709893847182003, -0.12977892084930212, 0.0008929205508477932, -0.6165433826628054, -1.230125691266952, -1.2589528178061211, -0.29294719201648045, -0.37610138487903555, -1.0080276788660043, -0.24580892707569274, -0.9505487503685764, -0.8386040163610949, -0.30362401065804606, 0.16467029033987593, -0.6739433017170933, -0.09876413358365758, 0.44467056885992384, -1.048148043781741, -0.42060820534328053, 0.7001883436358102, -0.6865529280428508, 0.9987842376840862, 0.3551910696675003, -1.137609023912993, 0.07774744275898873, 0.5219184343280667, -0.3180862263109512, 0.8638341506250927, 1.0362785169694073},
    {-0.44357994553688324, 0.7745618179925151, -0.6855161917920642, 0.17079522517036597, 0.2017417688871785, 0.6115280823037268, -1.486034038159734, -0.9520918581181037, -1.2720692256096642, 0.2404973482096808, -0.4328471958306663, -0.2937537391681784, -0.9415297697003453, -0.7119629335858054, 0.7138872813277143, -0.0638605370756351, -0.6673490465252385, -0.7662498419073214, 0.8164453545648761, -1.3021712666511651, 0.6080089475314467, 0.3608907612253213, -0.1101435972433763, -0.13403937857341153, 0.7298460338751145, -0.19249487141606553, 0.3078858373588771, -0.7951544473243656, -0.7716475351427633, -0.30267318365287443, -0.947010462029204, -0.9330649627848009, -1.563615223773426, -0.26771196220438304, 0.014627233869008785, 0.3352009763077105, -0.7651964449796229, -0.9069190989896094, 0.08178881761493001, -0.8363324701263468, -0.7322298542620433, -0.17591698775630185, -0.9342326244262149, -0.24398792480186585, -0.174081098135521, 0.10478887048255577, 0.380168318989933, -1.0606691991647634, 0.5919548853660016, -1.3361194061562554, -0.9443269738316573, 0.3426040941981897, -1.4506654770349001, -0.719907264875102, -1.199192513825594, 0.1379025603446159, 0.4293756671766008, -0.5540671092506132, -0.8773354709152638, -0.29267895812191114, -0.34679629138647944, -0.35568185368881755, -0.5566237730287257, 0.8287010875677029},
    {-1.4842180131205895, -0.17087602847378192, -0.7164019831303216, -0.5968685093997953, -0.5936132657995972, 0.7452396545598954, 0.04118492583020498, -0.05939469618694497, 0.1285252901542677, -0.12627851419880778, -0.18193691668886877, -0.35154508510172716, -0.24724238785971417, 0.23930606007527438, 0.27148286328764487, -0.735954337602189, 0.298570766191056, -1.4004741420081945, 0.12958217144625195, -0.5776811057410217, 0.5667459683750327, -0.04417343937071163, -0.21815742362182175, -0.1899202896150063, 0.4225166818044086, 0.4987157128679957, -0.8564119005214149, -0.25763806400197553, -0.9533046100679795, -1.278521014497705, -0.7192735889166112, -1.0671015129153547, -0.5929644248925238, -0.7209349389563248, -1.023525759889153, 0.11944700194250224, 0.4353356656077094, -0.6241155767761237, 0.894098453274492, -1.1682704566091813, 0.6268832689453122, -0.9070875345723857, -0.9590047081894336, -0.591702477179943, -0.5022177673143466, -0.12558348731554222, 0.2710572946855952, 0.9438185708778433, -0.6776993734275907, -1.1955360773492565, -0.35873069230343957, 0.3554258158704321, -1.0793703650907054, 0.7635109412094895, 0.10791599207193125, 0.23934275954068873, -0.5447984270741756, -0.7248958355855689, -0.4867790694821665, -0.8944067641477417, -0.6565120227481582, 0.6901205938665377, -0.1674184924962379, -0.4688392606478076},
    {-0.024714127555044506, 0.1700926714026104, -1.2960986368642284, -0.65189371725215, 0.825953532335114, -0.06887402605076924, -0.36940755792248653, -1.1313003232552348, -0.9052552059786986, 0.3064659556238804, 0.7947539940873709, -1.2355708446979354, -0.6625352454802084, -0.32478025407514066, 0.31620657182945505, -0.6177162072644644, -1.2393718389037465, -1.4405561667858493, 0.5045987208814893, 0.35397042650816224, -0.7313262345961747, 0.3702058686006945, -0.6571669165347775, 0.1339081488343031, -0.9217963235847376, 0.6587626637999843, 0.7036182918744835, -0.4481983946626251, -0.7155224275746835, -0.7760455988802756, -0.088673670130315, -1.0216202021989333, -1.4996995685477024, -1.3760341060361811, -0.008044234701922537, -0.9591749838350963, -1.0911942910465697, -0.7717738292878479, 0.8448843397937389, -0.263332833402764, 0.5990224315456806, -0.01500110688700338, -1.4269360841903551, -1.2188477616458306, -0.6578462311363678, -0.7792512846902923, -0.0177187826731456, 0.8634488956875113, 1.0533099616446138, 0.015165807606372057, -0.35279856377191526, 0.7610694973244088, -0.8928740336102027, -0.3493695077341304, -0.8116614803690397, -0.5447104310281666, 0.03781309528741528, -0.05279570629885634, 0.41679310245848084, -0.9007522131066419, -0.8490534298124425, -0.9028418248541666, 0.3874974582659491, 1.0152814862538095},
    {-0.9042293132089646, 0.19690854791664533, 0.43228408996342876, 0.03556840481206016, 0.2926000974472331, -0.0882686851425504, -0.27766542117828286, -1.4693495665113558, -1.027463679111576, -0.23693614338016894, -0.5037168575263662, -1.6328226869803668, -0.8614566699623718, 0.9956035939947856, -0.11764849769567, -0.12061264507799645, -1.3150421443674791, -0.7307460648418442, -0.4186399473031205, 0.5496574372750467, 0.7807992364497729, -1.2846633086875787, 0.06882300802246911, 0.34330540671551846, -0.6817312582685356, -0.7010478012775723, 0.733080151334252, 0.9218937741901468, -0.5325310278839008, -0.9773217160498481, -1.2798672779668945, 0.8481659493931154, -1.7441182365342673, -0.5875341628496129, 0.24395617780766424, -1.4600746277515368, -0.22972314400986887, -0.7405924306712987, 0.5048069866049353, -0.3901774750520692, 0.2961435039028275, -0.37852071493922457, -0.5414505921191678, 0.6923639577502325, -0.6912176007242261, -1.190724818729786, 0.7275413529327266, -0.6986370324965997, 0.849591823906173, 0.6108230648171088, 0.30836635643501453, 1.3389426258618726, 0.5502357475468713, -1.0648808881209246, -1.1799373131840383, 0.14038829182239204, 0.44054451915733817, -0.8126946729486798, -0.46794414609898627, -0.3298089424814809, -1.6153419929466832, -0.7844173344996745, -0.4644230842043798, 0.4706100079445738},
    {-0.5199724757604378, -0.9472149275107433, 0.44546636588475536, -0.7984112693743295, 0.40949610843163087, 0.11240776202663268, -1.1427904827154465, -0.8341143937482749, 0.03509216168916218, -1.1000560684175467, 0.001256202592321139, -0.9349531477981174, -0.14461881351784658, -0.15286658073978865, 0.5255669467206737, -0.8929871822642789, -1.4268819802978103, -1.5171050473582175, 0.9383075424585575, -0.45124692500505703, -0.8787817178819524, -0.6942790735592865, -0.4986633352753399, -0.7564788852617046, -0.15700459878302736, -0.7671880352317788, 0.12895566118072638, -1.080174407197736, 0.15266682510366453, 0.18754745192651964, 0.38585782382158806, -0.41167175007948903, -0.7018007433018225, 0.1632412627105983, 0.7576323661413642, -1.270391060767507, 0.8287143350932552, -0.6677505575342711, -0.29885063655725913, -0.5107611566855565, -0.3767273396322313, 0.05889447716943875, -0.7678053085748445, 0.8719899367882245, 0.11399598071424545, -1.183491961124271, 1.1547016895204159, 0.3490548584547573, 0.8581477496125619, -0.16525577146154516, -0.010070113633906754, -0.16290567496568617, -0.13729259743895972, 0.5443264537384269, -1.407478573336473, 0.8596667091536373, 1.3624750522381996, -1.0138633499287275, -0.6150502380115628, -0.3589290734865965, -1.4486491102442225, 0.5681588541319409, 0.721482742527538, -0.372956046835885},
    {-1.3478657266955834, 0.4630552468658281, -1.3217297472568241, 0.24610181003266357, 0.3797300312441548, -0.5365230463013378, -1.118649135415534, -1.1931690717014716, 0.147674463503465, 0.6366639754254949, -0.6880337232388372, -0.5300043603506659, -1.5322052004603337, 0.8799190357570583, 0.8474424232165585, 0.3082531238047793, 0.48183272276350214, 0.25573512242034624, 1.0078551544720153, 0.06310348319550076, 0.2606855848126029, -0.3408002618636184, 0.5663938308252356, 0.331028484576788, -1.4535069780282999, 0.0587779038765554, -0.6803655846754724, -0.32716245680595823, -1.278075519730193, 0.5599397940847982, -1.2365345867819275, -0.33898846326839577, 0.10823385800297881, -0.05677003770687355, -0.29494939287934135, -1.1675925742558857, -0.13101495124753818, 0.006608123681673856, 0.6680191733560283, -0.060700168651259184, -0.4564881600416949, -0.7559090651150597, -0.31549854058491195, -0.257734991187701, -1.6689850510364255, -1.2058988527908716, 1.2661749565292548, -0.8688377019989364, -0.46440961280060516, -1.4162575855606834, -0.5154424024594133, 0.18580931404723347, -1.6040498697666086, -0.94472489757298, -1.236295289429626, -0.7113487299494058, 0.2441554895083159, -0.002032806012751093, 0.3559354201949881, -0.13794554350299373, -1.2636372769400175, 0.14098065017618366, 0.20855536485669243, -0.26881098071683646},
    {-1.6513745346226276, 0.7099085803513021, -0.3695489162659534, 0.08628958529931896, 0.9955763025960632, -0.07204919337688577, -0.4034960575472663, -1.6978766707161508, -0.49829782616721363, -0.19570483544947784, -0.9312968522388103, -0.8038012611447721, -1.318813188835135, 0.2285129182293346, 0.03487063482266027, -0.16067165799535738, -1.2416967518553532, -0.9458137016603846, 0.34084511673674484, 0.7287976102381529, 0.7569019321926175, -1.1863681076767139, -0.8447736551599492, 0.761744517762382, 0.008390271183451847, -0.3183406684946599, -0.7285595440114225, -0.5059565552186739, -1.5236869993644269, 0.5395889061565563, -0.30672462557968677, 0.471980499536931, -1.861323051975827, -0.34784243248996594, 0.6791799893471852, -0.7440455452289022, 0.47727416496231684, 0.5520883655901616, 0.3743598210682035, -1.4067575639308445, -1.2544652177259863, 0.06575852909780366, 0.2736245292427779, -1.0872238284272078, -0.31992336819313766, -1.5187350867177118, 0.32040675320473233, 0.8720451758046083, -0.5102098203467679, -0.1321342049830619, -0.7534303660113507, 1.3066630090282316, -0.9535071744995433, 0.7655594332449518, -0.5719415182520277, -0.8784260170781226, 0.94780667110481, 0.5892399407749812, -0.249691012329215, -1.0816005660249093, -1.4953160846055467, -0.5523610240805278, -0.3694791453440104, 0.8010347100703951},
    {-0.1903387684608131, 0.2891194985964677, -0.3416188414234383, 0.11996242513014259, 0.28484586016379687, -0.6931457599962498, 0.044065845957544696, -0.8027500656009126, -1.310076847301462, -0.23332829203331062, 0.16124902797439442, -1.5501193052855762, -1.2727919042177327, -0.8413765443621763, 0.619896039124816, -0.3326292371275652, -0.2703377732848672, -0.9753601363011167, -0.13029852918640686, -0.8073071939373171, -0.3330765569463292, 0.1651968232576858, -0.2868742827951748, -0.010717195127281608, 0.2745810995815003, 0.45597555815969393, -1.2163775817872144, -0.06686119165227591, -1.5554569233269433, -0.7274881760593724, 0.28353110217632743, 0.5966584821876776, -1.168188295791187, 0.5283790417504516, 0.5370063932314049, -0.2822674680345682, -1.1874829236216453, -0.5611853703809067, -1.2266534511099463, -0.6314282925877146, -0.23016741366994642, -0.8911858815248239, -1.3572112206387752, -0.20113569119608002, -1.1292990035203017, -0.7017159744422762, 0.8849458069049996, -0.5400753253770878, 0.2552372222568291, -0.438471895255957, -1.3663722025380396, 0.7500887885795747, -0.6228108837321664, -0.5026818719951649, -0.3162094819422681, -0.009304693878092702, 1.0054094943360616, -0.3424056058813349, 0.28416796651880066, 0.17403393851622104, -0.9752803165052635, 0.4315859271911377, 0.5238496986303336, 0.5075998253217209},
    {0.22045614770691518, -0.31130806091900026, -0.9423211677410828, 0.0340795024770107, -0.01698337731161184, 0.5824053075961036, 0.1755763238653849, -1.7843572776386827, -1.6762559144625762, -0.8546661044448138, 0.28962818947505437, -0.6685785617517249, -1.3734184028960499, -0.6585087588637557, 0.6426646397377569, 0.6280925070525825, -0.9384703932617939, -1.5034576274625686, 0.5771925581459234, -1.18837441921146, 0.47721364309627334, -0.25705427107030643, -1.1970406301466447, 0.3106404515515269, 0.5035886592841947, 0.788435524756855, -0.4125142719714758, -0.5165913856818221, -1.0693222565156801, -0.46824427855452666, -0.9548806440470262, 0.9447003451044733, -1.6006905600785186, -0.16835288396269713, -0.3105282515609544, -1.8459833153396144, 0.5458041797599373, -0.6340292246521321, 0.5435490744573567, 0.25695922671319193, -0.4127672036472213, 0.5724749442876895, -0.24865868353092388, -0.9229706489421146, -0.1270516264299569, -1.45944228494373, 1.292003519414349, -0.26709478691066324, -0.6015163996327632, -0.6674057843576546, -1.3493105794892004, -0.043669556062314666, 0.11721525903111663, -0.8294637064729649, -0.5769910108613289, 0.3030877807642492, 0.6072678903418788, 0.6895570827312093, 0.01550140026783461, -0.255462031989406, -0.04942470520722799, 0.06549152427480347, 1.187255693695263, 0.5956648725445934},
    {-1.4873268849741932, 0.1463191292965193, 0.08684362455072284, 0.702897334794451, 0.6500769754903617, 0.23996934901714173, 0.14135519447264122, -0.3169801501662763, -1.8672818466440555, -0.1628425556147606, -0.5357530415022557, -0.05563828073987305, -0.7286152416069848, 0.9542104265738584, 0.0516646255555076, -1.3194152772669374, -0.38165140208898085, -0.20012283652642235, -0.18764112165170022, -1.0032732110035065, 0.9652650511488764, 0.40622696827824856, -0.5788457762546809, -0.5020615881231574, -1.2228448809926926, 1.0713458287411401, -0.7256356575842408, 0.6973466647324666, -0.6295389395859273, -0.5965960634053518, -0.7092634410629903, -0.19416609327175094, -0.577631301798421, -0.3638301941274653, -0.6914775366498784, -2.0068225253347527, -0.11426337941979724, -0.9043472593165663, -0.49765016555221275, -1.5952922079580028, -0.2891209139918594, 0.5244453132566408, 0.34737767030093, -0.9882027979685127, -1.0244260027442451, 0.32258244465304353, -0.2906406955048573, 0.6932846003330174, 0.43220162984677835, -1.2350014320747447, -0.47761025554144515, 1.3606098521843248, -0.4745062277299046, -0.15721687119168745, -1.433660030791003, -0.48522527752768285, 0.4293592626783295, 0.6402291102952875, -0.11265994853305107, 0.405053657572212, -0.976473649150146, -0.37140466732446503, 0.7145909881544286, 0.23278192457333283},
    {-0.40828754827438923, -0.02390581737014012, -0.6414264076597653, 0.7217351487062578, 0.6773017304789312, 0.6963480206287237, -0.4233300332729033, -1.0043565554806908, -1.5742254093087216, 0.718077206199209, 0.6452105868674827, -0.850953855604039, -0.5965128411259005, 0.5658897140091078, 0.5139582314470597, -0.8160006654664919, -0.6469378085005729, -1.1734958795976367, 0.3053568658138205, -1.0607821749088393, -0.2565212337984201, -0.7888890011750892, -0.5721514885433947, -0.19265435141920748, -0.7939721656455418, 0.9564729747720653, -0.8307478650324887, -0.8731469278100724, -0.5295547522241705, -0.09356121310242888, -1.578053686979191, -0.3387880705637782, -0.9937238817212722, -1.2594055926918446, -0.4726456987185647, -0.6263399068836475, -0.8170816709049391, -0.7962138414103075, 0.10252991818717525, -1.1388721496736416, 0.004146678259495939, -1.0043288137382862, -1.0199644998113522, -0.21242733138117484, -1.1739391287670142, -0.7746575244431183, 0.09497036347098128, 0.44002167121166946, -0.4156411271935876, -1.0738473627226637, -1.4753236103205811, 0.985865030840387, 0.5172665518789696, -0.712903102786648, 0.11280069769248731, 0.03722076207837051, -0.3450440873070651, 0.4509087819766947, 0.14995219946033822, -0.79803653971671, -0.3162861389687389, 0.634036981013438, -0.5561761523219343, 0.5397253064078983}
};

static const float b1[64] = {1.1186023564290153, 1.1514623893795322, 1.0711261520828852, -0.27764565642053707, 0.6312286792885521, 0.9240978725511146, 1.1387835643212578, 1.2519043478274843, 1.2208401375843108, 0.7179768282405711, 0.9099646611233253, 0.9824761236257272, 1.1809726469523911, 1.1269293663870505, 0.5131634262645928, 0.9859619473866783, 0.8367115204509783, 0.9450083591608683, 0.7090799342597007, 1.0157929963367873, 0.9342292917667925, 1.1944042677920979, 0.6748646076037379, 0.8350122358647528, 1.310071627800732, 0.8710789028638234, 0.7217889950936821, 0.6150911454003958, 1.0979792559233725, 1.0543593041675792, 1.0563301838800832, 0.9733996542161965, 1.2381030428635356, 1.2045162524152808, 0.981295035820936, 1.322429142858522, 1.4272286300190316, 0.6185893967301086, 1.2327705856380053, 1.0562902459695536, 1.0159947106938712, 0.8002855204513236, 1.1011629884549854, 1.0304024161106065, 1.3115558641218992, 0.9620583783577362, 0.27986352208505316, 0.761695193201852, 0.6582353056670445, 1.1821655645694156, 1.089639283215307, 0.8378646479400684, 1.3343280931397732, 0.7200485639345634, 1.2566795183951847, 1.0603944794691702, 0.6822855265318477, 1.17080988513658, 0.9585914141916955, 1.0179871512084275, 1.0969447016620508, 0.42065584452136645, 0.28409154648527823, 0.8064773706597101};

static const float w2[64][32] = {
    {0.5518492337149148, 1.4700439032153598, 1.5305308717388864, 0.7039446562618816, 1.3596767038221331, 0.8039248285264078, 0.9536290005637733, 0.4933704840958546, 1.5391491907365076, 0.5749920912976706, 0.6257105005392686, 0.4930962598807343, 1.4373166355614777, 0.9151180991263844, -0.21055331450927275, 1.4755920164595904, 0.05115363217359451, 0.7151207294776372, -0.1090170539375411, 1.4628596821465476, -0.6348772223499783, -0.5915733769390318, 1.3378485678768217, 1.3868652791354432, 0.49442820878291227, 1.7349325971627794, 1.4685700889518343, 0.6347813330681845, -0.0736248177363098, -0.840271124803986, 1.7793321523639094, 0.4507773339680858},
    {1.7969551565677622, 0.8859610229596572, 0.959031296999976, -0.5200776757617714, 1.5738554224340833, 1.0113501060000407, 1.4623411640259234, 0.44566114251927214, 0.07000158253413304, 0.949510298094113, -0.7036451667555057, 1.4646487326406104, 1.2205809879865845, 0.02060506841709821, 0.7413121828276837, 1.505312936659011, -0.1486494288336519, -0.3592991401387234, 1.1689350528936884, 0.6115018859599185, -1.1749865916734388, 0.7039907128446553, 0.14023625360258324, 1.1836578328717868, -0.08210202685293452, 1.1129538095446838, 0.856271169917985, 0.2960508674606002, 1.6242158974533973, 0.12679022836661627, 0.6402935245639623, 0.7449123007956653},
    {1.6768338123429953, 0.5301601670101294, 0.12812013547016465, -0.9805379046685508, 0.7006654986784127, 1.6819457254272137, -0.012282108097687263, 3.3928604470770566e-06, 1.1625434679260855, 0.027431783088810384, -0.16165631571422764, 0.7522777165426622, 1.7179972751163426, -1.067623815844299, 1.568112534591484, 0.6824516818960235, 0.4829427042436107, 0.3150563122246677, 0.469484518333519, 0.8427987852818845, 0.5168624301231423, -0.10311936692421872, 0.07118879403572603, 1.132756955409517, 1.1745193594525225, 1.072488543043683, 0.8818707319693181, 0.5436586084859462, -0.025578867715097844, -0.5495464845984934, 1.8218182075105325, 1.0473680091839954},
    {0.11830229873036817, 1.2272995113213698, 0.7008850905309177, 0.7328850494998356, -0.07035526735552157, -0.09566238014821923, 0.028250500782968212, 1.2762750195291268, -0.1946467474699866, -0.22854163862665336, -0.8748186352150101, 0.04271122026649778, -0.07508289921901537, -0.8170525465829187, -0.05312609137301064, 0.8531965655333916, -0.497752495318196, 0.5282080653022387, -0.14821032410765084, 0.26111715182345036, -0.8821866185607273, 0.16477173920641622, -0.43560886496509776, -0.1521769624911941, 0.37480494336432124, 0.03330272751325494, 0.011408669568616959, -0.44644971812200374, 0.6926838718046093, 0.4640800943510177, 0.11850267930345212, 0.5337683117924094},
    {0.03650312950015973, 0.7802434015386255, 1.6905739088520253, 0.30360551098784516, 0.21724093672107547, 0.4116195631143804, 1.3671993980906747, 0.5092531872291692, 1.3317043116282072, 0.4332451307950754, 0.3961186751793151, 0.1841145125808281, 0.28996104252841587, -0.02321713338637161, 0.42969245541732043, 0.9798237090137468, 0.7470812178478107, 0.749232242850416, 1.490659591335736, 1.408030007701785, 0.015736348509398982, 0.8842420341710326, 0.6270532676838692, 1.1408818401249885, -0.35462482777058807, 0.27995572545292946, 0.2569202511613389, 0.4148117517232963, -0.00924294871851578, -0.04096871518350842, 1.1279689510811362, 0.8154524470544231},
    {0.4039921643203652, 1.0591463736696347, -0.16942747861636528, -0.9240517725363305, 1.5289575845404795, 0.7583429391131491, 0.695565193490821, 0.06582522090937405, 1.4072993650737178, 0.28300452987031616, -0.7493475573509392, 1.4145070583761588, 1.3177621753209807, 0.7394042443715985, 0.8233434061444506, 0.07392680249477741, 0.474993516631771, 1.1854213348719573, 0.2587483586226672, 0.243741816089025, 0.16410419416146352, -0.045310377288921184, -0.4676794280597297, 0.09093192673446766, -0.21947705768580117, 1.3074633033645189, 1.867385477619692, -0.2981691654682249, -0.079733612840627, -0.1136008477233974, 0.8808694379826365, 0.16928838596466536},
    {1.6545186373048262, 1.1365705223467069, 1.7113922976452798, -0.44694490725614383, 1.460392364689463, 1.4116873860976737, 1.1411768704395686, 1.2603782351454786, 1.8734783220719182, 0.8516599679874675, 0.5312905855228712, 1.3249233541215728, 1.4505702681765613, -0.4357192784013569, 1.478385941815321, 0.5769225377289642, 0.2883855310745229, 1.143048059866919, 1.1041512350338278, 1.83318632073647, -0.5882658969061176, 1.1593256192446768, -0.2227898249697629, 1.3467533357022798, 0.0655298486032318, 1.2119696320396225, 0.24676760273018358, -0.6499727227662918, 1.8861068143596509, -0.9766131627666531, 0.8357295949404396, 1.3045366864110641},
    {0.77256877328401, 0.6997198587039553, 0.13355163348907512, -0.2042973321339829, 1.4568040551163788, 1.8566134218721644, 1.0455751913724483, 0.30489267947205884, 1.8486816177318206, -0.13747562416072592, 0.26277886731550915, 0.6154511916241115, 1.7394853646552322, -0.7836096744153545, -0.19239628366594128, 1.3628645942733928, -0.9811610704437497, 1.13502166348033, -0.23419571010797946, 0.08288593138245057, 0.4881268350669492, -0.5412131822271941, 1.0738613479527088, 1.1235023406611138, 0.3803292221009156, 0.8612966162207614, 0.3038992688491535, 0.112417966887972, 1.1902682370053101, -0.03960861988560422, 1.7466043785006513, 1.9498622168054742},
    {0.9961055392633573, 0.010402132620518154, 0.4749731967056225, -0.5421904901354593, 0.7141365648381922, 1.9893456424049707, 0.12956673040113803, -0.04097033231398604, 1.333041104674802, -0.29754615856692535, -0.11258019245454723, 1.516541490522813, 0.39422445682451634, -0.5383624788501323, 0.7179010662650885, 1.0085527248339887, 0.48318129709616714, 1.231131774739744, 1.3669367162343034, 1.283360847759928, -0.0059284453311459415, 0.7846626296646242, 0.8619351244312431, 0.8100254694424954, 1.2356925535911234, 0.009564782205293656, 1.8500384527550824, -0.04932400648222295, 0.09009002299356758, -0.593755465404662, 1.749592817373759, 1.1031419815366164},
    {1.0906112326071629, 1.4985079682496951, -0.1623260904613247, 0.7117130306338291, -0.21038589511823624, 0.006650610720180645, 1.2803866102498995, 0.9343354145045026, 1.2135814399530318, 1.0937395079893975, -0.566755119671356, -0.12229008262408542, 0.5624548298854282, -0.1637232996564259, 0.40760232498307436, 1.2919048806129585, -0.6840696696030982, -0.5777674700568682, 0.3065633657464427, 0.8679036602048107, -1.1996767125920698, 1.0370091997735902, 0.1341522076130438, -0.024470822127303303, 0.696129110370305, -0.05351922364105786, 1.6693649230335872, 0.5473526637621728, 0.10644721200441581, -0.18786377954515657, 1.3322380200898958, 0.8678427036944047},
    {0.26020649306947474, 1.495674107435463, 0.5611171933316084, -0.23368490786362275, 0.3068720631375113, 2.0644854543515287, 0.7362004357404335, 1.551667723058649, 1.641424599893634, 0.3783875951892374, 0.25880743207623863, 0.30436583749881263, 0.03400616343405309, -0.016930275842392577, 1.345127191663749, 1.1971720103079526, 0.2964256388453143, 0.13445862682014312, 1.191910640477567, 1.7965385737113826, 0.5949060926464815, 0.8393745579939125, 0.8070579622214413, 0.48612533010920533, 0.16099857014914326, 0.12560924583657462, 1.609541413596496, 0.8369036701916457, 1.6602541025021267, -0.7214766202668461, 0.04845113117991343, 0.4194065669847004},
    {1.6806438710783413, 1.6058807567575586, -0.020275028545048836, 0.142664526154092, 0.40711826396423634, 1.6188326294347921, 1.7062518235055328, 0.7792465293003088, 0.880528926520809, 0.6357516159354245, -0.3917971377640649, 1.6429491942983738, 0.7926111886065828, -0.6508163645891883, 1.4352634248406644, 1.3556493252914574, 0.5147208014813113, 1.0390881693324727, 0.23814466593733472, 1.078337957176377, 0.015874414213439575, 0.3234818587087083, -0.4007885430543811, 1.2070665902767008, 1.430683991944118, 1.6111188513163859, 1.7348304745666774, 0.11078956356336986, 0.903132255090987, -0.33741066310494444, 0.1873238625367414, 0.7546335639115765},
    {1.1781981447300014, 1.6653931599154252, 0.02064587355622832, 0.1826223913911638, 1.4591331433573826, 2.06119673486833, 0.9675184094140289, 1.212553859300304, 1.6200957365637894, 1.0960033783002117, -0.8452811475304062, 0.4300669458392771, 0.9997192490338035, -0.522315117112634, -0.20027101227124355, 0.6827718301198163, -0.5400789252627575, 0.12945396933115721, 0.17704174447903115, 1.0678965268855558, 0.2652511403009894, -0.47256886807772996, 0.9413362943758753, 0.9909225844109771, 1.528748272589869, -0.09916793998327121, 0.7732851369987256, 0.31650916168001536, 0.4539070300884666, -0.6716172010926417, 0.08017605427700802, 0.6569026575992419},
    {1.7986000930658799, -0.31222001069525684, 0.2848353779925152, 0.00027607456626668996, 0.6143954217061217, 1.3940487260894225, 0.7504793245118457, 0.7367477718133689, 0.8048980491892386, -0.09549769080028181, -0.014800608516424724, 1.685865794543481, 0.808446582126455, -1.0116760800038085, 0.5529352686181543, 0.904539297964376, 0.4222849996294596, -0.23638335845660216, -0.08378336532829479, 1.261543523550558, -0.7130272383941489, -0.1761053159143311, -0.11710708134987813, 0.3074416079763367, -0.0989346113285444, 0.9965036476831567, 0.2190895637388577, -0.2590689264660194, 1.196536817432082, -1.0421744630378134, 1.6691907525449003, 0.0765031584025408},
    {1.2340947335891759, 0.6376660222005003, 0.7394306213069709, -0.28798615320739895, 0.7333029812338252, -0.05758230959784094, 0.9475739346098843, 0.42360030705420215, 1.3726339608658202, 0.6102724507754486, 0.7990886872368939, 0.34449548169916383, 1.4528135227947985, 0.8663396856247066, 0.09394293230974639, 1.4035870851818772, 0.48203995253478177, -0.49733977560419085, 0.9961557511975923, -0.30607105669545054, -0.6939066805484495, -0.16946110840398568, 1.1880435308543067, 0.37058682993009884, -0.20090578918367277, 0.852314695540729, 0.028282878507129603, 0.13947422844998952, 0.9376270660320677, -0.908691256386195, 0.9315456374200897, -0.1480822737853844},
    {0.9843758968683249, 0.8233842469033511, 0.7649755853543594, -0.06045304670800992, 0.1779510220491635, 1.229606986429201, 0.42549851546027595, 1.4423230621191425, 1.2191352669282538, -0.2976818206973643, -0.5090291883748845, 1.8382550040854049, 0.6017540780391292, -0.8120642286701514, 1.1777054048567508, 1.215382014796369, -0.5389967825741987, 0.6710213488887125, 1.5266721664947882, 1.3056791550727986, -0.23873748143014298, -0.5544417917988319, 1.210088364216895, 1.1838706902983196, 0.12353400608604348, 0.9112864220369143, 0.42201296522445236, 0.8210197331399215, 0.17943147930691852, -0.9276305166029619, 0.44829145289973893, 0.6137104166888964},
    {-0.09733396918440673, 0.5437123626732587, 0.07593269451876039, -0.5849813574678291, 0.6922377930430713, 1.198292692642716, 0.7513245541987938, 1.2482207234090699, 0.11114088261813428, 0.6455946887386855, -0.4417926429973371, 1.783547224256489, 0.5253126041847371, -0.22663150644059143, 0.17526116342290973, 0.9783957098242381, -0.3977599333718579, -0.5769386676481155, -0.09172911696406376, 0.8331009718200378, 0.3889024894504085, 0.1818420055978794, 1.039067939826219, 0.49610185043442706, 0.3459342292416868, -0.13061149619608187, 0.7907132696768784, -0.31397960785229695, 0.7741070674784464, 0.7720978725439697, 0.50776949993948, 1.051826112802807},
    {0.8490696645095372, 1.411243241626267, 0.819367255323405, -0.8950830125051537, 0.10442973892348864, 0.8595864713655716, 0.9310759825097256, 0.7992836124383136, 1.8140637047512456, -0.14859332326625632, 0.4330970190021738, 1.00525611199681, 0.9237312177028687, -0.5775955601016303, 0.15823447621835884, 0.27080249077741325, 0.17947650695451037, 0.3165122446997202, 0.8889872871249422, 0.8124266518307756, 0.15948315644461075, 0.7308709616168291, 1.1213202310740338, 0.661971814382549, -0.22077517622092827, 1.1926793947303505, 0.8961147317042255, -0.8820612384008152, 1.4059312140263331, -0.22126351303987438, 0.554186006428595, 1.2339119679800459},
    {-0.05938276590579642, 0.23585331775326773, 0.5615702084710857, 0.5782358719053141, 0.3396610245490352, 0.9880976726786882, 0.7352015243052037, 1.4039467867675524, 1.3886781188606059, 0.028611947112932863, 0.08387286692033706, 1.0324468248263192, -0.2972862836204368, -0.16117775561979772, 1.373794343670944, 0.6357312244628748, 0.7564808906082019, 0.13248685072214628, 0.8340517139521507, 0.04253802482577221, 0.3760537388470018, 0.26110326281055185, -0.04714425406011763, 1.2653520239645828, -0.12172120456512682, 1.063280426275159, -0.011328173876504314, 0.2408196077903129, -0.004703602703156997, 0.7991140604522365, 0.9307410496774474, 0.39837144017654214},
    {0.932153840050957, 0.09862853218924807, 0.6414618630964073, -1.0615701791592336, 1.0197212906996622, 0.9815716899830493, 1.1511967789615303, 0.23335833362224515, 1.8501135447003925, 0.954227776907824, -0.0553102310651536, 1.7623652354380082, 0.2298810553599769, -0.3132975528012963, 0.8613267871692941, -0.12191583377720672, -0.7063249577377216, 0.0731138477420444, 0.9167796710517562, 1.144001520347118, 0.5491829113556764, 0.26199005019718286, 0.8845456929902573, 1.1463929534667314, -0.10383269371062087, 1.2642657494877318, 0.6878796494358059, 0.06681113859609125, -0.15762818901629655, -0.19726820271040682, 0.0887155748144324, 0.5248382120734698},
    {0.28956578890573303, 0.5042362928815829, 0.6933071455087455, -0.5507419603205704, 0.07862739084188954, 0.35943639685628026, 0.8119121096080146, 0.32275867322396706, 1.198795608592558, -0.09256637495558186, -0.5666857681423947, 0.9200773408710891, 0.9799351885025027, 0.8023382059148892, 1.3603356619018012, -0.153585182709745, -0.6324596485421926, -0.2874769798013069, 1.356779064092234, 1.4818888403204369, -0.6006941821788219, 0.9470003629208217, -0.4651800223471369, 1.72090758359293, 0.8931589487001463, 1.0940890341205762, 0.2545474651041313, -0.6503285339094674, 0.5545870621555484, -0.8559657479646107, 0.35715408385418346, 1.8292844071885883},
    {0.5894333207181962, 0.5189591499906884, -0.10595625528788462, -0.6751161091400862, 0.7446368703808175, 0.49850367342641805, 1.319568218176795, 1.1571632611363696, 1.809915789965021, 0.14791138162496265, -0.9622743652639327, 1.639152089456775, 0.7243328349124484, 0.3247682850572845, -0.32543038946805863, 0.1258864776422119, -0.8012793670471442, 0.16714959488836534, 0.9996436508600787, 1.6618669436100246, -0.6040521284497615, 0.5011423163478802, -0.24120382339375154, 1.3744388692903073, 0.11686513748343855, 1.5780125370742648, 1.2988675993936176, -1.0178047485466266, 1.2535868622153563, -1.0131625377949833, 1.3036374899135224, 0.5672756168733959},
    {0.7382599494158945, 0.7292434235904437, 0.23975677418097993, -0.4681114143998859, 1.4929674152225634, 0.8247950487535597, 0.25600395694161304, 0.5555739681164334, 0.2388954729132333, -0.04141132973241917, 0.31056450255997853, 1.4181599017232778, 0.5207396149427581, 0.9099061077638969, 0.7306598481140394, -0.016876192653810882, 0.7676222500005063, 0.7575529999207737, 1.2575043507016543, 0.3454440653996634, -0.06883562374966042, -0.6290895196554654, 1.280567926568425, 0.26742360503421275, -0.16246019393378294, 0.37968383243382814, 1.6257571097483452, 0.3481991720207407, 0.8303392732710179, 0.26173095236756116, 0.12900750911343964, 0.6346667413674951},
    {1.1943288181150051, 1.0732407855078239, 0.9794354418892458, 0.8219874335946329, 1.1283784405102524, 1.004490505155656, 0.2669284539491376, 0.06053924511090724, 1.476124377099612, 0.08590568976339899, 0.73556564890923, 0.050666614286166714, 0.4560603670360237, 0.512517885282745, 1.3028162401207088, -0.09567134747286661, -1.015264582435735, -0.011718803336881778, 0.9270714891200322, -0.051803307369999774, 0.5467767461787737, -0.6217003261930564, 0.19462306447865763, 1.3908030922040133, 0.9226502626986492, 0.6035146496586229, 0.5700851338478526, -0.5811712719127803, 1.6368040671891635, -0.027670404584993605, 0.5366673137451328, 0.9646049569209298},
    {0.841167034015248, 0.5101612419918017, 1.4083950133909673, 0.6361876628801545, 0.8844323150176348, 1.434886223869606, 1.7992047436331466, 0.8071262475770137, 1.9425628672405693, 1.5215525906951484, -0.7919908838684961, 0.8676575525396798, -0.07890954257759045, 0.6178425006518399, 0.06303518636207794, 0.3102422656358611, -0.15565254267577464, -0.417925187714135, 1.0534980950184327, 0.9581156771042375, -0.09370310806771634, 0.30054525512129276, -0.14017940207683455, 0.2667511632095028, -0.25448468649299194, 0.18063514171533165, 1.6818828250428504, 0.01717586801337612, 0.10973868392856079, 0.8032424311067559, 1.4252929351117196, 1.6320679424457332},
    {1.506277156691018, -0.07537018474360867, 1.353294649454608, -0.6369829141733484, 1.7272215920758782, 0.8430467701088894, 0.13108774394398512, 0.9317690475167728, 1.6523917690246972, 1.2172317199607217, 0.7423138449023657, 0.9503197333748951, 1.5783797812823832, -0.3423008950005656, 1.0638385090556821, 0.7532405321718724, 0.17191822354925998, -0.06343660121537796, 1.5237231947088925, 1.0569972918163801, 0.47834823274457894, 0.663125953703869, 0.9065586138482861, 1.341225027463038, 0.09495709829098892, 1.541550870071985, 0.06017665474626925, -0.005538662144496738, 0.7474858645444658, 0.3953033537544873, -0.08802775545891532, 1.486034963710752},
    {0.26969527533931076, 1.5688790597894053, 1.693899884282152, -0.3951543792955886, 0.0010142672811589584, 0.8450657088919562, 0.5374605913917533, 1.25996554862706, 0.018280756866074145, 0.5883672718491677, -0.5785958999401576, 1.0579646228793034, 1.4302255786523144, -0.4692035300422677, 1.4281185819081508, 1.113470431397216, 0.12800405513735852, 0.7933402460956217, 1.4312220428688067, -0.05705270882032887, -0.57989006781694, 0.9997810400808648, -0.10547573274843536, -0.08789788749040872, 0.3458750584605124, 0.6657664601124514, 0.8690212263400463, 0.3145118200005302, 0.9692378649521927, 0.0520644836607216, 1.1407549217343833, 1.7043178560628431},
    {0.17666652189895243, 1.2924717706296387, -0.03921629438619563, -0.21367022529606022, 1.6219840964732277, 0.4983685707386419, 0.41597343223034894, 0.3095698767857792, 0.9409588764508504, -0.029228547990129135, -0.8236271922092351, 0.4174553885787352, 1.2281169643517433, 0.9287575965035433, 0.7719729136423851, 0.820113704527793, -0.9991250591837538, 0.6326493571297996, 1.1854164716458542, 1.2727226567776797, -0.6301444522100972, 0.7675751849879118, -0.030786112882842612, 1.0763506483104175, -0.2552577353633888, -0.19515916504934244, 0.42207295202475015, -0.8063029796579086, 1.6499530988607933, 0.8296132246327301, 0.17544503546903273, 0.2700245590072155},
    {0.11234115483043512, -0.0923310678544725, 0.8053171479168604, -0.9468413828281671, 1.6537204251120736, 1.6967722575444835, 0.12337883632319864, 1.2457798288923811, 0.30508014699586, 0.23783329391751537, 0.3990033316564939, 1.4370535756899958, 0.9673699331026757, 0.5846658223526242, 1.3958599264858063, 0.6097295061214908, 0.5085166107948349, -0.5125342781325802, 0.6674776042619289, 1.394994878659292, 0.5440295011294713, -0.04617613192499834, 0.9589627026526821, 1.2757383882679825, 0.9661841059645369, 1.85298236484987, 1.735488543979818, -1.1017946836833066, 1.6801882925882465, 0.6201474114699539, 1.0741100956642353, 1.0385576700507224},
    {0.6766879449611067, 0.09101498755903717, 1.1466793708693237, -0.9622014553818947, 0.8264116458386024, 1.1851827081716615, 1.3357906589642399, -0.16163514728905695, 0.8340190210537022, 0.43586006568438923, -0.27595579815143706, 0.7670500460491632, 0.1583035888408064, 0.10981634146047524, 0.6035635139959505, -0.10498911059840788, -1.0952959080945128, -0.6317284784869799, 0.9745538596423583, -0.03254194938642076, 0.6029179393343265, -0.1359724180048359, 0.07977209211891455, 0.02939523931933175, 0.07871645090658534, 0.5915601030072682, 1.6651639653846306, -0.3324882556708371, 0.1401895348293394, -0.909833637783348, 0.5649937438129771, 1.316946811428559},
    {1.5075330462905863, -0.0442529473154696, 1.0297500054589506, -0.07634229493015178, 0.8478593537988784, 1.9040124094808613, 0.13726785297155022, 0.7431984843230636, 1.2983106853826194, -0.04253241046358702, -0.4817987670874544, 0.2731347318829785, 0.06608918157620165, 0.5876478293244901, 0.9167759634780259, 1.369808466346942, 0.22855287410441177, -0.150829850649066, 0.5220818831824959, 0.7805053513130188, 0.3408654764233281, 0.5015075136663122, 0.6710288327439381, 0.59640843665221, 1.404329295052461, 1.5031858565010314, 1.2647639808166786, -0.894562946112183, 1.188946074725463, 0.7032937997715439, 0.21457702790410524, 0.5508562227648888},
    {0.6929218696982988, 1.0672968012778214, 0.3714495737604476, 0.12860186291610948, 1.2156914974650395, 0.9160097539998889, 0.3057717588022201, 0.5922770888293369, 1.2592437571053667, 1.391688725050837, -0.08067461730971433, 0.023054944976844835, 1.011069076499738, -0.20038079065179693, -0.055097725070594954, 0.37731916183519293, -0.03920592042000581, -0.7146385355777368, 0.49899653570081176, 1.7122260961898859, -0.08518657896340673, -0.6340735541630256, 0.8559369122428201, 0.8650231786648749, 1.5550523294176424, 0.9328625733459245, 0.043193712870650526, -0.3918126257595586, 1.5780813675034926, -0.20475649315647151, 1.5476921817374933, 1.3851721124093044},
    {0.6904731692647934, 0.7416491349517093, 0.3555398733190839, 0.7858125602758165, 0.9204469600206879, 1.1237241965224505, 1.909548867058116, 0.2791468350608688, 1.569183923305529, 0.9289234822619568, 0.12276633625157546, 0.3204598054475322, 0.9998312015323932, 0.29437323387666126, 0.14171819710296252, 0.2940139232808382, -0.9872286903451946, -0.41722234019472043, 1.3329773677694303, 1.6979469233094135, -0.931559303901156, 0.14902538453912564, 0.11639629160559024, 0.34526979451376394, -0.2903462771381813, -0.013831134491903404, 1.4482726511602695, 0.07587795664518697, 0.5451421979564322, 0.7036076248389203, 1.6533098077212636, 1.4953733433255072},
    {0.7646094410096556, 0.02278437750840914, 1.5201877093517504, 0.8496851093686877, 1.3345228349628133, 1.0953264382577181, 1.6632347266527503, 0.7924899757851078, 1.6668660907380806, 0.08101825121017964, -0.8608673693165902, 1.1417984616769046, 1.2970326169211086, 0.47820490312488295, 0.5036621149256512, 1.4872682774521584, 0.39575316135134964, -0.15917078287873482, -0.04261960650381261, 0.3623863663911038, -0.9530773977060365, -0.3377665868770214, -0.39743422237883413, 1.367514848558657, 1.0334382536274753, -0.05325906937453383, 0.4915497621095761, -0.5121108510536221, 0.8966055456309899, 0.09383070430745043, 0.35015196250410024, 1.3543486210849485},
    {1.0922513442097084, -0.2329669325363069, 0.2902424412477437, -0.003544133512129223, 0.4486372596170778, 1.5746199809345993, 0.9296958747918681, -0.014734284518158381, 1.243401376154002, 0.6920410199008192, -1.0595627072066531, -0.011634761627916386, 0.6972900282405765, 0.18720972025921379, 0.39355226104719726, 0.5695063820969355, 0.7410018857852698, -0.483595586921392, 1.4350804002381488, 0.3248104073610557, -0.6581806270678349, 0.9179564530287199, -0.24718529626990138, 1.1430483441039094, 0.2270179645464631, 1.2941434143965804, 1.0081236745266837, -0.6943659027795357, 1.7614489062010708, -1.0058772716441067, -0.02796615578956457, 0.5337757407819659},
    {0.24848338635382253, 0.7862502924893187, 1.6726458303943605, -0.6537952054179722, 0.6406036224499846, 1.2349494104776841, 0.8011869973345018, 0.8152818309143712, 0.5663139789185084, 1.2636578488383592, 0.03569108655618798, 1.8225338918033414, 0.021046390466775415, 0.5123696006560757, -0.3697927352530741, 0.34429949934411097, -0.8794308967118925, 1.1212711338564292, 1.7201082630245486, 1.9227595880617414, -1.078989877555043, 0.9866492315027227, 0.7343388043604071, 0.6696575468453924, 0.982506477259185, 1.3721833386187012, 1.482341229173187, -0.03801049011055001, 0.2874567111956542, 0.004706999242354879, 0.7981237332450662, 0.7773748398805073},
    {1.889905309004775, 0.7174542832067221, 0.7375717113837181, 0.7081030052746947, 1.0672755770651745, 1.902442558909063, 1.1304151599629069, 0.9470676503260674, 1.4666776067105844, 0.5605243967394631, 0.010630186052201548, 1.5069509820741704, 1.2090386268556788, -0.05326859060169317, 0.5184741177407136, 1.263154743832046, -0.07718048417917832, 0.2559311504620135, 0.3641866489256322, 1.7272019628865687, -0.2530191449831389, 0.6551991014569949, 0.002615177369757777, 1.4669556411586708, 0.922062680305828, 0.4055503481930519, 2.0696507651904272, -0.004299285933136169, 1.299479459889558, -0.8310765481520708, 1.0307153117416092, 1.6275809484055808},
    {0.9711018929603279, 1.389718659242059, 0.7284189583759539, 0.6977887438374515, 0.08878923252860411, 0.5027521521941737, 0.719240175130354, 1.4734145045979115, 0.9204213100813753, 0.014392527365085298, -0.8717324095074429, 0.46378806172022763, 1.3597246040812923, -0.4281882446312753, -0.16951708630387904, 0.8021875313976288, 0.22220849869591264, 1.203441734820371, 1.1772383228755992, -0.05095479161703057, 0.507412389163757, -0.12306373520394165, -0.06692013959467531, 1.3233834802916096, 0.48964414117183486, 0.3887492266110785, 0.2605218553710446, -0.6463279354805032, 1.0094995816451953, -1.0644900619946418, 1.1925937695232578, 0.22976215574624312},
    {1.7672988593756433, 0.0152997855184047, 1.686413834795471, 0.822873063089637, 1.0445748736778737, 1.707712802702609, 0.14629659352805313, 0.9940120362544028, 1.4087602272439579, 1.4743447630906787, 0.2441438121880517, 0.5426408521326953, 1.552873185973555, 0.5602700654720287, -0.22891696423040125, 1.4862669874654533, -0.2562132937896417, -0.5893804073109548, 0.8293590301489147, 0.5208075863661172, -0.4429465910746289, 0.4689118493355018, 0.14245040593124902, 1.6125277328459635, 0.2940583943517806, -0.016363829956845908, 0.8577017071497239, 0.38073202032329123, 0.3183911524169504, -0.07157419944735943, 0.445254951884482, 0.3573198819066117},
    {1.2554188176494558, 1.2926503108580876, 1.4179342618668984, -0.19248076694198107, 1.5686675428024557, 0.9770421144277281, 0.25702247896894864, 0.8806691026914246, 0.1355268245448319, 0.7004361235205836, -0.1310476470590475, 1.8455958246210116, 0.21882312905645884, -0.624549137271955, 0.8528219733862343, 0.6019486664502806, -0.8893526054588619, -0.5266717511750851, 0.8752866492768984, 0.5138144094542876, 0.32824251052024533, -0.27136103865336986, 1.5444831277359776, 1.7368115259230033, 0.9122577535929536, 0.8470663671525922, 1.1806793924406618, -0.18525118545852295, 1.0527729461996447, 0.560191462482225, 0.3485009448729616, 1.8780600948548105},
    {0.6200992577405279, 1.6640919140464605, 1.6750961381356029, -0.4638037569286608, 1.0234073023910557, 1.9539003587249544, 0.14841046361594895, 0.9228058834969628, 1.2104266499775933, 0.4763052533022087, 0.5216575633184208, 0.10813249803368288, 0.631904614741497, -0.9697205617217401, 1.448983264398285, 1.1469429572347827, 0.05146300330637386, 1.032449637224088, 0.686758280052439, 0.836074979964288, 0.2387389703401421, 0.1163828167170812, 0.7640727457227455, 1.404320559581129, 0.9736830314607802, 1.3538768080710482, 0.47652067551484767, -1.0861338001010419, 0.08504395678254625, -0.5094797557260319, 0.9302792051070112, 1.2152858577232506},
    {0.15220610324985284, 0.9806633687803348, 1.4280619751811623, 0.9237219148774104, 1.660135776681267, 1.0184425824191896, 0.6866936150426622, 1.5366039350238965, 1.2620483276856453, 0.8403322966988004, 0.4251467707291156, 0.798197074153442, 1.3642232250159418, 0.673132453769768, 1.4358909097919652, 1.0468093783915309, 0.015050162996862767, 0.7132567412254607, 0.30558060139179233, 0.26548342332267527, 0.077768551132821, 0.7930959288642548, 1.0475195828926878, 1.364729116001932, 0.25731185386629957, 0.23048278801215655, 0.047656527918889226, 0.32684801651734313, -0.057237825756828155, 0.11727712354427783, 1.1651312967180831, 1.0247233026976168},
    {0.9464304502752926, 0.5857687125585936, 1.4713929221524016, 0.4710683119252033, 1.059703006344005, 1.320449740437083, 1.9459760576542156, 0.8545992683167338, 0.9374260244823949, 0.8857545410612332, -0.5270499772200085, 1.3898195375359026, 1.4554562349027582, -0.6213216861560338, 1.3735464406918085, 1.3088309475027287, -0.7095810723814204, 0.05211083484980384, 1.5629786938325259, 1.564952318980059, -0.03335961632964067, -0.2591559456737304, -0.23031726237689001, 1.2217912842906011, -0.1906568434516594, 0.6050471020318703, 0.5458552844375467, -0.7190783830678511, -0.05092903648211592, -0.14086409508446088, 1.143206684977954, 1.5921368162883018},
    {0.3018957523434307, 1.4062961149596744, -0.009390594949027822, -0.786193692375373, 0.9956392840322011, 0.9395052306184113, 1.4491351663448604, 1.0030371500357387, 0.49898429348923135, -0.14382198977906333, -0.4816512739096181, 0.35198002223720654, 1.0088061440322582, -0.9222900462858498, 0.4695196052799819, 1.3229508795579965, -1.0674780904362253, 0.9082666181370788, 1.0393641767780946, 1.6073829110369056, -0.9734086810777969, 0.8032449371788185, 0.9572746584844051, 0.740832205388945, 1.4604461967859186, 0.12626883216865623, 1.736446290078653, -0.10637548809508578, 0.5916013588081576, 0.10985661925741279, 0.6195293119597816, 1.6125821001710754},
    {1.787483301603084, 0.054723710739470216, 0.7104628952750112, -0.6430823708704784, 1.3467216333644543, 1.7043177729402614, 0.2340876087446078, 1.0792747436412893, 0.33417999599224557, 0.18022333205443916, -0.43299020065877153, 1.3518121553056228, 0.9607344673083442, -0.21058752640792117, -0.35147383460252013, 0.8619030555416292, 0.45162082529046493, -0.3619236920217147, -0.09929661787278433, 0.5478704098360117, -0.7830878668596905, 0.8261353522699695, 0.625351253319376, 1.0829263025588125, 0.4266616957718077, 1.1231231701777609, 1.2477157437116588, 0.2246467917534582, 0.41886245158756896, -0.8518307055366107, 1.366750037976176, 1.6622815548102114},
    {1.7968321162042575, 0.9572070219434132, 0.16981732539133845, -0.348878195307841, 1.6303425981487718, 0.5946948959735832, 1.3617052870530837, 1.5529275416730521, 0.01792428126756529, 0.5429366629520112, -0.5962326757157779, 0.16260673908646783, 1.370083485870464, -0.4468339971145566, -0.025830503909863245, 0.02548190628391466, 0.31140468042062963, 0.565196287712841, 0.2882769129924253, 1.9446360912114435, 0.6004334629875817, 1.114359568102144, 0.8373721898432279, 1.3169805007159232, 0.17069911308365857, 0.6033732557758792, 1.5741166363810957, 0.026574652768198263, -0.13612312509975166, -0.3849040189611596, 1.9029516802720319, 0.9396843359724975},
    {1.6648068085107448, 0.5654400242434985, 0.3641216055022885, -0.5843599575461605, 0.6331821896209532, 0.01871766898368507, 0.13910643755173094, -0.13206477757714322, 0.0006102927721873787, 0.25126601667833137, -0.7267297536431769, -0.1369480365344652, 1.1647404049237786, -0.6105565609982868, 0.9958152838110306, 0.9059270658185424, 0.5781555394602238, 0.5559284962440704, 0.3319150487623567, -0.1125439702754991, -0.4567123152619304, 1.1082794412656853, 0.22584873848755715, 1.322483594276493, 0.4780820037965978, 1.0742199665149657, 0.37811888035976216, 0.10722658734604303, 0.19932312257905682, -0.49924790564367894, -0.013333257810301827, 0.5854880954344693},
    {1.262446354924441, 1.0904305104260812, 0.26123524913921803, 0.7629642845718604, 0.3043117021142742, 0.5792906091045198, 1.116001972776197, 0.9864171142357565, 0.8199633839167962, 0.8323933044441342, -0.11823726316785495, -0.02747356677871347, 0.3912369344630095, 0.411270641783085, -0.19393355381174715, 0.06524842160150739, -0.7367486941625626, 0.7540335288946062, 0.7114877838447974, -0.05451943590207793, 0.5463511920830326, -0.4808078134867997, -0.2527096785674078, 1.1902701313984174, 0.5187966298434372, 1.455785958440575, 1.0621443618007216, -0.5422240756658442, 0.658612127237358, 0.07928820375053812, 1.1413843767819705, 0.9439263821996391},
    {0.3722349141985883, 0.9602441695145479, 0.9796890844407568, 0.6086205769934087, 0.05800391968706936, 1.0652047396845086, 0.2613532981354416, 0.11691665700458344, 1.0382074116845605, -0.06492256388339397, -0.3329974612997915, 0.41527614572291255, 0.363639980173351, -0.003117913231587094, 1.38986945330497, 0.36470300516248383, 0.6870446317438421, 0.5208744244287182, 0.34525097823986295, 1.161170891153893, -0.41202302861733886, 1.0054808896804304, -0.5057839574529144, 0.676243366295175, 0.1118983998301284, 0.32674234938576424, 0.71672070202813, -0.937057824177169, 0.34085817416803743, 0.22183536120793199, 0.8293777609336722, 0.20947456904287828},
    {1.5939751670909956, 1.1849588448624393, 0.9014412604533298, -0.057072343547259895, 0.9423416821475176, 2.142527282800648, 0.05350164689678738, 1.3964236175443878, 1.1851259370972063, 0.9376335831773202, -0.706489541003876, 1.7980596400406013, 0.21383341636059366, -0.14045196346020733, 0.9797493890594049, 0.9233978458041465, 0.35604172593109307, -0.1485610825757048, 1.0151715609238543, 0.5370883758206879, 0.4092804531141239, -0.5517666719763376, 1.070118613928959, 1.8959495695431214, 1.6648055237893415, 1.656117215677627, 1.4335293852884945, -0.5429521744164436, 1.1363448467468702, -0.7771431835114685, 1.624351035184471, 1.441711519657227},
    {0.6809092387783551, 0.4020080873213144, 1.8064437585504223, -0.6605396005906492, 0.756111155973827, 1.4359840523885794, 0.0025288675660522725, 1.2445003555582903, 0.5208010326485356, 1.3596208480337015, 0.6004249144350646, 0.14436841982580947, 0.6147781260945001, -0.09570987642984292, 0.9200347876714327, 0.47549480099717806, -0.6064031768845696, -0.34307913893115, 0.4513482735631617, 1.439437961207337, -0.025551136744459323, 0.9718497642503766, 0.9532488935802228, 1.7776022068702615, 1.0326696973283584, 1.4486354984943959, 0.14772631205601325, -0.6328336596528826, 1.394389405609469, 0.05496094302593817, 0.4215125123525684, 1.479076771868227},
    {0.5833817301350515, 1.2684587057086112, 1.3144377613840774, -0.5043232786707846, 0.4985525242157572, 0.5450230838082406, 1.3820789603869226, 0.5170565772697596, 1.1334064707753269, 0.135958659637269, -0.9545281851380311, 1.641395510919245, 0.1285322009623505, -0.6939941485370291, 1.3154498444847402, 1.054677955674624, 0.10032093174105117, 1.1421292365747266, -0.026858683519978836, 1.3096416555812633, 0.23747150777315967, -0.4516814560410233, 0.7665264365163669, 0.21270962363171622, 1.0524853714526883, 1.4177723313880115, 0.30687106247653984, -0.43700030676098794, 0.8773677975807087, -0.10230668881403884, 0.27685137141863675, 1.2907870486268032},
    {0.5494778185376816, 1.0320287410246847, 1.1285242007654621, 0.37034278920897146, 0.5514642783450605, 1.6744621703573552, 0.6638042440583369, 0.41069040720952693, 0.29749556109095043, 0.49697391541558605, -0.3506030829838195, 1.6091681448498432, 0.8130763620259708, -0.6306792137241042, 1.4040398232384401, -0.15741467784953017, -0.1692959080731075, 0.1096492202963167, -0.10819217960709121, 1.1912319414442412, -0.7387533531204008, 0.1011971587699978, 0.9873987414216188, 0.9703991585215, 0.4213892558459013, 1.1046430366660613, 1.2982791875055426, 0.37771154546346314, 1.2918415867102933, -0.8382723177693656, 0.5840782751929934, 1.652913722004127},
    {-0.029715441302831488, 1.3209786693034624, 0.7413659333047867, 0.010015657959894507, 0.9367758182857793, 0.8564868465150124, 0.7575657160202587, 1.406034716629701, 0.32311247613608435, 1.1757379557806305, -0.406363525683861, 0.804879513119156, 1.1383725043068251, -0.6159345241267759, 1.3813514817783128, 0.3394593087517785, -0.9116848482615979, 0.9004651649976247, 1.1830944498140599, 0.2926778845374945, -0.6541734176892281, -0.2543076916455267, 0.1742805954382479, 0.2597938707713018, 1.142812450953989, 0.8271133499626147, 0.9343482876722203, -0.9804651310432132, 1.3512129411414848, -0.01036742841382809, 0.7371436315141898, 0.24606761862293555},
    {0.9362599233428874, -0.047544029340718844, 1.2449695729856924, -0.9195416318809737, 0.470182102151711, 1.2090864209626284, 0.607180716413051, 0.8201207503798527, 1.4477224321930058, 1.5205677602966294, 0.026164418717082947, 0.9168153979700455, -0.0009898794417100923, -0.36405865694299433, 0.5764974234973812, 0.30392815803470385, -0.7991716957172081, -0.5539510606805644, 0.5730231583582934, 1.921803118151894, 0.3804266815017808, -0.27811994758022124, -0.24549359525645253, 1.92775023384044, 1.480517518224648, 1.7217170065859777, 1.3917028438159638, 0.7045660354419281, -0.1054418486021194, -0.487994704929406, 0.6664434327747072, 0.7079242892705438},
    {0.13794811085650902, 1.3790488161729257, 1.0264303913426918, -0.9526345031361266, 1.8516595551375232, 1.6486530850592296, 0.2976119440628988, 1.1536723080176219, 1.952153426149741, 0.8260178835797174, -0.6415640274516238, 0.449907460732492, 0.9239086111010125, -0.27939627045699855, 1.1494719543574268, 0.07488049948015864, 0.1881801062669481, -0.12560395513707073, -0.07504120229173354, 1.4708990614724238, -0.5144076189622064, -0.6371533910582734, 0.9893725536641811, 0.15364815316494781, 1.5668779528769983, 0.7475124271712816, 0.8564832572000899, 0.04585544991694196, 0.02195720104810955, 0.21081316539454312, 0.7531431683912837, 0.04198991707555176},
    {0.7215293535130489, 1.330165974122014, 1.1907863810361403, -0.06572521362233529, 0.3811528920294614, 0.7400827312368672, -0.16876012511887634, 0.6597001863796907, -0.09456900952015161, 1.0961456483765246, 0.4514982439149399, 1.6339831536891936, 0.7711698481642683, -0.9811154663987038, -0.07005597340580186, 0.45571178686371644, -0.6771409265559937, 1.0405423761702657, 0.48594044837626144, 0.5495611074397048, 0.3909914886049949, 0.2475200339898269, 1.0229809752965928, 0.6424682172374273, 1.3168352721241219, 0.8900737583472108, 0.4133287278411995, -0.833368169061076, 0.6820370088308366, 0.03137537892388342, 1.0232474439701902, 0.1536191084125995},
    {0.09625612762538945, 0.16285787148975944, 1.5223846352037158, -0.8115992340003193, 0.21274296265255713, 2.067588800757308, 0.9807312139752506, 0.38321148898394386, 0.6439281911494996, 1.476259581602293, 0.16945667400978626, 1.6454086529089358, 0.0338174156032163, 0.33734105902418143, 1.2793283297842795, 0.7226404625980264, -0.43848109612748815, -0.06635813685674374, 1.057740452744842, 1.8725719222664505, -0.6945740862124357, 1.0553500104584912, 0.4199677213637456, 1.8274561504171059, 0.06829604395718956, 0.9363550608925759, 0.3912626743768508, 0.5929992413897882, 0.223227284705496, -0.8873664368601099, 0.5179129294217707, 0.2635547655262729},
    {1.1803060640046819, 0.8060540427626754, 1.0126800255173296, -0.11744534894363108, 1.21623755536556, 1.1839342168746037, 0.7469613163049685, 0.7428614670276869, 1.414347242945515, 0.39263032363637584, -0.25301001233258125, 0.6913801763611149, 0.9669146206690247, -0.4065192627492797, 0.9998675369719745, 0.5364999997087557, -0.029711075361843434, 0.1414348218793897, 1.1692639649904573, 1.5564230944280566, 0.3681784979411082, 0.6017789111645384, 1.0668288600533098, 0.4235282672229974, 0.1557267976717298, 1.3443879010920565, 0.8429092537703513, -0.008113974932487332, 0.8709347070949172, 0.5891780255321554, 0.9483150676816461, 0.9912845509628501},
    {1.742290243246056, 1.4493546079794128, -0.03160474347606921, 0.7225225645495196, 0.2179667750094544, 0.9317167469420827, 0.8255014683182803, 0.7924910795383731, 1.6797699020738481, 0.4229796320710991, 0.6601793225949928, 1.220909743809891, 1.6963082182210716, -0.7932304310464643, 0.35265362797722766, 0.5784500200602916, -0.5050692539463056, 0.3060306114650619, 0.6894066292451367, 1.496135622919066, 0.6250044756020896, 0.0067506633755800155, 1.2408714522274695, 0.10844684167035218, 0.4098140843003851, 0.9154162742915688, 1.936735532605941, -0.6009868991110295, -0.1262228358052607, 0.5552522061478984, 1.6234703089991018, 0.29188286467003377},
    {0.891543835561603, 0.4983530345483688, 1.433950464218831, -0.24690217861433922, 1.780873349796698, 1.0442616818712576, 1.1010321517533221, 1.0000352014965714, 0.9384638889041499, 0.533166946795884, 0.035965415751814944, 0.7865371591513695, 1.7123048208014955, -0.5674447646587233, 0.2875806368120237, -0.015019180243107673, 0.11272261343229097, 0.7225131483925307, 1.355210176299166, 1.0843704707990385, -0.07536137339474161, 0.11396685955485489, 0.023305775959798297, 1.4583967151038109, 1.5183652442139015, -0.07255433236352901, 1.8657623548044553, -0.6116752938527296, -0.10610791530139854, -0.0750226311866521, 1.1706112438263465, 1.3968587430421984},
    {-0.14018692398054267, 0.3220745700647586, 0.5070644480730088, 0.2882397523206492, -0.14213855260811753, 0.5996908742555251, 1.5899897242021521, 0.9271732122281969, 0.6522163354765314, 0.6772622412875627, 0.6019652256196827, 0.6592140380443187, 0.48093457536036394, -0.22173321107943414, 0.7595835241500898, 0.9421249881068352, 0.47929287224831824, -0.033318686981736935, 0.8502619262512797, 0.6797460339596503, -0.24740921438008714, 0.18634036340942764, 0.2738239826999594, -0.05376172237373661, 0.8811644270643172, 1.5098468856694214, 0.9239337661372983, -0.20578206070328545, 0.5988002121008487, 0.42923168976160275, 1.037689492153748, 0.7514819847641464},
    {-0.01717969243122456, -0.11720371529962784, -0.004704383481842895, -1.097415992560284, -0.01326008918753436, 1.3233085933596502, 1.1690297930952191, -0.2259044655784322, 0.08823846167813452, 0.8944809683680828, -0.35868361417878636, 1.3894874060050544, 1.043602911267306, -0.9660065476887112, 0.6625689780445011, 0.11529198379138472, -0.11776389439543525, 0.14020365478728058, 0.9845583374926649, 0.032415650091720656, -0.12735107032859044, -0.1080289618838428, -0.2540838472210706, 0.25820436017641013, 0.899582675449464, 0.6641809505615295, 0.06276863030202147, -0.08250935077723479, 0.6004483443961255, -0.10773768544492258, 0.1667523147994262, 0.12367381405597157},
    {-0.2116711998818446, 0.7667664296236044, 0.3841086580496086, 0.013737891744510101, 1.0220095288122717, 0.5132971965043049, 0.6375105680412039, 1.4570906267634545, -0.1859340562785946, -0.00451399692910023, 0.12714552821959205, 1.5660756948847143, 0.95254560688369, -0.15563333221829506, -0.30280259357518113, 0.6043501794655417, -0.9769598250713046, 0.7758199355480935, 1.1016378551905375, 1.1192760204178527, 0.5392352990756507, 0.14296156019194708, 0.9911813941632883, 1.4321747255471557, 0.23558999770206432, -0.26214400970031915, 0.20796352292047127, -0.17444458344749617, 1.0276948010837186, 0.17456311516625098, 0.7437540875434226, 1.373609205441725}
};

static const float b2[32] = {1.104450769403665, 0.7010973433851351, 0.9854653095481575, -0.11650275166352365, 0.9461913148096727, 1.232661902222055, 1.018111289515799, 0.8807968446436255, 1.1056193751825782, 0.6295694786451864, -0.2870932184670764, 1.0622260287708036, 0.7699491850598985, -0.13359899711701928, 0.5922300468997543, 0.7449854176612151, -0.3413406818582836, 0.37670204196096513, 0.7238942602930043, 1.0555196305317989, -0.44029933418731393, 0.282724429037488, 0.5427774253154487, 1.074689395513622, 0.7100436401902146, 0.9054981125894894, 1.110866213660872, -0.18074910904453012, 1.009520392254964, -0.1794838180169923, 1.0146557511368333, 1.114805816343393};

static const float w3[32][16] = {
    {-0.526452498751331, 0.13070309936240587, 1.1651668984074426, -1.0125492830799774, 2.014425399153397, -0.23653025431039323, 0.8878649026536467, -1.0447491428801279, 1.3729959801564573, 0.4289138324520935, 1.105685027734718, -0.6429684675942495, -0.9067618000588252, -0.12264137996654727, 0.8596758334047838, -0.194289556364904},
    {-0.2777094660182154, -0.030681285145923217, 1.0485488603620248, 0.19559284663117046, 0.9962078776376425, 0.7204829134694536, 1.2449511430867553, -0.25326429001497464, 0.7154059282028208, 0.42084297210216565, 0.9550864770164014, -1.0002994556414768, -0.3079901304590345, 0.31180043173399347, 1.6007145125289894, -0.771233480905233},
    {-0.3820223500645495, -0.3097145705096602, 0.7342785200946884, 0.6821970638154848, 1.8073873518860064, -1.0125874255305625, 1.3805660579490089, 0.8099275547954757, 1.4017866826324725, -0.7064322958505876, 0.17852238851775146, -0.5652903983387303, -0.47982070708784724, -0.14865932082873407, 0.929088293237181, -0.32141878418470254},
    {0.5711650355608336, -0.20600112430437237, -0.07390762049953949, -0.5059440707614241, -0.0467436314935554, -0.8170987891729469, -0.33791500093506116, 0.8737405029725352, 0.26895637928239974, -0.17698918178162473, -0.38105986277803505, -0.3584010912542287, 0.29141503253310935, -0.6701499577046806, 0.9292450803391791, 0.6242656019780943},
    {0.07565498681231805, 0.27285395299489673, 0.631368001389598, 0.6521349137678232, 1.6150016576667967, -0.13925005866024745, 1.1554181893131656, 0.8203902172212677, 1.996469716076367, 0.33991141283802156, 1.2878282881774832, 0.17882004071520058, 0.8187491353225523, 0.5416008416478992, 1.8821535014549138, -0.6854859339259031},
    {-0.1760421230007255, -0.6985265046406295, 0.889165077167253, -0.4770983653395481, 2.092251269487916, -0.4407818210762796, 2.25870374180471, 0.23227871665323796, 0.8413356715207466, -0.12301516753235597, 1.6389449679777184, -0.7225764829511028, -0.6501933079580539, -0.5268364679279065, 1.9552394698612536, -0.7632124224488487},
    {-0.05099285987648257, 0.13642154704492274, 1.2800733558692239, -0.5940085995774335, 1.546560210878725, -0.8064555673210094, 1.386603353492748, 0.3648802263314039, 0.5930147457996994, 0.28519460535625785, 1.2357829820714328, -0.4540375416697375, 0.12099486941081203, 0.017785285900240703, 0.8160329489728372, -0.9835801282349169},
    {-0.24866486282665598, 0.2719060695753983, 1.072092739121045, 0.06265601064922133, 1.6753457696038523, -0.7954443787485017, 0.5142015993824629, -0.06174071793936487, 0.8708719765429711, -1.0212524881558078, 1.0084085414548225, -0.909498131973887, -0.6538906892531116, -0.9819840424406362, 1.2735996541726287, 0.177427542287656},
    {-0.0530997481287412, -0.5496856487414584, 1.118737690571731, 0.5915494755634962, 1.0919582196495818, 0.605811597306369, 2.1181062337239567, -0.4142638445554018, 1.8436659810952787, 0.18005802495541848, 1.4063556306624925, 0.29558580969981674, -1.0610762660679112, -1.1667799720852836, 1.4384209555954952, -0.17672996553033102},
    {0.420097432651285, -0.6588852707065839, -0.07647667649234163, 0.5042707647099598, 0.5189854474599466, -0.4862150277965167, 1.4592394218634592, 0.7182025941762019, 0.5685669975223067, -0.2703746460296377, 1.3258123296708866, -0.4629149495915315, 0.5660537636300164, 0.15072423561056714, 0.63283950947493, -0.26917407984030894},
    {0.810417321717936, -0.9468774350380523, -0.2597413785436308, 0.23254596187231447, -0.533207843845048, -0.4686817375937483, -0.6732005254147484, -0.43031293824251177, -0.07984253689259849, 0.2531615951554049, 0.009490396269612247, 0.7171960326986822, 0.11133247860396792, -0.8089909421839985, 0.05635029391882546, 0.18662387505333294},
    {-0.9776044686851756, 0.546091550554293, 0.9115179100389694, -1.038245030480675, 2.055848262247308, -0.23516754759270428, 1.0421988157896755, -0.9787879007580149, 0.546400455174909, -0.7075957669264554, 1.3686094947064542, -0.9204040242411666, 0.2683078738733052, 0.7419326183060764, 1.6833733134487334, 0.3847986629479384},
    {0.7522109160118595, 0.6447427248041575, 0.32651777685601047, -0.1714572429745357, 1.0658914920623612, 0.4683854200861395, 1.3696451228347002, -0.8745987821669945, 0.6104959951312198, -0.599913732933606, 0.9178829656474342, -0.1300940191512663, -0.35336483789399004, 0.4316499955643059, 1.0129633804783724, -0.8761259653071479},
    {0.11196739316161805, 0.3348153740942639, -0.3125809222889661, -1.1106821665257425, 0.6841173017296558, 0.7171460962675253, -0.1958311665795747, -1.0042997027957463, -0.6945282531061446, 0.7238611372037755, 0.4020936187064171, -0.0824817664321232, 0.48748888109370025, 0.48722717948059563, -0.615286409655022, -0.8889859977734582},
    {-0.2615769145989135, -1.0048000848561693, 1.3407731293827216, 0.5684029132674904, 0.9857953595348006, -0.03609445606332189, 0.5768268727117603, 0.14001743545531095, 1.9070923851009642, 0.21341011166192705, 1.3166935122323393, 0.6191605074963527, 0.287013211760677, 0.6706680810667787, 1.601871720559583, -0.7671995602646517},
    {-0.6168638721846196, -0.32026173358601384, 0.9114962710052255, 0.21403116844847453, 1.703240897628733, 0.5599685962904148, 0.429926485672571, -0.8620054545718914, 1.3836289827562118, 0.5963079868963627, 1.4601331522118368, -0.45778359698211707, -0.29516180252452723, 0.42027631543515276, 1.567503801728911, 0.8120895172710679},
    {0.6996264832440361, 0.5975037472268069, 0.48126455402424473, -0.7822108769543845, -0.6491236953871067, 0.5191217168888977, -0.36708567373583506, 0.8047990266290157, -0.520227469045447, -0.6042040995783337, 0.7177292101845965, 0.02256930078821287, -0.663798289625164, -0.3994308257542778, 0.4048362357978613, 0.349763197644874},
    {0.48487271748274713, 0.3095330403388419, -0.6751287029846341, -0.44318100238761465, 0.41288228727924803, -0.7018314366127459, 0.7837189027856625, -0.20264374782489575, 0.20908990302130992, 0.7323659285621136, 0.33551795838168946, -0.28900798102116154, 0.6692594446595723, 0.025833032373751882, 0.8983781652012666, -0.9637780750458804},
    {0.8808220620257329, -0.8291380235100357, 0.531124222584758, 0.5962268560938984, 0.7791957668366724, 0.02529003172837532, 2.1141313690188195, -0.3947588911918223, 1.1944191540650266, 0.3735953289535306, 1.7682614200699682, -0.8873205308529099, 0.3999820384017137, 0.27316062874883124, 0.8399714264618029, 0.3765032134969642},
    {0.12205484333730054, -0.30742596892996654, 0.497987589141536, 0.3431351835435922, 0.8880334838778312, -0.7425394126368609, 1.777934207533882, -0.6432038497205328, 1.236657362875962, -0.1043330216752857, 1.4372238308656817, 0.6843567733664744, 0.468391267004573, -1.1775593275237837, 0.4285003457681799, -0.9752631198803834},
    {0.8467871779079813, -1.0140742805981757, -0.43550430446947674, 0.5923973210365764, -0.6633167621768765, -0.4123378402064069, -0.4864933267606841, 0.9046723271668716, 0.9715048698172261, 0.10802319357295885, -0.7713536526509301, -0.3636855881445461, 0.6557751991704249, 0.10614421470951836, -0.6715465288902721, -0.45148640560328157},
    {-0.24725274360107807, -0.916625095248077, -0.2288742119779444, -0.7298941257559434, -0.08813215526380891, -0.8056642800669949, 1.4878207634383798, 0.7648831941049322, 1.0949064796850836, 0.5293900928483242, 0.6434558777632949, 0.5030893597918086, -0.3890750316853399, 0.6986344321755429, 0.22091785937832578, -0.573880475801254},
    {-0.1251127549871216, -0.4240569147192059, 1.1600808434765382, 0.6716898319551244, 0.7398151229191776, 0.05269619191444719, 0.5745030503480867, 0.34332558654272133, 0.7117220051646429, -0.8401110282839638, 1.014160585268532, 0.12950768166873297, -0.45820660864049617, -0.3878002221544499, 0.9047562596948413, -0.569279916896313},
    {-0.886080882037258, -0.761708730721663, -0.17310391424122168, 0.6366970387603036, 0.9661017353475482, -0.6377415441599323, 1.9439116950292208, 0.4469980417582712, 0.9018844949505013, -0.05441635411664922, 1.4845732622677104, -0.7327866434894527, 0.07380787738720247, 0.6723120106839349, 2.0849665503653787, -0.8759496682677683},
    {-0.9043446383537436, 0.9247920527057903, 1.163351197417979, -0.5049083500671349, 1.924522668124194, 0.49275174813655026, 1.1241696477726424, -0.3750688199988327, 0.21328940071389724, 0.8304912435396047, 0.9464981773138926, 0.1494655521514259, 0.775139650257278, 0.8227325009235681, 1.0587140088730675, -0.4364596690473133},
    {-0.9569103526087251, -0.9034848071375251, 1.1172356560501486, -1.1320261869260726, 1.6797268625037658, -0.2651999758282424, 0.9412952539637095, 0.6769580974056182, 0.6059152207624368, 0.4663902245998292, 0.6664666253016485, -0.4149201291300439, -0.009865104791537032, -0.9326228692266212, 1.2337829946076682, 0.7079138599210009},
    {-0.9921985585073947, 0.17234885158643687, 0.9583969809725308, -0.753343765076718, 2.1291253201344738, 0.8478653283787683, 1.3351906966006608, -0.05585962926862086, 1.8969803518406703, -0.564528889800646, 1.7407254898039415, -0.8140585128249239, 0.5952014982518607, 0.6494498158769487, 0.36838173025163445, -0.4601256232400061},
    {0.680415773168368, -0.06386030479431064, 0.712680640724773, -0.7499659622918626, 0.292923029676944, -0.8101508771488363, 0.19149547190807686, -0.5452563009747599, -0.636058852218664, -0.6196273519856507, -0.5908642955238061, 0.7185476787223087, 0.6923021801152535, -1.0648300298255071, -0.3504557548367876, 0.6479831616311714},
    {-0.127974962385581, 0.20890658815535584, -0.36592532700811636, -0.12348202987075356, 0.46761150358347053, 0.9220810521323878, 1.9977337127239079, 0.6383585014315697, 1.0599287795268684, -0.2821178005778388, 1.2158512857247865, -1.0144431231102333, 0.09254800277314391, -0.6365559377893703, 0.6735392504121903, -0.5543114436772277},
    {0.6224494924254288, -0.7232426328475777, -0.9053144015436964, -0.8805666479465643, -0.7192521207326479, 0.13098309259688531, -0.2614338540941227, 0.023470360728397373, -0.6183683204122618, 0.13738662680433683, -0.9056513196337956, 0.09806978690004184, -0.1240031873649989, 0.6544074914876531, 0.009296000745498495, -0.3028350576225055},
    {-1.0796187492074663, -0.7715813431323169, -0.3150556562011489, 0.4124672451607113, 1.108037141591425, 0.8415369837287838, 1.5320776742577948, -0.37960714532610723, 0.5369071979142687, -0.8341221830219406, 0.6234796314391894, -0.23391393981893793, -0.29791870366583556, -0.5091005821040726, 0.9118871560192361, 0.832218427251309},
    {-0.17730730708662834, 0.1181760234960097, 0.20421842341008162, 0.3755447368743095, 1.3083339703601595, -0.8214302806208623, 1.1712884222364135, -0.4601238107750526, 1.9735164100715101, -0.2824253433317214, 1.5193437758613517, -0.4883829646124477, -0.6410122453151612, 0.3704906117285951, 1.6346086523758465, -0.47973484966992297}
};

static const float b3[16] = {-0.1913737019510039, -0.12429464946353525, 0.02198768053232577, -0.2268284362477514, 0.7437614122942061, -0.12183702522718587, 0.8777247148635058, -0.11593735865051646, 0.7717128296040654, -0.18308065972116494, 0.7892569341840409, -0.1338637756611234, -0.16123405364523807, -0.2666873800502136, 0.734914263957874, -0.05527796186651842};

static const float w4[16][12] = {
    {0.7452708641334104, 0.6854867900844155, -0.41554334221509664, -0.9761693242972412, 0.10808775190234954, 0.38070125044527936, -0.6407127300023049, -0.1387692564222901, 0.4863234804341055, 0.8017856730139042, -0.4034404478267333, 0.2012290369970134},
    {0.41445462039582953, 0.4165711758594266, 0.5212915993664324, -0.8136681507949268, 0.15113378789763446, -0.8782142356906394, 0.06446358422826304, -0.3009309518110811, -0.6141108415326599, 0.0817513400615837, -0.22956225513785525, -0.8407684989967705},
    {-0.6357817921350195, -0.018928759649591998, 0.19320126738657817, -0.5978397094470168, -0.6467833863902965, -1.5697944036734035, -0.17252970311263993, -1.6239197702581216, -0.47883886379991447, -1.0749687346797894, -0.6227586913230123, -0.42374325678937075},
    {0.30944543987544937, 0.627618178500134, 0.20186433739468063, 0.22940658146243817, 0.03296288407708936, -0.6545380202165175, 0.41902887048507587, 0.10942781686549195, -0.4707351694850884, 0.3521964423509949, -1.0055309417341325, 0.42896341612312267},
    {-0.6233643088580417, -0.2625784038431748, -0.014915337039547288, -1.1488631743723314, -0.9986583375147372, -1.6851448079543372, -1.4496676224160614, -0.18350992514538478, -1.3650646417482648, -0.7700832633204966, -2.2175432377797923, -1.1326565351852949},
    {-0.07782421820152281, 0.16165900973596908, -0.06656588097272781, 0.15458413570027618, -0.36922002941042786, -0.5049460590874748, 0.25038144567974857, 0.12168559799393358, -0.4677089759736416, 0.19008458526541883, 0.19013153809732927, -1.131748271017989},
    {-1.8827726699990057, -1.576277620658009, -1.3229073876702184, -1.5247284804269798, -0.38394278531721054, -1.3373767856316643, -1.5073357314966314, -1.3482161632746001, -1.3978160143659903, -0.8546111618738925, -0.902507507647653, -0.03550629375070786},
    {-0.8995709008810187, -0.049035871664060746, -1.035664171624101, -0.892822985301026, 0.030007393751991775, -0.19236456440136965, -1.021164323871598, -0.35161760296256556, 0.7446693704252338, 0.12717385843067436, -0.10461349095572237, -0.37954459298360166},
    {-1.1890774006388676, -1.4053098907381383, -1.5977328440187375, -1.1606438407350483, -1.4840698576766789, -0.3826329822622731, -0.2619074955272652, -0.2612346402115035, -0.7440519572076906, -1.1517323854996773, -0.5005925608580134, -0.8618142542992586},
    {-0.2756370175936516, 0.40590989463294996, -0.14014981864170145, 0.7950720859248218, -1.0041582798655047, -0.1442946827793046, 0.86063206674029, 0.17369018630633382, 0.2872517415670849, -0.39301444910704464, 0.5863808363128515, -0.18731139154286308},
    {-0.4622947154949533, -1.6132565903274536, -1.7153926386863658, -0.6448195102853649, -1.493003144377626, -0.15354783220978427, -0.46120177517110045, -1.6711021736767782, -1.035721404193919, -1.020862281687924, -0.5495940987285238, -1.7305561690239666},
    {0.7571081151820669, 0.5668397580600779, -0.5738769020387107, 0.36147892294248457, -0.4268126874718779, 0.37362882461757285, -0.4435938281127818, 0.9234180282716028, 0.7796516454780617, -0.5389740560914216, 0.9043535064428541, 0.5374753149841608},
    {0.03063093906533082, 0.5689567015025103, 0.8912562032606209, 0.1637536324964608, -0.6937873460143297, -0.795721644462945, 0.751968347395301, 0.3956901235064566, 0.36205482341015904, -1.0057487989546214, 0.8790974475302917, -0.17724704357105056},
    {-0.4630327217054977, -0.4639350820597977, 0.6196171724409627, 0.3842071090857908, -0.13723344728716771, 0.13025987073073458, 0.3382027334235222, 0.039811858398140554, 0.6154986239708629, 0.5494463078954116, 0.6154286801036802, 0.5339447943754236},
    {-1.0023553431561785, -0.7346224088139218, -1.1662032447087045, -0.6546345656261954, -0.9208235907120244, -0.9367623914006845, -1.6250859834634501, -1.2260056624602549, -0.596479535281891, -1.2574433874137136, -0.7243361163498542, -1.6463941781217548},
    {0.14015602446638736, -0.7562935620119231, -0.06588904372642414, -0.686863186557781, 0.5052732845385589, 0.14124794913291955, -0.7393417899515998, 0.4102017166531932, -0.8178324365196843, -0.3363718891226365, -0.09989432827347572, 0.704548243154328}
};

static const float b4[12] = {-0.6801710644123715, -0.5115617778846665, -0.41728463380396547, -0.6732837564695703, -0.5591813586914883, -0.6464392492601021, -0.45748580369146175, -0.5202231438005172, -0.5807552869138084, -0.5230906821431303, -0.6669467987258946, -0.4711805243260458};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
