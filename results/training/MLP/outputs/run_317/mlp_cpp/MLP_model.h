#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.3298786134319842, -0.20696365263328606, -2.165950102829622, -1.0886718240796978, 1.787704077220636, -1.7309409806819978, -1.3427158206376064, 1.7182792469677226, -1.8770439563594001, -2.0498524160196263, -1.8576016911325508, -2.2471670129085233, 0.18952643229587565, -1.112174991128702, 1.5641204016651773, -1.0396432852869304, -0.8459317903521575, 2.663369253411456, 2.086533946510709, 2.7050972987141644, 2.7556316070561437, -0.6522155947826784, -0.7056760016731659, -0.6065819205552394, -1.5574725352169208, 1.6541427855506685, 1.352462007507726, -0.9934190914085996, -1.59802484823072, -1.0504715096240251, -1.2817454688492937, 2.5403075456707622},
    {-1.4179434198575833, 0.6774976650969684, -3.187957326522838, -2.575979862079813, 3.1666067441924706, 0.23570396527230672, -1.3189665185781452, 3.2486404768576573, -3.3377979889634335, -3.1565430266840804, -3.5641651340140332, -3.0669373728078493, 2.3737194686901275, -3.5053057152411826, 3.0848433529051116, -2.926583040162932, -0.9325928888722431, 3.404286003341559, 3.234493660273675, 2.9527512507165325, 3.4667560356829514, -1.4892723594317012, -1.5826790192316722, -1.8407959909033682, -2.7954385625633402, 2.8699059635664734, 3.1785466635465016, 0.5628261943442288, -2.6192890271535854, 0.4486698052596476, 0.674034040218919, 3.6764442851661956},
    {-2.203995610410423, -0.6015543626856217, -3.2903995387158314, -2.9437584026701114, 3.474071723715426, -1.6451911231860559, -2.189734402484717, 3.4423570405265718, -3.5085090311370455, -3.03352210785939, -3.2828757446316783, -3.326857634704084, 2.2670215471236412, -2.9914155773729068, 3.327759407650276, -2.9181306437920176, -2.408861184300468, 3.906824280304264, 3.6418421083401555, 3.4913271178643033, 3.4748426441810625, -2.2512100107687187, -2.0816259274570537, -2.388522043505694, -2.782440429180446, 3.3044534754286707, 3.3551899424803855, -1.1012297368850734, -2.6542072451921306, -0.8879264373036762, -0.49519702019999845, 3.757312888997854},
    {-2.4567248316832284, -0.19451507483912792, -3.429079597697182, -3.3031925277191574, 3.120749254800793, -1.6398574331232616, -2.8813512011380027, 3.114878389104383, -3.681324144214148, -3.298671726392669, -3.5904106774093436, -3.7089632172165543, 1.5648801413852311, -3.3892213582900768, 3.194021482027265, -2.9697094963741777, -3.0301541983800364, 3.4609206558683177, 3.5300139471999694, 3.3271380542480107, 3.4195756704265654, -3.207950058195291, -2.9505692731578654, -2.9560379699125092, -3.577000511189677, 2.8808560342124516, 2.8899158875535886, -0.8457584269183749, -3.3240061922451023, -1.276766163191279, -0.9633091491535827, 3.475556466057139},
    {-2.914444348449199, -0.046805514383615535, -3.800770800803573, -3.6597648882872944, 2.5632339849092394, -1.6547908919842447, -2.969195274006365, 2.6840019766412144, -3.3762948570088853, -3.5499189249945173, -3.542352311054262, -3.7065069585150208, 1.4294848559803168, -3.104579207671136, 2.607521021575644, -3.129458886593765, -3.0572535993296843, 2.9373471760743732, 3.133022610184842, 3.2807659328848198, 3.3049664126117912, -3.307738279117431, -3.0616435378159634, -3.0049070182864, -3.93028351701607, 2.6869527035353356, 2.758008986020804, -0.8630725255846687, -3.437078500217411, -0.8409501559213742, -0.8167220584641895, 2.971713751857562},
    {-2.788058882085807, 0.03644247290760762, -3.6730877347098576, -3.7782832170181266, 2.4508110496815663, -1.3035139693307671, -2.771392089884261, 2.2872283301314433, -3.411338485187687, -3.504272832739046, -3.3421497006226253, -3.5325355592172865, 1.4883419311810355, -2.634490698314893, 2.775348129149336, -2.9248565900199623, -3.196334981402484, 3.026406430841256, 2.5343602403118695, 3.0748337317702057, 2.9675022600458956, -3.280497959927438, -2.903037475681244, -3.318873611797351, -3.461694817875443, 2.4434203141574335, 2.36594321867991, -0.7953692084162757, -3.4610850717188786, -0.8206564669986695, -0.1552634312143524, 2.840644668932766},
    {-2.4002293145185236, -0.011594513601937638, -3.838889164562188, -3.480371583938904, 2.1458306150158872, -0.7478350197606465, -2.6742308489142768, 2.23398706742662, -3.4750432089900873, -3.5584114633542883, -3.4944072569221594, -3.5315657028661542, 1.5102616458340798, -2.7426268087648267, 2.3834299406883175, -2.7031610452576467, -3.3152208010301933, 2.93005909910707, 2.567544190642308, 2.9244463100576152, 2.893000840227246, -3.319323035585857, -3.353158652518552, -3.174614200912486, -3.7566324444872334, 2.239481381331271, 2.4688458936248865, -0.5306760641285095, -3.5225589440046368, -0.5972012981085055, 0.09270949648503983, 2.7726986023276923},
    {-2.671302558983361, -0.08789997141235455, -3.5989441693172926, -3.84761289101495, 2.523339998273448, -0.7949551156139316, -2.9546614376513376, 2.1731363460985507, -3.4083130846320544, -4.02579117235279, -3.5282134825081606, -3.6113552057520173, 1.2797360123311137, -2.7406304524264824, 2.297175508493782, -2.8545956288945584, -3.5048964075057163, 2.878517334918378, 2.398449445449568, 3.1522248701621636, 2.996788536475514, -3.6260118104008905, -3.741924693832727, -3.8279115520140627, -3.71056207020924, 2.3725197187382903, 2.4531665331032895, -0.6939228731051607, -3.6459070418159722, -0.9732293412616351, -0.10217374065554763, 2.872896010575154},
    {-2.496397471970795, -0.1045472529296991, -3.798755594302811, -3.661218131722233, 2.6922266518667106, -0.7287257096979985, -2.8596572631514787, 2.3443835444885934, -3.527890488212384, -3.875901457392702, -3.3225625411088933, -3.60458697343447, 1.1779557239349143, -3.1253774682575166, 2.460272813997292, -3.123542490159206, -3.0759247580965576, 2.981116345186448, 2.4493180200868987, 3.0177044287097945, 3.109655604579883, -3.559943765866003, -3.1674788477565867, -3.5827290489575643, -3.6587780077167236, 2.4508749502409803, 2.3257505463600965, -0.9852765871767858, -3.5013856645426413, -1.0362050243414056, -0.44873387294806194, 3.1204783006271914},
    {-2.5810051144245336, -0.16363715641466642, -3.802913561349669, -3.513364930056527, 2.820327017808206, -1.1979315429278303, -2.8126354056149774, 2.6391330213887456, -3.79966351578175, -3.753570030268089, -3.8625555340188282, -3.6681599151945044, 1.6875602342751141, -3.453112318771431, 2.7212463043698025, -2.8061067693518185, -3.0656502330848916, 3.2295868655203073, 2.8111256272143654, 3.0876009020204065, 3.2400916111636984, -3.578321816812663, -3.2923300245779212, -3.512802047494634, -3.755738996781468, 2.916776034506224, 2.5991749519138057, -0.8680219228671612, -3.6003265952069414, -1.0214670044980054, -0.3592344444970775, 3.106360317397536},
    {-3.0048444228826283, -0.8706581370633347, -3.689026600993827, -3.2750755877611892, 2.5913051166800454, -0.9839090886497392, -2.9264718180769806, 2.547321451696778, -3.647717842150584, -3.843340277816554, -3.917708689734996, -3.782130559320708, 1.1492427777590015, -3.797272127508349, 2.3929260040825744, -3.0343979472704583, -3.0171279469035155, 2.797167281305195, 2.817957704765345, 2.5497817701797585, 3.101039426100701, -3.3110912149877376, -3.6709030717050486, -3.6929948945387197, -3.814775401385582, 2.074758660155145, 2.5500692058415, -1.1921248871195027, -3.488833133877591, -1.1060473010602807, -0.7258610872112711, 3.109602154897029},
    {-3.0633334985386123, -1.3264707047958648, -3.579390433053193, -3.5176092817877347, 2.2148535749071434, -1.6305338605519124, -3.398661040661223, 1.849273851835269, -3.4837115133167917, -3.8770329428078867, -3.656490429965899, -3.663939060881382, 0.6261869259822973, -3.314305809494174, 1.9965930319419292, -2.7737102559312445, -3.078528649766448, 2.470274255267483, 2.3285294086497297, 2.438990001281675, 2.6816380320585598, -3.444332470355546, -3.419627156480354, -3.6039770821804944, -3.5181287041124585, 1.6051865971807546, 1.9990070786758056, -1.8680709539156948, -3.7039376434567957, -1.6374153026521139, -1.4188479596899788, 2.484576994503283},
    {-2.8385834128512153, -1.0697741710573223, -3.7453992114434826, -3.43744007443752, 2.374040438197912, -1.497119574801318, -3.220709617654939, 2.4407323315708136, -3.5796380869740987, -3.552251323327628, -3.503238857935208, -3.6781152310272707, 1.3061463366980197, -3.417500029197168, 2.029915593381579, -2.7919202598210746, -3.3290954995577593, 2.777594954728375, 2.3805480971653, 2.299071424962708, 2.84824606133212, -3.609459730558348, -3.5013197446391175, -3.638795439266604, -3.6897147888840367, 1.7604283089405175, 2.562874073568148, -1.5253753539489372, -3.537744717180449, -1.548588959783662, -1.2396044703915698, 2.987552340587134},
    {-2.7044470733746437, -1.1310510395388789, -3.6715979336119107, -3.43959746175963, 2.4659364045299403, -1.2894594573535174, -3.088914190487338, 2.3902953943417113, -3.6571109709437746, -3.640596562621681, -3.4309219513575635, -3.913733716960808, 1.2322957569372817, -3.4184225501979535, 2.208960311830788, -2.940461628604469, -3.113091363616509, 2.630924758568531, 2.7960845853293645, 2.673813368446436, 2.9842616668708737, -2.9775683420806556, -3.5241881411576776, -3.6711268024258423, -3.519954039676451, 1.9226884249034077, 2.549880534706788, -1.6492461458243075, -3.492022751245569, -1.3518447788295442, -1.088994562489448, 2.8823834640391337},
    {-2.4824047083544905, -0.2569570426091988, -3.58900034194158, -3.5608152757532494, 3.020110279631222, -0.9176150715218576, -2.5090019295038495, 2.494511992528915, -3.3776144634644822, -3.6503885385907906, -3.528772691211156, -3.7507435302989163, 1.5478604311138384, -3.485193542134156, 2.8064715672385847, -2.768790048512353, -3.2239475965910844, 3.2622929929140554, 2.9507064708651187, 2.930964143839831, 3.402739957095744, -3.116292409474839, -3.3158925580532603, -3.308488693443386, -3.5215419009714943, 2.499507437870706, 2.7590509289009826, -0.9817315616546629, -3.4998703102536117, -1.3385701909583725, -0.36514676736124374, 3.148473917091411},
    {-2.4352982631597033, -0.1483587237872121, -3.734078029592363, -3.580540352929796, 2.935629700189638, -0.5065100424116836, -2.6374424235053935, 2.8942607921271986, -3.874366997872918, -3.511291879577639, -3.617574535581183, -3.8443788559504193, 1.7133304394944902, -3.4471771192626957, 2.644130447246441, -3.1105462482757136, -2.967450164148575, 3.301607575312946, 2.961637765539983, 3.2114089028615376, 3.5785916455814757, -3.253174262806441, -3.2977067108971077, -3.3473830615065916, -3.8454608004087705, 2.6620306005412613, 2.8724184462294278, -0.49488844044415764, -3.7566319043567975, -0.810850321039403, 0.2118246466052155, 3.1035590328796294},
    {-2.518615450697416, -0.28544798027288576, -3.6896405035535094, -3.4509196287265778, 3.2078400708305286, -0.7665606164507298, -2.4650503279073663, 2.7528058627909537, -3.5044278768859667, -3.466842357298223, -3.5142214517992287, -3.4222221533567247, 1.7078263419023507, -3.3619891236338955, 2.907799591106481, -3.3851348296794064, -2.793578123464512, 3.4355991013183735, 3.401811952183044, 3.2636336447563523, 3.2813036822199604, -3.1497898357768093, -3.0181648846520233, -3.3484074538855757, -3.542045402501552, 2.8944062662601877, 2.783791277795663, -0.705748627303631, -3.413473639153657, -0.9997148000463449, -0.2565238319423938, 3.1576264165006935},
    {-2.311558027567193, -0.9033502882300406, -3.409321017821306, -3.226622867646248, 3.4828992798857557, -1.414507747485877, -2.669244078841418, 3.2999423809428077, -3.041107161867118, -3.3737849710973298, -3.1389087802221316, -3.352824450675757, 2.0350474002995935, -3.1863912230755314, 3.3163648217372668, -2.8778253860892087, -2.5773241832077685, 3.828982106172846, 3.741839986303084, 3.413405255252584, 3.642347961121922, -2.458326815861116, -2.7212413874701933, -2.8223048857471404, -3.1798766080668983, 2.597472361081853, 3.2823674166075154, -1.257701397235297, -2.985798344517401, -1.3625007611442062, -1.007482273781501, 3.661405134069614},
    {-2.813475676547903, -1.160717396529212, -3.2785661445656067, -3.3410663551183926, 3.1987873082278386, -2.0705880586101797, -2.75824830414789, 2.8086850049119088, -3.135445827976785, -3.3850778685275684, -3.1017643246576445, -2.9032306622025663, 1.4161962531175836, -2.7855270510337524, 2.7951035106872753, -2.8645279020499212, -2.702085099013703, 3.4948478081027923, 3.174589472483631, 3.30252393221672, 3.5678297007190904, -2.7620301594319696, -3.1287372896293357, -3.208950055259981, -3.244006100140527, 2.3333799643729916, 3.0339398067195056, -1.723657382535751, -2.8451224664437995, -1.7968941282258908, -1.2939088561027825, 3.482347046174693},
    {-2.862947010823202, -1.048239387835269, -3.6298691019886133, -3.5049082432707395, 3.1872826422035168, -1.7195264710204907, -2.714178207847438, 3.1946377477928665, -3.57359905491841, -3.649978711718442, -3.4540308187241124, -3.629352240385429, 1.5443833431356677, -3.272141699707431, 2.8796997803491906, -2.847585412531135, -3.152613597535566, 3.3327526275126504, 3.2881322216711637, 3.1772076524109023, 3.146266229617788, -2.9634301673789922, -3.46993411965541, -3.19872069960845, -3.525938233271456, 2.663334304145016, 2.879765412190316, -1.6987533684595844, -3.419749726775373, -1.5501528533773312, -1.541669799310115, 3.509912560868445},
    {-2.5192679479096842, -0.8736738319856914, -3.8388653875245846, -3.513501463946682, 3.269984680079678, -1.0992370730715195, -2.71118210890251, 3.1303107962944994, -3.4808429679033095, -3.492965436129623, -3.422627762924598, -3.7728917854502275, 1.8064183647865006, -3.600172567577035, 3.0514509457991745, -3.0162449307972707, -2.9394559013487016, 3.4729123326203117, 3.2883063893720808, 3.1056046663104526, 3.4636368750165567, -3.2352179384668402, -3.637494401668681, -3.0137258908556075, -4.059723693479371, 2.6747060777858556, 3.1129871087910868, -0.6906680924896406, -3.6313265524340657, -0.7192589457180991, -0.413663323056646, 3.3745556832581785},
    {-2.3006951481633835, -0.6850697196039419, -3.3475605704950975, -3.094083395484905, 3.493557924643255, -1.348537736752187, -2.6283355673226976, 3.3554846480745204, -3.3324148527526525, -3.4743211920610575, -3.4432053317037976, -3.3765243509284844, 1.5661367706359701, -3.3250427652127255, 3.322483301185102, -3.0885358937138885, -2.4411016917079205, 3.6460444000092944, 3.5333014708687536, 3.7785361506335686, 3.9953630541374325, -2.89704659173896, -2.879392521894911, -2.755455009905267, -3.2072026092473203, 2.8672020414264465, 3.441339179852021, -1.1795090261149335, -3.3256744344151454, -0.7166211229588612, -0.36048422300000704, 3.670665072378423},
    {-1.8426188600676765, -1.0429319960275136, -3.1005312607568936, -2.8507398470414773, 3.6452453420726343, -1.5418080711882167, -2.112800064485552, 3.2605780986755635, -3.464945395702694, -3.1327089709077054, -3.196976960202599, -3.21336636480483, 1.5404536583347448, -2.898382880362245, 3.383939736544053, -2.4452670108212815, -2.117544423095318, 4.238148692073181, 3.6326127738343876, 3.7078468601980368, 3.8681322313481323, -2.365492784233638, -2.5285640261055193, -2.337779592875462, -3.0530195123724937, 2.890881380231349, 3.2212324845057743, -1.4448149575454772, -3.012580595358356, -1.151458090909606, -0.8360733754998994, 3.9065197220781345},
    {-2.4839914825424994, -0.8201638151812011, -3.3518883896785003, -3.214925418207263, 3.3396535038530732, -1.3981273929087599, -2.542916054256915, 3.274683852068007, -3.433001649574404, -3.5307819086879744, -3.410497884788093, -3.4805316081686386, 2.149403200767142, -3.249066507433532, 3.231929411041351, -2.9011611391129204, -2.754675403872782, 3.52343576126626, 3.637386362557182, 3.819324114234914, 3.598999898057628, -2.9946120959346216, -2.9656217418769244, -2.6142368705890493, -3.285530256419324, 3.149106196510173, 3.4784975800121085, -0.7743080575342919, -3.118825160287216, -1.0429712985851995, -0.6266389928982234, 3.708007469193807},
    {-2.3176716934125223, -0.40512090743391177, -3.6702745770640366, -3.23331381575054, 3.3656578667589234, -0.888566879202787, -2.5298294968275674, 3.2901054287147002, -3.6245700820065863, -3.7365547582344747, -3.5841096882522243, -3.706536974339179, 2.1517297003138176, -3.2559146992732604, 3.1530765038444755, -3.123240521398471, -2.8444837181625453, 3.51536820786917, 3.420252772681346, 3.4620242373946177, 3.4200908577348357, -2.771297940477189, -3.1051818197305607, -3.076735265011565, -3.188825317916018, 3.053160259887005, 3.2473121985706395, -0.7976794481483304, -3.1910653690895554, -0.6662464770465913, -0.13112197756263608, 3.363362991104062},
    {-2.402745986035147, -1.0122889762575074, -3.331835496535872, -3.093670852312468, 3.056307519085263, -1.2848308292041437, -2.4799691632602743, 2.731513219916135, -3.1162074478603836, -3.1616562590403325, -3.418604188580931, -3.403823188544168, 1.3887653388825387, -3.179518024129534, 2.871694789892905, -2.6389101527685317, -2.7452256455377935, 3.3720809885059824, 3.2034243139604124, 3.2942388705487295, 3.4696390050816586, -2.9452349744300776, -3.0832765159490476, -2.950539325848299, -3.3963809964418394, 2.608982059098051, 3.313254257209342, -1.4971494943187662, -3.0703461189766053, -0.9878021064322827, -1.1108413507708343, 3.544755869613088},
    {-2.3966095980722684, -0.9019211044989892, -3.4008324941777346, -3.13475822533003, 3.4688116992929854, -1.1566707268239225, -2.2843440619445587, 3.120436454962741, -3.3104736598333018, -3.308167879136882, -3.2775551663169957, -3.547248140013791, 2.1556062953039765, -3.6516586236995545, 3.2858170119421217, -2.9404943564326587, -2.689613379785606, 3.8336261940982173, 3.5473794099492655, 3.5525222927937565, 3.9289165766885, -2.8191017004608487, -3.1403546865773517, -2.9121134973347766, -3.2506705225046404, 3.0544101361818363, 3.5743652467156983, -1.2108142347492048, -3.057342641028972, -1.0478875594951416, -0.8727454515249893, 3.6447492917947497},
    {-2.4772196400588093, -1.0223930408926687, -3.598723718560776, -3.273171471460767, 3.572997694146202, -1.361243773835895, -2.4931058322300004, 3.197962372677592, -3.366345547594657, -3.5438206602458067, -3.312267989419704, -3.4873130572141138, 2.2941951758429835, -3.576974763996041, 3.011832647044238, -3.4101260917884044, -2.7643188724681758, 3.7756895701231947, 3.5418784854421363, 3.584340113161803, 3.641766248517907, -3.043733248251382, -2.992626933070341, -2.9774113217848512, -3.3133598601563627, 3.267070020255668, 3.3337607767486115, -1.0999371933693722, -3.2656096693736343, -0.9756051040786493, -0.5145481397791865, 3.5929746237734452},
    {-2.2663151530461803, -0.7711181935846709, -3.5530063402605707, -3.362791009872463, 3.640012646194309, -1.1712719902513409, -2.4604067534985594, 3.6175670325716585, -3.5280299050566324, -3.4528139413824546, -3.654180670778465, -3.6325824995548, 2.1837304267280024, -3.4701795256228216, 3.354757600050933, -3.1789698779667064, -2.7984774473748666, 3.5084335666744177, 3.5368639569255835, 3.265047520234693, 3.5694489117853307, -2.7067709206829678, -3.0197767189009155, -2.692986619557686, -3.158814292208974, 3.5618947396127054, 3.6197164918166496, -1.1032011628432576, -3.24067609535861, -0.802093383681684, -0.41471715173811413, 3.6483572640463833},
    {-2.2517474125133887, -0.41866879568278403, -3.580194681771395, -3.1622386211841578, 3.558711299234731, -0.9202081590605209, -2.5247964297835295, 3.562833889070821, -3.54293600404773, -3.732355637230914, -3.669606869599041, -3.673372796348775, 2.001450124386062, -3.668997537766234, 3.126493681615302, -3.264126317770849, -2.5511102025445407, 3.5408669302831033, 3.350711883641515, 3.3992752892108316, 3.4236783719331534, -2.850346833130535, -3.1190027537866296, -2.8075093905841606, -3.2533803841511526, 3.120906115410363, 3.2028653250523362, -0.75955097266747, -3.501767274416799, -0.901857075906254, -0.2203807145451907, 3.3695443012811195},
    {-1.1108997496381163, -2.0166968473699853, -1.001117768981876, -0.8303433649861508, -2.218268753586286, -1.8763073516599769, -1.4453330119139642, -2.2811363634619872, -0.48584537437381875, -0.6557874454443617, -0.7431111973780771, -0.4325224920762215, -1.6852060565727638, -0.3496140775981082, -2.083832693116495, 0.3654723055767631, -1.1394769739257882, -2.0716567831778394, -2.063269284875241, -1.6946321085647884, -1.4322739560340843, -1.5383571409973957, -1.0450437947610007, -1.1858484837004064, -0.831304029496817, -2.236160032653289, -2.0310758098784643, -2.669331605249691, -0.7046515860354025, -2.2041718407839337, -1.8104149643308118, -2.0586080398559847},
    {-1.485570589249668, -0.8187509661626577, -2.2518237146467426, -1.7377613503948988, 1.2113522943516968, -1.60688710253264, -0.77891002197793, 0.7836929389031554, -2.037778511859098, -2.2726338788415874, -1.9277964900938047, -2.2648394233478775, 0.07172874506356526, -1.3824744953490191, 0.7229008681489424, -0.5233800519589306, -1.1150434621616547, 1.6318354978469862, 0.9727098140908761, 1.4673667979809766, 1.8039070087905302, -0.7471129171353756, -0.2620702778075028, -0.42578910858608676, -1.6169974912171527, 0.6731376489720825, 1.128688340414188, -1.0242453492513606, -2.1724862711811297, -1.1699013560171456, -0.5740153009072743, 1.7022800381243184},
    {-2.4631623177363795, -2.7717585428829374, -0.8475510965047737, -1.3959246853890714, -2.173085314319029, -3.001922381672331, -2.2363023007590295, -2.676296489162106, 0.9411404351212893, -1.0132945179535169, 0.8191223623667269, -0.7241188199257489, -2.6526664623468217, 1.370928875709907, -2.5923890061059796, 1.2997937719308816, -2.1951308184585216, -1.591214554593186, -2.217731831618714, -0.4282671305977413, -0.7881283378950079, -2.039340904326453, -1.884989073332742, -1.7504827139188153, -1.3155747064829244, -2.3765843539691742, -2.348899199269565, -2.7374237521718388, -1.5237271047543477, -2.5744098694244855, -2.687106657526902, -1.3987427693715146},
    {-2.0488717532390512, -2.291985734476527, -0.7697639010209816, -0.8740882033087467, -1.7518562029757367, -2.375631871264506, -1.907160924595807, -2.4847309753551885, 0.19051804578333287, -0.7680726890709423, 0.2601733780731466, -1.153912156781809, -2.6771993903718485, 0.652099706787471, -2.3499826939845097, 0.8144948893707148, -2.313678276216708, -1.4657750996461494, -2.244491224438127, -0.8596907637121649, -0.5162798634477787, -1.8885074915725821, -2.12562639440301, -1.7436931698804816, -0.9747610241623302, -2.31497918019157, -1.715170190028371, -2.6180532045933544, -1.4031977074834299, -2.6146351020119267, -2.7368382529498083, -1.2230579094844658},
    {-2.8114015925679188, -2.0662588843335175, -2.2483635480139736, -2.343511676367042, -0.8401806200107736, -2.5636347096150276, -2.5869766091544437, -0.7794168103967133, -1.5202686318529886, -2.552429535028031, -1.1908412320381163, -2.4866563394249677, -1.644560465199109, -0.46738563158660845, -1.15977334546818, -0.22186816307216534, -2.505357782647142, -0.13281530133647368, -0.8547766087293365, 0.533719910331322, 0.6020700550928071, -2.458816607147472, -2.5182164541549463, -2.71066301616624, -2.576356421913928, -1.1114742340711714, -0.5423952098761113, -2.444225281598103, -2.425797897402078, -2.4109393391097753, -2.6730967806072745, 0.1799789828095949},
    {-2.4526507169698997, -1.9814170242250198, -1.829095727452328, -1.7505605321710342, -1.2049761181259995, -2.5904845545019235, -2.113759512210412, -1.5142043230112363, -0.8360021093442825, -1.8953199844521602, -0.39012647450404125, -1.6920196706687927, -1.956869497751731, 0.4105669202657771, -1.617515752759359, 0.5374150684278851, -2.4342360117529696, -0.502850867943604, -1.4831924976481967, 0.21403024233254925, -0.014316360748752874, -2.353662653133664, -1.9964109672188666, -2.396756118631193, -2.2449905176546827, -1.5884969937749658, -1.3249564497193818, -2.3987411693315743, -1.8090386738692559, -2.3731311574711618, -2.482620586899201, -0.2182309641676261},
    {-2.8581384584306355, -2.0680501978274597, -2.1678910806615788, -2.3178718413640302, -1.1309135615428878, -2.939106855838435, -2.5024603383906805, -1.3804112520942418, -0.9812010523200436, -2.3827725920031733, -1.2191199722858277, -2.239672280659406, -1.860082461773184, -0.5090726516228974, -1.1750758532144734, 0.32992264320228665, -2.513809852457653, -0.26779274293010236, -1.0085546783940522, 0.46060539358732266, 0.6203942803164897, -2.611863857317873, -1.9928594940078048, -2.5666213853029136, -2.4087140854085094, -1.4442549928277353, -0.9961893181843279, -2.4071081018928897, -2.166309775339402, -2.348650585442855, -2.571761031372671, 0.12146621888448925},
    {-2.803161210043233, -2.0554467169958883, -1.7050817873287065, -2.330863539264599, -0.9415098974448656, -2.839026384191207, -2.57889306781122, -1.1969149201737181, -0.34400885319125235, -1.9958479736464436, -0.5507025517999427, -1.9792796177315017, -1.4883895976642618, -0.09243701427812095, -1.2789355204310315, 0.4553587014140852, -2.1214037826665146, -0.6626541760935011, -1.4323755515371153, 0.4799141646396423, 0.28547898081629264, -2.422102800558701, -1.9636950961539261, -2.390173322523627, -2.014634644982409, -1.5322202306997, -1.4254811214162315, -2.4220637117107087, -2.2145053261619028, -2.653926104027627, -2.6386872496700504, -0.2685837470054552},
    {-2.6597797074142426, -1.9304461909999813, -2.1643200166824172, -2.297586537089673, -0.9612184274406615, -2.6191340159456575, -2.3567742913552294, -1.4294239392674069, -0.7425935261825577, -2.35598368814239, -0.5366908914679371, -2.3221438888522745, -1.8172321812046446, -0.06053528324837985, -0.787886195222118, 0.2758440198999625, -2.5471070360770933, -0.16122647501314658, -0.975019264368409, 0.5295407643887592, 0.5649823408898509, -2.5762582427775556, -2.2904947871077446, -2.5847014454997552, -2.468005268144971, -1.3164362794947044, -0.7250792911282025, -2.4910281220646047, -2.3844475490384243, -2.424561844682489, -2.853706853532279, 0.24611805134345552},
    {-2.7885456400305806, -2.294472230297682, -2.685848114596627, -2.6648558253607866, -0.9022531715364792, -2.738644691476968, -2.958132621149639, -1.2915380295052816, -1.6942171323113717, -2.7640126738856625, -1.3957369074929569, -2.513329720398724, -1.9488040488352376, -0.5551657293335301, -1.5279401773275478, -0.12722413990146816, -2.654566120050096, 0.18331576057948468, -0.7087916200572072, 0.9689537455348755, 1.0635182643675858, -2.7790478907454923, -2.74217042902245, -2.609946093629098, -2.9473986961265277, -0.9859534688077123, -0.871041701842612, -3.144707675657507, -2.5390815004792486, -3.1074830091780297, -2.758048894380094, 0.37721354864376033},
    {-2.5867595932927565, -2.43610938770318, -2.0600787178572895, -1.9567371216028666, -1.8318799606092262, -2.536210014852481, -2.640343285966299, -1.9475828975264688, -1.0288650465872855, -2.2185628450091976, -1.1330938864793494, -2.009932384725139, -2.4381879496485523, 0.13332434502835788, -1.7830158396283553, 0.4322300678035936, -2.355230785373473, -0.600902991268235, -1.642997933490735, 0.2078468563121352, 0.10975997090948697, -2.3258938185821614, -2.3272006749196628, -2.443902724621899, -2.064702453035429, -2.1289323169835632, -1.8591438202953756, -2.6503070804410105, -2.418500457890718, -2.6334559943391747, -2.8243776778551997, -0.5225084195658831},
    {-2.7375007419190567, -2.267664261878798, -2.272312866306361, -2.175006335891416, -1.2091757295416912, -2.6725867641732757, -2.988879654586842, -1.9927660704895631, -0.8461982942903515, -2.387352217454936, -0.572004029334399, -2.2271232993964074, -2.3848458573537434, 0.26148368898926855, -1.826325162962055, 0.5391720444726448, -2.6908626555101116, -0.6094478375195818, -1.4627296892550017, 0.14744832713573008, 0.5076112796652497, -2.9268329865454996, -2.6332739610256457, -2.610669915296223, -2.465212032288511, -1.8631446329706742, -1.3222466192462294, -2.620482365039158, -2.2122795474057013, -2.9635522958294165, -2.385983270945154, -0.25346742451089166},
    {-2.762504825910912, -2.3129031066860333, -2.839654214173187, -2.9891045864515524, -1.3338729134773835, -2.772233594002016, -3.268431907055903, -1.6944792097722148, -1.4175065494506445, -2.7961426952138306, -1.2156507759782345, -2.6998040481802335, -2.4812412286133068, -0.4157162636098015, -1.53872551144268, 0.43432228851740007, -3.03995341557822, -0.4864270399816046, -1.1125049273558567, 0.34418103519944065, 0.30983078363439737, -3.053141426020524, -3.081178927996543, -3.0449008719559036, -2.6757545636232813, -2.0477501886894522, -1.5268019037226561, -3.1673753020198405, -2.9605192075139697, -2.8246949086267676, -2.853565275599804, -0.22998478748620735},
    {-2.744015674964712, -2.5897231980366398, -2.8681865817048235, -2.721234029477934, -1.8888661633085049, -3.1390582080177243, -3.1160736559478757, -2.167947308975429, -1.7421418829160102, -2.6720221508962387, -1.0341792543888242, -2.52882122610728, -2.58130686185914, 0.08554516855967341, -1.91137589602668, 0.4492113687458553, -2.8916638924594897, -0.9211334225555116, -1.6152691163604451, -0.03975272017703891, -0.13974242635036727, -3.0406476949175287, -2.6689248632001896, -2.7704965645865154, -2.9705333628786184, -2.4341867620445603, -1.6018474662917064, -2.6229199671618884, -2.3976040306343456, -3.1308045362024797, -3.245761547509672, -0.6549164454488516},
    {-2.7968822253174683, -2.4925738873700736, -2.6793130606734032, -2.5258807124468126, -1.6812153980260274, -3.11131207793086, -2.939711599796985, -2.0357086534887476, -1.194065672643446, -2.4606878695697953, -0.996190439536057, -2.210561470404992, -2.358331027214253, 0.09890453147413661, -2.158477437407338, 0.3561187685361546, -2.8306963936181364, -0.4309112253179081, -1.363749840182639, 0.5262872720246944, 0.4471737171437152, -2.64501634047984, -2.5542835284126473, -2.6460592028445817, -2.5724489162134767, -1.9004541338740715, -1.691788111683023, -2.9610102134446312, -2.4682431221814114, -3.1498998700294125, -2.961501713226516, -0.15740642667393326},
    {-2.996272040762712, -2.7013805106282995, -2.314668906907952, -2.442455968513182, -2.2051948237106327, -3.306414160763445, -3.0494217513838384, -2.5482817762489525, -1.1922417647067372, -2.2270905932241067, -0.8977056314779293, -2.0827638552577943, -3.2267541366409493, 0.4565447341964602, -2.719991070816481, 0.22401944208034918, -2.498940781375729, -1.0031687266454778, -1.966962109496014, -0.3147183131500077, -0.5119745732858861, -2.713666123784818, -2.383677649891573, -2.4146233315971077, -2.534156543676033, -2.3237755542204717, -2.2272757716786655, -3.286461747587351, -2.2901742293626874, -3.2652759174451744, -3.212754056595941, -1.1205424951188194},
    {-2.85834944000038, -2.265929879992273, -2.0625023806848826, -2.2745217386971315, -1.7957947268397285, -2.9302670306543415, -2.75219509671747, -2.2773460105525114, -0.6679504046530943, -1.7613942269343315, -0.46605326379608564, -1.8875727982231145, -2.309473383753657, 0.3273962024798441, -2.174670085338932, 0.6888124628809127, -2.7539698539120896, -0.4448919361826013, -1.3788642877049342, 0.4881268665923022, -0.2276334001716828, -2.3948819963900445, -2.176671123425637, -2.390510003829176, -2.086357317592928, -2.037688119993732, -1.6915846178634384, -2.943787703119471, -2.0176896092726144, -2.862697573596178, -2.742541892050263, -0.5138877882526746},
    {-2.4387356667074984, -1.9926058586321933, -2.2331427947764264, -2.327891819322001, -1.292070840286808, -3.0036289936357763, -2.5415106537953958, -2.113199564361687, -0.9288875649166454, -2.2281694084418158, -0.682934199866287, -2.024038219594332, -2.262917569199054, 0.43168096980467363, -2.012571781925789, 0.1731377564023862, -2.3778340107323785, 0.034357586415167944, -1.5863952262849919, 0.17713109324864512, 0.2658578401194475, -2.2423058157277493, -2.0807577289362396, -2.3318990761511786, -2.1997631464415437, -1.9312610263272647, -1.3863247330698827, -2.877563665643717, -1.9153373470235937, -2.9217850135801546, -2.4911470003118037, -0.317327131666815},
    {-2.812663681889869, -2.5603489455899373, -1.8388737679750016, -2.5237276918904037, -2.001023503621345, -3.2667000839604756, -2.8615710398974237, -2.801140235105974, -0.6976172663925958, -2.241587092679599, -0.17360249027893843, -1.5709347821764634, -3.1186008882524034, 0.6828217762598399, -2.770985979123537, 0.8614541666230445, -2.491136924455794, -1.103981001892274, -2.173503862410275, -0.2659485935769342, -0.4641105627394025, -2.367497781657828, -2.5651973879618475, -2.406591749588508, -2.333728874092051, -2.859128939124571, -2.4066163615258165, -3.13842376175476, -1.9775427775719274, -3.225122517311421, -3.0622666969718684, -1.213275934632436},
    {-3.339748342352764, -2.631257551768683, -2.5223358561534726, -2.6353016117699823, -2.098459170443726, -3.561668552150144, -3.3950003253996863, -2.651881150785943, -0.7477387148928851, -2.5454244907127483, -0.3970617333248754, -2.1185118663060947, -2.7084104439619776, 0.7116763178260516, -2.4393871002019076, 1.3080061453493053, -3.0996900520364137, -0.9455616470311761, -2.13139928226731, 0.25790471563869066, 0.06430249269987005, -2.8785515538124455, -2.8663124096362314, -2.889283420795526, -3.0555241023266695, -2.8498627476558758, -2.190725127618939, -3.444159553470904, -2.33632753090116, -2.975602202632915, -3.578770750584755, -0.6155556462404497},
    {-3.3346461360768664, -2.8738233682117724, -2.7069071822184716, -2.7218355118822193, -1.1469924081660896, -3.106910194409579, -3.24877148865667, -2.057809769017374, -1.4568771414430646, -2.9579766773769496, -1.3089107051119615, -2.6659299870805833, -2.5500645125040076, -0.04957552040634748, -1.772560540190415, 0.3914213002210225, -3.3211831075000213, -0.5034314693208429, -1.5695334032458546, 0.8610792624826709, 0.516948927220104, -3.252509677771771, -2.7733984220530874, -3.2862040935837924, -3.206454097771648, -2.022364739717259, -1.2997668994809415, -2.7392714737386537, -2.696590445876782, -3.021293053622039, -2.8093221195933844, -0.20730075657087413},
    {-2.9143995407139647, -2.6843324462865423, -2.862060727878326, -2.6254012648038367, -0.8197984324381106, -3.1655044064120483, -3.0622240940439696, -1.2643846281408129, -1.54083977442324, -2.607787020487751, -1.0629130013833497, -2.1730634673335927, -2.348911415927168, -0.09808625563819993, -1.3362941072724097, 0.0033384510943526716, -3.0483467795038997, 0.6638138264580299, -0.18354598632386743, 1.3547523921175624, 1.2725727430167102, -2.6097825887081862, -2.2931795964348276, -2.4430635307892583, -2.6669767782431824, -1.148280063366207, -1.0577948154341976, -3.1173849050629863, -2.4942783394449397, -2.8671636318775113, -3.091014536224685, 0.7733754477630368},
    {-2.787531012449778, -2.486410657826019, -1.1859484061137517, -1.5410568184043316, -1.9773476396516436, -3.246663493954009, -2.787502390859611, -2.6858864119786534, 0.03493682003547993, -0.8615121054819384, 0.6023328769800308, -0.8172106866301465, -2.967983552803689, 1.1076536924405862, -2.302067695974368, 1.2532112758796408, -2.113082308764506, -0.5786029198327752, -1.5238353196152827, 1.1764040948979497, 0.1486161260748617, -1.9085835513154743, -1.6757032761239938, -2.055389546754508, -1.6392245318147993, -2.318730887145539, -2.2963862517840123, -3.327502236474978, -1.2677109804788944, -3.017959542136159, -3.010309952220565, -0.602716238824655},
    {-2.7562778509013666, -2.946276275520693, -1.7790642160948635, -2.3486495537121677, -2.402657826847201, -3.550691755790978, -3.15072783014533, -3.2588828966315266, -0.028892711511896048, -1.3081705986061913, 0.384906411384262, -1.2436553972223643, -2.9957237515653525, 1.3829299288724635, -2.8993362988452502, 1.2234174091763277, -2.9981502042801647, -1.2388746146905003, -2.1516978919062364, 0.4496469387554757, -0.2326938729983584, -2.7395577794599473, -2.2689125490644675, -2.600883126621445, -2.163438001114342, -2.7022012453007846, -2.6831585593575817, -3.508946675213171, -1.9688124966817522, -3.393508124356883, -3.3492913623190215, -0.9327566170382737},
    {-3.1462098239544107, -3.1315283254326216, -2.555345206654362, -2.968743777153026, -2.1985146260323716, -3.45322632692723, -3.1921992467186775, -2.8295345387153312, -0.9197011130774547, -2.2054549914017345, -0.18061648319320342, -1.9102907827271751, -2.6466440640321296, 0.23249574604470846, -2.558547687465891, 0.777040407193449, -3.044262548475868, -0.6214972528684815, -2.0250583286583206, 0.37988278288044736, -0.28495237441024895, -3.1104188506243795, -3.2230494801516003, -3.054840894531097, -3.079194492639992, -2.565950273916397, -2.5840947588843304, -3.3895682520293295, -2.693854029340808, -3.111078102186689, -3.3311861424447304, -0.47693192723475414},
    {-3.191287010146287, -3.278612447925133, -1.374476352731393, -2.024641320651278, -2.888819594790898, -3.87108256187668, -3.152197420804395, -3.254589486073001, 0.15477333960630865, -1.2040112314193723, 0.2832866683198458, -0.6593585900587765, -3.4085247745454845, 0.9441422721376136, -3.0706635464322876, 0.9189573063043163, -2.7574547953165744, -1.5460214755477757, -2.4490649594798386, -0.08455304252127889, -0.5629986059131019, -3.0214806657136846, -2.763201616676187, -2.3852868700602694, -2.047652806095781, -3.218520648172409, -3.034193079575499, -3.975029023606621, -1.614161746190608, -3.619357286068934, -3.4698531842147835, -1.5147518455751536},
    {-2.9905167439599123, -2.730481283419484, -2.015181090715343, -2.688667336589099, -2.1001121470663793, -3.075112900605827, -3.1932390354928235, -2.8060806130019342, -0.7518801742067754, -1.5371881564931065, -0.05966901380563862, -1.7684645968637651, -2.894892471783961, 0.47821194245211096, -2.5437163962883402, 0.4600949438115229, -2.4739022990343207, -0.3556689030879889, -2.0211570087558632, 0.6591765221094107, 0.19113309594130012, -2.7385749280405407, -2.5809007435016995, -2.612901038462499, -2.655232974704023, -2.4192490172002232, -2.289710346124942, -3.6029919190397544, -1.966095238201914, -3.426936112374316, -3.483906857317701, -0.6165035922984549},
    {-3.2369877213000375, -2.872257564858576, -2.1929143360361008, -2.6444058280480216, -2.5317248978458045, -3.3041317129270076, -3.2253965442091093, -2.930278852608817, -0.6397044561272922, -1.9467696545943862, -0.31702356660218617, -1.6496566756401152, -2.9719346676599736, 0.4312916546139609, -2.7979438338504674, 0.36814904473475013, -2.8541986714325764, -0.7659826391253162, -2.204337997423132, 0.6601028878619803, 0.11470004231914711, -2.943699595240508, -2.6451124534771178, -2.927698234155524, -2.461339374302663, -2.877068506284642, -2.652431041631485, -3.3680225139370807, -1.824798758219862, -3.1675989354058887, -3.0808351937824305, -1.1851492216098916},
    {-2.9646104849677353, -2.8512458075957885, -1.9682748643380756, -2.5526122777054003, -2.69636800901522, -3.610925014830667, -3.301723981353701, -2.960610900721386, -0.2399917276525103, -1.507704927952329, 0.036685626418728114, -1.103626498455748, -3.307315401369409, 0.8276295169725251, -2.927746976615536, 0.7749950585491168, -2.704566655905365, -0.89122373467153, -2.1571636812563577, 0.5335092578326317, -0.17915167749012026, -2.7532165541631843, -2.562162909899694, -2.6611668439202414, -2.4967677937761206, -2.9647969333958684, -2.840390759701262, -3.6828847827973465, -1.6675451622331283, -3.2071768244669787, -3.3103053550583628, -1.2800864311628224},
    {-2.7949272188359324, -2.93249597751218, -2.0764252092948112, -2.4759375937609316, -2.2144557462797185, -3.322155876770727, -2.71740557867029, -3.2138209759909633, -0.37772606766228906, -1.2645032651671329, -0.37539389371067156, -1.5338203008104454, -2.9682127197275383, 0.44666444839036684, -2.87254159960628, 0.31769714364054813, -2.5065975338538347, -0.6221334076813612, -1.890164995529017, 0.6442625973274756, -0.13056350487902288, -2.350808471503721, -2.4167730476235194, -2.2605201969853166, -2.4823520289182324, -2.6048451853839008, -2.5446573404846426, -3.5367202799457784, -1.5738228914321226, -3.4201029131132965, -3.1588260186883055, -0.884101797412334},
    {1.637494724519721, 1.896601330457722, 0.031516196858318794, 0.5444848636936254, 0.696033534268169, 1.2184194720523422, 1.0594192323630334, -0.6852702427554149, 0.07247488241918222, 0.061041074306628786, -0.8213342094080834, 0.22536162587416517, -1.3676033818997486, -0.5693654274476533, -0.5497852599543659, -1.3813139925747855, 1.1718387385820102, 0.9274848162995734, -0.11180522503482189, -1.2613214151252963, -0.867429978305617, 1.127510724776631, 1.0660980989589122, 1.2572468320877628, -0.04430795079886085, 1.3360130430407942, -0.11395797963478993, -0.531347352399382, 1.0103762519977404, -1.0758490972790762, 1.2592334816596011, -0.7817540706737486},
    {1.3438953142146846, 2.16926302555883, 0.16614981485523223, 0.26451825836649573, 0.8367532149626222, 1.1142746516558482, 1.3746135530278103, 0.03779847955079097, -0.31735461766631684, 0.10573891804473268, -0.9209229107592479, 0.4286776340907039, -1.0597706951905428, -0.5175795962942297, -0.17212558866406844, -1.4192771697590383, 1.2182317411416623, 1.1216041071198293, 0.5620752745886866, -0.996803891300079, -0.45058591426994626, 1.661084185194637, 1.225967763481627, 1.4778179872985155, 0.10086650837299008, 1.8899205327533641, 0.20923072663518116, -0.19771842602120432, 1.0733030665723255, -1.1454107287402968, 1.3364828001339055, 0.15146750892516764},
    {1.8165535648245386, 2.286217367572075, 0.17610044037878672, 0.8881178165180345, 0.24633660188093986, 1.3211909100786672, 1.6868149977890536, -0.6517175085884717, 0.3824170878882598, 0.3840143603589577, -0.5529046119066031, 0.29228568890813295, -1.6007115898089508, 0.2573041507201192, -0.662809215345494, -1.6988996222445685, 1.6740334837145834, 0.7786227364932699, 0.2649197555020935, -1.4021009146113446, -0.6305329019208794, 1.8648397992515209, 1.6515931676801572, 1.8488556520407102, 0.17766628218258965, 1.3159400437990623, -0.3160588635594289, -0.7468224928219727, 1.721234181243598, -1.6707774871352767, 1.1040185292898577, -0.3448353483668662},
    {1.8013594535825261, 2.023739992858436, 0.8170575560202741, 0.9088173900281702, 0.5104749865858015, 1.5169773333751249, 1.6875181198067495, -0.33806835995539497, 0.39456149126427886, 0.5751924934999736, -0.1999719189870238, 0.5535059477721641, -1.1398974989859494, 0.3756075484218826, -0.44089086206505246, -1.5180634065040568, 1.1944233785776575, 0.7682347341266987, 0.3086621611220672, -1.2480835473513763, -1.0838736919498277, 1.6670049800355184, 1.2426441932526209, 1.4811458831798026, 0.415247740880012, 0.9821546323337051, -0.4681110486151241, 0.08012212568421677, 1.7346547102855354, -1.1865922986230575, 1.1720157920023226, -0.2818453772338484},
    {1.895022739797771, 1.8661007844907034, 0.29196045342569116, 0.9111242702412088, 0.5141949761536094, 1.435602034940443, 1.1682366117238319, 0.0644735395472652, 0.00888527777641057, 0.36414256254484023, -0.6446263175984167, 0.4978504913457978, -1.2993063340702258, 0.23119077158367624, 0.01112638784848208, -1.498307115670164, 1.2553706184717726, 0.8362778926059583, 0.40652214911511314, -1.1749115572330062, -0.7262825791366864, 1.113545887512327, 1.3608530526207925, 1.4733344448000962, -0.00833207729439365, 1.251529831925511, -0.1398336708755833, 0.08552367948351414, 1.2554493458395268, -1.296666119086826, 1.4171049770499395, -0.11796582249800526},
    {1.7596081581066279, 1.884358339946527, 0.19434496060377512, 0.5678559899224849, 0.5965200855568902, 1.6670244512442727, 1.2790314312113547, -0.4934001361193891, -0.030853160252001778, 0.7467117072364249, -0.9390264927190863, 0.6429697323991113, -1.1185132506072961, 0.15549963746028259, -0.38577901279718935, -1.9367587395200243, 1.417133375127912, 0.8542200210893578, 0.25336347927035924, -0.8438126500701175, -0.6718193053957843, 1.2276824894970289, 1.2083490084345017, 1.7711776147709846, 0.4058490928119023, 1.524226903879605, -0.08647414903434503, -0.7672115594195275, 1.295234373353541, -1.832607214576268, 1.4380818157514683, -0.5052086939333922},
    {1.6476374716153657, 1.5552196386530261, -0.0036677331430817438, 0.5875862231437543, 0.359003229952305, 1.5327445473717476, 1.0536529175600444, -1.017633234027586, -0.17652128318386417, 0.42309696754104076, -0.9015098122676588, 0.4438191587714841, -1.7321319062602871, -0.398819380597519, -0.7211161157303424, -1.6451643879138973, 1.422513394175439, 0.3378684391360228, -0.3770404996278031, -1.4058159516735114, -0.8330881961549468, 1.2535524153125606, 1.3254345245820465, 1.7269004293053876, 0.12761540819396747, 1.1231658123829034, -0.3201921988005629, -0.887393391040536, 1.1333134355391221, -2.001817721627937, 1.5224620357751952, -0.8441015112946216},
    {1.9467352231745318, 2.2307585932388454, 0.46669069788748796, 0.9838304063741755, 0.43651858592768766, 1.2887255921783085, 1.865145549143775, -0.5734698983930013, -0.020821166051801523, 0.33281008280897645, -1.234736449362426, 0.5746764373326635, -1.370263042889539, -0.2693230774684121, -0.5051528616495762, -1.8149111455608025, 1.473115658680296, 0.7774821596549021, 0.01503205577735351, -1.5413467693047902, -1.1441775194063712, 1.2609557196360945, 1.4803289268756765, 1.6604911857904052, 0.022658773651601273, 1.4547333339239374, -0.36273583839497775, -0.7075530156265385, 1.5882204374102764, -1.4976459213617321, 1.0349469171365873, -0.12128411364460176},
    {2.144667345057303, 2.2901875632058877, 0.5087192297659017, 1.2025414332389022, -0.0088216665536114, 1.4699136568352762, 1.491803874880377, -0.8861433470548229, -0.1601575484692152, 0.690497208687476, -1.0375318532432392, 0.6209649735151654, -1.1608255137737162, -0.04867823874124099, -0.6558268366524553, -1.8151848809599909, 1.7277302299335051, 0.6781381869913033, -0.2133819315170067, -1.6030164197805201, -1.3610451121880045, 1.5825021761735691, 1.7700969318557387, 1.9235087825833572, 0.40033273459886753, 1.4713985392369744, -0.26080062199738596, -0.5243004154333776, 1.8574687217245929, -1.526314233550721, 1.435856073781287, -0.30062416387375335},
    {1.6123560413580307, 2.4757573574590324, 0.5105439802282742, 1.022270656384727, 0.4473525715198735, 1.5087891964000484, 1.5058367604875582, -1.117072929767298, 0.16449800769080575, 0.5816214468077866, -1.0608738592083626, 0.5766072625165028, -1.7090609596820736, 0.1913026748493243, -0.9671449325764403, -1.5552057803165398, 1.7420282075001703, 0.7067368793196553, 0.12721240891137178, -1.6800234052053145, -1.159500354724477, 1.5258924703475123, 1.9751552166060637, 1.9358014698007806, 0.2780914032379188, 1.3310199904730753, -0.5245656531683043, -1.0265222345684264, 1.9022199187411228, -1.6900874084230755, 1.4517210725832708, -0.26047519398788777},
    {1.5311426395563368, 2.1042482248810623, 0.42705667849034085, 0.8350027921023122, 0.21336745728898585, 0.9792786468249334, 1.2153094008222536, -0.638486531470034, 0.34560549579378896, 0.5941003542716129, -1.0334980980387336, 0.10682472461872708, -1.5291589789702222, 0.20106051289253185, -0.6453875068650414, -1.7840846690130148, 1.5463357906537107, 1.4815433496173875, 0.25998266300539563, -1.4401363276365375, -1.166887085511194, 1.5742525473709787, 1.5473098856515815, 1.7358127965178223, 0.16112043766037842, 1.3421810210621592, -0.12990620488635596, -0.8327852964679388, 1.394912293588981, -1.6342046418363465, 1.41241974259423, -0.027510292140927393},
    {1.9859012593591772, 2.4505471042512776, 0.7316860331838441, 1.221895697470386, 0.6131467243726554, 1.4891136460575762, 1.4314108606943352, -0.34438192442222276, 0.14783680623801232, 0.5934200762748955, -0.8229863297012717, 0.9566352031366787, -1.4897869059346336, 0.4431078427779297, -0.4341150920073683, -1.8969466451094295, 1.589105888099676, 0.9917952089876161, 0.48464729567256076, -1.8838972103038656, -1.3989702178061143, 1.6209564388802307, 1.6519344314204558, 2.3358642158477663, 0.6011641065590019, 1.5771021219608161, -0.15079992225730798, -0.646197572638212, 1.8510983914089993, -1.4714065860073318, 1.969168499335359, -0.33181102072067226},
    {1.986277553215438, 2.296946166988255, 0.8078879532917266, 0.8737440500444311, 0.5977731166706429, 1.0559511787746014, 1.6219737529691174, -0.7128097730806588, 0.11654756786676668, 0.6203905067346155, -0.8337726304425588, 0.9479820769392685, -1.4955231151724528, 0.27577519841917203, -0.16911159919048022, -2.1272040883776095, 1.672214477460117, 0.7490523635688487, 0.09977176255931064, -1.7856454461383398, -1.5113956280947949, 2.0240429549596297, 1.6211307774258155, 2.0535571617543544, 0.5340698343477207, 1.5876017210455453, -0.4500039390775322, -0.8198430729362902, 1.7799192089627316, -2.0587339241522753, 1.532921636083635, -1.016870548349516},
    {2.059953526681654, 2.23345161705784, 0.9708096330330755, 1.1139173407661216, 0.4743038954739633, 1.4051003770556383, 1.3809250076111055, -0.7479106594114409, 0.6434646614975963, 0.9077131994882317, -0.5000365526424632, 0.7025754249595016, -1.5043549918984498, 0.4173746276573772, -0.3930968481454512, -1.4671204460980358, 2.086372209052993, 0.5467790563440812, -0.09197052259383692, -1.7534343245051855, -0.791315702333025, 2.200057130959778, 1.9053395431573916, 2.4443024754312748, 0.8655114829246753, 1.2269562156720315, -0.4777001443503728, -0.7896468037005873, 2.1728233462865805, -1.7159681678612264, 1.4853356776548776, -0.6244203926014552},
    {1.6338778673023018, 2.417107696228403, 1.1607798207697333, 0.8278977069254501, -0.06864356188199276, 1.249146924883718, 1.2436485360733396, -1.0522990847134026, 0.3488849135108003, 0.5933068136038645, -0.4824812300309063, 0.9683048620912214, -1.9321572332197166, 0.298973882265796, -1.0374886950876103, -1.693714806328194, 1.7250111498586376, 0.5287077038024506, -0.02233377342862014, -1.7602365579376498, -1.3859175126787553, 1.933732017481888, 1.8909845898113993, 2.02974442049862, 0.8711948980839571, 0.7522158976752934, -0.7253606027825621, -1.0780626729145217, 1.9003094316330182, -2.0723215937855035, 0.9387329311094728, -1.1615768021800845},
    {2.1196949138739574, 2.3395624330379134, 0.7777396066261171, 0.9700967522664127, -0.0033449474027499953, 1.5092048290731428, 1.2061412260439262, -0.7409413944882227, 0.24528213884675149, 0.6506144753340383, -0.830884684611371, 0.5946184244614342, -2.293013829281967, 0.38403151990617956, -0.8188704996006596, -1.7937654292810743, 2.060262212514737, 0.9153564416677648, -0.005353821896453099, -1.9512650953967674, -1.2430425573824073, 1.5689224290621364, 1.9089653498151873, 1.9158187508173325, 0.5357573967378184, 1.1644932898056477, -0.5681426262377204, -0.6729579513281396, 1.8805215247394729, -1.9838753315581186, 1.730568540563529, -0.807499417242713},
    {1.8247514627687498, 2.4521333219817265, 0.4263458526820261, 0.8107557687221596, 0.4686625614799377, 1.331252688731157, 1.0916811253622234, -0.37994012581907965, -0.07049168372549654, 0.11314187890909216, -1.0019413342743375, 0.7285053606902755, -1.7784496857352983, -0.13846275056470558, -0.4143309120575554, -1.5742191142117665, 2.0243662159130356, 1.4114821606851977, 0.7276027052488243, -1.5647774359777142, -0.9210797963710777, 1.5617041972942924, 1.9897132783614795, 2.0644627026226305, 0.6345620970698392, 1.6130521918562644, 0.17748988676290833, -1.0054290027659127, 2.1593131321733563, -1.5557130366614862, 1.8034488570832088, -0.04874304640059361},
    {2.0494850239064535, 2.5821520141211667, 0.5830351372852167, 0.7602243034015241, 0.2261497449057272, 1.7918608925967225, 1.5741954769757915, -0.7347201937519044, 0.08877499886555378, 0.5441139864614309, -0.8692018035594877, 0.7763220780620514, -1.7712203278351906, 0.14369978083235105, -0.4835271155156869, -1.8235831869442862, 2.1754797050123256, 1.2220655245348575, 0.416795637236027, -1.776103502722813, -1.0528132307431057, 2.0850402437871787, 1.9123097573895735, 2.20939175051642, 0.5809377001167111, 1.3210356390421347, -0.35607911728641695, -1.0959311362064117, 1.695091291736632, -1.5662705832947483, 1.9982619999508462, -0.33295339572829125},
    {1.9125675528579273, 2.1519232069140948, 0.7443691521371795, 0.55993873655871, -0.07367451765639961, 1.371559651716548, 1.902399582083439, -0.4954630487632816, 0.2275369271718081, 0.3917618494339202, -0.43299508614759163, 0.5385547726320176, -1.527407204613013, 0.17149973477928565, -0.5523152354139531, -1.8308377950667425, 2.1036652281614807, 0.5788626157405168, 0.24362843885072294, -2.074835681601618, -1.5775255340951815, 2.008515554072205, 1.9058293680103628, 2.293180241060757, 0.6197948728635013, 0.6347190900523506, -0.5028182264664148, -0.9994334377357095, 1.7403045844257417, -1.381888131425643, 1.701175755309392, -0.7912442889723605},
    {2.1081010672087372, 2.6008777862634185, 0.8166207018223515, 0.9405862518417191, 0.38191400596062497, 1.6913903880163708, 1.8936541767771273, -0.6876502305104908, 0.5927507219518571, 0.7226385249572083, -0.46713561306358914, 0.5213792502113238, -1.5834768886905037, 0.24668919559035768, -0.2859219680145542, -1.6495841341528843, 2.0687772371022355, 0.8518240057628113, 0.28577813264194707, -1.7992192199285666, -1.2765525782056493, 2.160844292317499, 2.0855339896119456, 2.4782656450644787, 1.1491625854976402, 1.4592842074426657, -0.29180159276983164, -1.045278143452812, 1.8622935313262874, -1.765313047787622, 1.978817869049879, -0.48254309995882666},
    {2.1092577336969125, 2.1567107499778033, 0.7784899060379187, 1.1666432170842012, 0.43651887608072587, 1.683073194574537, 1.9592637655923328, -0.18455872399519624, 0.492956989292421, 0.8027722971796739, -0.6169042739978404, 1.0514783978904383, -1.2824846701018087, -0.06834280399366992, -0.158025339310954, -1.7968011019059245, 2.081623872256944, 1.336693916634842, 0.3106127667595493, -1.9580106650150775, -1.4945171570507625, 2.1044020012886513, 2.026227558224026, 2.3702610443651824, 1.2400231555045276, 1.9060529485218727, -0.2152283860202578, -0.5583894778141479, 2.2656589377574163, -1.3589175435932805, 1.908217519991394, -1.035290089959443},
    {2.293765236403552, 2.6604822983625485, 0.7736387462134726, 0.9490013818383589, 0.6698779908006587, 1.3643690833848365, 2.0383649484903854, -0.32739655916817373, 0.18253072546227342, 0.7852913913956743, -0.4425236039949876, 0.9594574305466088, -1.56830862368156, 0.13657694090256828, -0.19028042710826662, -1.9155658234035773, 2.2451649389811887, 1.4142698358320633, 0.6685608916490257, -1.9129307470670933, -1.4054362372064793, 2.2703471219297158, 2.196389733598729, 2.5912953353401442, 0.7926291410642845, 1.8514885034236395, -0.016414486209843638, -0.8454535846769563, 1.9288385769304737, -1.89192969267744, 1.9474920514922853, -0.4609499529087095},
    {2.0747591181639846, 2.7415659870971467, 0.7860888495780718, 1.0193282084783926, 0.17871482679334236, 1.9154717882504424, 1.8057154487666063, -0.6147108314602622, 0.08288517804236326, 0.49121810688459905, -0.5819865293941572, 0.6957435879444772, -2.212930599793608, -0.043424617186918216, -0.413944915293442, -1.8298298752292472, 2.258305391751597, 1.08891908520076, 0.2824985721775523, -1.991182722649056, -1.6328287332809495, 2.2083078461554364, 2.17954842052949, 2.34503895605923, 1.1419697433253047, 1.4995180912356032, -0.384563812425201, -0.8447959088849035, 1.6784719998269932, -1.9714220816546473, 2.4158403820790424, -0.7895118781567674},
    {2.2924668865804447, 2.709495401725726, 0.45603729616619487, 0.6129407078184339, 0.5244454790123617, 2.368410626919505, 1.988411297618754, -0.5990553735294332, -0.05643542725989276, 0.4729542875950319, -0.8141339525992355, 0.6912437584917867, -2.365078494436448, -0.040338031952234135, -0.5169402406985646, -1.9445585548006281, 2.2234582752715464, 1.0108239257522527, 0.3154851536875784, -2.061690704453164, -1.6267311833318185, 2.0331544263137658, 2.4963158564836125, 2.4038444748243433, 0.754812263998731, 1.5280772480108638, -0.4890469974701486, -0.6473626029868638, 2.0025460588652857, -2.2630538651294936, 2.078428034644215, -0.742917978761202},
    {2.2574307191592933, 2.703970482934231, 0.3008988352753089, 0.46132912967520695, 0.7352346038177499, 1.8918584743993545, 1.9260048126282578, -0.36862335070106655, 0.1010418878117393, 0.4960125751547138, -0.8776900163462792, 0.5237577736072148, -1.8678172152140893, -0.177562354657538, -0.22041713593489362, -2.3694806156436887, 2.284164448570414, 1.387747411808442, 0.5290978389795696, -1.9211817479561693, -1.0419874975099828, 1.9900128270608037, 1.9404826294899264, 2.1910667132446346, 0.16864950077225346, 2.063042040726858, 0.25503728609566284, -0.4837091892759016, 1.6918344311924047, -1.7798483043797744, 1.8706993843475934, -0.6062433194388058},
    {2.5992006159553225, 2.786326348921758, 0.29998416664290084, 0.9761554422296267, 0.48385212923218873, 1.9923207107415202, 1.8404422680969525, -0.8524596381255549, 0.16554541927259117, 0.5598197174339768, -0.6883965706348174, 0.5943456038993119, -2.050022239383659, 0.0962153983654352, -0.5999439368652602, -2.0611645215139682, 1.9811314508461602, 1.173953269071803, 0.09906697051949524, -1.9682622934334428, -1.2278749305737828, 2.189872096515664, 2.2608064275568376, 2.5659017425239, 0.2885628362217941, 1.7972112614821214, -0.4250541762220206, -0.8595221971411338, 1.8952820116580031, -2.4421004485446036, 2.156257460143866, -1.0982381816483637},
    {2.4787144945492274, 2.816571155988595, 0.5285986717848804, 0.996680630339285, 0.325906437982555, 2.0738352785131267, 2.294962305692887, -0.918543595333452, 0.2819111283328326, 0.5884731335698984, -0.47058093059390116, 0.7175853205954621, -2.1580445374567616, 0.2504868446829628, -0.7105200941840718, -1.8266290977164703, 2.3073553771533213, 1.3409001591055447, 0.1520580411906604, -1.8972888312412435, -1.2204323344155117, 2.3865143340721997, 2.4519457559409985, 2.620732301637829, 0.58364752143857, 1.8446088458161751, -0.39808291405649643, -0.9908725180893735, 2.1289119116345163, -2.147169115284051, 2.1873889007588407, -0.9292237914870545},
    {2.0666492540253354, 2.818506879218774, 0.6481975432347736, 0.7585753887166552, 0.03752290022374523, 1.5558015129275242, 1.5450182187464048, -0.7306622245084758, 0.3569067111890118, 0.6341376789144687, -0.39859602862994575, 0.9598103134653538, -2.6697937304255146, 0.015776906611414235, -0.8897234185660379, -2.146119640087306, 2.0125035642893527, 1.0082677311954786, -0.0254217713590845, -2.0853074107911214, -1.3004119035421369, 1.9488172944274258, 2.3188142467557418, 1.972318401591868, 0.26855395415167366, 1.6984202437405216, -0.6108877659157703, -1.202817551916048, 2.2411496220159908, -2.6098930181114994, 1.7531354070770906, -1.07328468191871},
    {2.156827440905594, 2.6558540724360613, 0.533395031695388, 1.0476157617529496, 0.2205886911527802, 1.7540934983984113, 1.8123975847102165, -1.1883836389277547, 0.2680871837801092, 0.5633669342667452, -0.652291395897214, 0.6249730399903091, -2.552670901335713, 0.2374035000862465, -0.868697449195673, -1.7911595912795335, 1.6614096281300585, 1.1550564867827529, 0.08391276489856499, -2.06818916401089, -1.565718369037462, 1.9435683502315064, 2.235817179413464, 2.2742778781253237, 0.33666396323125386, 1.7344962086911166, -0.7237606347718019, -1.257551063982052, 2.100054737522048, -2.4964408762053463, 2.1720730804421593, -0.8021591409824304},
    {2.3099133602862225, 2.6423241068219894, 0.38904903553267056, 0.8799203557613117, -0.21470414416742278, 1.8816101135727665, 1.657510680861389, -1.086866102143181, 0.16304631248417345, 0.7289715444448217, -0.6127957641225412, 0.7327156137020913, -2.3315111125798555, 0.1834085649950834, -1.0403443115396718, -1.8171994218795633, 2.1905613370637105, 1.1668458741343417, -0.1582596966234095, -2.183476874695883, -1.519097901744971, 2.245638067112715, 2.1581047497305823, 2.5768359418940894, 0.4921996484687413, 1.4537863176951715, -0.999228990502403, -1.2351433390671611, 2.0813480393442436, -2.486030781148245, 1.9392133777896294, -1.2520512732480675},
    {-0.9741288173273778, -2.080459535231882, 0.5581049695478656, -0.29028502883056223, -2.655313381517665, -1.824145901882658, -0.9792266112294408, -2.4712146093830243, 0.9907100386329872, 0.7826436371019061, 0.6427885369648265, 0.9540907561441452, -2.22670634171418, 1.3883989838304827, -2.3942502385933935, 1.4494596921631482, -0.5385662013393073, -2.67030924298683, -2.435801874559828, -1.4481229338697115, -2.0527576335408884, -1.3697803976174017, -0.8681308035387173, -0.9696835834159365, 0.1529679696852962, -2.741346732310205, -2.6086122433533063, -2.5939624927377696, 0.40420745573771905, -1.6587084578607425, -1.8358984638223825, -2.0665716098275855},
    {-0.6498658152970063, -1.4756554764005958, 0.7434199960528048, 0.3663174889322103, -0.6848430792194233, -1.3689399170804863, -0.22694744749403545, -0.6672864842467215, 0.6554507065774923, 0.6604568582085204, 1.1858599240371026, 0.4606967776652626, -1.17143850824986, 0.9541291349455238, -0.7975855261738889, 1.1929788145338551, -0.5446564255250288, -0.7211710888530228, -0.3567821489881501, 0.38899570601516503, 0.224675344204204, -0.31402766017369976, 0.45047026194571316, -0.2994209607842009, 0.6794135320329364, -0.679763272186219, -0.2029376935567356, -1.7584776246163385, 0.006489124380426679, -1.247679810356199, -1.2097127268112609, 0.10391701731901774},
    {-2.0609192851159515, -2.7626182923150675, -0.6116707242604636, -0.9274714928501331, -2.123074671630728, -2.4646472066083502, -1.7134316553775442, -2.6381827851634134, 0.5128383386463781, -0.5116998929645676, 0.9798563468804042, -0.4257372233958005, -2.2391243851061664, 1.6162420552369228, -2.6041883503504795, 1.4956119813813196, -1.738603566167066, -1.6985792879627293, -2.2320426260309154, -0.00036273314785367295, -0.3359306318746868, -2.319166972321291, -2.0510856651597713, -1.9903106854631412, -0.9553701849559378, -2.053145252173596, -2.1802767558832254, -2.783906529020443, -1.152837474642989, -2.333716012584929, -2.261431741349272, -0.9344314154414891},
    {-1.3365531534416106, -1.713080414321631, -0.13393205579052292, -0.3517156382614562, -1.7365010260156575, -1.8128314241838517, -1.797618102165493, -2.3955200005439687, 0.771779617159978, 0.18643754452003228, 0.8794027996082645, 0.28774200306162073, -2.386511344730406, 1.144198285572949, -2.3291980688545935, 1.2707876653648968, -1.4775228001064311, -1.639625782682032, -2.2419280668164308, -0.5894189590831843, -0.9791357537502644, -1.423457342926763, -1.8159062298217077, -1.381408367538155, -0.36888858399400004, -1.8222306494203668, -2.0969167980395116, -2.166693170177643, -0.4653266779745521, -2.109184137140463, -2.157440711625039, -1.868298081466438},
    {-2.10116556194045, -1.2882831480819803, -1.672145635467618, -2.0176269498152584, -1.0558666315082406, -2.528455973904942, -2.2382122677333967, -1.4325969974268495, -0.45607568633630696, -1.3569338030857487, 0.16309904415127768, -1.4576825476188213, -1.9121640572393905, 0.3500097697311217, -1.4689433790811783, 0.21458667641383253, -1.9729074804563036, -0.2712710160511679, -0.9377925862904418, 0.52487924630684, 0.30516582510786455, -2.3553264996353835, -1.806658426127995, -1.869046952909953, -1.719643782553391, -1.2856639240158427, -0.9912653450353667, -2.30810052314411, -1.5672013420898323, -2.3695705819019484, -2.3759552326146, -0.2672787218996492},
    {-1.7136802483074822, -1.2785881249406537, -1.1338838941654656, -1.5634712015575332, -1.0347234299361052, -2.0098001198479793, -1.765084635933228, -1.1783657800553924, -0.17572147923688303, -1.225107052122918, 0.05785979643064768, -1.4896072011009678, -1.2350716306065432, 0.23135996283634477, -1.3372031227830177, 0.43837994133311364, -1.8023545325665709, -0.7359106466867709, -1.394340208580194, 0.3787281714368129, 0.12668884410267536, -1.5317341691639754, -1.4875040568079778, -1.7306645948318002, -1.2513256541086546, -1.1909672223090118, -1.1132542754202854, -1.5471756562010823, -1.3390317475137774, -1.947580307366697, -1.7952510904598198, -0.06225251538925517},
    {-2.432324222447668, -1.904347040898724, -1.2928261731435557, -1.4712164692495753, -1.2222642827553838, -2.306087977988814, -2.2088065635694245, -1.2741826317542966, -0.659350733179917, -1.4038613416558898, -0.6631238828804653, -1.430838980543171, -1.4870462647899556, -0.10407499762802355, -1.3881875252726974, 0.3096996638553983, -1.6537406893600748, -0.8993424245459258, -1.3453403810083495, 0.22306645763016764, 0.5103874365059611, -2.070351830826171, -1.3649135676761046, -1.6314343173536543, -1.698522637662477, -1.4944555698875166, -1.2079300209076507, -2.284306745486771, -1.3435463885744034, -2.408906426810481, -2.2847830342100854, -0.5961209038161106},
    {-1.6560758768136943, -1.5931362394994382, -0.9631424576057163, -1.332911691163757, -1.2951708855029296, -2.0547750460380096, -1.8109508976539468, -0.9787692968529353, 0.06567256182144517, -1.1138325850328545, 0.15139683890290895, -1.2155824339316268, -1.284063273334568, 0.7250310039535482, -1.03889830261539, 0.7954550882911641, -1.348182642104185, -0.9733296509483645, -1.2009896445193022, 0.43627372733534325, -0.18361163449997217, -1.5870142021295894, -1.4528817787882937, -1.3901949064639025, -1.3183901622228265, -1.5148432663315934, -1.0898345867332786, -1.9302579493933032, -1.262027359994226, -2.072133091967371, -2.197881609970063, -0.3222525434247683},
    {-1.937783637264511, -1.8935820380625956, -1.239674463103549, -1.2768164655997574, -1.2337477552418938, -2.1039455832034557, -1.7589979977959032, -1.1609809483783693, -0.05432526390847001, -1.422697325868553, 0.2979413195270927, -1.2326964892679901, -1.4930179279116549, 0.582765870235729, -0.9750901300470254, 0.8602376443171159, -1.7270424779366593, -0.5895303098347581, -1.1314652666686908, 0.3861551923284024, 0.07550671688816774, -1.9636645445427563, -1.7810676731510282, -1.378499381181536, -1.4669736470483705, -1.5447550164133195, -0.8398320320210433, -2.1145115149042404, -1.7062939305438312, -2.0823659171416518, -1.9398936341384188, -0.12509296626750963},
    {-2.3602628672519264, -2.2446226613106655, -2.107736551638575, -2.167511113124131, -1.302489023328973, -2.520524541970061, -2.551947695776867, -1.3423283644881967, -0.35499249522095455, -2.193437759116789, -0.4163422335835596, -1.3926842234772288, -1.4247741970133783, 0.7362864142637727, -1.3870234528569294, 0.8768785544511536, -2.056334315039136, -0.22749460324207565, -0.8139727292153491, 0.8814374547691519, 0.6612159823305349, -2.54128692953724, -2.093398388897008, -2.306934254276703, -2.28467124289447, -1.4165501674739147, -1.2350236382629467, -2.720839264658955, -1.8439550826072264, -2.285766071902448, -2.537392618560017, 0.0428061616485747},
    {-2.04019694410663, -1.8438841731843747, -0.7631183710452812, -0.9418645716673607, -1.5305359916375805, -2.0209877465975383, -1.8692312309405785, -1.7429072812643414, 0.04419606138396549, -0.7664140024375092, 0.16624493591192002, -0.5226274654719334, -2.1520846979990034, 0.8244468637059186, -1.9623232857697837, 1.1815684936064514, -1.8612313704979413, -1.0074974094414948, -1.9344862866929822, -0.013470855171259387, -0.0035302296860567255, -1.8578731749817208, -1.4175424835080377, -1.652942591394247, -1.3726096105133279, -1.6698992822857188, -1.4355836920936342, -2.055115510929612, -1.2400537921344372, -1.8901111954099146, -2.1354688238267734, -0.8501808882194771},
    {-1.9523067409138428, -2.6736408992523253, -1.3657083538705763, -1.6317501986083893, -1.5282079371146522, -2.071045798713912, -2.219373980012081, -1.5929892767509195, -0.057605414147346254, -1.4633125664935607, -0.2396555673101623, -1.0164977501871701, -2.01861275006858, 0.556275368806052, -1.9927831949096428, 0.9165961211121949, -1.9395911975308664, -0.6969503552095364, -1.7685538662234999, 0.3272331418931856, 0.2727481357417224, -1.8074272500473982, -1.851147353989604, -1.748864373045622, -1.8927117854712887, -1.6926462752186204, -1.6826930936634827, -2.2088226072929413, -1.7232263992063641, -2.522513035771537, -1.9500211348467213, -0.9509696732920875},
    {-1.8986513999577936, -2.1406753794766056, -1.670840035751413, -1.8032362023276292, -1.4960508084593276, -1.8789224158681184, -2.2653925539184385, -1.2271682506685673, -0.3428625630834928, -1.7697943368649844, -0.18765338215230232, -1.4019448351576262, -1.6245754934184646, 0.4612816843113581, -1.4628202564681445, 0.8364572815700554, -2.1825853739223198, -0.9215306462498538, -1.4159195473690545, 0.2729076287973207, -0.16451669918812248, -1.9681877736391906, -2.062120160916141, -1.98683376050488, -1.765957809916765, -1.804717085515159, -1.236922904315675, -2.2085479826025725, -1.9010397829979566, -2.5016688663958995, -1.943619882015473, -0.4734778852480715},
    {-2.08930645393764, -2.005549635749596, -1.3397853669910011, -1.5839378149352838, -1.7592360011265058, -2.3868536481841884, -2.233964481757892, -1.743829585198812, 0.12931518609719886, -1.2244501751645436, 0.18818043267302123, -0.8145249738494204, -2.3494279536991254, 0.48581883626459366, -1.991613763178214, 0.9997085481360196, -1.7802472352218601, -1.6183084118821252, -1.7320453229018544, 0.1740219382167497, -0.39100489577055353, -1.7570691149501099, -1.779615227336528, -1.416262851436147, -1.4646612546566677, -2.306934980954702, -2.076236190985967, -2.5524430300932615, -1.5712262181206391, -2.6240872953099856, -2.421407460859982, -1.1499579654252055},
    {-2.346758566680427, -2.008844106667811, -1.5330372085936324, -1.5612249961432831, -1.9526990052947604, -2.813527384266255, -2.609308476418228, -1.9509465118371194, 0.030314018150497397, -1.0922412671233122, 0.3093763703771595, -0.6046589208242279, -2.008088012257317, 0.8546023922677184, -1.9203390135061038, 1.1191159187280941, -2.4017756368971925, -1.2469948850426684, -1.6635249504394798, 0.626072430158392, 0.37095209298009774, -2.2733146935688087, -1.5900019489166393, -2.0398695091997423, -1.5684734053061158, -2.0448606041271, -1.7462731725889395, -2.879204204789725, -1.6782716051337452, -2.1549684342980036, -2.7502015831397943, -0.5297241386963767},
    {-1.973023088558059, -1.3466671228134521, -0.9506143238807797, -0.993442305022546, -2.4355810834945646, -2.774618847564158, -2.2109083146857906, -2.7765567324616423, 0.26763718569013245, -0.7015026520451656, 0.3663060624562649, -0.4656016358968315, -2.398797678333733, 1.425904886454794, -2.4895877677619325, 0.9015734394279811, -1.7939528913820084, -1.5654317000323967, -2.0572291646231573, 0.08329741825140513, -0.5096554915382356, -1.495525447222379, -1.3484613695350616, -1.5443181811325668, -1.3501436984129678, -2.654803836452855, -2.556327214176876, -2.7018303367469447, -0.9011715145314297, -2.3835962593686237, -2.6510198806723833, -1.6438024974513101},
    {-2.211122089792858, -1.82867926708638, -0.9354135724803676, -1.075897913648394, -1.9788396887156727, -2.5915580892763046, -2.299671133257207, -2.6453729813485127, 0.3978330062628276, -0.34478739207190995, 0.47907006870376106, -0.6781300237938687, -2.3299990935350308, 1.3770459177803205, -2.1565981319670033, 1.388110366645412, -1.9333024837013895, -1.0374235376445113, -1.5724009687589535, -0.04006678279717039, -0.8814950736914633, -1.5581699588018223, -1.031611599066568, -1.6570105717525359, -1.1740881039660518, -2.324855450680315, -2.2334910266889016, -2.691140422634474, -0.7741695329239576, -2.314133590728135, -2.372492347818974, -1.606234334395604},
    {-2.45007381583213, -2.1642889374138283, -0.9925504246662284, -1.62322931511824, -2.534071175613022, -2.867711251599072, -2.4987396593346305, -2.8307383838458557, 0.6458892963698969, -0.5359062862007409, 0.7116965678868401, -0.3378819254236759, -2.7425638128917744, 1.6416839484874342, -2.40436752023326, 1.1957091650319192, -2.049790059956478, -1.600494558697839, -2.1335580838153843, 0.01714920006533621, -1.0512439398030773, -1.7306550828642502, -1.3733335387920917, -1.8159944431851087, -1.2058957532860537, -2.6658210786692305, -2.435986481312787, -2.977337819071813, -0.6723890130954328, -2.9830927490417802, -2.690380692254019, -1.8140707506295757},
    {-2.0257523274548532, -2.1943505987606025, -0.6397008546248796, -1.1107916137283, -2.7135871697656415, -3.1534885965893173, -2.210463607077246, -2.800522939102447, 0.7365528752691824, -0.6707654562688178, 1.0347577871381406, -0.03367209958409962, -2.7730666354222486, 1.7931715973152096, -2.5851795350277063, 1.3849575640363938, -1.7279163874680814, -1.6495420561396432, -2.055255089656114, -0.43868876611536595, -1.1390546885268193, -1.2047625803202198, -1.3571042793393948, -1.6356232215237039, -1.159614276474356, -2.640443313013887, -2.6719847942844934, -2.928536492241683, -0.9723766304445339, -2.4370092466968543, -2.5036396351464663, -1.689611279690928},
    {-2.283942287235165, -2.010578820955048, -0.9725386351350372, -1.158910625263382, -2.400070105713331, -2.9342319025914207, -2.493318798871014, -2.541492944290864, 0.6553198058059151, -0.7261747633194204, 0.8901103914796891, -0.7070887659896844, -2.6464561278857466, 1.5512504305257784, -2.2133242842765917, 1.8129264158319183, -2.1832330615011553, -1.7000777302574581, -2.1951691390209067, 0.06503913167823856, -0.5099937329801943, -1.7987735992617202, -1.5832079325948931, -1.542177344231426, -1.6544202906778809, -2.414586377894633, -2.5400231545836616, -2.808081598844779, -1.2297348897616678, -2.692712646394966, -2.710754272529254, -1.1599460499903471},
    {-2.4645934778435286, -2.346772329472236, -0.8422304644789652, -1.7658627104074514, -2.5797797572685526, -2.9918667052634773, -2.345004668996397, -2.8743555875037274, 0.44893548094908786, -0.8114572954301067, 0.9303920748518699, -0.40034732750438085, -2.7353525750743746, 1.5471533415197851, -2.788717373066105, 1.1160528041208408, -2.649267237840006, -1.6335878419600747, -2.2685330121703005, 0.3650914101797635, -0.3985922193476282, -2.420451073942062, -1.7354813890613208, -2.0710135242093703, -1.6981460400327568, -2.5724879098613807, -2.2092342428430176, -3.064540597740872, -1.0364419962394225, -3.1561490022885192, -2.4230899354006605, -1.4154760248639757},
    {-2.627962248356904, -2.8786523591788837, -0.27633200375647415, -1.1092887839526455, -3.2397768015920896, -3.6006135203914016, -2.2387932447535452, -3.6200821043857374, 1.1895616243195137, 0.20416039234500963, 1.552764979024109, 0.6975181597196105, -3.1511463315657418, 2.327821490924627, -3.3514239691444763, 1.8316043702038016, -1.8136265950171597, -2.370331773001823, -2.6077483247433535, 0.218498202284967, -1.011624847605693, -1.7503956468852624, -1.2729909130780204, -1.5966431687223754, -0.5291631345931507, -2.7469244842059894, -3.0701843048875697, -3.589249863191826, -0.595212371751847, -3.376029361800488, -3.273362488806383, -2.156840920850834},
    {-1.8668900215245798, -2.583684133503054, 0.8988005704016377, -0.26626540679015187, -3.6094915991141097, -3.2931604409261297, -1.9939933432626342, -3.8113468535376764, 1.7044165119185508, 1.4316240522392463, 2.2580706518469076, 1.8026999670680348, -3.657286246367247, 2.719181803319198, -3.5009041379285275, 2.368839898848869, -1.2963621546533157, -2.860946692514761, -3.0258995910373323, -0.4319380167655273, -1.9041490694223753, -1.444233346471249, -0.596725888482956, -0.8058802106671664, 0.13813381081118672, -3.112574912588442, -3.4804989531002914, -3.7938233567682613, 0.3343827464873206, -3.177013566183438, -2.921197184133985, -2.9939439552859395},
    {-2.636806767137489, -2.9823879989934547, 0.21271889433163982, -0.6280829079645581, -3.4227397340756736, -3.302599404450483, -2.522543896562592, -3.8297015361070876, 1.6319138911667785, 1.009744703469152, 1.7471893113001553, 1.3828441568417937, -3.2252634820755293, 2.589859682764098, -3.412529754158601, 2.2385677864112683, -1.8091080772628305, -2.7309404745385155, -2.955690988296806, -0.5830822678428631, -1.8188584333763, -1.5725286908530067, -1.2953692047408165, -1.597710322382369, -0.43399371537808695, -3.362682812705053, -3.5130099375820816, -3.6830654168100994, -0.42502756557279586, -3.358659065289364, -3.3358953810590837, -2.538935924539243},
    {-2.7778388080804226, -3.0673145138938387, -0.9659750947811596, -1.866813967627624, -3.025865308119729, -3.387884975927474, -2.862573470411243, -3.115388489912856, 0.749870754587185, -0.47955508764420757, 1.1595548963214843, -0.17796054619882695, -2.9579252651510344, 1.6320977470662281, -3.2271792998264286, 1.6622051854925952, -2.4196103819704735, -2.0740110945461034, -2.839459617662024, -0.03314629147455647, -1.0259246958224564, -2.2973390620824, -2.0462047927669604, -2.1993859352995035, -1.3807444920361533, -2.8713957370726266, -3.3045152419728736, -3.390673433903947, -1.0700197074143503, -3.2617817536354194, -3.182192001020873, -2.06295751044039},
    {-2.623389062008862, -2.5886604060970506, -0.08253476523175605, -1.0233559521553552, -3.545655087806927, -3.6111197113239886, -2.594313928832221, -3.9478001075973608, 1.5385125098981707, 0.6073386307146935, 1.6689487117915272, 1.0850721455429662, -3.6031605060359033, 2.4346983101568163, -3.8538234590329967, 1.8341224651419166, -1.6422258231266003, -2.533756595435747, -3.263214789456247, -0.20895039438272095, -1.7440391649244897, -2.070306214899384, -1.7123782401646122, -1.4046709308591379, -0.7142966584328628, -3.3896340602004957, -3.510680222677845, -3.8633690971084054, -0.3902293972732751, -3.2466205525493943, -3.453732744561323, -2.6125014434022398},
    {-2.9558589027180666, -2.978004907844415, -0.221460087359693, -1.3930022826889783, -3.3786503880955667, -3.777863798231798, -3.135112570163082, -3.7052875432659946, 1.1920803574335825, 0.41222119515873346, 1.6290984459960847, 0.439719682499225, -3.4705953934507137, 2.1848701907591654, -3.749110081100574, 1.933633733915157, -2.3007742058105167, -2.1773304713773314, -3.104173356352528, -0.3818504543232544, -1.2441763626619533, -1.9608006778741445, -1.973754291677295, -1.8574389682524044, -0.9426742962620052, -3.513559067417882, -3.69686727745286, -3.8255201490545474, -0.518103684336284, -3.449986467999293, -3.330560435870634, -2.806055535853357},
    {-2.8717409160502725, -2.9003184819533767, -0.3032256189412987, -1.4782932542168392, -3.6517536195509033, -3.3941851194128785, -2.7157503832164407, -3.4970853518734515, 1.5737909885869725, 0.10779261657111229, 1.4857175187848224, 0.4626020915549906, -3.613955632942149, 1.8926739450143728, -3.730868708913836, 1.634275613979298, -2.3996999696049723, -2.535290957803637, -3.2409354178900305, -0.08318047815388316, -1.4713910233253729, -2.2854388665755576, -2.018912410538629, -1.7904700250081171, -1.0321823957806653, -3.7205731662964054, -3.7164156690509533, -3.812588172510213, -0.590764746885398, -3.6535928880386073, -3.494765560394846, -2.888570163054999},
    {-2.450626888212321, -2.906850920275765, -0.12640887705500667, -1.385239678061619, -3.3742949727546745, -3.470209895963562, -2.6678063464477706, -4.142517913229787, 1.6231849902582223, 0.5526555725828832, 1.878490882391726, 0.6197166163423631, -3.544927283785198, 2.539282393241403, -3.735836704125622, 2.2617018196017997, -2.097121504146145, -2.510834464032448, -3.0676832956816296, -0.2519196102788459, -1.64008373614723, -1.962368882647578, -1.4879949223408302, -1.5118450125201015, -0.664132541554676, -3.4736040297599042, -3.5962064769149222, -3.788874848192157, -0.1972325317371775, -3.510282123093229, -3.2012767522705037, -2.7088598120374607},
    {-2.3405159829254236, -2.7782990933102694, 0.3281449960135775, -0.7675345541361269, -3.7339526323268353, -3.3617037632169837, -2.4038157666585254, -3.902836633357424, 1.7648057693006138, 1.0466872270917884, 1.7387448434043153, 1.0556331808368695, -3.255008077598474, 2.6432612455572957, -3.8494806195051914, 2.013788930579449, -1.6754404954404187, -2.846356030523384, -3.3157069467239944, -0.4462277031994831, -1.9224040901459731, -1.5540121326008818, -1.3393590715699106, -1.2912172034794722, 0.02356013894462104, -3.6621756450559375, -3.7502850601807367, -3.727057927254944, -0.21177825790247942, -3.2112756929227784, -3.3035692447082967, -2.583970106661952}
};

static const float b1[32] = {4.401745714320621, 4.573211959269746, 4.373208912559892, 4.249258631424971, 4.3791645238851205, 4.506278379662601, 4.385385531071201, 4.523197644240446, 4.246980991700273, 4.413789066681034, 4.434782071575298, 4.430180221461921, 4.537727802876061, 4.450652936640063, 4.347347801083109, 4.337662875439751, 4.374689559859588, 4.471216382361323, 4.444389165476381, 4.425702780489174, 4.471688923889781, 4.410717053629339, 4.434470982006075, 4.507619585610149, 4.27746039554437, 4.492174331380361, 4.300928010181698, 4.46777908836127, 4.4274687530511425, 4.523405382240946, 4.479205704195781, 4.426610385145324};

static const float w2[32][16] = {
    {2.5771573203985105, 4.05797763241771, 4.3133677595002755, 3.428287320658033, 3.6119013450634085, 4.167770920300447, 3.3361282603217353, 3.3225182354886504, 4.155877104037045, 3.4276982805685106, 3.2044114205999406, 2.6915809645345674, 3.796846944040483, -0.13880394969957352, 4.188338479409942, 3.7646441544324656},
    {2.6695362794155093, 4.125930194746047, 3.6871546195253053, 4.012578416639656, 4.369470304818716, 4.227690722872259, 4.173684519755946, 4.025214601452523, 4.363391326150087, 3.5267300351337405, 4.172218475243001, 3.179136654712727, 4.0726201188260704, 0.29513270458378377, 4.111691949898799, 4.269300654368795},
    {2.4359190557876795, 3.987180129481176, 3.6423678106121513, 3.4207967828867627, 3.584637263755755, 4.1523514832505874, 3.5316671085979157, 3.6257083142583086, 4.041109661951047, 2.9264917362823293, 3.391103879685017, 3.2828426004984164, 3.9302036753082525, 0.30091402003202317, 3.3836953352624586, 4.071777296190259},
    {2.738025039986075, 4.036649453869505, 3.723448375554497, 4.108583741635235, 3.917632161317966, 3.4960704372071674, 3.956217817377229, 4.022284567535137, 3.5614939985803478, 3.5490389288903925, 3.0277274251451685, 3.1575299525823484, 3.426180378257736, -0.18523430831223353, 3.9275964669633647, 3.332524380007456},
    {2.508534731625478, 3.6887963021572108, 4.017123638480998, 4.10071824928559, 4.190859641039472, 3.9415608070919186, 3.8876203023345868, 4.121675686176874, 4.010980088701796, 3.5346867753521387, 3.274459747507937, 3.3440228573137505, 3.7580844715562374, 0.3593638359515127, 4.359221723477502, 3.544427814923035},
    {2.652138229854869, 4.167353284878684, 3.662831814920455, 3.7390778317240905, 3.825716885381505, 3.9848599383026766, 4.302589139351326, 3.8940381953590135, 3.7914778926467614, 3.3979377153732906, 3.690834555041564, 3.3188396768630906, 3.8122350561876344, -0.041838987765883136, 3.933924234253284, 3.8931829880809516},
    {2.6371026979873826, 3.7418221932339444, 3.6946372242365046, 3.630824531399375, 4.019813353698883, 3.7614694778223092, 3.918263722592059, 3.8055679600365195, 3.986587554051431, 3.6251179887145066, 3.2887188748632843, 3.400928264532541, 3.7674906531784833, -0.25152173934758465, 3.8505307439881653, 4.040395129718079},
    {2.5575714682589132, 3.8066464216168674, 3.607293301801952, 3.827518539655052, 3.981390185068156, 3.5399185586263995, 4.058633542911235, 3.4795631874514887, 3.854065792354444, 3.4644635085769857, 3.2147374872338985, 3.0546454068806055, 3.3465107138121075, -0.17132347230593878, 4.0917789592809575, 3.8169475856225246},
    {2.9001823803095967, 3.6731364293477804, 3.830473819694488, 3.989569175075373, 3.8647449886358802, 4.270900279142669, 4.024817157922159, 3.68122802055043, 3.789974484171405, 3.4024099963856336, 3.5310188524400865, 3.6256535065619113, 3.9065379828915767, -0.2559172553768048, 3.7377311295604385, 4.04272635088467},
    {2.630654129304364, 3.5722768114679484, 4.111347521810419, 4.033686214989634, 4.039981726752504, 4.306702815105237, 3.968015423724911, 3.964336275286535, 4.329214532540619, 3.6945150464762238, 3.3449414766438963, 3.260308703210528, 3.9066010490605607, 0.018163795224170255, 3.5612343502127684, 4.085792168658303},
    {3.2503789626154567, 4.108948878989389, 3.5101756401015494, 4.08236793159476, 3.764997287388128, 3.958251195735188, 4.414911031541064, 4.337293049281549, 3.650050815520483, 3.6012007502994243, 3.694152492126537, 3.2652242515282044, 3.938499820853472, -0.20316040679253608, 3.9239716134090363, 3.7528879987949746},
    {2.4711819392339063, 4.0171826357965355, 4.028699433884016, 3.59310885303082, 4.102629242042635, 3.6025631512505076, 4.072308884796638, 3.91082080513641, 4.458554190825027, 3.4280733527252494, 3.263094549994836, 3.823336990690675, 3.760357360884978, -0.22184450211828552, 3.467580317615401, 4.122710683388436},
    {2.8609692006915077, 3.891668840165101, 3.9526440040633117, 3.6574084755654104, 3.923504310501605, 4.085826241040501, 4.306237709640258, 3.71011798804157, 3.8525988204309294, 3.429704767225425, 3.601151964168328, 3.356119819041542, 4.263562166978321, 0.13161164326254904, 3.991646449819007, 4.059379875595315},
    {2.941466386650666, 3.812376382869057, 4.25537377171331, 4.468361577713199, 3.8863422997459414, 4.377593373386171, 4.144430415178293, 4.181500438476127, 3.8405735645185897, 3.648300221325736, 3.6015498600281304, 3.3051282293097235, 4.087728867218845, -0.05550839493299411, 3.674712203872667, 3.911308953167777},
    {3.166805451460022, 3.7646007031193047, 3.505376372024316, 3.8446122113544035, 3.616377333810912, 3.5918396572709934, 4.0695764605386495, 3.836392579548719, 3.933771235784077, 2.9891133547512023, 3.3426357726764913, 2.742639040031395, 4.050762146110236, 0.21368769956507, 3.751565995830366, 3.7523333745000524},
    {2.615082474270982, 3.567240727688689, 3.8790029755324267, 3.6528493257000885, 3.8817184132634615, 4.027110205765579, 3.7935188532008457, 3.820481325840746, 3.846763141069233, 3.6003157772807577, 3.4473453471749536, 3.4398563044447044, 3.9207646867008514, -0.27708562989673025, 3.5390014970871664, 4.02161983317739},
    {2.441510158434533, 3.6883974062024465, 3.795725003046785, 3.9086946372576143, 4.288572022357473, 4.335511558184211, 4.230273001400885, 4.17232370671208, 4.025053935470093, 3.719161260100829, 3.4706471969330837, 3.358397605770948, 3.943422937579127, -0.06326645506590409, 3.664190741087296, 3.8214970579751277},
    {2.9055960315852514, 3.6487472577833757, 4.02187295254086, 3.863897982142944, 4.082619005356631, 3.695744369402972, 3.94835326050702, 4.070244083554297, 3.9076147570723836, 3.4171651868526607, 3.4074144003693974, 3.274954455312569, 4.080147056846653, -0.1314315160007185, 3.771584753050852, 3.814498400215689},
    {2.2732493354130594, 4.390727086495682, 4.130737882997209, 3.61935390731281, 3.5020595715455785, 3.822462133818707, 4.134113899941883, 3.927349407134976, 3.573158528117715, 3.4374932346871763, 3.3008873683198927, 2.9825695650615867, 4.011790928076252, -0.13005357802179932, 3.659471553296295, 4.126993151779807},
    {2.733310158792225, 4.089623407646921, 4.265810487697547, 3.689832662781031, 3.78693082194069, 3.937382905816025, 3.563959082731196, 3.9726742413876894, 4.0011510329913405, 3.3723721664530064, 3.2898026976856327, 3.0509878366845533, 3.8807196631167575, -0.1225123987458878, 3.3776643819348724, 3.64887885741165},
    {2.257944492597555, 3.8054052701739542, 3.953580095006002, 3.5541462664270633, 3.998881882587627, 3.704251644896415, 3.7971812792004784, 3.8418581650387695, 4.099802518715634, 3.2558965752547846, 3.1813966613023767, 2.7573908891987653, 3.8934604072907537, 0.14322657966794938, 3.7674516402844964, 4.054165835824726},
    {2.4502138486206606, 4.014512216394397, 3.8089113037130393, 3.4600131794285356, 3.564689023916295, 3.5945320534771543, 3.717579347034016, 3.834431763585228, 4.180255231208962, 3.0742500435958022, 3.1986883524327565, 3.1923686918905125, 4.071144497562953, 0.009524632378768428, 3.9781445626400362, 3.7228195733931155},
    {2.5932181983824925, 4.33699425096804, 3.552073730503095, 3.6861199269873905, 3.645883054621398, 4.156781636469867, 3.5887795650642498, 3.6866334842838118, 4.228384031016312, 3.5049784833132365, 3.470156226032444, 3.2261263806329317, 3.5838105383166776, -0.07995444218660408, 4.139803503050608, 3.578256241609888},
    {2.229666792548642, 3.8345468833512673, 3.484620148954382, 3.813404774083868, 3.6533672194764697, 3.4110445610666393, 4.107683330418265, 3.4291191078672663, 4.1812126460016525, 2.9553566777055202, 3.5121180662235933, 3.673458994654408, 3.604197819970628, -0.5693506673961402, 3.894397826743052, 3.9128517819985063},
    {2.6365952476792573, 3.5097646120526673, 3.962976335196701, 4.0210080790169105, 3.800400943889283, 3.659941306930889, 3.7913988056687384, 3.470750660276065, 3.843512990468789, 3.444552985524085, 2.6227110737297283, 2.916809872170498, 3.6019522647365734, 0.10244596523396335, 4.211813721299063, 3.448336698627296},
    {2.7327497283529856, 4.191521972252126, 3.9654673647161487, 4.096186636857789, 3.9460994519716617, 3.7407419385048266, 3.759600855559824, 4.148521185869468, 3.531238888924792, 3.3398380121532423, 3.850264994374196, 3.008024719843635, 3.684093380084279, -0.29981862332945014, 3.957543865560635, 4.335033613359765},
    {2.7243111391819927, 3.8089184005442216, 4.0477081264288195, 4.1226895654897655, 3.7437882572058765, 3.9481419745885695, 3.897200594767726, 4.076419067138278, 3.771229658396337, 3.6040069195210385, 3.209138751377751, 3.35943313007774, 3.9844739939657394, -0.30333645013045246, 3.8789320286925753, 3.4717360953324703},
    {2.4138368279878137, 3.8728675830286483, 4.406834441392051, 3.752099339847369, 4.131447528549924, 3.9820267391766757, 3.9953339247291573, 3.72868867891973, 3.675809949426428, 3.4865618782751593, 3.8255067224673462, 3.3510351236524905, 3.6804362978165215, -0.3625965017108245, 4.104233921658829, 4.191176562231282},
    {2.997166224090995, 3.3374447941534506, 4.41854257349665, 3.827484608922771, 3.715268936584109, 3.9931025382975545, 3.8280270731165356, 3.807194180091176, 4.06962124909752, 3.594242712176764, 3.6885324878142867, 2.9556659437823214, 3.9667508462496937, -0.24383733266681565, 4.036247493667757, 3.8720942177803126},
    {2.508004800984692, 4.18880776104808, 4.049677153114342, 3.8630731549925157, 4.019378219451721, 3.753919640755151, 4.273281130843252, 3.8282721977010494, 3.8841287590508466, 3.548063997319619, 4.01712027112994, 3.4921925034433734, 3.519809635619122, -0.04774738079767258, 4.410187733186528, 4.003318437129241},
    {2.7612763796778315, 3.7322435494407062, 3.9150646892947316, 4.31101893463245, 4.372553966081516, 4.220841783947639, 4.393240160843458, 3.571753342376405, 4.402100144613456, 3.6157953390455377, 3.3321768487222285, 3.2045052738086808, 4.189949244236425, -0.17149900597137516, 3.849439077587299, 4.400132031711303},
    {2.6063126399849827, 3.701498638578621, 4.1959259913388305, 3.9375922583595466, 3.9406501583991336, 3.505835176379267, 3.705624039965908, 3.885022689299633, 4.4914479519102315, 2.717867889888936, 3.114024817322943, 3.2503588206180343, 3.9327816736482943, -0.1408927402879561, 3.6344849356975804, 3.714402131069524}
};

static const float b2[16] = {3.395284699792838, 3.5403763175738034, 3.756045922445918, 3.7243113788651616, 3.6455595264595417, 3.6859181054464596, 3.7584229686525163, 3.696500069789332, 3.722292797918059, 3.66430917755069, 3.699719977639283, 3.4515347672402825, 3.4910060795462123, -0.05759991284717744, 3.5401686352022312, 3.4029680025302893};

static const float w3[16][12] = {
    {-1.3018174093305368, -2.0074006724840117, -1.5866376164176064, -2.3759669842989277, -2.3667496051131014, -2.2982078956972685, -2.144869180077338, -2.3064598784485364, -2.1156664361389868, -2.169191299885263, -1.9150638321295297, -2.851669812118564},
    {-3.1738688644856152, -2.7523791659152823, -3.39533985635608, -2.940299427096474, -3.214332214454623, -2.6246555898936674, -3.7699377082809478, -2.9159658846815724, -2.5590683357630417, -2.9519243160102517, -3.3251948852281306, -2.74666980128317},
    {-3.4499426621423317, -3.700742609179208, -3.198043427197521, -3.301052116757866, -2.7511096895634073, -2.9330858958992456, -3.083446161065824, -2.5520222142675983, -2.7100263745052953, -2.978379783037867, -3.0184712895496086, -3.400281453484827},
    {-3.308212548770744, -3.355526453622768, -3.2560208327543303, -3.070010777796764, -2.450779167391274, -3.034115835668292, -3.161044997840806, -3.225195489915219, -2.8592765192694465, -2.5605456907634845, -3.69304093743347, -3.023425969912689},
    {-2.8262304714049207, -2.9362528890904005, -3.422760520044837, -3.432949107922383, -3.064317628989754, -3.554687222736681, -2.5002759665357486, -2.8422810087766277, -3.7356245524629443, -2.9224712785769347, -2.9386528062764943, -3.065298746168386},
    {-3.6564021444419765, -2.6201029556645943, -3.194775468071784, -3.2847500765142437, -3.1644776939435135, -2.6483732473042823, -3.407689494240945, -3.402770158515723, -3.4357377592710834, -2.89379467530629, -2.96408026267444, -2.9899110224840637},
    {-3.316552556519012, -2.9618499172744532, -3.016378066562833, -3.115561579653131, -3.5658095599477626, -2.9776086632620786, -3.3318345950917267, -2.9464202018920407, -3.017653474555282, -2.7745188997094257, -2.83054995852387, -3.2886321187411642},
    {-3.1682911784100303, -3.321510005075102, -2.9384239424274896, -3.2732274803404233, -2.6826867078062366, -3.3774243996580644, -3.45528306791985, -2.791196359139432, -2.8611931805245767, -2.9245814520498747, -3.4738843801795216, -3.192532414533536},
    {-3.317566820167811, -2.697825327584975, -3.1505322936170237, -2.630754559329845, -3.3153343853749235, -2.9934019497067035, -2.9685022829471017, -3.6913213358990262, -3.090620709361246, -3.139772421483354, -2.880138372768104, -2.8736886122982597},
    {-2.537331841416639, -2.56485169670624, -2.979059311344056, -2.0018547680634247, -3.189300171001273, -2.6095427350841733, -2.5567620629200296, -2.7311379707474153, -2.5394385505510098, -3.3740143961375275, -2.387982346992804, -3.2286436529320177},
    {-3.0762599241336432, -2.7813588029289895, -2.5960594829369303, -2.9583029379207684, -2.3981721158536193, -3.2073920769651005, -3.0157265649516645, -2.700030739145333, -1.93973767185156, -2.8680651972799347, -2.9364440417787416, -2.4179827530606177},
    {-2.259978465887968, -2.3613758310339237, -2.619458505778529, -2.5487974976378167, -2.7238679948625193, -2.693169241349267, -2.203127089361582, -1.9524369123267085, -2.9832085838531777, -2.4920444385645846, -2.3852095075052664, -2.2093703231177444},
    {-3.39166270842431, -3.1294339250935757, -2.82239861628102, -2.651901301529752, -3.3774702186885563, -2.863242637064313, -2.8469507624128094, -3.1904458507142297, -3.439805131772727, -3.881941294132644, -2.878052990992496, -2.801739139920595},
    {-0.1550176456057207, 0.31856192979709197, 0.3963651589881174, -0.06973263417318441, 0.21001487793091408, -0.17997088531162628, 0.19049797043230815, -0.09462764660182651, -0.3894544767274241, 0.3874229105831667, 0.4557500174485327, 0.015468404175268857},
    {-2.8348491630826915, -3.1837286578356463, -2.274465220030403, -3.8324614505662358, -3.0105410636313024, -3.6365233189459936, -2.774522697734502, -2.9600387337855456, -3.706499310823165, -2.7308832197461848, -3.4562799554113344, -3.400360594493712},
    {-2.2337451001833935, -3.6675515079272376, -3.543326276911431, -2.598778325148656, -2.948746845682165, -2.873900158205868, -2.933754308374605, -3.847625007171671, -3.0992026551694107, -3.6557814200818224, -2.932405097855217, -2.8323956689800585}
};

static const float b3[12] = {-1.2706390942990198, -1.3589956507968906, -1.4035797555801157, -1.7144191339256343, -1.7715735864357645, -1.9813504030292617, -1.281104086598482, -1.9584088265359896, -1.0108405797464874, -1.312741570370833, -1.0726875894782517, -1.5772543682098379};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
