#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.4942617537669967, 0.2506193014925464, -0.3245327450822158, 1.7235754650115729, 0.37681321477536556, -0.7934864295132427, -1.6457149670628237, -0.3037466121266121, -0.9375485313028071, 1.3116469056086528, 0.9245043300499126, -1.1825197757236332, 1.2771127266362028, 1.6607862132708093, -0.5887395000208427, 0.7897389807756453},
    {-1.0569582386158811, -0.9169247223745401, 0.10115130799381476, -1.3117880302787746, -0.0425263290367119, -0.7153750070830451, 0.12513982548071748, -0.7927175993955954, -0.5523799091663217, -0.41150954419242547, -0.6179254075113454, 0.846489824855615, -2.0151572336248886, 0.730724184824865, -0.6794739174425858, -1.1798862075878012},
    {-0.36920654385945534, -0.050292813900781046, -0.2686839653273233, -1.3930264474103953, -1.168304754953099, 0.21851693150264714, 0.5116865250764863, 0.6659979101640601, -0.2684382876404234, -0.4462128673949925, -0.9600284466979755, -0.15973944859614916, 0.17153783878709264, 0.6726384252024266, 1.1504308116994808, 0.5187690925644372},
    {0.7889562953342893, 0.08460710278414856, -0.7026078280646306, -1.5145637431632142, -0.34289490224989133, 0.6047280890238546, -0.1619146286400151, -1.0970001133549243, -1.5063950571707012, -0.8701585956287914, -1.1354166577838467, -1.1991804263291117, 0.955752753424543, 0.8510678546857241, 0.04628058639074282, 1.828811545217366},
    {-1.1415685762828092, 0.2798404408584149, -0.11524031698734774, -1.3033585720874281, -0.4787547060773516, -1.1877608927418966, 0.48855243092721123, 1.1074839936421519, -0.7189321653489298, 0.176284230916006, -1.0402358580625635, -0.20051520780647272, -0.11816379002960334, -1.1582932557007273, -0.7197508890356932, 0.6237918361472364},
    {0.1618382155631044, 1.8127738310533794, 0.19456133433245396, -0.7559804327386307, 2.3593244513888734, 1.2578835838980762, 1.7315426067948076, 1.3543054024976042, 0.17564286158844283, 0.5883428346506417, 0.05567484692159478, 1.0182140737393077, -0.9806677909781076, 0.13827896720463873, 1.3697731772664783, 1.4041219832035425},
    {0.588252812958364, 1.8022494403934906, 0.014476814669547249, -0.5234289487395843, 2.2124658126286456, 0.9554307949508675, 1.3547337822238268, 0.9659995907745567, 0.42851586295814265, 0.5117017189010689, 0.09216803188976855, 0.9721216162605115, 0.2511970250716465, 0.6736815738794023, 1.8836941948919976, 1.9763304719262604},
    {-0.8081810953640317, -0.59388595560298, -0.38313722166820124, -1.246174965261765, -0.32641219673577104, -0.7057388693527842, -0.2667422967962742, -0.5020782756267128, -0.5957048762976513, 0.5371377533107236, -0.6517119242537124, 0.17163992589977067, -0.2550835349442897, -0.5663311020089362, -1.5795633719912165, -1.2876475161936156},
    {-1.227515591022188, -0.3927101383693149, -0.7787463930094131, -1.4009039948248145, 0.3231374079577045, -1.787510782045802, -0.5520275857277058, -1.108538307783477, -0.6826400349159436, 0.03314012570325167, -1.5403094167985185, 1.0771746113949645, 0.9101401838032981, 0.7245679831375982, -1.3265900205664578, -0.2979612154439904},
    {-0.28229200259749365, -0.7666894024336999, -0.2091441613264983, 0.10236685409150169, 1.1059211609825705, 0.24524851041168372, -0.16325616849417943, -0.7136988477512772, 0.3627254943902183, -0.13597794844324812, 1.0540461035636295, 1.2972501250976605, -0.654364554164905, 0.12459242835186649, -0.09519521660149746, -0.8380055423802591},
    {0.14626760818388024, 0.32813692922826126, -0.2725254189822453, -0.644281213541752, 0.45563668521144013, 0.020264910734782163, 0.09484134833358637, 0.06437868519944936, 0.9306997229831995, -0.21222508164243817, -0.002388446965632009, -0.05678761655364729, -0.11172724651311744, -0.7263293277623314, -1.0016443267561803, -0.6619403530855584},
    {-0.33720113719965655, 0.25094174395905094, -0.827606555239127, 0.1032759887631677, 0.7479090825953284, 0.9805777158656929, -0.6936535687607875, -0.02816583468256883, -1.3481024977512341, -1.8231116450537352, -0.5827733341952799, 1.1438562148453055, 0.46337862269929464, 1.1542999351890262, 0.9582316453073122, 0.2403448409842933},
    {0.393075610850032, 1.2767965825148746, 1.4261222168542214, 1.2134381822437843, 0.9009121027912406, -0.35261583893238824, 0.9385475363966245, 0.5974867471386999, 2.121032440037726, 0.912561482823365, 0.2454185376663539, 1.3980794004634007, -0.4277741322366675, 0.18597459697900456, 1.5136803910663712, -0.6391869444460215},
    {1.0951591976136144, 0.6168874692537825, 0.15766581359403148, -0.3710167059015502, 2.33827238509682, 2.2099964171795676, 1.3556179432378177, -0.5873541828846404, -0.21619622697164637, 0.06161113231891673, -0.4524757973660494, 0.715162989258716, -0.21865293694505367, 0.6651538767789072, 1.0153381793641085, 1.5743310343208727},
    {1.487573614454541, 2.3665511015336156, -0.775985969270291, 1.1350208447563253, 1.752924232255885, 1.5216462426396118, 1.0595300157861582, 0.6371596803312455, -0.38762107819720454, 0.13861865821301117, -0.36617465944711736, 0.14353633713834468, 1.4564663393876705, -0.15540452630606436, 1.4940456404101448, 1.188488026403657},
    {1.260744956310373, 1.884051002294254, 0.5839101852976839, 1.9863170568006019, 1.5023849791486008, 1.151787943944458, 1.5304174179633128, -0.08498449240229387, 1.6373447639252343, 1.0262693959279858, -0.20498886728846813, 1.298712216688527, 0.6082161220957557, 0.4382199214487238, 2.0245329882986445, 0.2259130206038958},
    {0.6528425426993044, 0.813764962744808, -0.7935142854240516, -1.317875707245407, 1.2546164210878823, 0.8303333610033442, 1.3662165152427812, -0.5902452224234421, -0.9172468545771457, 0.05001689346582011, -0.9659409002110393, -0.31692484994887693, -0.5945157994494018, -0.4962037538148384, 0.46583926806872517, 1.3119012054412014},
    {0.08056390422938316, 0.955998924097477, -0.3384050629993675, -0.8554158587636241, 1.1345950198548902, 0.9039154079751714, 0.8383164294709297, 0.2604329606364473, -0.5002154137418218, -0.9153351692361612, -0.9106527578554013, -0.4103502043113512, -0.4863797122384804, -0.11527054859911386, 0.7100749789646793, 1.3177932021746914},
    {0.18825552076160423, -0.4008325126425039, -0.1954005867994545, -0.8877612075796224, -0.7137917621761481, -0.4324121851562666, 0.23613818310536566, 0.023869862541407594, -0.98636355456489, -0.06841783049853746, -1.8830052957397005, -0.14465203532550466, -0.32769183688750864, -0.41538259022899476, -0.2544424783447327, 0.4924568468931773},
    {0.8110880135538181, -0.8125257985564328, -0.9336888510721261, 0.030479166025525882, 0.9806659249656842, 0.9058505229858106, -0.550810793533964, 0.3952604999204487, -0.6485822348364414, -0.11569696927258498, 0.7038721212835541, 0.2346257726520415, 0.486784252774646, 0.30474639269897164, 0.23788166062605726, -0.3224998923756232},
    {0.9171084683586651, -0.8073079872378783, -0.40417865348786436, 0.04722776485073123, 0.06450133667825678, 0.7196044301338965, -0.4664190514683092, -0.7175811040807133, -0.4754987720122185, 0.45619093818912665, 0.31327655105189134, -0.470485963603179, 0.8586459957378282, 0.18341932424445762, -0.3865246788779527, -0.21415296368956313},
    {1.2651446743426418, -0.25336702034588654, -0.435509828439498, -0.0009059250596142486, 1.504191056342522, 1.4495893002636657, -0.16480493703439134, -0.3045437767552341, -0.16844772069237315, 0.31459306987378954, 0.3296207866465113, 0.06476140724656078, 0.22684437255928167, -1.2895767641888745, -0.22190620955758328, 0.38027978824578845},
    {1.6523877684675081, -0.0595415919076357, 0.1800452173738268, 0.16485143029507718, -0.6672567494393676, 1.667788049008256, 0.719266940425989, -0.42174919541912076, -0.07104987749743455, 0.6245874521134847, 0.1936247531072594, -0.8667811309580694, 0.42601829427079896, -0.04632658375745271, 0.9675357939375403, 0.4421472276786493},
    {0.11312493994735275, -1.5609554293507044, 0.14971642774613236, -0.9194529264581102, -1.1993745675036636, 0.9409670667571967, -0.6240624081986051, 0.2921968022381751, -0.7668361584351835, -0.7172542652813239, -0.6184559924107922, -0.6179315955578352, -0.5989918806341723, -1.300690701614834, -1.2834397996740308, -0.7963332896383274},
    {1.158427230169421, -0.5964594833162443, 0.11701553089181677, -1.1409916087838767, 0.24709995721106087, 1.3004161498836007, 0.5887003861897089, 0.6207546697921248, -0.9692586085093904, 0.14120873450946234, 0.3459696008120679, -0.7671525547771424, 0.1406004019852695, -0.3482683775785591, -0.3250687167664707, 0.6090849318338051},
    {0.2039820832959941, -1.0914763538419516, -0.8329817659643313, -1.2419315015301164, -1.54947070986174, 0.34127302583796404, -0.5475916264518147, -0.018306293961899492, -1.565434440395275, -1.2656581503161601, -0.015117573053767097, -0.6763761431818718, 0.24019422239147262, -0.4858504583098702, -0.9926587169500474, -0.033376553776334486},
    {1.0424483850361286, -0.3303491408997784, -1.365364460804177, -0.9473389480073837, -0.16139250199593463, 1.0926802248317538, -0.5514672236570418, -0.20031503107253587, -1.3534833449743564, -1.9341933090198813, 0.5013371758348132, -0.8314908544582379, 0.6133854765011594, -1.5387034853917851, -0.22400714585802797, -0.03697580116278517},
    {0.9949908370484775, -0.23256137167063243, 1.076400300930844, 0.1597026885019048, -1.2392187117094189, -0.019387629454725608, 0.5103562042497843, 1.5260362038179454, 1.155778646898798, 0.3530647701370498, 0.10480472759298798, -0.2187442368152999, -0.4950498387052704, -0.16317292834310773, -0.2421470186446308, 0.3243725619761805},
    {0.32005514389300416, -0.5558925596990174, -1.5440885239137954, -1.6810859542551524, -0.024449211535990115, 1.6240953666604203, -0.18187918163931452, -0.3578295633975967, -2.1062021913622915, -1.8566365774184568, -0.3654385054312023, -0.8777052187076485, -0.555678706915344, -1.0538744753438005, -0.4952164284423746, 0.4085376694178091},
    {-0.1635887832771011, 0.3723110323804952, -0.20961115838488578, -0.9361909829525384, -0.06798885831628279, 0.13197672956901035, 0.8626693176732683, 0.43404291441720827, -0.6506136231284, -0.7586426647313214, -1.5651821706667608, -0.8455527095593306, -0.5990063914681305, -0.8381033485420936, -0.29973429643918764, 0.7294054383007336},
    {1.8222022796964488, -0.702829521497872, 0.8883513396781874, 1.4674376001527167, -0.48869997207464355, -0.8678268210984135, -1.5622927748256654, -1.0539007188483447, 0.2632263180433746, 1.7120311681953089, 1.5379368657223869, -2.1722459281503412, -0.9628858357758465, 0.6417644586288488, -2.211536541633169, -0.7253166055787201},
    {2.0899092975597036, -0.7221602315307227, 1.4713397126284293, 1.5538021256631411, -0.8914544962029095, -0.7160475095454004, -1.5067668641696064, -1.2311294841102722, 0.43902016202603694, 1.703828586256886, 1.3031717720002156, -1.46810617964707, 0.41908396489517, 1.389313985431145, -1.8668870469890728, -0.0991521626592808},
    {0.9819343598563534, -0.6234878337028259, 1.5522516835014903, 1.7787715370099575, -0.17091225985158506, 0.038679282185899264, -0.8521706743396528, -0.6211823429387726, 1.2981138661873082, 2.2756459132578866, 1.6080340098933585, -0.4775743301740534, -0.6258330868714085, 1.1325936505847236, -0.5154686283542969, 0.3379389083300196},
    {1.1818418787307454, -0.5274400400023713, 1.7210580759772107, 2.110023010092542, -0.2880023104814202, -0.7582763100213955, -0.1457733771609511, -0.9480391941499277, 1.186483024300898, 1.7982368029874973, 1.7704283327832853, -1.2388082093255912, -0.5203693365355712, 1.1647936528887002, -0.31655797865197555, -0.5923640613789912},
    {1.1866102797123426, 0.09684069776626145, 1.1840064458172015, 0.8464945071550347, -0.007217163587339759, -0.08045001970860098, -0.4879312461363005, 0.00888503725627065, 0.754903576890553, 1.5804299279064071, 1.3929710868724852, -1.0826451225332108, -0.5711752911877392, 0.5959680518640985, -0.4165430232438168, 0.11542859185195391},
    {0.7196127919023648, 0.7274980576671733, 1.2105265288107234, 0.429176906565111, -0.44661292632241034, 0.027633118314120145, -0.4163398020832327, -0.007530561509410384, 0.6177900446620052, 1.1953986231648022, 0.7558224509776499, -0.5929979458206973, -0.5784501659454411, 0.278932893027957, -0.5011195685740137, 0.37449733792186063},
    {1.1929710821841157, 0.4208873734932769, 1.7939892376713067, 1.275457981619781, -0.1460930667578571, -0.012169432717584026, 0.2694912792991595, -0.13376194766020638, 1.0215968579630272, 0.8567461685732825, 1.3474761812361933, -0.8536142111958956, -0.3892655302459848, 0.6885227988104246, 0.04949966502163828, 0.3961505905867342},
    {0.7505482576218904, 0.46013196544638457, 0.014059230621169054, 0.40083808753768074, -0.10380110040765265, 0.27983143964210355, 0.32594623198684686, 0.649672960923896, 0.4311966767361493, 0.0028974897329976505, 0.32572868784661835, -0.22644404960567752, 0.03603994374624951, 0.10070236841832121, 0.4801743757603905, 0.34802028510023425},
    {0.2829241186023641, 0.09732496036550856, 0.38744565419739524, -0.5006969093588455, -0.8247749558204256, -0.28395245567319577, -0.31488991082225504, -0.21761112426147283, 0.5027979736178666, 0.38273427511296537, -0.33323667177468386, -0.7166632504593567, -0.5818234843851184, -0.014317255233307367, -0.8417313216743273, 0.40510202957826036},
    {-0.3027328050524456, -0.6173978983905096, -0.23904192688677892, 0.08711791644591668, -0.259693720766968, -0.4394873494278663, -0.5815366889744676, -0.44399966896893295, -0.2663241830544573, 0.1156491903882822, -0.08389430766417766, -0.5123089343576503, -0.47265028292460015, 0.012562706538743237, -0.13165644232612517, -0.5642444867307064},
    {-0.1530931912887193, 0.5188036541269361, -0.2580668640657854, 0.5732073675193139, 0.40542067863665265, 0.2447985084213954, 0.15302901029559074, 0.30142156826281374, -0.12940746735662112, -0.3237417976231618, 0.2775334010039851, 0.6920323738192025, 0.22780626141924, 0.3023329747027874, 0.6634891145870814, -0.021868439471045546},
    {1.0145999020508414, -0.27784924318360654, 0.9128927870421542, 1.1308665259924007, 0.04206347870794669, 0.4313542983610442, 0.3955855287219152, 0.411316157412857, 0.91679006061008, 0.8402923345005286, 0.6021232986012661, -0.007161407309739841, 0.04566998873191105, 0.83169399028207, 0.0338367586548507, -0.08013722593581285},
    {-0.5869643105945617, -0.131054676725763, -0.31631321167320764, -0.5382403845039138, -0.08199491479842043, 0.16164758821041095, 0.2397904727111144, -0.37636498237349436, -0.7386810851562885, -0.5948549317449804, -0.8036986140452456, -0.24219405561272195, -0.133519208435706, -0.34522582452560907, -0.3868063958553481, -0.00041723308986574796},
    {-0.3890504204448163, -0.24837425420011816, -1.0551596084373789, -0.4411204050098329, -0.5977530273571207, -0.4009505717767556, 0.025495379327433156, 0.030032814724588953, -0.508801119656934, -0.764326632693783, -0.7564340479259396, -0.18931708275426243, 0.16769260724290688, -0.631660747247465, -0.31408053603077, -0.03256212568115504},
    {-0.3506495865128239, -0.23066273662423378, 0.4496465244265595, -0.6301479993145469, -0.13162168866319304, -0.6072530822782398, 0.36168053840173486, 0.10677982237404782, -0.12729610968709423, 0.08271337350362373, -0.15290097254993185, -0.047465429128525215, 0.14038858699067425, -0.005224674832607077, -0.5971884571186838, 0.2624517641422826},
    {0.3480316336676143, -0.21861085301981126, 0.4162913064762188, 0.374863919145449, -0.36603557073466525, 0.16962179835016356, -0.45252584603255586, -0.3633847993692442, 0.10036942462482137, 0.5576516984007729, 0.8171259389325933, -0.5739296474738673, 0.0814659274200774, 0.5807406709111116, -0.4937607636060239, -0.1336955239664874},
    {-0.13825414219228768, 0.34458311427825383, 0.39722620643631545, -0.3818676510783965, -0.012692372025196531, 0.3814009086299193, -0.15163907238395102, -0.1119657510071245, -0.521096333354137, 0.030382302896382298, 0.11965101090880062, 0.10472140435505482, 0.40795969726018694, 0.024056560952518364, 0.1265931873747556, 0.10057380087579275},
    {-1.5365548745597621, -0.27858162587682805, -0.37659917475112437, -0.6906531122038787, -0.44687707836520935, -0.8678417237632163, -0.10664301002250545, -0.33119730300055594, -0.3080263438775856, -0.21086589504897432, -0.8213427910301543, -0.9328195981944767, -0.6422330475362384, -0.4904679217672202, -0.27231148915928416, -0.504624598607349},
    {0.5498229154364705, 0.5426164617422911, 1.1435828510440198, 0.6917499872816085, 0.7506306589701806, 0.49977080797883255, 0.4534393653023714, 0.10706972186022903, 0.6975719872365458, 0.6756077367180388, 1.22868378705325, 1.0933212816853937, 0.28824068040181183, 0.9348369188493392, 0.40607150843729023, 0.48440623446611064},
    {-0.6671221860475333, 0.5460037880802546, -0.29891705091319776, -0.6858381993511451, -0.4656229197447972, -0.09202260771014353, -0.07330812922656378, 0.3326389357815195, -0.13839089649826503, -0.13357138360191975, -0.4240325603824478, -0.13482366579531935, -0.24133729863008202, 0.15734123546431764, -0.24871240071800824, -0.40952317739477095},
    {0.4576394647073688, 0.306645959591701, 0.7826972194335725, 0.48064824424666025, 0.15363289870702254, 0.9085620343175644, -0.0862016171522316, -0.1284646349957189, 0.5489985514542663, 0.5482833053552877, 0.6780605300245119, 0.34780547483315577, 0.2335719440800657, 0.5700101754465301, 0.4681049191898175, 0.2999960905931407},
    {0.21973208644406417, 0.17263680506561654, 1.7060625165525696, 0.43811396408481185, 0.11031137932879921, 0.10601653435373068, 0.10597999017043509, -0.2871224283125168, 0.7358263821202535, 0.9395757843176451, 0.5671015689840649, -0.7733783171197057, -0.18653223064110866, 0.6679781795429021, -0.3873157170449729, -0.2874974023512108},
    {0.9004741312224568, 0.0035046150574410155, 0.4784013469334786, 0.6557467561820995, 0.10446820217733534, -0.0006367256798403447, -0.0645624776514803, 0.20603295871216712, 0.4805939173304547, 0.7191996836587644, 0.6690349706506137, -0.10207213835232941, 0.24862965829527311, 0.44206016225693906, 0.30493482730250365, 0.6204373051739873},
    {0.7991431149125233, 0.3827640796228568, 0.3492765949129211, 0.40802148779002534, 0.5162926261346793, 0.8593094545182314, 0.584091396935812, -0.06831688997247358, 0.1042742813508268, 0.009465437479943021, 0.8021859967561731, 0.5062182140706188, 0.43794674069236256, 0.4435184865610956, 0.5072210374015076, 0.42355463149671413},
    {0.35544243832388817, -0.28144898318188133, 0.06694015288537616, -0.6571834578355013, -0.9587571487795339, -0.1811007923085889, 0.329131246214993, -0.3968072487161794, -0.4086052638291999, -0.39836267049706864, -0.6465545338955309, -1.5175855796975752, 0.049875997489033146, 0.2129779365787316, -0.6103221631758304, -0.23766060216580856},
    {-0.1620857526587938, 0.4203037903229714, -0.497930312947032, -1.1835042841389418, -0.07075023531531134, -0.1278942238615263, 0.6608672211705586, 0.379658276807284, -0.5834014645801457, -0.8492166233808964, -0.3533723320428638, 0.15239673741148899, 0.05367351974456156, -0.37083833250141834, -0.2665041840114451, 0.5760178079989084},
    {0.12408598852918146, 0.5535363177211428, -0.7114601296897871, 0.09284795744919219, 0.6467727305802381, 0.4655379372453826, 0.15502874545242154, 0.4633807971084644, -0.15363203384702484, -0.5459340604182082, 0.4141276206524687, 0.7994091037002733, 0.10508330760900485, 0.16929927586837767, 0.6427250139689547, 0.5906516313939334},
    {0.1959649100106643, 0.3289736539777863, -0.9331124640768987, -0.4566659479620371, 0.23637761412629732, 0.5724717710659684, 0.3041010375266891, 0.3580626148052823, -0.6850719981123969, -0.9734886374175645, -0.07686747003222379, 0.27281413742176314, 0.20808889218972637, 0.09780004775067472, 0.7091378283168475, 0.4878577377142363},
    {0.7463483421249466, 0.5316456678933275, 0.7893408797962381, 0.1410115700875861, 0.20271991820573412, 0.5028923594403975, 0.3335974383420825, 0.15237804449691653, 0.10968010694587246, 0.5832271092332727, 0.8136770394573681, 0.08399942004502219, 0.19425178903905452, 0.6922938090262044, -0.049945626977110406, 0.23104719029950002},
    {0.4487879139291241, 0.30891041339710396, 0.4348387754224353, -0.24638439183728508, 0.1604037946138977, 0.23279559010784656, 0.6685829735546786, 0.42614234104118554, -0.3768672528800025, 0.05162807533971873, -0.17792848394701546, -0.33176015131190123, 0.20641208820691978, -0.12415518662693627, 0.03907696962003329, 0.4346610414627955},
    {-0.9315523767442351, -0.33695582433435584, -0.6569915906089231, -0.9567172624646603, 0.19407287815594843, -0.24004338996624944, 0.39570831969808085, 0.15632055255107888, -1.1022671538693731, -1.0021461718074025, -0.972299784322882, -0.3108607434596084, -0.27414660201384405, -0.6580591327358223, 0.221800458906929, -0.23896698285719103},
    {0.062464926551213426, 0.40836593244027447, 0.7049245326643098, -0.16869292483236586, -0.34348152097740664, 0.0527431258597632, 0.3042884827403395, -0.10175241102288611, 0.4238285968861877, 0.1335254734372606, -0.14599863936730656, -0.3412352246571237, -0.655424249134317, 0.07735080977207819, -1.0217856500688431, 0.4896268966920605},
    {0.7068236930603049, 0.4096048586821834, 0.6820409837098452, 0.9947231068578422, 0.07621154092202585, 0.6793528950955747, -0.6809949838528415, -0.3452917870000353, 1.385717064226431, 1.2060285951248475, 1.0776208595575132, 0.6813987059550547, -0.10934808202373196, 0.6127696983014509, 0.15820366691260365, 0.5398073183473802},
    {0.6253956602536509, 0.33025440650047866, 0.545743466858724, 0.8426722312881674, 0.1212166328066774, -0.005211479303602482, -0.057730739165783966, 0.2695393137615852, 0.9792142278086469, 0.925688449215908, 0.519716877984959, 0.3871377546612598, 0.08924596678678069, 0.44669071048443376, 0.034233206153386396, 0.12750263366285924},
    {0.01727680122248169, -0.2680028787014724, -0.7558827027838994, -0.21057449522894012, -0.0002238661452340987, -0.38034849786125396, 0.1630932468662093, 0.0280831188370442, -0.10750335014617592, -0.21903705736560192, -0.26400444269781775, 0.25475544435149644, -0.16395043361653858, -0.10033515293810805, 0.017765761694851313, -0.5849649225960551},
    {0.3676066436055887, -0.3129591160249201, 0.42302164088144406, 0.7183511043558602, 0.17596681584445015, -0.2253602372935321, 0.1839833375469028, -0.03286779716452164, 0.6506805585310839, 0.7329809732089391, 0.5967071918389104, 0.23805796483787234, 0.3521087042658333, 0.3317998141904199, 0.1316206018207686, -0.2867717797277467},
    {0.5343245594210397, -0.09739300898467074, 0.5782428315638377, 0.994169377541932, 0.34593184247890835, -0.07825150332472489, -0.12270056113003708, -0.30748389561457695, 0.9064596780358559, 0.707445442999696, 1.073038194465548, 0.34127050206637155, 0.12395148670467435, 0.586615506275173, 0.23793243691066807, -0.2709542285857976},
    {-0.2893679089020948, -0.3255223862671266, -0.28799724202169724, 0.2522618327021611, -0.17990409160752197, 0.09999840922517511, -0.8368942585044581, -0.44060290144161257, 0.1366655836893933, 0.07728679496214326, 0.3008450287327311, -0.045764468987909326, 0.08531877741400683, 0.7409604642741114, -0.39913760320442554, -0.883345840162493},
    {-0.27176195296024597, -0.25277294964810815, 0.13510973088366132, -0.2907319222271161, -0.15607200459816992, -0.5591156840207824, -0.2896342404266864, -0.45576115486052104, -0.029893614348697372, -0.06468043744830514, -0.08670999118984218, -0.4122706871856081, -0.2389723272759646, -0.028262153510631955, 0.030678246357166754, -0.2977554482492676},
    {0.2781388778432019, -0.06305131557739607, 0.6265500576821315, 1.2952503171826806, 0.4596214694829471, 0.013967197036479657, 0.10955507928002206, -0.03347172368776285, 0.8415775460466856, 0.8854650412117895, 0.8709163206097857, 0.15068006412685264, 0.3045534385298004, 0.33010569417815294, 0.5061542540213023, -0.1297238859570075},
    {-0.022490549020857557, -0.48698834985530054, -0.07255960940446543, 0.17467290336532096, -0.07677643793430902, -0.07131944634799794, -0.30567785601309694, -0.1886644332046001, 0.5131479412337157, 0.23418480666778665, 0.21187836197572127, -0.10028582188361741, 0.13250981282023383, 0.32010499517552, -0.0877308863512417, -0.2867786010082917},
    {0.9636553589278938, 0.19345506627828218, 0.5534139394780737, 0.3627669097873337, -0.17025353445054797, 0.15411664230359015, -0.21220178842560228, -0.1654184812639792, 0.9810610645162312, 0.905999124187289, 0.9606045158025504, 0.24805273970761574, 0.19422494070803398, 0.5993372201964382, -0.11026976654799699, -0.1637469701287086},
    {0.7317823614683705, 0.3952541323919046, 0.42711515068793615, 0.09856153418774788, -0.08121290896611078, 0.20609282176384208, 0.30837702170197007, 0.0926147341020223, 0.4276478849634618, 0.4657579887463346, -0.07270754494454826, -0.07123796467448873, -0.023560564888545587, 0.23085240480667274, -0.5066643917962943, 0.07308971386998693},
    {-0.6532614061455753, -0.3992748076037888, 0.16039279825231995, -0.025771288828805493, -0.35852714870519314, -0.6374155649806561, -0.3776414509231052, -0.4464732927505541, 0.13949883443391864, 0.3630817246964009, -0.535644981633615, -0.3171956741233828, -0.4466859946095313, -0.012353977812177225, -0.7796327335263713, -0.3179486681139905},
    {0.5413100791774933, -0.10889442465122895, -0.373225644655441, 0.21896280620830424, 0.3417703259766738, 0.32317043073296753, 0.1360660330064629, 0.04121017436484905, 0.29774811164921694, -0.017882027714304385, 0.5157670308223483, 0.6792447638185648, 0.4826270498126614, 0.12527389655455684, 0.261765079477803, 0.240718736323131},
    {-0.2945697356976905, 0.25051461905472927, 0.40253089614028925, 0.6784860307579731, 0.7260397777249473, 0.006481460743166713, -0.10066422550667488, 0.10809793148472285, 0.5143403098422096, 0.3394477192076746, 0.4872770122933072, 0.39517825791551875, 0.4601772485381056, 0.17760399038600413, 0.6577002673050076, 0.1405992119114748},
    {-0.5918957117862353, -0.34742891710312307, -0.6877050983294727, -0.09058494249474473, -0.0735256324724356, 0.04068236912844568, -0.1226409674541922, -0.09124608702706397, -0.359619132076959, -0.6064148421393618, -0.4248892717528064, -0.36952267617778506, 0.025360548754688877, -0.009412682776830276, 0.45472823092667713, -0.32237193535733266},
    {0.9795865855921366, 0.0791008809595946, 0.7367354774283422, 0.35569120381701114, -0.33213484608400723, 0.1577623438336098, 0.09790088174706743, -0.12995725326020957, 0.3661847270078103, 0.5885797927970339, 0.7051877285389804, -0.23756192135509485, 0.08993862031173486, 0.5601964536194597, -0.5249297451519506, 0.18852855949012606},
    {-0.12695436923715708, -0.1955114900732454, -0.07004316467539594, -0.22099917024310886, 0.1516838533186095, -0.38939962294367597, 0.2731465087508758, -0.01231971877476242, -0.02976945064586322, -0.33081189202138916, -0.07013550537763301, 0.5011262364906549, 0.050158929886767935, -0.26858135553124385, 0.5983685024913211, 0.29880235646868547},
    {0.782140053385382, 0.17968969460522954, 0.5194964159558307, 1.0708837476410409, -0.12238632038264902, 0.3561535228047176, 0.3681550155997449, 0.06723449079509528, 0.756220786835448, 0.921508591673052, 0.9031559568031681, -0.13294626289973, 0.27912243258471703, 0.34893965554225526, 0.3764485422210997, 0.18598852604138502},
    {0.7013620706321989, 0.11057750283320222, 0.5627772408773271, 0.5724793466501785, 0.2020997934112225, 0.21644306408363823, -0.005903724869815995, -0.3027522268976538, 0.7616413587985169, 0.567184515583494, 0.5890861089575057, 0.529598095192376, 0.3744873287531557, 0.8876662867378494, 0.09686083129324825, -0.023338049749125806},
    {-0.03967498102895912, -0.14531151438939516, -0.8344102302813534, 0.12364691895332348, 0.15807235864321134, -0.2467793894534278, 0.3902192426864685, 0.3053677344754887, -0.5472274788530331, -0.47884979642399494, -0.2586091624910825, -0.10456448036573483, 0.2659915880543991, 0.046176170302892214, 0.3134080313010658, -0.13996721185618033},
    {0.29301764827774474, -0.7644015487342314, 0.15418230352441617, -0.011257968630258016, -0.7256702167875572, -0.5474904961716321, 0.31913017989572656, -0.26592892051495576, -0.033432461407477534, 0.15178985616657636, -0.11296111454132246, -1.0902796874233556, -0.2678504974847424, -0.18220622347303353, -0.6598651197995581, -0.5506602089458856},
    {0.25849871072679576, 0.4867432531692625, -0.13430473598140122, -0.39033441080969666, -0.38665069155246157, -0.011626839339019783, -0.0006440078909996608, 0.0820889920933148, 0.27997837422284666, 0.19855261820899037, 0.3081308252524132, -0.006361512812174696, -0.2746496202499635, -0.08888847707899829, -0.36485436296910123, 0.0788726802094557},
    {0.731985652429562, 0.7474246018046125, 0.747840267792542, 0.3163637760992984, -0.004421799724276983, 0.610100056239234, 0.4596063880812208, 0.48732947464321597, 0.5175732176762179, 0.1698595479779877, 0.5429376526167506, 0.4367189655415796, 0.08249453379045589, 0.3832987369406989, 0.18022566910603985, 0.33708744406290375},
    {-0.4046682025507973, 0.09978099535862947, 0.5943233338465291, -0.19401487523699526, -0.0828707350474806, -0.3199428738786885, -0.48598348117444, -0.3371320310350662, -0.09800554866845522, -0.09666863317255837, -0.22247716000672424, -0.2612843115588164, 0.32430546052413417, -0.48652792876486883, -0.08218829150061599, -0.4261695935834161},
    {-0.13488132983663942, -0.38490398893314404, 0.17996416575175533, 0.18115539198781344, -0.09389876358312368, -0.3140676112478995, -0.25509212553812144, -0.565807570218955, -0.197431493046585, 0.20396321080759358, -0.021714961435513866, -0.4479198966953942, -0.1870702237295061, -0.22950683747533018, -0.09212859281626973, -0.8358884652600898},
    {-0.2646213067264699, 0.1748166782030447, 0.23549826942275282, -0.009041960950853805, 0.12580787671683655, -0.23549856175967765, 0.06294218929983653, -0.08251723233108443, -0.012435430483425812, 0.08901939562685984, -0.026650713793618903, 0.4097663374398161, 0.37123206803142805, -0.06706970435837101, 0.7940847845389517, -0.3965447120213694},
    {0.08927125895940193, 0.042296106496898835, 0.029596561138273286, -0.13330700121893643, -0.08876625678524869, -0.04112131795179066, 0.16454763713852394, 0.12496168803159992, 0.22150493364346563, -0.0804473317901555, 0.28866385650044324, -0.003027338077764859, 0.19801827493074287, -0.10000571333145258, -0.19200585671761916, -0.03932043731917991},
    {-0.1274223972531129, -0.2833887198653368, -0.4037373469808164, 0.24145048085834553, 0.05666551357164906, 0.07158067100774922, -0.7235717902038318, -0.13589991545982893, 0.11675004010250037, -0.09681881783292895, 0.02073728580423028, -0.10484447573462677, -0.02519885484735396, 0.36606520022176814, 0.045779121444488854, -0.5330883602179659},
    {2.074924298569586, -0.5739733396710752, 1.0096003489635335, 1.3444130402419536, 0.18816840624351006, -0.761246831621501, -1.5860250532019036, -0.26370560768168627, 0.28194600779332485, 1.4115344025254122, 1.7262977978760932, -1.4691243322039966, -1.752603561385609, 0.9185809266289785, -2.077402197128646, -1.2460997465953265},
    {2.319890411398377, -0.8714103334704857, 0.956621224719945, 1.1128854587914139, 0.034181912426983194, -0.25883592641511144, -1.4897313116230804, -1.0582782827109178, 0.14997980675929157, 0.6926428143294209, 1.6156987185449432, -0.7722112447290758, -0.09445758690397045, 1.30107511952775, -1.4109752334811823, -1.3340281909033733},
    {0.9443840104741666, -0.22684024356937582, 1.3935305023811633, 1.419297788841318, 0.1402406682775572, 0.29893386563087354, -0.6889951363893825, -0.625202656906571, 1.055867343706125, 1.434716038676543, 1.3134358297222062, -0.2922059956078783, -0.3285597017397235, 0.723840938859484, -0.5546622535125052, 0.1087401668779883},
    {1.286503119266123, 0.004755071975005874, 1.7869418575273672, 1.992416870872397, 0.03072323702475802, -0.21758509630680656, -0.004467601732547591, -0.31020215288155095, 1.6447072449532694, 1.986537459056817, 1.7256422922023995, -0.24851398165922545, 0.25016694225512187, 0.8462191653882696, -0.5110600323643865, -0.05409158537102078},
    {0.6376025411378905, 0.14703624361312637, 1.2089922387296073, 0.9396107196571197, 0.10167772267165553, 0.7318676135303427, -0.15387711458870545, -0.3557774981357358, 0.6294216753209126, 0.9717284863389574, 0.8809111917992796, -0.2981666481708823, -0.22116340649080338, 0.6872806779302056, -0.1451410027189947, 0.3359918325400208},
    {0.4529618938387922, 0.7297163595383251, 1.0267076366547851, 0.50619547691301, 0.3509585665559866, 0.2500669122914787, -0.1480853562399324, -0.3442414051236163, 0.3495285551981141, 0.6503050029212748, 0.9126120688260978, -0.059036235452247704, -0.13685118001827595, 0.1257700036733274, 0.11535413401100615, -0.09893945575632022},
    {0.6817924533587458, 0.331229476301734, 0.8336983646036716, 0.24813975453081524, -0.20269865957675154, 0.1585928361154372, 0.34756055968570565, -0.23442418638240406, -0.005470169472144841, 0.24852528080247505, -0.39757775230718007, -0.6500297928771948, -0.2519990702295748, 0.18875164999876243, -0.21655701286135695, 0.6236757049601238},
    {0.28155858761312325, -0.10610218092241572, -0.720464949658602, -0.3866630578000418, 0.2186888903484482, 0.8027892976118168, -0.1202387321694718, -0.6124474339197219, -0.7132254593001042, -0.11344954329409297, 0.06649716220554594, 0.09612445815130916, 0.3342771532506287, 0.0036359892302529444, -0.012025667880367134, 0.20801250545124175},
    {0.5728114976412232, -0.3880473586926513, -0.01393248952818833, -0.30548156858145575, -0.22947977976570447, -0.7371290405134219, -0.786762340804905, -0.37821331671178243, -0.25651321324570364, -0.11103622827251021, -0.26714912826703574, -0.9606579164580229, -0.5323851235015842, -0.03131438738344052, -0.4925363385449381, -0.3597207690391118},
    {0.13899603462823076, -0.02777730490958386, 0.26052909708189703, 0.6908651291485443, 0.6783403883018582, 0.05150634229324352, 0.12497071596030974, -0.11786779764313687, 0.36568677901340235, 0.708229071541921, 0.5934486292225923, 0.560839974004534, 0.4024280297802501, 0.41582948533570147, 0.47248826783411524, -0.26205706572014814},
    {-0.5082806658624371, 0.058600413670998726, -0.6056509348417157, -0.493254362428352, -0.022808017836357237, -0.5959100806224931, -0.19945152534044325, -0.24169214109843104, -1.0908798852559503, -0.5700698516985004, -0.11815644292897756, -0.4110099137470646, -0.38727045378593095, -0.6669323533704409, -0.4090598479611828, -0.6921976138993708},
    {0.9481079749955529, -0.4752288843935062, 0.8779097667721903, 0.9217000493775727, -0.29131078130552485, -0.047986719248782096, 0.26256026489883033, 0.06221682660968386, 0.9179976778942297, 1.2534441030589483, 0.8079842018828266, -0.5163201977640203, -0.3004836332114099, 0.32005720578023833, -0.11932861722367077, 0.2930902254436823},
    {0.12292984400532356, 0.3024597427204884, 1.0757874521814024, 0.4371853376206352, 0.7919712390806902, 0.38276218758419533, 0.144667272084735, 0.13837578545057047, 0.21162989591147477, 0.44166566883515024, 0.5905782980828593, -0.2547279030704887, 0.23277250679880382, 0.47178798420649953, -0.10697255762860805, -0.274211140157422},
    {-0.08175321749578869, -0.07024062754643695, -0.7510695584151772, -0.7181501798124975, -0.08113350880633803, -0.26358464539922555, 0.22222896223190788, -0.12950771744967704, -0.7813178186696395, -0.6466423106142355, -0.4126449021088571, 0.3868691481894549, 0.2815427659900433, -0.23722252548357542, 0.4472202599792288, 0.0013664554091208344},
    {-0.1716162869655835, -0.011216676166199945, 0.40862601091425227, -0.4130179535934461, 0.4639483403068619, 0.11834756968248918, 0.3717655265868235, 0.10962886405258465, -0.33501747409627136, -0.3425953873402336, -0.06821337921320947, 0.2617997095075902, -0.03947777490191252, -0.03936498792040516, -0.06483594601632553, 0.20078291087453606},
    {-0.10047274731952788, -0.49300821733529554, -0.34924063311069814, -0.09903816716622289, -0.26878076590583205, -0.438901136802297, -0.446379926316127, -0.16814381090795216, 0.02034798590984249, 0.2645425750806716, -0.28273623535393844, -1.1742033613405956, -0.6112482813957543, -0.18916449925819948, -0.6847614507907116, -0.4201502117056486},
    {0.26936832198409444, 0.34620300986723795, 0.2244955796662609, -0.6385242445988416, 0.47316769347547577, 0.35490104159680863, -0.15562673557885126, 0.07677833071732373, -0.506368025069441, -0.5426969397455178, 0.04046516772322868, 0.2962817638820744, 0.2570541807759737, 0.07772848826221541, 0.1434801027993424, 0.07886339802987266},
    {-0.3299502446717947, -0.8353046687677498, 0.14170574130227998, 0.13070949219005276, -0.009011191346363866, -0.7940796682330337, -0.2630381584081417, -0.05400986701437116, -0.24442710650208407, -0.12868657776500683, 0.024463464158868832, -0.7335455197087656, -0.3753800869335551, -0.1107311296577517, -0.45701887696184734, -0.25011135793491635},
    {0.998733407012814, 0.5182783987047217, 1.0474153521171923, 0.4471335651210375, 0.34366146493142885, 0.06720303751914254, 0.18404203078659664, -0.15192725402728374, 0.4463179013326741, 0.6787944436646691, 0.8039140541610397, 0.15690338747299842, 0.08572250829345023, -0.018335458646444754, -0.32780911625178283, 0.21790402439626863},
    {-0.5222348688745285, 0.018369352947219503, -0.4732307547343547, -0.5062973618332745, -0.5052291413563984, -0.572288417396726, -0.35750266072117964, -0.029913644963432084, -0.2624058222500444, -0.07657014307443374, -0.2634727489365406, -0.055784829478703696, -0.5098608901098312, -0.28920043853717187, -0.43939745494211346, -0.4476059457588913},
    {0.4111068568959776, 0.0861532645519341, 0.9320802000392392, 0.7368460844081662, -0.15502254711288208, 0.01972226186220726, -0.3717619134278191, -0.18713712487792686, 0.8920809140734787, 0.7777059046332331, 1.0579402045013535, 0.2574446771651997, 0.09414307223853663, 0.45400918110743993, -0.3701390231448719, -0.11513279781372657},
    {0.896336224795977, -0.15701387502586153, 1.502229139279053, 0.9605791022129536, 0.607854630022241, 0.18661329570987603, -0.3171957499607601, -0.2481841807221006, 0.9048045759491722, 0.9486476207681759, 1.0025968705585973, 0.01918015773309733, 0.30809649486725793, 0.8756247503340927, -0.24886935737112956, -0.20148268162616279},
    {0.544877513306128, -0.10181007474145579, 0.09545469874104302, 1.406200912803983, 0.28796984757359173, 0.664567941427392, -0.3539824906285238, 0.01038502865733027, 0.4601704569747804, 0.7446669199736788, 0.8675348542651293, 0.29765988885586814, 0.21813644003437588, 0.365200669005154, 0.31483184216381577, 0.20442660496299342},
    {0.9019557864031008, 0.10757183403469212, 0.5005409607060488, 0.5759258730034494, 0.3439405268215165, 0.4163945425772498, -0.34308515760144587, -0.018209832079483165, 0.36678741515579005, 0.6444420769958444, 0.9806921441827678, 0.21100137568333432, 0.4363540386212792, 0.35910464626990224, 0.008155775613508581, 0.17459090214804446},
    {-0.01796170898943886, -0.6058472363902245, -0.0506903965620887, -0.3479794869390721, -0.755836752436138, -0.2268421813298183, 0.06002471445495157, -0.36209904394114956, -0.10423721909969381, -0.2599789452611262, -0.1371699436034135, -1.2806097601004776, -0.6438301348364103, -0.09975279393268324, -1.31855676427839, -0.3175178062016267},
    {0.30749952764512245, -0.2771991344935536, -0.8291880481246477, -0.4418812705646435, 0.4883054158909649, 0.4128415793973424, 0.20413878843913383, 0.33944500539346717, -0.7747025044119598, -1.3197918520413374, 0.14131481871054374, 0.05971146539062123, 0.6991200606309678, -0.17755457167523875, 0.16262507522280628, 0.1696425554615289},
    {0.2180585422660481, 0.15403464849044265, -1.236784760954451, 0.010995650469483084, 0.3281155187131834, 0.4688929953108476, -0.2911772521677006, 0.3046879605196265, -0.34961876592274604, -0.4369010638424439, 0.29375265316337407, 0.6860594836022682, 0.5443470664801145, 0.0642287186347507, 0.545013603600068, 0.16515120323700452},
    {-0.1041557256990991, 0.35659535340459436, -0.7036759697862188, -0.8429220423074225, -0.5456336079957037, 0.03706460061803289, 0.039274015023392166, 0.2143651687430828, -0.6432221310752766, -0.7047580826583227, -0.3810844056684265, 0.2338414015468344, -0.14286246129001695, -0.30959596383256954, 0.019025827811061703, 0.2949137155973976},
    {0.006292734568825143, 0.40926151520143267, 0.05459891391790292, -0.2067644472348629, -0.4248338700745159, 0.1938955402124342, 0.10263434633832562, 0.02964223078732691, -0.1038656283980478, -0.2132747239796717, -0.32801118946834296, -0.30286292491509265, -0.31624140543261553, -0.19193869703432384, -0.15657094197201676, -0.09640488600286007},
    {0.3860146951400598, 0.17334489034835718, 0.3022445665099606, -0.37804631145040124, -0.2297515271019093, 0.010907858230387705, 0.4346867706337281, -0.623195369662053, -0.0018147014244657544, -0.026104759231116707, -0.3839256696013272, 0.046230568950496945, -0.1290499085063048, 0.32679636865582545, -0.12005174031890174, 0.4643702166067313}
};

static const float b1[16] = {3.1691779558532374, 2.117538059903272, 2.8573968952592383, 3.220012075228393, 2.457247237250291, 2.3872307979884484, 1.9949154937886768, 2.2853133926880256, 2.9466520718839777, 2.6591919109089415, 3.19293978049432, 2.509224343210129, 1.531571859643549, 3.153948527297973, 2.2979536336849846, 2.1201915740887225};

static const float w2[16][12] = {
    {-2.032401957207768, -1.3764964996467781, -1.6351613502589808, -1.9860127828818137, -2.1998246117694644, -1.3038276307892689, -1.8508031136116332, -2.0342729702442846, -0.8813490790255587, -1.7144246511329206, -1.943123625993012, -2.5063310602679643},
    {-1.2165013094507684, -0.7617564081862827, -1.4407813168704084, -2.498453841947895, -1.1915599980874696, -1.085659932957391, -1.1363313156331594, -0.9433893945120593, -1.7526450718027993, -0.5448473586625776, -1.4498155817785154, -2.1633997208357174},
    {-2.010264171726037, -2.2601603881207284, -1.8520319540554602, -1.0532109637630447, -1.5300367860915833, -1.972010366986736, -2.1007596994785414, -1.8007106323811972, -2.0333368897558954, -2.0744422710065273, -1.4009560929799518, -1.5195925128544874},
    {-2.2590098902100557, -1.1581981580564527, -1.4122636809295985, -1.910026329890451, -2.049543531717856, -1.9098639533794923, -2.5897866579392326, -1.010652320689695, -2.109418124742094, -1.9737093329634383, -2.1749880881021038, -2.0876769427623167},
    {-1.1023482113279284, -0.02098606379090092, -1.599169913718461, -2.258610264373765, -2.2229134325241624, -0.6716178921979843, -1.265405956686066, -1.9425039055361784, -1.9883326136701844, -1.4557347903128472, -1.5899538459529046, -2.389694187353256},
    {-0.9518337280072191, -1.0863982381603001, -0.6758775847782218, -1.7257791705108019, -0.819543611042118, -2.1313698793044336, -2.3716060955391836, -1.5685733048598334, -0.7878808765934884, -1.7088264639692312, -1.5653989359388503, -1.4060717681016002},
    {-0.4475879668649602, -1.0772808012837316, -1.2940064430716984, -1.3416947066283726, -0.6933443180335364, -1.183756215806557, -1.4646338130531695, -1.478820393498919, -1.911380399031242, -1.4424574361219453, -1.8963081160792064, -1.3669239242536535},
    {-2.5511433252984563, -1.4691531804742524, -1.463706872080477, -0.5368643157113897, -0.9291444007277636, -1.3958765601135554, -0.9841304104229801, -1.4052530920587538, -1.9542337885367849, -0.5890608653158856, 0.05040545717913282, -0.8470091036630015},
    {-1.2134150640496086, -2.519349489521433, -2.1759538924886246, -1.2083061787962552, -1.6145435686242857, -2.3205811440665935, -2.1503077328562954, -1.2959682368901, -1.4536741059521323, -1.5333752928824318, -1.690883357605112, -2.922788781522644},
    {-1.6764762256754884, -1.3674317080659286, -2.008092694838604, -2.0723049937489724, -1.333886166325343, -1.5168691824820515, -0.697233743578465, -2.094354482562421, -2.2869308003969633, -1.6399469538877387, -2.595118739094792, -1.6465128699157618},
    {-1.5256459250365915, -2.243896765223545, -1.9820083312951065, -1.868789195980675, -1.9656466517425581, -2.741371349067697, -2.0908986115378423, -2.692699955148649, -2.0072287353526557, -1.9681165425705667, -0.4469030073932461, -1.7048067623438186},
    {-1.3454097962161518, -1.6909746483156007, -1.6790034743951574, -0.44219552377494953, -1.0206075106808956, -0.9596210754742434, -1.8675042268469217, -1.0364368184266233, -1.6285174813294736, -2.1985321284704975, -1.7099115788796309, -0.9671944669252627},
    {-2.1822638245900667, -2.2378872396904455, -0.8205353097573994, -1.3176045214157115, -2.0751890071947834, -2.089924522394631, 0.4013164085430523, -0.14247656061840774, -0.7527097598859109, -0.6527840952857377, -1.6400494840532183, -1.4654674781531283},
    {-2.138819475783813, -2.353873541422607, -3.3016813626433024, -2.7153400226632445, -1.7798336121528069, -0.4860238575805249, -1.1595481384350932, -1.8328292137380584, -1.7696708181415621, -1.537580412125748, -2.563395269729547, 0.08113294398342376},
    {-1.0190856113436413, -2.2411465095846186, -1.8308976368325989, -1.75938056748631, -0.8800342409166767, -1.5779797536093452, -1.509180489374876, -1.7291913015110674, -1.478628020811352, -0.8306855101137406, -1.5869545033608043, -1.070802186866995},
    {-1.4334717170690658, -1.725328587564651, -0.47933495513818886, -1.8785079659657165, -1.9852207387195586, -0.9443855483964593, -0.6672998606483063, -1.761766547371491, -1.7456508323598112, -1.2533845392001937, -1.6366387224245182, -0.7792141980826852}
};

static const float b2[12] = {-1.119384799327262, -1.176071794022361, -1.5002677014630146, -0.5693466530350488, -1.2717501387895815, -1.1776506065705523, -1.2356046235882223, -1.091031738278709, -1.0083452232568224, -2.284647496952628, -0.5610259464287627, -0.8914495207666169};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
