#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.01342861648805922, -1.080199707251498, -0.05875956101884877, 0.9073206955682276, 0.19741249402380462, 0.13881276974880702, 0.3472171207285231, 0.933964558937694, 0.4535979578326054, 1.3222366099659117, 0.46999497169707294, -0.2132427503523618, -0.5207398458528097, -0.6608516698107698, -0.03715296098639907, 0.770981292872367, 1.33022806527468, 0.47632573186309796, -0.6259662535772332, -1.030155549573109, 1.3968667775550208, -0.25228271309453926, -0.0779214955444615, 0.45559851134749096, -0.03865564276750947, 0.13785891093404629, 0.20116387542049405, -0.5167747276138206, 0.5181428957209597, 0.22118959729627471, -0.8316604746653095, 0.763548522944236, -0.8017002862712693, 0.3360550447791398, -0.459351334340562, 0.7944754817150868, -0.4902669343615234, 1.0387889630185294, 0.7350617151620674, -0.39327313316372864, 1.4646508753400664, -0.6218866427846856, -0.40796786214577885, 0.029729061377414073, 0.16748512351786976, 0.411109939153834, 1.055212507690089, -1.2859609961816107, 0.020323073607598247, 0.41128016481303525, 0.10978883520303483, -0.992166053614367, 0.10107377226460158, -1.0223737078337247, 0.7163002157766337, -0.421470194618002, 0.3205706932178294, 1.2885489655725193, -0.8011271799227349, 0.7070045587213861, 0.45951426689410807, 0.055909139586892434, 0.30085098376693375, -0.17908651378922633},
    {0.31427924238753485, -0.7804384125764823, 0.9350757637815187, -0.5092148974281772, 0.8677212250767352, -1.3053602495778525, 0.23959599820646046, -0.245227207100097, -0.6403251305121073, 0.08082733348078987, 0.140942677683828, -0.1135064920265109, 1.021194547325215, -0.6114448022100342, -1.4128177786036527, -0.5252754821742093, 0.5705216691812052, 0.03350966504805767, 0.20124411296073766, -0.5684667794248873, 0.7331148611224941, -1.1968483927235207, 0.32213074638638667, 1.3951191389110968, -0.574190734076563, 0.3078692163594918, -0.3507689047166402, 1.2931838763216523, -0.39603991497760815, -1.2008145056928317, -1.573741402030416, -1.0389092018347414, -1.0750162720428127, 1.0310184807394915, 0.5392044612709284, 0.7568740896633854, 0.8712941759017514, 0.7160856270443816, -0.13196783483991345, 0.23891446375441874, -0.19305849718656748, 1.4095906687239395, -1.216105774294927, 1.0414531234920217, 0.30512791925634014, 1.5055898564216488, -0.6732646768678141, -1.1670832202885386, 0.3127065211112657, 0.2290173726196333, 0.07504749761445591, -0.6540064630163033, -1.2844025879958758, 0.8404911874698768, -0.8144822348357141, 1.213628010484669, 0.7146666842390955, 0.2117410297565628, -0.27769666319807945, -1.0244428185421781, 0.8038786659842878, -0.6595808305331443, -0.833165085511542, 0.6475595082540394},
    {-1.4386201790994795, -0.39856930281592556, 0.6701390442796972, -0.6467073105811542, 0.3121474995466058, -1.397039324077083, 0.38792350975727447, 0.5719622642754401, -0.8063754007940307, 0.12212698894453881, 0.19772949285262215, 1.4373190928675523, 0.20954160325851964, -0.8672856647293395, -1.1380977429369363, -1.1118012602462832, 1.928504824511599, -0.24746745998372568, 0.7389829729844473, -0.8429081982172918, 0.5754874483167384, -0.19525259015209953, 0.05251633054384042, 0.16389886468158663, 1.1010279282846613, -0.16358275400347475, 1.1277228406993094, -0.4622324049759596, 0.7121813743596915, -0.29779482645683625, -0.09841074913574896, -0.02942396503851487, -0.9127319333791057, 0.7641405049667125, 1.5265248254886579, 0.6416556829814213, 0.9183654349692347, 0.21301921499592874, 0.5605526422617503, -0.48966311903468157, 0.8649262596234848, 1.426816435835311, 0.673204961765373, 0.9697086232986727, -0.5785470114516769, 1.6129034331184287, -0.5454837531829672, 0.07111484362523778, -0.32257667261763584, -0.2908053576840465, 0.285830638608566, -1.3510960392194757, -0.9113355921566771, -1.041375605736771, -1.34612713375879, 1.7098861729292583, 1.2150609622326711, 0.36611736180532817, -0.14767347202279396, -1.1870775469458203, 0.2940865862615988, 0.3486912912525189, 1.0403461588717702, 1.3659499168923641},
    {-1.415756518841233, -0.5089148726953503, 1.171647522535268, -0.41774021998529215, 1.10265369550209, 0.25263460788241604, 1.3268470049843628, -0.13502360131862307, -1.333223054802807, 0.25367255300548675, 0.5654199888501175, 0.18408696865594476, -0.4163095685019831, 0.7335243071650619, -0.5018308950365954, 0.14803201783816547, 1.6013142532405873, 0.283185135947659, 0.4710145255854495, 0.14036459980785948, 1.0363732776665247, -0.7934011990483952, -1.6308465908425167, -0.1477305198871356, 0.7050972039317492, -0.6164761465410443, 1.034125583538569, -0.021684066668120387, 0.8621775537399607, -0.27810285103064075, -0.09157273816476529, -0.2985128261966341, -0.7032857268557157, 1.1127059196614764, 0.9613852699243194, -0.6259508242710589, 0.38381180413844923, -0.036697308816180434, -0.7887043231619275, 0.3482624306007253, 0.9374684692681621, 0.8080799471850959, 1.0444340165637647, 0.919698809205855, 0.32016603546821537, 0.8195346182195414, 0.4134012828598576, -1.5415261060059182, -0.1787535462702383, -0.6915922326908578, -1.5369012521838632, -0.0422911670824389, 0.434161154904162, -0.8885582794609225, -0.4150086970222504, 1.1129009723398924, 1.403300199520959, 1.0187675035210129, -0.2607383603257288, 0.14216755667593306, 0.13319334195022026, 0.238358670753323, -0.966292612699083, -0.5623181834637885},
    {-1.7021873764317401, -0.8602402114163766, 0.37261054644502706, -0.26456139194168976, 1.2468839612862, 0.2925273552470256, 0.17354981622359786, 1.5876360965851646, -1.307925471055517, 0.5961577750851803, -0.02199378913135552, 0.32264426640301536, -0.2297900813561056, 1.0498305944610695, -0.035873552776068914, -0.9935415224785242, 1.3337440548390251, -1.11139545985351, -1.024621058283696, 0.5982275313354972, -0.46591796631495186, -0.7120419262670186, -0.9089317762084518, -0.1538047364617964, 0.5988669568018739, -1.1987495334041183, 0.10729159414959047, -0.7206315813427675, 0.17211119598440677, 0.21229200167770965, -0.9087782595068871, -1.1456254686143026, 0.3595942721093753, 0.3644737216617989, -0.394850791044972, 0.4330353015874684, -0.6524544723385443, 0.8623673288099201, -1.0683843966495963, -0.22728089440452906, 1.0256181333654284, 0.22575469594088884, -0.29342645824170405, 0.03770278379584732, 0.7980175140569895, 0.027824668926385205, -0.9982037160269157, -1.3946561488295706, -1.6691599411347935, -1.2460529199594943, -1.5049561352221565, 0.25358774731759054, 0.1780524700110209, 0.0995882905819514, -0.5041063133154036, 1.5351702147301909, 0.5966103480269908, -0.4414846003351879, 0.1886296239970473, -0.48761478314280937, 0.9619078877302031, 0.9347070063972734, -0.2397285493189441, -0.6771574464613396},
    {-0.7909846984877391, -1.779277566966909, 0.3573146844723085, 0.9510961544118427, 0.8247681322289472, -1.179181695741274, 1.1730593967939742, 1.0564628272918446, 0.44355157134677237, -0.6653353533010468, 0.46882398242773715, 1.4030436025482806, 0.8992428650772128, -0.779817225934431, -1.2731802456441599, -1.452835291222596, 0.07941197231544664, -1.264168839808957, -1.0013221218133124, -0.9733767873010997, 1.1180329996870293, -1.3339529662288716, -1.5578137229009374, 0.20325786470987325, 0.44250810777408744, 0.3768305348750676, 1.1651154426134362, 0.710099756086128, -0.5164333800756699, -1.2563494375864832, -1.5098877762763403, 0.3543794309092003, -0.8342433138872989, 0.19806998398928402, 0.574703527838454, -0.9960250338771066, 0.8177429783537186, 0.29779716038447807, -1.0518951368656153, 0.3787981400929442, -0.09184914209798321, 1.03943723160363, 0.061276566709755655, 0.33951367040993474, -0.6495424443148685, 1.3291527183241973, -1.4774373875727316, -1.8920890421863639, -0.5411235040210319, -1.435095781616016, -1.188978559423518, -0.40998019407639785, 0.23998352856534705, -1.0786667345196599, -0.0684034601187611, 0.15030129485440016, 1.0366296701712199, 0.06061117491703256, -0.8672690972060719, -1.251941173536687, 0.264643366586115, 1.0617116783861256, 0.05293136029530195, -0.28124133730831596},
    {-0.32635257547106417, -0.40003750363211055, 0.4976960594802741, -0.3052249244118781, -0.46493865698433057, -1.347228545067356, 0.9076115020847078, 0.49488078189169626, -0.17653360895637935, 0.7844068561214407, 0.5950569252588414, 0.913769521692185, -0.43424595445952163, 0.3121052376314254, -0.5916650276309086, -0.44784073839332195, -0.3354725619747842, -1.5258794027339704, -0.12221659340370775, 0.4358022185385199, 0.4863759091093647, -1.0438134572394462, -0.8360369542720156, -0.5253375137239193, 0.8029531622144745, 0.32626482654507855, 0.2927343643004141, 0.25984648422909074, -0.7346095413043665, -1.255466495107092, -1.8307583418318931, 0.3251406645318751, -1.1497576920705928, -0.6241699958269915, 1.1422222162262554, 0.5066870341120348, -0.7273675097242026, 0.2828075631262307, -0.21973507568090547, -0.07871445153358247, -0.0925110909729063, 0.8632439225916799, -0.44917489689524315, 1.0304554523859781, -0.5663080581252831, -0.34809541697429114, -0.9842897189716935, -1.164513837122077, -0.8589208334838021, -0.9783062775904017, -0.5738747885426948, 0.6318395942952957, 0.05816167320137848, -0.5352042205097743, -0.8893567119124489, 0.7614721013889741, -0.09103572616392809, 1.2620483568613994, -0.8578951122037762, -1.3521541637960952, -0.44132879122059376, -0.10534419492881725, -0.62320004569939, 0.9474066464933902},
    {-0.41119793979925595, -0.47586556613486874, -0.17287382879782628, 0.037659266126993544, 0.6045552417851301, -1.4025334703691112, 0.5585162775616843, -0.4922784315344969, -1.090992425388087, 1.2278111141328418, -0.11977490813813903, 0.7616036859755048, -0.8270952080637085, 0.7363312469186178, -1.4932948563901003, 0.07426545335780696, -0.367334935751281, -1.2705294608699103, -0.047134893194682885, -1.2524094798426162, 1.1719729462730146, -0.4408616154687399, -1.5623524052318918, 0.2505732106512163, 0.9855193761594485, -1.5628930547929325, 0.09008943502774872, -0.15595712426321498, -0.39035468823188046, -0.25650332330289427, -1.7971451129181994, -0.9682998003139693, -0.8000037244937979, -0.23368345427663417, 1.3090412513433571, -1.2769421926964142, -0.4424599919515737, 0.3052717248837639, -0.9722999529913459, -0.7910945566156998, -0.4817093548817382, 0.28080730583045505, -1.0203069871021937, 0.25348177086697327, -0.35912502797948986, -0.21184939890906637, -0.10483934598185474, -1.6217849595901084, 0.06330405039523489, -1.1056267440896514, -1.0461616673032799, 0.36520313590366693, -1.1638018798815342, -1.0699390644627107, -0.20760976029409625, 0.3235735293922944, 0.6241437233723184, -0.1235448102960384, -0.09729303369016053, 0.11687306523441306, 0.6969871607421645, 0.8318082714893327, -0.8326732333281308, 1.0129653357590862},
    {-1.3429279311827909, -1.664231406391242, -0.319328952406839, 1.0613577099022549, -0.6038971490855133, -0.4737919186743284, 1.4583685960170831, -0.26800747916295825, -1.2970958866067668, 0.6478197678940623, 0.06924558120082035, 1.0522163176480768, 0.4059297463231412, -0.6789838268974948, -0.7384785295259608, -1.05761297984632, 1.1391859296790408, 0.2307822227825169, 0.7450436305820214, -1.262821418823555, 1.0070269553622524, -1.2155952259009093, -1.2034162867568752, 1.0183008625643941, 0.8825246110731295, -1.317522827784367, 0.6301631901669432, -0.2858627860384986, 0.7678915492605363, -0.42582815268064417, -0.718681199678519, -1.1775056898890293, 0.2322049209661358, 0.05621272789995407, 0.05771680714220252, -0.6757747914074321, 1.3494964881343017, -0.04243158478366738, -0.396483015016653, 0.7739149584554919, 1.3301091690591482, 1.135669663011942, 0.2011966302171372, -0.29142312746956467, 1.0339050018044902, -0.4837554246714402, -1.117916842024801, -1.4924157469937234, -0.9921127358272949, 0.3758411343067612, -1.319432574497653, -1.1277561651629402, -1.0692887464673129, -0.5396546489981524, 0.12029023740406874, 0.9851066720055083, 0.5841694106418862, 0.8604211118764918, 0.08374692283501392, -1.8092861807870884, 0.9150847780418095, 0.6756927155444582, 0.5100441930524872, 0.30758668402334605},
    {-1.6610184307813531, -1.48878380283897, 0.9115363574144939, 1.059013034733085, -0.38573228834097123, -0.22585991669442382, 1.2866804771380147, 0.24068750601073707, -0.10663290191759167, 1.3228558128348724, -1.0384378704575217, 1.2696155771059314, 0.6786446101409652, -0.13153567660739235, -1.5911582237927038, -1.1067246669039057, -0.22840305741929162, -1.5541455433827907, 0.6800080453990749, -0.9705478090406039, 0.8857328488817099, -0.40310064180512595, -0.4350470896833643, 0.15286235481335125, 0.19253675738263865, -1.4101218086291356, 0.16832998431058824, 0.4144293512099958, 0.8593544287198176, -0.33167600763357313, -1.5416061138351738, -1.1308699209725928, -0.1449510998427508, 1.4422912044418434, -0.019918629586927115, -0.8803817384462062, -0.1300285488910983, -0.9578677906238323, -1.2913883664230217, -0.19264557976877308, 0.890128669415923, -0.3541364794495585, 0.28487997702408047, -0.9753301519877008, 0.6937133774565967, 1.0737084099174177, -1.104864193000072, -1.0490483842995801, -0.7964486837279748, -0.967421770518426, -1.8276259538228337, 0.35870781329791673, -0.5709588777508121, -0.8948894834975984, 0.3473129245646817, 0.2354084010691604, 0.8043112652456528, 0.13414915442327902, -0.4961855209972033, -0.15962922253664458, 1.2272440487283431, 1.0605487288621933, -0.9771280304645121, 0.646866338239497},
    {-0.19010315669760663, -0.456211162925978, 0.944338835589812, -0.8984404820094786, -0.405977357120545, -1.0327675985745286, -0.5598521068392452, 0.6088674089371223, -1.0696525987967236, 1.0681374510143486, -0.8936597960449697, -0.5001964861102294, 0.4902560581528133, -0.30408939521053835, -1.541287485240102, -0.5824701464283862, -0.46875222464185545, -1.3552259823661936, 0.708029206479697, -0.5553752682406865, 0.32977774790467757, -1.4252257462947864, -1.315910426702842, -0.23175309919241335, -0.37121330338895686, -0.9598468927781199, -0.799767055513313, 0.5000302705253776, 0.7536477463212383, -1.2832865594738745, -1.2095890062241967, -1.2826443452891565, 0.17474202429978125, 0.5393517684592176, 1.1835045097127876, -0.024777068416951854, -0.18517285132471675, -1.1837582649020348, -1.4211087224007286, 0.5337141892675091, 0.20440050705620869, 1.280734636447922, 0.5019295563579244, -0.4646656583583279, -0.3709195623569955, 1.2269657043135807, -1.3456639679717688, -0.8347910726150758, -1.283015646158631, -0.04007179478082552, -0.4642470646838906, -0.8806729123264802, -1.3884789485790525, -0.7394745283261094, -0.8288788686747111, 0.338879191073869, -0.8287775377819278, -0.12309085341164458, -0.6179581132862401, -0.39758202470443627, 0.2005131977218001, -0.791023363994681, 0.4794666127275991, 0.9233171392708646},
    {-1.439572136736477, -1.401106403574428, -0.3784548817438061, -0.5838305115517797, 0.033494270754947264, 0.28355920306790405, 0.5973815257064852, 0.4869751280376183, 0.06896798476121077, -0.35486863875264285, -1.046454887783379, 0.1551245947718061, 0.689220069466026, 0.07022701859434533, -0.40794947816500715, -0.06111810625080295, 0.42229021213807616, -0.9684952627263047, -0.7333523912656612, 0.3503410510331677, 0.6856129962377079, -1.2346212147549867, -0.5776084544114622, 1.1951471926570736, 0.17763483296441482, -1.4179250355311208, -0.943220708583789, 0.6193912841833257, 0.5818089013969522, -1.2117550750664157, 0.24970266679981584, -0.2483201238951715, 0.5619291326031743, 1.3606199060230126, -0.4437069572519105, -0.7086935237135468, 0.9284872792444753, -1.07149323589711, -0.938246570876288, -0.491897418735454, 0.9447765723493107, 0.6656617710718765, -0.3634151749262793, -1.129115326572524, -0.49969536577843116, 0.3007600810949404, 0.23833307307344576, -0.8402971167505262, -1.4135305812277388, 0.48340035907326473, -1.0443963283367566, -1.454976772723162, 0.17528495579725134, 0.7811631287272752, -0.9350914169817619, -0.3150400231371044, -0.8040721504738324, -0.2571209112913438, -0.27784505557039807, -0.4898007041154864, -0.4198033767365625, 0.20041543546568738, 0.48452524785349144, 1.0524632075901004},
    {-1.484856567810127, 0.15896095391406903, 0.4568779499089092, 0.9873461265337259, -0.10493645531971611, 0.3749651334424639, 0.9309915613949578, 0.13285467415357394, -0.4679911142153957, 0.4693487714967786, -0.470609320431002, 0.1834663169644772, 0.08683581313180648, -0.1766145492882604, -1.5248633370316231, -1.3257283373791928, -0.21573527980344112, -1.6431493633489325, -0.8114996398956036, 0.40945193462825746, 1.0089381977780834, -1.3088905881136075, -0.0770783442950851, -0.11696886082098983, 0.45493169550371015, -1.0929621318560994, 0.5146313122117548, -0.29729074400354233, -0.7438949973723026, 0.294416002089266, -0.5492853565574672, -0.5022210878871834, 0.5284929588842712, -0.04719207961298131, 0.33313565871699147, -0.36716945648388155, 0.7915902298470666, -0.500430106016302, -0.49968630582916845, 0.8286934644020325, 0.4759701234676456, 0.5559630961087509, -1.2691102509446757, -0.28234163531452977, 0.004189156072986703, 0.3061987354769823, 0.47952315824182895, 0.03588963354108934, -1.9753789132238315, -0.9827354579803479, -0.3534560205589874, -1.0109043384672245, -0.45930656782737145, -0.4811588933237163, -1.110800969004379, 0.7934377340726712, -0.3557793330559074, -0.7481223840498674, -0.6268984156844415, -1.7710428145837258, 0.9098148775090278, 0.5901256445858329, 0.8647550593544444, 0.00595859741902478},
    {-1.6611009908114218, -1.581257803078773, 1.3319685752038233, -0.05478308412803784, 0.25141827418639157, 0.17679581419428214, 1.4023507424240436, 0.970879208663296, 0.25867659439782226, -0.41245704495659663, 0.19004681502070986, 0.9974646146464067, 0.18547402635159213, 1.1036195013173935, -0.15211982064000723, -1.4551351908698917, 0.586535852435194, 0.10403278038400851, 0.7007560171299185, 0.4061736908032878, -0.7462732626241529, -0.07994898524533146, 0.1477958018077397, -0.38245795933871196, 0.40135716423735857, -0.5385863198683634, -0.9904839278270404, 0.10468153388009926, -0.12005609561211682, 0.2893903063629482, -0.06276200647286023, -1.2031676999378078, 0.08121960751699242, 0.6623285668200398, 0.04770547822294516, -1.044139315548126, 1.2703301206670647, -0.0998792362388256, -0.19430705588400096, 0.306701050851863, 0.8833321880651751, -0.21878925696483453, -1.1857868323365384, 0.7575447848504115, -0.9329336881888459, 0.8045487199935192, 0.014545235483469258, -0.1185877533661806, -0.7586265056765763, -1.2870493277520252, -1.270869054106122, -0.40012809754828155, 0.5849376105451349, -1.1328039145760216, -1.2959224417584887, 1.3679345219812429, 0.3538754572664191, 1.0285212906246828, 0.12056843880623289, -1.0427687755368507, 0.1071202255136243, -0.8950526319219453, 0.8933845684767715, 0.07702666620956167},
    {-0.39105948309657124, -1.2727478815736641, -0.1261075532547004, -0.7187823378205508, 1.2489902521613168, 0.4315221009216475, 0.8213933251418153, 0.20743315433265103, -1.010108570354274, 0.6232695055307201, -1.1971086696007731, 0.7353966213362415, -0.736631109382968, 0.3045393726293659, -0.8019434290976939, -0.5798454142537198, 1.286520312505428, -0.7271982585586907, 0.2505602199621666, -1.1150407283512331, 0.21169590945213568, -0.2972226198768708, -0.9841006062155905, 0.6817451384201083, -0.4902067894756809, -1.3537116633517605, -0.3245687874146374, 0.1360952943954606, -0.17771635887409146, -0.05248044331539479, -1.2136050124194642, 0.3920639903470867, -0.5055396094440165, 0.6996374271388269, 0.0671420330233815, -1.2202544038770713, 0.7381910287211583, -1.1962842366451396, -1.0515921173176537, 0.9415069308866818, 0.05157420615101134, 1.2670448773406735, -0.03347715489055473, -0.6729818522131582, -0.10098247026342423, 0.24530687436992352, -1.2010644758856426, 0.08022055152135288, -0.7228012572611713, 0.30831634057580437, -1.81572256805186, 0.15807761890655958, 0.22938751006100722, -0.3089854384066697, -0.8203596297161639, 0.9011651563364327, -0.7658458954740222, 1.3297678345326263, 0.31283723069458025, -0.10878284859725168, -0.12764359504132455, 1.0850298424630997, -0.32911856581430726, 0.3888099740820693},
    {-0.856084955133052, -0.9144165703968259, 0.4891386633279704, 0.48158533130654724, 0.7031226400123708, -1.4411525346656835, 1.1998536963693787, 0.7072670969591817, -0.7382325842209323, -0.6164983114882513, -1.153591890060149, -0.21614810063782158, -0.7532359923320399, -0.8521046269612413, -1.7239648708199593, 0.006483527531506652, 0.6710883892364485, -1.1724463964144762, -0.6949117296715237, -0.7017255669124352, -0.06466395633208685, -1.7393583404037178, -0.03007833360086131, 1.3928348931432926, -0.2990219303064195, -0.836443759979696, 0.49938368162561825, 0.10978429042536308, 0.11500270354670651, 0.5195605450313547, -1.893900634386383, -0.6813231290722589, -0.15362757233881807, 0.4110960030913211, 1.4401858311883782, -1.6289890782759753, 0.34756009952598854, 0.26892434784051816, -1.4135532537131006, 0.9112607228396924, 1.0811583644787086, 0.9146442601684444, 0.29973840746865604, -0.07080623669347813, -0.6865482454990601, 0.11028452378187237, -0.6875433235959886, -0.7118619820796919, -1.8469722448645263, -1.3012993541516682, -1.0933850966808336, 0.10244007577885127, -1.2821018439665606, -1.1002705495874694, 0.09341666402186419, 1.2243798413721232, 0.25376155350524904, 0.7394546674830078, 0.3930996939798605, -1.1715894132000435, 0.9084345726118567, -0.1408866363996189, -0.10093590089421677, -0.4762406573956951},
    {-1.3548972424086005, -1.1834353160114919, 1.392565351993796, -0.21962827534838655, -0.3765245456521677, -0.1643216826021477, 1.283271356497191, 1.3193314338727502, -0.5526323069167134, 0.11528865319153099, -0.3890721009324582, 1.5577643203880578, -0.35715416475846046, 0.8711771256745104, -1.7761881167312101, -0.16278426171051438, 1.0889204440051894, -1.1155579467151295, -0.5606894518999035, 0.3075165335371738, -0.06395460844719685, -1.192447083215149, -0.16590238294434265, 0.5235128476170409, 0.08198914634212263, -0.10191718022159943, 0.330876843649714, -0.6838306741818285, 0.9872968387659413, 0.5094057407983862, -0.5969271673227655, 0.5071057411626753, -1.0640624235006912, 1.657757709503307, 0.5448721703652386, -0.5623154875634993, 1.2748890529834838, -0.6909634159699275, -0.02870607291123541, 1.1419495102087205, 0.7298546884234862, 1.6141249141307077, 0.9068892987251344, 0.9948018260076633, 0.7055991444508025, 1.4770503888889475, 0.10194271626683397, -0.9129159272505942, -0.9154226847042164, -0.5716047588607589, -1.6079165648048834, -1.139781953673477, 0.6867835741388807, -0.5501449287526072, -0.30893711576930116, 0.5521674104626848, 0.3224489416463003, 1.5078492900299263, -0.02116147515521047, -0.8017626252961466, 1.0143515873484366, 1.1851727592345815, 0.647248336195491, 0.9666114258184861},
    {-1.336026304830424, -0.1072369998918948, 1.4477348332644888, 1.164310924231258, 0.42802213012654344, -0.812610491866192, 0.11206316902162304, 1.7809480935982591, -0.6028656712133282, 0.08740072400287337, -0.0803111623940735, 1.5951052574258269, -0.10075864541951604, 0.12746290523834952, -0.07670512117571895, -0.37052146657116736, -0.031870267439017406, -0.4524834331648753, 0.6143319685759053, -0.0989147258750912, -0.3219042872884094, -1.250193279127766, -0.44537113244282145, 1.383053809203051, 1.0849510634387975, -0.46191876083278555, 0.46218381131665065, 0.7056622769475446, -0.5877134976944302, -1.0101137061535035, -1.3879551145781277, -1.1301357172260889, 0.5279775759807954, 1.5583565280741019, 0.1103985723923929, 0.5286352730854306, -0.2385962685227122, -0.4656863674231438, -0.12176391077042799, 1.2700083733038432, 1.7111805084320548, 1.7589167166150017, -0.4073345359537066, -0.030463885094949694, 0.1825293357452184, 1.3954601949309287, -0.005785930957440229, -0.775236032950665, 0.09990126098979535, -0.46435762678907894, -0.8168381922379078, 0.02223293328996264, -0.14977168625364187, -0.4869419765734131, -0.08696364936929457, 1.729606353722596, 0.8890158033405097, 1.1350250540212705, -0.43404922426278725, 0.23828292870812162, 0.2872201643838736, 0.01605071991833765, 0.9654164775787148, 0.8063138325400392},
    {-0.4470758830009187, -0.36145785032675903, -0.10368673591129784, -0.21928961776413822, -0.06481355612267255, 0.15544806202211037, 0.48712356642106847, 1.4709217706885154, -1.283399590973113, -0.5692555776694195, -0.9736906585415819, 1.597718821946177, 0.20243108924940817, 0.11388554728438419, -0.8527022073543785, 0.05098315407837586, 0.8593911897972324, 0.5416569128887524, -0.42209124401218984, 0.5932823207231701, 1.1849953103790687, -0.09648848088468415, 0.3232194120987804, 1.4842164408711296, -0.14036325949582368, -1.105447269393985, 0.4479200191767704, 0.19117938484315752, 0.728078871039625, 0.20682941608170569, -0.7659404581912186, -0.7794024005753358, -0.9731941288719628, -0.30086351791119725, 1.5403797153802243, -0.5307069466837553, 1.3458377407383735, 0.5986310888042253, -0.2930390385075053, 0.42210039677358824, 0.5153069281562497, -0.00813392473358724, 0.8509082746934326, 0.048386167537782014, 0.7824664441899758, 1.190396629879882, -0.9411371751216976, 0.03083556886181802, -0.7485121739422421, -0.7687559189159676, -0.1691008875040227, -0.5825216573660356, 0.2355446341092876, -0.08128822557880773, -1.1749234590330286, 1.7455696865843895, 1.496944569143655, 0.3130851791412674, 0.4840286842711767, -1.6373591674582655, 1.391205698960698, 1.124397655550261, 0.5527191212530611, -0.11799176309581133},
    {-1.478612599153018, -1.1962317598455097, -0.513859888693004, 1.157714766135386, 0.2891506425216954, 0.639473621396325, -0.04531081248659081, 0.7300488615269515, -1.3399396076561028, 0.8224310966794119, -0.9149686263331107, 0.9222943411071612, 0.23757048571620507, -0.7078686088630081, -0.0873800526388319, -0.46163449616798496, 0.33649626784999614, -0.9643156743191158, -0.10019185026959748, -1.020273054970212, 0.7476347768674761, -0.8802628607312238, -0.9863339470823131, -0.01590030611130302, 0.143902559918481, -0.5491586445203099, 0.2648854902922314, 1.1469699846768804, 0.6888781216080285, 0.4035045008187371, -1.751511348675056, 0.3604251591159036, -0.6160626748098589, 0.8059725053923928, 1.4207351731422866, -1.3146470760986884, 1.307317000747639, -0.9094488187338492, -0.044016477217265815, 1.027968502867423, 0.38171024477137716, -0.21223077446803063, 1.017933348076937, 0.37408049875133675, 0.03629939516129502, 1.353069220952691, -0.7384133463091989, -1.1442940490796063, -1.7419493334103306, -0.43627229245481114, -0.8824965922544191, -0.3770897505553561, -0.37160390015835626, 0.0900351330061816, -0.4393840783565171, 0.56246958991265, 0.11122122604125413, -0.17932291439560713, -0.37766213704965534, -0.36488466142471165, -0.5769183770055345, 0.47875291235791884, 0.8217875278996672, 0.7966646308405242},
    {0.014645711733019273, 0.06342905843990923, 0.1650219807175256, 0.9157744880368092, 0.7057485362302143, -0.5933691752985006, 0.8088498918872737, 1.4129513653280639, -1.157019227937396, -0.24665787340989237, -0.40063274472884824, 0.6266052833894357, -0.1795357971344733, -0.40945089718130945, -0.46341835014339794, -0.2870781324801747, 0.6065935870589655, -0.5984113007106828, -0.7986754398296013, -0.0019382447460807434, 1.1209691368574712, -0.6474625768134328, -1.630726168169519, 1.2542693804922682, 0.47336334744449565, -0.6314301976118709, 0.7491413815084335, -0.2864153133297755, 0.722101950222358, -0.13778041748451836, -0.03477657568879433, -1.3467146271338564, 0.3870048753573788, -0.0659440352119051, 1.3749192394320322, -1.2162227708543318, 0.24386934042877473, 0.6391130104500407, -0.9464014596515342, 1.4850623431959615, 0.6774536108036663, -0.2573907540393247, 0.13363051867721193, 0.5019851639944849, -0.2828060408818501, 0.7374718253317564, 0.04521620013559495, -1.048794878451145, -0.8618187255969558, -0.695271077950741, -1.0564572089307613, 0.4212112183601665, -0.47811590159507944, -0.4187710448467374, 0.4448657956402991, -0.020830975104192306, 1.0317689532029413, 1.1938809973157685, 0.6168925482048131, -1.6110571172918993, 1.1890313813388498, 0.4906017232048576, 0.8087404787500514, 0.9500310217317727},
    {-1.3009793267600358, -0.6333568477904529, -0.1770393724228771, 1.0866679854172563, 0.36423961077863987, -1.1209710507546085, 1.2382864625529226, 0.7671545671085904, -0.4055983327487435, 0.7718766080491378, -0.6519440932851334, 0.8340549609946398, 0.9831718401612772, 0.8963529919526757, -0.9159624217567589, -0.9838695878415279, 0.9490135073660896, 0.3755214067543115, -0.6893876397430833, -0.38376445663851827, 0.621666889300684, -1.2835798266464191, -1.0102440372400194, 1.0113166590378195, -0.1844919227687352, 0.4317015989206437, -0.4905944156806003, 1.085924348797798, 0.49822088875959375, 0.309903884224507, -1.1431252027547163, -0.8405213493766217, -1.2556696253301796, -0.09205478112863505, 1.0896330724816372, -0.5197566147303644, 1.5491963216202331, -0.7545830991168312, -0.2107854063804586, 1.0269475186460533, 1.4065524849799822, 1.5025915279160282, 0.9407702874554349, 0.08737604351119943, -0.20642363188949456, 1.351212769281007, 0.6193405914322677, -0.3011928633966738, -1.5233835823477193, -0.5484887845844783, -0.3800408886834413, -0.6126305431893033, -1.1325053981359883, -0.639263116319508, -0.26427343422325, 0.5439359636603056, 0.17400675577595073, 1.3169099290794162, 0.8078727703602222, -0.12783210180784388, 1.0867914323978887, 0.15433087882366672, -0.08999716967155218, 0.8162704688434005},
    {-0.4440164016268273, -1.0614350732822688, 1.4149862471569572, 1.0403332126717386, -0.6195138917757358, -0.11648765338008546, 0.7427967541164721, 1.6185523231365437, -0.034957328119192166, 0.7314534010859375, 1.0920864817606435, 0.3799526378721837, 0.6258481307261127, 1.1030664730939483, -0.1712847091846104, -1.1995121232184613, 0.11651202846406543, 0.45949597544257725, -0.10616662702058025, 0.40750439903384583, 1.37471749876823, 0.07777403276175666, -1.2386317998163063, 0.07930373692510194, -0.6101022751410982, -0.20124214031880544, 0.3094133125840702, 1.2944556116088488, -0.2678635819172118, -0.13520694227380534, -0.3242533625638448, -0.6638886215668232, -0.8141275969745334, 1.8437286741598853, 0.8992554884098872, -0.8764161706843201, 0.7666255069889889, -0.22210464327005353, -0.47368144501954834, -0.14688662485173395, 1.5947130788293762, 1.4401811653665875, 0.6978133398296452, 1.1113846872419475, -0.40572153522704363, 0.6379535618718812, -0.48318775412921194, -1.0573539447056512, -1.3370712230678476, 0.2863392178435171, -1.3979370071378325, -0.18711591600663594, -0.6432806985778237, -0.8702547642020095, -0.4216086106744904, 0.502079396191512, 0.6375145712391068, 0.410997281207036, -1.0410024696746676, -0.4434928254345649, 0.5413826465862736, -0.47225123379802536, -0.6646527502243276, 1.280467358158297},
    {-0.014282429398918463, 0.028394149050728727, -0.1930204816981855, 0.08498055843147419, -0.4571977426272498, -0.7148141725577439, 1.1726821028320962, 1.8485548429568108, -0.12201091595119876, 0.3421266658113849, 0.6856435692853324, 0.6108988430813782, 0.8349705233307839, 0.6006234361934194, -1.6167106936766587, 0.1379492393961133, 1.2370424526147854, 0.04803403403009853, 0.03567407578995837, -0.46879493920621396, 0.7490907827437642, 0.34525144913950007, -1.0350579281436638, 0.6897860315441198, 0.9899431413443567, -0.5413985775977547, 0.20939883563025433, 0.46040001228677735, -0.05172959661843826, -0.8672684587655192, -0.5599188490367423, -0.9823429027896331, -0.49616368999643884, 1.1359296261562424, 0.7183900502187118, -1.3499683787689618, 1.4474661449903443, 0.5920136079294036, -0.7182955839432358, 0.4769891267932869, 1.0591205801048205, 0.025526867699024316, 0.32192763909509103, 0.2281699390896304, 1.0194692655733377, -0.1737924417621096, 0.6629928901841537, -1.5060655759574226, -1.1649660660928223, -0.6588626320500751, 0.24763890450434348, -0.41015427720831343, 0.24658355084553782, 0.15383828322215132, 0.559236502476314, 1.3822370892377267, 1.499377787051806, 1.399880632934633, -1.0255081843521316, -1.6786059107557594, -0.3626179329187635, -0.27066543346979877, 1.1053966319929842, 1.1282003122541624},
    {-0.5155244387583403, -0.45491041689240114, 0.23549981563021172, -0.36940236895231277, 0.4153179032492283, -0.16154005955018932, 1.2004857123895667, 1.503907259678398, -0.8133502953416458, 0.5612074318979424, -0.1745061927083667, 0.8688226845184157, 0.8413355751854106, 0.8790628854282361, -0.9391622603050379, -1.027701227873792, 1.1787210298519553, -1.0881047516370987, -0.11318948472903809, -0.12510247902936258, 1.336834930727432, 0.5086245878132455, -1.1353456911808828, 0.9744776527777358, 0.37078190491407564, 0.06572452497041817, 0.43731254521071183, -0.05385853323169854, -0.17584944634505395, 0.5101732501338155, -1.89941643847592, -1.058493166019982, 0.17390917432212455, 0.28512217849647437, 0.943854344958531, -1.1327797527318229, 0.8349363872315197, -0.7748764251512967, -1.1624333672244342, 0.4384135202805116, -0.2000070039036027, 1.0334925489649194, -0.9496189045048803, -0.037905719075523016, -0.0788473561648018, 1.04769131043662, -0.2956932346438027, -1.0906001351607884, 0.1869303838234914, -0.7522739349244858, 0.07784499614925039, -0.43083136622692453, -0.7837690049167713, 0.9331224241910974, -0.6668536917577368, -0.0009184547607678305, 0.5564541584554604, 0.34710691705180663, -0.4112519161802279, -1.1636965533053858, 1.2609311637800709, 0.030924505424596953, -0.42082369523749785, -0.28199352383000525},
    {-0.43721960798007486, -0.65358047879995, 0.10241414386196541, 0.22914086340255793, 0.7391348595002065, -0.480564919403465, 0.3321592464960885, 0.9765477575046464, -0.5725652482244697, -0.4819073840330332, -0.583965903769302, 1.2309684531386935, 0.08613548314967992, 0.9043143498302177, 0.30702955911523594, 0.23519554413632646, 1.4013823979335265, 0.07377432471869098, 0.9950971263881992, 0.011425675990871778, 0.061129669934049655, -1.0260622715809116, -0.4124633549814294, 0.39453416878812764, -0.18558235296127795, -1.311658145630687, -0.5979225768686768, 0.8202298793751803, -0.6091453790939395, 0.6995224595121358, -1.8137998042402357, -1.0700254938041187, -0.7081461776782997, 1.4271492669238652, 1.3789030346866602, -0.4798959716069664, 0.5191286217660738, 0.8052677915544999, -1.1542645633450412, 1.2956510163605732, -0.04074097764434811, 1.3856989909839985, -0.9830955279522705, 0.4119427217873705, 0.9917248735487391, 1.6029450248174701, 0.1565397534106065, -0.7859891975120401, -1.2031546621108355, 0.43030824327031036, -1.2144381109159754, 0.06532892573635854, 0.39314534030909476, 0.2533013459760245, 0.17348164420267367, -0.029630429361843978, 0.5026495304719472, 0.6078235816792535, -0.2767421498812005, -1.4692800645632387, 0.25316290099743877, 0.9840649466645437, -0.37492785372929605, 1.2624516076076628},
    {-0.6704813839830625, -0.32078122778937873, 0.20312245485555697, 1.291426346807042, 0.8975316495344383, -0.7142603216472958, 0.30312747292610553, 1.484909098329078, -1.2402529793449806, 0.34041732373083394, -0.8376975112685129, 0.5488128285842157, 0.4047827656312956, 0.034527655979327734, -1.0378120254520617, -0.08456419990147968, 0.515437338617143, 0.5225858479199781, -0.17524287655649745, -0.5438485520788782, 0.8305082076031666, -0.03041736351521812, -0.4780473013564739, 0.2920019982763088, 0.26642069219736286, -0.592293107475271, -0.14014437465800103, 0.6343670262683189, 1.1982613592107143, -0.6272086968826881, -0.6542748250506223, 0.4720689025646915, 0.008706048911355844, 1.8260406590869702, -0.06911101835740353, -0.8440511790025081, 0.5922394904832757, 0.3896848557618257, -0.19250735833782415, 0.7012488177110165, 0.12157827249724304, 0.8003901597888761, -0.5810627260389194, -0.03461803266159273, 1.0874255794211771, 1.2805594391615893, -0.5323282872631863, -0.8973448865271039, -0.614452625506833, -0.1673306835066123, 0.050149985640961306, -1.0862663398625119, 0.4723954293868902, -0.3906417376157611, -1.3205322471715308, 1.7694567189195503, 1.0983259478766534, 0.6883372618529965, 0.5515182743920483, -1.4029346293758438, 0.38727320950216687, 1.2832616816326743, -0.5036359443225235, 0.6956766064061679},
    {-1.3263758972683364, -0.893161674580794, 1.5245446036259702, 0.6265293976222226, 0.15175240660409506, -0.09743741799735471, -0.10367862570908455, 0.6685253669647948, -0.2749274528500403, -0.15482576179208388, -1.0329560329768686, 0.9223396368143464, 0.09557419773751248, -0.01688904329385696, -1.6389588643182227, -0.18843119181545773, 1.3423660890289038, -0.6459106847384595, 0.4035262673933642, -0.9433039554990287, 0.13966283988760422, -1.4133196564453863, -1.647398162962643, -0.29010713501897595, 0.8855647640034824, 0.6605402435762358, 0.9636245315291395, 1.177068538601381, -0.025299591605445582, -0.3187988933994661, -1.0214232927718427, -0.533753357635946, 0.3226034841644143, 0.9533822486033623, 1.338740973934339, -1.2193088410612427, 0.4037355468133874, 1.042773410035936, -0.2043623621969914, 1.041968133097399, -0.331797247993257, 0.6585388647984475, 0.3112049865139488, -0.7272034467906034, 1.106863979415366, 1.5358494266680611, 0.05588634316096313, -1.7399228107781732, -1.2376532515661613, -0.9677225128852129, -1.4896929359085096, -1.4326394367774158, 0.42335618629754646, -1.0587366974043149, -0.2770909395927568, 0.7824845863900023, 0.30760519050958124, 1.2276078615673183, 0.6372203746002034, -1.397177443208428, 1.1725133021906238, 1.0809644269368925, -0.02021207922381014, 1.4777938966499118},
    {-1.214364691236131, -0.9930573862409009, 1.3596422511457575, 0.02562709210225464, 1.006273242617228, 0.17245255841184162, 0.6832911801700623, 1.4614681076110774, -0.4530848101569302, 0.7771237539824133, -0.2714632678790087, 1.40470249847386, 0.6733327507149308, 0.636628623394254, -1.747841290536266, 0.5612016324415515, 0.805762383949711, -1.0860875537899937, -0.8647416181127213, -0.40818323100524395, -0.288060404109274, -0.6132133958041531, -0.06455567432754022, 1.35721115177038, 0.3514335633070826, -1.1145700488664105, -0.5862645989710409, 0.5312176007821866, 0.37285306926829537, -0.8353460182010873, -1.1691831843584755, 0.5277801852715422, -0.2750996807233857, 1.6559597235221384, 0.537073562333354, 0.3641907215850832, 0.5736161211085609, -0.851179291376065, -0.6337667167623243, 0.10815934376473398, 1.2929233995078213, -0.060195515886009646, -0.4818514194938894, -0.5903853599958879, 0.866537931383684, 0.24319792985867186, -0.5244442732269184, -1.473919438937597, -1.2595217714412315, -0.12118366614662937, -1.2567665331908593, -0.6730424642692717, -0.5159910917052515, -0.17545167737837442, -0.22321525543702378, 1.0016418254596202, -0.285155474127358, 0.45720700292606525, -1.0547899936326273, -0.4629530552738251, 0.025276306585359388, -0.050871521987102666, -0.8731540409389219, -0.3859487858680448},
    {-1.4789215357540406, -0.7271415765321916, 0.17357587692496884, -0.3644080111415364, 0.987664019397352, 0.5389689782395469, 0.043785682117546874, 0.7038917256594938, -0.5593416204671026, 1.0720297464174724, 0.6224422842109387, -0.3228528635107592, 0.7979962334903065, 0.6586243520944796, -0.21388780638914623, -0.25443495431734425, 0.9794398944661947, -1.0723926025346846, 0.43762145343254905, -1.29431097775645, 0.3687651047147789, -1.1754589764449048, -1.160104806741667, 0.07326712110275867, -0.22746587558105036, -0.3059397200929351, 0.8107587008746251, -0.37947205262666966, -0.431089032372723, 0.3614419479952433, -1.5150711383092703, 0.0037993073972067298, -0.0687923746832525, -0.07939317244076238, 1.0525567350143135, -0.6368066689214533, 0.6830245029859024, -0.20540052940035833, 0.5015888381312213, 1.3749534646099846, 0.6083070485438792, 0.2512274852938638, -0.9470000420732032, -0.7867071803789151, -0.8275463799101281, 0.27082346791692025, 0.6320797489420561, -0.7160929024608905, -0.287021464298126, -0.4899004026150369, -1.0153081529789598, -0.7913581467556869, -0.9455327884021525, -0.4422022878344485, 0.6728821361025722, 0.1490265717696977, 1.108635982611857, 0.24334913120597998, 0.8442704453462921, -0.8790572599200508, 0.3102455596390801, -0.08057772770349347, 0.704858515628949, -0.09613028666777776},
    {-0.6386825349068503, 0.38528623188484507, -0.656725068430356, -0.6358826353629738, -0.9212394526250183, -0.22485982078585687, 0.4230615320025684, -1.3790283449937049, -0.050121070226489706, 0.8069782548569452, -0.9290991078347677, 1.0761593889787318, 0.6574554388381696, -0.016272677893834346, 1.3714846472184157, -0.6010758463850827, -1.1386381281703308, -0.34897958278159463, 0.6140626896999108, -0.4978138000170173, -1.0866926975306712, 0.7688819425834965, -0.27739545325870574, 0.6465400911529408, -0.5476749649508165, 0.8753918628639347, -0.06139032015501648, 0.21290037692723693, 0.5970246710110366, 1.2759614237751833, 0.5149872359660964, 0.0012992049473071372, 0.9884397633836632, -0.14202139938353533, -0.8914424565934318, -0.592408754892751, -0.11519681389537906, -1.2989154124203783, -0.39967122448449005, -0.8514615941994942, -0.5884160204514288, 0.9684368545614096, -1.0034817457890473, 1.039412663894534, 0.5144848842779961, -0.9289106055613986, 0.056143857075965566, 0.4445495289465617, 0.36204728592808866, 0.7685035866391307, 1.286890243944532, 0.940348969504767, -0.9275966711640297, -0.852465094702462, -0.2675022631291313, 0.5774856342673838, -1.3797316887102558, 0.4206940061025434, 0.8492963664640029, 0.40684789198303234, 0.8913784895136521, -0.15933256597218604, 0.02393167829781833, 0.22935544474005579},
    {-0.6343445652505948, 0.025668124079165813, -0.40455655188213685, 0.7351745348882189, -0.5994104097121871, 1.074205399434095, -0.3677721264714135, -0.6244259339998657, 0.8655359635189264, -0.4244814713775319, -0.25823033859747857, 1.1375898974215854, 0.34533386357770024, 1.102902804593768, -0.7366929879255006, 1.0395309998125204, -0.1238834853693188, -0.5001960867766323, -0.8909875412592978, -0.058834738653141996, -0.177410192291079, 0.8287345540093639, -0.3853948884002898, 0.3122730691152899, 0.06584410288886121, 0.26776793886718664, -0.3434099888175981, 0.47778457330007906, -0.7996667282021863, 0.07902535897877684, -0.8883033593704431, 0.048068561848760176, 0.23009714832013986, 0.5060824233338891, -0.8281196874554807, -0.1552669104221157, -0.08367321943101397, -0.26426574010736814, 0.6916394061126768, -0.11488867085108267, 0.9106984779192375, -0.38932786805613895, -0.4875173266475968, -0.7955866491599806, 0.7682924605448797, -0.23323127411889333, 0.18841820868806866, -0.8199681802117065, 0.67920789788559, 0.48893300647024196, 0.6783423019453891, -1.304150169048408, 0.07262337375913638, -1.020490233927818, 0.4167015626618794, 0.03678051282677182, 0.8227612934325319, -0.45822601515285727, -0.4420595392325947, -0.15098217495824964, -0.24260434364611055, 0.535136537734183, -0.7732070943304825, -0.3168706012687953},
    {-0.24814768469081985, 0.7872530016533863, -0.8524312521837778, 0.4726165890358261, -0.054235651175092, 0.8115567222899034, 0.9233114319692796, -0.9366421501091853, 0.024211997028793415, -0.3005870445120575, -0.4471613367079323, 0.8694613758394039, -1.0873325519969528, -0.21371366311123094, 0.8531897792414075, 0.663635291559253, 0.2909464818766481, -1.084352640602323, -0.4934733583936028, -0.5197844320931609, -1.0361469887412167, 0.43396844104751214, 0.48577492915018977, 0.31910642466755335, -0.9930268738555788, 0.8143355379728322, -1.069999707074857, -0.8648073242972044, -0.45523684182318436, 0.6460723992091953, -0.06092724892987531, -0.5626216631952667, 0.5439336821931854, 0.10709697868884385, -0.31625173417487956, -0.6507188033388966, -0.5590917108721619, -0.9084135952582195, 0.15822591149217294, -0.9648099762902097, -0.27149564053708924, -0.9342850257486875, -0.8458378353819916, 0.6839873906259821, 0.6894760565209157, -0.0019553714010095546, 0.5166117236383385, 0.2962431203716424, 0.9416443509894513, -0.9813055192202785, 0.282355683740157, 0.5084893168324514, -0.6344434716803726, -0.8734921003163036, -0.7722250886326018, 0.2725021207865061, 0.47688432214788445, 0.7233312106691047, -0.37835367349019405, -0.7030732144816759, -0.2912624711307313, -0.1827682956040061, 0.8657295839585162, -0.3426282822457364},
    {-0.11332266915716636, -0.5696367828830748, 0.9223831138827754, 0.4251308775046249, -0.9653706641758417, -0.5039351943757632, -0.615716612492146, -0.7206200787885837, -0.5229464050085383, 0.8164958692775472, -0.38427957994756773, -0.40694459774932507, -0.956366806597767, -0.5816054808481099, -0.5998007673136158, 0.46102880075615743, -0.3075571931850115, -0.2609468890266643, -0.5139572744727118, -0.5300578781861317, -0.7828507222285893, 0.2810683871650219, 0.6332886065280461, -0.16676961321516562, -0.6332117579877048, 0.32918779367405077, 0.2626751163058935, 0.24318821472355712, -0.8116545105994045, -0.7363883392676183, 0.9270889436971459, -0.9776613092580303, -0.7802986531789275, 1.1196620785535938, -0.17403673449330093, -0.9817225966708992, -0.13948215119003612, -1.3841964231890218, -0.8688274654184166, 0.5353873983635886, 0.24785239716399526, 0.3161211476001156, -0.7883156783462715, -0.491220031102779, 0.5057193261499329, 0.1693957058592753, 1.110993933790465, 0.5065982876331643, -0.15463084726224774, 0.4128987280344875, -1.038968218417347, -1.2888508476639555, -1.1539643594799938, -1.1234606890403231, -0.41776582651320493, -0.7242903244821451, -1.0336627904413114, 0.5885798197473844, -1.0856257522619317, 1.031368807952472, 0.5793876845888188, 0.3521296848664898, -0.6383347160841213, 0.7008642459942336},
    {0.5312712475798116, 0.11803117179938885, -0.793323817415883, 1.0763189433470595, 0.5634795712474714, -0.3018364168258755, -0.74647989020027, 0.3498858346824428, 0.202736988534256, -0.654853715365602, -0.9841791845397388, -0.02349472702459654, -0.12269593056665956, -0.1461610360424242, -0.7185920625606944, 0.4174521391452761, 0.7503968011453184, 0.33469388901467656, -0.8894457314762247, 0.06056698722303039, 0.5321909550739106, -0.012305727519639695, 0.597379224342548, -0.21854598021524543, -0.5223539911420251, -0.3070861235816424, 0.04383035996456161, 0.8597712863340484, 0.6236337249503349, 0.03510917103240831, -0.12089445991067521, -1.2320174845522813, -0.160948780036493, 0.015850849798652738, -1.017125495141289, -0.707213364222237, -1.0694004748575672, 0.3446545101653413, -0.5396819725812696, -0.1738348794725208, -0.6667492731327976, 0.6348590695036055, -1.237138522433357, -1.17461208303775, -0.20870219989439093, 0.1690096074430184, 0.7327050848425163, -0.9043547671801329, -0.4836816617592739, -0.5661052617597436, -0.9704423720838093, -1.2606980945594988, -0.5898925808583956, -0.5316554284958175, 0.4518380606614074, 0.6208410670974028, -0.7564476114046915, -0.8736982138539702, -0.7484119101154183, -0.19682155240943194, 0.6223682479613696, 0.15804583484784923, -0.27585204829132876, 0.255234278245358},
    {-0.5652723492173092, -1.4045790492298487, 0.15487462809909, -0.30644669705826105, -0.33301504210248456, 0.3727297413571546, 0.5382838653852053, -0.7096355757181364, -0.7330077469050854, -0.38935535172660746, -0.8628982808428646, -0.24109698726870776, 0.5305084792461799, 0.1621480930052783, -1.150526685960219, 0.529922749509756, 0.533898159037444, 0.19529775896172114, -1.046743016048693, -0.9645093742389245, 0.8215330008642502, -0.16074849229773194, -1.3166081676133046, 0.9128269698552944, -0.31166476663414977, -0.560914934332031, 0.4517901706234288, -0.046016925058939326, 0.2022559180329669, 0.3552332550540643, 0.3841236876542977, -1.1489362925996962, 0.6436156959055979, 0.01989261396332597, -0.5090702026811388, -0.08320750384981902, -0.3544211249085628, 0.4356037917302635, 0.3666906722987503, 0.4050752217333993, -0.389580347115823, 0.017276597462568787, 0.6517019587422596, -0.4795036065833429, -0.03018729100922999, 0.5407714015923412, 0.764901287798425, -0.7060749136265634, -1.0346286626082413, -0.6109894109463432, 0.11945169535689944, 0.2978137261361491, 0.036910660489705406, -0.9440897761925431, -1.1396128150459244, -0.5031622932749102, -0.7455160936993472, -0.09379861243560302, -1.3080408579637528, -1.22420456892343, -0.5102756980811713, 0.8551350553347329, 0.3116065016937834, -0.04004251810839211},
    {-0.3510557358053879, -0.28391980475701817, -0.653288736766631, 0.11984067266826794, -0.9016780609147576, 0.7437193695481482, -0.2930502023311609, 0.5951985243376178, 0.4308347631416311, 0.905959735225446, 0.053852280721188424, -0.6482225383713374, 1.0683912331729877, -1.5336835955094315, 0.2358874574006312, 0.501607836990437, -1.1270033970349564, -1.1792916007334306, 0.4040970953734373, 0.6652261474926479, -0.6773151277397113, -0.6930824723638691, 0.05192521272161651, 0.9534244174725058, -0.5908434360636566, -0.8605916241914341, 0.6491005387576209, 1.1313754738130097, -0.5909812607301623, 0.2804308166827658, -0.539447351754862, -0.3873358353122828, 0.07038746676938387, 1.011169344609987, 0.25106181647342674, 1.058979102564794, -0.9403884410313263, 0.8412729566873968, 0.04592370896910236, 0.9662526026187076, 0.6915183643438314, -0.7629301166861174, -1.1630207941252368, -0.4699047178690964, 0.5796298003962044, 0.010571871939777884, 0.23501611782874085, -1.5588355377090397, -1.4055722161381332, -1.1544220606013924, -0.8864686370750255, -0.283848268760411, -0.4599113293041995, -0.04698765846192005, -1.2448489218003551, -0.005531468802829461, -0.01039691799451483, -0.9406334161681608, -0.3896958648045497, -0.05932161560283018, -0.9574174090524619, 0.0009771042059436646, -0.5578718065234467, -0.5928707057371346},
    {-0.8396751381181702, -0.09184640741791181, -0.20714316812136707, 0.6049826523401471, 0.3011279420626695, -0.1547549251888132, -0.5483039629934876, -0.4800964211576669, 0.5328173142169796, 0.2973961931138007, -0.2562530756827126, 0.17263532773675092, 0.1749446229656286, 0.27759982313143955, 0.06775374499087641, 0.44888195017950605, -0.36930222098586807, 0.2034803743589537, -0.1363070841585802, 0.7590159057668877, -0.13794872238611677, -0.049660992142071717, -1.5293991235136757, -0.11742714632336586, -0.25079101318996105, -1.237548927504029, -0.5963366641553475, 0.03123219426625423, 0.9286330195808584, -0.6593231073949275, -0.5327775312620591, 0.2153469745788226, 1.007349047038411, 0.29161078560372483, 0.40366266699553127, -0.5235822651677258, 0.48766972092879646, 0.19513022208175632, -0.5628806876226312, -0.7111123298666193, 0.15045645393730822, 0.4637328952806033, 0.7651774177037038, -0.7214604271452159, 1.167093315118191, 0.31516072017601865, 1.0820335740955798, -0.4986789503856837, -1.009332893042495, -0.83150281244941, -0.0212466211190538, -0.7450237877574799, 0.765673726581151, -0.6674586652728652, -0.5063167491492281, 0.4683401981198979, -0.46817486285226656, 0.24526136762609937, -0.9891246225522252, -0.401326562607646, -0.02422479208332358, 0.36680723581062524, 0.7634046623575652, -0.5765715302220793},
    {-1.1879200738024787, 0.07661193381179056, -0.2097374271361595, 0.5598588065625233, 0.25208058900328784, 0.7798549838781392, -0.8971017986532844, -0.4598137351299385, 0.28190534377825355, -0.37423406568000744, -0.3498817840575082, -0.059407947978606324, -0.6508592281835656, -0.8103723010988086, -0.708264961052837, -0.2707976115418456, 0.21088816124035573, 0.007151892921595318, 0.06278163463237284, -0.16019152487902644, 0.37386473201619036, -0.27109961684576794, -1.2075234148180591, 0.16645856328963357, -1.2296114475187772, 0.6283318274175906, -0.9993888372959726, -0.6260392177148333, -0.8690270984998811, 0.8094583619755394, -0.23131811417573853, -0.9292764806382068, -0.17114119850100476, 1.0541885857726843, -0.498845935549156, -0.6454490034446128, -0.5863272984116886, -0.22256336073857258, -1.2063197501263603, -0.11131421162399836, -0.8198038927827206, -0.1314240137561378, -0.637684431604207, -0.7532699425428034, -0.8573032045464933, 0.7949791847248348, 0.5473238142551115, -0.7164119621161807, -1.2826047284432276, -0.8901461640693732, -1.338401613761563, -0.060063971114210093, -0.3832949828894052, 0.6128741562528857, -1.07964275574498, 0.19436999566361243, 0.807753479925106, 0.21242848454644914, -0.5018567343884657, 0.7561270081488973, -0.42477009899995805, 0.22018094369628577, 0.3339567965226964, -0.1965734922711027},
    {-1.1734198057072458, -0.8459079163218308, 0.5728083794543396, 0.5740557703871969, -0.3429466476396381, 0.05058152554926398, 0.2941056810697034, 0.1292887708899535, 0.47905590301967527, 0.544308375106098, -0.3138203693891131, 0.6265941025695099, 0.41016287258390627, -1.0795647322135056, -0.1581430061592448, 0.8699987870864586, -0.635570839858221, 0.18323334382587994, -1.3436408436426988, 0.7674152088016226, -0.6711195221937749, -0.6242666161787741, -1.2796862867785963, 0.7215505655468322, -1.3085992846623768, -0.037405592077921136, -0.6971947601046649, 0.578683735978545, 0.6466371281406745, 0.5989413781174471, 0.18996694574284223, 0.4481684350619919, 0.6989191335422837, -0.5806111177010653, 0.5918892909876792, 0.09644571250906911, 0.6775323268683152, -0.5269617235599324, -1.416007258306351, -0.5200675263796349, -0.07512963887042264, -0.8931549752077252, 0.13549328861548116, -0.8760251293642335, -0.6718206638286393, 0.3409267910871676, 0.27155537221191195, 0.42215626413966656, -1.1424853008744729, -1.0131326041626836, -0.982470467285308, -0.35987156635047085, -0.16449644013045092, 0.37392383587275485, -0.6347553454541311, 0.6812612782486857, 0.8334548348350435, 0.8407517191210002, -0.23831343498540852, -0.465311959479619, 0.10423843718879547, -0.7902499791930059, -0.8577024480424801, -0.1403389182797053},
    {0.41932751939175966, -0.23501470712895897, -0.6132117460094315, 0.4191017560255714, -0.030545867804847728, 0.39175388027092684, -0.6053762498245536, -0.594810359330551, -0.35621877779874506, -0.7247487621288062, 0.8088828111875652, -0.939152759205624, 0.726832298692066, -1.1010140453565789, 0.34844931093001474, -0.36482941380927286, 0.41721492416602607, 0.7518369491314543, 0.642610539971951, -0.44689258029678547, 0.35581865250729033, 0.43419317807698676, -1.497767974685909, 0.416510217140963, -0.23233164562527361, -0.0706649240117164, -0.5122505495497672, 0.3494083055810584, 0.5638026847857451, 0.917588417557946, -1.0969177054592294, -0.3258260255322139, -0.9258633689121681, 0.9722428947283037, -0.44373018693171395, -0.850872075547353, -0.5791393747106789, -0.7927247051597837, -1.0702026532848399, -0.7432286514415979, 0.5867054132742622, -0.2690310836176659, 0.6074913093831238, -0.14741290589369427, 0.6542026692268175, -0.617521289416049, 0.6783575789215615, -0.22145813744748125, -0.08382161128297368, -1.2467866150982585, -0.25816334188481616, -0.08143525995187646, -1.3447294641104222, -1.0407492276455492, 0.3647873571725352, -0.27662513925991794, -0.8734815853519856, 0.6654070060845274, 0.308509157423552, -0.30812897185028, -0.9969315537733371, 0.3446869271828307, -0.9544899262351045, -0.15328992044243706},
    {0.4708520563354911, -1.0818764925666349, -0.9100307995672273, 0.12865520297708552, -0.8927844157348596, 0.5872721942292622, 0.7849483125256311, 0.09646930679711606, 0.3081756079748579, -0.012871748616464425, -0.13782987175101855, 0.34266802090955384, -0.45730688232936406, 0.24882586651835895, -1.29238947764232, -0.4295335517375872, -0.19500127263086195, 0.9006341402903301, -0.6803929961213969, 0.693934030982614, -1.2852955669155128, 0.574487661426993, -0.33291694910489905, -0.9567872043506265, -0.024163085284674635, -0.06557289648847804, 0.8386221988148845, -0.34839203834909654, 0.29643511222609803, 1.0155926744861692, -0.4117766937519047, 0.26460953888697725, 0.3681707619908269, 0.7561712867565389, 1.0189831971284968, 0.4920013048537314, 0.42002361812580447, -0.5940716269102017, 0.6314122411823591, -0.3647702570429179, -0.792990333614508, 0.7385323473722473, 0.20733548650993808, 0.5410540592154871, -0.5052822818104655, -0.45135767441899827, -0.9284820001232746, -0.38661156597203444, 0.4877927390016418, -0.8310889066257898, -1.3913429325647884, -0.19350016020179203, 0.5080619057794985, -1.0900258016412676, -0.8844561024848403, -0.9115848812622247, -0.05121012984910404, -0.6957169790531397, -0.537430022861348, -0.0076285177191483455, 0.4004947081809362, -0.3475932234466882, -0.4493244686710004, -0.14182827352960356},
    {0.009327887270631881, -0.152821920653808, -0.7964712305129548, -0.9685559828416541, -0.49664329204475777, -0.29028438023066305, 0.30900645725739156, 0.11548019854664204, 0.23287054573803778, 0.675646604539876, -0.10180580975379518, 0.5913688220553964, 0.22934387510068463, 0.5778269514694525, -1.099929013273705, -1.239029203738702, -1.0275075623227483, -1.1234566347253967, -0.9653353989536768, -0.7529909980703535, 0.28196865697571294, -0.2909934648366546, -1.510164272906938, 0.8976424647184168, -1.2622133629302104, -0.40062699962830045, 0.8368541415601899, 0.7390274610799348, 0.11685148554524875, 0.23143118039805427, -1.4193396508019112, -1.4470376395940092, 0.2606684136386442, -0.057986077188161976, 0.21001142832555228, 0.46640615627046733, -0.6129005344773478, -0.2013489758316178, -1.1702513518415272, 0.5152374456774501, 0.4626548239595685, -0.854103973136364, -1.4952788655644216, -1.1200253815545873, 0.19249791619468684, 0.3340403187468621, 0.2044575326418199, -0.049870254527658656, -0.6765123160627463, -0.3112348240182917, -0.8035533073714721, -0.16232453078060524, 0.06731147627528421, -0.12146773180073141, -1.3481932912936774, -0.4545269422387378, -0.6472256651918359, 0.5453229555987021, -0.5446189987835423, -0.5606032326145806, -0.13828212945749652, -0.9276601597344165, 0.9708495479407772, 0.44870062496003343},
    {-0.000936973908364384, -0.504365025221963, -0.15457688974060566, 0.6096721159827574, 0.43527605583815293, -1.1773579174737265, -0.8149415470171917, 0.5901746789027567, -0.2832370378184081, 0.2915826662277369, -0.13081124812938927, 0.7012914204025908, 0.06750764116082206, -1.0860243962585454, -0.11262269165917785, -0.5297485434229352, -0.11923708529151814, -0.4457335594366, -0.6905043657280652, -0.6014729250385737, -1.0619357052775291, 0.23680606265355705, -1.1131419391231878, 0.9210582344223225, 0.232914072450736, -0.4301850035311527, -0.948756903963691, -0.9395687222583415, 0.8303312672354988, 0.630474604355515, -1.0285056786580802, -1.021568586126891, 0.8388593054607478, 1.1151456118350243, -1.0083077941235166, -1.1585927504495572, -0.16650450131411182, -0.6507419470856972, -0.20743795324077838, -1.1602804740644703, -0.8876339196807504, -0.9489489678077883, 0.43156092116559774, -0.5497796416862009, 0.3915050830761981, 0.06740776696105091, 0.512460356217197, -1.3147698346283268, -1.4021494590108454, -0.9846635159554031, -0.9759623703119583, -0.36899475168489904, -0.36526349093909805, 0.016401071629269348, -1.3075350942945623, -0.09376106577614006, 0.5052231048003075, -0.45559469774618383, -1.3901199708158527, 0.2671422064366908, -0.7378301538086841, 0.29753077231499436, -0.7862549872278244, -0.7772254308509495},
    {-0.10927690017884535, -0.8583002001788385, -0.9582118599307943, -0.271131864912021, -0.6931791233033255, 0.02487651228221156, 0.9684058375826747, -0.6184597576411281, 0.39644140975274206, 0.8410211390023629, 0.407577285063084, -0.39646997861574707, -0.7162825943257528, -1.5517740357595833, -0.2613824904879331, 0.5640554832308234, -1.2061273824624759, 0.09741995056892275, -0.07914574271635921, 0.23170738285719084, -0.008219301647394825, -0.7247827529868711, -0.4322525923172866, -0.886110923487147, -1.2027556195528317, -1.0463766265901286, -0.12391040420785131, -0.5083035345407962, 0.6923219801478468, 0.8364270243116826, -1.0474554467421695, -0.16637554824146936, 0.10148363411779418, 0.15125454774852803, 0.22229476335260692, 0.08257980529211573, 0.6792944369345532, 0.30733237038966377, -0.42732536848194164, -0.6317194226318134, 0.0028830007559482473, -0.17946475468830198, -0.4373277999678425, 0.2740613311214667, 0.9237085576558511, -1.0334320815455125, 0.011701090473461932, -0.30709987856885795, -0.763361147718531, -1.5322277489296576, -0.01853794095227321, -0.9217247104131553, -0.2517449326079304, -0.3156616208156866, -1.2737098923403185, 0.09734488685244942, -0.5030180904124205, -0.7509206168991748, -0.46521318373019244, 0.4765743963160721, 0.6828731643675827, 0.3637512758569567, -0.05849576525205006, -0.032847213751669116},
    {0.5970800562337243, -1.0062124779587542, -0.07219769882509262, 0.07589989982531807, -0.38803863270302047, 0.5959831207920007, 0.6219855164711022, -0.042347184880106414, 0.5159679233580688, 0.3498811311885362, 0.7862668003727429, 0.2604090008065678, 0.6869455219856432, -1.2080291647495416, -0.319358430853856, -0.7684189225688909, -1.4747232368740983, 0.9609137261477212, -0.37791940022479614, -0.9739497731195302, -0.2765677028272768, 0.722682623253118, -1.1758319408772222, 0.9270256374788618, -0.5587875810397431, 0.06165505841581192, -0.7124735366020816, -0.2962709704958521, 0.47483022641632805, -0.8241869503373238, -0.8082954668947057, -0.31122049093268517, 0.3443500088162969, 0.40144660349789363, 0.2595742652961354, 0.7031431328501737, 0.6965450083419206, -1.2147144278031863, 0.38666071633652904, -1.0737729125708049, 0.0681532354984809, 0.7952773964466706, -0.9127418635824879, -0.9794149418474163, 1.0631293845182292, 0.5005075206389804, -0.9561829579264778, -0.42112246099873707, -0.6945046401167052, -1.2186106026548016, 0.44664221864303544, -1.3453271471867352, 0.6462243379724137, -1.3153473875815345, -0.4449593571473962, 0.13985276010981434, 0.08477772521442746, -0.28151064622531763, 0.2507427363101368, -0.32785182197032264, -0.36224291010959836, 0.5494346194659998, 0.14577079489033662, -1.1864441922949978},
    {-0.6299599466170447, -0.8326066036248376, -0.1253695643974607, 0.8033474337196521, -0.45063707320801716, -0.8745902040187662, 0.4014560114094691, 0.6530056798364842, -0.657988375400805, 0.54482176505429, -0.5237861951815185, 0.28894850768768027, -0.6185724349353294, -0.8433856865063392, -1.228088322349306, -0.4102696072045424, 0.6172048578920308, 0.009691892184129894, 0.4835690484443905, -0.06540080511360781, -1.0097372449996136, 0.2501723390540447, -0.14361993757288893, -0.03510695975536232, -1.2133184504312633, -1.0695072849591984, 0.26564424644360507, 0.8011858036701697, -0.5172968126849528, 0.23269895921819364, -0.6050000408898364, -1.249466908557212, -0.4383359904434384, 0.3099812909189586, -0.4004750650806315, 0.474699855032578, -0.08016762170847132, -0.38030031268499925, -0.36428329015790784, 0.06762217794566634, 0.7263789591064581, -1.0631378318298748, 0.27947875841031333, 0.2806010381427912, 0.49944418929139145, -0.2894653702247332, -0.09542906066899436, -0.18191392789387018, -0.07100185449560864, -1.0431093096049406, -0.9418891714988452, -0.6233032356891774, -0.7433121682567889, -0.676473688395104, -0.05332894684231049, -0.9096132441845712, -0.899354739453323, -0.790069481331592, -1.2900401986184151, -1.3570645842805324, -1.0584815901117344, 0.457171341514823, 0.21556887245337827, -0.15436643807161912},
    {-1.331268076084083, -0.31334006071461645, 1.1732753245109848, 0.39909249769619604, -0.7730912071741347, 0.2193399390348484, 0.024880811062287036, 0.08766084887709295, 0.7573429632167188, 0.838803742749428, 0.9119270829248939, -0.40283562873734746, 0.5118744040563257, -0.17340173425786418, -1.3102955366857347, -1.0631254726100579, 0.1995506381536522, 0.16332033065409768, -0.8231735051115999, 0.5008163143814071, 0.23158201497639264, -0.0729907652185954, 0.04421778190703737, -0.013587620963628921, -0.823001067390256, -0.8556413164720327, -0.5596366464748377, 0.41780592632879954, -0.04624619305983756, 0.7635417356302918, 0.09860655330756897, -1.2676562731707361, -0.2398975238883185, -0.4816301785135566, -0.5354777238148554, -0.8799658758980337, 0.605254313528208, -1.0534093918234693, -1.2211429243023584, 0.24494716335983735, 0.9706828554347926, 0.12401571345619378, 0.731749306691406, -0.9253062803617962, -0.6911636839577812, 1.0543022333423941, 0.9223768693938342, 0.5259785307299094, -0.4031667420560193, -1.2628063602605062, -1.1621611373975005, 0.19836159822437835, -1.252392979245921, -0.06653889212168759, -1.1699942546885593, 0.981013946271137, -0.39444435012989243, -0.812405933912949, -0.595852194679936, -0.3002860888053151, 0.598905099518454, 0.33677646980730797, 0.5573692063705339, -0.13195875318322184},
    {-0.3714305482686586, -0.6481094358742447, -0.25154389611434536, 0.7829897432707432, -0.5939202080149708, 0.706229637203941, -0.852151683639841, -0.34619535188824235, -0.9506725905994112, -0.4496792416702827, 0.1674414643875569, 0.5479306982980816, -0.11746061032896145, -0.7396246231489118, -0.3985530003288185, -0.8329758871823888, 0.291445683735247, -0.8383006596792665, -1.1690101054982245, 0.3994043081756889, -0.5755577163560331, -0.2737767114362768, -1.3269770555280662, 0.6683958310149818, 0.08997025417886803, -0.8772970961810815, -0.5080786025191174, -0.6252367252620767, 0.8210076579229022, 0.9384345120806791, 0.6922618438512296, -1.0776622903661972, -0.32357672137011156, -1.0573152505499839, 0.6292954659846408, -1.0160839701636473, 0.6315629928595473, -1.1916502660587027, -0.3171833427570591, -1.0152033924486588, 0.15113157807561697, -0.4095714314268877, -0.044759671078609585, -0.04888373647167347, 0.7637988508695978, 0.7939931869895831, -0.7371694408629902, -0.04650664013396135, -0.7391496837433223, 0.1470281582400942, -0.45316579832894255, -0.6977453731682322, -1.1062651222337048, -0.2700004561443538, 0.42713026163680007, -1.1105985260737334, -0.6011852145576005, 0.3021446085743126, -1.4146614214585704, -0.29493705249049446, 0.3555211308404104, -0.9276355569694004, 1.0519873325563105, -0.13810496411080941},
    {-1.1796797137464043, -0.4922786260615861, 0.7708140907240468, -0.13040125520956225, 0.6052715729915419, -0.9861932440684215, -0.37078529734435706, -1.050784412501685, 0.6477709515636959, -0.6604290420763416, -0.9468067256301341, -0.46215305196562756, 0.11997822895511318, -0.8882524443301212, -0.4480273127938104, -0.16700642738517726, -0.6680775838366559, 0.8409004346380584, -0.5437349254645389, -0.26398740950164806, -0.29140541389277086, 0.5468476729291399, 0.2291158090039691, 0.7854847925008746, -0.41099783676007706, -0.4740731875655481, -0.06286093854760152, 0.7040354764400341, 0.007139831528539623, -0.388777900365308, 0.029433814750230214, -1.4156107838132954, -0.6889083122695704, -0.5431629040809, -0.8233361283793813, -0.8869149765813957, 0.7415264995882265, -0.7561032932725916, -0.8938520950400708, -1.2053569914304365, 1.0799148342586242, 0.9247789198685616, -1.2670566459350379, 0.16642273028066512, 0.8292496980471877, -0.03961596807406694, 0.5779199795006889, -0.5283029317261971, -0.8635825042612751, -0.3364682401952321, -0.21637807790871533, 0.11692275473896847, -1.0263528560508506, -0.9841196146301473, -0.11615433728595617, -0.9484542101129466, -0.238463675405012, 0.8502724414674803, 0.06609501982316811, -1.3529360831919826, -0.6842174824255249, -0.054560836324991015, -0.22025542278357702, 0.7982035467516617},
    {-0.7762739252216297, -1.35582544024972, -0.35608277350717266, 1.001960984824283, 0.5101761487357918, -0.8883135117782673, -0.06161588664159237, -0.9959602438484166, 0.07370484720582217, 1.0272034473225289, 0.3157399613404129, -0.3849953626909187, -0.06321265883760413, -0.8298724287796115, -0.893106463971365, -0.11120995761770965, 0.03828221981614304, -0.6476074972525765, -0.6951912108988924, -0.6088378603317023, 0.737421912462008, -0.20721394156644754, -0.5682612103846034, 0.11036115686411252, 0.3706701001751122, 0.16552446012407582, -0.2569382733409165, 0.27392020900148717, 0.5664639461820636, -0.9794220163529692, -0.9236509925055261, -0.5901145899760046, -0.3325478363064718, 0.8421784049222295, 0.4861902726058659, -0.24989994803689372, -0.39654431717040595, 0.20210812912964268, -0.41896433319694815, -1.2519040952507299, 0.21351644295188568, -0.7491817925538431, -0.31986100289979147, 0.6186811722113472, 0.5560978411332506, -0.19836900820596542, -1.0333446621170275, -0.7591164600859308, 0.06782315301977761, -0.44206230538370755, -1.5780489538820004, -1.2666347961778228, -0.05767777843785276, -1.2521392870972254, -0.7902233590921135, 0.2561468732410859, -0.10863818201363239, -0.9516526213220312, -1.240083941272032, -0.6146734009838806, 0.25642423418919763, 0.18267554406785053, -0.4110462017764483, -0.29566260009254347},
    {-0.20173011150066825, -1.2797236131486058, 0.6590655828371966, 1.0091181336261332, -0.4835040833106846, 0.8259043379479869, -0.15575978044191274, -0.4079243275221027, 0.9498603721405332, 0.22832750851799571, 0.24086331193663874, 0.6659082192119601, 0.04007155466207182, -0.7425213784765415, -1.1563327840602753, -0.7440538471275808, 0.9237403184787164, -1.0582642613723345, -0.3272644416380128, -0.6997373725498295, -0.3771630554696243, 0.6095826883437359, 0.3544144383324887, 0.7638935897182421, -0.6124351549993678, -0.2916294870406391, -0.5797778050795295, 0.7579779153330558, 0.8307990307653355, 0.2432414875730546, -0.2986576073785448, -1.020221658236502, 0.8200216551736751, -0.5800564248444137, 1.272984016488666, 0.13569716140343094, -0.2429253170104506, -0.8743666809285948, 0.9024334922496752, 0.3479341173886918, 1.1375474879316463, 0.9032328647635659, -1.239188152479904, 0.9260149117095523, 0.8646637328706508, -0.7052859424728304, 0.5293176264856476, -1.3790689999425711, -0.8888543347679776, -0.7390829567988936, -0.662102888996074, -0.41475920398669075, 0.6463103539429429, -1.0775720412282745, -1.1865045360512771, 0.537579427590887, 1.2327834497394428, 1.1525895000967468, -0.14160364186258637, -1.0885734273274057, 0.8859122912446845, -0.4184871364791884, 0.594582558500381, 0.7594923721820227},
    {-0.6944870450968262, -0.7859438286848818, -0.46967547336396104, 0.33002258028880344, 0.8129854574469484, 0.09889780379963285, 0.5588262143280797, -0.04792141641494688, 0.20627677764421243, 0.32328700144864675, 0.4525459429610106, 0.2888752449931638, -0.36878669442551204, -1.5333404700882733, 0.5410443531391915, -0.4594673555402461, -0.6736146694439034, 0.3012846456241179, 0.07962302128578448, 0.7274903104487189, 0.9431590761563424, 0.5012586867587324, 0.2852504645631231, -0.8025268788162412, -1.2315537924705318, -0.8097805800661382, 0.8345134247436815, 0.8473957735771974, 1.1170825268845066, 0.7076094203496218, -0.6741212495966603, -0.3339715220942575, -0.022832422943523684, -0.3917196696270155, -0.5750784575365039, 1.0564801799995711, -0.9274806999299743, 0.627545828593033, 0.37368387900533556, -1.303758387328659, -0.28804777972500833, 0.9701831645666812, 0.15845262887834435, -0.57734334915976, 0.2794335948986706, 0.1654100756530385, -0.06031047578061585, -1.6708045343403937, -1.088607202248438, -1.7453887006234658, -0.9229247488656983, -0.45029440710672053, -0.245453183151189, -0.7730908669848988, -0.6561779262468462, 0.29396784920304564, 0.5445906948682552, -0.0036200499368690313, -0.5848764963270754, -0.6693238924284226, 0.7580244553235764, -0.2102848201026844, -0.06606937325847886, -1.1542810935943075},
    {-0.6269019103145224, -0.38119597809788414, -0.7365703546349579, 0.3667326039943896, -0.8058888072948253, 0.7099618620375887, 0.2520160566252015, -0.5762440803191479, -0.1474428379406896, -0.2875790195972979, 1.1832921982148172, -0.6649260806213163, -0.6936824472022814, -0.20304902489799462, -0.32021860405540575, -1.3176018909299156, 0.5162815955714665, -0.05356292258435447, 0.7565807929164946, 0.49925145752814354, 0.297711886447337, -0.8207963524018742, -1.0761661661331563, 0.9815648566385147, -0.9307007000841743, -0.7728752356274494, 0.09394475663290096, -0.15495004027102066, 0.5337386500008934, 0.6491984412597644, -1.0696243705442723, -1.2801061848377504, 0.14284366232601148, -1.0632898142744345, 1.0476993061100517, 0.5359371463740594, -1.0755687024869034, -0.8832387431967635, -0.10188560356950371, -0.570530754614686, 0.4782313920859692, 0.9594053397998903, -0.9218451262762457, -0.4031152209898729, 0.9717766338948108, -0.427861861342448, -0.5293856442994483, -0.06887133838011063, -1.1485856470621754, -0.6917468852526565, 0.1346678016881599, -0.4245099608828362, 3.5888533698318625e-05, -1.4121414973384792, -1.1059171769554366, -0.2706264325139754, 0.8029994071623463, 0.16062069645870702, 0.2623968725895041, 0.4712325781616318, 0.6195385921665307, 1.0710130229037442, 0.15646280107951477, -0.5045717601997152},
    {0.5072934619848943, -1.3783482341852926, 0.9269928541321948, 0.5937652077093759, -0.39964226581706974, -0.7626894393515588, -0.37110180303597173, -0.15322333441063513, 0.6504539406369938, 0.09875034358431983, -0.3774974003871035, 1.1417825010576488, 0.6790826175916884, -1.4343700986919539, -0.8165029557718558, -0.46192559898107527, -0.7287460771298151, 0.3198381213083066, 0.21738136865734167, 0.13106541883141695, 0.03216782910342024, 0.01811171847761375, -0.927023372922545, -0.4646227815750021, -0.8272603418966819, 0.1510412402795936, -0.41662894163984127, -0.4485094847312314, 0.3328686423855702, -0.02513473229520088, -1.0552119984029964, 0.062382661517012605, 0.3527863786957128, 0.4393687023916981, 0.45836385245462175, 0.2683565409904525, 0.7521006675122698, 0.28539424678253644, 0.12215722676220246, -1.0293914877112598, -0.970995691145707, 0.21910465961327272, 0.3374979117693784, -0.23650217708538282, 0.2557058836605907, 0.18695671159964594, -0.6218710431538583, -0.4188623142510082, -0.3966309665854564, -0.3229425205534276, 0.30482779237743357, -0.8027765631120155, 0.46918502104002624, -1.331643970816938, -0.7408364224657892, 0.6060106941948095, -0.73638283592063, 0.65593684827766, -1.688758267665436, -0.7966237957762067, 0.21414608708718008, 0.03276089817661752, 0.5693225193554654, -1.0920493219727285},
    {0.4954113705523488, -0.8715960044485701, 0.7670177975423949, -0.8973244987324043, -0.8148124987147473, 0.09385908491644036, -0.8716740200099621, -0.5702042467228746, -0.6349228932930023, -0.03267555943834032, -0.013016206658646437, 1.1945667405252665, 0.7408051549699323, -0.09159260913220087, -0.08989688450744984, -1.2191438178309506, -0.4683751779429258, 0.4551347671777501, -1.1192871108887847, 0.8264588769205375, -0.9554693999479832, -1.0283867335233612, 0.19901567532130374, -0.12378123691908059, -1.4673433008352013, -0.023791740470813214, -0.14988459487521233, -0.5719679798894748, -0.026296464570274073, 0.7255117560426654, -0.8143021251119972, -0.9770862752040967, 0.44702455139215275, -0.06941078692394338, 0.5332436830119098, 0.9893280706911789, 0.4632682354234329, 0.6950711417587586, -0.5831166096552437, 0.6529377963510781, 0.6307234151212462, 0.6654243455478525, 0.6883962037487263, 0.731346989048362, 1.1601242063790387, 0.1019121777723131, 0.11629702694545375, -0.5853087233725874, -0.6661853055366347, -0.07283058595300962, -0.5757333550265992, -1.269309457628463, -0.934543999409899, -0.2910388176400599, 0.11100440831120471, 0.5896223322396142, 0.8068403162275548, 1.2964134985209714, -1.3367577751253894, 0.6418195752009441, -0.3847549627617684, 0.9959853743644929, -0.5467296822234897, 0.17590918570721156},
    {-0.3978621972763299, -0.7822097529458952, 0.6671119469372845, 0.5614646862590794, 1.238083416397929, -0.16131199250050143, 0.35835687573828817, -0.7295335224458868, 0.936210195326168, 1.0489256733468801, 0.8776901730576148, -0.6014010952356077, 0.4145465805763723, -1.2770770184864155, 0.31640099838035374, -0.932764574857819, -0.9951038686846849, -0.3364477179492385, -0.3969543359043449, -0.4288961045118554, 0.2730046212962367, -1.0635432753870642, -0.4441537398478253, 1.0897034129756862, -0.4110009237110384, 0.09915281027492312, -0.2096620419288261, 0.8990929138333571, 0.23089335326906177, 0.6109977959527697, -1.059500483466769, -1.0926070650559596, -0.40460978583312923, 0.6842011241451229, -0.3960747367920814, 0.08612892448065647, -0.4780715592101759, -0.39884463084903216, 0.05442571970882716, 0.25646403053140887, -0.4210509182145792, 0.9972240763625929, 0.40851191438256007, 0.5534064637916515, 0.5227669334639593, 0.2893311809299138, 0.6758208478821842, -0.9457587294808067, -0.1745905065457198, -1.6807787881453342, 0.10691984579673845, -1.4346229759280225, -1.4038971245348457, 0.1182221071632485, -0.8957885334290849, 0.4791098373399792, 0.24838900803246025, 0.5605691367090702, -0.5388587182949485, 0.3505446560594571, -0.33272115042526007, 1.2390247813167574, 1.0858561816681676, 0.07985265916896404},
    {-0.03755577667050418, -1.0154482966657628, 0.5826355349070299, 0.18694063285459034, 1.029848541356191, -0.05359912125974392, 0.9614415841434936, 0.26103124673168104, -0.4936028959411958, 1.1735854063650493, 0.9346712777371925, -0.2040582466340837, -0.6147180873495741, -1.70862069044381, -0.38340763977760783, -0.8325686546784771, -0.38163053635131733, -1.0764421983417252, -0.1292636059048733, 0.7808928674225486, 0.2611759272796349, 0.7979830646014427, -0.27478717563814054, 0.9137808353041453, -1.323201722627692, 0.13389361594797636, -0.8393819215214687, -0.7220093506720625, -0.09042773857334957, -0.3860499175867797, -1.1936108621106833, -0.7240690685873562, 0.8334188644712749, -0.7006122203222206, -0.3312049986155295, -0.9373307374110728, -0.9690447545886522, 0.7073124957685144, -1.277368096474784, 0.4591434087912951, -0.4392112688883173, -0.3370174511090724, -1.208457867863221, -0.10956333486588053, -0.7672213109251461, -0.8493914308297065, 0.04403751613174861, -0.19983828304013962, 0.2416667192915441, -1.1321470783100631, -0.30780069282245287, 0.3131181464345549, -1.0047787310672742, -0.03604922894253864, -0.7825438759596488, -0.16778113800440767, 0.05950978048052494, 0.3364191125085489, -1.2048296370578222, -1.183315610999831, -0.4944647534503664, 0.3916981710255809, 1.3261166439716665, 0.04444763503441574},
    {0.8054062376494404, -0.527340723075935, 1.0894602815994636, -0.6647744572199035, -0.37476986158857234, -0.0740383019990922, 0.6646735395112828, 0.17367769432675212, -0.13223490465507626, 0.9243997469212131, 0.9035026208935979, 0.5844692728143237, 0.525534464127391, -0.18047970524915816, -1.0363814433354614, -0.40571915043620765, -1.3356322219904369, 0.747476885358126, 0.4572153382675824, 0.43786002126624246, 0.7135873417495182, 0.22494374120001767, -0.29870214056105593, -0.5044813192028266, -0.7646604141560149, 0.7522606293875077, 0.3337076942576865, -0.8166191755819849, -0.5217458940077423, 1.0062538741341842, 0.3683167937029112, -0.3546125306266409, -0.15073620306197635, 0.37280585118095066, 0.49108309511158305, -0.36519841881849396, -0.33284117148217046, -0.14139541038202516, -0.6778292541619823, -0.20520768309506723, 0.14326898944089897, 0.0014918064615142485, -0.287743141864035, -0.442408909916652, -0.3383596901987109, -0.04340197499478883, -0.691685960974236, -0.2569468423095644, -0.08262291647291505, -0.26997961423277433, -1.3143970528862354, -1.53555458784197, -1.0263446208261788, -0.7070011318505393, -0.6879350996222457, -0.5842834727024507, 0.3522087435154535, 0.5522869368941823, -1.629665490270478, -1.3190536928790708, -0.2648035483928981, 0.5281066045418094, 0.2821231995616411, 0.6259132959384326},
    {0.6835229948879231, -0.19070755687795055, 1.0251122963388248, 0.10992594197693988, 0.28081193241430064, 0.18201261137750946, -0.5133823609724346, 0.666119104727177, -0.1398566187819909, 0.3389898172236332, 0.39629062415085947, 0.7021219752578115, -1.1516883713837907, 0.18027960913303318, -0.30188067496989723, 0.6692564405437801, -1.4423596121816602, 0.18362016246395274, -0.4626948629113249, 0.16500626127720802, -1.134134984772491, 0.41054893119498753, 0.1359504378648916, -0.38860966023647164, -0.4295670963522631, -0.03762680631135863, -0.8583154074936434, 0.04079593159159566, 0.6121797940499474, 0.2794639397948879, -0.8958741391757287, -0.7854083615083286, -0.6387861503554014, 0.7877788499415487, -0.5938117944337942, 0.8657074096326197, 0.5225319209867718, 0.02698946020596116, -0.2640864325082771, -0.09360844921187782, -0.45033749666257944, -0.2810979692850834, -0.1526052157398671, -0.9666162169101618, 0.9341951164062097, 0.025247756218775848, -0.5672696810634418, -1.2000985522611383, -0.2523415503553964, -0.6979890932920668, -1.0408690896875785, -0.16407992257214218, -0.09741755019182073, -0.04477264536287902, -0.13181526199241445, 0.2717581008597147, -0.3564251485121371, 1.0600708377174903, -1.5834525181467511, -0.9512864445045507, 0.7773231461304048, -0.1689773398584986, 1.4030268334082636, -1.0461818216147154},
    {0.4336621506500925, -0.2695843585552863, 0.7428967126675263, -0.4681392050330689, -0.12301219872419704, -0.04872396168576682, -0.6007072868750807, 0.0181303366223888, -0.4470063268066492, -0.9165125877958085, 0.7535425108937186, 0.17167825083824778, 0.44137987178090493, -1.079357988853169, -0.05067275235200748, -1.4054653507428518, -0.7465853270215078, -0.8663561210227094, -0.23593190498406658, 1.3034415363254748, 0.721718272898902, 0.7516499037320988, 0.23229223959364903, -0.9690875319857999, 0.8114765522900252, -0.6824157487983029, -0.916378936061177, 0.7910803421268751, -0.8308764519103212, 0.9427243553028258, -0.0061847844686204545, 0.5007177301038516, 0.9925902862975521, 0.11602767636023147, 0.7687916589036327, -0.20235027894999047, 0.4311375704381767, -0.5428517379410474, -0.7450566980951826, 0.4357148319957891, 0.3532584361615613, 0.4793346100307192, -0.11122655904063301, 1.2137684444693244, 0.20910276081466217, 1.1400468519555425, 0.22083540564265372, 0.7069852554012882, 0.9244428971804133, -0.7625942101766272, -0.4128264304401748, 0.6647595636807407, 0.621575095208741, 0.15386029950908642, 0.28486722824738064, -1.2259910829561576, -0.9778175987454146, -0.4555475303668659, -1.0058318929288774, -0.017164736629666794, 0.37270110852423677, -1.0454002126950304, -0.9886152288669197, -0.6907290908031138},
    {0.5523837548235057, -0.6933746661657288, 0.990942773146744, -0.33161713328106773, -0.4494130399983283, 0.5088043016870323, -1.1386808799082142, 0.35735305387595895, 0.3902123177451933, 1.086176718390201, 0.570498678827964, -0.5296882092730837, -1.1808536553360593, -0.9000919004771716, -0.23718140594358803, -1.1268961443127092, 0.08057132759210162, 0.3934711428696292, 0.25664496598170294, 0.7431873595172565, 0.7885737815302223, -1.2729395659737646, -0.2050172273049537, 0.8470832338121347, -0.09172440842626803, -1.2873637743792534, 0.2494257243179678, -0.19380060123583442, 0.7448512442700956, -0.9867716823290613, -1.0791732037766943, 0.20757999563854718, 0.2752106961026332, 0.8454810060354995, -0.8506692310114492, 0.15947711453044586, -0.8174142177942793, 0.5684168735431784, -1.2129132171901662, -0.37190251434232724, 0.1079913105550971, -0.4001636360946775, -0.407620494855707, -0.11177174795588726, -1.0128883283522339, -0.1483635452236194, 0.2703038071650412, 0.5212708210080306, -0.5571387754031772, 0.1541663240220139, 0.45868996953194574, 0.8629237220147538, 0.0800392523069052, 0.668675925703563, 0.9492333970743193, -0.24312478596544848, 0.16152003601807877, 1.1318904620309214, 0.017773202303183747, -0.3100631216583561, -0.31380016462035865, 0.9370337669782968, 0.7860636858238235, -0.15388872967073328},
    {0.8580545857246661, 0.9531306517265898, -0.215009820284861, 0.5300329120005888, -1.1056512131535596, 0.5589479458321541, -0.3452359545551469, 0.6057399628643915, 0.5860481014167821, 0.6140998108897958, 0.8453256641386541, 0.5042883037659935, -0.3329151588410831, -0.4516389802968116, -0.6031026796690259, 0.6665282558810506, 0.7252467823891601, 0.08425855450980217, 0.1370450789457479, 0.13724474002530254, 0.06821648143684422, -0.5078425153420163, 0.9574028360563033, -0.5650553086634152, -0.8034552758596516, -0.6839554998086856, 0.6308166148476766, -0.9576634734406088, 0.32571920027649054, 0.7475299633759004, -0.8470223454671011, -0.9503991598897709, 0.4100336506248842, -0.3370896362888845, -0.6984812247285936, -1.2862275986599878, -1.0981681264607819, 0.16249006077913564, 0.10898623448767569, -1.066681693532944, -0.7691044596828376, -0.7682538481624576, -0.5550000499691142, 0.9215690084255167, -0.7395969483325436, 0.3363939287822752, -0.3370591997469386, -0.9266865022436208, 0.7198569954313564, -1.1544291751882518, 1.0848848610724633, -0.5404434851645079, -1.4355475251529792, 1.0550022897662932, -0.062450428207016774, -0.3071468646659173, -0.479514971929906, 1.0371036269458334, -0.4305455470894581, 0.2072170364148536, -0.13376039120019306, -0.034298733001589206, -0.2148933259393359, -0.4906703448749618},
    {-0.6443185721488276, 0.8088562027667319, 0.27083365277139976, -0.6835909386668714, 0.14089783655076174, 0.03006274004270188, -0.7770787798314442, 1.2644187686487085, -1.2053239966622313, 0.37646441382958656, -0.34770828501962125, -0.24641718993314096, -0.7794084508178835, -0.7623860572908081, -0.23604066201937743, 0.8315540008908783, -0.28966995769092996, 1.1836363993047627, 0.24715740709584474, -0.21245298660618217, 0.8247883980625189, 0.6840573390270597, -0.20099894059223652, -0.42313518115202003, 0.6274577875749853, -0.0353264131328559, 0.6467821350288899, -0.15388659432836319, 1.152213293386721, 0.13952203060189444, 0.10381281000217127, -0.5471848683007932, -0.8133755320999371, 0.22862280193190299, -0.6845304614692133, -1.0780158714963781, 0.7318064375752477, 1.0272892940777423, 0.11969655614780375, 0.3196732706217058, -0.7557473414342174, -0.047682976059564994, 0.4052082360627868, -0.2323678282057851, -1.092889462092305, 0.6774963472889561, -0.5494675389524447, 0.38948522025863297, -0.5312508761493506, 0.5518994355773569, 1.0657489688289798, 0.32130188146807453, -0.5942024947407355, 0.8115738634091408, -0.595260884799463, -0.35893033633004345, 1.0174271124303427, 0.4276418559672396, -0.8653507222925219, -0.8703525779409188, -0.23844690406659538, -0.8195938188941113, -0.6140793556320747, 1.4980911731088797},
    {0.7664676293826529, -0.22820834449631103, -0.19618989031091236, -0.36742553175145154, -0.7927627358986012, 1.013162744171134, 0.4452039399421163, -0.23566069818348812, 0.14380634200517922, -0.2238595472852586, -0.7091393345724075, 0.4217477360807824, -0.6016040374190192, -0.1916569378678811, -0.7782466395936429, 1.0125652575602409, 0.5119510111257458, 0.73133026278164, -0.10329006116423169, 0.7874179728942564, 0.8547707976624859, 0.10948597877503898, 0.5094264329485864, 0.619724205546316, -0.12951806937923774, -0.023966176244274794, -0.3215192882788584, -0.6461583127009355, 0.8364917642547663, 0.08353329715246273, 0.13991612471311166, 0.5659839990900232, 0.8180983500150476, -0.4310196825882107, -0.7340617613134554, -0.6662402037988591, 0.45155265532053884, 0.9140807582318052, 0.5911749581810105, -0.06596539401395951, 0.9693774724336295, -0.11013312484423637, -0.965047886412326, 1.333451371527238, 0.06546500129880715, -0.37464120994609723, 0.17578008229110798, 0.9136953005054472, 0.8631920076042636, -0.18407961550111862, 0.6263062525525621, 0.5841858654371992, -0.06139125508323499, 0.5245387986386287, -0.8406079419598798, 0.3046626979496031, -0.5706270290559892, 0.1755590747299651, 0.17208417321556188, -1.0653362224718874, 0.8675897090061296, -0.8825285011484425, -0.12207515561701238, 0.43859076536942176},
    {-0.6734360381688104, 0.6226599590303977, 0.35796296297642033, 0.17945049481326267, -1.0527782231554605, -0.799574378509405, 0.7750838889888354, 1.1422968176822148, -0.9206842631593066, 0.14701403251286937, 0.42124331025390466, -0.412927567926514, -1.247709242883376, 0.7313842912295174, -1.0726506931333593, -0.37594233774427727, 1.0371378604695207, 1.01335709804934, -1.3342193681984607, 0.16051884378317763, -0.14929579700054002, 0.6037934965228534, 0.6561195928282225, -0.981172682651578, -0.9963740830335498, -0.7294261624950891, 0.23339098994613747, -0.7194228430494596, 1.2954994053488558, -0.34599310122159654, 0.608506177403649, 0.9391297506048804, 0.6543552664387297, -0.14391772748967868, 0.8971067183601646, -1.6045342447397346, 0.17440715501625104, 1.4460753848218995, 0.24384077059313503, 0.211864293929596, 0.3558337191685246, -0.8730510532978012, -0.16114079049515903, 1.3899310534803968, 0.27067863308904333, 0.5239626643603985, 0.21291022371397525, -0.2352464015876083, 0.194250033133933, -0.7156408155926255, -1.0602297374378318, 0.6985676239205862, -1.5178052827661195, -0.11978542284240928, -0.3910348594789602, -0.5701813371937924, 0.17962283663071926, -0.6911836877075793, 0.5168036888723517, 0.6553861339630708, 0.17765679527269357, -0.1615215290855459, -1.3400970893086785, 1.232999295407796},
    {0.853510772112293, -0.08901602659511576, -0.03764394593137957, -0.1791873234904139, -1.4653012514096977, 1.1480372054083023, -0.9416095770755455, -0.7619207387890702, -1.0377285432236536, -0.43854067506815186, 1.2196987403049018, -0.9999952176218796, 0.8100082862558676, 0.6993727352516564, -0.26404055116335245, 0.04717225781294282, 1.0862637433651183, 0.48549874510718566, -0.827865989556767, 0.01992240468922104, 0.40806516736723997, -0.8626739637086188, -0.6674288111785496, 0.6385208799281437, -0.7113298840172941, 0.22827394621995645, 0.09342301658130515, 0.21056897503995947, 0.27868679572714156, 0.18733490272717804, -0.774087510748035, -0.5427048153536195, 0.852339966305662, -0.9608641864871079, -0.29524313000346863, 0.6141529267811175, -1.0977910881399773, 1.2888525962309332, 0.3189133590354253, 0.9561058215464237, 1.088537420713675, -0.44289804164623237, 0.5965205631487962, -0.5547093852766749, 0.5209263566441245, 0.9180737404888641, -1.0691185973956414, 0.6194133462905433, 1.2930838501440018, 0.026342179033508818, -0.8155653326031267, 1.1987056091994412, -1.3770645641482968, -0.11719351814876816, -0.9728647782755101, -0.06720920944234107, 0.28088025244181786, -0.21852037278328454, 0.8440780940929052, -0.40132763195489213, 1.0897914871736245, -0.6994806514696703, -0.15774512563913276, -0.1253893617564831},
    {-0.05614346929927516, 0.967465328318149, 0.31707072796127744, 0.5590817563606229, 0.14498119372074958, 0.9993888951728298, -0.923028408758976, 0.05728668433888526, 0.5401259471234255, 0.8466406529659821, 0.6977536231736998, -1.0449134388192398, -0.1866977301510226, -0.42080029310680367, -0.6410423530326774, 1.016970471007244, 0.13812012759471462, 1.1147001681171689, -0.4733918963871035, 0.7305935372253576, 0.007460973205547072, -1.2790248405297024, 1.2060340361853918, 0.21906261448767397, -0.2657716050112987, -0.011060092759959258, 0.529072280862166, 0.4830056947191196, -0.4799210132765397, -0.03197770737812776, -1.1365540348389644, -0.37934833560718734, -0.5202010287212305, -0.31440280146266936, -1.0699029941832232, -1.4310507832830854, 0.04509958241346062, 1.5573551572460371, -0.4203743472819999, -0.2521332628390956, 0.018522051218606905, 0.2335178718482038, 0.7856787841353094, 0.20938535313974038, -0.3839925618580699, 0.46228181073657304, -0.7556370381680002, 0.6385052850819526, -0.529468473233271, -0.6537295528448213, 1.042850144349763, 1.287741230326923, -1.1579088947828486, 1.221058314298406, -0.7015299725518174, -0.08108193541823279, 0.9540474654842748, 0.6636966041253013, -0.27383741464929456, -0.8191058961567272, 0.5852087803736677, 0.3247949946308433, -1.2233993462070902, 1.1802322236077167},
    {-0.7441768630597603, 0.151612115866615, 0.6181629481117794, -0.08933855259936635, -0.5572095096176359, 0.5031658805152175, -1.288808662111875, 0.6397018921181529, 0.815508421936332, 0.9588420509823854, -0.13511859015831923, 0.03047055323340132, -1.1393386361885656, -0.3083309518349005, -0.9926615630993798, 0.809615598832487, -0.30100341583132356, 0.321349031456785, -1.0035261705982819, -0.5937129567682108, 0.3817189440290385, -0.3068160237806196, 1.2090810398317358, 0.3852609920153084, 0.14162166856292538, -0.7058467785429401, -0.8413976884301216, 0.07184963058914424, -0.5406589521627789, 0.1771973550110759, -1.05291863956073, -1.1637397888593213, -0.24858551691015987, 0.43593138173433343, 0.31534476516767435, -0.6377362085415119, 0.12850286607385428, 1.1294752311842957, 0.22835044538773966, -0.029224976009395966, 0.541719804016, 1.411002948106083, -0.09831993836852106, -0.41832230181299684, 0.27895162557027636, 0.6511695632145699, 0.25443874354124585, 0.18098907297806832, 0.6860717958222377, -0.2836192818908604, -0.8726861423629557, 0.29765511798107747, -0.8903171777737173, 0.24836123385682754, -0.6457491177544401, -0.48661822564865426, 1.2812780992660178, -0.8666666265087085, 0.2282223185191395, 0.13951917938175337, 1.1005294441337203, 0.22330083524180885, 0.489795805613315, -0.06780650903055951},
    {-0.36927172716015505, -0.8333364954762414, -1.23025144733078, -0.90476591501442, -1.0901062406353186, 0.289812148408325, -1.005994074162431, 0.945963414216305, -0.775683326073565, 0.8234481365305879, 0.8326951427209631, -1.0124463770320584, -0.39482465494361246, -1.1133324899646915, 0.5215851095696016, -0.22847823302417317, 0.856052066047837, 0.5834827552626151, -1.0926277246165073, 0.43573680684365906, 0.39832233980901394, 0.5248210187240365, -0.005191801683276834, 0.2661522124822063, -1.1508827416474465, -0.8583165444269443, 0.08069666452888707, 0.6849802700915824, 0.9058915232438103, 0.4886937000231299, -0.7312658346912421, 0.8985202371589189, -0.34453159704416686, -0.46137730114703285, -0.31138736170093473, 0.14888642843849115, -1.1861474748800969, 1.1695954865068465, 1.08645762015496, 0.029460352689466937, 0.22837801202627922, 0.28604822574332445, -1.3142038332105077, 0.5525548659210046, -0.3688221926085726, -0.19160697495325046, -1.2420500993784174, -0.9956201797580984, -0.06239707481655381, -0.8034844831847383, -0.3195055600225738, 0.5516393070091613, -1.432671089831871, 0.8081213853157121, 0.12620042749555432, -0.07616847166885421, 1.1324758582533967, -0.6425188645953454, -0.42830171868587547, -0.006330872699607368, 1.0748761555883095, -0.09862450542855092, 0.32747762344622355, 0.0771173405915063},
    {0.9918964405805485, 0.4651542224205158, -1.0144443161816346, -1.195205038886048, -1.4094792223253498, -0.249513248991093, -1.0651740209381715, -0.23545448653738138, 0.5157156398175335, -0.2732162648499177, 1.1596794199093805, -0.47152760435561486, -0.6414145349926116, 1.0506949104749788, 0.7786016896020398, 0.6701570252260635, 0.7195449712424977, 0.14076330985341473, -1.0771792771791178, 1.6692732329792348, 0.3984564638567649, -0.8478819609190449, -0.2611163779367935, 0.27495478048395844, -0.9213887992751559, 0.8245681313138976, 0.08115107067060513, 0.5082694102364681, -0.6058231658948555, -0.30839924004637254, -0.13260434996680223, 0.005166085682606943, 0.8827036760954629, -0.5475322854789971, -0.656667582686883, -1.0231209912305979, 0.7892077908843804, 1.1132376093503895, 0.14829536880957456, -0.08773416280957, -0.8052595680766935, -0.23470705865557595, -1.0965629170705569, -0.22588039419997455, 0.06737495652020396, 1.532692293717708, -1.2780888140571556, -0.46120360558277224, 1.150789850826058, 0.9917354448261547, 0.020865977404315957, 0.09008639721050098, -1.0813331571732103, 0.651555641800724, 1.2548679928223831, 1.1650903441366585, -0.19800637987430794, 0.4070151543796065, 0.505723338912193, -0.8685099665169956, 0.872892045685882, 0.1865875439536951, -0.17936044925425937, 0.8629245474037378},
    {1.2795095415805833, 0.24199940772927972, -0.9665205957731763, -1.1504461240730859, -1.2536472673715684, 0.06398051786412313, -0.16254549543495186, 1.1445159568447147, -1.2472950251150643, -0.9279866531520373, 0.050410123315363854, -1.0323344655417843, 0.29390267321217367, -0.25601240989836854, 0.22082003612718876, 0.5750705952861018, 0.8747312626936937, 0.35296293449217886, -0.39704298279563965, 1.282134887998264, 0.6892886241426155, 0.02143693605037822, -0.5456541180143535, -0.6739643187279803, -0.7205965502886569, 0.5671877611235131, -0.6902845605962452, 0.6911339634849109, 0.8481136952042042, 0.4062351572334799, -1.1333296729547948, 0.08626968924938506, 0.5491560457917264, 0.9257670629973025, -0.5302105589535528, -0.42095062819812035, -1.3805661323842473, 0.1715229657201323, 1.0259089629718507, -0.23115551311057203, -0.189566899188194, 1.0205242049798624, -0.2361883245672564, 0.14296126015389793, 0.21098049643604527, 1.5450919586649627, -1.3302481316319745, -0.661718176424754, 1.370211485805455, -0.3090059837772444, -0.6736427569181048, -1.0479470599685758, -0.7878609478191632, 0.17044113513238082, 0.688667161766218, 0.3716230359882306, 1.0541673388416044, 1.080582834895675, 0.8515409557266463, 0.11932658441949756, 1.3874354230077766, 0.1863311901677593, -0.9795992257469108, -0.09005351647241305},
    {0.5668605637342573, 0.98213877226223, -0.7414956637520409, 0.41965937711093776, -1.0684367769920453, -0.8728907732216217, -0.13101515967610963, -0.4705675038784997, -1.3245439278632998, 1.0308213646014663, 0.041263999045173756, 0.547423175728989, -0.06407192656713258, 0.9589616320638957, -0.09091092609948112, 0.5855308633632446, -0.5688448099807719, 0.9967041837251716, -0.4966778066525826, 1.6108160970769638, 0.627090388940216, 0.7847652149250217, -0.8460853326418094, -0.6855000123013433, 0.567826551696111, -0.5686794237918038, 0.15163313416361018, 0.14758646181160573, -0.016216354101758028, -0.46032707062397143, -0.991888143925266, 0.021215763123774586, 0.548462175874241, 0.49259308965984117, -0.6623684323465603, 0.05518925846476726, -1.2808014713466696, -0.6530676286033315, -0.37497476520663825, 0.566234720554004, 0.09525459661924224, 0.7270056920532753, -0.5671457404849569, 0.7636966337550832, -0.7652745704296285, 0.3804184831475847, -0.3501354463692203, -0.6977007553717595, -0.018183625241771174, 0.40826708860570016, 0.9952991598569081, -0.23275466912244408, -1.6014319734397722, 0.5407039696301841, 0.1688833311980193, 0.25041221703802263, -0.4194381335040806, -0.1365614570197351, -0.43357007948314064, -0.38258016339439455, 1.179576988417533, -1.0757502140876645, -0.6102160081927531, 0.29431442556164344},
    {0.7909772259018442, 0.40486458232084915, -0.3869241992919942, -0.9183679044712405, 0.12106802975182875, 0.6407971087086185, -0.5738548419837399, -0.25512889371933545, -1.1214571471945212, 0.21011267892791913, -0.3065323538929894, -0.9596876029783924, -1.1956398398338601, -0.9010738454714262, -1.2167829147897395, -0.34637192658539934, 0.7882967053675153, -0.5705966750472972, -1.2506770207288167, 0.776881516452445, 0.15894949031125832, -0.19224283556309416, -0.8059171417708735, 0.22819223013790205, 0.3173149374761233, 0.05446147779010631, 1.0079911471542924, 1.0802455858188624, 0.8186750799905887, 0.4691104331838761, 0.5272917546143311, -0.3356112272404577, -0.5442683982322163, 0.24737579220143543, 0.8426627560655449, -0.46756793640697025, -1.2786016301752703, -0.6089240551242727, 0.6386991239640756, 0.785262759552597, -0.290549719344836, 0.9438798590815667, 0.7026170390767639, 1.025661149627976, -0.21769508903139617, -0.29838640183851045, -1.3642691181434825, -0.7527965896735548, 0.6665614163090791, -0.2930087013928401, 0.14620952058644193, -0.4131799476035704, -1.1644182806767176, 0.7549999732158711, -0.5250870651298667, 0.812419395701655, 1.0123457065779897, -0.7433498314819194, -0.7953752155785959, -0.07410755617846718, -0.2199452187228396, -1.4129277522523431, 0.058413960226391046, 0.968138952553492},
    {0.24485685884338787, -0.003049690973317576, -0.66776201532019, -1.4768512858896317, -1.647164752933167, 0.8463535076550651, -0.5373789906987188, 0.6312929875589267, 0.05518700211252311, 0.6453798762220244, 1.2776857737058256, -0.848066748748847, -0.4076812116512936, -0.9835279809702135, -1.4284356226881714, -1.1724798898718327, 0.6388683403832839, 0.6866662106283484, -0.38324547449755847, 0.770481375090598, 0.542501127421355, -0.5920392155282359, 1.21330114210704, -0.9239527266357963, 0.6419141395450116, 1.0544934109685338, -0.12049419829272309, -0.38452278089045827, -0.1444663052703884, 0.733632020310473, -0.979922168835406, 0.2446781914678867, 0.2981097009674821, 0.3850223765985056, 0.11069613578209782, -0.17292394150185034, -1.1029351734984663, 0.16795971645853086, 0.3657160547693597, -0.16375978353055326, -0.09996061310686073, 1.4004754443558494, -0.2703313016160672, 1.1198943074744803, -0.21316587728828712, -0.2105069326024779, 0.6373819842564491, 0.3972988529181211, 0.9420995552230305, -0.5227563895695612, 0.5484679531547026, 0.344479762913946, -1.4373596690580728, -0.09300367539131181, 0.12073225092355754, -0.1668819255795006, 0.938831172491291, -0.7359323096605951, -0.6657645607254848, -0.3054658533058134, 0.999610088047878, -0.199524113261106, -1.2371918077100421, 1.37949519578546},
    {-0.289319179523489, 0.8866951156978483, 0.26437574801995894, -0.7615811340638611, -0.43779545951330284, -0.6382093949960114, -1.0874268564025735, 0.6603222523382402, -0.8643105053617804, 0.7444912180149957, -0.29385673010446073, -0.8343167138356294, 0.43708746801978937, 0.7783656253562777, -1.3431133523861294, -0.22727728866770255, -0.21885560890126032, -0.7198742991843947, -0.8933071291968646, 1.213919146254489, -0.6835941301012098, 0.48877295697943673, 1.0443423405274328, -1.0032762269822868, 0.06561487815426349, -0.7565700149841255, -0.7281554119059719, -0.7142079169174601, -0.300108501321695, -0.15066415664924449, -0.7535490414757088, -0.042351572279393526, -0.450550272628972, 0.4499407638034741, -0.8204136506541315, -1.288064144553061, -1.0933673419133638, 0.02404128200223754, 0.44077148179314485, -1.0607541109678713, 0.04572138986565645, 1.1242665620944754, 0.5826377129390891, -0.008162192012419028, 0.7833301932326074, 1.2066963362951912, -0.749762319675585, 0.20025240686971923, 0.0889278065138913, -0.5118534909405668, -0.7153917936645522, 1.08933107175553, -1.287777229019278, 0.5800209563628727, 1.1158381651064069, -1.0724042602848223, 0.7598924481652639, 0.6741321792334812, -0.9098298269792292, -0.5630509027237546, -0.8525411458040116, -0.9292763171818428, -1.3151321395375823, 1.0727837194517822},
    {-0.10224306734773733, -0.6462111505128622, 0.12354306624625584, -1.2377825071882755, -0.5782127739227341, 0.29040434587174513, -0.88518359860203, 1.1680335292866613, 0.7946186360121433, -0.25330787542182004, 0.2804296494457409, -0.6241693585180095, -0.4836867480051391, 0.631349818280612, 0.036423265369391715, 0.05680105475268038, 0.9470408082958698, 0.5583068963134202, -0.6169500405834838, 0.007305110802782381, 1.2480817702577107, -0.5664550801070867, 0.9025782634121123, -1.1377759676680246, -0.7290837849472402, -0.22087038193561048, -0.22506075468476777, -0.7460082954741557, 0.4506345376992759, -0.05019962581181872, -0.4410976877418915, 0.7322970954345288, 0.1364292990025107, -0.7635900605515943, -0.749084577422413, -0.6413318760762665, -0.5082168583268207, -0.28023634440249473, -0.5439366060239613, -0.4119962594586463, -0.1035133883680929, -0.10120336230378127, -0.49891630675738946, 0.4137037091709377, -0.4456502239235052, 1.6215402620742712, 0.7949712275162337, -0.08316755242334557, 0.7795366015023003, 0.223154029981027, 0.7909824101240513, 1.147035516331992, -0.6939645669950912, -0.03992236816117924, -0.5173179224006371, -1.0720096638462993, 1.5333247533549508, 1.0551038026192112, -0.14446185542766218, -0.9888852043092589, -0.6295956502066105, -0.7008455711383658, -0.28047650388406, 1.670794016708094},
    {0.2786081679591174, -1.0010562035938344, -0.4674549433706124, -0.060519097237675144, 0.4131645093580645, 0.12165662212155778, -0.7338553053230599, 0.5168737144642161, -0.7087214848037409, -0.9468052445296857, 0.8798044584148743, -0.23231485016672843, -0.3558474832456807, 0.5751243379493801, -1.0587964123476261, -0.8651404489103077, 1.2974487912746617, 0.36200277440593404, -0.07634394951212188, 1.174652597650552, 1.1791705918614321, -0.9993072560772301, 1.0079928918746686, -0.5218985808033558, -0.0042403644554988825, 0.5695445165810372, 0.8184138800559216, 0.5960294439945794, -0.9255748327767062, 0.776254023639689, -1.2077800111742332, -1.022521852585095, -0.75684554832501, -0.21994413265591745, 0.9002906098911195, 0.06988553013540014, -0.9459897931789657, 0.015669991832387944, -0.10901427158081951, -0.897162658542965, -0.5692184279274931, -0.44695365414755633, -0.5880523792861009, 0.9414505708685923, -0.9982607104751222, 1.010353376835537, 0.2526383523529567, -0.434813047376785, -0.6192593403018639, -1.2262088948576175, -0.6791289478296895, 0.2097207390934968, -1.1291852227347867, 0.15825033793834686, 0.560473472834635, -0.600054776154869, -0.08038158884964398, -0.48160090831234514, -0.9087175579423942, -1.454947312329115, -0.2847011901242258, 0.33581790932095396, 0.06322943181372881, 0.9079791353487724},
    {0.5779535667295185, 0.22682345720981528, -0.590716892218541, -0.6421059202360917, -1.334503688858846, -0.13591202013235956, -0.9485525910826129, 0.19867564132922236, -0.2510214618453377, -0.3606550987596861, -0.17886628932215962, -0.782886605703773, -0.4977860792827939, -0.8214853995514166, -1.188967844686906, 0.2885548000951283, -0.8010792963176209, 1.5126078017876465, -0.42123298375746676, -0.5105750329036067, 0.510727547453492, -0.799444391133947, 1.277352431761352, 0.81314296292273, -1.177527656263113, -0.7056944664916682, 0.39864356659490735, 0.26439907628213216, -0.10588513355350997, -0.13278787693555724, -0.4115464889647169, 0.6811535405119212, -0.3132003286583958, -0.5418645431338667, 0.9106740197397283, 0.1716469418596337, 0.522983165234132, 1.5101264194867634, -1.08276367266664, 0.9368553658184489, 0.10182043740803047, 1.0873034642147346, -0.7695238008379367, 0.030116415136542563, 0.1695640232327874, 1.4597646743995947, -0.8910045512364588, -0.4282396455160147, 1.0524532327122667, -1.16744087831839, -0.8511672272610004, -0.13469213986041859, -0.4666710352336845, 1.2325851654952364, 0.12432887679581343, 0.7519897026667316, 1.072468495852921, 0.9179676209627002, -1.1516674331772663, -0.12779774583459375, 0.004681869382885046, 0.418435900375992, -0.2478581306048534, 1.3640897937656593},
    {-0.46129640226855473, -0.14556161105570203, -1.1144178429005744, -0.9291962552098839, -1.5250963149770744, 0.7633400466350386, 0.3786570906480628, -0.5423746184778032, -0.7762809619173585, 0.9784709706195348, -0.7780883413272703, 0.39333259760768197, 0.4280261187171545, -0.8658909634643842, -0.760818928685617, -1.250081729669046, -0.7530316724327757, -0.1149581822736227, 0.26153886102094304, 1.169278682099293, 0.18780163872821332, -0.877308823194229, 0.323087680346317, -0.8493582739887423, 0.09233663757030174, 0.7378697248190117, 1.0342081222923978, 0.7790666906851589, 0.7459259915202382, -1.0535027036668998, 0.26824716587864533, 0.9647327400151695, -0.8610799970976691, -0.4995286684441944, 0.4552879704417299, -1.2038459351471287, -0.18425381802438587, 1.468035280217095, -0.36782945486964963, 0.8772275852778076, -0.3998907253828255, 1.6039846812933567, 0.6200743978110677, 1.3044990009173922, 0.43919649189721727, 0.7569932488714173, 0.04575334231130664, 0.777325311567495, -0.5714883880106383, 0.7456711068006904, 0.7140254395831651, -0.14167000376466887, -1.1602189619596346, -0.21649201953180794, 0.8408190881109587, -0.8678269673726489, -0.08749854279090494, 0.338794972031159, 0.5479437915299057, -0.8496769044561925, 1.343956433509447, 0.17022548669481943, -0.4264437377565401, 1.214635633164044},
    {1.211706168253323, 0.181513629508148, 0.6147569574229211, -1.1159433131387693, -1.1275252109400367, 0.6997146326027925, -1.250439548763608, -0.524463038308545, -0.9573764950565072, 0.885943699058715, -0.5646061676610473, -0.7311485195322357, -1.2234022081233555, -0.564448993208002, -0.4520601564193087, -1.0244243680240257, 0.5398730166311998, 1.5232209622789399, 0.011672151001578658, 0.05508186596024677, 0.670275027295106, -1.2081211339140645, 1.1400562994715948, -0.8016007507450312, -1.243767586555729, 1.0675574528397784, -0.169360455879052, 0.8600518971971635, 0.014849642211278555, -1.0255719132932866, -0.6333622560206711, -0.5320983327986805, 0.5167514097256688, 0.6679574491851791, 0.8360983466130745, -0.7199244362755423, -0.13346035344496435, 0.7059141043666792, -0.5754194173214104, -1.0689887931151048, 0.4083454473099319, 0.48634360760705775, -1.379563566177956, 1.3178272200247598, 0.7028068271389531, 0.5154091958344067, -0.6044340760399496, -0.44399375886906717, 1.0212383001110379, -0.6482937400079243, 0.2204744936348754, -1.1300131642905606, -1.4808362152872552, -0.26670276829506306, 0.9063559552809012, -0.44050971004649747, 0.6733137127154154, 1.0812643893844722, 0.5929662503700819, 0.0969228838883446, -0.16312873106554063, -1.1320008589518538, 0.5115937584738053, 0.35146512251887646},
    {-0.1456300457682925, 0.4001807788924135, -0.21676460221617888, 0.6427798358564413, -1.3987276729900882, 0.20999779977408609, 0.5457865258046618, 0.06630506266242948, 0.29314562654145115, 0.6368238387383928, 0.41531614687182505, 0.1531381225104647, -0.5440710160576925, -1.0243070884774415, -0.7403268959533298, -0.7831099569713419, 1.0492107637950112, 0.3477579315044369, -0.5427206755519944, 1.5611945487188459, 0.054267630336207656, 0.15768811017962228, 0.052571393957857884, -0.1690407765729242, -0.6282833789470613, 0.42700025193108715, 1.0207025354384163, 0.9905814841413535, 0.5854356633294963, -0.3187361280031512, -1.0952466420287177, -0.8333055883212076, -1.0845769974050663, -0.747409690905816, -0.05336239177880329, -0.07143620481820298, -1.2156568012642748, 0.745746756065708, -0.7091084348669316, -0.9923207113598224, -0.18210122529767417, 0.6273640054224292, -1.4539843008712643, 1.4742778834566477, -0.8245031200236728, 1.3636873906029576, 0.007043473023607385, -0.05098265637160878, 0.033084074673056726, -0.01227249807992129, 0.5547661861891203, 0.4385258749697509, -0.7303500652352554, 0.9979933675817046, -0.4836894143583906, -0.725250241237331, 0.9425489848988899, 0.7728638765507846, -0.8603527927985629, -1.0418714276327927, 0.14127553419821198, -1.3450208498777865, -0.5219773924016349, 0.007679171763297336},
    {0.7717906617736959, 0.8960691265912417, 0.1422073944678224, 0.042397724947596305, -1.2464253573150534, -0.6506665184513465, -1.0072494832824772, -0.9237195924804511, -0.30478100192921553, -0.34679712376771926, 0.5660967853987017, 0.8918449792042, -0.8169520229730944, -0.6138253261952163, -0.5191908993554456, -0.41083128319879175, -0.22944753975495147, 1.3632975603467874, -1.2657214334583051, -0.40901334634129893, 1.5309875532122577, 0.2705445382136188, 0.9852755133803397, -0.2794957114088457, -0.6962321630703232, -0.4131605827475019, -0.5638928790716208, 1.0482427699958328, -0.41904709527862183, -0.824395844768312, 0.375636305007879, 0.8648721327706446, -0.6506602641950388, -0.3232374498947445, 0.3568282004749912, -0.46174112851499866, -0.6127725655720051, 1.2262804359323207, 0.1556624380363078, -1.0672962762117082, 0.06544421867154661, 1.0868430450262156, -0.5698047764145113, -0.30183829589919786, -0.9142291230620762, 0.10810081459691093, -0.543418917183138, -0.9305618094780125, 0.5706278474955793, -1.1138029515060563, -0.7008753377797576, -0.7064009444512701, -1.5834238390717077, 0.7213120151686392, -0.28575578271413216, 0.6092799608324635, 1.06689320117918, -0.7390967057633211, -1.0382714816851362, 0.1141205161879582, -0.5927216893125445, -0.8440229489426464, 0.7665024201448398, 0.20250917269514107},
    {0.9627205949569915, -0.29454943813309803, -0.16397791586519714, 0.010418721994988802, 0.5155825455872927, -0.8722726776888098, -0.5883534719101491, 0.03599126362567174, 0.5749397084154603, -0.6361901895015774, 0.09906364578851556, -0.19155779115002933, 0.1516726059639084, 0.6216155876758059, 0.715027795890048, -0.27761003937837186, 0.6514472215613707, 0.9131132615694675, -0.45398800932508515, 1.1501362793939016, 0.7041234512513925, 0.11681439475714302, 0.3885940028172176, 0.026646793018091704, -0.4938548538268736, -0.09267217560940867, -0.03838037895346678, -0.19719060678404038, -0.629981262410081, 0.5078346125485892, 0.5719890262050483, -1.0326503423355442, -1.0516567867941005, -0.8647154196691048, -0.3130691919058968, -0.01564046249615232, 0.3476356135293696, -0.23904845982229167, -0.05859045858088457, -0.8695572227061774, -1.155139198159076, 0.5305166637747208, -0.14819624649879748, -0.6059244650667653, 0.6170246851287924, 1.1851194229409059, 0.23482820591455053, 0.5081690360066301, 0.2472467179100232, 0.5896296875701662, -0.6123630768932137, -0.9622580483640769, 0.02293771972990724, 1.2584912223028293, 1.2104320340088361, -0.43650537066287887, 1.0385953790982128, 0.05484322927934636, 0.813817328664731, 0.366354738031027, 1.2707869763681843, -1.253164690783599, -0.8630042298135346, 0.9393999761227433},
    {-0.6596466607721184, 0.787174020157693, 0.29489893838437264, -0.4723849375034352, -0.031126176359560737, 0.5006080940088263, -1.3211052828347962, 0.45747374451241135, -0.9770640838645364, -0.9806467593970009, 0.6625582062383237, 0.3548707346835989, -1.2436426430206917, 0.07216684304078691, 0.5837006356722928, -0.624224280283218, 1.2053020291113672, 1.2427856701227038, -0.6109717207713843, 0.18951544052107547, 1.4986514487812401, 0.5051863985240178, 0.6804992465045684, -1.273282012994306, -1.044834376604722, 1.0623266248203778, 0.8904611391152736, 0.005680890902848527, 0.6854063145505446, -0.5595584744910332, 0.1523368237365211, -0.46234503340494976, -1.043677797752209, -0.69824361416117, -0.15015002849567088, -1.1902666038860814, 0.2027370225089794, 0.0398038213075362, -0.48831786098106467, 0.5935971494369827, -0.1944437741721905, 0.4876469928056544, 0.24007969609955734, -0.36223649812588504, -0.7551514083460196, 0.9205396137019731, -0.6089146606338889, -1.0774425323971422, 1.4255417605968879, -0.6905580962369814, 0.31921972951125394, -0.5377629696148295, -0.8563532567200105, 1.2133685412028283, 1.3011603548592425, -0.02104809539106342, 1.2831222502009816, -0.426018514055192, -0.12660144488762456, -1.0537218247920395, 0.27639096737243946, -1.016099998843456, -1.0576242076361384, 1.5733966604661096},
    {0.9985448290836069, 0.3131962006045784, -0.6800510479228412, -1.3523140287231643, 0.37276805157151616, 1.1199369083336046, 0.541501021009975, 0.9495291498120031, -1.031079898345599, -0.6856920866353091, 0.6771000245008942, -1.0278191503078666, -0.8171363615597803, -0.4757438388119321, -0.023280358006333626, -0.7105427236387899, -0.19842525924293072, -0.23973613807315994, 0.3143155084273508, 1.1150221859270772, 1.2799100773118528, 0.8577453822699828, 1.2180490218443805, -0.717173409955643, -1.2436325782450337, 0.8549816760163494, 0.6888481175770759, 0.6883102155400304, 1.1481368429295757, 0.9564342720292904, -0.8762710059511539, -0.38769647081954484, -0.46292412078366996, 0.7444236681781974, 0.0519153900920716, -0.05012179917511621, 0.04797533874820437, 1.4263494110514794, 0.47975285266751555, 0.36015359029480937, -0.3318139315453913, -0.5452925129550734, 0.594694247528283, 0.46094184173282876, 0.38778901507211433, 0.40344177053433544, -0.7236626358582449, -1.1258850203692126, 1.590259046559873, 0.5293393437528939, -0.8134829447109287, -1.0476812518696759, 0.03285023278971611, -0.2099458321054537, 0.14477326083025682, 0.903751108172324, 1.5686963449656532, 1.1281200951941235, -0.2303342624951253, -1.3235908550182518, 1.0892735004673255, -0.969384541965881, 0.9138589798591923, 0.43691584548308543},
    {1.3135741283417148, -0.46607155440064224, -0.08332830337182873, -1.415257354178164, -1.0556557459877207, -0.7959233557541469, -0.6671196112645009, 0.9234321095437222, -0.49080082492551586, 0.4166445898324875, 1.2222605545723344, -0.3547951511660374, -0.054454616530546035, -0.608125731002608, -0.9003691235490736, 0.7353415671804009, -0.17558723293689915, -0.1500632304696664, -0.47767128775243567, 0.4816834251254703, 0.1714947617840305, -0.7784489324493079, 0.959125117960349, -0.6770457814595735, 0.20115665223179283, 1.0663758021861, -0.25833420650651306, -0.06419175913636728, 0.6562191893808834, 0.6652362969280083, -0.053948771147613116, 0.5490209387285994, 0.06010164781934801, -0.5237826031275857, 0.6177240934359529, 0.16509201100595056, -0.3125195555292639, 0.4963590414421991, -0.7270567818858562, -0.6556639750692423, -0.6509584981921892, 0.9080783454504551, -1.4932115064252387, 1.4599635604917531, -0.08837604935831639, 1.5315184941938342, -0.7447787162677808, -0.7587670120560263, 1.5686628400294758, 0.016274490981690332, 0.7370053263370201, -1.0199262915283416, -1.6580919693253908, 0.9658500049792399, 0.6050348352244154, 0.6636082915470309, 1.5112559637279916, 0.5111922873370308, 0.31047585598888566, -0.7912125218890477, 0.40133556436686657, 0.11059812461093392, 0.008067878945973935, 1.5177899310083014},
    {0.2577521963595062, -0.46895151726342277, -1.2001648107003737, -0.5464113779511903, -0.7107441595472703, -0.8657181330705835, -0.6194407130627273, 1.3224258513310356, -1.150192018736622, 0.7352640111636161, 1.30785031821257, 0.5804632517588423, -1.2550017442346457, -1.021641036270832, -0.45394239603034114, 0.21688523812675245, 0.46820968380327854, 1.1582518754660405, 0.48505228155451424, 0.7380848616208516, -0.06679378755837956, -1.0335960821822494, 1.5467526868593113, -0.7162843301033793, -0.3471458241336812, 1.2245107672833822, 0.22830707943100742, 0.5803758034411274, 0.9064430407181306, -0.39002311888936947, 0.44648359529372517, 0.6650594840334833, -0.7399063520378556, -0.23695563321712432, -0.70685976256258, -1.1428257558634498, -0.619893073019059, 1.3220771046238893, 0.18212660945900913, 0.8493060109395477, -0.2578827056020192, 0.5064922910324116, 0.28020765782711043, 1.297117357940655, -0.581557583172602, 0.06411665621500429, 0.21363769999861135, -0.19221938493117172, 0.9621754261562185, 0.15246787813047336, 0.11916564266467648, -0.3585069870595327, -1.4601416503757727, -0.6767838772715798, 1.241219662016593, -0.5321396289043716, -0.174863771961614, 0.9376094673027446, -1.1741466728179304, -0.4455753309738707, 1.0264373109983052, -1.2787273052494006, -0.0958640358454985, 0.01856764957601626},
    {-0.012448332844046324, 0.7520858494556238, 0.05965448456705603, -0.19793679693912292, -1.3289170382322928, -0.9403937775006546, -0.9476315489159421, 0.5864211293800519, -0.8206086936618529, -0.750752805450966, 0.9712821213641708, 0.7669300330075322, -1.006154979595502, -1.3070286652069463, -0.6663428912309619, -1.4132447698998987, 1.2192904407694263, -0.11135884662103165, -1.3230644845970825, 0.22835246298688366, -0.5257537694113833, 0.03990628895640261, 0.45830167284661955, -1.1635786389509208, 0.005047725975710333, 1.0948097489030453, 0.6931791163098582, 0.5996064516893578, 0.9110677299667534, 0.17057260092335996, 0.5113373538724285, 0.6026145597321717, -0.8250295475423055, 0.8098120225218582, -0.7380795978222946, -0.6048959686578533, 0.13220219565904814, 0.6325076880973841, 0.2606098432193421, 0.32688359683876395, -0.7350489755705807, 1.1251610458952324, -1.4730891408091467, 1.5110915389122113, -0.3635804633858895, -0.050681717623364195, -1.311582410126674, -1.0836537406857214, -0.5088757815983012, 0.4633305212482877, -0.8639079745791777, 0.558556316555859, -0.8366520840659789, 1.0566246481821961, -0.5022503520124134, 0.47683260012888995, 0.5218321892327815, 0.6557062173772018, 0.386577466771233, -1.284563453072825, 1.2850671397391886, 0.651533749585407, -0.9668735714634696, 0.1698161221466622},
    {-0.5121145294012722, -0.8217751208201368, -1.3114618850323398, -1.2322116958470317, -1.4307281857516503, 0.4729576681443233, -1.290398927346688, 0.4879760381309436, -0.7759432539053916, 0.058354668846276075, 0.21078300096073163, 0.06088466513544571, -0.03307193181944883, -0.6213924377792402, 0.18364338397849267, -1.323263497174646, 0.0990197980828332, 0.9976151129948391, -0.8612843678669844, 1.0335201660049926, 0.9343072267143907, 0.7793656191813477, -0.5135702390308495, 0.18748900841772892, -1.37090745888358, 0.3483719771344773, 0.3354714197191791, 0.08256256862644107, -0.7318459927251998, -0.15688462334550513, -0.04032482894862289, -0.6126849371525681, -0.1895638820211569, 1.0025316426443107, -0.18878790529938305, -0.6138494771705867, -0.5735168535505845, 0.3954765926826056, 0.3895746796222802, -0.1510102215308119, -0.044810071428712656, 0.2747507482623416, -1.2389433491407262, 0.9655442015088764, -0.18381717234946637, -0.5186945940119733, -1.0284481719578862, -0.5249106887936665, 1.443080088241792, -1.199227069497589, 1.0103207783726216, -0.5539074860631467, -1.0150460166662163, 0.7394173375688076, 1.2861685291418203, 0.47703442556093584, 1.163676828372052, -0.7682695206899386, 0.3038808015972265, -1.0105522998098204, -0.48738246802682766, -0.6086884354565911, 0.2532810415187207, 1.498048453671128},
    {0.9996416570547197, 0.8503648003120862, -0.3065702719568666, 0.5916883886500046, 0.8521298584032292, 1.1419212476596607, -0.9457606029900367, -0.5880248895719452, 0.7575604156591687, 0.7241817625522875, -0.5979543585621803, -0.08016422634132946, -0.683609751878878, -0.28328884358670114, 0.1977492368421943, 0.635784839835921, -1.250554732186175, -0.5134347863739129, -0.23240372896705125, 0.8235618137708308, -0.2802295394175559, 0.42276296480243847, -0.9650989784399397, -1.2252923052450806, -0.633545361777068, 0.10895259044934746, -0.7579646973290876, -0.6968460472182225, 0.1909158365316167, 1.3042010092089387, -0.3259689576588443, 0.5578007617011342, 0.6342345756272036, -1.0595866274156227, 0.7845635807240913, 0.4707691415033288, -0.20878468137044687, 0.025533307681234543, -0.10234429092101188, 0.6773589758081308, -1.653189112915423, 0.9887413649536259, -0.5773352555168186, -1.0902493796654973, -0.49111125890442575, -0.13799894776790242, -0.5867169313910362, 1.2393176208972188, 0.19854737449683724, -1.2611062869322598, -0.5187638240701856, 1.0252507405234843, 0.7281656321340367, -0.19959310014993667, 0.16178035642115954, -0.21135024582763334, -0.6349050284982715, -0.11928205249010138, -0.7403890562180108, -0.44714388647446934, -0.8456995437440169, -0.8210998247062569, 0.40920478052583625, 0.027548341928578805},
    {-0.9749879063216274, 0.8996572056709129, 1.0993070513481864, 0.7595408264339432, -0.4851924722086095, -0.26393040220193603, -0.6487504515343594, -0.8479466161634325, 0.21889293090764145, -0.46111748575441874, 0.9111559795300095, 0.08451916940734894, -0.05841210792197247, -0.30865032675558385, 0.0018491211676214502, -0.26701792198901125, -1.162446923932177, 0.903538164337712, -0.6726680054876318, -0.5621346474526496, -0.9999270422486305, -0.240975067181514, -1.0666986133675083, -0.4237475766597175, -0.3381755858596089, 0.7110474731775845, -0.3263422198453075, -0.524739714239307, 0.02746371177071598, -0.2542478862817868, -0.44965995285740984, -0.5894316336503044, 0.8613909565185154, -0.9863051928884461, 0.44023860113166297, 1.056241864503265, -0.2579108705497334, 0.6595806657086499, -0.8093715259000565, 0.8720492264764982, 0.9090253099118498, 0.01836917952016426, 0.7349567633927483, 0.24748158973165643, 1.0605936885352603, 0.1479429175322635, -0.6315199922068431, -0.1927960810511534, -0.4842125234071979, -0.08247800772385022, -0.277337023890301, -1.1918934797653167, 1.05406742701568, 0.6203679723755294, 1.010817074188552, 0.10417763897473156, -0.933704775716722, 1.0775416747036752, -1.1843312636673802, -1.0798278537546009, -0.0895250872651663, 0.7465779007560212, 0.9936272152190255, -0.7926124188214443},
    {-0.19535792056963613, -0.09335787383057932, -0.381938743404595, 0.7348171383044273, 1.0717528538028724, -0.09304869627297148, 0.7300781558873488, -0.6942667964565623, 0.9553754782004817, -0.09129796999073049, 0.36244098134062697, 0.07384152583618162, -0.36570087462598483, 0.090658671632154, -0.9337001250894071, 0.6960032675120741, -1.1873418787698573, -0.4763155666980921, -1.028446672469318, 0.784816553022598, -0.7138048429523038, 0.5091331033962386, -0.6652513090830743, -0.665844463676104, -0.786317735796354, 0.42717771925198583, -1.0095141930911073, -1.1757690162695855, 1.0330510189577002, 0.4661055199876585, -0.8997406790777104, -0.7004940211845677, 0.36178682802972223, 0.31901168537632657, 0.5385640809507135, -0.2778994385854212, 0.7157448800981334, -1.131374483570524, -1.1174476523079344, -0.42369287337432826, -0.0671075552546956, 0.15291097874415144, 0.15406149881147452, -0.8916937631990515, -0.6234597312235338, -0.2440122497580161, -0.7004449510450341, 0.7118614586761077, 0.15971472192282712, -0.5928219842490474, -0.5114534781394927, -0.9869738754283307, -0.9847454095437688, 0.404913590260969, -0.36115312719972886, -0.5866332076194697, -0.5614072537784962, -0.42214980465489715, -0.14814286893030643, -1.008618972244659, -0.3754054260987157, -0.8142892374126506, 0.3662283898285368, 0.034145132472575924},
    {-0.23326295256178672, -0.4047424743079381, -1.1535418031298557, 0.8622357995529831, -0.47971824711152944, -0.21899056960909655, -0.0489290855027263, 0.5160831795373544, -0.534645021882948, -0.5928829275500921, 0.33214786137623953, 0.4096395578899462, 0.5117322035763004, -0.053194857342407725, -0.5334138332031138, 0.13327827994268995, 0.08666637119212067, 0.012274806815186558, -1.1967358623480229, 0.17225081348906265, -0.3881449603382248, -0.43075158129940533, 0.1650510002649041, -0.1586989446714026, -0.08007498380964206, 0.7584978370396376, -0.8638345385696813, -0.15651086112995571, 0.4823450884970427, -0.36329498379417785, -0.014857267444195525, 0.306069908083645, 0.9181569390665089, 0.5245601356308612, -0.10405205349376279, -0.3955819628337932, -1.0375177406444103, -0.9851064172353345, -1.0945296040103942, 0.4073697806434266, -0.86704681556142, -0.47498737184141837, -0.7480802597582279, 0.30545508863560994, -0.19833266808135355, -1.2846247543207876, 0.9561726143041286, -0.2644256394682903, -0.12272238867661751, -0.9313142136795549, 0.059355537930904166, -1.1771837806235028, -1.1138135373065892, -0.35717192726704194, 0.8619162569033026, 0.6065240601310874, 0.2862374831395419, -0.8801118316066722, 0.5285271278995934, 0.6895682149392026, 0.7594690937634274, -0.8177700041754887, 0.891728427321375, 0.5207050441442433},
    {-0.8187630523947459, -0.9264915207044976, 0.9720606802612154, 0.5367502957305537, 0.7905023854701074, -0.6448847725129038, 0.5184869726267936, 0.8550012594170333, 0.7911203273743225, 0.23216914420172005, 0.8077124627967597, -0.9524254084281512, -1.0749827348726004, -0.8907926080212171, -0.07313534736713334, 0.4501124700218855, -0.16919199029400886, -0.7552085942978225, -0.7149265608133915, 0.08042283798181836, 0.03964657838931642, -0.8122934645686579, -0.28261127440914363, -0.00519319425670776, -1.2067233314642238, -0.8876326907073848, 0.5931706452583337, -0.9603239439333768, 0.9239747423968219, 0.15810513499026757, 0.4235288682237366, -0.661739324712815, -0.3225651605666299, 0.6337212403694162, -0.9330123780310895, 0.7606651182549954, -0.9757198107668585, -0.21318450703249847, -0.8516065920254619, 0.19367921153139778, 0.6044981817864206, -0.9255749991554796, -0.3080648039356182, -1.0875722070930718, -0.7487908160376653, -0.45370234236967566, 0.7207731174325935, -1.3551056334077474, -0.2941191280726756, -1.241066984999433, 0.11341657147539716, -0.8992254410457586, 0.7233528119475762, -0.5938631628037738, -0.998928784922199, -0.016214378696201823, 0.6345008994931014, -0.35802279843503454, -0.718374020342503, -0.18716714842723225, -0.8111943526029053, -0.29343492211529154, 0.9596908165127588, -1.018531737190038},
    {-0.7356350259921844, -0.29778277279947535, -0.18584106262956615, 0.9900031168948686, 0.34893754363474944, -0.04621902045706556, -0.8057067842401541, -0.4141449284394023, 0.005175973141412709, -0.3635594703702932, 1.057196454404127, 0.5566560424205078, 0.005753481871794671, 0.38272325949096253, 0.6321077696414902, -0.4450000087164858, 0.3009001787273221, 0.33944149089290904, 0.22722597372952674, 0.7989077607806595, -0.2568465794549906, -0.77668021142408, 0.10051712720259662, 0.5668755562213369, 0.6723723165522751, -1.3025459044524073, -0.31284302682719306, 0.305707278676764, 0.7653714701508678, -0.7770864125111514, 0.708476817679885, -0.14157848616208127, 0.6579328732522608, 0.04304340013235666, 0.047681340180526006, -0.38503255653817214, 0.6217347866650952, -0.2882436608898584, 0.4408333241698984, 0.3015666817985305, 0.8366915100908927, 0.8776849606797557, 0.04180460096734991, 0.19378638951024318, -0.43207874910691246, -0.2562941675430799, -0.203997632951314, -0.7489566545307156, -1.3974967006784407, 0.30596510924961934, -1.0211854494275356, 0.3103922547329408, -0.902707232029331, -0.5224775522188567, 0.7156741121446686, -0.7390787587700793, 0.6251388426712072, -0.40848854963173625, 0.5817432058158152, -0.9570393258754207, -1.1831852318898508, 0.21208358405032318, -0.10871866004517614, -1.095407754970456},
    {0.3613331712067758, -1.165089684723342, 0.5863025545908086, 1.1239683865225165, 0.9295540930121025, -0.32200625729120574, 1.0250831789529282, -0.36240575147464743, -0.3508624166165967, 0.08179729354448018, -0.5740066430249713, 0.5885043941240046, 1.1411319466136225, -0.9236162987454986, -0.20134676398742074, -0.341713387599807, -0.7202984290353642, 0.6701436307307334, 0.2644930217051952, -0.12167203867183637, 0.4889264540608858, -1.0506053719449382, -0.264522482474125, 0.25236517194203734, -1.470453939270951, 0.7176169493762556, -0.4850756431287705, 0.8002593704484585, -0.25836909387951335, 0.5258726437870457, -1.0882911204067984, -0.8142344028424716, -0.0021720018991362652, -0.31067203608444643, 0.8427534935623034, 1.1058674927450718, 0.5722350491356853, 0.2781452316505181, 0.8892620711652319, 0.8692270678863839, 0.11838957189342872, 0.6555394633909997, -1.4446986252714926, 0.7655514632399614, 0.7999943958096415, 0.38825684286995227, 0.8736448507400693, -0.7843222472207069, -0.768250665597311, 0.34854295111935935, 0.7898660011075503, 0.051522342866287534, -0.9800491997350586, 0.5220658240420398, -0.3799177377170513, -0.9764587961367073, 0.6322642306136852, -0.8692877682127068, 0.19611954005563903, 0.12559546998515883, -0.6192836608863068, 1.1300856959071837, -0.16377060809357283, 0.03344505843789225},
    {0.554727409710083, -0.03822276669125446, 1.0944422146543493, 0.22765408749942928, -0.43907470050757685, -0.07218290329049057, 0.65973574867223, -0.07967059906818888, 0.41886367538903113, -1.0060886385303547, -0.27362507743395725, -0.2935370533258508, -0.1559341855587334, -0.5609597205387711, -0.35028178870456694, 0.9345321779394827, 0.349815015071104, 0.008034550424772665, -1.1452665926914731, 0.25935605699444203, 0.6474763789468477, 0.05041208140899563, -0.5349364043202288, -0.435176695195833, -1.017367091689367, -0.2069543947570033, -1.0061775961619819, 0.06830344677048715, -0.5195107004365569, -0.2132704328490442, 0.6318754892255153, -1.2024379144881183, 0.9985869245037332, 0.32481841885247315, -0.23554229613626226, 0.47184218888843193, 0.3451472292243444, 0.6080508236122517, -0.1453908863030434, 1.011167816559858, -0.8520388930351179, -0.1920662922373159, -0.7742998685429482, -1.0446288097769114, 0.777177367288612, 0.6438707878984238, -0.8654001763979794, 0.4770953070368396, -0.0941796779305921, 0.5571871857727217, -0.4429466434535471, 0.4244791833764046, -0.6032458172244968, 0.45644601546265656, -1.2979594905788068, -0.4478391885807236, 0.5773440036688485, 0.7778719691541228, 0.7460616484798285, 0.7807871200108183, -0.7094216808640904, -0.3376054842230587, -0.3361084452777614, -1.126503901310166},
    {-1.172565135205616, -1.3158459350197553, -0.032679588638739786, 0.5727319190568452, 0.25380583857305966, -0.33655009681415526, 0.8241552390370014, 0.8682357372573459, 0.5013624210582135, 0.009621941926759074, -0.7846571229393362, -0.7275541476650874, -0.640673057615238, 0.13149919326753853, -0.21884738013543503, -0.031284554171103054, 0.04332658480774478, -0.14435103379190256, 0.4559121543660096, 0.9609063432079573, -0.3175660040074462, 0.39398326485320195, -1.0521726864676022, 0.573508984849945, -0.4492710996536105, -0.6441993474778502, -0.14902767854689541, 0.6603375571585831, 0.2520439321579541, -0.46831012833868996, -0.5167041057329474, 0.5986850062168153, -0.20744327473236934, -0.7319125103803462, 0.6848363207306091, -0.8752861850927681, 0.06668211692614139, -0.9750064885740296, 0.3459371888905474, 0.6191736684352426, -0.3514149411783854, -0.447802951483477, -0.7461804652891002, -1.2225371332811021, -0.29988787247121285, -0.7610167358905051, 0.028609528608732355, -1.230276714295443, -0.2348552613081654, -0.6210867396294323, 0.7001443641609443, -1.2877124806290225, -0.9217583381845829, -0.45061883769595396, -0.8961052386028792, 0.8872377071197495, 0.42038140643139155, 0.9685352581993139, 0.2960914110819979, -0.9576565675489694, 0.05622753250171611, 0.7761108330429641, 0.01116080409694444, 0.1932304057123444},
    {-0.6209039832615534, -0.3239610775118189, 0.9206864694140254, -0.6822539604613767, 0.6583206603201991, -0.7776247849914453, 0.37117503923686734, -0.28134605523804096, 0.5334057178326712, 0.845677017641236, -0.05767488275327677, 0.6304037580230215, 0.9996526012178758, -0.22930010045261845, -0.324907447788802, 0.8723593312760834, -0.20352013035772026, 0.7924238756758472, -1.3178364285279713, 0.9210914569038303, -0.5996526048130323, 0.1140032910301738, 0.10686164297127496, -0.5442633366852269, -0.2192906637632937, -0.8989082816169268, -1.0207201762003497, 0.10829467483479463, 0.48469999480996107, -0.05279361020001195, 0.06366759385334243, -0.8878473653158756, 0.1571721055016532, -0.07107346293783813, 0.010065609768256722, 0.18316112465661244, 0.7495515032730475, 0.11024444336839621, -1.2540739796349964, -0.7218034878972027, -0.16088139425846446, -0.4132001238713027, -0.6582841526139471, 0.2421782879410002, 0.7597713542132819, -0.29230738996816036, -0.5988933424361295, -1.217872002730251, 0.2881916997413879, -1.3913818098605624, 0.5931332517366967, 0.4404719298525746, -0.8095473014014236, -0.2200850994594821, -0.5750162244969695, -0.6257665728828381, -1.1199790068983755, 0.991381021484534, -0.9377932713567477, 0.2870811490229364, 0.7267688102649422, 0.7802943106741397, 0.6374579084238129, -0.17774942587588488},
    {-0.29320346312743517, -1.2852873365204345, -0.9883068816068166, 0.7715151337654728, 0.08085443001178615, 1.0733063746241551, -0.7261265990213794, 0.6247351820338776, 0.5081332345426907, -0.8550437650585854, 0.48750934978135135, 0.2122703979270007, 1.0797392151900271, 0.5266183413891135, 0.33849271424223043, -0.33206532390600096, 0.03247042863293255, -0.7861300968989153, -0.45802713599425077, -0.26412242039852585, 0.36550967795516803, -0.14802835618842816, -1.0313897323466958, -0.6958452140441104, 0.3584931075443466, 0.7231760920332347, -0.3201561354840313, -0.356500500832177, -0.18163788999316807, 1.2597959339670206, -0.5039297754750657, 0.12198423010524602, -0.7707757959463967, 0.8778116509502522, 0.38480709425053483, -0.7025703016536533, 0.04054075698910278, 0.2606461137650587, 0.617740598205505, -1.1570658481247342, 0.9542767308320211, -1.062456394276961, -0.32298247663879964, 0.19523749357901946, 0.3967140383529178, 0.782096139219042, 0.642303324015222, 0.5972630592256347, 0.5171232253909505, -1.3896507535224811, -1.150860714130536, 0.9032934091071786, -0.6758826104890298, -1.0657491725532255, 0.7546311490249461, 0.9786059414703906, -1.0759274109409738, -0.39778489744126805, 0.36815882687838775, -0.9431498931770361, -0.6267279751751809, -0.7563592543420108, -0.08118376468806995, -1.226060864344072},
    {-0.6889569460101039, -1.3025471058304534, -0.7339286620514477, -1.0547068307097993, 0.7852260700025651, -0.0945893614742937, 0.9111097245790476, 0.7890055847655995, -0.3289264108005645, -0.3417873792093643, -0.06515457447662566, -0.1178673914332482, 0.9741675676006761, -0.3742712073539296, -0.7414422810667697, 0.9314308124858773, -1.2537033882205315, 0.749869210411068, -0.7953760917354737, 0.2682685053323858, -1.3589848331730734, 0.8392687100782559, 0.04604308709568491, 0.1994350140283681, 0.587015573634333, -0.2974278282824142, 0.5404788449474347, 0.44993902837753624, 0.7817018157844297, -0.2676388517234712, 0.46306383929448786, 0.0353439353211821, 0.14714007885771566, -0.7269652747917899, -0.13109962073340353, 0.5322818844201783, -0.3804649350425191, -1.084489038572411, -1.1335888953673685, -0.8913043365022758, 0.21260990647624903, 0.31079586304487755, -0.008902161134399213, -0.17147830060250102, 0.6523512923370518, 0.33602768882730755, 0.13406443942605742, 0.2972847538306385, -0.9010371340118078, -1.072259308593088, 0.27279832341964355, 0.6345248991031723, -0.16598027941086801, 0.23630653298422818, -0.9094238525214626, 0.9513525102357733, -0.4091472176359525, 0.8563088235074537, 0.2970989879750057, -1.0367981254518672, -0.7762337572355276, 0.09697847708669825, -0.10505685731017074, -0.9047060448942105},
    {0.08093037252493009, -0.01932660334386998, 0.15467706202849935, -1.0034445040815547, 0.9984920961320238, 1.0341357446767676, -0.3313336612218214, 0.37028776053669055, -0.4327217083355145, -0.8075114270447898, -0.972986477146025, -0.8380632319049831, 0.9500816063282999, 0.13108948524246855, 0.27142773307643364, -0.5156706058144451, -0.03298338546689331, -0.12693140772125186, -0.6463839026227385, -0.18368007359856942, -1.1000105595512872, 0.17160101828658728, -1.2737470245585447, -0.5434433458891857, -1.1934445529160573, -1.0041980153385794, 0.182038173003795, -0.3982029420775773, 1.0273161966571907, -0.26073670050486475, -0.911450339916356, -0.9889978699816707, 0.08924465915643581, 0.318564969452242, -0.4165765874010188, 0.6563121276094988, -0.9218369286084661, -0.5397266019690817, -0.26475602601959297, -1.0388258710527503, 0.9503300679625821, 0.2689688382893361, -1.1685458799409116, 0.7424916191652389, -0.02299159429430363, 0.009403512580310766, 1.0522631224416383, -0.9571045809861062, 0.01600989390364295, -1.036113412063988, 0.530590890271209, 0.4081537349560838, 0.236172711890687, 0.6398266893106417, 0.6498058051679757, -0.9358423041744611, -1.017329358260186, 0.8208910264396441, -0.32532342651541035, 0.05218193729374572, -0.7283033928007654, 0.9518532901008077, 0.9610624720402354, -1.0041918302362802},
    {-1.1886403480046093, -0.7935726611408362, -1.1726865460398268, -0.5111181639283654, 1.1175778213806398, -1.2738383485166727, -1.0489933673418945, -0.0408386415731839, -0.6586103655984533, -0.6462439417882881, 0.6862695424145921, 0.6304595170273888, 0.1915176712413588, 0.0987434118474292, -1.0403456416506047, 0.3147267550696021, -0.7790979395443407, 0.5957335453778986, -0.9277286582244778, -0.16168112080410027, -0.13549936298026613, -0.2988594564758741, -0.760310660395365, -0.9077767757491793, -0.7693877355237652, 0.07746187691304429, 0.24460818695520894, 0.7479959170963654, 0.22130904669558563, -0.1927289254433436, -1.1203493679493295, -0.2629798980131738, -0.0487344138012245, 0.8685893330611164, 0.6405816668276062, 0.5027633075822431, 0.5470432813335353, -0.8653871110864184, 0.7348249448124125, 0.6320444880469405, 0.3106868240098282, -1.2007828356029024, -0.8259610979350406, -0.6492778224089595, 0.09267457525196855, -0.8408707068831384, -0.04505396757196859, 0.22392685119994699, 0.4954108849020311, 0.10995787161058608, -1.3157465662699017, -1.0094288321020164, -0.9623052110048764, -0.6232029460233282, 0.26137240342380896, 0.9437347327329622, -1.0701673332617676, 0.17178808792526287, 0.09697638885123258, 0.017285209278056206, -0.6850456231866962, 0.1827623376799642, 1.0630125436076496, -0.21531851957436876},
    {0.12073463869220959, -1.1092692094330507, 0.7222631558051922, -0.3860454619361496, -0.3841100851951806, -0.8984187230129185, -0.7281539733674337, 0.3623975227895837, -0.7463946543029705, 0.7926756658921524, -0.7931545924131569, 0.6253131693885208, 0.19143253505007546, -0.8688835236303747, -1.019904163457366, 0.3469083134572842, -0.3124115346952736, -0.28768490239701466, -0.9643962814084905, 0.8743659716412499, -0.8402435858662236, -0.7537300698460984, 0.41407954805581626, -0.8524270521576147, -0.19702930496216828, -0.526057446709792, 1.1532865026664207, -1.0262666686127535, 0.9474011335063505, 0.27739183874988055, -0.8361390743738966, -0.07908959186578458, -0.0557913530251461, 0.38949044898454815, -0.8799246394935547, -0.1978255257724234, -0.7463852354944902, -0.29491751314398346, -0.05081754837396254, 0.003830308183744534, -0.7685763739502786, -0.2807083763329709, 0.1544942238929897, 0.5115612275739044, 1.0364878695483213, -1.0607434575435823, 0.5217115829783517, -0.05980483520709501, -0.8838437010661307, -0.7753863282138211, -0.5478961309177046, -1.468435674485457, -0.7598400914023379, -0.4657317034126114, -0.6422520475943245, 1.0071899791543442, -1.0562086403650819, 0.6153853114266067, -1.1994830450781053, 0.493800073049902, 0.7062671406578738, 0.373010889602183, -0.15746006420249828, 0.43943646339718295},
    {0.8966046353196687, -0.7642363382153797, -0.41337694339464204, 0.7032525922960439, 1.0423849002509638, -0.33528505905071515, -0.13204082279304785, -0.5886668108466483, -0.3083396335809812, 0.9275200843232223, -0.8100350482838786, -0.4183719250440429, 0.9627176018650688, -1.6274525320155262, -0.26453917099940133, 0.813339088870155, -0.23478195201090954, 0.875481372388262, -0.6898888460753791, 0.05096627790886679, -1.0277531778268802, 0.4020632051983345, -0.1439282658192404, -0.1991205962449686, -0.3376448323075667, 0.5701979663360935, -0.6270725748128261, 0.9402188741081885, 0.15301295577483814, 1.1121537981716616, -1.0914890084612008, -0.024413414443749944, 0.46861662104910545, -0.06952260050203732, -0.6202337512903903, 0.022864323331487267, -0.13105531717181082, 0.39139920718257504, -0.5701491718503148, -0.4231033819103127, 0.30978059667520913, -0.834217968001005, -1.1005917961166383, -0.30999545252172067, 0.44891113062088467, 0.24518586006924423, -1.0477889745350888, -1.0160542753724666, -0.3753593301122495, -0.36956376921441236, 0.74502643558989, -1.5909814733437773, 0.5969211612926903, -0.7462402001325814, -0.8079467750600484, 0.30274871836399003, 0.30543105111916846, 0.9660173282848827, -0.8067277380559997, -0.28778664633791406, 0.783249226157882, 0.45097746134849326, 1.2171620822355642, -0.7149138972925693},
    {-0.7624853402330497, -0.8468626035883008, 0.9044800531737824, -0.643863163493945, 1.1202191184477543, -1.1137139956218296, 0.007406934623140198, 0.6998844189803483, -0.6526317992485522, -0.731518530147124, -0.8726676817296969, 0.34036383343438253, 0.6036303257942868, 0.014139359045305246, -0.1817905161832436, -0.40429704349023476, -0.23835540882925518, -1.2409972208158206, -1.2891778466000765, -0.08037018997413546, -1.198603262511485, -0.9720941957375271, 0.11013417486146565, -0.5897288670056082, -1.6136018601682605, 0.758937216826162, 0.3628416763486255, 0.6162526295452974, -0.3987171266817702, -0.47653934526340935, -1.0157008010387116, -1.2807294557632862, -0.5381537884621237, -0.1336382886146072, 0.7789684261102467, -0.6201364073961482, -0.07704274527276755, 0.6852799586850993, -0.5710436128947536, 0.6110438907746997, 0.14997673737045694, -1.019206521078215, 0.3121655058934463, -1.0863436729814093, 1.0150832471636189, 0.08754433386092139, 0.9347640503699409, -1.2039603661587135, -1.2021527561802292, -0.6211749382877393, 0.8311958518847714, 0.15645621951602653, -0.43142419155952255, -1.1824024933671209, -0.8271802455183016, -1.0387887879385098, -0.9116925020213437, 1.1628966376414411, -0.306043794660719, 0.3027460047615949, -0.6440154004192353, 1.0136746375339782, 0.5720883234828121, -0.44414700860362943},
    {0.4095944209355207, -1.0332962135394463, -0.15186335698371503, 0.9932550496930413, 0.7987402292718838, 0.046078775882244766, 0.22353030225566242, -0.14806536393407954, 0.11845581430666843, 0.399854026083169, -0.3894076850333636, 0.7214318695621832, 0.7747045249008476, -0.44298659520693734, -0.06407919610931043, 0.3879155191567296, -1.4023151047074605, -0.06993797086004662, -0.24247170420758263, 0.5038146684787627, 0.3596928625927865, 0.632515581230333, 0.6617916968674838, 0.4290938428705823, -1.38896827420892, -0.4775233626446387, 1.0452177524980653, 0.6073645614699852, -0.5051812395566743, -0.058028747636743504, -0.1431276463973242, 0.7728209319803953, 0.7173889665410418, 0.6045175492161644, 0.41620321761019147, -0.017635160359888893, 0.5857066885590259, -0.00038470879590721783, 0.27127982766595166, 0.5751944604234448, -0.11387928018187336, -1.2188292021453662, -0.6225704700295343, -0.5084286462145038, 1.1651970117503392, -0.40286020651372184, 0.9486445960837769, 0.0618070221352297, 0.3247381980884366, -0.9830275044747524, 0.7623694212497606, -1.1924676612049065, 0.8189475676211171, -0.31230068479447104, -0.960121146790347, -0.5453362296091594, 0.7634792689721279, 0.018097579754737067, -0.776040194615419, -0.3255661075452887, 0.5848959186355799, 0.6998295591556503, 0.2569661418376917, 0.4631607603292111},
    {0.9877546804405026, 0.46554424958544804, 0.8916369813615568, 0.7855182895306372, 0.8418080816763461, -0.3063099806313822, -0.5524606394060384, -0.09487886531614312, -0.7002904003718532, 0.9315486263493494, 0.9359758148468029, -0.8273797048621586, 0.7998391334231922, 0.05506284190966229, 0.0010168641203819417, -0.8288714698038655, -1.3115875512195336, -0.9184135649639585, 0.36847381476398466, 0.2770472594817359, 0.45139844345268326, 1.0589485569165105, -0.8069270995509034, -0.5102054001162494, -0.12506070684686038, -0.37570641979529057, 0.03735544025811815, -0.8183135657409877, 1.013376612362188, 1.2841297059206758, -0.019787338282482064, 0.041706629568430985, -0.8737813249194328, 0.7788230743343051, -0.6536281735949186, -0.4855789119739694, 0.35029055085104666, 0.07074084131840197, -0.6600808060492478, -0.49847259760006835, 0.23286370394833392, -0.08029047054108779, 0.13939410624859264, 0.49502337909733046, 0.6117392848426604, -0.04100371681582948, -0.4117079259829806, -0.992889634522131, -0.2295824487889914, -0.6094471401169355, 0.9927352544519913, -0.4069050566416064, -0.8849842663789785, -0.38435746230107104, -0.8973608795037274, -0.6868245452432912, 0.65681702231458, 1.0771892616405823, -1.3634697070420767, -0.14768770577696325, -0.047459536725911536, 0.7479434014551426, 0.29769803362651354, -0.44790862749889143},
    {-0.2335887674447901, -0.3867713598115, 0.7728454973824563, 0.5310767726404921, 1.0456695979308361, 0.9176627195465324, -0.3810353281201662, 0.42013503569146254, 0.6020186876508296, 0.3553501951990289, 0.0393762921353268, -0.48777071420965656, -0.23361974316651682, -1.2741032502967586, -0.46893183828620505, 0.834881066500295, -0.7433422619522859, -0.9926778244909436, 0.6899271254113253, -0.829054236737362, -0.47928341118398426, -0.32746874594252223, -0.28905185579955406, -0.39728185193507115, -0.0025205489421957065, -0.8420714081401125, -0.9048259864074674, -0.8057351661425078, 1.0691587873850867, -0.649709414848846, -0.7129653805837869, 0.26976200668001404, -0.6623631662893356, -1.0873773031061003, 0.1761042827201786, 0.26914971555309647, 0.9304005900062372, 0.09067662392923036, -1.4462355824571898, -0.3561125946052196, 0.9120182164736562, 0.8265824543298541, -0.016710880145352616, -0.34447650408765046, 0.8765155392767802, 0.43757862464897684, -0.20830285184380776, -0.10129374370351556, 0.41218951100179607, -1.5722976282075862, 0.24590937176539152, 0.5127701822653437, -1.1841913166521745, -1.1226010176762922, 0.5456108633066592, 0.1358325827700623, 0.8941884721673429, -0.07190643687565344, 0.33353589887260804, -1.2274891932081997, 0.3745887946844559, -0.6069349779662971, -0.6809487040898503, -0.625980032128626},
    {0.2570270626381808, 0.22692246760311924, -0.47218064613632954, 0.35309818753200384, 0.5116644217386654, -0.7081680387737822, -0.8094404311857752, 0.0977622573884702, 0.3981880539320707, -0.11663603606605162, -0.4745986408360591, 0.5835227376227871, -0.9347567165894364, -1.7295064098564228, -0.07210078063655942, -0.6282702372525085, -1.4375710539329825, -1.2101927204506415, 0.014606243930520657, 0.849554265330389, 0.7011702516696908, 0.7990126597428897, 0.44615489017500704, -0.20254731214732116, -0.5281091957178317, -1.0439583146118612, -0.5607968399465217, 0.8336200580315195, -0.4592221830985154, -0.08129532545078777, 0.6909822259095323, -0.30767839030904753, -0.21455503658205471, 0.6079763786769877, 0.5652957123591862, -0.781298311815038, 0.3779027834691389, -0.5960487533116138, -1.0616396990022368, -1.2920830082559456, 0.3481794494106983, -0.4019400517827692, 0.77352334363082, 0.5683749662973756, 0.20240857512027474, 0.3786505878941463, -0.4346290818154163, 0.12001804646922219, -0.3631243516077967, -0.9198724390380714, 0.23921231541776258, 0.3405216949775328, 0.799751928680143, 0.13641220499649917, 0.6984643481126654, -0.4864387584031874, -1.0531591183338291, -0.2614371759832769, -1.5308037759468325, 0.24012731890235742, -0.9522381728058582, -0.03581118583009699, 1.248533136254574, 0.25473236492410556},
    {-0.6658717797526753, -0.7908042686912098, 1.001875688748698, -0.19111723191611296, 0.5989448861397235, -0.4764710038214627, 0.8972618254662068, -0.2841421860923409, 0.9546365698055314, -0.6110566741216301, -0.36466674391649256, -0.8011201852745259, -0.8083004770446718, -0.5535203793862276, 0.17489788054461103, -0.48343499790251215, -0.25047754875891876, 0.08250690027089223, 0.7949337608767505, 0.5373215221827431, 0.21912590089001, -0.1921398103465685, -0.9312329276797486, 0.3472779759128888, -0.9519338802146081, 0.3937544139434778, -0.27765131632261547, -0.7421319947417909, 0.23190420569747586, 0.679684428722355, -0.2714119954291286, -0.7086522593585843, -0.8038894759588575, 0.2253222025636709, 0.8718046215251974, -0.5873277840303668, -0.9749798392265292, 0.8550106459875321, -0.1477299619761427, -0.3538166348581983, -0.358119102995886, -0.6720046677829302, 0.23947597283415342, -0.5722734986432036, -0.640524769496256, 0.7297958972460337, 0.8817629839007227, 0.29733664792523107, 0.16385532506489284, -0.38814951527992814, -0.28905632473737924, -0.16651204725387084, -0.9064025965566841, -1.5094281234789868, -0.9546453874031526, -0.9567358660882795, 0.41616022562110416, 1.198194661867412, -0.208433858785621, 0.23394375586799473, -0.1931296313265864, -0.11424114477727437, 1.2082007276871454, -0.7543923611810169},
    {-0.16897950337340872, -0.9050885097863757, -1.0534432106119789, 0.20621784170651222, 0.8669817566754559, 0.6797245882933881, -1.0825982813952195, -0.9369621822835374, -0.4598752894921595, 1.2032567211884455, 1.364049832605664, -0.8831802452853801, -1.2121759884894912, -1.4409938585520303, 0.6637395212106441, -0.11185833896808114, -0.5305927740813108, -0.04718839305036045, -0.0683847746340255, -0.1716184511322868, 0.694160547356818, 0.6179722215054231, -0.2424688287828103, -0.5646278640494634, -1.1013126399773923, 0.290670334384816, 0.6919861391110266, -0.5220746146231497, 0.3715389645331946, 1.6594670107435354, 0.34234639579902276, 0.10402327252712135, 0.3907053968917638, -0.9993668522564066, -0.6427674952983823, 0.19046934578859734, 0.8206678937907935, 0.01567981929827222, -0.8130141910295504, -0.022661919716833193, 0.8271775162998178, 0.4324779983238258, -0.8666864308625756, -0.9997358674790496, 0.7052636402935478, -0.6212277769727191, -0.8115470711948174, -1.3191436885482577, 0.5234336554104501, -1.3367920016797914, -0.15418938937658158, 0.17872352402541175, -0.9055203943442636, -1.2279334809606968, 0.6386597554101849, 0.922822374001501, -0.02192166316437738, 1.3206109839881983, -0.8311252158974245, 0.4173233979223054, 0.35128718813182896, -0.23660958371965968, 0.3623232761403891, -0.07408764614480289},
    {0.408595408997596, -1.4673621348448345, 0.14797637757992857, -0.15633682145141292, -0.626112963468319, 1.137522081067193, -1.0020096633988584, 0.3146804588703093, 0.6159213272648106, 1.1645510257973368, 0.7936903292205659, 0.8459723135181634, -0.45818077704205046, -0.6005823644398961, 0.24756177031876728, 0.399582739317237, -0.676346630575173, -0.6467555210429972, 0.28620618810665743, -0.10113857074532466, -0.7731413622916371, 0.25951110429056345, 0.6266697459910764, -0.5425567145788948, -1.2033350592268053, -0.8808308727592595, -0.22808568426848244, -0.5546486149748348, 0.7315050770363261, 0.40971563406063666, 0.6279819731718982, -0.32784917121559787, 1.0422257366312448, 0.3740536083710201, 0.6195436141691881, -0.2965768486305218, 0.21361999047436728, 0.37439094248010507, -1.1170791758091616, -1.1396959111323075, 0.569109326811987, 0.5488990174497264, 0.5013643223732102, 0.8052377897046087, 1.353441903874854, -0.44965034739977316, 0.36266672681974904, -0.9654737220682815, 0.1568541582695321, -1.2122887778763642, -0.2319523986049865, 0.6033186683983274, 0.37990234665129347, -1.4404270576251823, 0.17115032498666347, 0.9324511476377739, -0.43993153372011745, 0.7146147084632587, -0.08777596684714925, 0.850567289317245, 0.33367648901560526, -0.22975212584352436, 0.8880855121021445, -0.06770093702522897},
    {0.6031641903218657, -1.4586296256814815, 0.10524747178674028, -0.08664063925155072, -0.15098718696940056, 0.6275226320867137, 0.7283378315226963, -1.1364658929399682, -0.2964744582221698, 0.297854366622646, -0.5034221014172493, 1.0532290310809753, -1.1077505160542345, -0.8021258477091718, 0.5847450706185494, -1.0785272202349376, 0.20278420137548053, 7.563345706637223e-05, 0.6701690861286362, 0.6225089856759228, -0.18796964117075926, -0.2049696480376937, -0.9103151161875488, -1.0619278878758571, -0.3241004016512569, 0.736149172183424, -0.4890539409554065, -1.1379668761914594, 0.5847292966853012, 0.20576090564877386, -0.8597517115542119, -0.15369117182201072, -0.7905950874364258, -0.8698143359670492, -0.7795532858318219, 0.708758688788553, -0.10001849588104297, -1.0274913282392217, -0.5917601189391624, -0.5026483132858355, 0.1447932613722156, 0.27727069688710004, -0.7673970697179939, -0.873757750930368, 1.1813480176997184, -0.6480806261516775, -0.7795957049424015, -1.3044498658206194, 0.42304562298368686, 0.11658830818792512, -0.27628588377849655, 0.5009951933698545, -0.5829152594777008, -0.848495984294036, -0.7403183411335249, -0.09444162611980723, -0.5715496177087881, 0.2820208035577143, -0.9170464578984616, 0.2140140550267822, 0.09608022761640513, -0.5877589433401729, 0.07644262897276018, 0.09813508736286013},
    {-0.7931832890219366, -0.6722150713955335, 0.7697796773031605, -0.03737858801709285, 1.0939907210096378, 0.6387693536463309, -0.7861412849485455, -1.4185419178983132, 0.9501193506356083, 1.0449072536596276, 0.5323757026004539, 0.1998433105090137, -0.36405475129865655, 0.02215038703982093, 0.49051069931422514, 0.3173993792902874, -1.4462101165809107, -0.3300062408697744, -0.4342259934811091, 0.16114361653194922, 0.8609963989200604, -1.0452769595074964, -0.005131582517907835, -0.9102664451845658, -1.7397853306811326, -0.9305712997983038, -0.07530368608023351, 0.193453988529942, 0.2347795002364038, 0.3114620201864756, 0.6006380017620438, -0.7019235639426082, -0.04380507942470101, -0.9596236206426324, 0.8740085666408113, 0.48136620845764144, -0.45081808639258414, -0.0018923819175878207, -0.5505577318171244, -0.7780954293048831, -0.7510939541818462, 0.36807935174273104, -1.1781999278438127, 0.49032470638283904, 1.190151060733433, 0.09108354108549775, -0.21595911805503992, -0.4944459233967669, 0.8623501481214457, -1.5238825335780228, -0.5672507117437848, 0.31768188521942065, 0.25071695965695223, -0.44598381124102215, -1.2070839040685868, -0.9819082299831609, 0.33490132635251557, 1.0282029316441905, -1.2553087426495444, 0.9097352743488916, 0.42028827038221955, 0.6282871841990475, 1.2818675588430481, -0.5921771839363448},
    {0.22923299662328148, -0.5226297278452599, 0.48206617847523014, -0.5211048856659266, 0.31509538985569535, 0.7152421442639009, -0.9567917109863717, -1.0682528185121984, -0.401780701001122, 1.0888673586951083, -0.809077822310688, -0.27210662017816256, -1.2382815029216687, -1.7433512581297939, 0.9337163408795648, 0.21302903302393325, -0.10169461715683696, 0.8073073425792646, 0.7294994017613704, -0.5814977209827209, -0.29438736295901374, -0.8340077880411528, -0.549989266207848, 0.6862872022426233, -1.604565802423449, -0.7776235275232009, -0.3258347666403664, -0.9449630483171929, 1.0456439244067868, -0.15343111194658643, -0.02488932811959732, -1.1721427137985223, 0.7763871721124317, -0.13332311311742362, -0.5137181170248704, 0.9791878391326911, -0.9680538839294826, -1.2419608837588851, 0.4470989320455418, -1.2786789918925896, -1.151895599481426, 0.3582972472049783, -0.3953227941433996, -1.007699600508282, 0.2752723933039385, -0.14456269938148594, 0.3980482543369103, -0.9102408021899852, -0.81690868165248, -1.3163012399276828, 0.9089750014498698, 0.2090519894917515, 0.777943479141222, -0.21111767743680063, 0.6018247885769948, -0.5542183404879062, -1.0027235482330166, -0.26995026715216547, 0.11773637552220123, -0.7672820848454356, -0.6255067807674609, -0.2957197962435842, 1.2768089988347877, 0.5277272328627668},
    {0.2592573193106891, -0.6079755482644539, -0.6642216801650479, -0.0332403324202284, 1.252386267162364, 0.8174526137960276, -0.13157703243628188, -0.9309782545362558, 1.0553407077648098, 1.2007363859351425, 0.5520580454214544, 1.1697689318916678, -1.0099320983678155, -0.9082936049702626, 1.1932631388420931, -0.6831364579735704, -1.3346820429926072, 0.04635422491867495, 0.29064326433676174, 0.7120532257630382, 0.6911259492953642, -0.15104481135492773, 0.5968223966195326, -0.38072229865733087, -1.2862098074002493, -0.44137004995434687, 0.41950288862089946, 0.038185848107765874, 0.3131359872626988, -0.2570393941049377, 0.3536226625408494, 0.48482506390725494, -0.4864055683060409, 0.11711551861500312, -0.4053588492042909, -0.41885870839414113, -0.6942982025839405, 0.24753528916065187, 0.28560892999684834, -0.48756274991527926, -0.40476341121179543, -0.36344695525098236, -1.3057522521046456, -0.30380015435464097, -0.12878196004921683, -0.5827669133749044, 0.4457322634222721, -0.9075697207595695, -0.03061395971137702, -1.4663334813485471, 0.6223032941120529, -0.49907641055689284, -0.26152444245607415, -1.074023544073664, -0.770444372846336, 0.509077393115045, -0.0697013106553466, -0.22605722437106024, -1.6244417873050694, -0.9663517950132295, 0.5377697285800423, 0.2120281651191426, 1.4828732621116287, 0.002233368035084961},
    {-0.731291175022014, -1.084408690082472, 0.45323405127010347, -0.69562545171529, -0.25370247855232264, -0.22715971340465566, -0.9164421580847089, -1.6035215763671775, 0.3272345158465126, -0.26994276390500577, 1.2656417747412405, -0.7419866841986432, -0.5218681490509247, -0.9654185077114149, -0.04905098338187764, 0.03846206831647716, -0.8109289720428066, -0.2052358708058204, 0.883602231966237, 0.5350686139499256, -1.076129831643122, 0.8364361039881527, -0.8350614126656517, 0.4463002888333081, -0.03856852538467932, -0.2677475586330896, 0.8032767672493208, -0.003832811043439935, -0.40757317484323, 0.75462874975769, 0.009491003041583405, -1.0257154737691376, 0.336710258079794, -0.8788039699966679, 0.7027787433668247, 1.024866808970009, 0.19030653765797811, -0.9048038488510731, -0.6747686802337647, -0.6751410704257732, 0.4264500359780199, -0.8595208245591651, -0.40607275810294036, -0.9012452355333128, -0.04203100691610092, 0.5775631456993715, 0.8676836479067209, -0.5338779536543703, -0.3914445117802378, -1.5639160636943925, 0.7603233250632735, -1.0595442446535026, -0.6458774813836072, -0.5343766956376503, -1.1040352497394266, 0.9568545296275605, 0.33777566425728195, 1.4965229931836825, -0.5933998183436459, 0.5165504636180868, 0.39382533856595275, 1.260200490522628, -0.19513874854333277, 0.4889215231853261},
    {-0.41730831262592344, -0.6431693710242863, -0.5619354242867343, 0.13689813373096651, 0.9501855081129098, 1.220789787075528, 0.35132691773697033, -1.3643609472485734, -0.7946855330757346, 1.3107260526220061, 1.0010597055345403, 0.5289997643586326, 0.12657911793091564, -1.7497827868991143, 0.9546906899857793, -1.0503217932644928, -1.1790918092099094, 0.10111392523373931, 0.2339730527205229, -0.5541296587262139, -1.187159705307583, 0.46447122302272853, 0.6548013232584451, -0.7709053320625506, -1.7982836766057377, -0.13195576859359842, -0.2954291064842686, 0.5064228461125346, -0.13565836500719455, 1.256282477350964, 0.3191878429484959, 0.04954237484489086, 0.5459299788257895, 0.6412867559456537, 0.1983087317640983, 0.8761499816874506, 0.83534084065051, -0.9555791912562459, -0.4544594828168944, 0.4098833455931527, -0.30599507304243195, -0.16748579035848032, 0.5879723522683838, -0.8924828233572601, 0.44029865491013465, 0.08878437799506031, -0.41054404103856024, -0.7748248862237151, 0.816959630871735, -0.232712652128327, -0.7620979288089235, 0.6756130522336569, 0.04404042355655156, -1.2382935944458675, 0.4504431814493185, 0.1493977211249608, -0.8184047291000455, 1.201715156321001, -0.5234342915131754, 0.015965491404898096, 0.9497720448525623, 0.644609134152514, -0.2967301954840024, -1.1071305574510724}
};

static const float b1[64] = {1.2048175399452752, 1.2652052909513303, 1.3000017579386256, 0.9490840030387763, 1.2406405468069535, 1.3802608879654192, 1.1566113007901009, 1.2418488382236488, 0.7973021155394961, 0.8693707985874309, 0.9502714525746961, 1.091087169143344, 1.0932662567553215, 1.4329218355058329, 1.3285020673995678, 1.1932575990214505, 1.5527158256036644, 1.33724005503288, 0.9439111999481962, 1.2196006171841338, 1.3689651621962693, 1.179937987295005, 1.440944799604638, 0.9848061284175427, 1.374208903697272, 1.0263085384126527, 0.3890839657968706, 0.7648131622665187, 0.7713430544004372, 1.5097565448648564, 1.31869128309746, 0.956386413651124, 0.5818365159693838, 1.0989509986230475, 1.1157618858695626, 1.414679777444847, 1.3041347017539309, 1.1619894351710771, 1.0723283316650285, 1.1491708095344229, 1.1390632284110183, 1.4368114261031084, 1.4010196154153731, 1.2460246647226065, 0.6415336717406283, 1.4189249276422502, 1.1641815668478874, 1.2875648374186242, 1.3780138234907906, 1.39399892321566, 1.2851554050760305, 1.3699274356530156, 1.4629314612738922, 1.1077422236137673, 0.8682599415042753, 1.3172677190368467, 1.419523436126885, 1.3563126476146206, 1.4328734384410904, 1.2391215889638056, 1.0059070123480038, 1.0550937007404202, 0.9606879195164206, 1.4944449603886665};

static const float w2[64][32] = {
    {1.3387072347792301, 1.6491794886761681, 0.06141597184869658, 0.7738939499831168, 1.427589639851035, 0.3779323610596277, 0.7374761959991885, 0.07067277712701879, 0.720904537980861, -0.3043200256523067, 1.633817323202232, 1.2908316621074516, 1.6622022633877354, 1.6150820180527794, 0.3544837016104855, 0.6866332381311666, -0.3316940321376523, -0.06807083658954077, 0.6769214243627116, 0.39525399205701994, 1.6068520688350316, 1.0268637624071604, 0.6387343267564359, 0.7552701389533834, -0.6159070768430809, -0.2989480390408046, 1.6865170486835093, 0.2007858631386178, 1.7291636795801582, 0.574307243481629, -0.35619304288656717, 0.5700845462567821},
    {2.1275783094892238, 0.8019715176257817, 1.3801113985262838, 0.24300643321077778, 1.0005984826986958, -0.06905523358978495, 1.0501232363209068, -0.4423702932327869, -1.0624777908811058, 0.311678128862045, 1.3353620834361288, 1.165169870246618, 0.7299371730974575, 1.3487633810447326, 0.7759302487814723, 0.8785519889178612, -0.2975109135187278, -0.8829180455919035, 1.9295631367608124, -0.4293945789042746, 1.1797007654679796, 1.031040703868733, 1.865794351089266, 1.6432623835381128, -0.8531737720837265, -0.7186361496453126, 0.8788644966548927, 0.27418570712278667, 0.7070046837634005, -0.02797602644744259, -1.0998301729339284, 0.6526735530046381},
    {1.2556385322955241, 1.1827651164725164, 1.3228725003448512, 0.9668945653794472, 0.4366059807871473, -0.7105029146794251, 0.13669689987910605, -0.9168436312700095, -0.390560820212486, -0.25360804074236626, 0.9639334583809959, 0.3277687984992386, 1.4442675255736637, 0.5513456797774918, 2.0251994343549033, -0.32728801202130686, -0.4452758559324693, 0.47022861762738655, 0.3668287493890319, 0.15152002837405087, 1.2797993389443711, 1.644111424601417, 0.23797867142546866, 1.7064081800366202, -0.27772807939034483, -0.7442577726769495, 0.1604593589271128, -0.019367616334442974, 1.0144028459291137, 1.1989557812564962, -0.142071490696076, -0.3525166541303861},
    {0.9802292310394828, -0.1630125551576438, 0.07544368271086213, 0.40738744148863093, 1.0661459448277935, -0.2613191991572046, 0.8306300294996168, -0.27564552585013224, 0.7710141934033324, -0.32962219458334135, 1.2575019779919139, 0.7881165184792914, 1.7154328512037773, 1.6062088287935217, 0.08264530555644815, -0.5441392437882625, -0.7939511005752761, -0.7818673110199094, 0.13484348157723114, -0.14147310015886125, 1.3111347556296882, 0.3699070993443883, 0.84588481809144, 0.6779508184335986, -0.4928122319052452, 0.12478704136133642, 0.7586258368796873, 0.5169733332269753, 1.149059293287814, 0.9811129606006588, -0.23151581574335328, -1.0456452003351049},
    {1.3554098540933948, 0.07847390088413041, 0.6986906824430476, 1.8105905874299373, 0.9541534327957295, 0.277715586517471, 0.918497090533462, -0.48996464589109595, 0.2813610745479729, 0.5246910435447159, 1.3280711698921788, 1.3490388946801808, 1.8919623288900105, 1.622174760407487, 1.7673233436196476, 0.9217922014253147, -0.042769230049593245, -0.8695313137722349, 0.8981018283746179, 0.31069443346776193, 1.0508362828758269, 0.570824192536226, 0.7894894198413374, 0.4434845945193914, -0.6138782969925175, 0.7150402883010107, 0.7675113491555416, 0.7125276027986723, 1.1015980094381874, 0.2022215913776009, 0.1400766729656756, -0.8377387011184146},
    {1.000800681494343, 0.17620604856948027, 0.9610147797187673, 1.7055058205195057, 1.3270311848606144, -0.787877368299307, 0.20666944000422915, -0.2065496310601604, -0.921396376389111, -0.4471603371037421, 1.1254142022149316, 0.9495314666276828, 0.4594640061234625, 0.057379678488307696, 1.3163892195057316, 0.03138842772434777, -1.013451941304694, 0.22312181215425417, 1.2828055709037143, 0.15160279360311438, 0.5059359050307469, 0.22346459887096876, 0.28175471589669887, 0.9125109644220819, -0.9957220244568292, 0.5140277663775065, 2.0522305607205875, 0.2980537160612568, 0.2333515014218828, -0.5113116054286804, -0.7160081385636436, -0.9282286759295081},
    {1.8366368119695116, 1.611462335984649, 0.9160101323310844, 1.46464054509276, 0.24214961923916525, -0.5090886203200771, 1.4688266893580402, -0.5959792603933458, 0.5409096636659023, 0.003502726739008255, 0.3009187606218227, 1.3958758463601222, 0.22020767250174997, 0.2632202383857187, 0.17650593917460472, 1.2396840652713765, 0.02461387765268755, -0.6057369380490555, 1.375172444360536, 0.0352806836560909, 0.054694843903964056, 1.6365957307571724, 1.181247663168347, 1.2515383778538034, -0.6598858868597414, 0.7654548376022274, 0.9170666396914371, -0.4567094762743357, 0.4281513099092282, 0.300685502415523, -0.6042674980597468, -0.037918259408561396},
    {1.8592380203160213, 0.9866413286862601, 1.0374548876389704, 1.8472117170593156, -0.009009471815721324, 0.45211950701860026, 1.5332982074243786, 0.3200374458574553, 0.427309975885777, -0.3415185627630146, 1.2748475034259146, 1.0081290431761492, 0.43155585295958515, 0.6790749577148608, 1.3238429388688542, 1.2086421917814543, 0.08563611168589255, 0.5371400253654424, 1.8367278048339037, -0.42625961193658807, 0.1996699992193391, 0.142568181514893, 1.7749759513879944, 0.001304145312754418, 0.23314637535381344, -0.025792785319516568, 0.2727857261286874, 0.30244851323863775, 1.3625758793388005, 1.197936654053847, 0.7745466361000638, -0.694687855030416},
    {0.3502101718557654, -0.09275412573868647, 1.062823565062582, 1.6885233241572817, 1.095770947405481, 0.7522736831246231, 0.2563325289931066, 0.5623122515691518, 0.007636009248754438, -1.0076732386492477, 0.06305538844213865, 1.5647460353135048, 0.02484215195447509, 1.2653874098325502, 1.4428056485981722, -0.01692315990907914, 0.12958174153205015, -0.5104558639756639, 0.5826783764972211, -0.402299463640624, 1.0973585336408678, 0.39807722820987934, -0.0926371091971283, 1.088551302763778, 0.1525667127223308, -0.5261078750522551, 1.0849536786025102, 0.8688738974592518, 0.9576159804581236, 0.6876401352661802, -0.1440611684149201, 0.7108099853192501},
    {1.3703886400404817, 1.2753538440116843, 0.3573602668685787, 0.9850193762949567, 0.22580306080863363, -0.6927072113092171, 0.36202255514072595, 0.6589017963687861, -0.09367992313532772, 0.3523176898536479, 1.0730204394001777, 0.9452168656523923, 1.6694515714435127, 0.08744618323712791, 0.49172856931643066, -0.301736844569409, 0.740286801268426, -0.8924672805235921, 0.8187990572175525, -1.0043060327474989, 0.060899379000530836, 1.2398419072773679, 0.146262895234648, 0.10783014107495596, 0.626870787843421, -0.531174144908712, 0.7134915675859108, 0.18079967472716663, 0.11927845817554786, 0.9896434132828877, 0.1744944774817312, -0.7849084530058881},
    {0.4763065159777308, 1.3883370561648012, 1.1558317598607395, 0.24938368584031856, 0.05965937893598501, 0.056921660261724634, 1.1670917148103208, -0.10850574141266156, -1.0757866952351807, 0.586107377844378, 0.4007580854928074, 0.32973094459367863, 1.163051592382994, 1.3508115862306525, 0.7245197166823155, -0.15527293457537963, 0.6461307831925683, -0.8640742675939058, 1.1112538886848677, 0.13159173214967884, 0.06881023140575268, 1.5953761130497353, -0.05178603639452056, 0.026676104833511897, -0.692330095905759, -0.9000025942623261, 1.3608530735361262, -0.3321365920954056, 1.9421070559155813, 0.4348623057597896, 0.47290483367037717, -0.48630080394060254},
    {0.05216730638652076, -0.16805366385880255, 1.6440995260689675, 0.7214574080272197, 1.183823849131875, 0.421874496857548, 0.12228612894423829, -0.4027116884408015, -0.6312523207409547, 0.6695309173706178, 0.5234799007459853, 0.9803202180389688, 1.0734471079598074, 1.2739797107541349, 0.5766806359349447, 0.3599593526508294, 0.06208566074527908, -0.5120775546029734, 1.5179417337952563, -0.9824416032756456, 0.9563724943995116, 0.631252406533983, 1.1199566259503937, 1.3619383214862, -0.27645581465734337, -0.6002991004223103, 1.3846455255400854, -0.9304817466561339, 1.3530377557689082, 0.14341943537986004, 0.0822311230483026, -0.3453270713851719},
    {1.3993803315752085, 1.799518581004878, 1.4705664502672278, 0.5149947614449912, 1.8234669763704585, 0.35382122898992857, 1.6774810469753922, -0.05622948459418594, 0.41600346726099324, -0.5273497080615718, 0.31231177809678295, 0.834560643011622, 0.7491401544368754, 1.8016658775106194, 0.43618091233192435, 1.0496216203218196, 0.1949296878008986, -0.7048810503089297, 0.8369628266943409, -0.3445072080305102, 0.904330618251262, 0.47630832610605706, 0.42459773156582586, 0.2729551921254819, 0.23063852177688335, -0.6538289147001998, 0.3114382220609247, -0.3412560268587967, 0.6819044221227332, -0.5259064715022096, -0.6582056907427402, -0.5563030716370161},
    {0.5845098985426511, 0.9644056813306425, 0.5155103833534638, 2.2163538498628905, 1.8301489576763765, -0.3204641199350258, 0.32877665638165515, -0.40313452469152844, -0.14236058669098142, -0.2909764041537199, 0.3851752315299041, 1.025022046732795, 1.687225065666158, 1.9802330297211426, 1.3038379847676638, -0.011924516894590674, -0.41503093474521546, -1.052712705133809, 1.3890429018524835, 0.17657713670807323, 0.592850925912345, 1.5022772117434362, 0.28831191333775863, 1.3197100558961588, 0.05880340800885693, -0.6948003097627625, 2.138687736437891, -0.7146286976879057, 1.535142966345156, 1.275378165448934, -0.9976469294369056, -0.15532451874489747},
    {0.8994607898768642, 0.5520406077901321, 1.1069147192837283, 1.8422421285658126, 1.382898229795575, 0.7855435142804519, 0.7514363961347603, -0.613066510608943, -0.8862224985946868, 0.3986583836526235, 0.6134953529466091, 0.009144963889545176, 0.6105314562435393, 1.8405815347789616, 0.5429231058493911, -0.48841225060725957, -0.34006576109156395, -0.01493301643236637, 1.9458744505942924, 0.3077982461503231, 1.0371426980004732, 0.41924612495021035, 1.2869382813442456, 1.4269347607976341, -0.9778507867866421, -0.4283755720342365, 1.8136048249191878, 0.7433880230772548, 1.8857855304609752, -0.15587606337001467, -0.23511283075826214, 0.19733950716605406},
    {2.0756094187855054, 1.781886147050095, 1.3470186978906524, 0.8117362897769219, 1.5861311162892784, -0.1942554808108614, 0.5590251835045899, -0.662762088708427, 0.7214583576650998, 0.7450453769508837, 1.9951917065057225, 1.204295565833175, 1.7122748200969617, 1.6975095770720017, 1.136071192906341, 0.042518823796618394, -0.2752493347425799, 0.6158594525887608, 0.8359858191216403, 0.17554539046201817, 1.6494400856415017, 0.23257848834474007, 0.9635755041224213, 0.9388595495056525, -0.9105662879569046, -0.4462194331252882, 0.8250255411677258, -0.9020065283896488, 0.9834970312674526, 0.8994139431967454, -0.8073044282985369, -0.8812383646532052},
    {1.4463025168311154, 0.8132812349956992, 0.6794091743531019, 1.6341885745120077, 1.4567967615521278, -1.1022819229548306, 1.3113316523597507, -0.11641236883677708, -0.9842828516989973, 0.4883736459552229, 1.5549645158897358, 0.20085445351336242, 1.752201504366632, 1.3276414811988582, 1.4983061559883397, -0.3375344121372922, 0.09539265031868108, 0.527560515671051, 1.2538237212276728, -0.5979891026814754, 0.1094725373564618, 1.210797688900433, 1.156320832197447, 0.48926434609080893, -0.4962781107695072, -0.7471610338182041, 1.354949189991982, -0.5645277618858763, 1.1778147316882688, 0.36160020146583804, -0.5822889222518214, -0.5726208458077249},
    {1.1080689330012536, 1.4293163047309925, 1.5560909045793345, 1.949573685910185, 0.7229906986990563, 0.3304395931209411, 1.1010663757125707, -0.12172190519214073, -0.9435641886467513, -0.24663156736654832, 0.5253729628187088, 1.1516204097790619, 1.6332914639032428, 0.8081945265824517, 1.7902756320476627, 0.39032288314527425, 0.5149264677090754, -0.9175798873801387, 1.137459385977381, 0.5222123213160416, -0.11944482099570893, 0.40705878485034724, 0.16086557574663804, 0.8333213730268315, -0.007412702407101334, -0.6942575437691105, 1.7417776797548372, 0.06647786279770011, 1.3460614156570974, 0.18908202297946117, 0.5853211446121012, 0.6220298401678226},
    {0.6699572386796255, 0.6621231414607949, 0.26888214345043215, 0.47125798746964953, 1.446486733296557, -0.7398684526885123, 0.5539931626759, 0.544329864575197, 0.6633696082754251, 0.5030282443098875, 0.6079228147762578, 0.7704569221070074, 1.4243820028999121, 1.2306387266460153, 0.6459512424280551, -0.2959490109389443, 0.23812206690390147, -0.812389068555098, 0.7960890076854319, -0.10265286746439946, 0.701656288425946, 1.4495668276959597, 1.588859887859893, 0.6474913935331539, 0.2755075160958279, -0.08186030735556626, 1.6925759826422586, 0.4124706320470941, 1.0976196831109855, 0.22707018946879112, 0.34813932288359506, 0.06521953929699986},
    {1.197185100659383, 0.9407985839843698, 0.9176370053409609, 1.8914130708819168, 0.9024813592879007, 0.4892693107036557, 0.2313373044479183, 0.5463608755384415, 0.2232167999415641, 0.26677152561956197, 1.7692479265954495, 1.5797626724023255, 0.13053360426328314, 0.8995220139471571, 1.5276237937436354, -0.37634618037302375, -0.16817482033450265, -0.7778415099033098, 1.1172832649724875, -0.05418120015241951, -0.13387929844228863, 0.884424058395555, 0.3308341995665795, 0.3839860131496913, 0.4013330110355797, -0.2943500769085901, 1.9007849318115324, -0.9750181462433318, 0.6951532882442971, -0.36377316316137154, -1.1778581252457048, 0.5559602346254201},
    {0.7753177325113224, 1.8014880688803026, 0.21646027545594695, 1.1083326412091987, 1.7167565451821414, -0.006314365787999881, 0.2451850705869424, 0.8032394468996557, 0.005221285423847747, -0.6562736566861795, 1.5472802755037323, 1.3885236640918126, 0.8374927751776697, 1.2325730187538124, 0.5867106654306055, 0.981999885065724, 0.19578674591488004, 0.4111374890014026, 1.8355305518270437, 0.4993008824551933, 0.3097728598870053, 0.5979792085934849, 0.757313321614003, 0.719942933706081, 0.6094328501546149, -0.341794484085743, 1.6286237763146643, -0.8069819092547652, 1.7223161244964627, -0.5768047798420836, -1.0708456720623045, -0.6958911441695098},
    {1.0034243172713342, 1.0750290830695586, 0.46480066238333384, 0.8480089021688633, 1.7398013339436422, 0.4378133683580985, 1.633285038512097, -0.36908725789889285, 0.7854366657298903, -0.5616739681875919, 1.703866058020028, 1.6464331851868257, 0.30451514156387344, 1.134405236487463, 1.049499797325916, 0.4878739137930751, 0.48689874823892454, -0.2530700313443128, 1.1293605812423368, -0.10414498328374419, 0.8584260199891202, 1.139809754775956, 0.839454659465015, 0.6931198997912338, -0.6467962573820343, -0.015340182284266639, 0.8405166005561369, -0.4646423070724706, 1.3680244726822266, 0.5116253670965546, -0.8556267432856077, -0.8091547390012346},
    {1.7004558285409817, 1.688460300397203, 0.9142336819252014, 1.0372800578822907, 0.9514018358381499, -0.439723753764199, 1.8358657466476562, 0.314535140727728, -0.2415486986225277, 0.389626630239673, 1.3656578498170922, 0.5895678531413618, 1.3173164548022447, 1.2798338438244246, 1.6385791911193952, -0.43781752301712046, -0.10352545031068454, -0.17011859420578596, 2.0319647026662544, -0.16344788596528395, 1.243234480527583, 1.2343888179890292, 1.244644419762688, 1.3033951568692765, 0.5963935545210618, 0.17090335874783708, 0.23799799798950422, -0.5479119227021759, 2.1499816417493935, 0.05262932168792309, 0.27792680472859743, -0.933778177620866},
    {0.44220447507480015, 0.2699016996157978, 0.3420954243540639, 1.2716009158888566, 0.8502427533145133, 0.8901291348022843, 0.9921460083220144, -0.1709004511447033, -0.5119337828984453, -0.6209875041788803, 1.278940359016349, 0.9643366660032517, 1.4597429294297735, 1.0047665967107864, 0.4567317668411642, 0.8409292173012178, -0.6580415487570233, 0.8094303610426078, 0.11250678908589315, 0.776034920702845, 1.306632264298581, 1.3254657180915863, 0.22228322588397317, 1.2705592964545955, -0.3221704493846842, -0.6662344725986717, 0.8912161558615753, 0.32565930265067555, 1.2858401274950342, 0.6505300853414533, -0.7057832209883238, -0.09679434575769393},
    {2.06991800579192, 0.9275611945491934, -0.004322852476688956, 2.0814916985247267, 0.19938869946135843, 0.060444562106635506, 1.7396310914434112, 0.5355033629544528, -1.0036690033782825, 0.2667520406360038, 0.7081152355986259, 0.39557793795822843, 1.9075114289404782, 0.9106579146950337, 1.2668485171691006, 0.19988271669500737, -0.13089814938195707, -0.28549843648406265, 2.067861131177837, -0.1929060301576752, 1.1847281526281568, 0.9584623865109609, 1.5742677390191337, 1.0540205231866153, 0.09681541855656121, -0.4603760734290607, 1.492728660026554, -0.9387137272572078, 0.77851430450077, -0.06294020117618394, 0.36510414726121476, -0.30210678239899275},
    {1.0503955039092503, 1.3240762420030998, 1.0844452214170164, 1.370037026307094, 1.6138346272133073, -0.2100644103483992, 1.596331534002396, -0.07925939344081359, 0.2509271097657275, -0.27881601244554355, 0.8508986004725828, 0.7900533818684637, 0.6869675733662507, 1.1880760118717941, 0.5297127404047227, 1.1811793459466338, -0.08565304987856484, 0.03647376744904401, 0.5305853713443479, -0.007979836955111737, 1.4198566425459456, 1.491534539475284, 0.2971709157672083, 1.6095531274592239, -0.5416698373310256, 0.2882864580658111, 1.505278661718813, -0.2291456656241327, 0.9833915849903331, 0.8617581634534867, -0.4252023421650098, -0.3154980867075901},
    {0.6529330765828233, 0.9055795702756857, 0.46743731646245945, 0.10479718346455616, 1.2147889696341883, -0.16541905088556738, 1.2732376611460823, -0.8379737856780836, -0.8885617889460729, 0.11857804305230234, 0.2756489074693822, 0.5797609442080677, 1.4688504957384385, 0.629605521883888, 1.782974782587098, -0.5197840938324895, -0.3618743803583489, -0.3580236256066214, 0.13271474997093155, 0.4464458641268693, 0.6323083458675793, 0.45260609476869396, 0.1988537003256854, 0.14807585288216915, -0.9803253403528517, -0.2171965146185864, 0.2018867552764803, -0.4221784568993315, 0.09609110451459235, 0.09478087804158755, 0.059659506654898845, -0.9825382991013619},
    {1.2425722577486362, 0.22171302750324398, 0.037417642919260474, 1.5693123314611594, 0.08779712036755057, 0.7737943725595101, 1.0429107383088199, -0.595657719169175, 0.7000718044516828, -0.88043676635909, 1.857713225724755, -0.21682912249216119, 1.3614134151388957, 0.701216821321163, 0.35297344669482195, -0.19227945969401247, -0.46428859894103386, 0.6949033799717029, 0.11893779388558594, 0.23962000372201708, -0.30501363040921975, 0.1773676400137689, 1.3659216698024517, 0.2820629711003296, 0.04078115725850226, -0.9283886562430712, 0.5727120533108566, -0.6487241848035873, 0.26343438251112555, 0.7585907607693082, 0.642789846857025, 0.375629992386233},
    {0.3758775408093084, 1.7804718454391162, 0.8442847337505892, 0.5202342127317197, 0.3603970435752831, -0.030352424361618644, 0.0737536273450696, -0.8341687209131106, 0.61142614119442, -0.9041676418011011, 1.030495619273469, -0.18684214309337902, 1.3562998406957296, 0.31820787472197487, 0.2972259489782347, 0.17189112378408036, 0.5516210760051057, -0.8790758832952498, 0.7290206851513645, -0.9573442447544334, 1.107753457949161, 0.6008695888660112, 0.5403742969177763, 0.5624139262617285, -0.7742731535886973, -0.17288354345965765, 1.2425264394470317, 0.03834099065144829, 0.9148293330149626, -0.32267298687906376, -0.6873052076445836, -0.21008398847372595},
    {1.887567034308603, 0.36243636794119644, 1.7012865561095805, 0.6532676450052209, 1.4092679048536205, -0.9471688885940683, 1.407619720749752, 0.09729606476246765, -0.6951995359663604, -0.5575748198091667, 0.819683599293945, 0.5211473593209578, 1.749868862913323, 1.1939786012035334, 1.3890015206786732, 1.343567749945804, -0.9896541569056377, -0.12454816115767883, 2.074092575617507, -1.1005877408619027, -0.016817733295563735, 1.9191331365977309, 1.118360150520328, 1.2779797404293831, 0.5365192280615104, 0.4373985825920827, 0.9831696612432858, 0.2236917685308739, 1.6398764624688646, -0.5368872888848302, -0.602665607800346, -0.7101290713014136},
    {1.4321771123137135, 0.25713088478057783, 1.4828569300345245, 0.45963564800190554, 0.46178050489760947, -0.42945752243889784, 0.47819174301257605, -0.6099200193186126, 0.5932453781365042, -0.510625041690143, 1.8903214665134322, 1.264511922115356, 1.1537104016333508, 1.8296815567713758, 2.2985833954411965, 1.058930520298549, 0.03693340575836307, -0.46821198027626054, 1.4543017438506143, -0.5383100427282711, -0.21257376197325387, 1.2366552930458101, 1.4401517917926303, 0.36292563147551926, 0.01013511443395246, 0.8080647592010536, 1.2728900518592867, -0.28890825138975573, 2.1352758852478786, -0.09106743341978416, -0.07569960173431918, -0.10617674246815459},
    {1.5302611666888684, 1.5223013396685074, 0.49667739150297113, 0.3248330153948391, 0.4558444261196003, 0.018893446974901144, 0.4433481791959585, -0.5898425239925584, -0.6581923673361748, -0.32447565123323197, 1.8120201858926324, 1.6646013286272232, 0.32396018223926865, 1.5890162952279017, 1.057152586951508, -0.07799203071714196, 0.0833076752324445, 0.73703518598451, 1.177322521581719, 0.8713840133063296, 1.1115633801374507, 1.511645864987413, 0.7760813156391412, 0.22336823165649614, -0.12292864883294587, -0.8347280537084737, 0.4769323697084151, -0.5845338292377684, 0.6991550531168956, 1.1388570850909103, 0.4929588553965463, 0.18886241287775954},
    {0.7485842326448399, 0.661897288438692, 1.1138135232740387, 0.5334169753481234, 1.6506489735353236, -0.3537316188972976, 1.769632368947968, 0.22731395657624032, -0.23631356945132445, -0.17379150993988043, 0.5103228180284618, 1.3159392530514928, 0.3708649859166247, 0.8877769562757515, 0.5795738368006177, -0.45609355649048766, 0.23129864963454527, 0.43800142895520233, 1.3443537479795193, -0.2279994247561741, -0.14239131555086482, 1.4695248417436038, 1.381723664010241, 0.35239245089285665, 0.29047486726870375, 0.0727755483274044, 0.4966720296484224, -0.6907284894696922, 0.04281433159773602, 0.4857832606392335, 0.5004549019489208, -0.23746514692028964},
    {0.11523172863529031, 1.0108595258438104, 0.7824769681451702, 1.4710482414414376, 0.4603139691790995, -0.7617649210763574, 1.5061666124603215, -0.2554581469188439, 0.2705599082151267, 0.10527494380561102, 0.3241212675287923, 0.5521324852376636, 1.6117932216513686, 0.12936895978879404, 0.5983207819707533, -0.40192817598308506, -0.17668721096586587, -1.0891332917308645, 1.9328581869458215, -0.1423708038249484, 0.6589332282717437, 1.1430021757269735, 0.9627841043243622, -0.09213009720804397, 0.7635914734044892, -0.48979832909764986, 1.7442572966096377, -0.6851427253233408, 0.24659184259561956, 0.8443912025727216, -0.33781408218375897, -0.6325217602125086},
    {0.9623143273158116, 1.2768569677450778, 0.652133838815936, 0.6744996863039526, 1.0703127329261437, -0.408211179498045, 0.6433117219038196, -0.8293752397860881, 0.35642850714307206, 0.7009370376419232, 1.4821017748034384, 0.9784206861565936, 1.3542502543496673, -0.06191311950354068, 1.149093294022867, 0.03212015877189412, -0.9748421142552591, -1.0031739553096182, 1.2189409131707243, 0.6257871884071325, 0.48217511931385704, 0.7222641720194433, 1.4524444958463107, 0.33812771911904244, -0.8802073343843929, -0.47567213204111314, 1.7016624859754084, 0.8077974473840078, 0.5453572099499349, 1.1492120896721536, -0.1826625057998838, -0.3910058698768921},
    {0.9518161261826789, 1.6900019773650228, 1.3759614240537026, 1.938738862815294, 1.7300366627637498, -0.4458277448018292, 1.4019205467646203, -0.8028984066636848, 0.05926688215389364, -0.76067246835204, 0.7092673665889676, 0.5642804171237399, 1.2178921249931929, 0.517883797868303, 1.2899597927431106, 0.6034925492804755, -0.5413585460890239, -0.20888259508863344, 0.8762577373677276, 0.2605018892813404, 0.9836433054558533, 0.9039341535197474, 0.15775496410398254, 1.2097101795278677, -0.9379426387655246, 0.028333065202607102, 1.6692629611894076, -0.6521140831254782, 2.1189642593615914, 1.0563924435292742, 0.6848738419184874, 0.2839872413114722},
    {1.3166884462003448, 0.877384011301651, 0.5024146906699782, 0.6463750645364578, 0.8169058072888129, 0.49699037826206216, 1.6635187703248622, 0.481009948239996, -0.8945195387124252, 0.33651731880833397, 1.571457610799122, 0.3507422822627603, 0.6181463547497879, 0.7234913678824336, 1.4887887499777306, 0.38236278918692507, 0.35484767033895565, -0.027584739728238074, 1.4616513201980124, -0.1292925686675388, 0.7478488219745912, 1.6750939850616906, 0.895073382078276, 1.6651453949843367, -0.31235570530926554, 0.29019417953553905, 0.5717996611768212, 0.2734388153372927, 2.009659811172327, 0.030883763371057655, 0.5048115479648525, -0.03793899105713511},
    {0.48535766811365877, 1.318296056744976, 1.4350680437435555, 1.1146186325846805, 0.5547588112676897, 0.61161217520498, 1.2059118247252498, 0.37803553593257905, 0.17219211075817878, -0.8065995908165108, 0.12677942612713894, 1.6302405798656914, 1.9692080004521817, 0.895503763385025, 1.6607605770053715, 1.4792812356355256, -1.072329777991023, -0.8962379229122832, 0.9930767381595335, -0.17056738651409734, 0.8910181310368106, 1.2765490675413922, 1.1567523548651168, 0.05730527590265001, 0.05470524880637159, -0.04258359150974784, 1.2271418212048608, -0.3305056997364726, 0.7426585170286927, 0.7192450945591415, -0.7903563720126727, -0.01906719749891463},
    {2.0374903574911114, 1.583259108167249, 0.1410967383858371, 0.7242742653669886, 0.4464157601011866, -0.5974472359170887, 0.1421373504004112, 0.12676824772985515, 0.10960168758804885, 0.6532437797220707, 1.7381938559639287, 1.1353858782350545, 1.2462569405246666, 0.6622255851749081, 0.8768359624103392, 0.9842126719091656, -0.36358454908813287, 0.463607233919091, 0.23649733901379932, -0.07838646817110685, 1.037380840411859, 0.3615381119276919, 1.8444046410291313, 0.6068141350946921, 0.13648770895225557, -0.673304538272488, 0.6328303457853608, 0.3431510956880294, 0.8445460852210699, 0.751174138027148, -0.7825111989800498, 0.843220334772828},
    {1.7438801652246851, 1.830290435596384, 1.746685629876959, 0.3143873140921802, 0.2826527414311691, -0.4606614939020003, 0.29080432542196405, -0.9086944922781026, 0.2586988641745605, 0.10115960895350691, 1.099586871072549, -0.08860751401290186, 1.7047959187620985, 0.898234463281197, 0.7297026298954186, 0.4955338821227223, -0.2701364969860309, 0.360947968472402, 1.358482822633187, -0.8246256165199408, 1.3373064494140663, 1.3338008664643906, 1.325463441385306, 1.6654656631068636, -1.062446811471534, 0.3063306281620841, 1.1004623611541395, -0.48728830437313875, 0.48723202828323786, 0.7526493476089768, -0.5531191572498673, 0.5946053875376892},
    {1.3953962103308843, -0.035656883196722916, 1.6554987816200908, 1.097538338076502, 1.6030033690232879, 0.5812643839227754, 1.137431898367579, -0.735360368580865, -0.8070447077507964, -0.19514868421197878, 1.0436490171593047, 1.182967072189365, 0.17258988469471914, 1.3495696323711481, 1.661900783192026, 0.542295187905589, -0.8211920229538752, 0.5749222779142902, 1.1379734460994344, 0.21275709857248817, 1.278421403451525, 1.4379752866475273, 0.4289349435814197, 1.6807094190478657, 0.1281614175637832, 0.13511761451910312, 0.4884946754188789, -0.292672616140686, 0.9131613594666342, 1.0541001758872715, 0.5387709327748889, 0.5219339127830249},
    {1.2433829799186964, 1.2703622661522902, 1.2570601966688058, 1.9800832253930338, 1.789641669400225, -0.003871807167568459, 0.975780485584652, -0.29692197469966114, -0.014531927337359394, 0.20314565862197742, 1.8833913460727354, 1.0606042635269124, 2.021632790336364, 0.7528961504142041, 1.6833018407998106, 1.1582473264896758, -0.1693795630452168, 0.31878150344405115, 1.4644029048309186, 0.4187817798063054, 0.3485164310088727, 1.62794794316342, 0.9369849914506175, 1.1909483215868297, -0.6850235867866714, 0.8532214675943404, 1.6335288658871059, -0.6524247269575628, 0.4550027544951213, 0.9178662245892307, 0.13974199730190603, 0.3989667994763794},
    {1.9807890377057955, 0.3650098239097979, 0.08538369005717972, 1.8889995931848618, 2.0593156342875534, 0.2310776141456751, 0.9874717751386372, 0.3035827131948076, -0.42757606496509554, 0.46807191558349276, 1.5105781384512091, 0.4599799714953631, 0.7239695811516869, 0.9536887088296849, 1.3038863373197314, 0.19609583419021845, 0.2226557200001975, -0.757005370501136, 1.687868815164697, 0.1427236631490694, 1.0260569187661057, 1.149090186019488, 1.2924132029657587, 0.36570353397246785, 0.897758798420892, 1.149799089293668, 1.650865840069724, -0.3521623712798359, 1.1913307779859919, 0.33012625413535684, -0.22914001190192956, 0.2903967160924885},
    {2.0148157910925297, 0.6388460600710678, 1.3820881581501154, 1.8048908412290732, 1.3201738669879146, 0.10963028691502287, 1.6978941368329523, -0.10590096104991367, -1.048075724341734, 0.6415892094858886, 0.2682295426738341, 0.29549354914168535, 0.8665568336841978, 0.7585680256243995, 0.6563379818520342, 0.8075624719294877, -0.5548047732273601, -0.209428450239067, 2.175545097411996, 0.541109889175597, 0.41240227673595237, 0.6298356184159978, 0.28988749977952, 1.4875698671957507, 0.7931374822489582, -0.5493266896527849, 1.9674999316417527, -0.5956365927391946, 1.1603354278757658, -0.3401749289456164, 0.11121797165325328, -0.7161259572827288},
    {-0.02719212639967558, 0.8210548020582308, 0.49495017280769454, -0.059349778971553455, -0.11491898184034025, 0.04991806175405734, 0.5700630921001337, 0.6428438193098307, -0.9946689022629495, 0.14972083841117184, 1.4401211781764536, 0.5745347722582618, 1.2877269323488596, 1.4531983830463382, 0.3589830323221761, 1.1906706261210531, -0.9835476781680099, 0.016817162886688736, 1.158475391569156, -0.08098902414302044, -0.21947597824973486, 0.5013452366909743, -0.07010804201569482, 0.9084284557814569, -0.6606263802754454, -0.4872629122698855, 1.6023067087350062, -0.129405115607519, 0.08536145290928406, -0.041895137247517956, 0.6085909197062499, 0.3680070708692027},
    {0.8131701450123477, 0.41040886991885883, 0.9866679373752786, 1.347586253583037, 0.2850985834062505, -0.5413767203989661, 0.1770675615699662, -0.30267875593518245, 0.030488069941163376, 0.3428932085668276, 0.6583420346511148, -0.14693829916189322, 1.8145530089789035, 0.4654865957983658, 1.7558932293896334, 1.173337213981165, -0.10846128004320217, -0.2663640917171714, 0.2685525927201518, -0.9881779289737986, 1.1984705490340481, 0.3479995212758852, 0.6296863961762662, 1.0244380606791466, 0.09000108097886568, -0.1940870078108516, 1.4489419457050066, 0.36310568768152257, 1.089997521633014, 0.545087828910924, -0.3768764315011099, 0.39998221952541557},
    {0.9028678861594607, -0.10770429278901121, 0.6163449454646073, 0.565550283519891, 1.7126451244092866, -0.039909550686092976, 0.4064503210788302, -0.0705461892696176, 0.1314368813530311, -0.3846344965618445, 1.427505672654346, 0.7913464790612401, 0.14388204333941093, 0.5086844113522047, 1.9968245188085263, 0.1667375534342399, -0.5734556379770956, -0.44560073335408096, 0.22069224612875063, -0.6175653429749105, 0.9652992684445869, 0.7728456682802063, 0.5588947628939959, 1.4340889811648376, -1.0750676591688804, -0.04442534271103499, 1.7960857094595617, -0.7578381068132902, 0.7399817647562715, 0.8562630375774419, 0.4488647560043325, -0.48986950413394176},
    {1.4830455484367675, 0.7288516896530365, 1.7284181367416767, 0.24467991917148618, 1.4959745081675944, -0.8598708370907978, 1.5722955641474041, -0.4163625099634442, -0.07789131977567702, -0.01089294876451266, 0.037850538206087206, -0.16368288019774793, 0.0894446997734717, 1.8592544099625647, 2.07693626606178, 1.0908401138926085, 0.2647547291425809, -0.6333258991911047, 1.2752250697514702, -1.0040566243763096, 1.2993433928266203, 0.5427522784357671, 0.015379298941627952, 1.6298301734319247, -0.06898651541034444, -0.5346857222738101, 1.1932994381435031, 0.12009708208913944, 1.6816773470660051, 1.0307066667756084, -0.14317943393295005, -0.2112064189503182},
    {2.1322850127545676, 1.2128049883820322, 1.5143977442672716, 1.9780665285273633, 1.8990846125898926, -0.233224024749372, 0.6714689505206204, -0.2187044714642854, -1.10211451497541, -0.06373922217798281, 1.3439189940834726, 0.5685430676112341, 0.3132910758361045, 1.2357682067007967, 2.0840492717598313, -0.4476902825814337, -0.5636469906938418, 0.6960356204346562, 0.7268907347368309, -0.15245314002478663, 0.4652269193960805, 0.8293108880306451, 1.7113321691974384, 1.936361602599746, -0.3807423608429834, 0.3385586519160026, 1.3308315070176062, -0.860987166512682, 1.075979701157414, -0.4664231999773646, 0.4171604429397664, -0.39228420178037393},
    {0.6460155644266153, 0.7164698629982896, 0.7055575918687949, 1.1659254292703356, 1.2443393535670038, -0.22783617348253338, 1.849817854672193, -0.3843461940396722, 0.5500405472425773, -0.6918544726431932, 1.6015029991367276, 0.9450548762556384, 0.8029625659744687, 1.8514718579213416, 1.4858544546625627, 0.48125544973322465, -0.45551275806086533, 0.37465272459264354, 2.0428108832463794, 0.3264825468252756, 0.5878778323324442, 0.44031231116693853, 1.5872993022498125, 1.9636951869911237, -0.63819359227344, -1.0609411746408908, 0.8228403656969, -0.9850307886689744, 1.2091227326201552, 0.6818564465676884, -1.1256714297560872, 0.7237859005463791},
    {1.741244969965334, 1.1226029678335498, 1.257111172302617, 0.9098184565037816, 1.6759294297471434, 0.08718033328428547, 1.6499130296896216, -0.7414467343845733, 0.1899221111233095, -0.07732015173272327, 0.2896082134405474, 0.743532187700126, 0.2943903099727497, 1.6109490916861011, 1.840385942219129, -0.3713632115936499, 0.5231896899063846, -1.1112460057569604, 1.8757923476718712, -0.4829678177742212, 1.1715979625302206, 2.065655643025024, 1.0667278508782876, 1.2527658609670138, 0.17522279862034995, -0.970099756189908, 0.46120555878684977, -1.0680320982300213, 2.1368957372493615, 0.9307154550529696, 0.01790908788107659, -0.4409409775660252},
    {1.9900154345258467, 0.5971694305891387, 1.3426013910749894, 1.0746727556972973, 0.17668437393933376, -0.06350302376651618, 0.27454215950977057, -0.499900772224873, -0.3766610952027819, -0.042292672926268156, 1.8764170845003265, 1.4534112759453073, 0.539707586033671, 1.9590910464183113, 1.2748430136291606, 0.5158342666617755, -0.2644922189274096, -0.25809242359729606, 2.059229576808989, -1.0241469475029539, 1.096867944318299, 0.07708839674880448, 0.6580772887908358, 0.9028440194030586, -1.0451331308172012, 0.3577623353327292, 1.8537706006483388, -0.107490147294142, 1.9935569826990522, 0.5549754616495537, -0.31620318255411217, -0.1805241151427394},
    {1.4187551196248267, 0.87615900797536, 0.9973931788296508, 1.7520804798706164, 1.6591482209252801, -0.5911141222534733, 0.7562300201793263, -0.27424012580374946, -0.5260707349212109, -0.00403639489180858, 1.7839142731274769, 0.20550887600952214, 0.1975787014537671, 0.5988386068901572, 1.2336272102691777, -0.47591530207731775, -0.020744768678670488, -0.9534519758266556, 1.1608355490762137, -0.03612861581406944, 1.5497942614169908, 1.318572010339979, 1.0478659553074068, 1.5037405737103107, 0.8545724982991854, -0.17757637444426855, 0.9880305755174171, -1.053724427435225, 1.871699530209604, -0.1931045745557477, -1.0719494696785283, -0.934865222384149},
    {1.1916021544142563, 0.7809825578032562, 0.001776610108415762, 1.6893411467159252, 0.6543676410431519, -0.6363758252597619, 1.5208352188312753, 0.03412040232441371, 0.8491213668142863, 0.3828797141176947, 1.1923073579423888, 0.9009838211691925, 1.2944279884974137, 0.929544252998151, 1.3831513251092529, 0.03130672735605797, -0.17790150063220542, -0.4038130553182366, 0.7453882232511544, 0.3983182215377777, 1.3019743383053934, 1.782452979165295, 1.438588674295308, 0.47240195946818414, 0.4302139751129363, -0.5537723313809859, 1.417953100415772, 0.09817172097424924, 0.6311014801440363, 0.8059955813912781, 0.6599857406691132, 0.15163930399004114},
    {1.3619793687554518, 0.2622034039055024, 0.9648763629127639, 0.5640514252717562, 0.17530045055559185, 0.01304103314304155, 0.8285542287288312, -0.6298253758796334, -0.4927226449435561, -0.6488905047496804, 0.7346380617472046, 0.4164585488156657, 0.5729950331947659, 1.06185228569046, 1.060371103933659, -0.3844797477956385, 0.3058712244174704, 0.7102564129954851, 0.6569559257987878, 0.16430460751088993, 1.3625137617959462, 0.43661866711890496, 0.9322849557366812, 0.9813146182200417, -0.3169826464451418, -0.17681298010138993, 1.2241725664318526, -0.8585840945364948, 1.3735182797912313, 1.1832444689164412, 0.7055775835940095, -0.14511495596191815},
    {1.6120631704481863, 0.8359046595296021, 0.3652505775417868, 1.2470214956794705, 1.6805472102527663, -0.414453872887047, 0.7876404754942476, -0.15323967326830254, 0.5946042048401702, 0.05796803480902684, 1.0620687223653886, 1.4448727872692102, 1.0366692265284232, 1.2101646132733765, 1.4260854599506256, 0.4478536929709139, 0.7668786156315007, 0.2517558192417716, 1.289031337196026, 0.15382843602586094, 0.4433788995737309, 1.9145665953634354, 0.6659269678388143, 1.0566475146711953, 0.29520629421386363, 0.5877890660761211, 1.9199224944407445, -0.4862286437327596, 1.0479327204742837, 0.9791904692149185, -0.717627318636907, -1.066332818675824},
    {1.0907077687920936, 1.9902023958571253, 1.872947521228119, 1.9714873078741524, 0.9573570051198299, 0.44044016433819627, 1.1377733675828692, 0.04962555973348323, -0.6831721432797803, 0.4307488746680855, 0.8308244012789439, 0.4212279639912637, 0.736302821651341, 1.4764236502939472, 1.3461135552074635, -0.38900023446438353, 0.7244909292574072, -0.12649733336423258, 1.5858665126975489, 0.26909221349162765, 1.1647111170096018, 0.23133021985454294, 0.30212845721391585, 0.5501281038002651, 0.045387419075913274, 0.8385856932396083, 0.5080343090742623, -0.20707001567525687, 0.6255749445128237, 0.026672378464746058, -0.6531089701843851, -0.5616336997593002},
    {1.3488714321376007, 1.655932470318364, 1.0698806454343932, 1.9669677311259675, 1.4681426338385652, -0.42310630789573817, 1.7635356157670727, -0.10372678446963417, 0.5139797462989528, 0.1081280056056564, 0.3750928693662116, 1.3333410579136928, 0.43331811515279556, 0.7428573487581206, 1.491378834697409, 0.44044780802680683, -0.7802554093276041, 0.72737345419317, 0.4373583545838006, -0.5048391455231738, 0.9331073394637496, 1.1985698911438216, 0.06371001597566724, 1.5608814962540287, -0.1482576603409273, 0.5436282527347955, 1.558454606747706, 0.291981157745599, 1.6150393906027807, -0.599849924342381, -0.29574891537797704, -0.3123501167097273},
    {1.433144864554133, 0.14394755400848533, 1.3251600463747963, 1.9979978254300903, 0.1806857327524425, 0.6506591390838241, 1.5018178995555758, -0.42599356485997014, 0.05959695355613853, -0.12369030034739263, 0.6029059909065726, 0.893858872836762, 0.3134806393013031, 1.0083430576289283, 0.7238523488926112, -0.025512921174521665, -0.887629311981329, 0.4118504917010204, 1.6616738105058138, -0.49795529262617655, -0.12006169208941836, 1.8525390752799482, 0.7777227162967684, 1.9909850739897768, 0.8561372488917343, -0.9069808590009165, 1.1372152923721457, 0.6594075116431065, 2.1213846974783968, 0.5218611781122712, -0.0470966490475045, -0.38693556191113954},
    {0.8249149341295693, 1.6231969179141728, 1.7115695704264229, 0.46017802249686623, 1.863753549961027, -0.46666566334839504, 1.2792695534055547, 0.6746523811160497, -0.8623805215442182, -0.6878822265634976, 1.1216188960031293, 0.5075658810451112, 1.2747477790695942, 1.532441544558312, 1.4249737334449353, 0.4988677696237045, 0.14277909834444302, -0.28247136280087987, 1.0092253131219417, 0.23410169250664492, 1.2831989535196546, 1.4817627309338293, 1.4344176214530098, 0.6178619689893271, 0.5270681108045366, -0.36712474971849574, 1.7304504941898378, -0.14390329345262018, 1.3769348387878144, -0.18316227796782852, 0.7323292463827233, -0.6259026560348383},
    {0.9262768065438525, 0.4424422189776126, 1.3655269253643134, 0.7748279906131883, 0.23011736172559852, 0.6209117804030206, 1.0376276290107083, -0.7781150338701767, -0.9533606111510433, -0.7909274766915944, 0.9995912294956498, 1.1590956658123448, 0.3204423409453129, 0.8533442567334242, 1.0308114695535149, 0.27128319187630484, -0.33924972297095557, -0.1285600808788547, 0.4461151599391971, -0.13147338944635034, 1.343622414774709, 0.6088651247314586, 1.0321943272381995, 1.2197571665357825, 0.24135186099675218, 0.7259796298779546, 1.837042683653133, 0.5189895408351105, 1.4646841725460744, 1.0104466763609812, -0.1268548339988442, 0.770671429699935},
    {0.5586623715122588, 1.477270869143545, 0.9156305486040784, 0.44793102855980566, 0.40787202378120335, -0.389940915313109, 1.0255804843748841, 0.0014694557844470207, -0.822757742116342, 0.3645822553653234, 1.8188267954107895, 0.8237230767099644, 0.5466637677761685, 0.6119211222711995, 0.366285374333712, -0.33790881850187743, -0.72891794140447, 0.6013519664799858, 1.6571905222397771, 0.11636987688344497, -0.0461235995022906, 1.0101760520801342, 0.4898652081908659, 0.2991255145942897, -0.6344600858475699, -0.19628003342905842, 1.1116365936367458, -0.8671923063114314, 0.21009185684923934, -0.11958923930988577, -1.099370030419829, -0.47967543635656257},
    {1.0792251821107945, 1.1888098722279166, 1.3021744628384486, 0.789247312822756, 0.6260406922890716, -0.692137924923226, 0.14597873812717915, -0.2695042448766833, -1.062996823415257, 0.5951970210592931, 0.2987258724549941, -0.23389253415657993, 1.1197989516427205, 1.591209776268386, 0.4244413550157884, -0.23448510168948122, -0.5878141631160473, 0.5490262975256863, 1.7120159574441642, -0.5989641354717788, 1.395135755751876, 1.0729219112216328, 1.2440583585850908, 0.4847796216518778, -0.0289347051042945, 0.5987595542663395, 0.26034008504516154, 0.11307554971644845, 0.40803658615800925, 1.0270130429634705, 0.25695355115771384, -0.6563756011571755},
    {0.9117893000123722, 0.6169247867385987, 0.2897819838560308, 1.275039430040495, 0.7023800243034252, -0.5389730266284907, 0.2668208279676286, -0.25437850122779876, 0.27940121421203845, -0.9182771066779061, 1.6579753291671324, 0.8240957064008732, 0.827087303095987, 1.8233366189341076, 1.6896168905769677, 0.43846386464870807, 0.403308618806133, -0.9911513302926331, 1.0898397525815202, 0.009487383319404165, 0.5868390394695222, 0.5448573900078661, 1.132883661865304, 0.751355530936484, -1.1590332657718567, -0.3699668825257185, 0.2097945238432808, 0.15416806557311563, 1.813635689946693, -0.38854553218317156, -1.110197921888479, -0.9951562362470371}
};

static const float b2[32] = {1.3899666009837315, 1.1743742732582074, 0.9936732548703624, 1.4070546712408845, 1.2191360324702245, -0.15699591114261027, 1.1314376733116527, -0.1318204748414563, -0.21344352043495765, -0.2657137972377693, 1.2452173965719242, 0.7395465459200022, 1.408535530204093, 1.2282882862413187, 1.4546798458809092, 0.698215086668897, -0.23071041963929975, -0.11504292323039708, 1.4195152228095167, -0.2581324083881452, 0.8451454165882328, 1.2331615499265811, 1.1394149932454245, 1.2215862305653862, -0.2162852659477741, 0.0610793354769115, 1.183493856486096, -0.12331750231956978, 1.3869601072125866, 0.30326858681284785, -0.30564100229495855, -0.0545788710161963};

static const float w3[32][16] = {
    {1.6078289428101078, -0.11915980755955814, 1.7473456926848747, -0.25528395839287865, -0.8275348662531391, 2.2105969914772694, 2.0311104461827316, -0.11819968810706241, 1.9056290389390524, 1.0080958861419977, 1.151617679583651, 0.32464674804174465, 2.164960474596164, 0.9797750781590764, -0.8012819032121076, 2.1947805524711956},
    {1.9114512104607537, -0.9145326462263544, 0.5734223216035886, -0.8167814616722452, -0.968241073009342, 1.3470506408796916, 1.0126467846484781, -0.8155212857406752, 0.4033652917870096, 0.4668646108680933, 1.34464863256298, 0.8133409124304802, 1.8169235984106753, 0.44022485192484695, -0.5590526519346617, 1.4560689673513891},
    {1.5243203334751272, -0.7064077262312249, 1.7096284386570173, -0.1282405882677224, -1.0955561426830687, 1.5198273847226957, 0.9044668892192012, 0.46376348332050127, 1.4934714448548798, 0.5223538688944968, 0.7569008479204162, 1.0918748435293797, 1.0451403164286026, 1.1981565427045235, -0.5091510822891901, 1.550039299187517},
    {0.9811778090743642, 0.5661235044523083, 0.38525296324610386, -0.8662163992253619, -1.0571822976815175, 1.9842141646895353, 2.127369697067229, -0.06304533959753682, 2.4535860373320664, 2.1715625118526822, 1.404515474853221, -0.47047816696596645, 0.35216439975962754, 0.6187283768854258, 0.7412412050679658, 1.1416582931281771},
    {1.6684733594926935, 0.06868916786289098, 0.8747339569162059, -0.7667326913407262, 0.6247722291579183, 1.9923555526814039, 1.0938423603769694, -0.5779461035390698, 1.2175709508086308, 1.2438572043195117, 2.046369993516149, 1.1993991199192684, 1.4263809854611034, -0.4038022355421938, -1.0907471243169746, 0.6340458957361674},
    {-0.6731880787665405, 0.3359815217898996, -0.1256968468938888, 0.28834319471861564, 0.26368010972295786, 0.36233061767873287, -0.8849809008293464, -0.11209568855173141, -0.5211595193080807, 0.7602688745109017, 0.3209479644029005, -0.9085817120019147, 0.09064965734943888, -0.7488868349702942, -0.23548755508366923, -0.39773816079635743},
    {0.8370075994322409, 0.7271231626295337, 0.8662720705149256, -0.9773945521629324, -0.6992380660353354, 2.312294845429501, 1.2613650779422687, -0.9102268779592192, 1.0927407450599493, 1.83613859093552, 1.8367835575235456, 0.7883574648327525, 0.6564201825145459, 1.2495571904333103, 0.3977722214856908, 1.6465706553609638},
    {0.37635925932940373, -0.3569985308183946, -0.31028202634931723, -0.3486142929106862, -0.9566852723634534, -0.553424526762195, 0.2223987678950382, -0.10105472556353012, -0.625234173682913, 0.6490713319636081, -0.19367604811371691, -0.17958351400008793, -0.8517105675004081, -0.19051424675130377, 0.6005508477209803, -0.22277475035795954},
    {-0.1466470021859547, -0.5587674873934175, -0.2273026558505297, 0.6997646867392294, 0.3966364135564224, -0.18787092421589685, -0.6453837318186889, 0.8394821949429699, 0.7447561312028892, 0.979535000098971, 0.29739794628213395, 0.07273069623280776, 0.1410932420253183, 0.4403267267252972, 0.8070748564153416, -0.6049493822035711},
    {-0.40241707388510445, 0.8987154190769328, 0.2462242611892856, 0.7117073734579681, 0.18516478248830243, 0.8295603763131328, -0.4138823574987049, 0.5542283479220678, 0.19204532918627318, -0.08001926199391907, 0.25048825088900917, 0.05435899347229846, 0.6961348940494614, 0.3790487423139823, 0.3291330047225547, -0.6531431061766141},
    {1.9833013813948777, -0.14757759931388548, -0.05838230960596821, -0.16005521354693372, -0.7297016001236891, 2.0684811353707757, 0.7392943964334924, 0.5170890060314318, 0.8763090617394761, 1.490771455286675, 1.5900411047608674, 0.577478662379099, 1.5416694077676114, 0.7250557505948835, 0.7192623208573995, 1.9847518890078528},
    {0.6529729931145386, -0.06394562586983686, 0.49024133562811, -0.80234768049383, -0.17853110862376206, 0.659218376359612, 1.6653107480801412, 0.6545110033323146, 1.830309840062276, 1.412041336696286, 1.9336957626411704, 1.2095469724593717, 0.22091998137844002, 0.20233077311930425, 0.6487846884348389, 0.5820766648114561},
    {1.5412601944628992, -0.7256196519031423, 0.638163133506554, -1.0034242865110319, -0.32332886179986875, 1.053170362504806, 1.7423129161296451, -0.9708890985862637, 0.48530061227240184, 1.5588216518458764, 1.461422840291237, 0.5935738857090467, 0.5933813481922912, 0.1257241896606434, -0.5670456841648099, 1.4129395440046324},
    {1.900212638525244, -0.48296544445461437, 1.0728100555602529, 0.12676350766117916, -0.278779428839664, 1.3717140707091808, 1.904102068049194, -1.011873376002636, 1.5239986455740087, 1.7664788435379462, 0.6108418925993939, 0.9707017187671066, 0.5752236509953464, 1.1572040457419928, 0.22947049415539866, 1.4217313120877018},
    {1.615344163033363, 0.8050514955161328, 0.7175531756730263, 0.23667953423050492, -0.06766216599561557, 2.2400724168168904, 2.0419485974094336, -0.2891936559145923, 1.4791007276450638, 1.7713430306619906, 2.309746678178202, 0.6691368003370233, 1.9224175234460281, 0.4545334837308288, -0.9456295868765199, 2.2058753392099395},
    {1.3158482564331682, -0.2871002021616801, 0.8188276539295332, -0.6537254985756823, 0.49896737041713496, 0.09509251126299142, 1.478499950313944, -0.032459527072289746, 1.3711914484231085, 1.6253627296438466, -0.23834373367147757, 0.2716149395126544, 0.3212983298588886, 0.7070586062217079, 0.3786666748523569, -0.07666115916596208},
    {-0.025473469607289776, 0.3903967331167507, 0.5927834127452957, 0.3383407641874939, 0.4950167152571525, 0.018331511917498388, -0.11204408330929626, 0.6451019150263805, 0.597287491863241, -0.8227222059248808, -0.04435924591183689, -0.2949518382226512, -0.266434864463333, -0.7527401226806067, 0.15942385371394496, -0.26926355441453104},
    {-0.8226511801084615, -0.02135890412973181, 0.13434748196457355, -0.19081658036493715, -0.621275389520769, 0.47870547965170024, -0.9032747317773738, -0.5920060472809516, -0.6734946055660347, -0.7284396599601497, -0.11810407309573961, 0.21493188848444472, 0.27876095444336546, -0.9951076227051546, -0.7983598641923351, -0.7524439174398869},
    {1.2909276203701026, -1.0174827090255532, 1.3414693871004526, -0.6278023529821756, 0.24578080093038182, 2.149051428547224, 2.099447864364164, -0.35334491919249894, 1.7358702928648608, 1.3623617343667203, 1.2394111343342096, -0.55288837777913, 2.0985053423954807, -0.3776897873654762, 0.2982514486084754, 1.2719608539617617},
    {-0.44738556308556315, -0.7086416777957386, 0.802628317371618, -0.6745133969982885, 0.5258542285782511, -0.15014292118687197, 0.3569641490490318, -0.8659060937032971, -0.3092101764752931, -0.3362835722412048, 0.12394245805971464, -0.8531184567645362, -0.6775488616208978, 0.5909033963083133, -0.4585228959079593, 0.38590813652192235},
    {0.7711288544476657, 0.7388221031496269, 1.2971959182116364, 0.6670002424864397, -0.060437835047392474, 1.23950408585337, 1.172867067665873, 0.10892022549195, 0.719954742594668, 1.1805218969258813, 0.5875919795981794, -0.03457418292599543, 1.7794951001148798, 0.11829967341650488, -0.39337280616091874, 1.27666068203022},
    {1.8676723930322743, 0.39681653569154796, 0.7231067187268806, -0.7953717765697557, 0.6638829137483758, 2.128872516506036, 2.0809435896926147, 0.09487485918520766, 1.4134554976711937, 2.389512492203711, 0.7105982127324286, 0.6128182445526106, 0.8378914347592459, 1.3477570717264407, -0.0895451533314726, 2.148146184162028},
    {1.4003910044992975, 0.40255203931211103, 1.2636449506380982, -0.3886952815525853, -0.29236274752041436, 1.5131119868767693, 2.2369467224600963, 0.5778361711167592, 1.8744924852251643, 1.7517536368199353, 2.2724810000687983, 1.3222717819746284, 2.164872113586901, 0.7985440361636966, 0.16758436540001592, 0.6117825227122048},
    {0.4032083498720883, -0.5626053396654284, 1.2307598646801574, -0.9019602620887823, -0.8094863033026869, 1.7247469305848588, 2.1373427275767716, -0.3790452598892831, 1.227764032574381, 1.5571741301201305, 2.20866525541659, -0.39243603218666323, 0.7874221786232067, 1.2040254452802714, -0.6417639459052678, 1.4938528978787677},
    {-0.2595903660320456, -0.7165883665528399, 0.3284737927251886, 0.9461767656560865, 0.6169262210914277, -0.47338700474328405, -0.37971595459157514, 0.5047367510334981, -0.5987734731549585, -0.3726242558771894, -0.9541536861781861, -0.23678682566955572, 0.9092702097296199, -0.6673810096687463, 0.19229547442275297, -0.781602669403322},
    {-0.4183680752620642, 0.15327958712007184, 0.2557154607758781, -0.42405651694765556, -0.18698626062157853, 1.1341187198218101, 0.17689126116405418, 0.040279079954950045, -0.0869020909905452, -0.6659671947821583, 0.6713195185704292, -0.6380015758101478, 0.01856113551864855, 0.5016412618444062, -0.5375481090495902, -0.520653133628442},
    {0.8923576700973886, -0.5553355977958112, -0.04194364382121744, 0.6923306779561009, 0.394121475023819, 1.8562043822652108, 1.2237853287388658, -0.11278777224392612, 1.0125512045207536, 2.1251924277114393, 1.7330833143627222, -0.5835972875598435, 1.6426682707302462, 1.1576201271152922, 0.11820296233784504, 1.8124935834415783},
    {-0.3512725919712228, 0.6901895663350993, 0.29640212387846165, -0.9440865098999965, -0.13671920457933928, 0.21059358987784896, -0.11810388207553452, 0.21064647502190503, -0.14229367700761517, 0.9838021810874195, -0.8056627701187091, 0.5339698143178498, -0.06294687807953896, 0.30479728592475586, -0.3952555107556196, -0.8393431744687196},
    {2.39283851989048, -0.0626805838604367, 1.0354822167157378, -0.7500493764872415, 0.48341815228758117, 1.7626599648047632, 1.0986538591569421, 0.22168375283809544, 1.5435749605269797, 1.2391273142544672, 2.4475503892392445, 0.67677337068862, 0.8854031816201803, -0.07011225784611311, -0.7137163887243596, 2.2529148286919076},
    {1.6032912399323915, -0.2534640926278012, -0.10391006713240411, 0.767789914248805, 0.5397302619834431, 0.1383660806917376, 0.9968997634697876, 0.4596727217427313, 1.5649715210910184, -0.043181048025014664, -0.05964053446889429, 0.009565870858530055, 1.3376802725419514, -0.421958589453185, -0.5246847301318512, 0.21573512476588766},
    {-0.8291984031545652, -0.023721058071513004, 0.12228380756246487, -0.7954955216283437, 0.6042523449763528, -0.5246966685729431, -0.48848543229512476, -0.6485878075017033, -0.5544379883731532, 0.6417107571081301, -0.7911059476987087, -0.22005972736560775, 0.335961538128872, 0.6143426492436851, 0.8108780830812523, -0.8007882159165831},
    {-0.010736174085935224, 0.32022067899714574, 0.2990305755557107, -0.2356928535451258, -0.8399397435969925, -0.7177501512321193, -0.12357277644940098, 0.7497782940070392, 0.04323965519685351, -0.3288478146984791, -0.6933666117026702, -0.02730202832612061, -0.4642443514823797, -0.6609246553053217, -0.41972934143735663, 0.33101992000279196}
};

static const float b3[16] = {0.7788448215683641, -0.17783736732654667, 0.3155455228385131, -0.1258170818730068, -0.25402054701135085, 1.019346618968006, 0.7173566587942499, -0.2070165140699575, 1.040362426318197, 0.9385976690211963, 0.8361367745042391, 0.011343777388241636, 0.6195092127447173, 0.1228145283205842, -0.22759946084811986, 0.806711336077615};

static const float w4[16][12] = {
    {-1.4426959385616436, -1.5071359899658683, -0.7928015159579637, -1.7752632921907012, -0.5157302665256627, -0.6740162164233169, -1.9038059576741015, -1.3928284356165637, -1.6864645311528337, -1.8602290356285573, -0.6974817441268804, -0.11510362339353142},
    {0.4627953932329456, 0.13269040098311172, -0.47553204962436346, 0.2887487450726397, -0.7080911909055115, -0.5897882245279261, 0.12833174517960483, -0.045452651040317656, 0.27017848800325245, -0.22784104071404895, 0.46997596094635674, -0.8864594164948768},
    {-0.6186687797701582, -1.1635148242111086, -0.8960995278580366, -0.01982337010991219, -0.37096657966478536, -1.8205163592757243, -0.2353720206000506, -1.0831923275411814, -0.6061870414450342, -1.4256447997609356, -1.4702817305883615, -0.6559759165013717},
    {0.026222159956241418, 0.49505191383471653, 0.614598311771181, 0.4213925305616979, -0.22728305480030458, -1.0921356177176844, 0.24298061434120688, -0.27070788387575156, -0.007853907991997902, -0.499732440442962, -0.2637645779992751, -0.025741290911953627},
    {0.6790036544035596, 0.6213122271966506, 0.8357411395110371, -0.3774015302296783, 0.29383046133709184, -0.7693448698692522, 0.22281715187256784, 0.6293314474741557, 0.43048836585318095, 0.8050905773023721, 0.3857327840274569, -0.169914345929043},
    {-1.476594662080559, -1.3620465674628277, -1.3950418837811003, -1.1481154629766863, -1.162429634378134, -1.760188808840119, -0.8283222181439628, -0.7655740377564545, -0.5613568106490303, -1.7885197625829174, -1.1264048884717321, -1.8533387169259217},
    {-0.7742946107836501, -1.6365513664529197, -1.876535243717441, -0.9265571293190826, -1.28497851465746, -2.1581602579668706, -0.747562598154656, -0.4011601597133204, -0.6417064668461597, -0.5186919839003997, -1.232814416576268, -0.8702198146338682},
    {0.4848791466957009, 0.48277808913875364, -0.6414624381994302, 0.6748568975239934, 0.43604374317472244, -0.9343983829845252, 0.05659165167713014, -0.3989260351049204, 0.29065317541347596, -0.11425646260277547, -0.6312933661780443, 0.34195856765880434},
    {-1.1479538879126816, -1.1973273785068703, -0.7668387386230816, -1.640352223606992, -0.6860306161456053, -0.6420554521230487, -1.786368791023894, -1.4163797207444777, -1.7176117168987928, -0.27999620906315636, -1.1687889862210419, -1.1133145305455558},
    {-1.0310922368953939, -1.6285921105461498, -0.5279343936251997, -0.8782083016118069, -1.326775097272675, -0.935431493555852, -0.23888073521060396, -1.6515283078718421, -1.6341006828896767, -1.501101083701284, -1.2982342762815338, -1.9314426285282138},
    {-1.7042775948724604, -0.6868881121084921, -1.0365610062940012, -2.016572935185197, -0.9176384145566409, -0.8871831565249974, -1.895635751497613, -0.8372531115096011, -0.7624292763695681, -0.6298538737118244, -1.4812569955519599, -0.2442740700591088},
    {0.046201243857874025, -0.9848422546999962, -1.514933893368442, -0.08372472324008898, -0.6220678268615517, -0.3598755941240936, -1.221663798007399, -0.19753067813713232, -0.028555518950062524, -0.019655670515200313, 0.12091129482982436, -1.4994477301293372},
    {-1.7197503729454409, -0.8012022666400579, -0.6119980290380954, -1.0208521026500277, -2.0205821700933613, -0.36195896344818224, -1.1330710179319332, -1.1762858243885215, -1.0807205639392357, -1.729848503716245, -0.7716491037854634, -0.5475971640835617},
    {-0.7131081187650127, 0.08079654754482947, 0.020603955405478814, -0.6604923837672135, 0.13722796783716704, -0.592810444657065, -1.6499361829310588, -1.2613491168584723, -0.1154738747318322, -1.077327581203882, -0.46594440327576314, -1.5067913240549649},
    {0.7581386220704255, -0.6343556434940243, 0.5610184944256216, -0.7971158001327466, -0.5183772172986044, 0.3010099522066172, -0.37443452719319253, 0.6684059117988456, 0.08128984578248924, 0.2123510655612672, 0.16951435266681641, -0.03026221844795989},
    {-0.27271148498602416, -0.3702962529639758, -1.9759679205796454, -0.5522912036246485, -1.9285939365990539, -0.9838067534251652, -0.645800592497511, -1.452399934318304, -1.9075649645949813, -0.4758196250570369, -1.282586308858808, -1.8372244187119555}
};

static const float b4[12] = {-0.7156158618184898, -0.6662784651416519, -0.7318226571974358, -0.7133007582103951, -0.7989210346787654, -0.82073103582446, -0.7182351618293716, -0.7628737963474941, -0.7461477702968676, -0.6970901256118743, -0.7168526553192052, -0.674073694638298};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
