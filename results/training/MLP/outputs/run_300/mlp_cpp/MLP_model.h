#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {5.658416628702506, 1.6333521540808584, 1.6560696456249058, 0.6111246976119353, -0.38470253676425264, 7.267213114954724, 1.76935038506521, 2.5731607376485703, 2.659495090559077, -0.3261667892898316, -0.4613641689910987, 1.5626388486528024, 6.413731610751598, 3.8298010309660557, -0.1743139681658008, 7.0153633320513435},
    {3.415369153308694, -2.308118052710617, -1.3766501132015683, -2.675520120548343, -4.085775054163605, 4.039014452766976, -0.1958732921627123, -3.7176757014511743, -2.9852455428082916, -3.5487629894257977, -1.113326824488466, -2.1503986208519255, 3.0046754031100615, -0.1861324804746997, -1.8668406518144185, 3.6221180923503407},
    {3.109885025991826, -4.798790214279468, -4.734886843824235, -5.551278108235768, -5.8740292862336965, 5.487482749319558, -3.4423331527190015, -4.66025299091803, -3.227819721631, -5.348530232161806, -3.5779188482496225, -4.746230138078695, 5.354823902492809, -2.4463735918659437, -4.094187158036805, 5.510025594463536},
    {3.6054336379405503, -3.843487029504601, -2.979998156730463, -4.954214111279717, -5.331798491934921, 5.758287475624713, -3.281345233938685, -3.8685129615675766, -2.7093947358697488, -5.330321527196518, -3.3045019966974416, -4.0833295038870165, 5.7201335509190745, -1.3761131818474455, -4.100133820329616, 5.896820238846715},
    {2.450330134633757, -4.950556289566371, -2.845576804995641, -5.6624340496819485, -5.746860856667694, 4.968100494239776, -3.3215925483247206, -5.165358365518662, -3.733890409729266, -5.541456420443783, -3.8823981746417444, -5.079876430905853, 5.249078838484757, -3.3425613830836953, -3.9421839881751874, 5.26754998802752},
    {2.087098299519679, -5.065052889542711, -2.5948402579234484, -4.729209469863152, -5.3416881252193225, 4.632898338547905, -2.4686547736690736, -5.089239434253514, -3.264170359585223, -4.450583366217475, -2.803480052266185, -4.386086434067335, 4.679236219743076, -3.7960193209829285, -2.7688451444924858, 4.873013812635056},
    {2.159957746834532, -4.808666681817583, -1.8219587314350585, -4.17336350817108, -5.437304696554546, 4.433120619786963, -1.590007979762619, -4.923087802786882, -3.3270967073575513, -3.9192999115184355, -2.559523673092204, -3.6088272730794544, 4.636965600531514, -3.4299964026294067, -2.7508759596811316, 4.621539809378573},
    {3.366864623031095, -4.1251845533044555, -1.4087097078623267, -3.320983620095539, -5.038860665989254, 5.144097126793899, -1.897256325618608, -4.629482055177946, -2.1970634696577767, -4.388931767991649, -1.8154773046875206, -3.7798556036773214, 5.484353995467542, -2.1163196402824496, -3.1579357355543682, 5.159405025792574},
    {4.458008805495333, -3.0755663070500074, -0.8651097172229432, -3.6759168336928365, -4.80734220437705, 5.25989071143629, -1.9353434832588514, -3.998914108807641, -2.2158234263752408, -4.500882997863207, -1.6998029803684092, -4.123267000293764, 5.991606196895837, -1.211120711997184, -3.0435371780042315, 5.636954114489058},
    {4.5034303137292095, -3.4573403356180865, -0.7997253426702595, -3.6850717073836132, -5.134870045220278, 5.760784956613604, -1.4724189359986013, -4.553660832598898, -2.7008608873862108, -4.427337535692506, -1.7626009153056506, -3.7561961961854102, 5.696953224077585, -0.8889136700747922, -2.583009876132403, 5.629376586567466},
    {3.8476136188628263, -2.6332507341305664, 0.40865667640163983, -3.7366162756257775, -4.426740923206102, 4.664438952183871, -1.0091278834289483, -4.448239507429984, -2.632011829665326, -3.030690967012466, -1.3328322395017755, -3.5291884455802456, 3.992568604065078, -0.749781264673137, -2.7043503152922814, 4.603679710878168},
    {3.821618922088857, -2.114912228736405, -0.06055041382219722, -3.623668973964935, -4.0531858481414815, 4.372382051596063, -1.9391783339289095, -4.4374805151696854, -1.352072734636721, -2.806716471491867, -1.5583441985733069, -3.5188501880128733, 4.877974476645452, -0.4001190057366161, -3.5191102190383567, 4.682358596209676},
    {3.8678693113114044, -2.815345885815869, -1.254588252575336, -4.044102220069518, -4.6093161811410805, 4.754637020968238, -2.6225235820683737, -5.0909258563985, -2.3625560488158657, -3.3565189265767446, -2.1532757980436683, -4.25560709961199, 5.099876270949235, -0.5070635988340937, -3.867952556414773, 4.887356400874305},
    {3.667319366920211, -3.5930437394661094, -1.7659359374431154, -3.838346457791855, -4.789207690618544, 4.561469374605481, -2.8050336858403213, -5.115907377555586, -2.183759198356552, -3.579885679615075, -2.554746303584936, -4.408079706876758, 5.28312983770446, -1.0774651303838787, -4.077480390616878, 4.646696119864572},
    {3.638835603379331, -4.099390802659378, -2.6640327536126382, -3.614684416611542, -4.704940953115092, 5.142039394957191, -2.7764777072492755, -5.037053464605053, -1.6824007521832585, -3.9101567536606856, -2.5694836175770623, -4.06605610966966, 5.42041913857623, -1.0623023463937973, -4.376606411022473, 4.941511705012338},
    {3.8746069791792146, -4.781206778417404, -3.568543131465686, -4.681884033191418, -5.996918237126101, 5.328687228584539, -3.554819340700557, -5.185029022000973, -3.5861844328053185, -4.66028066038055, -2.8089945603018065, -4.616165777684318, 6.0785470972353925, -1.7274341015364887, -3.8578305391184475, 5.585467420764842},
    {4.090405915168899, -4.528410415915159, -3.8003358203894266, -4.918667355612862, -6.036673034721211, 5.934797613141154, -4.05446676090354, -5.386596780993613, -3.2788580324677015, -5.180273389712865, -3.2218586184926394, -4.997249162549902, 5.977855069694636, -1.959078185520831, -3.987760708963885, 5.51788347209767},
    {4.370171999193774, -4.044540389233922, -3.8145548208769595, -4.548156190225961, -5.528184075785025, 6.38285692415871, -3.5773233745855886, -4.926353444707764, -1.9947118926493856, -4.566813626464355, -3.3137110079767855, -4.526015846598931, 6.47548085625823, -0.9475107358968836, -4.292324836340399, 6.134320267647725},
    {4.569414739646557, -4.023149538520933, -2.6103002865649856, -4.44233769612381, -4.93676101818446, 6.385004140216238, -3.5399369620179373, -4.740691644629551, -0.7307891725246223, -4.523236611054411, -3.3514663121707073, -4.288762816723295, 6.500856385967177, -1.1463429359279378, -4.180797351031742, 6.374800964533801},
    {4.391605434049915, -4.394360784642998, -2.1951064033346275, -4.739505512385454, -5.31443604964353, 6.12911107557993, -3.148264619597474, -5.253911741542412, -1.7514756006606105, -4.644569588263836, -3.682202668958044, -4.04692523400605, 5.937626217389567, -1.5243585644806972, -4.387818980844352, 5.913258725686894},
    {3.8365255284135564, -4.20635466024959, -2.4398998125714106, -5.251600055434655, -5.587271247005942, 5.68045122899515, -3.778893006622707, -5.040875575381975, -2.9742693498863395, -4.889331348570771, -3.8131478381444226, -4.407417033615224, 6.027359967852208, -1.2596692430651701, -4.493245293831995, 5.807731876171686},
    {4.641552461380129, -3.636564473687749, -2.385152150412773, -4.822345382130069, -5.410320287832762, 6.196487708757524, -3.2379955476988704, -4.676212921340951, -2.236360618660827, -5.06364891170353, -3.246253925573453, -4.809112105629681, 6.122836184530633, -0.9199125512686825, -4.514883849867002, 6.276302502912043},
    {4.8371359180079665, -2.332657536237664, -2.371140764608419, -3.4382478084671, -4.795235722061411, 6.449665665518048, -2.3186859256499845, -3.813268083447151, -1.0798767227954686, -4.239082306573716, -2.939182231315755, -4.116560218142113, 6.306766331605727, 0.0757488647683315, -4.162362092754453, 6.176798928416569},
    {4.0981601136830585, -3.3984657750535727, -2.357953238526555, -4.469336191091861, -5.510053167259277, 5.781588344747371, -3.0357476412258237, -4.999687822154331, -2.5025866027853985, -4.805555626037009, -2.9346912869967072, -4.461736204898657, 6.093056039470399, -1.165623782852309, -4.507358897783416, 5.719497592118532},
    {4.285235310853497, -3.2079688175568415, -2.129450732292848, -4.934559824530345, -5.491914171791083, 4.969400926042097, -2.850660203313345, -5.243924222703174, -3.3969379978572194, -4.705498902797704, -2.9014016789839796, -4.906727499498548, 5.13593012510999, -1.122738576115308, -3.6121330858494503, 5.059646966220641},
    {4.123358461751759, -2.74726963068934, -1.726516273708505, -4.659469408588468, -5.13068923575281, 5.541849795184704, -2.8494830854082385, -5.0976186709865905, -2.8241314747422126, -4.349565249136165, -2.492654737652874, -4.687163110008161, 6.167867110116724, -0.49830606577051406, -3.322005344719299, 5.813812727773193},
    {4.065735048875227, -3.7356170487720726, -3.2347562259515543, -5.009642369987555, -5.625695814595351, 5.488759680475291, -3.3091022946513564, -5.094253594585554, -3.512404451786271, -5.021487518804681, -2.8235441513485844, -4.835443992614601, 5.850955547183959, -0.862065628780003, -4.183710775000278, 5.824020337248106},
    {3.366529034839837, -4.233753819381002, -3.5631269835088037, -5.602689712988947, -5.825727187469629, 5.709978684467213, -3.695816366785122, -5.462409611972458, -3.3661452373531477, -5.319507265217445, -3.5577248769092007, -4.9656664939379604, 5.311524494329419, -1.8946230768447425, -4.61612351582192, 5.62105030598264},
    {3.1383617664784964, -4.302096989597579, -2.9710833856160077, -5.062317955544857, -5.799231857261618, 5.293853203766063, -3.7528372758738215, -5.550555342860223, -3.734308634815309, -4.703235896286349, -3.7841131065150733, -4.8838744855117815, 5.256558339436264, -1.8381966532226426, -4.207261439099845, 5.505087350272103},
    {3.889219786186418, -3.8297156233981533, -3.587453115644525, -5.877761407342364, -5.976000920292829, 5.1873208774896264, -3.9403822593374063, -5.297375680487563, -4.094796719421604, -5.335289982873133, -3.898415869290534, -4.838472714156768, 5.694366811944318, -0.7676162833516391, -4.278813593857573, 5.347186535221842},
    {1.1211307603051122, -0.8659767731391161, -0.821032302660925, -2.484118330866088, 0.094374673624186, 1.2254238692954746, -0.6045636885817456, -3.527671901106018, -1.9054716873000133, -1.2856486144037897, -0.29548436949134194, -2.171421095369548, 0.4209223129183923, 0.0024708379371259255, -0.4447407978583651, 1.849788189159482},
    {0.6435916573585012, -1.2875173341530761, -1.8176918711768184, -2.152609089581713, -2.2743334315669053, 3.325543876035568, 0.07071355891173876, -0.9503824157727713, -0.04241908493122576, -1.0461127010589522, -1.0197485537269095, -0.3316372031199756, 1.4854369765391926, -0.020492762516222937, -2.0813319159404746, 3.041722839311924},
    {-0.737251644792404, -2.1261200253856978, -2.0262272246048543, -1.2868609270002411, -0.3970927913112701, 2.5601841780371895, -2.4003250674508814, -0.7988932697556783, -0.4048677542195465, -1.1849352760667686, -2.328125888789643, -1.636107786350072, 3.136494835052902, -1.5025709924283916, -2.238641679640553, 2.98299356468523},
    {0.43329741918097325, -0.1848518626598848, 0.030182338257887045, -0.05619280901210579, -0.5329646999957224, 2.1332055361138833, -1.3083509838326237, 0.0809395006551398, -0.9381248208855982, 0.14835597905015507, -1.1605097662431882, -0.7927472446093118, 2.3339501675832004, -0.3925534971363373, -1.1458078354397252, 2.549129018958182},
    {-0.7111253879471021, -1.79647795651054, -2.531067296357183, -2.8525545483854255, -2.160284031176065, 2.519019083051124, -2.5040019321094054, -2.0756061825973795, -2.0824246175323533, -2.2338199686577203, -1.9835789315280792, -2.3609149638887628, 2.4843157131488676, -1.5647233053791239, -2.2188268297925227, 2.6716613737498447},
    {0.4469026182350456, -1.2935924822062832, -1.3394439346743614, -1.129301757515838, -1.4150437572756807, 2.8623380854569773, -1.4277609968316336, -1.1710770795204137, -1.0170544643019104, -0.9671993638410941, -1.2652872509375086, -1.614202464424852, 3.209947812312861, -0.5277094893104661, -1.2247424353759935, 3.173632654842558},
    {-0.1357633232437122, -1.9506066990321902, -1.1063207377603526, -1.6262211200117336, -1.9867670440376597, 2.218775424502024, -1.3719596968132213, -2.2110116340070416, -2.344756799012404, -1.7033212895056333, -1.3057032148627694, -2.6824234782387486, 2.269681164629267, -1.8866337238726432, -1.467742725576548, 2.712355232975608},
    {-0.2838543575717753, -1.7162842859303147, -2.291776884933505, -2.0886665035425414, -3.3553424084668753, 2.107239522093965, -1.978605007676978, -2.883858014989858, -2.4763671720868388, -2.178838514931042, -1.6314598319309828, -3.219276907314004, 2.1242651215880985, -2.5575578184243106, -2.319003725591651, 2.1658029171225266},
    {-0.8567214853954463, -1.6812630300473959, -1.7397674202397055, -2.1753639871486428, -1.9489689189876571, 2.653012636840571, -1.7131505877478668, -2.018310475053326, -2.487734575377265, -1.8320368460695666, -2.0398597188826857, -2.450509160880485, 2.511286888377935, -1.9675456602899013, -2.4047460788484245, 2.692023933955724},
    {0.2178059568797438, -3.1015198680313465, -2.5984313606467095, -2.7842964915358146, -1.9639676312164054, 3.5672931779871324, -2.5914671938104403, -2.086257159469036, -2.2277376917043883, -2.8954948020143245, -2.4787154768504833, -2.5853046627491825, 3.846475926447961, -1.7050228713266748, -2.8790966278253918, 3.821916029165943},
    {-1.0368004320960844, -2.310653055263115, -2.553277542247087, -2.9212984894948524, -2.5102668915154, 2.120360556174508, -2.722919575734608, -2.892069316869145, -2.82127948087738, -2.3702652763147727, -2.63054235651877, -3.0036013394972065, 1.7969119073009037, -2.2857533598940614, -2.8533815803326377, 1.983576533049787},
    {-0.7770620913762691, -2.059983553294339, -2.109519571147334, -2.0898163494485296, -1.9078274226397052, 2.442919928028895, -2.5636252324064803, -2.8423752410923653, -2.888695441468879, -1.9665673536739476, -2.261046458493446, -3.1787097489421448, 2.712112175556464, -2.6533108974239026, -2.1623934359783474, 2.641610092992193},
    {-1.5866459935856032, -2.250499815695145, -2.6647515714469128, -2.593194303311361, -1.7680648608629297, 2.136558886272698, -2.509293658956862, -2.597582952592206, -2.9506044996696676, -2.2802128028924953, -2.6908574106552736, -3.2839418530359703, 2.329870442968043, -2.56490018999454, -2.639557527085628, 2.4017325217926353},
    {-1.3478643088244404, -2.116276122284449, -2.206835306077983, -2.730511617645429, -2.589653572564911, 2.365252014311019, -2.1899033296988124, -2.763822215724651, -3.0538572289652346, -2.818109899414641, -2.3969800836801545, -3.262824661122464, 2.514338503883595, -2.50932440056984, -2.5312842692535775, 2.3099429360946813},
    {-0.9337649792289867, -2.705771269973655, -2.7344014712755413, -3.06099519089223, -2.163253778605645, 3.1809918979739806, -2.671037312735812, -2.118917838376506, -1.9196578843377317, -2.4718371701879636, -2.576053693622554, -2.880859012987406, 3.2866540897047947, -1.820237729074302, -3.006634558653479, 3.234493354226895},
    {0.18583465557614018, -2.3364703850483863, -1.9281376190857085, -2.405889790141027, -2.2764379066473435, 2.890701590923967, -2.0593256966681093, -2.432989832204695, -2.143824535089611, -2.402081660976394, -2.3613136466177176, -2.630958422901885, 3.0333853173015233, -2.3024128748334936, -2.2137803701317393, 3.080881437699379},
    {-0.6975250964374189, -2.345176253850954, -2.9451793652233356, -1.6327533160867065, -1.8303066045749956, 2.988326712931864, -3.003340541921918, -1.3171620817762966, -2.0139385282289464, -2.2316553916112043, -2.363350903771657, -2.1006686881869268, 3.189736178758848, -2.6595249549467397, -2.949558441696101, 2.915052549279748},
    {-0.07923469435259187, -2.221541871704731, -3.800068748016788, -1.5921624558480822, -1.4805056330426438, 3.257478598254989, -2.7645309638006497, -1.6191420340823386, -1.886011398935818, -2.191025228073234, -2.8521126479351566, -2.7522538314529736, 3.2662528660558348, -2.3119246054277123, -2.8310084708283494, 3.08790091958182},
    {-1.9690204233644295, -2.588213829298074, -3.4968415294232953, -1.8559856531629193, -1.2087270589685708, 2.0526275741740374, -2.8207921986160205, -1.4735377547391122, -2.509826797967359, -1.9746388114586202, -2.8409113343938843, -2.8715185853025336, 2.5789707652330214, -2.771762566391942, -2.6227316021002283, 2.1899250527544445},
    {-1.4791859311749203, -2.4920184603384716, -2.11873259744594, -2.1104740607638015, -1.3343120482695656, 2.539792345645472, -1.788846943761453, -2.1462356965279796, -3.2497341704984755, -2.5970035607310957, -2.487235976191632, -3.070443093443946, 2.5354742345328916, -3.1435838195902734, -2.1792839676057083, 2.789429889699449},
    {-2.531939382950295, -3.2058722118253726, -2.50773753028776, -3.04722373579029, -2.0883738981812425, 1.5655634202376834, -2.9656450449807585, -3.115607665677174, -4.320788474119935, -2.8068681470351566, -3.504230064879335, -3.6769112633326637, 2.0772844578560568, -3.834743469068592, -3.0754388502773637, 1.8692555346820556},
    {-1.4086150165301368, -2.9037026544396047, -3.2616712643598507, -3.930559398277598, -1.7846811085947472, 4.166263953270395, -3.2800776422199283, -2.102257757126979, -2.8222065651735986, -2.557476301465758, -3.731476894586289, -2.7333239313738478, 3.8349599663493543, -3.065876886397349, -3.076968143339382, 3.982034338906177},
    {-1.2603191411595995, -2.1104363461364892, -2.7354193108780587, -1.8328074691839962, 0.9013197979429012, 3.963013133451729, -2.2995418413994786, 0.6013687530112622, -0.9873669679436003, -0.24179080516693516, -2.3175300639151657, -0.7613443953311066, 3.5883976418280614, -2.2506199544438275, -1.5579651412017128, 4.07340089106944},
    {-2.034116645080082, -3.0604313934334697, -3.3502045546199155, -2.2207463824444154, 0.20217000206534957, 2.782035813163823, -2.9442544841489533, -0.7568642111302972, -2.2238440553001597, -1.493091732193022, -2.7772414806991947, -1.981079327050168, 3.1811153973920665, -3.490494463168121, -2.6961758848607453, 3.0651868416237225},
    {-2.1535188821070896, -3.588030250270073, -4.50752986145283, -3.718651672582951, -1.381581922345713, 2.393878252785152, -3.8772626932110144, -2.41167738460531, -2.897516475667177, -3.2720666978936723, -3.766881448359093, -3.259522903032861, 2.8638435744859714, -3.162242773256146, -4.005779932033219, 2.844357333085627},
    {-2.208526947892787, -1.8704502679234205, -3.217228007240269, -1.6438891776706197, 0.7386841002000153, 2.969393908913209, -3.64658721692571, -0.11656239979267656, -1.7746070833956995, -0.3180635767405661, -3.224754043174747, -1.9332863034974772, 3.23421455725508, -2.4072851288812473, -2.660305719409077, 3.1525493324011733},
    {-1.8319369331098905, -2.7735547421817217, -3.2911618106192004, -2.787210679447788, -0.8533193270211458, 2.9781976822730303, -2.86409200021559, -2.955443867565847, -3.7849522969472513, -2.588356955370807, -2.3973603435637356, -3.590295960511022, 2.496963517489459, -3.2725886577342473, -2.588368385253455, 2.944583599220653},
    {-1.513014719047272, -2.9567735856110695, -3.092290651414778, -2.985132349546002, -1.132568465881186, 2.728982041009671, -3.071347608020834, -2.9287041066835235, -3.5176173647342024, -2.648448643704652, -2.8071009316642184, -3.5940986895491362, 2.692963641269827, -4.086565735362292, -3.0116363265094135, 2.923349848578761},
    {-1.9244734040598215, -3.0958307011365047, -3.380855886167493, -3.5852085355147456, -1.2634084233696474, 3.1557496513796206, -3.176958852768675, -2.2742858983690954, -2.925435804665627, -2.084011628041977, -2.9582726044485845, -3.628731657079915, 3.300798934205005, -3.8246547885038567, -3.028180355158547, 3.0069982175573857},
    {0.21656991343502324, -2.5436257457641824, -2.5855817596632678, -2.4075863695387114, -0.49810034886207843, 3.4272818593602032, -2.824335768437335, -1.9760350883879247, -3.611719110042532, -3.0443173742065213, -2.6480934197445114, -3.2986185785482767, 3.6475690429876964, -2.9983976298105177, -1.9340045135782338, 3.7332098712467703},
    {2.566493892770535, 2.1987431733674114, 3.067582147538973, 1.9415456440809664, -1.0752406108489254, -2.2912348321972584, 3.0116095590517378, -1.620887336349256, -2.5294112922037133, 0.9474160274021832, 2.491233835668615, -2.22565612506953, -2.8804281551645214, -2.635648983156326, 2.761273841066087, -2.50668990653918},
    {2.9095844169320637, 1.4032632833354828, 2.6220730253881457, 0.600039013270752, -1.455394557819667, -2.3979218080655667, 2.372722535599196, -2.02913731892087, -2.675353218986856, -0.41158495878870666, 2.0934537757824665, -2.2291188030865148, -2.9569492485487756, -2.8665666046457345, 1.684280911567806, -2.545044505014804},
    {2.8824440194173997, 2.5635804965364217, 3.5862294247174353, 1.4128218005065467, -0.9546787291281283, -3.5471243479023333, 3.946602462172865, -1.8154293210968055, -3.0040546786823423, 0.2463318997418121, 3.260666702769156, -2.24379792788643, -4.009813575334103, -3.9388650344554637, 2.8122773963020173, -3.69671687435897},
    {3.700059560084639, 3.0917248493840157, 3.7358012930966105, 2.1730179687371356, 0.0310360912040511, -2.969458312772315, 4.182233577419205, -0.1732536539170813, -1.8931946589051594, 1.337637952003674, 3.5416313752966277, -1.246209511108989, -3.1928801324479656, -2.925946582144347, 3.1866869236085424, -2.966685571023124},
    {3.624242414721074, 2.712371319197543, 3.9640913668954587, 2.239493106677753, 0.4811302427521345, -2.5838433373777674, 3.9454059701597983, 0.2208117850682799, -2.184881489569618, 1.7380298037244135, 3.1691709421195506, -1.105726826163746, -3.178477341307775, -2.837492520837459, 2.9899989120186636, -2.8175587994177307},
    {3.0591935458955195, 2.6383591009803857, 3.6426212329029224, 2.4009319008947623, -0.129805356123343, -3.322672817945939, 3.8661720777578776, -0.40565233348356383, -2.600847564214166, 1.7018947945090768, 3.057890622455243, -1.9032402151267849, -3.531894419124181, -3.511036926529465, 2.763091499359439, -3.3431456434281066},
    {2.4531547761183443, 2.390229201527517, 3.2726180048066307, 1.9020479559248293, -0.6416612123936679, -3.9351909643276466, 3.724624546758811, -1.8249428286834928, -3.7069225452596792, 0.7412047279652663, 2.955189629344417, -2.7279323622883584, -4.0046031933069095, -4.198657746823975, 2.889044340888767, -3.6994491294482925},
    {2.334118379943206, 2.5880114160355663, 3.8569286320984832, 2.193668706576914, -0.8081263868091602, -3.973061434976507, 3.953641930510678, -2.1465860554207863, -3.4942944951010433, 0.7870483527251092, 3.334794775886487, -3.1406299556649193, -4.239621010974689, -3.8456864854040433, 2.9009739372016545, -3.960790057934681},
    {2.511497660243776, 3.0315998101167123, 3.7054943550620343, 2.6786470005843057, -0.46180402824435, -4.116889596161172, 3.8617733279531685, -1.5291992980417786, -3.4671114060951864, 1.1130502180567414, 3.5326873987402663, -2.8347930697307366, -4.521534737625163, -3.889244587401603, 3.3433427227294037, -4.228939668165808},
    {2.087279514115322, 2.661566706556912, 3.452836848325864, 2.45269256729067, -1.493868371962163, -4.075976811451145, 3.649366002439331, -2.205850643620556, -4.067366015719635, 0.40368756491579966, 3.169956704666706, -3.5103514800197875, -4.470143507115035, -4.386096520896922, 3.0778774029723572, -4.223348254232603},
    {2.671927689557957, 2.773510497603238, 3.9124519535109377, 2.5771470794878657, -1.5295986986634398, -3.745287910524146, 4.034347108381319, -1.7214369081925116, -3.1349933130881147, 0.6632957936625218, 3.4483761377514273, -2.829191518113089, -4.257425075255391, -4.047002292433356, 2.9033659459773786, -3.94528262493435},
    {3.6888460706776454, 3.483026860165072, 4.087279789268365, 3.042504065448558, -0.46059806035386536, -3.0796089340695, 4.61736532470686, -0.5525068168911301, -2.565263597156861, 2.0834004913022146, 3.8578277089849977, -1.6856068826555908, -3.571057783004779, -3.2239961359408937, 3.5748144383129383, -3.3522335740159073},
    {3.209775142874564, 2.95263071048389, 3.9924252390923805, 2.626582161021367, -0.7663534332758671, -3.359819007222222, 4.1300506886068185, -1.1548258080887481, -2.965683006110396, 1.0458936692470033, 3.6578979350747574, -2.5179630758298774, -3.6125229277481656, -3.321949091023677, 3.101851285469819, -3.5329613614659467},
    {2.813945193557624, 2.235659487185434, 3.4149892033224236, 1.9883210272027463, -1.4523750556150432, -3.0906256567325983, 3.1396650175045537, -1.811444176563701, -3.4294923972513507, 0.08505100163011022, 2.67661725076778, -2.9444040529776387, -3.528218645786756, -3.8030930026545464, 2.277659380647004, -3.2694956452668498},
    {2.0444603780407817, 2.5904500433141764, 3.29111548194279, 2.0702777412693263, -1.5140176723775995, -3.9378592983772784, 3.479790665722343, -2.0857452691698337, -3.5828162111506976, 0.30707609795245544, 3.093297858868975, -3.0472454980656773, -4.244148221048676, -3.6710633303429407, 2.8167123091269586, -4.102840455727604},
    {2.662262794844716, 2.7969174134724524, 3.7116850909694685, 2.2617555373683498, -0.9265789852544238, -3.596041112670058, 3.952734689808949, -1.3601871330156103, -2.866051965456035, 0.39690635024218385, 3.2634267147627076, -2.468887647142838, -4.029465443925904, -3.5914108416950294, 3.246539795688637, -3.648234100223478},
    {3.494700495083691, 3.259489034203674, 4.165717731126773, 2.857842945838727, -1.1777111943867187, -3.7354357069439184, 4.272349972206006, -1.779166661109224, -2.847039420118394, 1.1801608968758268, 3.6626031109917783, -2.627534942276338, -4.242603012895695, -3.7283126926169157, 3.679785220720604, -3.928906839317646},
    {3.341100435771068, 3.4598886641799713, 4.106098634248338, 3.0646556628402055, -0.5198140142081747, -4.242636271864521, 4.566003203466455, -1.4468915764057988, -3.2697920434463885, 1.2253079272959517, 4.039238941472177, -2.4073184803892196, -4.623993534586445, -4.253561530108668, 3.966360160174984, -4.509855974167805},
    {2.790868745502025, 2.849706765115366, 3.844675765871059, 2.0795709640767277, -1.5996560460116371, -4.256872446189581, 3.8703934124025356, -2.466371005687715, -3.690595062750859, 0.23994247849719869, 3.5583847267693343, -3.264585032001727, -4.676897649395047, -4.59531170660904, 3.202606672876279, -4.163840719581829},
    {3.4550329945232883, 3.509289753050996, 4.136821346494064, 2.7311844892977004, -1.6767961578276491, -3.9370657748705327, 4.224531032073777, -1.8590675839785777, -3.392558590533577, 1.1638988514199378, 3.642300757124704, -3.194336792029701, -4.283472774118723, -4.068333924330117, 3.6067359613102252, -3.9360024106763145},
    {4.12469764130591, 3.2908475649677604, 4.2597722000868385, 3.175067434612, -1.643045454203876, -3.9052560672332914, 4.370711421902821, -2.66246707269855, -3.729533169681678, 1.0186597495939813, 3.9249994965937955, -3.5118519182580283, -4.535756562253421, -4.042644432990052, 3.7973418195470763, -4.096913268552507},
    {3.9222770242823413, 2.9435081296863896, 4.297920021099459, 2.4004076417044335, -2.6907581524241206, -4.0805145156811, 4.546543561645215, -3.121344211140444, -3.9049199409154696, 0.3791022888992615, 3.8974689133268368, -4.087228547138756, -4.689792157803451, -4.452967421858549, 3.418208361141275, -4.335702486406754},
    {3.4306775510610596, 3.1168084873393678, 4.085252967008196, 1.984899360851202, -2.5607113017714, -4.229504870852117, 4.132827349864405, -3.2267105949337154, -4.1632478963766255, -0.10449705891117825, 3.674253179397751, -3.794968328948297, -4.666873064255652, -4.737691198647962, 3.245665878917302, -4.133247850428294},
    {3.5860096801457115, 3.3881531416126807, 4.502994532896518, 2.6974343649800248, -2.1565710109235674, -4.65352073871501, 4.775281746787484, -2.831137672231946, -3.96053565352958, 0.5068467586838338, 4.264489427592061, -3.7961037758753338, -5.301192233264275, -4.8427280647147155, 3.7212637909802075, -4.916038184715779},
    {4.214939625631736, 3.579040297878291, 4.527636270018109, 3.409418527578869, -1.7921897261631166, -4.269990772117678, 5.007440246734579, -2.359104994852402, -3.804166501458106, 1.0205930532572474, 4.395751052860817, -3.386156636141862, -4.591127229829715, -4.573409449182621, 4.102184260433363, -4.031597820491467},
    {3.6060668129534967, 3.0147490531640995, 3.819948692504566, 2.0204604795479186, -2.406204398831569, -4.212430601088722, 4.555655402643889, -2.5832755518582977, -4.06577403799548, -0.23628398974778603, 3.539993912025881, -3.5737210345365824, -4.798081524851267, -4.724663564290216, 3.2660076963674514, -4.48049874033371},
    {3.782732244910029, 3.373884269325672, 4.635209725555652, 2.743900477987194, -2.229222513222507, -4.299482140981068, 4.683561349589197, -2.8534411653125065, -4.194990838250854, 0.7059780317864491, 4.159590989785543, -3.7817281649691896, -4.293693267948798, -5.064382405969783, 3.7748052567634858, -4.307596384455611},
    {4.276734460047492, 3.6457641635557114, 5.0207351646731375, 3.320310090474504, -1.5747953324549675, -3.8425195510766237, 4.891341328634945, -2.3555141279143843, -3.768138735282732, 1.4880788702267151, 4.480196416109317, -3.4179834665115068, -4.360393334705769, -4.657683162773054, 4.1448367230864775, -4.07475589813127},
    {4.446426574458719, 3.5699481184843376, 4.783754337882349, 2.648620699956661, -1.8698701951361987, -3.805195752974405, 4.9272872986514535, -2.6552312709736094, -4.095265613169337, 1.2200800392261548, 4.634280692147573, -4.026558874893445, -4.387632049651899, -4.937465709560474, 3.913621813307126, -4.033826430107941},
    {4.0495752792406225, 3.6009519463332595, 4.937368688931195, 3.4796964719554584, -1.7592990385686922, -3.913232183901913, 5.0280424371258015, -2.749566931186316, -3.981011185438983, 1.0508826776972506, 4.6595005946010675, -4.0466504993468195, -4.75537623977231, -4.479928484986567, 4.347535375663591, -4.105712954941302},
    {1.0939129143864237, 2.1229279866141946, 2.4311012260939724, 1.275254169720841, 3.4423534105015037, 0.8738441476466066, 1.3465203956184943, 1.2481521243678275, 0.6430237900237614, 0.7856365222659982, 2.211027645421786, 0.39517781418678694, 0.9749851655459483, 1.1885657795213467, 1.4048219917675382, 0.8557302180240484},
    {-1.2396873046083767, -0.6144831657936445, -1.4278976588060333, 0.879686048417933, 1.3025184607856566, 2.7766097510031718, -0.7667647582073174, 2.0249982128754263, 1.9775486839780265, 2.391718812260482, -0.7287136182135425, 1.590981015114146, 2.2010687263003494, 0.4389963603910457, -0.7973011552758009, 2.5223130943814756},
    {1.4419056961812533, -0.4978189599577066, -0.8074498796386839, -0.28242132716528645, 1.9051412083181372, 3.5337900267070634, -1.149273821830298, 1.4856428706445164, 1.0719738995886265, 0.8473925364089068, -0.7844700190062517, 0.8111120838168493, 4.293061626643133, 1.7731484883280353, -0.0698026885541642, 3.987372413679581},
    {1.2687817504263603, -0.026695002791019686, 0.15419850662802098, 0.2551206563035955, 0.8028890973555344, 2.2867148432926188, -0.4197388829182784, 0.14525767193541572, 0.042523355964205777, 0.4609181949064701, 0.21582723823145517, -0.3492883596468701, 2.6786537088025955, 0.29327977486607265, -0.3210207464996663, 2.656895267850419},
    {-1.353930799164933, -1.8868618877596788, -2.1302514903927117, -2.5197270022803213, -2.311169340344836, 2.1721918913004523, -2.3551713572045276, -1.982853919055091, -2.7961218615598096, -1.8241340501545578, -1.7974241517743608, -2.8184086000848008, 2.1571772696847566, -2.452002310649558, -1.5590895929199289, 2.3273290694121913},
    {0.23847067109850761, -1.1015573473862976, -1.4306400845143699, -1.2578358831621868, -2.0622642910645093, 2.723968681904356, -1.8388450588368626, -1.2836209373873175, -1.1767372905506217, -1.2468935439185567, -1.5486011305166472, -1.8852035142085863, 2.8916587734689836, -0.9717766953249259, -1.2274614356659022, 2.9405629175256642},
    {0.16142693336239444, -0.4722341656290397, 0.0774370780314846, -0.2976249717331669, -0.6966545391364569, 1.807194863679667, -0.7863500089600306, -1.3089707766753023, -2.0472222517744956, -0.4774494265022004, -0.2503339769075756, -1.8937717190533343, 1.75933314888113, -1.440575830898724, -0.47139780453682356, 1.876326479017461},
    {-0.7304676371193723, -0.731109495403361, -0.6959915214240477, -0.503183609947972, -1.2876515489546287, 1.9272833584019156, -0.8475001325732519, -1.8146517986460466, -2.276066814134976, -0.895989644845536, -0.5059848129602352, -2.3123455355889666, 1.8451642002309585, -2.0793622320027296, -0.8058011931920119, 1.76928882441514},
    {-1.2316519985980543, -1.0782832905735198, -0.9326240365844087, -1.8742405645863467, -1.6395739786129828, 2.243980866661131, -1.3853362153385613, -1.3126026066065473, -2.1460696979969374, -1.1184981484299898, -1.183575854279517, -2.145766210437715, 2.274099418178202, -1.6702947382783973, -1.7810943246483892, 2.4163151410238926},
    {0.24673979750785205, -2.701386967346531, -1.533710395313448, -2.65360548997457, -1.0332448433617902, 3.7374470345527078, -2.383168236535319, -1.0079634098503296, -1.0848377346753175, -2.1186400892501283, -2.115902141367971, -1.3711446432682834, 3.997341289436125, -0.5877888226228917, -2.3349421792064557, 4.0563257523480045},
    {-1.1068043826235372, -2.1183188020808497, -1.8523850172489345, -1.8201914423064565, -0.7334649903767759, 2.0098637908927626, -2.3524687748525266, -1.6760624583773314, -1.70989756065881, -0.8586113653547695, -1.9603888936966212, -1.9653055144892686, 1.9099208955443874, -1.3007767842805322, -1.991699184335763, 2.1207645064895164},
    {-1.1858287687494744, -0.85460965343805, -1.383724215171943, -0.9191594845497225, -0.9566980796763063, 2.182501375257333, -1.4105345817285573, -1.9104160576929836, -2.2604126551067303, -1.0905399367234412, -1.2937554772451723, -2.473284684044774, 2.3970169279165323, -2.3129353697688226, -1.132426998520588, 2.246080551551923},
    {-0.8927536388342691, -1.3989744105493829, -1.282200412867556, -1.2893334670603018, -0.22956977450393373, 2.2627975420855666, -1.0582306437030473, -1.2376629870206486, -1.93567799060005, -1.0921090954966033, -0.892984235903175, -1.7728764899873513, 2.1864480158835002, -1.867412842711744, -1.2446097175615694, 2.2207815904560437},
    {-0.5681361885242273, -1.0035682981514138, -0.7287917213341039, -0.8727576128698793, -0.1800003841449662, 2.277107223738191, -1.0603125526867438, -0.7395684669922561, -1.6514579423931715, -0.9863400798764551, -1.0934095655477891, -1.3252924289463137, 2.6258503639083344, -1.8920646412540656, -0.9488408071292415, 2.306138372436514},
    {-0.3922210528933606, -2.1435090067777995, -2.1619150193261425, -1.4323517183153407, -0.00784407500240527, 3.4458473208239973, -2.229258744395424, -0.5166395773134156, -0.9271780856638224, -0.683584850758872, -2.1254222006538765, -1.2555457675117334, 3.427784950777628, -1.0315654583602025, -1.7310352594511251, 3.567085428192698},
    {1.0885158375460942, -0.935710790296715, -0.6630217783584453, -0.6004680644327065, 0.3181645108687501, 3.24919218469982, -0.9267419782707766, 0.1755075817238488, -0.493064429069933, 0.03969680154540365, -1.2304382870768364, -0.6767248356840326, 3.699064224414931, -0.35034832597218135, -0.8532867475166067, 3.6690903512112847},
    {-0.5532930869231315, -1.6651468423921, -1.1642938812415964, -0.7065409790872543, 0.08606491974358854, 2.836002511075699, -2.3098781850877286, 0.15087880406206636, -1.9550656855597597, -0.9413427537902131, -1.8588025789926883, -0.7867641089189996, 2.9628072993601693, -1.8987539699518674, -1.3027595054519059, 2.752565330743238},
    {-0.9824641548874761, -2.1134707522284306, -2.7539606971048247, -1.471778756981836, 0.43564307047618384, 3.3602095575134734, -2.806118903390263, -0.12453705896120278, -1.4180165852816207, -0.8394830986638121, -2.3660918566927, -1.6335187016643542, 3.4881695160893966, -1.5794524090568025, -1.7083849748744846, 3.5289773592170364},
    {-1.7096426379095822, -1.3010492652232655, -1.6687192640769315, -0.3051214129177069, 0.47139438787285554, 2.5161701139691135, -2.071614459693011, 0.1376634073844278, -1.7975809214416199, 0.2823564604346787, -1.4594902764579203, -1.4660915722540975, 2.8013993776297483, -2.33958060018392, -0.9688189082457971, 2.6505831389586665},
    {-2.3279063919231135, -1.1923440857857301, -1.081441350383124, -0.7522980642006819, 0.020372941930883917, 1.8748644257825655, -1.037930919635746, -0.7888221503418736, -2.9055046608059225, -0.6443681625924808, -0.7551873291600977, -2.5478063189535476, 2.14297931565971, -3.120022026686583, -0.5206989292705803, 2.128556029474614},
    {-1.7911762476271071, -1.1853609011814652, -0.8315901756172067, -0.20672149762147782, 0.3379949611024765, 2.0201604181583908, -1.4990848673139154, -0.1252262532058078, -3.0261529471645927, -0.822402993196884, -1.0956637205309916, -2.1895864013605166, 2.432186312250544, -3.313090210691209, -0.8435687452247214, 2.19636030800618},
    {-1.8698633729145897, -1.965853165734955, -1.974341092228371, -0.39116870857273084, 2.1995760864749396, 3.2984418576127412, -2.7716410152186017, 2.4456674521563153, -0.27479789922620146, 0.1272548250357444, -2.337196191911869, 0.6166940897210693, 3.4750219540549985, -1.3640069322750423, -0.8027856515975543, 3.645295568504018},
    {-0.9850730841899195, -0.014771205948736505, -0.26490606996094873, 1.1555864601955281, 3.6207507495959996, 3.7817009904471974, -1.7277177974877846, 3.3272518446007107, 0.6604945461116497, 2.227941477486786, -0.6009143559474779, 1.6600228907438097, 3.7652141207341017, 0.22041219526370395, 0.6377902791070993, 3.8598367243410117},
    {-2.183459224005235, -1.215869077488965, -1.8779335091091214, -0.20296625609530558, 2.7485064232152396, 2.5019421757057305, -2.5669240204877304, 1.7759168881495528, -0.746696085814304, 0.6710446508576849, -1.5962877381173526, -0.021609498939061143, 3.0425311470035354, -1.2660381742458342, -0.6569210721179513, 2.8901489108446934},
    {-2.4527010364186657, -2.885581307579271, -3.3391330401945414, -2.321548352511893, 0.3202210685534433, 2.632147820112973, -3.8864458944053086, -0.13158196174854594, -2.082684865262784, -1.5816741819670987, -3.3245211142012767, -2.0466312660362274, 2.8187668403346064, -2.8307732490509956, -2.428445820722974, 2.964695035707335},
    {-1.137705041897923, -0.12070645261124124, -0.9009782877600166, 0.886283172649016, 2.531741734201573, 3.241058581510752, -1.9868871651581685, 2.0222833130992255, -0.546029382227693, 2.1473478086718143, -1.0122612930193353, 0.03840938586911562, 3.3492072853398236, -1.049758105873537, 0.4594461266073062, 3.4357900536530597},
    {-1.7963011998127927, -1.1162318206260284, -1.8326966806098295, -0.2937783384970728, 2.376961018495064, 2.5594794550708255, -1.9311956145534992, -0.2002980290394036, -1.9826494825098944, 0.7885105230390499, -1.205987689598219, -1.6533066917554002, 2.974046213847526, -2.126618761784252, -0.457735578321726, 2.9082219858023812},
    {-1.6504000184714618, -1.2049013910028343, -1.735951536165965, -0.5618693496847857, 1.1887553047946822, 2.596595436540441, -1.7721804808604058, -0.4213375781692555, -2.4463309259343, 0.18438806473241398, -1.6467157418395557, -2.3731972534388044, 2.781460634133092, -3.053812532318724, -0.7039303846089328, 2.9693539882263567},
    {-2.2217489378019657, -1.2606907612400238, -1.8987629298577824, -0.4818375329541586, 1.9276465054018135, 3.0390601735444465, -2.2699464347976095, 0.40921262192808144, -1.7384785421190754, 0.7082848800576195, -1.4879297578153297, -1.097868384821205, 2.9845510511483937, -2.706127176043729, -0.504208192961592, 3.0387928869042042},
    {-0.9037245981198655, -0.7387959185032069, -0.35196373838254336, 1.0181005726429577, 3.2062142147315087, 3.091057259732714, -1.389326468851602, 1.9642276274337493, -1.520360980700557, 0.17484732664502628, -0.6688820419554267, -0.5845309856494402, 3.7021869513929015, -1.4387355059509928, 0.6458030199852857, 2.99705602316184}
};

static const float b1[16] = {7.718351240544456, 5.869311835514021, 6.341932223482461, 6.0962577767954915, 6.534253146258905, 7.660051635847262, 6.393838110418767, 6.3639560433070095, 6.586910919461136, 6.13314478783229, 5.858820169621495, 6.51424919789366, 8.014627408581108, 6.822108801322859, 6.10121833988262, 7.646342894771467};

static const float w2[16][12] = {
    {-3.812890723192797, -3.6548041061255674, -3.6306636289882506, -3.7473019781437347, -3.8220733914609304, -3.6868666199332796, -3.607487283863512, -3.581509941182712, -3.7037437821042047, -3.6617185386500424, -3.676773110631734, -3.73169310683804},
    {-2.3535931753600767, -2.1752167640296274, -1.887483718670697, -3.339939569345449, -2.3791094167252003, -2.543976124575781, -2.032436154007623, -3.1607550509043825, -2.8936135859059515, -1.6280841385091824, -2.1407009910225523, -2.6889929563217914},
    {-2.129122114444908, -2.19080103788979, -2.836033935733648, -2.4298991440464257, -2.627528607948627, -2.230674601897153, -2.967678929191435, -2.716803698467068, -2.725331817276569, -2.0413651158283646, -2.4760005821221136, -2.979836081599727},
    {-2.273641665320268, -2.493091796916319, -2.1021795059451063, -2.4418819680115056, -2.6912241093982887, -1.9870136655214048, -2.5626430446225346, -2.144852329099852, -2.909697070439777, -2.895322753826991, -3.2294930708539953, -2.584689053851764},
    {-2.6063135850026593, -2.640413077130189, -2.9486339811171596, -2.976616675315249, -2.680453074366755, -2.639173273549045, -2.805073961355296, -2.6913694726903703, -2.5918611673905065, -2.900457378793743, -1.8218016091664313, -2.9755621921194755},
    {-5.44116173446767, -5.227163306676694, -4.602238080633111, -5.387087640375326, -4.869927146996107, -4.1642451076825155, -4.583821642358167, -5.383406159907036, -4.678901463670807, -4.826348374704176, -4.935111889358041, -4.08924184228309},
    {-2.3771558521530776, -2.872030504872477, -2.3712757301818126, -2.21433869248544, -2.419711103298276, -2.6464564866524327, -1.966624404103529, -2.575375812640712, -2.5849971309303146, -2.507903466064932, -3.0003334140295217, -1.6773477789933067},
    {-2.963570935910178, -3.0005605905213284, -2.519919314662053, -3.095663473585113, -2.436156238937761, -2.257933845164942, -2.991569125005182, -3.0536368742667963, -2.314379670996681, -2.6639836089602595, -3.5202297287068856, -2.811883852211785},
    {-2.051675473659675, -2.974681714995821, -2.134672199717766, -2.9215984483715207, -3.062354346846345, -3.2982980076502697, -2.870458611467666, -2.7988702167114075, -2.3402348608354093, -3.219842734495692, -2.6598685138050855, -2.9199984671379897},
    {-2.607666567532856, -1.6119564787443397, -2.992757441751775, -2.025005168096392, -2.8204582938751392, -3.2388139978512087, -3.264510748842359, -2.705610167628943, -3.125901873721458, -2.8242641880053565, -2.4544010875329065, -2.7841756662955572},
    {-2.69449052845933, -2.7959748143298704, -2.315597313805449, -2.6176770434300276, -1.9647781037581384, -2.5648223827911285, -2.6411238534394275, -1.8675933283546131, -2.6196570362226512, -3.356873336961794, -1.960351197509722, -2.586523329943276},
    {-2.7739389812647706, -2.77144292458465, -2.9645544475488856, -2.102002051405643, -2.7243485398569267, -2.689064216804774, -2.552359695705596, -2.6433408869943102, -3.11882237244844, -2.43654271126063, -2.8169976175842644, -2.1770285339962676},
    {-4.385432252703193, -4.534595865542565, -4.404534968738721, -4.59430594620229, -5.0263524771070385, -4.416360702865916, -4.7192377155406, -3.768972194760309, -4.650158376021489, -4.942396022465158, -4.397967446486807, -5.403019444576785},
    {-3.3724119919184474, -2.9717940919768018, -3.197268188539155, -3.0410209602350258, -2.648562727638178, -2.6784086024590423, -2.7934933820931693, -2.9157356259735865, -3.2790486368009417, -2.559259790305205, -2.952382932356728, -3.005501879204349},
    {-2.9991945873720036, -2.920650325551228, -3.1032452151771257, -2.153729752346593, -2.6268855667827022, -2.547642651914947, -2.6213872126434397, -2.498662203309647, -1.0567221680949903, -2.3747263356960535, -2.315279918499596, -2.349630612030642},
    {-4.469147419089452, -4.3048032561609775, -5.1449427332961255, -4.098934109952231, -4.429992109168596, -5.558415513142634, -4.8124040720130985, -4.983773925857301, -4.722270318454365, -4.389941039676315, -4.77051844548841, -4.521272146019771}
};

static const float b2[12] = {-3.306503416775418, -3.7410240417434886, -2.1074972929472837, -3.43573021905541, -2.9656626025685413, -2.3921579996771025, -2.9853128477360125, -3.9442177409528454, -1.540889278735841, -3.3975727218893224, -3.1049462962647616, -3.1491632940453744};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
