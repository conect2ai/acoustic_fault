#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {2.212435340920476, -0.7478841017227235, 1.201090248296427, 1.3345687223601257, 2.016372167563036, 1.4682093703334518, 1.7125873500301347, -0.19113077573956372, -0.0011547445204410733, -0.5992130525213318, -0.9585174333180733, -0.6096776172951395, 1.3641090734919337, -0.08604524800065012, -1.41823996070832, 1.1993483958336184, 3.3714743590028227, 0.21793311403541207, -0.6417544459988637, -1.0281090546786962, 0.8245988230118099, 0.3726357884185747, 1.4778965732276446, -1.867079229224578, 0.7055029913045026, 0.9749303426747441, -0.11957346375641995, -0.18331049930679955, -0.098037250539741, -0.5372833015462067, -1.5334361374720498, -0.3686250945723715, -0.023199992186815562, 0.5201446967936751, -0.8992707148768686, -0.3616350360947994, -0.10212377374149757, 0.5445615066321899, 2.193337421549641, -0.1456935239338035, -0.6628032013363147, 0.7227439093094318, -1.8551188225431927, -0.10253784662168527, 0.19687934394358922, 0.11257360287332095, 0.6682658080324638, 1.9439713999322277, -0.3704458160005283, -1.1803115497562437, 0.019483896019279395, 0.900920644374902, 2.5738657070681743, -0.011740699606667194, 0.5603008185914995, 0.672244023746246, 0.8698809541012686, -0.2558293682150271, 1.7707067406471788, -1.0636499528333785, -1.8335211366854458, -0.6572715271370217, 0.28485653137342326, 0.001672055372040649},
    {-0.4402648420195077, -0.4965236521837202, -0.8377486492268729, -0.6873953730373259, -0.06690333757918955, -0.008430985347002921, -0.01462411854939463, 0.7393277006685429, 0.9056226814202524, -0.2979609735590487, 1.0229646624359845, -0.4264224831959385, 0.3947820142052902, 1.8838019182217125, -1.250074539895217, -2.49566659556184, -0.12851273825069984, -1.314383759210285, -0.94747266185405, 0.6215486670544887, -1.605025651893411, -1.080895092122597, 0.29531215816861933, -0.03375804250381936, -0.4150224743482848, 1.1289780493839336, 0.32958777882801854, -1.7671727017081322, 2.406131292490998, -1.6105348502038082, 1.6588739502464822, -2.6798709839616603, 0.03747037978361465, -0.6448409395846049, -0.9640513269563997, 0.0481954794775305, -0.56984098231707, -2.1254332160242995, -1.3746086857066202, -0.3339681983648504, -0.6615633500656635, 0.27062255270097646, -0.3044414897786551, 0.9495645542701028, 1.6034619146499618, 0.7040846568964017, 0.3922611659087554, 1.211295794083279, -1.0102166132528483, -2.1084715591321914, -0.09242018775025364, -0.13839308570319153, 2.3510310437227853, -1.7128315102837692, -0.007619240160601584, 1.8302604951202466, 0.2115479718633034, -0.2109129632886657, -1.289066046267552, -0.04502392107778021, -1.0962422529171416, -3.3872113946181592, -0.8882628453764586, -1.286819342751991},
    {1.2638487578387618, 0.4905216072652859, -0.27950687351398956, 1.2650669321931636, 2.166674796623795, 2.740263939411732, -1.3611105679729398, -1.8478485774683193, 0.6113592128492135, -1.2221781785653318, 1.205179098594565, -0.4761416407769645, -0.1458794002023991, -0.35579097412793104, -1.9824600432189203, 1.1012923552608125, -0.5120298525496059, 0.26925504263759514, -1.8347179077001756, -0.44972434535867784, -0.45711761815727425, -1.5657004022810714, -1.1285443201999652, -2.642112541555542, -0.04571254244927566, -0.05225086943570591, 0.3078847850323617, -0.700054765918428, -0.6947412911928437, -0.2146311243897064, -0.5609988455639053, -1.1507864839844815, -1.7672548676938964, -0.2768334399400413, -1.447128253889139, 1.6396820978142843, 1.044692897252844, -0.8528431253720347, 1.1735151166455176, 0.033637054042423446, 0.08352861780856537, 1.0265829098308166, 2.189846808637444, 0.7318999983154972, -0.010037279180632262, -1.7280064571063718, 0.45307964828657843, -0.6232957986535897, 2.0304437442196184, -0.49263346741605, 0.8937575370697901, 1.4625038156715118, -0.9661014509488804, 0.11339147486760828, 1.2109685119430251, 1.0488533619875138, 0.9618191813107119, 0.9494484568551382, -0.3998322269031629, 0.9108040873908206, 1.6252949816181963, -2.491750387539379, 2.3486896183630224, -0.8797201971635686},
    {0.2703091420604155, -1.1655782491333846, -1.5059366687353695, -0.48180480580106533, 0.06546554273542901, 1.699091657452326, -1.3634775936476724, -1.215166333238229, -0.3958803404573288, -2.021242472713073, -1.7475284790730905, -1.2615208243229168, -0.27750437391016575, 1.583854967430373, -1.0915357991590844, 0.27637884696952614, 0.12905616005375314, -0.5072981474775944, -1.365764390867366, -4.1500723992122905, 1.8905304808245227, -1.5927890602041694, 0.6436115899371959, -2.4364965932921296, 0.1015055101463923, -0.09892156309039771, 1.5412976890193348, 0.05078238046036588, -0.7281010553005459, -1.8709234214505315, -1.3458970178216803, -1.572040388907829, 0.964727048613112, 0.7162947591783365, -1.1614507979181454, -2.2105414195496267, -0.003307999402639229, -0.4593387404294027, -0.12081093493827992, 0.19234463680976832, -1.402928528186129, -0.4418596421191838, -2.221733812731029, 0.3531703609066994, 0.5158096092856368, -0.08678759462029544, -0.12315494467428267, -0.5981831373244211, 2.017072411487755, -0.08530955289098346, -0.349567183497842, -0.7868867396262288, 1.7297706502390604, -0.7177242023517257, 1.1893250213950601, 1.059683001284493, 0.7329891287961919, 2.1457276310616074, 0.7070953980752437, -0.9059936448038262, 0.49385246816702333, -0.9385710099886253, -0.4480698758609211, 0.25033817582047324},
    {-0.6573532472041232, -1.245297741607916, 1.5898462174507286, -0.8167820404508863, 0.29726361221949726, 0.28660277928165384, -1.120653474647543, -0.08682883472100113, -1.2368313140140035, -1.9542519472610205, -1.716456382258263, -1.5241937607559064, -1.9368479671663261, 2.376923678560517, -0.8557952670818543, 1.572386086485663, -0.5881782456644173, -0.3966920328644143, 0.19991768208377458, -0.5698974596419224, -0.28139142764027253, -0.312685654001518, -2.317689249983571, -0.24987507850310892, 1.1448637621045474, -0.15023010510072504, 0.34289873436763557, 1.2765593243472104, 0.10841864429066707, 0.4027687889763053, -1.7302590421936963, -0.2612462010006248, -1.1943187484169133, -0.545589666966908, -0.5230205087081444, -0.2887109917261185, -1.615384326448835, 0.9588143343015573, 0.5954426933692368, -1.5765996360850554, -0.1304965319240776, 0.8237686185877935, -1.085711933547035, 0.29385911916732155, -1.0042968410660431, 0.18500755713334957, 2.569757483225802, -0.8259301862808346, 2.0604464806008, -1.002343517682278, 0.9192936296149238, -1.076721767128393, 0.6742836582248121, -2.8183233944760637, 0.7514529480913676, 0.8734354565464416, 0.16484452480330425, -0.48440189794367705, -1.681765626560766, -0.4922584335159429, -0.3550248367330971, -0.656884291764858, -0.6104394633632785, -1.1732402494067369},
    {0.06862315884015582, 0.8470493233480129, 0.8139058490255892, -1.1545239802272558, -0.8700169853697531, -0.4244995369387089, -1.1522037750710297, 0.036616310453772866, -0.7202658655287975, -1.8022327536467926, -1.5905675941279125, -1.2542311341798085, -2.964572684608651, 0.528938491726106, -1.0313954851038036, 2.3521971290689416, 0.3362292941338265, -2.034366113900301, 0.8191321349011875, -0.5247941673770897, 1.3055862480515492, 0.19794105919100838, -2.2599231335321073, -1.2270837072028957, 3.274848926102306, -0.3042106028680347, -1.1384115079019388, 0.028052981158846284, 2.097232217353677, -0.9962382321455332, -0.5802826363927938, -1.234522370880026, -1.6753656774976577, -1.6218674506425799, -2.0026495021150432, 0.7780788695210931, -1.2100872961328064, -0.9028524067361231, -0.009109162526363176, 0.4317368713667286, 0.3627877798260811, 1.6814720760267314, -0.9054258996192608, 0.31007319581788434, -0.6262504951727624, -0.15601788601741098, 2.2346297643020545, -1.368279832287496, 1.2790561960805757, -2.048945413152547, 0.19549991476562806, -1.50021188934819, -1.1804720420901598, -3.9118337648650363, -0.2247687052849964, -0.5304475117001661, -1.5759957484624563, -0.6369057785090438, -1.2177694005891837, -1.075926480585108, 0.2992353265477425, -1.0379595608399075, 0.9857302065702839, 0.7468787020326857},
    {1.182991396854167, -1.161348480893204, 1.2082862077917427, -0.1653681944101645, -1.5624340016643208, 1.1229745535316766, -2.2293858804585964, 0.8237081836246674, -0.45170555646793864, -1.5480699305828884, -1.177307510392906, -0.8931064035109503, -0.7529076972707163, -2.202116169438998, -1.8427909011289907, 2.2379611441522207, -1.9649949202937145, -0.5768526014251946, -1.6685884765864847, 0.30795410448669114, 1.2735206490541116, 1.093676455850699, -2.8502297651994413, -1.2097538827995722, 0.8542446781325821, -2.4029861193402144, -1.4525613939240964, 1.5518210999599473, 0.9145455445742249, -0.8776064450666125, -0.7725115842636556, -1.5946245965588772, -1.4897010321167412, -1.112637365806821, -3.4530942750115163, 0.9676122586893846, -0.5256722826055669, 0.3760036908637016, -1.4255657015654442, -2.392284843811135, -0.2569419315203039, 1.765997796374115, -0.9463722266438692, 1.1133580787015278, 1.103037433746048, -0.6168529629384496, 0.4349257092072303, -0.7475608519944705, 0.2295553951188999, -0.20566514293971647, 0.15391726933901168, 0.6095893108120767, 1.2955063030512755, -2.044689232626634, -2.2867245815432224, -0.38287743123822715, 0.4232449793378258, -0.9526116570866996, -1.2412094969253944, 1.7337808614172956, -1.5491711657092895, 0.8866374243573025, -0.6588553647250806, -0.7124599999671352},
    {-0.05440041448047119, -1.1572571360978976, 0.39483155446658874, 1.1255718124645602, -0.8291584620028636, 1.1477966158077502, -0.690247336811964, 1.3336711560807513, -1.3862663114211007, -3.2322007144249683, -0.16872809939443228, -1.387290839412259, -1.6353684100659605, -1.7785572118261346, -2.187285904637372, 0.9099707496769569, 0.9819605680369682, -1.4749527230292538, 0.33841015545101644, -1.1164043825767336, 1.7999026545470902, -0.5722333244613236, 1.1942123192199339, -2.5711991968619388, 1.9142804345185165, -0.1360086323135342, 0.08136343899121383, 0.10453103505177937, -1.6237745468270932, -1.2204957659365074, 1.9722321214263847, -1.7897521897047433, -0.8555966810968431, -2.702879905927507, -1.6055849988230928, -1.2340083795555237, -0.5486538441506468, 0.035702979833329346, 0.4421893411714369, 0.8353229894855806, 0.2378777784084678, 0.7757050683329691, -0.5910600969754278, 1.8323127936821018, 1.8364859746067155, -0.08481437418570986, 1.3928075435021081, -1.0051180220249638, 0.9040307601411323, -1.1391520704420908, 0.6700114161430757, -0.6693892489676225, 0.38604355870900664, -2.1554052700019795, 1.4229360418857604, -0.6223251596932021, 0.8477107733499053, -0.19848537208630934, -1.5192540755636554, -0.8980971669950025, -0.38589575611196775, -2.4652602757382605, 0.3476403973438458, 0.1382077779659145},
    {-0.9697035078133313, -2.7699184909548755, 2.2281326403818698, 0.21692692459908533, -0.05801729251939714, 2.3540624607088283, -1.708741334827997, -1.9802834866919938, 0.6855718088025922, -1.6708619418975912, -1.0787471826609167, -1.9357713260659637, -0.8925513508597942, -0.6101421952355626, -0.8229166591188722, 0.6548091876782827, -1.1475832972456423, -1.005444384399927, 1.1406611173882155, -1.6841302872818575, 1.099440504479122, -2.8408269658389886, -1.0633067773225549, -0.6534348336212643, -0.962939265619125, 1.8631525898012682, -0.6336379670972495, -0.5341541755603696, -1.2543403613522106, 0.4020068324557614, -1.620738801251904, -0.3332762532469452, -1.1437421304842652, 0.36596605117971315, 0.07381048065445585, -1.3685432106686883, 0.4282751831735783, -0.5462241932653756, 1.1769988047209141, 1.5147961907050451, 0.2701205476268345, -0.08425364272302913, -1.8803517215524224, -0.24016396900680775, 0.9941424633220317, -1.2255830161548043, 0.8120315057274643, -0.8391339726222218, 1.6883798119960622, -0.4552395880868029, 0.02069806254105816, 0.16727801789761856, -0.6955852499408665, -1.5168643384301335, 2.4615710882864197, -1.581839109089854, 0.8539703059471853, -0.10876322839081884, -1.353088768379625, -0.8365328081850374, -1.0945167728733318, -2.8775914574873487, -1.7703193136367963, -0.7580960586347878},
    {1.1203284640782265, 1.209084143781096, 1.4435563145154242, 1.1627885276547603, -0.10243064380935091, -0.6177614355184115, -1.801707196435231, 1.278569457602575, 0.42901939896916563, -2.231786955887414, -1.8754842416527877, -0.5768541343339625, 0.21806328709158918, 0.21546062612790107, -0.8816697121685954, 1.6666887842524383, 0.20918580302674422, -0.6009589949325498, -0.6182051456847414, -1.1459324034949079, 0.22666600201631937, -1.4611266075493792, -0.059613489547496464, -1.7020885987578573, -0.9055747883173918, -0.6367732232157008, -1.8980223519293915, -1.5086435156616873, -1.1760465432932972, -1.980538090787512, 0.45655261386909063, -0.9606969515399285, 0.8031340099589799, 1.195748546376027, -2.3966880677186855, 0.9538689893465676, 0.9092437370735033, -1.4558294527853148, -0.7145932523734397, -0.035966901809300976, -1.4602647053848283, -0.17141239744544937, -1.5971078489803494, 2.228480804617167, 0.9661883354620971, 0.5380566646783785, 2.0662678698702157, 0.1030702427744687, 2.7726055487123653, -1.6567293152376383, -1.5261307823697154, 1.6207958954633124, 1.6538278191339313, -0.6394368878655272, -0.7207525513045473, 0.9240628281058019, -0.0932313666277035, 0.9692311199008729, 0.376085771796191, -1.8780168048847017, -1.0493249247971868, -2.0320763625337377, -1.1400273667277088, -1.2571929279940481},
    {1.2996836150878581, 0.5967745216797118, -0.4977582207814068, -0.3782300670415892, 0.8957819331279294, 1.4490715639310885, 1.296417610849079, -0.39641114574939834, -0.031188506444568064, -0.1866937719433996, 0.043273099075398405, -1.7024318612228164, -1.287343351146941, -0.37016619278753626, -0.9153066986095396, -0.3114890349014867, 1.603114167308994, 0.029836916903097983, -0.9755238427234912, -2.2475457252214057, 0.7286116355103502, 0.06984378229577358, -1.7385409940383185, -0.2880845482327219, 2.392486566758247, -0.36725650670244964, 1.3547896454640493, 1.8438821852389922, -0.11369878550640562, -1.0996528389778335, 0.6812123555205138, -2.469401460050777, -0.48452579658274814, -1.2471951439358087, 1.4954696907147602, 0.20716084660567535, -1.7583872136358651, -1.3378507940152347, 0.614439914941441, 0.4321313093160295, 0.523459526165135, 0.7792889689854862, -0.8275976025609715, 1.382412132624168, 0.03848771989568746, -0.9251490353978745, 0.46270560176972697, -1.2190922100029131, -1.6418951750389097, 0.13794243694445796, 0.1264458147113156, -0.8303054219177082, 0.7802968129680585, -0.8852652527936496, -0.15167417759903706, -0.07589389364814422, -1.2764794854672867, 0.7810308556431969, -1.2439127236795011, -0.9500767421240239, 0.1787824943578857, -1.6922713877942157, -0.3861342836985012, -0.499635157212432},
    {-1.411903520510927, -1.6062462979876837, 1.5608431527486901, -2.7833365087763506, -1.0609079704694686, 0.8652638594590571, 0.9269495634753532, 0.33426760166916825, -1.4764908228153124, -3.1999615777567443, -1.4573672529048372, 0.8583589805382773, 0.3244951257126459, -0.25502253203086606, -1.0112861908849822, -0.41617474580494, 1.6967998585985526, -1.6485787554959814, -0.2472961812642828, -1.520428883451581, 0.24133428684227415, 0.14291043538071074, -0.0016357079788783483, 0.20354754556140217, -0.34496413461591563, -1.4271285380371226, 0.13516590022793698, 0.33562460600804084, -0.12799174925090195, -3.3929562739425436, -2.759893621219938, -1.7084914952148027, -0.43191230477249476, -0.6196893100147317, -0.27877278334982736, 0.19276972285970298, 0.6479158230984923, -2.5014172030363677, -1.581636522601231, -0.885616459110903, -2.8584532059031456, 0.13486663850794522, -0.019613458130921656, 1.8412668596476698, 1.006701197926157, -0.987475691011868, -0.474167975394099, 0.3737536571135884, -1.0286495079839921, 0.2850972572851881, -1.6681738284023917, -1.0742116072729622, 0.46070287694893003, -0.08694119122471901, 0.2664084598012841, 1.3205200636695555, -0.39787294956300223, 0.8784783432917385, -1.6998039804995508, 0.15242904348891342, 0.4670397557300295, -1.8085104415948094, -0.7949265325519794, -1.7341340551652236},
    {-1.2335291345902282, -2.260323619435941, 1.1155577021649012, -1.4810691155005131, 0.28690767812410994, -0.37168795597660564, -0.3746061546799511, -0.2813292812081992, -1.407543381810621, -0.5107811541585104, -0.23407663873860693, -0.15435971165818435, -0.4485726904642819, -1.0894151315145904, -0.5721922952866215, -1.0647226656397177, 2.409247701073101, -0.8596281826095481, -0.9118542807478172, -2.2560608237609268, 0.059847556708954856, -0.8207244589262694, -1.8187711605254078, -1.1707767795547928, -0.8983630180325523, -1.6324590464966615, -1.4526525469250775, -0.5683791962865705, -0.9925315080659778, 1.4750853546623555, 0.0394412247050374, -0.910113869296882, -0.6137411421743008, -2.689693372823977, -1.0956309942298101, -0.7614878071483762, -1.8334355139096057, -2.257240837241466, 1.3325555746384083, -0.20269124839448932, 0.016488860118579498, 1.3935353713645289, -2.260927279203139, -0.1173253266680484, 0.04476049685896171, -2.1469612672366982, 1.6065410910796944, -1.7828858138933912, 0.15637645091571392, -1.318817205508022, -0.1687305703196752, 1.4736004568168237, 0.07103517118539016, 0.33610832154572284, -0.19246441608428247, 0.6308224709279406, 1.60949479693645, -0.19759405062141963, -1.600020103425628, -0.31110904942645395, -0.34757029705076803, -1.193601126337603, -0.7172877764813909, 0.7857834257962186},
    {-1.115240358013812, 0.28089629799212434, 2.6169271348495657, -0.2285887349513669, -1.0926865792033622, -0.9625078569591342, -0.0632406598335785, -2.6233813980835405, 0.4163590765531142, -0.2760610718391128, -0.23947024429082844, -0.7002993974932871, 0.4647570646002286, -0.7855442607460534, -2.029732976195107, 0.5392261446410981, -0.7566535623864946, -0.8520877321897342, -1.3342259694317562, 0.8358384249515916, 0.8039792674308844, -1.2891876434139282, 0.45149112746488623, -0.7516338208886804, 0.24547087171708645, -0.10082736905550874, 0.23787121031196784, -0.8094691373735046, -1.1437220464433222, -0.9102278315654359, -0.27420015520381225, -0.2818916902519268, -0.1032423531224516, -0.17753372595161987, 0.9812852113527115, 1.4780648477845448, -0.4544102159548121, -2.1403560786497415, -1.196684180482833, 1.0799810891074029, -1.6315540485694613, 0.5355485159192548, -0.37901274219214526, 1.0549827811381598, 1.6691764375729368, -0.8188482345068248, 0.36222958487770995, -0.14559241627347017, 0.8719366430566468, -0.44562562371829584, -0.290638909312219, -0.6653729423286078, 0.3561973636699624, 0.13636852783938785, -0.09549306934994933, 0.4971555652055501, 2.105505603202952, -0.8763924595160584, -1.6896082505929846, 0.13289988732618696, 2.2250207866518057, -2.013792196657236, -0.07773724955989926, -1.3936648094102626},
    {0.6966149184842476, -0.29166544354679186, 0.36181975690913276, -1.8260206275885453, 1.860135102732951, 1.9084558267325114, 1.1315635965072992, 0.1052440744376082, -0.38412972158384207, -3.423070415082817, -2.0277817763684616, -1.4964641870686775, -0.533625521566377, 1.0921774663896364, -3.4564796434473104, 1.0822996782743917, 0.9170985779461677, -0.8967234217583976, -0.34619097355661377, 0.05083322261348777, 0.9615900030659317, -0.8781579315459292, -1.1297627433627682, 0.9591930148642075, 1.3098890085625765, -1.8347856647783574, -1.2964781750858623, -1.3844257474143125, 0.6769948626084056, -0.516345280077246, 0.15576733655312308, -0.03419934575916831, -0.9427398848830255, -2.1168449295434257, 1.258447719092208, -0.5182426851592763, 0.4317140578491249, -0.5889352540279681, 1.4508964845056311, -0.8261503808735353, 0.10436913071110077, -0.0005420814800986903, -1.8337243847885214, -0.4113127946869464, 1.7328117639463219, -0.8820721215448175, -0.23151450157023185, -0.31273028499660077, 1.249299313376556, 0.11559276793828785, -0.178617286472661, -0.7384539077906215, -0.18125001139746347, -1.5387392351061593, -1.503246435475637, 0.8724340625718973, 0.9997110613676893, 0.6941931983175126, -2.1070955295519873, 0.570325163872611, 0.5640678854796767, -1.5620453725422836, -1.6407834258376506, -0.46113386544424273},
    {1.1122268985008994, -0.09203072233251054, 0.5596798187980943, -0.5123307568162574, -0.39748308646486646, 1.842266533075803, 0.5171698782580453, -0.3681429992050497, -2.3064790994604865, -2.111391000797733, -1.044272865087203, -0.9420884558535724, -1.1604137145957767, 0.46734313451567905, -0.9623289805461872, -0.2706938497427098, 1.635020020784532, -1.7292863534614653, -1.9316527584417933, 0.1662730376719112, 2.592347887128391, -0.8789100148956991, -1.7242755138504782, -0.7522770741564228, 0.07531984686720224, -1.8663441504956437, -1.4997078614352986, -1.8661474847877724, 0.4495917710262736, -1.7622609477882993, -0.4036486208055003, -3.425600445051288, -0.21210564808912435, -0.8583204290592695, -0.31947006678506534, -0.0053149296116517565, 0.16953668866944951, -0.994946264597978, -0.19006988234023883, -0.24740685702402643, 1.6195191723234499, -0.5953343296945769, -0.5029056965438313, 0.1626494620542207, 0.016573258760550588, -2.7698567145256012, 0.28072934155753226, -1.482462279900923, 1.050924913523968, -1.1542142895165963, 0.19414944758790909, 0.6704172288920132, 1.5503992539842257, -0.8081065274294927, 0.7834435267337626, 1.2861734127249398, 1.3704506788839068, -0.9330773618358412, -0.5020165771873272, -0.7360858242463338, 0.09531843927082646, -2.511769387349337, 0.7275839142358104, -0.5253475632849793},
    {-0.6507664630031562, -0.9001489001226664, -0.0817686125448355, 1.1976145069479873, -0.010008208402516011, -0.21059636093661266, -1.4255387026026831, -0.6971495306636973, 1.4358083542635993, -0.7760599514462697, 0.9084536950945656, -0.3649601084183259, -1.7793211692350817, 1.3897215277849608, -1.6393700265436408, 2.256834283252809, -0.24071133853565693, -1.513503035579348, -2.5668952805437257, -1.0562943556365068, -1.2628559536237136, -1.6899360849442644, -0.7783273781437016, -1.2357020866527202, -0.14471349931980496, -0.5627765346585728, -2.322469060786728, -1.4697225907266454, 1.4305052364716564, -2.4289779189527576, 0.8193281308542362, -1.6696848353518712, 0.462204124481283, -0.8786364241815308, 0.9133467833102518, -0.08467121930187223, 0.3494436460091347, -1.0471674131126187, 1.7553884847828074, 0.018973157543448166, 0.22265754358317463, -1.498234463695391, -0.04199188403014958, 2.6100997318865264, 0.2020170627076769, -1.3375976493863144, 0.32275372655814155, -1.205097105836641, 1.4762247008693192, 1.72171291454729, 0.776658428074003, -0.6099223372409422, -1.360352755217935, -0.30193171165639726, 0.699650706056792, 0.4791304414427326, 2.3553629503995572, -0.7179931423493716, -0.825323948777419, 1.158179495613641, 0.9887885578934378, -1.4476550318890746, -1.7458173612369186, 0.8649379154488013},
    {-0.5363323278723174, 0.5225004076906358, 1.6454035905961149, -0.8558461223655113, 0.8506919564497561, 2.6032565298217065, -1.7014747241955785, -0.6535639585426318, -1.6261635883162233, 0.464204100576919, -1.029371426256955, -0.7131646383990674, -0.4678175190300484, 0.5457473544962751, -0.9037472470439257, 2.5607681442765133, -0.4888963014274143, -0.9990723199789782, -0.9139498234374858, -0.6682068080012197, 1.5381745073007282, 1.5965609004727837, -1.4821676934324042, -1.1260148386097408, -0.9254199251900131, -0.7015447281181622, 0.3481389721390434, -0.7692084534197096, -0.9481474885816472, -1.1999602878025748, -0.24521282808241804, -0.044766076505234224, 0.3139736289752232, -0.5622558671610404, -1.0120158714960448, 0.10781596198216185, -0.09548648548557036, -0.6586917444078485, -0.12688837505825498, -0.7915078361077813, -1.6312032303386113, -0.4256076836729087, -1.323134075456195, 1.0950773718649032, -1.0544620618617868, -0.4980987366410962, 0.7999873107481733, -2.8485528953110535, 1.9458300533634156, -1.1138603845418777, -0.039877829013783755, 0.2528513522680876, 1.239310704422958, -0.7136794488099474, 1.4649156314537426, 1.6316337522699178, 2.23145523698021, 0.26725537703625457, -0.7650763254039946, -0.8560912350718051, 0.7087694544341524, -0.975523394196992, -0.40569726558384045, 0.15537729333034397},
    {-0.028865044803108707, 0.6401881388952749, 1.134166616986627, -0.990759914752335, 0.23632717853006746, 2.527518589460645, -0.7944642580243526, -1.0474163577247764, -0.3517906665174464, -2.67415304686039, -0.7632326891011271, -0.3401911838655884, -1.4753125896073556, 0.11502727963729731, -2.769090090775421, 0.8506378227570704, -0.5274449423677575, -0.7022648553213331, -0.47521094238073036, -1.0314917695102224, 0.30539122565811705, -2.2958492502925814, 1.795970229014461, -1.6859964717191354, 1.445370023884061, -1.1082142773637695, -0.7160655922122662, -1.054319969928167, 0.8481406022802748, -0.5782020896890706, 0.5239684973733457, 1.088623877054519, 0.04474764430819025, -1.8854447275350423, -1.2500857287318774, -1.0531014898519038, -0.9179076314488442, -0.7189553490452594, -0.050072793269217465, -1.601838746565274, -1.0543788867377213, 0.6203183658453355, 1.398349641531193, 1.17847421704245, -1.526912370085759, -1.7738686885612893, 2.0282221845176296, -0.5998115778115731, 1.5056123788676257, -1.546540658801298, 1.1107612703946046, 1.6106160396350642, 0.7244061462550234, -1.5553078751623957, -1.26009551914849, 1.0677333111480416, 3.0980768704597854, 3.073208746565799, -1.3976790008410296, -0.22587707612061725, 1.1950967993606005, -2.3984515733004996, 0.0035410923500274927, 0.7250688118854138},
    {-0.1807812718430615, -0.9997478244284066, 0.007149612671642375, -2.0889592589850303, -0.033700366729793006, 1.0675543648312908, -1.6428420970191213, -1.1137522215418174, -0.0852952866908026, -2.1427949281486285, -0.7084316260852502, -1.4176375748791221, 0.3952251860184738, -0.05493311642925057, -1.7875913507236985, 2.145374805034641, 0.008600484085417371, -1.9619848171331495, -0.4049592218722415, 2.899912948371177, 1.4076708831103573, -1.4009222745220005, -1.0203434174711674, -1.9216035642074025, -0.6064035805089594, -2.124430184076042, -0.5981192273583376, -1.2409173560600042, -0.9013222558748883, -2.216077151532055, -2.1262210502150385, -1.7901820671562805, -0.41162210679688344, -0.6882140958503169, -0.6329490546528423, -0.8383554885838912, 1.3370662091162686, -1.2294002679997649, 0.44653003559316096, -0.2791713948938492, 0.28335420186612387, 0.381635251080668, -1.716809424044365, 1.4759221415172405, -0.22610767686212438, -1.041508430421873, 0.7105703728312083, -0.2732553685464563, 1.0119999830160211, -1.8788537732288306, -0.6564272138329305, -0.4861461069934543, -0.0545569563772788, -2.160131299252234, 1.4729496355683724, -0.7400175764704839, 0.15549156618060472, 1.583428263202271, -1.7283521256469196, 0.6348051030809575, 1.9659714603164353, -1.5603084039769652, -0.689431743904139, -0.04785451132621274},
    {0.11431252008261536, -1.6343505831936818, 1.3942936293227652, -1.7621812245973258, -0.6192897304497839, 2.54692689868384, -0.38034885452837125, 0.6753143926950822, -1.9630809561234415, -2.419217287249307, 1.167932722138776, -0.502888050861999, 0.613808133739443, -0.6285285378115382, -2.2327912056743022, 0.9242924497003616, 0.36086807882225, -0.2834046080462319, 0.5569357890448957, -0.11356852006528893, -0.3918038302020087, 0.5254446407436513, 1.1511142155476008, -0.6856046566981561, 1.9432662370439129, -3.101260916422546, 1.3578181377579681, -1.853432532314929, -2.008339500419913, -0.6629148200748948, -1.4055142600481798, -1.8197814735106017, -1.6885968269115004, -1.4097647816619479, 0.07014239797407415, -0.35917878222588023, -0.4362820773359556, 0.13043793457610522, 0.6105843388757031, 0.7167057752641256, 0.3671348183116035, -1.0438453262667355, -1.2911480164767204, 0.34082553380685865, 1.4575161388448508, -1.4024208774115037, 0.7509118813046537, -1.0483533445347442, 1.2191323212791525, -1.523229521900842, -0.7571038252012243, 1.2625043146247108, 1.7525864996248377, -1.671633417150991, 0.32422526721586964, 0.5873317076442526, -0.7019283692302739, 1.0087494355729096, -1.2197415661077105, -3.640115475338289, -0.40349005350979905, -1.0676225557938792, 0.9545735450493149, 0.9712707601638986},
    {-1.4432117017060937, -0.009419737950520209, 0.9225632128633182, -0.4467437400192968, -0.16232601888234954, 3.1636111676600227, 0.16476846169823556, -0.4291973732136591, 0.6593065786262919, -3.7690015156339283, -0.9053995419821415, -2.2129063870670156, 0.7634465954821699, 0.3560721047142771, -1.890185770969254, 2.660539801106892, 0.13127603120981152, -1.0481825136362521, -1.0807020548367756, 0.04956375453921903, 2.3694257137193797, -0.2963599819924439, -0.7789331510697695, -1.6155722586827148, 0.22570075320409339, 0.5411125904475322, 0.05425533619989278, -1.1581337315324833, 0.24918592967317235, -2.0911835378571952, -1.461733404646179, -0.30095031675446005, -0.46269991270998045, 1.135189250461345, -1.2678677761071486, 0.32641782925320356, 0.2362466613231686, -1.5123715584654591, 0.8915070592765464, -0.01801150023137644, 0.1335942707161505, 0.3385508528240409, -0.24572579241628043, 1.6951076346854281, 1.0558689212612813, 0.17664606073630781, 1.8791709543300175, 0.30702143463145565, -0.17220889283075858, 0.6111729854167344, 0.16059938904542598, -0.7433425790551967, 3.485802091924675, -1.294339357423342, 0.3015594843829288, 1.402096309601287, 0.29729582282724565, 1.430512888612754, -1.0991068190094824, -2.0749549462221926, -1.0906328585815035, -1.3407612256154782, 0.006007403592510796, 0.10985755901812183},
    {0.7342805129673186, 0.19584514153072394, 0.9137439409544619, 0.6328119098278648, 2.1845102732862496, 2.0217895122739415, -0.8478867918899015, -1.6766186682712678, -2.6330003729035125, -0.07362778696213275, -1.981371590180825, 0.5416676904807203, -0.15585966793464484, 2.0759886772676817, -1.7934101238829605, 3.817126518062969, 1.4201791131316406, -0.7591641217479083, 0.9835408680065012, -0.63504958452193, 1.205747148738744, -0.9014557449859475, -0.11879138573851024, -0.705135897916945, 0.6943706167641086, -2.134400261493661, 0.08016180068369147, 1.2023553353714813, -0.35263021401987815, -0.5189205085039325, -1.554796658987476, 0.416471529781326, -0.8406706447515431, -0.5267463774760971, 0.0028107030050773217, 1.3321225219455064, 1.7828875382076912, -1.4374967814128568, -0.7019180466103293, -0.3027256535898686, -0.38543119650733176, 1.0005760013294789, 1.315156189170164, 2.77636730570984, 0.1869031222145924, -0.8034445464321335, 1.0539650967318344, -2.3808663361904827, -0.3116303317163227, 0.37140721874210403, -1.2172523176636998, -0.5371846199106384, 0.5938612858574827, -1.4509727011174276, 0.17587768729249376, 0.41415558367030986, 1.8834363246720185, 0.5152065381721359, -1.7719719449914446, 0.07409131415532716, -0.5690598624655824, -0.4471054105042507, -1.2138852188051852, 0.36404275561912813},
    {0.12890886173540547, -1.6431031423144091, -0.1680935741326394, 0.15251259319623325, 0.29212155862224154, 2.869515460788315, -0.9008903238158498, -1.62430149924503, -0.8838015222933727, 0.5463826398678182, 0.36004387125028636, -0.778427608775026, 0.9540627528603236, 0.09744376531035413, -1.0907783650004006, 1.066840943982235, 1.9949029235212463, 0.04848132985237824, 0.0352285285327534, 0.20386616037156244, 0.8183415346713123, -0.3967453946655476, 0.08271094077562367, 0.014543280253224704, 0.4142057381865353, -0.4462963189887208, 0.3388763312915152, -1.4162461937629751, 1.0871439010609558, -1.787085250038902, 0.6527347112847293, -1.0691646764801699, -0.08375203498924474, -1.4741944217252512, 1.250524461348051, 0.624451457315445, -0.7022943885766214, -0.31267423643317316, 0.6503911250049339, -1.2886155719853714, -1.4851733377088743, 0.3244749481470258, 0.1393101017013735, 1.7969357107799573, -0.33846061547194745, -0.10438018960780067, 0.28718560828819784, -1.161505991763275, 0.7720626141630874, -0.34250474049074897, -1.4155016768009916, -0.8747483852445155, 1.4990711698457906, -0.7424508919478613, 0.4986597570500603, 1.5167946648937023, 1.664204599624485, 0.6076090354308544, -1.1873203400570427, 0.25927389089959046, 0.21308220881772966, 0.12787134649464432, 1.4994336688620933, -0.7654027262661881},
    {2.09256511407086, -1.8235258063425246, 1.728983414150783, 0.37636086390689427, -0.805901528598754, -0.14259699882843, 1.202338449412404, 1.4729336584267503, -0.12988050774670853, -1.099288956744317, -0.09328571031744654, 1.1935478321489563, 0.1617199000809935, 0.9555723561492439, -2.0932663530497697, -1.018207763733553, 0.17250364714281038, -1.0988972382357307, -0.2815301097736665, 0.09277760458604131, 2.861947419154378, -1.547153141644492, -0.13492738147495495, -1.2406445803191648, 1.0585269870054588, -0.886941776234294, -0.34093146570559824, 0.436504479690152, -0.1891894939519086, 0.10304038253521067, -2.380271067475793, 0.11507370063303667, -1.5954882539362396, -0.9374626503701304, 0.9022836695098776, 0.6644623365070046, -0.9249639123883283, -1.7136836589633166, -0.39988783562993874, 0.1832833190969946, -1.8268166972900832, -0.26982115637807086, -3.1769431854429215, 2.2635031521448727, 0.3713845757846806, -1.2816809769535116, 1.1832038104460578, -1.708527685514079, 0.9695673546458654, -1.2776646396984375, -1.7082432407241819, -0.6006888222780201, 1.605587299642332, -0.8992821989548593, 2.418981254760583, 0.22752540023762483, 1.6114964068802842, 3.997216078040999, -0.8003167399044775, -1.4589110644131031, 0.9018436226062275, -1.712855657837635, -1.2828311866043132, 0.8663968880421935},
    {2.2081892847570357, -3.0240063313226018, 1.6138695218144274, -1.101969590706016, -0.3461248216794622, 1.1824131915479763, -0.7103502148234156, -0.7763679250352534, 0.016466213134417755, -0.14930302177845145, 1.1257908078108358, -1.1842742480446349, 0.9471981096815502, 2.7265858418971596, -1.4070236537299186, -0.7067787068940289, -0.012148821494139648, -1.410570326211345, 0.09924216558104465, -0.9002464932362273, 1.8238333196419054, 0.9592797667615727, -0.4640995642334466, -2.675966222608756, -1.3445539672892197, -0.45824193087959114, 1.0344100502619915, -0.9809316298535096, -0.5293444805623216, -0.7078580918066799, -0.013547956254148626, -3.07632052621993, 0.32675101163031095, 0.17238593553489637, 2.6513284943156434, -0.5737749239048299, -0.7331233571851009, -3.735070339219499, 1.188151175815326, 1.9617038770003237, -1.5075646838178174, -0.19943065661261375, 0.6965641936532757, 0.8377124856099691, 1.6247714150268509, -1.593806404162606, 1.5958010868761476, -0.3748717412681376, 1.9124131788481686, -1.0052204497386357, -0.9094274806491275, 0.5906261426074498, 0.0845374613924279, 1.003084113050704, 1.0757618925876677, -0.4375944875691378, 0.8549868972431587, -1.3818881410539494, 1.4370306053099846, -0.6110784779344249, -0.5563641848430693, -0.5654246770603726, -0.5351313022910201, -0.143268396979644},
    {0.4179372015328715, -2.3844395747094502, 1.9416620975461374, -2.6555287506674397, -0.9046955226222754, 2.5455390023422506, -0.5024721673950434, -0.6089852522758806, -1.7401232170974914, -2.759161896663986, 1.8025803901489341, 1.079694431372248, -0.21686786953378293, 1.3431797363698708, -0.3091907104857708, 0.8502244539733113, -0.1331952669208775, -0.8516275104925914, -0.8312917409643386, -1.2638008795268765, 0.7328802200362947, 1.895422016677778, 0.4683020834116693, -0.03634052919115004, 1.1060340172875711, -1.5117783243317617, 1.163861282089158, -1.30949798640237, -1.6269738792671773, -1.349990967418141, -1.7795755657742893, -0.8129036527253518, 0.39928718016248743, -1.332602871917386, -0.07721657992175948, 1.2653485717231192, -0.8539820374123192, -0.40441947807881423, 0.21459134367744365, 0.8014554722055137, -0.25140229628596866, -1.4099710310585645, -1.0247659207845239, 1.8398874823961398, 2.0245932204838395, 0.762326435360558, 1.648998067812188, -1.633653877561173, -1.3797619612238565, 0.4645558095786733, 0.42533611728673315, 0.2973299210687833, 1.4239564476312592, 0.21294934956817127, 0.21050108555370375, 0.7793432109310484, -0.25916991838316206, 0.8978500158681294, -1.8029878264952823, -0.37898444885081956, 0.5987012906701181, -0.7150518220076275, -0.6498241008872322, 0.5423857999646343},
    {1.4654134448613998, -2.471932031829557, 0.8121927474777878, 2.6187940013499786, 1.0569045573989113, 1.2068700444481217, 1.766638248050125, -1.735670791932491, 0.1928439639836087, -0.5699731173282956, -1.0525984508178723, -0.5220067357705791, 1.3221979220669473, 1.3135447982584136, -0.09638715655634734, 1.4942151104814576, 0.40352983258199526, -2.2949929833297893, -1.9417020176606983, -1.6667366515926887, 0.9585132819518825, -0.23855899765752586, -0.5543429944873851, -0.5073229680282519, 0.6744688826072601, -1.4347927213786416, -0.48125079990651887, 0.3342101296079595, -0.4537300572482098, -3.85841775204984, -1.1792779230560568, -1.1865584686213988, 0.40752340428876493, 0.03895162943071753, 1.4668320908033514, 0.2538530594670077, 0.743160541885362, -0.5772035829713899, 0.25039959443126336, 2.2297935202897894, -0.15225108924295735, -1.3551170843178386, -1.0583029149972674, -0.21725616960724609, 1.4367829873793432, 0.3831094686142932, 1.2180212544267675, 2.4116946696625567, 2.8154288732478507, -0.24196241059973467, 0.12225425054682584, -0.6891898754653147, 0.9389779585442278, -1.0931233869675325, -0.47495486244277085, 0.7933167332951488, 1.1276502016749788, 0.05339902320264969, -0.8578430933917985, -1.6320878759213124, 1.6270547258353512, -0.6885228952016835, -1.6212682620541217, 0.36782565925227806},
    {2.2418517946242256, -2.0478009265609796, 0.5207486411215627, -0.03127266165587065, 0.7039325543962573, 1.7139521494362706, 0.2364148347435003, -0.7010407026771989, 0.10615044920231224, -0.8018167076601515, -0.6290012021740026, -2.203045467161007, 1.2500861493364053, 0.3837507579877827, -1.2314564925730513, 1.2463541648192868, 0.337900666438547, -1.8125062643428123, -0.9446277455570748, -0.9498246661805388, -1.4264851225469275, -2.595154280768654, -0.6424802493675542, -0.06871340887289547, 1.1013311424055916, -0.2056983982869981, -0.05760133414426722, -0.7985014014525348, 0.5512956025738793, -2.74375724021344, -1.0601899014202218, -1.209123605940932, -1.638386508748511, -0.9579380982885732, -0.5850452357281898, 0.7252676452950215, 0.0770288872292497, -0.24081586840135605, 0.686397747407184, -0.8826638553123477, -0.5236718984807385, 0.49666532639210165, -2.108704114723186, -0.16216769461510638, -1.7564796405202274, -0.06477423405147438, 0.29948348696630595, -1.2965008134969727, 1.0327992968518829, 1.0765045602804961, 0.8721325355951448, 1.7775864706993112, 1.3360684426214886, -2.870886930653922, -0.4800580859629875, -1.2435027580285505, -0.3785402764979018, 0.097375974376769, -1.7189532054614403, -2.2949414359772833, -0.7427104371586971, -1.224791746208813, 0.7679948041730877, -2.865712157442164},
    {0.6100344079200836, -0.3020069927354794, -0.5853067810229794, -0.12695888236634878, 1.03915995173638, 0.3010374951173831, 0.2435188909700022, -1.0263694573911983, -1.3610548214405402, -3.146380247446246, -1.7283329602522546, -1.4841017114202912, 0.0454766166291023, -0.6877521282741045, -1.8231100774916524, 2.0191065060242943, 1.7677747603698895, 0.10371698148146423, -0.8472432493742821, -1.5937564606699228, 1.5195889046641373, -0.3816503989508191, -0.5537042218320007, -1.8197070683943612, 0.8597683624721304, 0.44959484609085265, -1.7940854392447385, -1.1216931266057923, 0.9217601165137909, -2.421658719861406, -0.006155752104743442, -0.9894801885710883, 1.2370940413739167, -0.5106782914686877, 0.8115789338326906, -0.18064594692122402, 0.47052587058683903, -1.4327548997846151, 0.05145971745413068, -0.5389381053313956, 1.0664680773192678, -0.2096211287176288, -1.5259005831056383, 0.18234364213072876, -1.0376168283479084, -1.9741009802199745, 0.9634155109172354, 0.6291126570209897, 1.854661615061959, -0.3621202885370195, 0.847095309198407, -2.649619673314731, 1.2343063008004487, -1.4206822168496658, -0.4320653581073387, 1.4224534850448498, 2.2410338127497, 2.1894249252728746, -1.201153610040274, -1.0524389519421298, 0.5554347791158329, -1.527179415748232, -1.7265616436503433, -1.4750096456669284},
    {1.054341609849102, 0.23644092396608427, -1.0151506087335298, 1.37434985410732, 0.22162290142098173, -0.9576037766725962, 0.4798008149536239, -0.9756337417181009, -0.513018379560819, -0.11285679031099614, -0.7577155604364139, 1.1068663002230283, -0.8444285282092304, -1.7586566963120678, -0.7252830304211648, 0.07368383343874006, -0.6058384602468246, -0.7684468822635719, -2.2318512761956515, -1.3382670064444695, 1.277961610535108, 1.9024249696935147, -0.4121287005597558, -0.4288876021400931, -1.5451862916704404, -0.7975183121775078, -1.10557620055596, 0.7730450216170806, -0.9159502973313048, -2.6814617714870868, 0.659673553517179, -2.958428692502055, 1.2576654531499514, 0.983484928150556, 0.7213566700122502, 1.2279436226644524, -0.20826811231571257, -0.02749614668936577, -1.1939381795468518, -1.7928860974339167, 0.25863665873328, 1.3360634868303334, -2.3198372020362417, -1.445279165296081, 1.0879839528315103, 0.7851434140472302, -1.0487723020175066, -0.9482894840708792, -1.7840364662674069, -1.839823176191377, -2.4810355546368466, 3.1118087801460756, -1.0078559047236395, -1.0590134512097744, 2.0693520818374855, 0.9603390448347123, 0.5006648090000965, -0.03439980765818231, -1.8295930760292543, 1.0734518520265492, -0.34726145730838975, -0.8576689516606921, 0.1938038695164454, -0.09080661734236034},
    {1.7230506256455338, 0.25575831139159905, 0.8125211968825535, 0.7387278427677846, 3.363586171328289, -0.6509972693161332, -0.9026572737157685, -0.8535627809818659, 0.04774142100884046, -0.44426890674945385, 1.6547850898677876, 0.6788400649969956, -0.6964181246519862, -0.9629918828254274, 0.04261291269824861, -1.0637526160793738, -0.07333695601529061, -0.4694772330890936, 0.27689886586239687, -0.6059858522613076, 0.8077721988828083, 1.0948659221518207, 1.4545551533652912, 0.3246417992042793, -0.3267275119509005, -1.4239939572374807, 0.8744245139070639, -1.0034250688868913, -0.3824058717626974, -0.22981137983735175, -0.6530483392820075, 1.1930362451101573, -1.5536671660578378, 0.539806352423538, 0.9389189647516082, -0.013010160154793783, 0.7991096591627818, -0.9058925550362074, -0.8252557230273639, 0.2846589378714033, -0.2633802270930687, 1.3395234126043614, 0.35190854391216375, -1.432976619685502, -0.2960255405557365, 1.384750316351657, 0.36106739713727654, 0.40985138214319383, 0.17817242765076194, -1.6824324511241913, -0.9976223254342944, -1.032200986550063, -0.4835950283117757, 0.8245441142015528, -0.4236263562066192, 0.351954372122862, 1.484058018261023, -1.1589860036745299, -0.2410298921977429, 0.5631418674797897, -0.8279326687122501, -0.3194779536769178, -0.444219076022377, -0.4548176478832259},
    {0.40274002328399605, -0.10859395393173497, 1.0601298805877195, 1.03903271876239, -0.03810124100441791, -0.2231012463662506, -1.4535209313086643, -0.2597349139586823, -0.3829512627979005, -1.3796733432543784, 0.7255613641262569, -1.6631547586245625, -1.2244483052198827, -0.7448433765178714, -1.7854787104986753, -1.0253527054203544, -1.318386859034319, 0.41476724788507313, -0.42746766472654507, -0.9968626863521983, 0.878104012793182, 0.9146092308323897, 1.4845411506882253, -0.10727409458306252, 0.4711091418186466, -1.9030805009530933, -0.7474013249301885, 0.3903800972350894, -1.6000236361867564, -0.26170654077494065, 0.21826814971931688, 1.0947449890093626, -1.3373715959114967, -0.41330574161397204, -1.0997371461453709, -0.5729780503486346, -1.8270159157810366, -0.010927151901369857, 0.06904107871333895, -0.9958912686831627, 0.8099577687700795, 1.0221442812381278, 2.6759686423518367, 0.041275812428673946, -0.6964735532678371, -0.08717958540207733, 1.4549778774305413, 0.3155631548495427, -1.0548602438401946, -0.386830719409082, 1.0519814868309065, 0.1660661251253091, 0.30270139652876954, 2.0903450833709587, -0.5291126803059787, -0.4263888998778488, 0.000525268479562266, 0.9788530207879675, 1.0603289631878288, 0.8974097805288495, 1.7630356216610044, 1.3094535519977242, 0.18778537324399067, 0.8730727231038127},
    {-0.2446906986529806, -1.007791170408922, 1.0065730054915387, -1.0629017374386458, -0.7195287787032074, 0.3865479732847696, -1.130091335999301, 0.10238378716205102, 1.5219259827544058, -0.4479839231513141, -1.4958889923028469, 0.6267384778092353, -1.1505539804318508, 1.05633608048039, 0.19874902047708365, -0.3176367293340416, 1.352777723586066, -0.3060350765541314, -0.31990993471216184, -0.38848687560137435, 0.5846758432376351, -0.030773955785396098, 1.103276580295372, 0.8972118855658577, 0.5856923157013969, -0.20181619934917977, -0.2460323651208961, 0.8084066288164466, -1.4063534284875745, -0.1392218360740189, -0.33962798151083057, -0.3042877768670191, 0.026233741526249143, -0.5810849752270663, -0.31681422490998123, -0.40405058545349354, -0.6396053510260109, -1.4577137033322263, -0.7542659811655156, -3.1678631020834445, -1.4196081786630401, -0.3486447650124692, 1.4630199982766696, 0.6740830343206308, 0.6715850879738502, 2.337008036076884, -1.5044318142509352, 1.2483732458371641, 1.0691862054123566, 1.6828069337780804, -0.815797594169849, -0.09392533052838567, -1.3843427127873713, -0.7320827580648664, 0.2797588020449122, -1.522190582348723, -0.08200139511257933, -1.172675737066501, -1.1194113674449357, 0.24236298099501358, -1.5100244689114595, 0.5072443856268487, 0.23189227784270625, -1.3009504321524383},
    {1.1150981576985937, -0.14769489757483573, 1.9508862324653642, 0.9929973019483532, -0.16668046351580165, 0.012989589076335361, -0.7040475645749222, 0.8006774747969564, -0.2014631003339753, -0.8714546536662032, 0.33859654107992965, -0.11961938850577494, -1.0006808323970076, 1.3043637093680405, -0.20551125683203597, -1.0132209096641087, -1.6241814362213218, 1.2296119528801768, -3.6667793172667826, -0.18870231677619775, -2.2945575036316734, 1.032682734820226, 1.2871856287939571, 0.091376243347118, 1.463476728501432, -0.886827069789049, 1.8315130188184023, -0.09947878413797773, -1.8875543349805197, -0.5189089190518402, -1.3642767139752874, -1.5729790976569242, -1.5941061061068873, 1.9010101228148966, -0.8958072826083746, -0.15925012097381674, -1.5006588337765818, 1.1676111395627131, -0.9199490273032145, -1.1609538952593454, 0.5974619556835928, -0.37080508601403495, -0.8913550882483153, 0.5405807205145832, 1.4306910895679255, 1.5350586856547088, 0.39799620104075983, -0.71228692921335, 1.041181273287605, 0.7365257522630126, -1.4322903379612097, 0.8645309695287752, -1.3178065704001931, -1.7974066935799575, 0.7960384401320802, -0.8025488333653846, -0.20629306195326474, 0.49515026771894527, -0.6090207056439201, 0.6908891881922381, -0.4299824886702703, 0.20414976887028613, -0.847077097389958, -0.27641798168805837},
    {-0.752969401310946, 0.7442955565486262, 0.7709349454998075, 0.7960378889275143, 0.2745419307404799, -0.0186795834464828, 0.9715739208349897, 0.3793580398387786, -0.9967755066257453, 1.682168538790303, 0.9764999322210158, -0.0007652766848114959, 2.537137471827853, -1.058534408583021, 0.30592422668437624, 0.8828245771156653, -0.6673653908521928, -0.190956790480161, 1.450380145316403, 1.2605517599772325, 2.7223887400175864, -0.676274062929813, -1.130063308125306, 0.6990808027731145, 0.2080884170866844, -2.005564367266003, 1.5998183599313565, -1.3389262398755877, -0.772414036904665, -0.8459718840976604, -0.44539721429322016, 0.6919183143098617, -0.9823920813472615, -1.0787462352771446, 0.12411115343272366, -0.36140943153118577, 0.4984400841198323, -1.1036008366492251, -0.7116477295604048, 0.8571541238233585, -0.7582355511079928, -2.338792561147699, -1.1527558451418476, -1.2982666581099456, 0.40837683358687643, 0.725244227344485, -1.4115112215271843, 0.28350716649742935, 1.7125643775393609, -0.6517475870876882, -0.4141036275091541, -1.28703856594522, 0.0731875053974402, -0.24348022812097894, -0.24251915524997578, -1.3113543901984046, -1.0405795108572455, -0.17491840178879636, -1.645578890979846, 2.7191882854234906, 0.8643814595229646, 0.9507346253941474, 1.272997870896841, -0.6516164573994288},
    {-0.7195757910820657, -0.12355876127644862, 1.3144408038227657, -1.2277113664903494, -0.5304585494870094, 0.34604575467828624, -1.3288393826499516, -0.2681714893032687, -1.382292908367367, 0.4620451014620718, 0.3024397694086399, -0.10147324858738761, -0.9869525118472967, 0.2465857261936582, -3.4977889160758084, 0.22809554114836358, 1.2348060212601502, -3.3095336834194806, 0.5401971618061465, -0.3252411946278751, 2.8101603765476044, 0.821882836084355, -1.0078844879355442, -0.5475886528689075, 0.7702229866339376, -0.8513041026670611, 0.6828939397196768, -0.10409532168141306, -1.3863139578884014, 1.0643698732294886, 0.6463205306700407, 0.43376076439812256, 0.04902033018299778, 0.1795805823682637, -0.9131566715167365, 1.3871267726362606, -1.3471350603789756, 0.18986977793112908, 0.43560341363266664, 1.0619323749394287, -2.9974301196467255, 0.036668740421304795, -0.6426566093406781, 0.9903574701320897, 0.47332187572926987, 1.0218365304740207, -0.29436840069196396, -1.312913265993892, -0.834840611239728, 0.0985310222807942, 0.5268528370277283, -1.3186272894127449, -1.0561282151004732, -0.2474202979495438, -0.9620264066955598, 0.21087164087974167, 0.3176801878860851, 0.6421904582332734, 0.36130357414273595, -0.6981082829319695, 0.39880569741096866, -0.18035879967561666, 0.48739996364142224, -0.8587700762648003},
    {-0.17638453552111447, -0.13622471320534685, -0.19998148303113444, -1.148024793210421, 0.8535455058120968, 0.041323577157130933, 0.5312359373398654, -1.175910031517971, -0.2970734629240472, -0.9883281724404044, -1.3367304419720198, -2.3845712783540747, -0.6721797350101896, -0.60719268806519, -1.4478348784929884, -0.7027036763646405, 1.0247275193456769, -0.6389992558568015, -0.8632326928579913, 0.018889613905560862, 0.7414284925780025, 0.9519510795807907, -1.386046449269675, -1.7748419073937711, 0.6809900255780759, 2.211546136983437, 0.7282481233933333, -1.2287274812444713, 0.3326282812211923, 0.1180829440969433, -0.7607441051813703, 0.909631322411035, -0.8683682401056275, -0.2977261908854932, -0.5073412907891798, -1.0615459597704988, 0.9266623363727978, -2.188986028817088, 0.622719833692773, 1.5264651749417906, -1.2197741850917811, 0.7869041703340302, 0.8879720501570708, -1.2413442133611456, 1.0764240887654408, 1.051563130644413, -1.5975786959821647, 1.4408878274942092, 0.48061823121297487, -0.8685818026574063, 0.14672061417255508, -1.5427456651444778, -0.9100485738679884, 0.4572593900767608, -1.0855220941434107, -1.7730369068027403, 1.9419727035853371, 0.1977094653720148, -0.8992791518952991, 1.501466702731104, 0.4395420593295274, -1.6882428842693828, 0.07673970911781816, -0.27243291683686155},
    {2.5894195679676297, 0.17565727290972966, -0.5365693557806722, -1.543597348845121, 0.23426706389680374, -0.3897640238094682, 1.529664958691379, 0.7939641332694249, 0.01860407522503314, 0.2879527205832621, -0.28233046899648895, -3.2484486346624313, 1.347063611126005, -0.47014258943141607, -0.12490094173628451, -0.7181803297198298, -0.06886392156751499, 0.41725320446179714, -0.40433761601057694, -0.7846390794908713, -0.003780111529495672, 0.39698174457091545, 0.26351841922719577, -0.8237315962345422, 1.0309940828131305, 1.1645997493699738, 0.40240371087634136, -1.3582279894562592, -1.818789410168408, -0.1280746025069441, 0.3543784317616329, -1.4394750590821845, -0.04753200233943469, 0.5488172202294788, -0.613450981983772, -0.10456404769474567, -1.8289767959318664, -1.1520207737632144, -2.2103581406087947, 0.3306733457855668, 0.41600652287463197, -0.44191821791072033, -1.0248668564528154, -1.0144982251955832, -0.23234029203965634, -0.06325012810689622, -0.7754616948506502, -0.3889915456488463, 0.7087307635513712, 0.3322842549285649, -1.138624350940521, -0.24094595990497097, -0.9843128676962645, -2.2192532976020245, 1.2236753012976718, -0.6959490699051244, 0.5664986181046792, 0.5179979004282507, 0.6409107703503518, 0.006228123277320865, -0.24718116819409808, -0.4325767971463219, 0.47879246958990557, -3.1292369353104803},
    {-0.040934400765954296, -0.961955311899637, 1.894810747595832, -0.44387934464057827, -1.6353082984909177, 0.7470081674554031, 0.9653840624442336, 0.20672390205330687, -0.18799698571716733, -0.34092549992053717, -1.6556365675325118, -2.1454716725054808, -0.584322862216342, 0.4661424671831464, 0.7904697686924651, 1.8255022699456374, -1.3601386230416919, -1.1493859602206116, -0.17763453103926588, -0.36301603767135876, -0.09451240235299607, 0.6219594225212538, -0.6467574895765811, -0.4364270900792328, 2.0819107546702, 0.37300969131440387, 0.9705135954672943, 0.11361014509342664, -1.829057645927492, -0.23499504079111214, 0.7721493786193597, 2.003963936231197, 0.3495392543027832, -0.03813263098110536, -1.9388429085700027, -0.8761002038353572, 0.5254451658628922, -1.0136589703044128, -0.919664603782554, -0.8104074371695885, -0.6914696587336475, -0.6864172577535362, 0.9760462168149722, -0.8047907924916243, 1.166933053058194, 0.9276964384077666, -1.3153204568210228, -0.6726546139618473, 0.07054597552435259, -0.19474265308172506, -1.6757771870578768, -0.6613733746474787, -0.2467844697336841, -1.9448255995818127, 0.2400237206774221, -2.0801691904644346, -1.285562333685989, 0.026671284641290413, -0.5434661621532365, -0.3938798674997351, -3.1476363742467792, -1.6004446227094726, 1.428178459154916, -1.3847388975767925},
    {0.647819954954283, -0.3470033918606999, -0.2986979249707225, -0.22337389118096443, -1.6253252224070913, 0.33156286517855915, -1.3847134935994596, 0.3181562802925709, -1.2961562247159137, -2.057260141503943, 0.37357533951069105, -0.6141405046901186, -0.6351971156419354, -1.602786476511328, 0.43085439725437874, 0.21818638337488214, -0.8713789541726952, 0.7088384097595984, -1.8524557691329242, -0.5075716218105291, 0.018294107127609496, 1.3391624534462097, 2.439846459163744, -0.37328395552107835, 0.017176947373720733, -0.7414254733462936, 1.5417583146416973, -1.487372979749257, -0.3014018591300485, -1.8524488926825151, 0.3477349265365177, -0.41233723843055203, -0.8630339699312153, -3.2283117524071185, 0.5368289876754091, 0.7818403152201026, -0.02747916819797533, 0.013904658323337414, -1.3165226939433303, -0.23733826494401555, -0.40682415622776613, 0.3386945384192201, -2.6739431095840995, 1.246223565470476, -0.2867987813188733, -0.7474329664131178, -0.511000186425764, -0.31574292161256207, 0.2841605224771229, -0.3261523100191636, -0.7285742578857716, -0.8356417983110977, 0.5258193809922552, -2.843252324037937, 0.10543205368325281, -1.5532407593928006, -1.7914696208591336, -1.4104600017545865, 1.3802793272207654, -1.788431734823044, -0.13938804160905627, -0.9072550386803091, 0.46645094776942403, -2.7754579571111075},
    {1.4256225355447272, -0.8151759204208056, -0.10515323542263312, -1.9826072632904572, -1.0248127316395612, -0.8529692832092924, 0.9730110064521656, 0.6527984444646392, -2.635220941195552, -1.488765325090098, -1.5802102750174414, -1.8510721936594512, -1.3511861240493466, 0.08986021095586431, -0.7771238184300029, 0.7762689118689823, -1.8083003996405036, -2.4970939555168976, 0.4300930667608385, -0.6050595433664562, 0.7797537454949349, -0.1947604476127578, 0.9781686021971181, 0.19740235682594476, -0.8919433782605458, -0.7757279002727242, -0.2594255700748278, -1.5792851615033665, -2.7337321976332896, -1.8210706109625403, 1.9424790190823307, -2.150440354653193, -0.570928595065508, -1.6796559918360146, -0.3934386481507582, -0.3552550116540723, -0.4616527680646503, 0.529122889016891, -0.21306723368551933, -0.7520522976444481, 1.3358344626545975, -0.29970980481271725, -1.390265546072253, 1.1863264800441935, 1.1403294089082192, -1.834202714821024, -2.2168633903238084, 0.106019527144871, -0.9449520991427229, -1.6759883308632277, -0.8119032402445414, -1.7206060843118447, -0.5080700951445953, 0.3312914928097665, -1.4333906071392941, 0.02738777374143306, -0.32677468476891697, 0.8383829530023288, 0.1784078454789292, -1.0214843068629693, -0.054719842016746366, 0.4417168575649682, -0.7015341421946416, -1.90676986702322},
    {-0.07500481236513253, 0.73575880949317, -0.35525905001715996, -0.4175898903944046, 0.5827540634522832, 1.0904635353712475, -0.703108742426407, -1.1748096159961916, -0.7720612230055152, 0.42594251152978246, -0.5520989752818449, -1.9654555891773433, 0.03642085740628507, -0.11551435166285252, -0.4746869352649433, -0.4560438513335418, -0.5741928461444991, -2.1116454674221394, 0.04832058911344229, -0.43165656204209435, -1.4265881704096268, 1.5592413356807366, -0.9348428963592381, -1.6741534285799986, 0.1771272625167534, -1.408966023555196, -1.723485470659426, 1.117779745330837, -1.4453028380876676, -2.5006722060522026, -1.4278030116614324, -1.3251571829302404, -0.7690000984898635, 0.6908786079246428, 1.367692513930821, -1.2173600563769256, 0.4674157849654974, 0.1631846600433602, -1.4859420672701398, -1.3175768165581208, -0.2521646083706737, -0.48970096511177563, -0.5599281296018515, -0.558023964702269, -0.12051270420988633, -1.993513506021227, -0.15864702151147872, 1.3492186242644948, -0.1090663374233637, -0.5272913761547265, -3.289854289798829, -1.6114007489859525, 0.47557729526622095, -2.201241967525966, -1.2455083032657837, -0.5477416598751217, -0.45983197528266184, -0.25886632849858526, -1.1111359122723725, 1.5438752059766931, -1.3375877816841404, -1.7898936254336817, -0.9879577148133508, 0.9208872938171329},
    {-1.3370462364937357, -0.19219508283688402, 0.8350280965620472, -1.5100225541373051, -0.408797314556664, -0.7617829918218898, -0.17704780170199366, -1.4129421934960238, -0.11564699233170395, -0.8386496542003515, -1.2146196505653362, -1.2422294522474078, 0.014171875139197232, 0.7098723140751863, 1.4567088309110547, -2.130404177223185, -1.1113487319089572, -0.582948970337863, 0.601597574874916, -0.9771178333677163, 0.4222744630570052, -0.451396289946733, 0.5528401267267631, -0.8293033832836544, -1.7886198065745407, -0.06099927205855528, -0.5493439462445666, -1.6941992719542165, -1.3871699277928897, -0.8214770901340093, -1.607616103728938, -0.4053887508265743, 0.1406267841416409, 1.3934657981603322, -0.3726884963749872, 0.09689064396362068, -1.4700090138337019, -2.589990289429593, 2.813357358735228, 0.6639779930274168, -2.17194063004568, -0.46998631858700934, -2.6700834502784923, -0.05791529665467814, 3.1294066273353587, -0.7715057869882759, -1.0502122069147004, -0.5603379366585237, -0.6828571503303456, 0.015841691615282143, 0.05514940904510511, -1.538234025143279, 1.3820341411531523, -0.308775334865286, 0.02370632107700314, 1.6813950425956357, -1.2534293168799655, -0.9832289229188852, -1.2641970126709345, 0.5798625229742229, -0.9724919038158409, -1.204716251352789, 1.1667871320025764, -0.24631692651920642},
    {0.05526956579814035, -2.156484322946368, 0.010215385069791364, -0.18495995276722066, -0.17196046554775035, -1.7156759832167243, -0.87193409771333, 0.6944154233096018, 0.4709949449340938, 0.19561133858530425, -1.0742437643288516, 0.019789704580148726, 0.9937636667034115, 0.03559808612099284, -0.47582977436727036, 0.6148834355742544, -0.7433500960492404, -0.04880384661235788, -0.37473048088579913, 0.9878335657391778, -0.02008284118529985, 0.9641046149200452, -0.49710917415595957, -1.3765374310440455, -0.4625619605545701, -1.152819547874805, -0.680031951551458, -0.33253386491176584, -1.4670902345118346, -0.9282590835693307, 0.37153044333143675, -0.6180559620345786, 0.6018952353507616, -0.6309729893551456, 0.16854559798123672, 1.4189061865569792, -0.7180629022469973, -0.9499392181085926, -0.059543169352724114, 0.007503309589993034, -1.085065583851632, -1.9859182410486762, -0.47091036121075236, -1.4423188693734923, 0.08678241766472504, 0.18519955959208517, -2.582470762702427, -0.7829217448521051, -1.6622734044426173, -0.046634109338507944, 0.3853400716015078, -1.9894568788775604, 1.1397743073083328, 0.5040582547440096, -0.0178336341143964, -0.29100396684564617, 2.2250297131657826, 0.9323001603203501, -1.1154833468745018, -0.28384109529573437, -2.09096695107676, -1.3145961220314943, 0.7703251847041558, -0.8048887631061739},
    {-1.0457178270817742, 0.07437857398806795, -0.5854907783346193, -0.9492882412079269, -1.9127317856777517, -2.4784532142786677, -0.8443924758292026, -0.483288815564604, 0.20703557620256227, 0.24567291256386015, 0.5021581433980448, -1.3033373064041387, 0.37515583010107983, -1.6946973798315426, 1.789283685649287, -0.03499533917752329, -1.4089814506445024, -0.23924631900884277, -0.05641375488317425, -1.2588129589568269, -1.6886956479604716, -0.10000836476633745, 1.310104736027439, -1.38093385142866, 1.0451054951602499, -0.6600084788902287, 0.25220727360119505, 0.14094876312608273, -2.2384160263264716, -0.2786876042475111, 0.8598347151038946, 0.8088716778559218, -0.6780963316481297, -0.47168686043136304, 1.1694741416265462, -0.3376139524689274, 1.2381969981124152, -0.12059506696308625, 1.0146128066434605, -1.4443051752725695, 0.6965971060659507, -0.43876652123133963, 0.7261724032402144, -2.193878175936806, 1.2239956058105448, -1.5185457415890664, -1.31380336125021, -1.2393585381775316, -1.5458316107530903, 0.7951503108006728, 0.1805339617413902, 1.7932578063210993, -0.15911991222168856, 0.369264037069128, -0.11468163340272076, -0.5614999857049068, -0.311526989742037, -0.5177290171284852, -0.4002752076262597, -1.3213465596354954, -1.1632486285121173, 0.14882761790678123, 0.9694005252096882, 0.05370790803411086},
    {-0.7573931507218482, -0.20608165086549404, 1.1092501199686775, -1.0891491100366146, -0.37040538375827936, 0.06826411894744323, -1.996376090323637, -1.1734398036642837, -0.044449547546003464, -1.0254610573964682, 1.2081199989355522, -3.145289563875943, 0.4157668398170055, 1.6553098990901718, -1.7131243062160646, -0.42255784269874064, -0.9086153816547057, 1.1544758314370296, 1.41993342125622, -1.0736025881134594, 1.4706682235822761, 0.0718733951376613, 0.027094626421565737, -1.40863538561817, -1.3500381739330274, 0.3749207505590965, -0.6953546243060912, 0.04466165966591701, 0.013747611344132205, -2.256957470453417, 1.3982868341173447, -0.1496563138757226, -0.27402542880146064, 0.09285169254887558, 2.007012326499553, -0.1504033607564743, -0.27076855511448644, -0.8645527453352733, -0.36123705832338404, -0.9992160069251736, -0.7148636941609673, -1.3642643351315333, 0.3601148470268457, -0.47810934314965237, 1.2116142802850636, 1.6480715212497137, -0.803544149234353, -1.3967442106736212, -0.1928058756808714, -1.698721368502654, -1.3346070629401907, -1.459019777097424, -1.4983698071587126, -1.3523925028329293, 1.1150365029058182, -0.35884670283459463, -0.19327137902973118, -0.2682862122074364, -0.601838642709461, -1.0970423831600307, -0.5824653165887214, -0.031160566412173428, -0.22512979776720848, 0.06073542713548078},
    {0.4012439364378676, -1.8022424805051975, -0.4333992592087312, -0.8181305342269805, 0.5371546808641414, -1.3533499876119932, -1.5665027937397316, -1.3533609868366117, -0.6014834780195093, -1.430861650431302, -1.617250307102409, -1.8737057982094005, -0.5596543651739606, -0.019153507318208425, -0.2273874547976309, -0.06349289349948493, 1.8559704903220675, -0.9451925055618272, -0.3729411631607351, -2.9317760185712864, 0.8493430639535665, -0.48392854931139806, -0.20989251538970155, -0.10460196642180256, -0.11288052712179077, -2.186809779509857, -0.663487743512457, 0.15966423181027134, -0.6660255381842042, -0.1550419072699367, -1.2643388125784218, -0.9635336556517059, -2.80718701945635, -0.5132257028748758, -0.8098412095891846, 0.7718129543978101, 0.9966516758979156, -2.410122065751891, 0.2459045426516707, -0.8474305880278433, -0.4370856171770296, 0.15274711651071865, 2.081134343337403, -0.9015155241767682, 1.4296207819417994, -0.12238295156742468, 0.4528769333709277, 0.7426260947756765, -0.7276544740968673, 1.5101826216098493, 0.13457544013054934, -1.4165876837924152, 2.2546828868824345, -0.08517719171133646, 0.708419111098859, 1.118433167835668, -0.4512098895794995, -0.28966356930255355, 0.6147992416354823, -1.0052781574370149, 1.2509689600095593, 0.4644215677780894, -0.003975122861289034, -0.9111546947618545},
    {0.17774926184710524, 0.974315132689876, -1.4356173212201149, -1.9494220600003287, -2.313404414277913, -1.678163514141634, -0.37012871627527016, -1.0005507358136934, -2.3018176251823603, 1.0622474326508096, -1.4247359177726577, -0.4995843676027816, 1.8238205279120046, 0.12464989695760842, -0.37342177465657606, 0.9222519063834561, -1.2781640842677962, 0.06972684328918163, -0.04007032646898816, -0.203419976318778, 0.441524375049346, -0.37281936461954707, -0.25556057039953967, -2.211558250181252, -1.7239943847936474, -0.9834274004522385, -0.8732514334741839, -1.5761716645993522, -1.0368797461356303, 0.7298354159477507, 0.23195726394881344, 1.4205518775677861, -0.6160181714177216, -1.5347293118511922, -0.30925680160035973, -0.1692208312608773, -2.027527674907749, -1.496750588669357, -0.20579954918261456, -2.366363976175467, -0.898990987546256, -0.45898180499453817, -1.6637329156175726, -0.5502098446047137, -0.34704438604420307, -0.058377680630181165, -2.7473063090858516, -1.7661959922632902, 0.488933454504785, -2.3939056380727752, 0.29546743794028424, -0.6622927405237823, -0.5969189568818976, -3.310668482550816, -2.578891787966449, -0.3676073771918983, 0.06610881592768274, 0.04945654674800506, -1.1164173431180648, 0.13237914203308887, -1.810324777941177, 1.843812333274745, -0.5906569905085721, -1.307415343692154},
    {-1.4244680331249153, -1.4420639367814727, 1.5987334125298949, 0.052918523476059826, 0.1380862665946082, 0.19115823793536343, -1.5039846459649218, -1.238353063528589, 0.1638942653278778, -1.8454315418177996, 1.1567467688826762, -1.3434262056730473, -3.670562834522852, -0.08805127634776062, -0.9860580147188779, 0.3128719827021733, 0.08630332339547091, -0.03857936709983018, -0.9297616752369244, -0.8922662929345687, -0.5560978400673395, 0.47116525868139364, 0.824937065021986, -1.4327748392948643, -1.6518863952064415, -2.2255018480420197, -1.5526495379091092, -0.7256658964295235, -1.9589687391687514, -0.6588522787511554, -0.7517263683977686, -0.7523030228445465, -0.11581006975062516, -3.7365430256694263, -0.7968931621232976, 0.495947674050072, -0.24409546727495693, -1.4845950947530329, -0.1927377907871469, -2.24833973279923, -0.1274191206901009, 0.27851938370165025, -0.8711523300544208, -1.5235721644010505, -0.0780871450065389, -0.4871324192001865, -0.14464720872716247, 0.6154120359734967, 0.49963712427767953, -2.6601690585083313, -1.3614089290871634, -0.39209371163621337, -0.9403923844506552, -0.4388733606372806, -1.3322071026673559, 0.10183498952633209, -0.7275801268989454, 0.6735326162127058, -0.42487371556390774, 1.738337146328251, 2.5519169394312073, -0.008255037358744798, -0.05828501308207354, -2.241395857568356},
    {0.9600618363248977, -1.678250261701367, -0.6678349334523528, -2.0659762387257534, -0.1319290864129507, -0.03283674695807524, -2.451263080129952, -2.101127991984622, -1.3612849927065853, -0.13664101205915047, 1.1011564654308117, 1.2894816227468324, -0.3713893136660449, -1.4884563370134245, -2.9115245224168134, 0.004610316028608876, -1.087952721163488, -2.424455998840269, 0.2797882899326589, -0.11867080058943033, 0.2374627037670458, -1.8028245544117536, 0.5101089454524533, -3.685012467978787, -1.358221951510123, -0.6844169104940899, -1.897067708712061, -1.0359191777576489, -3.3721356539487606, -0.294842798419496, -0.7304574832314116, -0.40486760380281905, -1.0560924672219836, -1.1032987181533984, -2.2020765297508005, 0.9574544806384474, -1.339756806640788, -2.125948300630124, 0.6736084492312001, -0.5783645120643875, -1.6339366680901413, -0.29745668859674285, -0.9394209352882639, 1.237911148368848, 1.2498480518219834, -0.8217699053714776, -2.048341774906541, 3.128752807397239, -1.1513826148183317, -2.314899041012539, 1.1641900234334424, -1.5976355056508695, -0.5242762905114856, -2.117577694170786, 1.0693808363864479, -2.5926797029816466, -0.5612981085269946, 1.2303159052120054, 0.7318655760438515, -0.28974352881599347, 1.0723646203222899, -1.2420783237526503, 1.1808690207799746, -0.3778101371876311},
    {-1.0835955645606616, -2.0906004084533474, -0.6562460477455069, -0.5160203766846481, -0.25072520262256137, 0.769580594814262, -0.8503467997385054, -0.7806291614891331, 1.6495290857510627, -1.7090644810169673, -1.1939062419341397, -1.959034244096615, 0.3081629319931519, 0.40695777369141867, -0.6524695016615155, 0.6484521006686199, 0.32859050086536257, 1.664966744264046, -1.796428783143846, -0.5591035472191579, -0.6784141356525862, 0.7175670277400023, 1.0346666000898517, 0.09615610769057352, 1.197740365906749, -0.3147983688391491, 0.3392331376996103, -0.7267193172336085, -0.448352963980548, -1.3554025123529463, 0.5215507382644601, 0.42016364114547056, -1.0869802983562356, 0.9560430339768676, -1.3126848688329715, -0.7454598145106306, 0.5039078403025549, 0.45750817474565403, -0.19620152818029474, -0.2030567715842868, -0.9470342424218556, -0.1702089897189149, 0.6024129368529645, 1.4583390282989739, 1.1045545079340933, -0.5343243809431448, 0.05697691277186583, 1.580821290004496, -1.5111656907661681, -3.0868962417914725, -1.2542442432372394, -2.2657528396214808, -1.521991733090194, -0.2223876104827295, 0.45987384851281304, -1.461929052072763, -0.36845224849043207, -0.503942028563483, -1.7572091896653148, 0.8536126497879628, 0.1178323593334564, -0.28719148447400455, 0.6883879663232138, -1.3666931888066916},
    {-0.1901319990718798, 1.1679609745284711, -2.039820605259344, 0.06295671710302246, 1.0631267482484816, 0.6747504680804292, -3.057977801726796, -2.2745152444625996, -0.21072158148139236, -1.3161867572922044, -0.39769291561746073, -0.6845718762152586, 2.4415873977674143, -0.4825953941645143, -0.7821600509488962, 0.4333545287236757, -2.4020721882080647, 0.6223209018244968, 1.0410949838408894, -0.9619802661788054, 1.246006869653669, -0.4519558965001393, 2.2372996201441686, -0.919039226990464, -0.4092635371005637, -1.9930612721613281, 0.7143991423706711, -2.087784068909311, -1.7921622840848757, -0.011345653809969568, 0.8908715344689655, -0.3973801691412733, -0.8277416691837851, -1.2685531809908628, -0.48786850842302065, -0.31319112415100797, 0.06809033003255492, -0.6383095693046209, -0.07227129862542699, -0.9289646902772773, -2.902973466598959, 0.6012685505085908, 0.6572856507576568, -0.5523856461032712, -1.0955816857375016, -1.2389280861872805, -0.05469941819772764, -0.552721966681843, -0.7116607860872619, -2.26321616024012, 0.8458734074091484, 0.16571460716690137, -0.24855195254028803, -0.09259201950568773, -2.049037208694738, -0.9574182750987797, -1.4048804436050422, 0.8591563037263813, 0.5462113469435481, 1.3812005179974973, 0.6161922848638934, 0.24959121424631017, 0.9995146316114359, -1.9507673006695263},
    {1.8153201638016787, -1.1596681435203673, -2.2022888420338056, -1.4332366936456, 2.42566077279844, -0.9142500476074783, -0.756249396127247, -1.6272855506183237, 0.9766701983822031, -0.5033955890923928, -2.310070828208127, -1.587450584136058, -0.2670103988212139, 1.4753915877111796, -0.43984356610007447, -1.8232908871073585, -1.6674891457441454, 0.8687932267111019, 1.93180579387887, -0.6409864025064889, 0.23040464687167608, 2.3095436443985675, 0.16397334575270028, -0.021082261742469723, 0.89320257503341, -1.943927227713807, -0.20133972766849378, -0.9492986933741657, -1.7565347753637144, -0.5327529392657242, 1.643863735647418, 0.5075384749446181, 0.7515521136378258, -3.0093946054115266, -1.8202806978663688, -0.6576052854980444, -0.07001111938622788, -1.9759161098827012, 0.07352446280365217, -2.4232097750131127, -0.7614781627295691, -0.31830636767540393, -1.5332620027235402, 1.438864251500041, -0.8018815592893673, -0.1123406587683191, -1.3570720985838665, -0.9972765682839462, -0.6397607142608723, -2.8528953906132575, -0.2118886388431807, -3.1233711249177603, 0.42815073753468336, 0.14242400626511964, -1.3173510639553683, 0.2817122182136214, -0.25385837317439686, 1.9867142340308825, -0.9931820837087303, 0.40435777610074813, -0.1499689118296783, -2.348941209700595, 1.7283661411751592, -0.9345854570866009},
    {-0.9434454704068826, 0.40570298708478264, -0.22620239629042801, -1.7434086043140218, 0.43692908416217885, -0.22969407458764537, -0.6649708979619244, -0.9127723385285619, -0.730045380435869, -0.5797223677249315, -0.5555508183849085, -1.5170258054141634, 0.2158174238239344, -1.6946591629395733, -1.2569030529466794, -1.5756272344563065, -0.9841239723031909, 0.7254204295513051, -0.7218133621744683, -0.4227219884975276, -0.6670686283008127, -0.15400327459229862, 1.8289431333082602, 0.4553512848743622, -0.3554402720388319, -1.2414514617505388, 0.46097250567848586, 0.172723332067764, 0.2695713487027755, -0.25101592301805525, -0.21976409019934606, 0.3663548131917429, -1.4197874220407745, 0.4412043502313773, 0.06776952665151763, -0.7035200429176165, 0.6393645331297331, -0.8893932192346328, 0.963467380524012, -0.6991912469675052, -0.8868814882064655, 0.8709351999813745, -0.34956300785196376, -0.1288317142451794, 0.20940495252620167, -0.0003735342895213293, -0.34074466816643256, 1.0458625492154183, 0.5375781943457486, -2.1522277779095305, -0.5708239575918651, -0.5184299874797161, 2.007899175828282, -0.37247484516147256, -1.461668878246218, -0.9445732701256937, 0.17288426038819307, 0.32005659993399105, -0.4929164905281425, -0.6772279158309478, 0.4686081736622807, 1.5339575977835482, 0.4686025906525286, -1.819138622737088},
    {0.3813781016253553, -1.7814036371240276, -0.49205902068362795, -0.2866539802195019, -0.5094861666097282, 1.6654858864674265, -0.45991517313051045, -1.0721818372836287, -1.220619569898116, -0.219638085829089, -3.510798849948989, -1.606775003785251, -2.30818399788371, -2.003966982385381, 0.16646669566025732, 0.17358537123813875, 0.2933693885050552, -1.3245710292529183, 2.751122705723179, 0.10179030925729933, -0.5754983688810711, 1.2382763658018785, 0.22287212441578352, -0.4162660095811841, -0.5862559580509122, -0.24165806914259896, -0.692426630040032, -0.7111829366545583, -2.06538549345881, -1.8576067493466546, 2.2346973624238413, -0.48092507912818055, -0.15366064847686214, -1.3744963077271535, 1.4132506045226485, -0.696736089061272, -1.9361269509333645, 0.9752552631946044, -1.7562559046344355, -0.7817169856045803, -1.2067435461622023, -1.5786529671117924, 3.0852946768975595, -0.9049482965912601, -0.033684453430075006, 0.40947197860926576, -1.390929258995814, -0.7602251977122969, -2.6501380380879476, -2.261505116446754, -2.4661764935144626, 0.1636568384470122, -0.31605256047773606, -1.4173072366803965, -0.8890963640935533, -2.5546692517435394, -1.0175726897057111, -0.37178140181606445, -1.3170784557552409, 0.5315487212597705, -1.1775616685830532, -0.8960992499344534, -0.598919120785466, -1.8625423111006383},
    {-0.31221670917556865, -0.6924373967147568, -1.2080931871272023, -1.1157462761296397, 0.8008191559515367, 1.3259769892243563, -1.4260443625131742, -0.7916817598111049, -2.0939414867015618, 1.3510642984088923, -2.0210302207217445, -1.9965879623437104, -0.391707499123104, -0.11813873584179102, 0.7470489757640475, 1.0710039163085037, 0.4183326985272767, -0.8624854503912217, -0.9353922379405317, -1.9994323711977628, -0.22122895354091077, -0.4173670679580671, 0.7173811844854414, -1.5329968802467417, 1.3834850619483132, 0.5242966695656218, 0.14163501027070197, -0.7735073950523481, -1.9807686814834675, -0.04761449348543835, 0.6713121435575586, -0.8658174734170929, 2.1172035763127206, -1.0938512233386481, -2.668745557855459, -0.12556524334159924, 2.1611463955255683, -1.5139627792047012, -1.3165027487524925, 0.07448737714244125, -2.157690278075683, 0.09850687807346119, -0.2564342187736192, -0.5111246409470266, 0.14639074932896207, 1.1171404596490855, -0.3528723230386765, 1.3093933720284219, 0.0671090599021742, -3.0570953795695264, 0.21908178384728338, -3.225273052615785, 0.9778205223076579, -2.27091052624693, -0.6756046617278326, -2.2182458004951817, -0.8472252051471691, -0.06603332655932964, -1.0872634136938135, 1.9898397904363703, -2.7060646324687396, -1.076926962796368, -0.1968213117053711, -2.5682848511834395},
    {1.773254907677096, -1.0583833997331604, 1.1939709815288757, 0.07241491506549616, 0.37293496715328933, 0.25369148520416146, -3.461902004282272, -0.13734543552802925, -1.874469621721419, -1.4198320538338722, -0.009116076973424854, -0.36908619842508356, 0.3760583801833121, 0.3951411485341053, 1.19678365873912, -0.48212610974137915, -1.7556308169618078, -1.852131985319879, 0.3020129717837976, -1.8925970320832681, -0.44222044746510286, -0.3971623044762463, 1.0198293151056463, -2.314835137340527, -0.5555676148360293, -1.67707491990612, -0.9586319603098645, 0.17843273541749288, -2.8213279326903717, -0.33096183818663316, 2.808430321290607, -1.5104397961805711, 1.3834484543315848, -0.6880997961945328, -1.798136962565524, -0.39362864780347534, 0.7967850134862036, -1.3047195574631674, 0.2971099102667554, -0.9914174277713373, -2.5882095113563333, 0.5696475780664016, 0.6283888913184573, 3.0939955739622556, -0.5685487083674494, -1.437475211383252, -1.9310881718655128, -1.139077904762556, -1.6767170791071178, -0.9817712960631683, -1.3033830309780428, -2.346467818110372, 1.7045659029730116, -0.9962219083991904, -0.9458245095072614, -3.618917103720598, -0.714167634699443, -0.6711860434506269, -1.8049753660157446, -1.221075841956057, -0.9069974642944222, 0.17749432887667807, 1.3294846343860096, -0.517251459451086},
    {0.13178767441186684, -1.0179103998547439, -1.1923881254347375, -0.022348860087334176, 1.9153769431937884, 0.2582246887047213, -1.4730233490588989, -0.10991963430954534, -1.8602051214426845, 1.537304805924627, 0.5510297937240944, -0.8507341504954962, -0.9308986279783928, 0.00270367973589299, 0.29275153408778487, 0.2335385926541173, -0.4075163701669504, -1.642330969253693, 0.8690246164546218, 0.7147314933424209, 0.9228637520007366, -0.5652061998667698, 0.10230271087892587, -1.406685099266683, -0.47236856142197364, -0.43843721955528664, 0.39769529966904643, -0.779457071085911, -2.140165504765413, -1.266122805909812, -0.3702268268466993, 0.5976069204087723, -1.3134468253207363, 0.093592224575792, 0.21340267604293026, 1.6640793377014609, 0.5145804356742387, 0.28454761439317877, 1.3937485794622062, -1.9037448323469657, -1.0927024581267928, -0.45724527841943274, -0.6234386123452679, -0.400748077170041, -1.3593187640362059, -0.6937196013515643, 0.8719760234758128, -0.04455921562192728, -0.8967807278951726, -0.12885337153946536, -0.823651574646039, -0.9135416107422227, -0.37424010688976, -0.2341484968821869, 0.14392351694911923, 1.5302332796036273, -0.11101470423969462, 0.19821280317152679, 0.9557996912947555, 1.044208313225727, -0.5887078364369405, 0.2522769920820871, -0.8458878559271098, -2.2845624922126384},
    {0.36347274598072477, -2.98766917997964, 1.0000978951344481, 0.546953690782287, -0.19063561831229256, 1.7762917042375572, -0.7490752133277263, 0.980024485703272, 0.35254014406610557, 0.23655081042588896, -1.5945881260079435, -0.6090517541881032, -0.005521453994834487, 0.3254628969632836, 0.48621984503114385, -0.6754108115549612, 0.4602912303164542, -1.6575327305435374, -0.1573914306506436, -1.3380722546068606, 0.09155225146380251, 0.5653180695367197, -1.1017723985555954, 0.20419440617056872, -0.46313357090696766, -2.4381737665080934, -1.7816131407653248, -0.3580854342913063, -1.291285481320313, -1.5496333039161214, -0.9850084406116741, 0.3429398379374792, -0.3907223244687471, -0.17833057233534227, -0.2658689438971522, 0.07629602216981933, 0.25205820030625414, -0.9565808734175485, -0.27673834201559006, -1.1781833405125006, -2.78562828195951, -1.0385115938237637, -0.10900230770972291, 1.3261237187723132, -1.064882888893262, 1.1459638927188815, 1.0926089911344945, 1.6605975054425124, 0.05040712330901521, -1.0292040104787124, 0.07058167434005584, -0.5176806965288883, 0.5946246922815114, 0.46981709361691515, -0.5368575833029076, 1.263249745297514, -1.1398851356454098, 0.023273180353035446, -0.0910282685064937, -0.3370108837129203, -0.5812406021605756, -0.31938815684005273, 1.0924408677251776, -0.8219467954304808},
    {0.8289211874863681, 0.28852497116115816, -0.26045368680374115, 0.1678052331880951, 0.211215856501988, -0.3136211551004867, 0.6930196544210003, 0.27986595261553937, 0.7198808779750311, 0.4769935588490651, 1.7783411580848922, 1.3142695919096403, -0.2319694434596843, 2.357965886530103, 0.1789989349936184, -1.4106116265745277, 1.1865700354046325, -2.5414208551816677, -0.5939587801555364, -2.252627754929327, -0.018106289991457396, 0.6266542180737851, 0.16154904962667788, 0.36826578286280626, 2.345361175928859, -0.19147856633464844, -0.6879108551611013, -1.1324067756570464, -2.609551834280861, 0.5192813285972577, -0.1705109647396027, 0.4709689399438437, 0.5158333938135515, -0.8910607335578763, 0.4086114620739769, 0.7260743503840689, -0.804098184834155, 0.990228034590284, -1.0512190265863552, -0.5314405524618216, 0.6315917870367452, 0.6687672511711069, 1.1435966041267964, 2.283022447891995, -0.4041692721385635, 0.4276902431000571, 0.12229600008174958, 0.15844304614395893, 0.5973785650875534, -1.8835745286862267, -0.8161229968664118, 0.30093311515956334, -0.0052393157935944285, -0.49925591390691404, 0.9007419695549282, -0.8733412635246252, 0.5253683318896776, -0.2342310615811406, 0.16330996984137838, 1.3267351383061092, 1.4435718908020585, 0.3657911184235046, -1.7567944864926466, -1.2661011928742627},
    {0.6593275363302661, 1.5964365370082678, -1.9153284535586703, 1.4205679547852665, -0.9183691923752474, 2.0454845975193714, -0.045871692458801704, -0.3316268971927781, 1.7055750698741396, 0.07269288608546945, -1.0062746479237248, -1.1837319789998066, 1.1392774717044185, 1.4245729803038831, 1.0474671521218917, -0.3840830688100498, -2.038163725202001, -0.03720334893058643, 0.576678328037273, 1.1442103419663803, -1.6176971107756006, 0.7302679119080577, -0.4083025453386278, 0.6687480403356293, -0.48216404736580765, 0.329593484357455, -0.34362309618480996, -0.6402525231403902, -0.54541541650578, -1.4123343146799743, 3.465122039452679, 0.5072795080887401, 0.49683331760766264, -0.17099189730875858, -0.1386368147114058, -2.1331665051288757, 0.2858800341841889, 0.849580477741254, -0.925200060243485, 1.621541240505418, 2.2626070067653514, 0.5357433832243201, 0.5597909275506909, -1.5173953121695805, 0.2516430539801769, -0.4619307458949064, 0.9346589357221161, 1.7203015110699007, -0.4182127184002127, -2.005730350882013, 0.9296961263556023, 0.9681971966479946, -1.3125614175344358, 0.9910081113847455, -1.4159795358318434, 1.188449640134712, 0.7540334584070483, -1.0863548786555137, 0.34256409695029105, -1.1149501506652923, 0.44571239318015854, -1.0787340508478886, -1.8004254662169257, 0.1893119436180998},
    {-0.22855554333198136, 0.385425801123395, 2.189577460333663, 0.3964208714464336, 0.7887912362572412, 0.45887629153986975, -0.29636370150407004, -2.4978215235329495, 1.1792532988661808, 0.18834199739769775, -0.9657034221313815, -0.1684705998717544, 1.1712161820154303, 2.65610972326195, -1.9931758162418838, -0.0981951855246879, 1.5706293125315018, 0.826017586617593, 0.44401231991705775, -1.0113160021658036, -1.5043088553008888, 0.1298015162285858, 0.022195604776573924, 0.5244284638876852, 0.19243389256471735, -2.138285004214709, 0.5984203449563498, -2.340519102268067, -1.3865614601390814, -1.837849886682266, 0.9261991407601861, 2.018209362867165, 0.41353981511818316, 0.5501053252022455, -0.01657429044646816, -0.5579261661724415, 2.5894941318752407, -0.7129716944912107, -0.08475785674902479, 2.6184201910239064, -0.1086226332071196, -0.6544833345823949, -0.4517455334400042, -1.4592659716123937, 0.2534462031186693, 0.3187315088615495, -0.9946740114886344, 0.1389760614721078, 0.42762626506156953, -1.042113531744628, -0.2551906669859004, 0.13013872969057572, -0.423980251885449, 0.514900447122574, -1.225165192447238, -1.1117617033033884, -0.6227821031173082, -0.18288689422012058, 0.5732384504154603, -0.6729174535876333, -0.19966925132142202, 1.5154406960251325, 0.6829031839802365, 2.3828849742654135},
    {-0.2380997048266626, -0.8644004975802987, 0.5537195500396956, -0.20668556026404422, 0.8075133788179066, -0.4216838389002864, 1.153917348365177, 0.7313725958062898, 0.1581717836337696, -1.1396997170837844, 1.296759962064884, -1.0229316125708752, 0.0655437160665799, 0.8207169807974228, -0.8584218077612631, 0.03817753719112294, 2.325484626805913, -1.4358219461098236, 0.7472757981134995, -1.5183175022753788, -0.1895236637952688, -2.2631029027168688, 0.13184231564543253, 0.1750747763211546, -0.7648178915642735, 0.86504980864244, -0.9700476993327399, -0.5979220908457592, 0.9305471685902119, 0.21979804765302835, -0.7359673255537803, 1.3133644237199606, 0.9605447425015349, 1.4133621331376232, -1.4036672432580761, -0.5343218471744255, -0.48877574299579657, -2.881078180268995, 0.3943051324512672, -1.4330528307529586, -1.7510282535274388, -0.10520105899116015, -1.290934520437323, -0.8503784381690498, 1.0718495988088839, -0.5689777958094486, 0.6082841911385782, 0.19063804383353575, -0.819889218504726, -0.9058895858353456, 0.8204994365457626, -1.5137127837636797, -1.4571665329286974, -0.7945600375019279, -1.498733850947343, 0.9474805177718671, 1.3486322283422663, -1.1098279703281204, 1.1300828513729175, -1.7664791156520978, -1.950679033657923, 1.4093185797107999, -0.036065255302890176, 0.45135839994108284},
    {1.0495972556158495, -0.7396659900594703, 0.023757353732922207, -0.40970476125909616, 1.7668340442281432, 0.015447407143286226, 0.9871049480486904, 0.07358962956059849, -0.5329142154118112, -1.2273118273678647, 0.8670086313429197, -0.25631919209981685, 0.4214220624390925, 1.1144727812421216, 0.09549655458661187, 0.21802836241393506, -0.7166502987703651, -0.4291075643422489, -0.3436486222183625, -0.7313649431136228, 0.044779070839127494, -0.33699175604175396, -0.23302028623806517, 0.8865129375612324, 1.1131227256471317, -0.7113661002378557, -1.288785561724224, -0.7776378678271348, 0.6797107176250494, -0.8862646129394713, -0.22361443355677615, 0.43162148919446075, -1.070998327650637, 1.80819185109205, 0.4934280519031467, 0.21760975089297838, 2.0351023984631964, -0.3350770316169658, 0.9337353677849832, 1.9810412930264358, -0.2480444428221546, -0.05408488150097088, 0.1588820259701255, -0.27715516547398084, 2.6971811615581656, 0.6322784560608286, -0.7041398323607149, 0.280166187790263, -0.2621704007620609, 0.01581470563670785, -0.5870492197698403, 1.181896683348954, -0.5843615410478782, 1.419600229956528, -1.6593732148074731, 0.16156377606945513, 0.8098566774389204, -1.5431537858669369, -0.46968276163984285, 0.374499081309037, 1.283886881186611, -0.32023077588195437, -0.8680542718358574, -0.9409307751472777},
    {-0.8468324579199761, -2.736764985583207, 0.27502857666400293, -0.7887421104816472, -0.3212663722429201, 1.3318155867235402, -1.1122076935736689, 0.061464123797077164, 0.6484462950462725, -3.369269098180477, -1.906439103296139, 0.9181239333534139, 1.304666949916397, -0.32929807549490164, 0.6242738477102517, -0.16475817144814608, 1.22778774478811, -1.4113619886153523, -0.0019575694288306283, 0.5874140231035793, -1.222238806320559, 0.7403658791126353, -0.8760168332847991, -0.5464995642234546, 0.5588686917772981, -0.9704032018990405, -0.6004256463197182, -0.01890541331660737, 0.31393149387759023, 0.1879872328661193, 1.149709859382102, 0.6382875593978729, -0.8616901368928684, -0.030135649531029735, 0.22286112199495117, -1.1197269610492975, 0.6587070104028543, -0.14658116018896675, 0.8519292218967126, -0.6026494146686455, 0.9080175523436478, -0.3846996911331137, 0.8615957391906087, -0.10017365785399591, 0.5791964449331946, -0.16094111721502075, 0.23149014361918416, -0.11969169633309938, 0.1111776156756095, 0.43946570486983216, 1.668792923113641, 1.6423748784317664, 1.4078992209810832, 0.9581321851031522, -1.2831196752692875, 1.3525456745913207, 0.8843174857091751, 1.2758788927888927, 1.601706131544716, -0.28794395094345304, -2.308434880022228, 0.737716593648835, -0.5878695758402471, -0.5905048690692729},
    {0.34184959943220194, -0.6869204892996743, 0.07257343646127438, -0.9707145631662479, 0.046826376636646135, -2.233944480800625, 0.002498808021287759, -0.015962219247958404, -3.539170483547318, -2.3264020382179185, 0.08642628737886, -0.11720498196409715, -1.5129529327247753, 0.016611369729904412, -0.35445420745581746, 0.6715861696759783, -0.3696452018109429, -0.7521735713438777, 1.0001642448247823, -1.611216180382152, -0.41972288755993215, 0.31397020567543943, 0.6577921006845031, 1.501128150383518, 0.364286399058273, -1.5786173165043274, 1.1452732506688978, -0.5153802791402375, 1.6469448134941442, -1.068862487982149, 1.2667648046380797, -1.0915061855046206, -0.4482558919724089, -1.365123725708666, 1.2576418073598312, 0.486408138854593, 1.518606414448924, 0.40261004932006095, 0.27796520485039217, -0.07183684160447718, 1.5475542324605487, 0.8627514625598207, 0.1335049833509254, -0.4785058098548038, -0.3010175456468184, 0.5148590023092607, -0.5132211256628219, -0.27626743159935596, 0.4645205760898795, -1.1340604163044243, -0.27361472343627335, -0.9881181277394633, 2.8129841387544183, -1.7781977250706937, -0.923061741934148, 1.4365909994533677, -0.5097397608639708, 0.6545198200649739, 0.2464768987840519, 0.8113872967392586, -0.905331656796193, 0.643688071863986, -0.5405165699510849, -0.41339435713855155},
    {-0.024560177897997533, 0.9732328190755736, 0.8223638848584311, 0.27876438115957153, -0.8312572332213419, -0.7746493978729851, -0.7759175956622771, -0.25961261763915705, -1.5149489606254134, -2.303650166803897, -0.24440967483603063, 2.163424904609477, 0.0995684298901405, 0.44233528929623256, -1.8310454685693336, 0.8135089573603395, 0.6528072226869537, -0.7362987744472339, 1.7114532002270677, -0.21042104961772393, 1.6817963696921652, -1.7485940634455266, 0.10084463825066102, 1.1801296000861579, 0.14032969116327002, -0.12154256520574165, -0.32369653127066444, -0.14429572157460321, 1.4762653423606675, -0.7252410279369854, 1.0686973787601264, 1.5214012714542107, -0.9385910355261282, -0.22875768787779277, -1.77269488683096, 0.2568074990048268, 1.0887020748526017, -0.39155299770059254, -0.54863798810913, 0.8808455843760528, 1.3395321853652067, 0.5471437062321115, -0.42074261205460967, 0.14458562714101966, -0.679409838602678, -0.9259482093670602, 0.6463987110246979, -0.7214304744857961, 0.5564867866129645, -1.692780018630156, 1.5769518502564124, 1.1666791791830033, -0.8259519238858143, -0.22880434125452923, 1.420066872415163, -2.01530608703205, 0.9552200775142379, -1.6190724575643565, 1.2943650086453475, 1.926864348271795, -0.07009162995612786, -0.9062809175125781, -0.9636877615999149, -1.9901872439631751},
    {-0.15758258984888351, 0.12065815401495952, -0.23767411005680622, 1.6804914774076807, -0.2032529399190068, -1.359539411066888, 0.5250295063056738, 0.604768140226302, 0.8473703356031205, -1.736478291906572, 1.2016745960696245, 1.7690339041097884, 0.7956908326157435, 2.649490135636226, -1.0031004601860494, 0.7344548830203933, -0.6136240054892027, 0.1673628031888007, -0.20492054191680065, -1.120538186519475, 0.37757498814546203, 0.6687047857664015, 2.114771250669754, 0.4181739529459387, 0.7176467658994309, -1.5275785930418793, -0.2084045357965317, -0.4579431713698673, 1.3074152406379864, -1.1751525433149594, 1.2436481782305577, -0.8589595537530347, 0.6507166217263837, -0.5616151735852623, -1.2291241278362552, -0.9954926479725904, 1.0464362388102526, 0.7526911975970019, 0.7923550820456181, -0.40042935267821217, -0.5288824186156007, 0.053173281170275526, 0.8866044899736528, -0.12328039870673871, -2.0059028935743903, 0.951485585652693, -1.6219873125473023, -0.7591063930035788, -0.8703262025132135, -1.2831700763797325, 1.319350436576346, -0.629267965880463, 0.328616929581602, -0.42143843532038877, -0.5411032873734638, 0.813193734909353, -1.0428325841579016, -0.33370655906114316, 0.046957255672763196, 1.6109623579315777, -2.041532957901835, 0.07346171069359479, -0.34466722576226955, -0.16726528116054112},
    {-1.1169227210514183, 0.6358894486080424, 0.43696510888557083, 1.5070818529400107, -0.7957716933481255, 0.4968718139967101, 2.0991693602568433, -1.1158406361563817, -0.2745234362461683, 1.6325965505536137, -1.8555277456306773, 1.7798717770201105, 0.22807281489931838, 0.6638356748502391, 3.2925468340041806, -0.6033677772480908, 1.2108161971036946, 0.7284599140508999, 0.21144574597542226, -0.5799830120898819, -0.832790693311812, -0.927138957416449, 1.9863962275527032, -0.03773294544188172, 1.724154738473752, 1.444435583848235, 0.44188330887594407, -1.3702401848640997, 0.5997297900613471, 2.259714289156587, 0.32893414943671834, -1.9135058582188502, -0.901890017946238, 0.5572743370976349, -0.26072302162170896, -0.1884475035942436, -0.9835964725265789, -0.47395884017366163, 1.2506843348455012, 2.6708654035376473, 0.30320176787927117, -1.0722568909189734, 0.3068088371095127, -0.04396336135723296, -1.8448039656321369, 0.9006339721589616, -0.6357224226562802, 0.3618209038639746, 0.07758980525562716, 0.5000150671995506, -1.8702060981028679, 1.465924031932585, -0.2411237540975781, -1.6266367142219171, -1.2124197425073935, 0.9442608264133813, -1.1214936959024104, -0.521296814009616, 0.46590199758762263, 1.1271332092551984, 0.2201589561241262, -0.5060685835621442, -0.7205411018639498, 0.3682346188240285},
    {-2.6195154741561013, -0.856345140728098, 0.6063269538573881, -0.08419198729865628, -0.0657382976766456, 0.27725970105520714, 1.4427303407838847, -0.6487637837741, 1.3478150713558996, 0.8510243577264334, 0.12718416659513068, 0.8908597003602576, 1.0510496825928273, 3.2560524612890913, 1.04830607934508, 1.8124341372848898, -1.962480375033003, -0.47964411577599664, 0.4567855333382652, -2.6189089139874726, -2.2195494639377364, -0.9326917410416498, 1.311090633582887, -1.1201957367626676, 0.5066899399893031, -0.14842390608004843, 0.9944873740627657, -0.012658672087908086, 3.1058299916577963, 1.640672042982018, 0.09143199275831781, 0.6737891322248357, -1.1451807634149733, -0.7504592409263904, -1.3016941402394364, -0.2618543310503403, -1.192987799120019, 0.05048739708064806, 1.4855598484284458, -0.19425051754918443, 0.9033265047624426, -1.0544567470989767, -0.7920191659167716, -0.19068981859523537, 1.2202878609069612, -0.9960352658152742, -1.5379099713037359, 1.049626879594096, 0.5977768043319105, 0.5714888269409649, -1.0753750276604308, 1.3052220347481922, 0.6529543871541522, -1.0988426355965024, -1.0408889832469832, -1.2459330815147298, 1.5782782972057985, -1.901207151656272, 0.7272433974624646, -0.6912505442667791, -1.064119594446098, 0.5480308158643078, -1.3463055195192195, 0.49506164684649123},
    {-2.3375932187767683, -0.053419756453105524, 1.439262432551735, 1.56510536399341, 3.2063059661865134, -0.33606096783201933, 0.14459399263544875, 1.063681700287749, 0.3081194350915011, 2.4094816278798525, -0.16749885007745832, 0.4078346167545315, -1.384464874535987, -0.270821478169285, 0.23023330474662695, 0.6358701152798555, 0.8067294727799976, -0.7926081570310954, 1.8557844806370978, 1.1618436542230948, -0.5874667768527289, 1.5802695452363171, -0.9417352063035491, 0.2199520603156488, -0.2607564566631912, -0.699127869813141, 1.7638671100384697, -0.44079570752218417, -1.267449849117278, 1.7790939096300131, 1.0418058451449173, 0.5621486571018661, -0.5172753756269619, 1.39659591781238, 1.3521463082127856, 0.30173545679390895, -0.2104285368270064, 0.37288576174020716, -0.8494969108266964, 0.6056861613880105, 1.7056337866794662, -0.53553563191788, -0.0006052051089898591, -1.0705341986051122, 0.7461107467445722, -0.6537496276957708, 0.07291787032674889, -0.03100536234970623, 0.658064828354466, -2.435027826191679, 2.193942153286442, 1.4196402384085443, -0.7865897929232811, -1.3870138563230678, -2.0420553419173793, 1.3484746014742521, -0.9882977915028565, 0.8594881673947405, 1.6729761232299587, 1.4409865675815685, 0.24227450774080098, -0.7890446004808506, -0.4426670278903547, 1.2298086527670398},
    {-1.6900406944742146, -0.4042576024320015, 0.14569017050421498, 0.7635424992762272, 1.5386624707116383, -2.624360807875482, -0.7446096665855585, 1.4664265065422901, -0.8524807765013652, -1.3844740699899187, 0.13629398161055362, 1.0303423201465995, -1.246232532427768, -0.6512789003698914, 1.8423270504807023, 0.6245871609926406, 2.392613896675904, -0.5933665438881821, 0.86611780284619, -0.5014596056050139, 0.5845159754258094, 0.7237504664536739, -1.81840215859406, -0.5117830867406074, 0.46136061463036154, 0.4887797927235852, -0.6010029996994254, -0.8397618477365684, -2.190941819334748, 0.015241066411827004, 1.9009834925414626, 1.773630574986854, -2.132503078340249, 1.4087262022352907, 0.6251133062816242, -0.4564445198428346, 1.4047095513289782, 1.178699940396885, -1.2730990554883626, -0.21993588783636334, 0.19053040513462058, -0.24725485184586293, 0.3370429586403695, -1.0161388808209468, 1.600463918328666, 0.6163273447052726, 1.296779708607964, 2.324313948821655, -1.389888807551481, -2.4468762890755436, 3.0365983916980976, 0.02655377112404892, -1.6011566696932826, -0.575097838880897, -1.3768309147488058, 2.33479852928814, -0.66722529207177, -1.2544162862065555, 1.8598764145839513, 0.9961612871998556, -0.08341715689828819, 0.36312952215119515, -1.5454761565628754, -0.09720520946125799},
    {0.5609109133917831, -0.761162789866914, 0.43918332530753507, 0.9744411859825962, 0.7322017695845328, -0.14980671575823734, 1.6450082616845634, 0.6356387920728338, -0.6097129626214209, 2.5547365214415403, 0.584069464943792, 0.09547814196255938, -1.527868690116732, 2.104929546840695, 2.207543205779487, -0.3214641547749634, 1.3144581091943848, -1.3502415132193057, -0.49282545919277126, -1.0323349461112274, 0.6886247196394242, -0.16104147195882826, -0.9203389083032842, 0.31001855848134074, -0.7425140919139159, -1.8962157583992898, 0.28660399328031383, 1.417757926324331, -0.7724758676960747, 1.017567208734594, 0.7038238260142167, 0.7964895177456227, -1.4685498382540807, 0.41113282199522727, 0.6776281266510302, -0.6107494710196977, -1.510468200226217, -1.4305391943399246, -2.072665835281148, -0.17909193980734361, 1.200515789371945, 0.788852190994503, 0.6095204788341037, -0.9963589667184973, -0.8522930500606569, -1.2090549582086618, 0.9372495038267891, -1.8306701163045915, -1.7897891616147625, -0.07628847438889096, 0.8987600283961181, -0.6491189142836677, -1.0170741345949288, -0.4181513318529981, 0.14887450248908182, 1.4363818864552944, 0.2550329865557748, -0.5199593478826756, 1.1628885632439572, 0.44386338891111754, -1.5873176278728194, 1.1664108093587982, 0.9083292340729611, 1.6365610788052176},
    {-1.2585968336005455, 0.7260976418597458, 0.6808036279755174, 0.2651187488180586, 0.22066708236381744, -2.2612035538335653, -1.675602904792713, 1.0163136953510712, -0.7718004112747782, 0.9032960436219701, 0.26619550990680463, 0.4399167227015274, -0.061828092416239294, 0.481249656906991, 0.06286517782682917, -0.03824145048764821, -0.2524409253121758, -0.29168816830220723, 0.7581390431024394, 1.540547661933822, -1.5758996147660629, -0.7921922080113641, 0.9904538949168972, 2.922597571160756, 1.3560313878118617, -2.661401670773179, -0.08609266660590523, 0.3184394771460402, 0.15097500802451283, 0.9534504424965211, 0.31835591832745186, 2.0073411420786904, -2.2343668378056516, -2.4419139701622847, -0.7368312964996584, 0.21619423262738077, 1.5924181592299673, 1.3887449229843054, 0.8379567805240586, 0.6399183653538727, -0.4450126174895781, -0.6417659678476096, 0.2485927303100669, -0.43556455758566726, 0.4020360803135431, 0.8704447289809237, 0.9718373583604825, -1.0229542775186047, 2.1702161105018574, -0.09785530810686106, 0.46373045718683814, -0.6618304014488846, -0.8043658208573857, -1.7364361515687945, -1.0766546914262072, -1.999052689523661, 1.235746875852444, -2.9150308192967267, 2.3355188313222244, 0.9497348811135304, -1.2522272230760656, 0.08578386338356109, 0.036188412345793855, -0.5294525211014798},
    {-0.6234927718691285, 0.2872157175297053, -1.1381485927929107, 1.6054688590868864, 0.07667350777627108, -1.8153957079324943, 0.4214864801276752, -0.2424037745870671, 0.21447618750704942, 1.319731676327559, -1.425480514641125, -0.5316511432322201, -0.03088190508048643, 2.1251065049421682, 1.7934362043720418, 1.5901213606128584, 0.8421500279417603, -0.9435807766945452, 0.4197624471039948, -2.0563296046419928, -2.0125780017201245, -0.4595541310498297, -0.013969410257676685, 1.9273468396883198, 0.4981064695969791, -0.22788254298810245, -0.5476747999016771, -1.7152467806942169, 0.8485601218345388, -0.6145656698393945, 0.7502600900245054, 0.2071520529187987, -1.0385123682521111, -3.2158486294404134, -1.2864922748869765, 0.4358529137112022, 2.7003478800909533, 1.2434449963888108, -1.1709752032199896, 0.8586125085853998, -2.2569964802235214, -1.31652165797375, 0.8639421085807802, -0.8067471825753537, 0.4167023276060265, 2.3300880940475652, 0.28074471017763153, -0.6207551148199107, 0.8615465639584093, -0.20813385664940318, 1.4025988059239853, -0.14609342909292786, 0.24751868911645517, -0.09650079967441588, -2.9725316853765533, 1.804275599921745, -0.7112846883883321, -1.1246001730660629, 2.256956847502341, 2.477623131033876, 0.3043486059814774, -0.694678134379657, 0.14100477812488052, 1.5859365160559427},
    {-0.33035262578237407, -2.6995526351458476, 0.7147914204474497, 0.7915016336828918, 1.1652985109406795, 0.9510282124261618, -1.0540988722494886, -2.1257123211443694, 1.2997062690534242, -1.704610921850914, -0.7630536145002927, 1.5956811967201605, -0.07796353774417855, 0.8782453118103328, -0.901580739223101, 1.3147220247246987, 0.8288755231927181, -0.579208497898978, -0.6042629068244578, -0.5741557294720543, 1.5330189192474937, -1.1527798429736413, 0.06182876678283947, -0.8365959723490182, 1.8349886148755474, -0.09430221450718315, -0.7590468486382581, -0.2009589487935667, -1.3221092867862811, 0.6965739256282629, -0.735140984817782, 1.529429632986852, -0.7265186765764285, -0.005500141375549548, -0.8295625708263963, -1.4999188407307706, 1.0838180470282588, -0.2871483173656412, 0.5326655990697414, 1.934985509641463, -1.112504249896068, -0.3393786759228223, 0.37464990630148753, -0.9010657359323073, -0.8842415160926016, 0.7624626797821472, -1.204551690221781, 0.767502592390758, 1.976873983631814, -0.4149287928221755, -0.17780333570686072, -1.3757352727578618, -0.897404894457541, -1.068314956782617, -0.18579609958131313, 1.8986121059992178, 0.15734699502559005, -1.9013521486305278, 1.3348455300102942, 0.9790754262229258, -1.4742774011849626, -1.7313192654178178, -2.8698754962805118, -0.264464686331134},
    {-0.40716995849078585, -0.2828604446197096, 1.4417896094880578, -0.3742945014102442, 0.013581758166523038, -0.2683904154135171, -0.29925908772040916, -2.62613319001149, -0.04626385684222297, 0.3717241459392889, -2.3695829758515523, 1.6601189271559231, -0.8868147724472146, 1.3520613458162907, 0.8416174406840965, 0.5063772717954307, 1.2191390868636405, -0.18074646337429737, 0.8295484741021979, -1.76358333396962, 1.5812131336266908, -0.839555447032587, -0.33494024050056376, 1.6929440803460873, 1.9157255653246295, 0.9893967787375658, -0.7999323309479996, -1.1830035069449896, -1.0942244024591463, 0.9246440676727286, -1.2311206152989222, 2.692835413332463, -0.6897222359566152, 0.19105190605806804, -0.7810436902189017, 1.7813147281871773, 0.8481460229577391, 2.183566198479442, 1.3222453284526794, 0.5388739817070815, -0.3445215854018769, -0.4898578414246667, -1.2205988347007648, -1.7548098015080296, 0.9531763736010208, -2.4412327499986524, -0.33805171578285353, 1.7856105405958507, 1.1047695757306317, -0.16700694700250696, 2.9406143373051177, 0.7022929745683113, -0.8583078845960501, 2.7290980747165037, -0.9441656621025378, 0.3211728045368918, -0.7681209835721332, -2.164290866297174, 1.5568165129288523, 0.06266457234921023, 1.4967672402856358, -1.0112654456047079, 1.4955305161982864, 0.19976626025231567},
    {-1.8093101920949, -0.24064609014936056, 0.5845641390847939, 1.5869007533681254, 1.8879936680808047, -0.8239834319045979, -0.4095321798560439, -1.4613866527225616, -1.4794355403150206, -0.8635331974501304, 0.607491788322949, 0.34818035882491016, 0.760196030868267, 3.074585224595969, -2.1696536585517916, 2.147349965896989, -1.0074170404167901, 0.3649227339588119, -1.7483859517881244, 0.32467138931329237, -1.8348458191407833, 1.5599978884593118, -1.4810212336855513, 0.7532843298524463, -1.215515826084548, -0.9239722540827627, -1.4628939259490068, 0.8278261277440395, 1.6342254561695084, 0.5767841624485841, 0.06580382754282646, 0.10080246010990206, 0.6000345463555931, -0.12719829537391264, -0.7407590010471228, -2.544357066798932, 2.45496725949111, 2.680122694936974, -0.9947825253265472, -0.4702792543862854, 1.3139520108682075, -0.7692543090710097, 1.1288865220453503, -0.43353465478390407, -2.8015103424009733, -0.7647557778673743, 1.0297038469750863, -2.9429110560839007, 1.4070093350976483, 0.2837969400829448, -0.27370094496048053, 1.3728387517017389, 0.5467886594861466, 1.2435021644489705, -1.1998227092926912, -0.7758962706131104, 0.7271137573507689, -0.643187760039703, 1.3351101647355665, -0.9693875801002281, 0.33626403323800325, 1.5575161427654802, 0.45561528020463765, 2.2303545063477705},
    {-0.4063348945645758, -1.534523604538225, 0.30067243897813367, 1.4812869678668463, 2.7778012939458296, -0.3635676234796678, -0.3929722876140209, 1.4000852697120167, -0.2679804983668899, -0.9507837135276024, 0.16001055165694486, -0.5698836624367462, 0.5534481356140888, 1.1718275760014278, 1.1660048246059247, 0.289108340807018, 1.3153463669564918, -2.569717973524815, 0.7904993238298939, -0.8473407141341954, -0.27608587944613766, 2.16529969762879, 0.4439521672464404, -0.04602382827256681, 1.7811685706617109, -0.47023871771488457, -1.9393208275630187, 0.05979042307489968, -0.3116408296113905, 1.2671448170844182, -1.2063229493082521, -0.05791018667375709, -1.0321973201790569, -0.710311928981525, -0.8648849504239084, -1.0795967621781977, 2.115989908446592, -0.2273170924111039, 1.9878577876676973, 2.117136754457387, 2.1155424416220425, 0.16992245285514646, 1.2495953048343367, -0.858109326911769, -1.2433346906233882, -1.6348847847865449, -0.9075852873236533, 0.8349159517693036, -0.9537133964728892, -1.5337166778795035, 1.2183246518953814, -0.5880681762011145, -0.18541304716745793, 1.7072012344150849, -1.0913309588813662, -0.6848694272599487, 0.9887488992207072, -0.9934300289664034, 0.9638857552747672, 0.24471257087988996, 0.7060111711995055, 0.8843538656118635, -1.627442710732793, 0.44626572052170793},
    {0.351790395739857, 0.13641840707712602, 0.0900741281273555, 2.9489981289899356, 1.975857098034733, -1.3615725514258572, -0.413463563452108, -4.014329063912045, 1.2188362846105563, 1.261166639096291, -1.4116040906617595, -0.23398050654098584, -0.49208499667936306, 0.4265428881355965, 1.3721895676409082, -0.3364513498386528, 0.647585085469114, -1.2901080628254775, 1.6472013649993593, 0.12992169590192124, -0.13185988500818382, -0.4769681948246828, -0.07546225896800889, -0.6123953361093871, 0.9110047763110583, 0.6257824179003442, -2.290185703371999, -1.2157954414246943, -0.358791764011298, -1.1100451821316393, 0.5034985800816825, 0.30294776106801957, -4.08114962007166, -0.34170777070411873, 0.25413701433285507, 0.564508726535277, 1.3264921142712416, -0.49759627812540297, 1.2133840704826684, -0.4299869665298469, 0.5205198248109995, -1.3341020452422958, 1.078522856375613, -0.4006833778869187, -0.8258520347098537, -0.7446774379234051, 0.6954875164935469, -1.2930606746442335, 0.6259769421304431, -0.566225955605902, -0.5131491241952467, 0.39133665260329825, 1.1189368137555489, -0.8326772484482755, -2.1922423847907324, 2.0313946223719777, -1.5954391068638047, 0.9047998770161316, 0.06860195408327577, 0.5998372369965383, 0.8571183203158869, -0.44478806647899244, -0.947499402238657, 0.32106433683825514},
    {-0.6001204098541987, -0.3861561891543731, -1.4601482982243006, -0.2850580786696843, 1.8201875101337917, 0.21598375201587777, -1.068742232593363, -0.1365454420053433, 2.0530041227111604, 0.04064662852479549, -1.6076949389441633, 0.5694395547208682, 1.584081125883417, 3.107795991911079, 0.21454951690158747, 0.5023627356330022, 1.3746639437081674, -1.490009121374575, 1.9393089943714268, -1.943329531592933, -1.7065304328914703, 0.40627195959805296, 1.5195751840002605, -1.225671962191045, 0.8055633526287053, -2.4488654691967673, -0.6061598658821534, -0.234647966063906, 1.027772111815633, -0.23063420818812708, -1.023592084341849, 1.0016708178275229, 0.45510004433216483, -0.860925436499072, -1.1865640927103687, 0.12455260850008285, 0.22701341823945195, -1.5006775634438756, -0.05620826880676294, 0.6040869689626699, -0.03476339200472664, -0.25691956765473256, -0.5656004809683631, -1.0580753091787392, -0.6392379486169912, -0.6864839011432406, -0.7426688597593527, -0.8655088171824538, 2.090895950219976, -0.7057016757295398, 1.1065901338926907, 0.0003805627699105272, -0.5964333525472166, -0.03668841151695133, -1.9091945361303388, 1.5936272080237592, -0.10589535321225751, -1.7552278995353137, 0.8674351632875914, 1.5309255472004109, -2.2683846384309865, -0.637193354044157, -0.8020218488572287, 0.9317525952309997},
    {-1.474737152889349, -0.7881288298696881, 1.2956691624906236, 1.3303439378616635, 2.6881602550744326, 0.17166321117676733, 0.6519878464499105, 1.574626120081705, -1.806068063380262, 0.48136856474161194, 0.3106586915629662, 1.6880781121130566, -0.4794905824296054, 2.6551226281838547, 0.8309898865191634, -0.31819931979512633, 1.8659134033447196, -0.5785193667209769, 1.0146098660950744, 1.361213414837198, 0.9913776316661753, -1.6591997837047978, 0.6119357260486782, 0.6380258035268528, -1.1256995076454896, 0.4502207668178821, -0.7489491574332963, -1.3360800641758521, 1.3072733821460887, 0.32409236179550827, -1.9772802546812562, 1.1868393082020174, 1.7191508005427194, -2.516832736440032, -0.9016031456059145, -0.1316472003023786, -0.38791043222174515, -0.01219623701174853, -0.19575791226149322, 0.08438478636585096, -0.008887055090261805, 0.11439662914415867, 0.08141579967372903, 0.7303414318994569, 0.6177496865333266, -1.1070138501382971, 2.4501204997007355, -1.5877346983127034, 0.7074478576905344, -0.039864977715924975, 0.21851962230376484, 0.9292074800366884, 2.5920024240052726, -1.9763191670461862, -0.03266525606946219, 1.6567058745087406, -2.382396284948397, -0.3086566307070193, 0.8464729417823632, -0.1254944093954322, -0.8312140965427837, -1.2730604585307075, 1.6148132421687356, -0.03991320222179358},
    {-2.1088429035434424, 0.2529477229209382, -0.20395468077279472, 1.1641775096483968, 0.8696864964689474, 0.3010626702825454, -1.0070899949511276, 1.1604518897573157, 0.5495425874150437, -0.2834193619279744, 2.395694015960304, -0.2665725729267685, 0.5742678298599828, 2.4065251119799163, 0.9647430574327454, 0.13601477826283986, 1.8487524437932012, -1.208334787823363, 1.1734431116612927, -0.04239870216640756, -0.07989857940472642, 0.15936564694695948, 1.0616692159805732, 0.5406441775658681, 1.2821846024041545, -0.40800201411963266, 2.168638088087864, -2.66842479288453, 1.2291776616073948, -0.6420667509882719, -0.8739585441334973, -0.44013948005671527, 1.7868387363048455, -1.7283937012124837, -1.6794059050650694, -1.8927613084689883, -0.3619988818046133, 0.1701561584387632, -0.7513811637240617, -0.5411797463902606, 1.5629395828858563, 2.3791571166922174, 0.23296564735444047, -2.764109799729111, 0.5384150782145304, -0.8984890337556649, 1.9572231647046803, -1.7065462762407697, 1.7859772170150177, 0.13545617586590292, 0.6064793235033281, 1.087415861787048, 1.666073246366505, 0.10168394610031452, -1.7949899752509824, 1.2450471791267756, 1.0857848046767276, -0.8306546127814423, 0.05907068289599525, 0.9562730421525818, 0.7478975741166495, -0.8626854603601561, -0.31213468598985583, -0.34371187766675004},
    {0.2128334727390324, -2.625650449233234, 2.6689427334931572, 2.100304514262724, 1.2415534700326247, -0.4888556682480001, -1.7032064326940362, -0.8298660184374769, -1.1047585227637595, 0.24150833156585833, 0.6541891551927124, 0.666591276326715, 0.6987633791439811, 1.3036232257889804, -0.2279794634992641, 2.65899459802593, -0.21261800061971262, -1.2825333074194925, -1.1613405918751025, -0.7521020474431732, 0.8708062710315769, -1.3222618716493502, -0.2833490701448227, -0.4597657927887405, 1.119581819962003, -2.1053289585636894, -1.852210082911294, -2.0043534292894654, 1.0951389308213475, 2.462269276504348, 0.840188503109359, 1.1893934073332328, 1.153464604445567, -0.13474813198873775, -1.4606618718896234, -1.2859311614676907, 0.7678567622887686, -1.2472028649631146, 0.7700603666915057, -1.1775604533481534, 1.1891611413004, -0.8883540316024061, 1.6068444586735515, -0.42123889391753516, 0.2813309571434144, 1.28325700233811, 2.650395457102784, -0.1001070187365858, 0.4289669015243059, -0.6150347044429092, 0.08162629843431116, -0.3531385751115306, 0.543730069534851, -1.1354694960815197, -1.7095278478005609, 0.7238936679484261, 0.42506578136380213, 0.16269483497425002, 2.798579272376235, -0.711836968398413, -0.9514382724321041, -0.05541923904265342, -0.17501788062865384, 1.6386605535739802},
    {0.6178496191732126, -0.7580091351237376, -1.297848449850096, 1.5427612119704341, 2.3458414366688434, 1.379668146910619, -2.1135548066468632, -0.4174061588185394, -0.0009692627391521436, -0.45141336656127307, -0.9598653595284462, 1.35563472531397, 1.0621460346250846, 2.1235198243370372, 0.8790241682571249, 0.36739727193131, 1.5153971260840136, -1.0559551646344982, 1.4131264184053909, -1.0049964326116876, 0.16738936046524594, -1.040613103455541, 1.7296295788516014, -1.0532695407323793, -3.5104834286861024, -1.6363886141964457, -2.0300080397175555, -0.4019115461710608, 0.08725818239813121, 1.222262651337914, 0.17669765021201836, -0.22037255299211125, 2.319698940047025, 0.3468356982846491, -2.8259614116169995, -2.566269886489601, 2.4195782446313925, 0.5300530894318222, -2.531347116962055, 1.7300163708082816, -0.6832023270361565, -0.9377648317557903, 0.5621729115487246, -0.5041739150112257, -0.5398229754127594, -0.6467436471096067, 1.3109733580890686, 1.974681238786554, 1.0580672393784296, -0.42995578735119055, 0.5311368994042944, 0.40935081511257776, -4.202354820130771, 0.27800305443401585, -1.2479208778995885, 0.5318258186268884, 1.5762489041378305, -0.3387937434754214, 2.32108894363964, 0.3836304595456969, -3.285431464887129, 0.5325847564638452, 0.09507435591962317, 1.7904352250238358},
    {-2.0763819511862422, -0.45300810956523707, 0.2402550284661199, 0.4834197712418031, 1.46451669604962, -1.8609571966675302, 0.18140717962396805, -0.9116283148138019, -0.8095747229722444, 0.31128636553653044, 0.22512369921759673, -0.4437338256693409, 1.2529922796101056, -0.2636894346461879, -0.060340037507510984, -0.15788977122641942, 1.3143332696895595, -0.3355762393735445, 2.000340024447136, -1.5928460621428138, 0.48910193239011635, 0.08821483470306976, 1.6594884928603875, 0.394910762853499, -0.8251719360751374, -1.994082064115877, 0.04454117426615662, -1.3583481061941116, 0.9774695903400292, -0.3517921914306666, -0.549488321395683, 0.979274615021481, -0.7889260129993309, 1.0799997858416621, 0.39546689941677826, -0.4906773933770166, 0.14337888938445972, 1.5135049484275784, 0.5053487571040937, 0.7014813545777441, -0.37858839739607725, -0.9616601034626312, 1.8615706832387728, 0.25455210244497933, -0.8909997689004184, 1.1483512290815796, 0.38230785856407973, 1.5287721002432917, 0.6101422424791543, 0.18375956034033772, 0.2151869446471839, -0.8940825886830309, 0.2157903575965576, 0.5908658189477015, -0.37195602545908135, 0.6537767608168755, 0.6239199718495758, 0.23236072480383924, 0.6017991255152869, 0.4801271093896283, 0.9233292586961879, 0.5557901085220844, -2.1223912596726886, 0.014582373232219696},
    {2.4119187576340773, -2.592299558611233, 0.23006796878378014, -1.4511260578728316, 1.4187701072752645, 0.22183404538357537, -0.30645664560508157, -0.24695728313075718, 1.0079891941926675, 1.4653415200299638, 0.46069876290397266, 0.16767579640979244, 0.07137462385870937, 0.2794843464554814, 0.5283310710163002, 0.03143715787510518, -0.20293496830925117, -0.19941272731023038, 2.020261410690333, -0.07811675688399763, -0.3442085959231205, -0.15136832736991832, 1.4019170815588058, 2.3008023125259895, 0.8943676011539731, -2.0803885262298256, -0.8859675717177214, 0.6647318113611995, -0.3197624309548942, 0.014936357285496887, 0.2767434755314425, -0.020272368688717863, 0.5384544826141708, 0.9687779046961923, -0.9508165313054607, -0.519755150652679, 1.0976252577016803, 0.2299227769277128, 0.4056730170938873, 0.5227352309624532, 1.516915066775581, -2.0753859443403946, 1.3949652176443277, 0.22785446742295962, -1.986541167983914, 1.3227437815656324, -1.3039579163555397, 1.6435867239610376, -1.6736977103099389, 0.45016743182658236, 1.1974639164643872, 0.5409864155744815, 1.6753460563441018, -0.8886830792422208, -1.9931946340464812, -0.5860663744935718, -0.20113649972891046, -1.1958753156079331, 0.9206436962890897, 1.922216582313627, -0.7151442698901802, -0.24017125977174936, 0.7086773788728554, 0.626355249944307},
    {-0.026027415947175846, -0.37963408160596973, -2.0190155958487046, 2.495565530339008, 2.3151449924967102, -0.33021366078692677, -1.3783781215450714, -0.19254723562028464, 1.969654545349235, -1.7214776817594197, -1.5016936591577563, 0.3069348227806276, -0.2670999012723109, 0.2721735698385126, 0.26257326754151056, -1.33783016480011, -0.9016240568549075, -1.6624362441282396, 0.4359631535169976, -2.428007785578768, -0.9390308448473718, 0.5311636218337843, 1.447664111686509, 0.18388784971485023, -0.13188493471204762, -1.1450426726330036, -0.7959084354952146, 0.8875109097846609, -0.6828406468634827, 1.0424815774574723, -0.18728616621699457, 2.282209109092958, 1.9652420969468798, -0.2696544332416232, -0.26369360286060367, 0.10608874132635264, 0.7959800981505175, -0.7288465030072709, -1.7287484925750514, 0.602058422481104, 1.0271427904859285, 0.34453595779469653, -0.4854654105783039, -1.2930254156603207, -1.2740165254914533, 0.7027427877503163, 1.3754126825607182, -0.9772560328679522, -1.5514741127677416, -0.09638307326767437, 2.264045978366162, -1.24245082260711, -1.7954891559728328, -0.19629264612861705, 1.7353729060923997, -1.5023726122425258, -1.019848961310296, -0.4430580391440257, 0.19110369731480986, 1.4510117336820032, -0.1837109667538208, -0.09285054627851072, 0.19215704511728987, -0.3157424342292337},
    {-0.5732732258918747, 0.33642930886171174, -0.6717573091378304, 0.5363844982230286, 3.350948389615412, -1.238531347078129, -0.5171895615744859, -0.8663976257570233, -0.4000237842074016, 0.5052038563500529, -1.443094663293495, 0.2075075909297565, 0.9398180578506288, 0.9174781534872207, -0.7614829477885205, 0.7463803892762232, -1.3226605574024897, -0.9344072117963109, 0.7124401664637459, -0.40888622456850515, 1.1428031524132791, 0.20094745835971659, -1.4604907694264193, 0.33729121529343525, 0.7181089941824168, -0.6704608776446475, -0.7322343981538594, -0.9050898812472135, -0.31004016331275636, -0.9622407417082146, 1.3903015227689566, -0.03526580139147593, -0.8566549718515208, -0.16422438275050588, -2.574268478731227, 1.1632707317251039, 0.7076897322769621, 0.4586631783084462, -0.8843435182944838, 1.6768698540126175, 2.1895184738967055, -0.8356835029321772, 2.060727754276909, -0.9683641805307373, -0.7997076061184221, 0.18346744520542488, 0.04506194258208373, -1.22998889197418, -0.47053245787350984, -0.24639482337577223, 2.458439861706508, 1.4486576454718891, 0.9189811672102917, -0.31197459585799997, -1.0326597814894858, 1.236929498126628, -1.376413279413351, -0.1720860906749777, 0.9653897207282189, -2.356896492991487, -0.22656398376419998, -0.3634063536844239, 0.8107142686116013, 1.4697850603040572},
    {-0.22177084199869296, -1.122772121098158, -1.7162412423605473, -1.1398718092853874, 0.23479934927013654, 0.5348331523561203, -1.1610328276578028, 1.960908402260575, -0.949270593706109, -0.22287513433165107, -0.9888897778934389, -1.037373257449765, 2.326347698111662, 0.1357618508347296, 0.6155393190453067, -0.027663471460379046, -1.2337356803067467, -0.8030639761205451, -0.6571281745512579, -0.33374578020500967, -2.617556410277802, 0.9076480497029881, 0.1292176944083092, 1.3246558151440333, -2.1624555372646146, 0.2656505250843763, -2.1023239488655547, -0.32256283110180706, 0.28890676625118494, 0.47010466112760957, 1.2099691510390684, 0.609179482383021, 0.19320410417630027, 0.028800125406374204, -2.2109187800332784, 1.1774892030678303, -1.3559525751197223, -0.13747047010310393, 0.8018433031524241, -1.0473736169617656, -0.5451842767909939, 1.4471550033786593, -1.5959660938788922, -0.31599796424775645, 0.512227338141695, 1.0571900869938033, -2.915162815510396, -1.6619067623082173, -1.3288016928433493, -2.059350488717196, 0.4299410588287816, -1.134282566835266, -1.5620453213771222, 1.1003000759089459, 0.07438481645150956, -0.17087630026320488, -1.0981288021020756, -2.3513123809349876, 0.41801622293471274, 1.5132205786504156, 0.36553180531300405, 0.5834890468574019, 0.4589498134304543, 0.696313609766701},
    {-0.2805458883835814, -0.3974311003393264, -0.19561373152617617, -0.07171556959513424, 1.5803621311651541, -0.7822879889072495, -0.6130727162513001, -0.012159589390588466, 1.2479122734761676, -0.9910540419205076, -0.7266815118248329, -1.61305308122687, 0.07595267655420591, -0.15608245571358584, 0.5807449555981165, -0.3004263653501302, -1.884718722835402, -1.1453059354543391, -0.9570850249345728, -0.23728513867000176, -0.7962139357005138, -0.2022951212550546, -0.6159912368440432, 1.0396603405545168, 1.2452670377231316, 1.490484013783601, 1.1813183480098188, 1.209075346591648, 0.3896618361090713, -2.297977068938389, 0.9777603717992382, 0.8280413886958093, -0.40227996860212084, -1.441842414310212, 1.6621859192164399, 0.711813198808392, 0.0549171643570764, -0.42575500991094783, 1.5044154045965106, -1.3919080220731905, -1.2877709855213426, 0.025043986336882366, 0.10450076184721069, -0.10488886211867833, -0.5682372330250497, -0.9986431549533356, 1.0622719406933347, 1.0532385710901957, -1.315244734034401, -2.3523552956235254, 0.3935317296654014, 0.7841372788725413, -1.0168909929395178, -0.7291499535825695, 0.10621961111844173, -0.6060865605939708, -1.1111181676722182, -0.14713892143491344, -0.703872789406032, -0.6866852872407206, 1.4781471935511206, 1.4524680321673071, 0.24676321477821722, 1.3380245973696563},
    {-0.2147420080002574, -2.4212357266366573, -0.7263828340349829, 0.18787081805456507, -0.5320864521680219, 0.4522498945208309, 0.32892503944212803, 1.5443676642282516, 0.7920210534022923, -0.908167009071712, 0.24972619160873882, -0.38086366995330057, -0.574244955251774, -0.973192554486924, -1.3788033276072116, 1.5500060268142943, 0.00901534596769772, -1.0931827460487924, 0.6351874825052618, -0.34055657421518315, -2.0982369408267716, 2.817349085899345, -1.5098514585986702, -0.6977532148866692, 1.1601360725486614, -0.3973301365683695, -1.2253911980223187, -1.2522773456257001, 0.654980866346324, 0.42704197092275403, -1.8487564221531416, 1.4092631247616632, -0.9697714412317064, -0.605089544052136, 2.02007994375851, -1.3841857688536388, -0.8629893818101989, -1.7272471120436985, -0.7594537951888521, 0.4013779549532187, -2.513622922920664, 0.1490265323210487, 0.1180370615187499, -0.14392457280102125, -0.19393743773800748, -2.573993860970719, 0.10362862849711801, -0.5286260140637877, -1.7436334857687577, -1.323344571530853, 0.1183787498422992, -1.3380496266025406, -1.6103643475528782, -1.3275741609587302, -0.0379141899472436, -0.9329813576479783, -0.7750431369769487, 1.2200228688698858, -0.38905781685630236, 0.7918167517851674, 2.051385185904646, 0.7553114589188697, 0.8870676291530147, -0.7749485366818817},
    {-1.1489111779594374, 0.4929027506980104, -2.2826696567321334, 0.1582903020411612, -0.16941334180383869, 0.7453011472098766, -1.507842410526613, 1.4941546761870423, 1.8633872005568102, 0.6131081276101654, 0.61913719925851, -2.159629726027467, -0.25946364298830593, 2.448377450520309, -0.08897089992647296, -0.8037428415961301, -0.367489884876941, 0.18432427515632183, -0.010859345351820919, -1.4097299141346409, 0.08356932383275056, -0.9639470172342931, 1.2665478286575425, 0.42123687112242225, -0.4176000348781822, -1.416111030299806, 0.8763022284736942, -0.2010109973121612, -0.18777224016473687, 0.38880949694351935, 1.5276255068755513, 0.6954808656760911, -0.09242550797053785, -0.827765658223091, -1.1518570920309983, 0.6013230319157467, -0.6650388753830325, 0.41147531208313604, 1.8046391738882617, -1.392319659532083, -0.8738083463362978, 0.705070095868384, -1.1785613648353723, 0.576467709337073, 0.211439568416481, -0.17728560526195272, -0.026287758286574602, -1.8433541646915352, 0.06332241452111197, 0.8873886029843113, 0.7364247627827097, -0.007327302827316211, -0.7132376356046486, 0.13438933528535155, -0.8972175659285953, -0.6689598306417592, 0.7170675539458339, 1.720349700560187, 0.8311922766084473, -0.5879579142083277, -1.5794625363648969, 0.6675069814866934, -0.06087288473678791, 0.4737526072585428},
    {-0.19702919972042285, 2.3928367253520535, -1.6858624847455486, -0.5560083623190986, -0.7002186223310056, 1.6856746911495646, -0.4313198715961504, -2.082724199503513, -0.702642245362319, -1.8750914322344527, 1.1032349441688507, -1.1109124324153883, 0.5801071337554813, 0.49354201213739507, -0.39847741915930873, -0.6855777820711028, -0.6764111706892999, 2.4400111600441017, -0.004939980377554214, -1.3700839388537673, 0.3112627074916699, -1.4185824003460668, 0.11045085684694854, -1.2847132595499775, 1.3539910487416287, -0.4964773526604283, 1.0737566610775626, -1.667931430981707, 0.5982730931987833, 0.9573513132838226, -1.4163539926464048, -1.8220280099323003, 0.7476360963622278, -1.285274464435066, -0.8093952239646617, 0.5613465651079267, 1.4998543898237566, 0.3442550496923747, 0.9566909827504175, 0.6380426202367341, -1.20200579939741, -0.02773986202687951, -0.8345759370047399, -1.4458082628160036, 2.777159478278888, 0.7886105088349433, 1.4456766419234617, 2.849842673883919, -0.6373699730201091, -0.8355875780186348, -1.3263607236591632, -0.28729070612271734, -1.1246050271707726, 1.0062435188163914, 0.15733165298903456, -0.971051943715593, -1.0405431281419162, -0.3968038342603066, -0.5683221283179458, 0.22719863767187476, 0.5481471462916602, 0.35549414713517885, -0.26553954412914466, 1.6825413130290436},
    {0.4748442729897153, 1.1526254001297231, -0.3314456041717681, 0.3187648400308148, 0.022180071009290744, 0.4484950551705092, -0.24369878937136089, -2.2373909499528812, -0.5453333983018265, 0.13656213160361302, -1.4226541022157537, 0.07781004505934265, -0.3192351009091933, 1.0618978411148259, -2.1727333578904475, 0.5204523590699237, -1.4766714877537046, 1.4478419108219316, 2.3903039637364447, -0.1913611456387825, 1.7157099871989887, 0.41105775263647804, -0.33875922551889837, -0.6987602960049083, -0.19519394091385828, -1.108175141098802, 0.4238826556748316, 0.7603516227664188, -0.6633527512992745, -2.76720827137596, -1.7012508692483124, 0.5015700672607648, 0.2860264013425258, 1.261837671377604, -0.8490801509810947, 1.6923840033200974, 0.11736846991797874, -1.44909469407456, 0.62383283662196, 0.16853751390996533, -0.12796585942210925, 1.513964109758877, 1.912510305012909, 0.7745209624165525, 0.8678689243569763, -0.21803198255895426, -0.456855143823145, 1.1734893718787482, -0.4735749999948803, -1.253075689762968, -1.8089300928163285, 0.8086187847988475, 1.0279541964552041, -0.5011543470408061, -0.19188883062438133, 0.25444395755459037, -0.07042229308380848, 0.5053142179756309, 0.38381978309694015, 0.8245794878920002, 0.9398277051238623, 0.9727744044810236, 0.5928450962859824, 0.46013629230801073},
    {1.5621143276077498, -0.9002296446113778, -1.4562144348346242, -0.616940720711473, 1.106873976802131, -0.543163021082683, -0.8191843017814744, 0.16673846098630082, -0.48952435346828205, -0.17144527870794032, -0.7808251017949039, -0.9083646065516187, -0.9247576212965435, 1.9862686017184705, -0.30085593639326574, 0.7111926241234455, 0.4545262939646431, -0.6408376001876132, -0.22388066040099858, -0.28556875703634743, 0.7390920304870225, 1.61738847825807, -1.0781604731037269, -0.03689935486041397, -0.13950979777403452, -0.28054363997218207, -1.7795686483232984, -1.1547261554479717, -1.3361855909360496, -0.005668830834651813, 0.10144649379671813, -0.17627460204778905, -0.30463750763953124, 1.0354005459782665, -1.20329797330356, 1.2488514815649043, -1.3559696044521676, -2.2346851275820385, 0.855626515436901, -2.2077592760619056, -1.220069717388975, -1.129314101250995, 2.9055533328740912, 0.8370025639020596, 2.1015594879619424, 1.9126822147030602, -0.9108844050740575, -1.1226378060892157, -0.1751398314361973, -1.5600676458340161, -0.7289533839957147, -0.44613182926926914, -1.0456601346809977, -0.9342970090019502, -1.2934007397815501, 0.40926873223462645, -1.0889301352512208, -0.7529463520492562, 0.501991312417223, 0.36766378336991046, 1.0579185676241072, 2.283890770958185, 1.7254256117454123, 1.2518450349300467},
    {-1.335436290272461, -1.1535053184992123, 0.28927080909209063, -0.5403252868796856, -1.5475820922998957, 0.7629130077858044, -0.8667225295189965, -1.006165415769097, -0.020556258320337285, 0.3131937579804278, -1.6342735572154312, -1.8385223634549996, 1.6245566181401834, 2.7516134820918676, -0.36678868318752345, 1.057059330893637, -2.046034296831058, -2.2258704856565017, -1.3321616906937197, -0.6633298080702966, -1.140810711526424, -1.3191430062713163, -0.9305920419887943, -0.763651598731598, 0.4713162884085154, -0.9990513581803704, 1.1435695287583383, -1.835583943007489, 0.616500590868521, 0.66443463007342, -0.3166409611364343, 1.0318700920436767, 1.3994699833469466, -1.1476925392330977, 0.3373860590445511, 2.3133582745885155, -0.23979857837682103, -0.5837484342985618, 0.31847312108253517, -0.9152301377772729, 0.5066630908657527, -0.5574723896284888, 0.27129189283368194, 0.16198541221320753, -0.11911488758697641, -0.4217862178871151, -1.1410384596673009, -0.7533130708434206, -0.9958311519711233, -1.9468767536541358, -0.24093575361173677, -2.889791660151549, -0.819633593997417, 1.0684127056988768, -0.055555434619896975, 2.2652505352605137, 1.3476596578630076, 1.2685651564843579, 0.08100173264696504, 1.2880200137964601, -0.4712392553771715, -1.524678406733264, -0.11215765048826384, -0.9919167975730757},
    {0.6934436703721909, -0.8446714909313825, -0.5341935582366305, -2.7299814546643213, 0.14826626756350594, 0.5738379419818407, -0.4108195999343653, -0.8945551649635288, 1.6558460385980756, -2.070415990234803, -1.9704178170140827, -1.6207363640666363, -1.0747464268509865, -1.4728958232842433, -1.7842228923351462, -0.03546517730225453, -2.1819973266413255, 0.9489561664559003, 0.47676226100229907, -0.8646996889498972, -0.47651062660056404, 0.18911277098844548, -1.1630127725501715, -0.8452347779465202, 0.5559525971840652, -0.4353892826965591, 0.5498313507271962, -0.1781411951103867, -0.5371094999131654, -1.3350526167125596, 2.0954179233494266, 0.3025437646306399, 0.153024293594143, -1.297499432771832, -1.428693872525753, 0.6333147471872164, 0.10678300321360208, 0.7828584108102382, 0.4481608222523585, -3.4332514452988026, -0.8124972376470315, -1.299144080861677, -2.0795699409901296, -0.5008045122870987, -0.21809697191097585, -0.5725929335490922, -1.865167681383477, 0.34818375043278343, 1.1857294105856888, 0.5744518997961711, -1.951253266674284, 0.13561503797004684, -0.0640117499534189, -0.48520999841891005, 0.783766400476891, -2.2134977441712187, -1.0446520650194637, 0.43780654516094825, -1.677417511049131, -0.08046113562781575, 1.500175185778922, 0.1565296956185805, -0.09892273404064302, 0.1942457959269221},
    {0.15990124252845908, -0.39191121976093174, -1.2824616557550885, 0.5663504917603571, 0.09125165763241312, 0.49061438440470095, -1.1193286881471998, 0.4335946919566255, 0.59958660182626, 0.27322911779734466, -1.0215648100708505, 1.9233008259787792, -0.8471473048296223, 1.4058194863138607, 0.884523497295845, 0.37505798851157973, -0.34498727205465474, -1.9673575631161868, 0.4844225207174782, -3.7600144156945383, 0.4019319609601227, -0.08719347539462616, 0.44485875540130987, 1.7714377956558665, -0.9912064060492595, -0.4366211455661975, 0.7100487244270245, -1.1994383611017834, -0.6965542419575615, -1.6187311893115324, 0.24490740687851834, 1.2018365668081579, 1.1533321068201097, 0.15052078837059174, -1.4874491851638052, -0.10285944383054932, -0.5656253071819848, 0.43628339636847885, -0.8684081415055612, 0.24375321589058116, -2.5504282308030017, 0.4831557734979728, -0.9180173714216552, 0.8179187847008791, 1.450648217676061, -0.6612292448249668, -0.2578917204142067, -0.5270203287006819, -0.6926185480062765, -1.1363266860847643, -1.2869254178060205, 0.5680813140825316, -0.8154007140433102, -0.8875343837866121, 0.6520794628515839, -1.112371943640865, -0.38315986382021283, 2.079941322707319, 0.15595527053743916, 0.4055658630227855, 0.6822441336571322, -0.16913915058835027, -1.4191538353187947, -0.425751177452234},
    {-1.193818751950503, -0.7894438968607672, -0.9149407970852005, -1.0270845081302487, -2.2551702487040743, -1.6684178102324185, -0.0727322938118488, 1.1509902855475846, 1.611297285770012, -1.0736141990165033, -1.4796503455221377, -0.8410643597680709, 1.248381149080094, -0.5496116057924004, 0.42790253425469943, -0.9351658277209709, 0.2724846817337131, 1.5542793413247167, -1.0320107034111008, -0.5421131801266691, -1.734117819201971, 0.8273512568076452, 0.8632598793747028, -1.3948469284841387, 0.42579473962788916, -1.5032031529215242, 0.2876047196017196, -2.100343941074991, -0.393488943921562, -1.1892552151277638, -0.3947763559998626, 2.3283890389753052, 0.8012998571362606, -0.3499906317050823, -0.5271564763309179, -1.3552338970672582, -0.3011420054791032, 0.5292946473030312, -1.5507082093364346, -0.1406925326692514, -0.658363340401369, 2.2880880243007975, -1.071684300957806, -0.777521067535734, 0.31681676633015693, 0.7306843541234375, -1.119199139704069, -0.47995946370317966, -1.6736780080370004, -0.7950713449397243, 0.5091483880712278, 0.692417986266299, -0.31806631260369744, -0.47341709811345545, -0.27645573679997826, -1.8229123288732163, 0.7023039216324395, 0.665567200298475, -0.13467020380228106, -0.35353553023815454, 0.7173719721096666, 0.48931018343573496, -1.6737060470465488, -2.5078761854843297},
    {-0.7441525263320562, -0.15778255001535066, 0.15306974341510846, -0.4408340844516942, -0.8952458149511071, 1.4832464039328228, -0.021413163263685753, 1.1526201423966684, 0.40051091150202983, -0.27770893021753984, -0.07720993853827925, -0.1212840921753774, -0.4289878606297244, -0.6071206654289689, 0.19009369540402057, -1.180558595808393, -0.5238289481727236, 0.1694873976359145, 0.6647992957626792, -0.5429444061586589, -0.26593342473444015, -1.9054472703355365, -0.5594739336472138, 0.3807956930268319, -0.7670956037612163, 1.0907654622323633, -0.8522059522100949, -1.1360425983959561, -4.513559497733235, -1.007356419070233, -1.3166811527181836, -0.8814647934443351, -0.8394407858144066, -1.4237546338541482, -1.8897702757514816, -0.30190983598771487, 0.40139858399498063, -0.5381308534205661, -1.1307489214880477, -0.4040973263104119, -0.5889759969237803, -1.9841569060857192, 0.03481008940266415, -0.15804469360754975, -0.7072436118003927, -1.3002942423625734, -2.5431998854150977, 0.42177444382875906, -0.0656829624387181, -1.7551037107873377, -0.21395799170689647, 0.14816104626997167, -0.6366196465175006, 0.1505214152808547, -0.3040260495930181, 0.2330783613204338, -1.2169167942066008, -1.2664242164472927, 0.48793815191049233, 0.10682671802054053, 1.7544752958325214, -1.0745933157582734, -2.9372919947826968, -0.7348595905641332},
    {0.6831775927508853, -1.249325007111637, -1.3421031189534736, -0.573212549607541, -0.505865351997221, -0.747264364906756, 0.9049168739165391, -2.203436837578557, 2.862582677839263, -1.9227478907373214, -0.23582760837769728, -0.12861031148458846, -1.0883385291746699, 1.6535046700859162, 0.020322929375580317, -1.6572165843657, -1.0426218802057359, 0.2838103805057552, 0.31810210575413683, -0.43277370368891493, 0.0888524151823807, -0.8510597659529466, -2.103289105275266, -0.5637957174079382, 0.40469389509330594, 0.6063834345866342, 0.7562068227570328, 2.1137433959174627, -1.9319481458897503, -0.29155623926594787, -0.49493461413205514, -1.647137063538964, -0.4423124938377881, -1.5485016521598456, -0.3799276664359425, -1.1679061133987318, -1.107125673664037, -0.987246191289092, -0.8034576480229423, -1.9428387396171742, -0.2566070953637032, -0.680538052687778, 0.43963332881535194, -1.8348429264312724, -0.41142055868358696, -2.7499117183876782, -0.24733776903274846, 0.9233953343168161, -1.1311857577738813, 0.0005477936349510378, -0.2909301554037109, -1.6141916544362238, -0.8579281608147358, -1.0194801800037865, -0.4369493529439941, -0.5241765965466831, 0.16102660475147335, -1.0828012987320716, -1.7500451873866096, -1.9789921012351415, -1.1552851561125217, -0.5203039650491712, -0.8259135604584578, 1.113979798409469},
    {0.5195906704151736, -0.1464179056525836, -0.9006172662873014, -1.035415602430583, -0.4090373003130287, -0.28314660774317935, 3.5108169869770456, 1.6992757126388862, -0.4406311595656495, -1.2937557299838693, -3.6384616182044645, -0.19108192819964206, 0.5697842817109988, -0.9855850907988997, 0.18576531129185042, -0.47335565172232247, 0.3080287498084712, 1.3592544378258395, 0.0994343041421917, -1.0863738157025935, -2.9610968263360693, -0.671122119937657, 0.7631787839768821, -1.965166908186518, -0.9498915273235129, 1.5871930923391044, 0.8653415767013729, -0.3713560066250305, 1.210814210167316, -0.4364615623461431, 0.7142163793874982, -0.46492719738458366, -0.22638844603455824, -0.7455719198392863, -0.21761511238084555, -1.4722828337376663, 1.6909429455122076, -0.4793059255949958, -1.5469652332956372, -0.9412244190567385, -0.39325836355529564, -1.3016452561190754, -0.41506562994686963, 1.1099307633258273, 1.117377401487759, 0.07903714597023506, 0.7696224941483512, 1.4208877191503821, -1.8490429334218597, -2.0358220698504774, -1.1011446980998476, -3.401154380789976, 1.7030357728269638, -1.388246381041724, -0.08742372826160703, -1.0564506114075667, -1.0420407377592409, 0.33829076394364627, -0.7882370901213327, -1.8220173526620131, 0.6741199176164488, 0.6345272726048922, -0.9198046596830366, -0.9691226841017456},
    {-0.09822605998460239, 0.1714037290571975, 0.8077065422525768, -1.7966849458554857, 2.195416799498873, -0.10864339110754007, 0.41464849202702825, -0.23215439772293078, -0.6248250671969882, 0.09493027553988227, -0.7071923293827893, -0.3648243534619337, -2.032439829467063, -1.7546671893091286, 1.324390338146834, -1.0579042009665374, -1.5675428460804808, 0.5141186663810531, -0.5787593445105655, -0.5226164686737166, -0.05092834717026922, 2.2938335968934873, -0.8173915200183366, -0.6192744714153334, -0.6205451194370202, 0.6520936635142921, -0.37860348108636294, -2.424582581791613, -1.1120005822371664, -0.35541287219484324, -0.3191380431370697, 0.7629686377620989, 0.4923537423163071, -0.09386849371488039, -0.536997449679158, 0.825068500194608, -1.1562336225119851, -0.9309152437603538, -1.2425360959649956, 0.5203684056419645, -1.2144189490879154, 2.210888355093009, 0.14556929955534845, -0.33553377035116155, -0.5553795583739971, -1.0793653928282605, -0.831444236384421, 1.172021918921281, 0.4793284917601422, -0.6472634796175364, 0.23965126082699154, -2.1644284410882824, 1.1666271617769308, 1.6267787520357395, 0.8328552823134064, 0.05828389061010363, -0.029864640463522163, -1.264419559832707, -0.6567481816568681, -0.6164820815242582, 0.8993763235946639, -1.397444343016801, 0.7357055534017745, -2.2218313324080423},
    {-0.6198145880422831, 0.26972598410789694, -1.5998907253043282, 0.7910748634921774, 0.5098807219571522, -1.2745097184817111, -2.2891616534352828, 0.6059069407987902, 0.05897556527764514, -1.1252025760750808, -1.167815316667184, -0.2636196979824676, 0.9659738336420566, -0.6356670932251206, 0.023185598834329732, -0.5681107691901494, -1.9798608570050704, -0.830487531816465, -0.8413409942315718, -0.23611964060998586, -0.20926920207917962, 0.17269172005660602, 0.2258636129323574, -1.2517382210959727, -0.36285043054327404, -1.3289317761662363, -0.2934471563355631, 0.5385459333624616, -0.9804986076662087, -1.0690881404654284, -1.4926001149418522, -1.2659388743547704, 0.9486177889159313, -1.3825966042197022, 0.6292875963605418, -0.09708419827039691, -1.611992042876918, 0.1916279880518071, -2.163149847430444, -0.30318250105882344, -0.9655630692142187, -1.6988973220201051, 1.7333622410335265, -0.25350393954115735, 0.31165477364230215, -1.0486321534659955, 0.5412131023961982, 1.4050955627682298, -1.8616701453792113, -1.6030041616424329, 0.778832549987256, -0.4958019312283768, -0.8097081790390094, 0.4178837640950865, -0.3659426699394011, -0.7993458463934193, 0.27763966701319276, -0.8980315933374341, -0.8351458645847822, -1.2782927744724146, 0.46416613093732323, -1.2188042139652404, 0.42014323468834164, -0.2593798234137999},
    {-1.2192687659411277, -1.053658184801838, 0.0013192011392761695, -0.23159388611600215, 0.2748648794441006, -1.5136308204786633, -0.911493538189084, -0.495329153962233, 1.38047068702843, 0.5960756710957468, 0.8889067635085091, -2.0945540819215824, -0.24301777455220638, 0.7387577727248046, -2.5143619915449213, -0.5575602279081524, 0.4108404097260965, -0.012698068207793636, 0.28647375501661576, -0.700593664057407, -0.47530451334710616, 1.0055266786306576, -1.4792364150576554, 0.1589100989759235, -0.2561493169643078, -1.2717015105336433, 0.49579302691705357, 1.377441686609764, -0.5383590668991676, 1.737480000409491, 0.6357389393089135, -0.05342107309854067, 1.0390653153104517, -1.173003531412461, -2.8156119521465697, 0.13490058962794135, 0.272363861473111, 0.3446793939522444, -0.8627306955515649, 0.8398477776312585, -0.7623756626459618, -0.6462789685700946, 0.19103963575153768, -0.10696777235781108, 1.399320769399509, -0.5601230230911162, -0.0775325171528844, 0.670136740924415, 0.48018293401790463, 1.0194961894959578, -0.2630150051306949, -1.2755418272826151, -0.5675508079801803, -1.5934164029883457, -0.7843065397117849, -0.472365547221688, 0.4608960820809306, -0.17769059650933408, 1.4352198462627603, -1.7039600961739103, -1.6038515651664598, -0.7571143563003956, 1.2129949836985463, -1.0088643951369403},
    {-0.2818663456572729, -1.2093047840272502, -0.1715744013646991, -0.9108903136137223, -1.8470841349244382, 0.8143682888032786, -0.9839255462728335, -1.1347663094285012, -1.275144219460162, 0.09796010313459713, -0.5398190548743171, -0.698947050661539, 0.24747644052988949, -1.1661846845629376, 0.6997366826672042, -0.9259652854096984, -0.42411123739894835, -0.12793048014794237, 1.5661736404768547, 0.12384045253812703, 0.7665667806193464, -0.645530652788294, 1.1669125947952967, -0.5446498749009284, -0.3155050866071958, 1.2409257094156292, -0.36070241586968665, -0.1831169861313837, -1.4014153460292391, -1.238066095695572, 1.1078074196708945, 0.5306994871915562, 0.8361551385223621, -0.7802457062963595, 1.2832998347536169, -0.05426161525649403, 0.5015975403843523, 0.5251382940312534, -0.24592661598266755, -1.9582341774108667, -1.02493203379715, -0.7278191426675067, -0.2977170650649756, -3.13408870966323, -0.49516597915689375, -0.3065769247541301, 0.7940505621539555, 0.03429872505212813, 0.34694584152141567, -0.5455472401672661, 0.7887536272816799, -0.17349215718499483, -0.7145557449437107, 0.033955526033001615, 0.17057543181540696, -0.98509518305518, -2.0735776646935946, -2.1406912002571286, -2.1609587463091784, -0.3797753584734444, 0.1811332024693857, -2.2245757510608213, -0.2527937187787782, 1.217161597837342},
    {0.3906965937512992, -0.12652888536781798, -2.001572413393535, -1.6994751343113241, -1.3609606309785751, -0.8054638736465872, -0.7157978565647848, 0.0769574923297441, -2.2401728904502782, -0.09755096888273877, -0.4507962495326975, 0.38765537676290024, 0.6580666457128722, -1.6523557849221868, -1.2099645378908384, -0.5980221433516898, -1.3840328149974483, 1.162839731608859, -0.17483607847157512, -0.24928388937455082, -0.030070118148458173, 2.1154219363286937, 0.0978869816021543, 0.3897000632204466, -1.2112186124749746, 0.5379476202547071, 1.1954829382344134, 0.4060594518108036, -0.8180621592204909, -0.3212323825167215, -1.0300725497523135, 0.14560830174495454, 0.9676153276165058, -1.9286744897400847, -0.7598602622887479, -0.5282010074053639, -0.06052058422244099, 0.12853164248077306, -0.6794622353487532, -1.0791010659855704, -2.3485959724862755, 0.9578016797569268, -0.0218478763223545, 0.03335010850618551, -1.022505361730236, -0.6958519020486957, -2.8647701787528157, -0.1639043760014743, -0.3511998916709883, -0.05260596048181229, 0.3163887476933318, -0.36481309582443244, -0.7798844819952706, -0.691418501672755, -0.3381615716954238, -1.344220364632601, 0.6707745413002912, 0.37467726703870213, -2.2742722246090525, 2.2664416649953214, 1.9075987645022756, -0.16489662692731602, -0.2825706097946172, 1.2646925230738255},
    {-0.29571564729219485, -2.3870676592912914, -0.8428927514030541, -0.4923592502774153, -0.4623588197058206, 0.6174245651819892, -0.22906104818452103, -2.2653466081799833, 1.1166902577066666, -2.0643716235028036, -0.12691311914033337, -1.582475819747931, 1.4335252119653068, -0.6522108498348128, 0.44271988694199993, 0.04160751829294914, -0.773429176854434, -0.7861164213941354, -0.08487195326568814, -2.69115891253721, -1.1624009335970975, 0.5895120432254205, 0.10584390272004114, -1.6721896338512883, -0.9052245633700451, -2.1952996356792718, -0.4873521066943484, -1.6882907344580131, -0.34236422802769023, -0.9318754204859968, 0.30231877680879266, -0.07510699065579642, -1.097245755956456, -1.718861387561791, -0.9165245763677488, 0.6341428570284295, -1.353058652675417, -0.9441606595254729, -1.4662313437185273, 0.987104969081859, -1.1689234949746086, -0.41718478660733016, -0.6649802511920734, 1.7610020059514044, 0.3927103871808703, 1.1632909300783438, 1.0348873339540396, -0.7434516622219672, 0.3419859114294313, -0.09505023773419541, -1.6581713390226285, -0.4269499873044795, -1.4250893628989096, -2.095904368847606, -0.13283467961644885, 0.4119489149967879, -1.1130730505095179, -1.4000464846047274, 0.4407025932025538, 2.1604228834287262, 1.4682670162557363, -1.8645579681114726, -0.23787544898701315, -1.3130017157283316},
    {-0.6293840375249447, -0.5764184309156518, -2.0184525471124632, 0.39452451295340063, -0.8835984370367994, 1.3645504400117001, -1.0133799286645133, 0.27158696139082206, -0.717712136168882, -1.20004221281688, -0.6586741615811081, -1.0703581584188986, 0.4585106025107844, -0.794202219771573, -0.5627198447818847, 0.35368588867582224, 0.33890733384857924, 1.0855663685893306, 1.8196058568483982, -0.8462182252817724, -0.9370371115266891, 0.45757570428688604, 0.3715910741315775, 0.8762028658730918, -0.12252525436215132, 0.36154054452773143, -0.8250005253521915, -0.36333162538627367, 1.7948655378235716, -1.2627475383920579, 1.4049671867974276, -1.9735330140077665, -0.9976628803470217, 0.30695867412333216, -1.0484610733954556, 1.1664379102500229, -0.16232456076581217, -1.097068585505315, 1.5627133926607377, -0.160416157758712, -0.35951747637369097, 0.9479740684247566, -2.8113379732806036, -0.9049222711447102, -0.635501200715532, -0.28959458929568754, 0.05853602701906614, -0.6898247361286144, -0.7955639311521594, -0.37609943956145314, 0.9289172023772383, -1.3376713558104099, -1.2764808982600289, 0.28532462853737733, 0.972803297070886, 0.27597946212584085, -0.8916264903945719, 1.3657082298612628, 0.9419607494078011, 0.04778179743117541, -0.27301975947821056, -0.2588724225960862, 0.36528224433267564, -0.15074512439127746},
    {-1.966380837600796, 1.3637610720916562, 0.22887215165461988, -1.5735641154950633, 0.8162695942195942, -0.3181977544558208, -0.015125582274482876, -0.7597330336098267, 1.8450690086600565, 0.026367180177584135, -3.3452986794522728, -1.5472107006444835, -1.3207093533829173, 1.2725850387194824, 0.0591388852490242, 1.2878209828247926, -1.898567185009768, 0.24128239722800718, 0.3255632952404097, -1.8216941931287371, 0.30084985980307716, 0.9335373813075528, 1.3888010408735179, -1.4237145461679412, -1.0088653896091326, -0.2536791722553417, 0.23376481467848226, -0.7178542492233947, 1.4332125158950466, 0.22824093750664998, 0.42581773800984574, -0.16364570231911646, -0.9036218113175318, -2.3178210714455982, -0.734478656774183, 0.5503096478044965, -0.2867144204161242, -1.3084460396593283, -1.0404766991875274, -0.6462352860787661, -1.0139093740352134, 0.3804336932062619, 0.4094939626563345, 0.7730538534422907, -0.7946113975678132, 0.33169565383785976, 0.11235184097071667, 0.7611831751978851, -0.1715023413404869, 0.30386798913403384, -0.7478416452687552, 1.0219873394331396, 0.2673219223129393, 0.3444138697797932, -1.5978268886647669, -0.87445250974446, -0.04878401207607307, 0.4564489150418722, -0.04693407565401401, -0.9411874637885145, -1.0504148255614536, -0.6997786473128026, 2.1973295056033137, -3.6280319897711606},
    {-0.5673458763261793, -1.954033329372716, -0.820736376322501, -0.27399258213273536, -1.6874193389322598, 2.1343164065169895, 0.22473411368819604, 1.4001547366194484, 1.2367715008355697, 1.2943949576673837, 1.137188977708343, -1.2823464840285081, 0.3968770683710815, -0.7234427593289617, 1.474763039509271, 0.022486900164812994, -0.8289574316007641, 0.19440916181817539, 1.3576913813205047, -1.979080451305465, -0.4498669965122513, 1.1830181189091395, 2.8578202301026185, -0.602863940087931, 1.0099190395140394, 0.001918688389022967, 0.17958233195632298, 2.3281494591009197, -2.2031075648216905, 1.459865391852983, 0.9200794473039526, 0.4137768298751746, 0.40957172621382787, -2.0882722612641604, -1.3076165422162527, -0.6786220726065356, -1.262120144743306, -0.6072598159422872, 0.0029716429416691732, -0.9959605350377674, -0.4731617564102318, -0.09913961680572428, 0.5136403627625062, -0.733834418161275, -1.156048106215674, -1.441588247191809, -0.3217460989870478, 0.9288767048155678, -1.4040220115251432, -1.5133527946123053, -1.2675797470817238, -0.24907142522043557, 1.0631711373357684, 0.30598772493736454, 1.6451700947497794, -0.012693462614836401, 0.38870230592374194, -0.9918843283060937, -0.6901239789498522, 0.9881125937019103, -2.1753634517004707, -1.2375974019135507, 0.24583212398171492, -2.281515716571596},
    {-1.2006838615648336, -1.50274887470114, -1.27365399072757, -0.6886810155531251, 0.18042329284091788, -0.9869342194951818, 0.6348445778616237, 0.38769439850160214, -1.1110656126064595, 0.044456022749063843, -1.4643497121416886, -3.016394286615118, 0.02544578004352336, 0.22400568994125478, 0.6953253578412322, 1.2526379823668337, -0.6599619144661104, 0.15337514052933068, 1.6393986819943338, -0.7427957330582754, -2.339759700736358, 0.4290986290161758, 0.8804162288358934, -0.4728477880728439, 0.1281422754944406, -1.3426854937373298, -1.3656122924813368, 0.8802631805784882, -0.8151417951719467, -0.3197835853900479, -0.7867051030232783, -0.6121736108993894, -0.4083952222561631, -0.5198484201034591, -0.49887358420393635, -1.6282254785709587, -0.2816127557428993, 0.511975603173909, -1.1700617516181848, -0.2533953265862775, -1.0628372406559576, 0.032542989889398445, 0.9029553560242017, 0.5753905112387212, 1.393978239944784, -0.7056445256401767, -0.23614331103593478, -1.0324700332860064, -0.7599066718677646, -0.8935087359789338, -1.5437131293556778, -1.4965173329350479, -1.7187760106482584, -0.4897392493935337, 0.879837340713815, -1.1533626639929295, -2.0038388733057717, 1.1052090072545047, -0.31747566570757285, 0.39909385721623597, -0.5527869003952203, 0.20674570056813546, 0.8837337262878576, -2.8759630081812024},
    {1.9304894137852582, -0.8698644357699672, -1.5540313385896503, 0.9030357919087928, 0.9123921129749044, -0.8176876242188086, -0.8575049986267576, 0.4763852432144329, -0.8907074286400651, 1.5658647754757482, 0.08582829140030106, 0.31275822180528606, 0.12650353248904586, 0.2709537329298392, 0.32542684291871915, 1.9873151648487106, -2.371969668492316, 1.2096357802518491, -0.5465868021398228, -2.3501840693940315, -1.219717589433525, 0.7180687112010053, 1.2002037529451262, -1.0894110466306006, 0.17787622817185206, -2.090690463736184, -0.05225482657749125, 0.6933190025687181, -0.5293129257323987, -1.435090659398473, 0.6548750270041707, -1.1199684154059162, -1.2394511264446624, -2.7673629804894637, -2.010127889318106, 1.489942660485031, -0.051754645077455606, 1.7644551996681812, -0.09404532602295984, -2.0129990832157523, 1.327325714425083, -2.01669197935197, -0.62069209274635, -0.7495309531886456, -1.453076946980574, -1.8596204502618148, -2.455930003564187, -1.19408440217008, 0.9249747601710534, -2.9855016758725395, -1.7164904528280727, 1.0749604986241648, -0.9991404404686783, 0.31879901864075666, -0.5404825862438036, -1.1469017836764066, -0.6151717780412816, 0.26588920893684426, -1.6161440919578893, 1.3417877991479878, -0.42042814535904993, 0.022795999056605593, 0.026194228028877845, -0.6252480189067552},
    {0.4671611594602823, -1.8159773427855355, -0.6297967858109723, -1.0673054167939393, 0.5284892052740005, -0.905188174682127, -0.7829038439311168, -1.1076376232499212, -0.925483068400428, -1.329000063229365, -1.058812008678096, -0.9739552233817582, -1.2013811711650368, 0.3069733751823475, -1.3167976165569164, 1.2457733340522705, -0.9552182130321969, 0.017618082398727575, -0.10733401527077475, -2.673616117861658, -1.6830557445586842, 0.6060071428619244, 1.9578663330608634, -0.19494317621219245, -0.8161650471167141, 1.4072157022272835, -0.372841325444809, -1.3441746113276398, -0.8176952788725932, -0.5753307439420736, -1.280729170014347, -0.2727083090647997, -0.11170051298600144, -1.8022266967181184, -1.5005892578760747, -0.21993038153149852, -0.17213211698687436, -1.8187894741683843, -0.9578163252438591, -0.026682309586909977, -0.3013594412588479, 0.4384725756521526, 0.17724406132919765, 1.6220286375947426, 0.6852716132211519, -1.818599300695335, -0.8699058865903433, 0.018417679749454175, -0.6106450055464445, -2.693736368511561, -0.7900991760811468, -2.1133110657443317, -1.373566028554795, -0.38509682925626443, 0.44414092708028735, -0.6007966411886598, -1.1685124328666812, 2.0933323935887733, 0.2980547317800428, 0.9225047413320666, -1.2693604512046455, -0.6463140794768372, 2.9716478454717863, -2.1054709819444644},
    {0.7126679990857341, -0.8949421208730752, -2.5021358708377, 0.11945761291303658, 2.3778881435556283, -0.480771107421953, 0.429506217079698, -0.4813320003662131, -1.511668810586013, -0.3828240074257485, -2.5313258921507296, 0.41184375803880413, -0.5721107806069249, -2.265910924830192, 0.38366241081491076, 1.3205222447146843, 0.24561990499053044, 0.6570182313370242, 2.1567691672767966, -2.4482173082120866, 1.1610551000163272, 0.9350397776272669, 0.7203556916565721, -0.5206886396200379, 0.4246508281669142, 1.0406367504544278, 0.20106430054517907, -0.9801168335678863, 0.396319289744173, 0.8186997080322052, -0.8671608511493725, 1.90315994918433, -0.9454099650515213, -1.3336904455258134, -1.7186524015533466, -0.972216311718004, -0.3172624859301614, -0.42362953524186964, -1.2514535897447672, -0.5003094129524335, -0.2727040961989265, 1.6394943449930695, -0.24492963889008218, 0.813376555162352, -1.5909501378739397, -1.970354642897009, -1.1827811194410245, 1.0250517817389087, 0.1633092790191151, -0.27125607208084573, 0.5137068145441033, -1.6777723047374835, -1.6409995215290372, -1.4265595434043374, -0.5634294566058017, -1.3575642617272352, -0.11385000935051096, 0.03576459754438794, 0.13007478827844382, 2.242224919872165, -1.6425071831031106, -0.5712377447636637, 0.37766021341959655, 0.7674101236831465},
    {-0.3758301619846767, -0.38824966049591764, -0.25281735352454626, -0.2528686066126213, 0.848530254280868, 0.00982057117728783, -1.1237395137730275, -2.1053618460591927, 0.5700186926412635, -2.64219148735717, -0.4694202305003496, -2.0979929954701566, 0.20046157729102348, -1.4592031867548303, 0.3203647931033336, 0.10365390761706735, -0.6095870708560223, 1.7468941820451125, 0.424781975525311, -0.6152852617911175, -0.9656962078808877, 0.045532176207451265, 1.293093972944805, -0.2307237818989427, -1.0221268564048642, 0.7253017023492865, 0.07395142765283712, -1.1940543294903976, -1.72762966463209, -0.14544405801927054, 1.2064542590727803, -0.48286171075555334, -1.5378248605027016, -0.5875795883928479, 0.4085335387020622, -1.7691594637889465, 0.678775599654453, 2.209322634549551, -1.3552391003539421, -1.2575724851145196, -1.631226515637571, 0.09324679317151532, -0.4554187688396546, 0.2948536798293202, -1.5063064458012199, -0.40696527975981706, -0.6390438069915468, 0.511291631114132, -1.5281035672782164, -2.5041798586487047, -1.5262506960626596, -0.6612803706842902, 1.1408637627231837, -0.4428631739467457, -0.30588178244770475, -1.0105809256561324, -2.1233151306325873, -0.48206289186022794, 0.5427900309521906, -1.8896695610505543, -1.746433198072711, 0.3520150019269142, -0.03972452142370658, -1.6436145099740482},
    {0.7236076739869476, 0.623788880136058, -2.2092817601376713, -0.28942097127373206, -0.5130222541373641, -1.9727236275012627, -1.9371524754604605, 0.5852555996472205, -0.17585435413288053, 1.2434247609754676, -1.2534913227294344, -1.4576898229242414, -1.0830083279247416, -0.89083096768801, 0.8140227963490365, -0.8409953895772094, -1.7608719766501195, -0.09030850256334398, -0.331955320007205, 0.6927883096461213, -1.4955620355397032, -0.5579833371216573, 0.08284222258900384, 0.5228339831877695, 1.3193622219712426, -0.32259902467474816, -1.0410761289905164, -1.4537238019126584, -1.3564175176451834, -2.546098545012962, 0.40435033802906545, 0.33020569653429477, -1.3699502203433913, -0.32337925547966395, -0.5512973952385135, -0.2312630411618697, 0.4208784809108761, 1.201020133014502, -0.5105375722310503, -1.143026310518416, -2.658740658924691, 1.2735110831126861, 0.338139126021751, -0.5117071001258564, -0.9680225564654258, -1.7026314759156422, -1.0804771604977221, -1.1983798366770404, -1.440053468067255, -0.8104300134474245, 0.6209223880323159, 0.3482682628979924, 0.14068018712187919, -0.5462577354335891, -0.27233500849799275, -1.906319230763374, 1.7187201324446086, 0.45279096913386985, 0.4430186047322221, -0.31417617863573327, -3.5144657635264913, -0.25621309298476846, 1.5883866432617717, -1.6799137767419483},
    {1.4667490844196853, -0.4715179854257826, -1.3912454182389475, 0.32939531156080915, 2.3019661793288835, 1.206260419211437, -0.2548860555166234, 1.304431634428186, -0.784668668080627, 0.5063758353285513, 0.7551077927066248, -0.8094303186033447, -0.44041975206693523, -0.49627579848585157, 0.5102588617825589, 0.6756991843941512, -1.4995731178986276, 0.23204746129448944, 1.5814334502539547, 2.1201130360272455, -0.2048732710531159, 1.6774342952109638, -0.48395847580525925, -1.0008749794212675, -0.5648819340498697, -0.7325242215186151, -3.077120753471423, 1.4763785551548483, -1.4356979645365662, -1.2836364253023507, -1.0699564040147524, 0.29181822948505187, -0.37313397729311787, -0.7254564701999469, -1.2997322689759028, -2.194150382786484, -1.567268244136113, 1.254542237951969, 0.5612699554063548, -1.8622160165005721, -1.7697171719025917, -0.8167929056866591, 0.5938466105947452, 1.8903869754486597, 0.14865634983439785, -1.0915030235880605, -0.8304922294722131, 0.23813020606777557, 0.5508727336638629, -1.306372921841002, -1.9370820338995276, 1.4628877022106423, -0.3952814459866161, 0.13581795112457695, -0.7973337199817333, -1.1214040308298936, -0.19404072847814177, 0.5093730457147799, 0.5482116225547882, -1.5012134886585993, 0.48006474727154785, 0.6379562562297129, 2.1704645891826857, -1.2114047182964687}
};

static const float b1[64] = {1.4321126148015852, 1.9845229930851223, 1.696337011085223, 1.9866466193211063, 1.9285980493176158, 1.709780607498135, 2.0519863167686436, 2.0680815936490067, 1.4351148482723175, 1.9432066221631987, 2.1123000719290963, 2.245582512410563, 1.090047467351121, 2.1684468751789856, 1.9972858750975482, 2.027851851993585, 1.9398414084590616, 1.8686977699074945, 1.9658513098240247, 1.8390425709857647, 1.811240448020718, 1.3641253092212386, 2.0737476328062328, 1.9248595139746665, 1.3080608171492603, 1.736273735133771, 1.7414776554828821, 1.6620433587467436, 2.5175026928445075, 2.053751504339166, 1.4140206278837624, 1.8882629124891868, 1.2191244237735335, 1.956797614445682, 1.9618795042076596, 0.5422299532464268, 1.8497268469519288, 2.1692346294399503, 1.7185231512502535, 1.8024102214469886, 2.1359007151849525, 0.4227160599862275, 1.9042747612521995, 1.7079998338564466, 1.2813329484591056, 1.7304281547765787, 2.146740276371454, 1.6954250595606326, 1.3770957018539207, 2.254089172899767, 2.0173057629998565, 2.0275259667063015, 2.137800680659612, 1.9681967189026348, 1.8625842538937787, 2.088679740423293, 1.8244602012041278, 1.9120330299404436, 2.3253577164646386, 1.3535816168234418, 1.6944286241612385, 1.903531944611595, 1.8747604525822632, 2.100885341529626};

static const float w2[64][32] = {
    {0.8977568980704841, -0.7156451210466798, -0.567323803634358, 1.9603031940964346, 0.7337264935206196, 1.4775624533878522, -0.7065580597864617, 0.6915336886230113, 1.7495950154011808, 0.9578672351881226, -0.5940440746495596, 0.08030140641882065, 2.6939088355117793, 1.9211995575372296, 1.6477107975997047, 2.292861398830541, 1.639685367909223, 0.9590315102449452, 0.14386430539800182, 1.8177493208306248, -0.4449133082293719, 0.9090548719615468, 3.134803838004832, 0.41650022164284767, 0.009282148093533633, 1.328789210430875, 1.4816419397450724, -0.3826479942992174, -0.2923756784728184, -0.13946776689508922, -0.5248508676859286, 1.9254940652228154},
    {1.8351476826838549, -1.4472236037668484, 0.2873844410873281, -1.619205745468214, -0.3390066094910066, 1.0438969110953467, 1.180659236610427, 1.6385358939972778, 2.971757092570882, 0.7188078404688297, -1.1245059832676667, 1.8471384315760864, 2.333756550535384, 1.2343883537746392, -0.7060488539026553, 1.7317109980857412, 1.6188423442841786, 2.1368815185325016, -0.5239687604117329, 1.3760192114402676, -0.9366004239336633, -1.1114901704753553, 0.7876846142851288, 2.441876107654661, -2.5896309374313975, 2.302959334526546, 3.165712190224528, 0.6972466301417338, 0.6058676025546743, 0.5240591172601297, 0.5881981126592704, 0.31999533455022167},
    {1.490233785609295, 0.9404817477813903, -1.0932771530900265, 1.0488346297520095, 1.6095395876083463, -0.19320613648960808, 0.9768344946061587, 2.071302819027196, 2.4764011312347076, 0.9706496314462673, 0.6545937319852083, 2.0909072957906534, 0.3548748515992549, 1.7367297195035059, 1.5667305912805016, 1.7785894313851798, 2.284583799219811, 1.5444727326003007, 2.075295505972514, 1.936747792555579, 0.7971815646138061, 1.8352577323726789, 0.8432432064562659, 0.8091936876714145, -0.49606528572687847, 1.0037723856808696, 0.13515263133022923, 2.1203430602555207, 0.6310042213470827, -0.13573036103572558, 0.92753152345245, 1.4771312739475484},
    {2.8202908120406303, -0.200898483604289, 0.40841568623327146, 0.9134984336300219, 0.9038352172219924, -0.8779980846319716, 3.5866317680597164, 3.342058170459337, 2.892053196641749, 2.6240814184439745, 1.7540719087791237, 1.0046270503291177, 0.7791693456596169, 1.1010768536175723, 1.925305923909252, 4.020564428386734, 0.09315110965097034, 1.835928073471371, 1.5918887141333613, 1.2204745643830623, -0.48345094171617387, -0.758819102619522, -0.10298010200874086, 2.324584499372269, -1.927435863029354, 0.8505783305259101, 2.9063531652838765, 2.162239411712151, -0.7192772292746787, 0.9995796560736613, -0.7384231727120721, 1.4145353952531778},
    {1.8373035869823229, 0.35108925123921925, -0.23675732559077192, 0.1932396211846319, 1.43173690810432, 1.5470692560242867, 0.15907143092303533, 3.072501144758614, 1.5273518999619007, 1.2442628474735367, 0.22632565863388382, 1.242588708940905, 0.43538346145378687, 2.03965396638864, 1.921681694360894, 1.3504425472033967, 1.702567956921884, 3.456348757720042, 1.7723590938507474, 2.1744906077156703, -0.7474192503951017, 0.7576821027304264, 0.1655190910283341, 1.3625934119879166, 0.05437021542945014, 2.690690857591539, 0.7605565975318275, 1.7409823440834638, -0.9969642444005686, 1.358095825759956, 1.739040750019138, 0.0882918571527973},
    {1.1985300254015565, 0.7968940860020897, 0.19898037565102702, -1.2942756666673343, 0.9998963138558091, 2.509326927136724, -0.36944943314302736, 0.6132092112291969, 0.062226486085132385, 1.491112157474458, -2.0896292128964684, 0.6032144877027262, 2.9761924422775605, 2.4730480517624613, -1.1427446542302628, 2.492267163812651, 1.1191677069123525, 2.04520622928887, 1.323593007832369, 3.288055820356118, -0.8546323733750072, 0.8793157232437973, 1.8385255556688125, 0.5045182644466321, -2.641440944590411, 0.928664905894907, -0.5981664678699546, 1.152341339292702, 0.6334914812791487, -0.026275815266154495, 0.7206712830832731, 0.8426895536305693},
    {2.2455542390067036, 0.09336126485647442, 0.3640752799465533, 0.16397896917641386, 2.1442028513639633, 1.3435860486321898, 2.1890464975281403, 0.4109937389468492, 0.1630688063979567, 1.3640973880555674, -0.6799413876789867, 2.1609255462206653, 1.4331346261332576, 1.166962920203709, -0.08498768633020935, -0.5965310553991917, 0.8419682888561943, 3.853547507334168, -0.049493163924762176, 3.149633181039791, -0.44867340737852357, 0.06522018933375956, 1.4833200968145577, 1.6980241934225189, -0.29842657950873785, -0.6376782611509828, 1.6058365012000564, 1.8542252513814212, 1.1889920200987725, -1.0209547560571248, 1.931056036077663, 1.385736569535401},
    {1.4365460367811913, 0.09729791935615079, 0.6421583298058882, -2.5567708981934643, 1.0925883099009455, 0.012768674643996872, 0.27868081682845186, 1.9586223795183961, 0.6615819963335094, -0.4739775455460941, -1.2697901315142077, 3.2831964523442316, 1.6023322506520599, 1.4430139372412023, 0.04588036661788307, 0.6763762881468076, 0.619135131420944, 1.6249697795808171, 0.4310094986904426, 2.6996627148814545, 1.1045142147281721, 1.1072330901539909, -0.4442915563315979, 1.491881085033888, 0.41308144118702844, 2.21688306628959, 2.002397256783607, -1.3894439456428131, -0.3321666301923927, 1.3545908995548868, 0.6245850511632502, 1.9572160483595997},
    {1.8054197307816933, -0.5093593333661541, 0.500572570831018, 0.9811792671060823, 1.6166385143901354, 1.5022265928970382, 0.2974245764577387, 2.273474531411102, 0.5108093932224665, 2.8427775020195396, -0.29206258193090184, 2.686906170962331, -0.5033375952356479, 0.8381839110343201, 0.903285130494216, 1.5754914673955034, 0.5522453590117663, 0.8584113410321202, 1.6605971702679774, -0.387666872877828, -0.6470990371012895, 0.07369373291879952, 2.0680366823413756, -0.6069427855024693, -0.06092433180602733, 0.7641969620324189, 1.4264297298607926, 0.7403321880312441, -0.21009690278328177, -0.93635353789491, 0.13981287884781352, 1.0392548060195868},
    {2.088542596737201, -0.07298200820545088, 1.255168124061577, 0.3368848297653947, 1.238933566092923, 0.9248257694307955, 0.5029192489949535, 3.1822207805701495, 1.6356380859183801, 0.4675051677826335, -0.48966798319480703, 1.8003651172371968, 1.425937858781291, 2.4900217539154093, -1.2838803061218065, 0.7314298575430992, 2.453374595855561, 0.8371390850394472, 2.112770317853103, 0.9180338812835486, 0.6060659983454184, 0.12984886790756667, 1.3867812402905846, 0.727861294855848, 0.38892735920146815, 1.5797367216951066, 1.7724255992305826, 2.6929232088173043, 0.6114421743040744, 1.6638197542361328, 1.7660713836653135, 1.8836303569385522},
    {-0.0513212921624879, -2.1760883790154297, 1.4327224605501465, -1.1300971237482058, 0.830652383367993, 1.420692369170174, 0.39196012026279875, 3.3392594544908594, 2.1962646492701396, 2.674761451763391, -0.2557790616960677, 2.9539313411534764, 1.6345392277801112, 0.9737853054464535, 1.1128043112766777, -1.4169452934970213, 2.43081816094061, 2.5979453554672225, -0.26560033953675144, 1.163159049638907, -0.8067105606024805, -1.6382045082173136, 2.9039631665875767, 2.6516670681687073, -0.2251458875156128, -0.0970679194135999, 0.5337750299916261, 1.1958232731285097, 2.521439915432454, 0.5687805148381644, 0.29209750126791467, 2.739656931001615},
    {4.248272962304451, -1.7212762091577545, -1.8748155936703128, 1.106099198901071, 2.264117352016772, 3.8532701503542293, 1.5426313927880335, 2.5082621382343406, 1.471454557550275, 2.587523203340181, -0.49638278382343, 0.5163828000164602, 3.0509130626509564, 2.9951065199388394, -0.21252843044855593, 1.1602764600137827, 2.0089317569368452, 2.2761660109465267, 1.1085634639251432, -0.2491874894125168, -1.88984144725746, 1.8777310096082946, 2.1289244536396135, 3.8133957886972225, -0.4459871280503808, 0.23979613336207714, 3.0323209805098026, 0.7111026046652288, 0.6691065155935114, -0.328882538351276, 0.9161717437089797, 1.9007462369555848},
    {0.8876742412824288, -1.094752304241219, 0.00821799092285145, -0.1604023344129564, 1.329973341517883, 1.1182471715116855, 1.5424187457751661, 1.1519703749157055, -0.8395570191846157, 1.861138818632182, -0.2212376858814424, 1.2505098197755515, 0.8743142154162248, -0.8053682352647339, -1.1904177157712992, 2.641850031352517, 1.5898281092882933, 2.8558790743872207, 1.396359211728479, 2.028709777989898, -0.807170776062673, 0.005705061977333354, 1.1033766424614664, 1.5867202183730424, -1.5300779737839483, 1.0093520934219733, 1.044246954462353, 0.500269217142969, 1.4971176062219969, 0.7718005682611164, 2.2450839635785633, 0.3407421298389995},
    {1.9386034594509918, -2.1227786859754323, 0.9282535765903642, -0.6527925725775698, 1.543772312157986, 1.6711876113896733, 2.462129349429206, 2.7867163251259868, 2.981776255025605, 1.2548012247303209, -0.894810562471383, 2.6891874897636683, 1.8454049705782205, 2.909919075348701, -1.044824582070074, 2.9056673982252463, 2.174203187927702, 1.703175026027222, 0.3545467844033442, -0.9923754895023568, -0.2508810711009, 0.4493863641969487, 0.2927327710379998, -0.32970361071336496, -0.22962006929306547, 1.384182994824097, 2.5838009286369648, 0.21273831448164213, 2.465575188438238, -0.5199435548085745, 0.8306551882110627, 1.8781048191213137},
    {1.4770971680268095, 0.718928649250795, -0.9240202553267189, -0.3052366902344383, 1.608874804508667, 3.172228621332391, 1.2074378615863472, 3.028216205949064, 1.4404780756618831, 2.323096887591206, -0.7700725639306739, 0.2683233290871868, 0.28981512811596627, 1.0417450512538495, -0.8296133380358011, -0.09721834394963533, -0.4727027976211023, 3.050339889924782, 1.3751594177678388, 1.1198575435450824, -0.7548980286788501, -1.030936270820668, 1.6829937115753517, 2.205675421808027, 0.14097163760774992, 0.5210232026408246, 1.6129974567024952, 2.738770866662344, 0.280309057068937, 1.8959517869647133, 2.1876122142974848, 1.6161322679617625},
    {3.198817707740428, 1.5784197326342253, -1.162018713689147, -0.6676651360173326, 0.9053921951301706, 1.5975312778698918, 1.723340354956325, 1.0016954855130586, 2.9996699918238274, 2.9142697611900483, -0.6946823688657318, 1.9501640910766003, 1.2381812376567698, 1.2359157598329695, 0.2957603831972757, 1.0838684856334422, 0.9101740533792969, 2.402784837093993, 1.693315653218835, 0.8159391285395616, -0.8598261860498254, 0.965380714176647, 0.21963021304862662, -0.227282838061674, -0.7064384231412136, 0.9639009686816534, 0.5856305008574509, 1.3880196990946554, 1.3168966086433673, 1.0165086176885556, 1.2362459668417265, 1.8154312152982923},
    {2.0582730833097806, -0.6328397202327841, -0.23529043295659577, -1.5355702729359333, 1.1219700919989968, 2.0344603330326207, 0.8826284294690746, 3.25105199359029, 1.13392843904988, -0.45944795088042184, -0.1295183153105571, 1.5199274922303057, 2.2098999793835072, 1.5127981634374343, -1.0278750758801258, -0.2980662087541347, 0.34243852264507535, 0.9643928593946454, 1.2810601899300087, 0.2322585579983413, 0.08331993954111319, -1.5116107539287496, 1.7226269450952418, 2.6739107362566457, -1.1181588457551013, 1.3065815102316392, 0.867336461124584, 1.1632382426373653, 2.130937948706518, 0.9533472072532035, 1.0766603222409643, 1.7156095567490666},
    {-1.2706669982901104, 0.07817847562135918, 0.02406754886676364, -1.6930346364706013, 0.996437254600912, 2.608474596750606, 1.7095224183797613, 2.755347848132433, 2.1745338575815714, 3.4212179033057213, -0.8562023780818558, 1.104582053568698, 1.1665500514795384, 2.0400979161751263, 0.03478051672618403, 1.1784980568429964, 1.4672027082158792, 0.6572309500299898, 1.0466085659447373, 0.8662916851557648, 0.5742382469849918, 1.730893238249531, 2.366545421639731, -0.5675182307110782, -1.00747311806993, 3.4829017038462564, 1.0325143216072967, 0.9501746152626198, -0.5565961523300091, -1.9402504383725114, 2.1881916990889865, 2.094217749860179},
    {2.327001898935427, 1.3873067676179187, 0.5445716581322811, -1.9673270054147414, 0.7536912300963746, 3.416991606984227, 2.4425406348371013, 1.853370568135467, 1.0111227632379534, 1.8761556041302345, 0.39944184543359595, 2.2092779546531776, 0.6880265742036417, 0.9632678809831751, -0.06080852146788198, 1.9763029135303167, 1.6791641015968972, 2.3843064796768365, -1.3453030110621325, 0.7253901490827197, -0.21887313353978047, 0.7078982802355679, 1.8014560827963286, 0.331817118425824, -1.145999458664577, 2.7963275681319146, 2.2732397395874986, 2.888161988233399, -0.6002768362781542, -1.7310392325810626, -0.22359426846779118, 2.3169347187578633},
    {0.676903996367415, -0.42227829812459483, -1.6064896279433885, 0.9665202542072671, 2.186273251165682, 0.5125099144918728, 2.1793106991224778, 1.1015669993289898, 2.214460227891177, -0.40415846823064233, -0.37377058096927884, 0.8643956667731569, -0.5395328271425166, 0.3375587011552473, -1.0970435093490538, 2.5691482057292534, 1.7278250836899622, 4.517116872187519, 0.6827548692351403, 3.5870653739406118, 1.0883066693980805, -1.6373970281603083, -0.04664363374669119, 0.9546998089983366, 1.5486348578384037, 0.21518276920305338, 1.7889850218341936, 1.686026847080126, 1.2372254818225432, 0.10203740714100051, 1.975405154131754, 2.829695448819051},
    {1.427773622570469, -0.9878919919287792, 0.10426584921135347, -0.7340773747072002, 1.8515347291690514, 0.11280523586132105, 1.4084838129228328, 0.7220049288872608, 2.198027798663908, 1.4086231076603997, 1.1184056929827564, 0.38445981645911703, 1.9579064927099772, 2.1962935824691763, 1.0212732599373304, 0.48982264841317097, 1.5715688361143114, 0.7779816395888451, 2.6999372074582086, 0.6010908782744893, -1.285619482041801, 1.8135187455672528, 3.2212905420483415, 1.6512812964240007, -1.063811367404132, 2.070268737676022, 1.6645847415044377, 0.1410563992199941, 0.7371273325651017, -0.4353005656913121, 0.22764459272745582, 1.5746431590371426},
    {1.0731853094597832, 1.363674889926, -0.041489777478497566, -1.130057920743997, 1.0222926245180335, 1.0320438703420605, 1.2886700749245035, 0.8279754738169715, -0.4025863356382646, 1.3660261358214103, 0.5912480445209011, 1.0218329969362407, 1.061667963706807, 0.24123850232005276, -0.47163208719564226, -0.9063352091029022, 0.7341579838725315, 1.1963945642576364, 1.966154814010755, 2.017439983353158, -1.0581621347872634, -0.30721591719511876, 0.2620783092332684, 0.6475790431383542, 0.07543208806930143, 1.8058350386475714, 0.9494293049649136, -0.697439262489338, -0.9833389234921446, 1.8604634334216672, 0.19863866345851844, 1.612764312040445},
    {2.159235728334655, -1.8025467373552277, 0.7014347439682558, 0.1368373630498399, 1.8247633609186111, -0.5264514265536197, 0.8106581396435631, 1.8540886211545824, 2.66105710543103, 1.4851797282618893, -0.5069245835520291, 0.34026845289403945, 1.861359079102207, 1.1528683354312126, 0.5803803711996525, 1.0831296856351111, 1.7382732641544298, 2.713418495836542, 1.1440418609098595, 3.951335516546235, -2.712131416560343, 1.4906180796213002, 0.5183695373231705, 1.6114321202646205, -0.9133954890216054, 1.2442711713283325, 2.076115151346225, 1.3946314645090852, -0.6591373089237097, -0.3188080618247576, 2.059850991524816, 2.5234144996130925},
    {1.1285641556141865, -0.8049263597823403, -0.4293739184299122, 0.18526882073312645, 3.463226898233129, 0.1454031576197848, 0.6400438171642715, 0.6275389775745743, 0.5494449556952115, 1.5009051399425803, -0.5900463949593301, 3.687711236095105, 0.967289133369095, 2.419056961598944, -0.846594958353944, 0.219379387480351, 1.256879183837947, 3.374534481555646, 1.0781378312438579, 1.7828572338577964, -0.13996718938807184, 0.35138202624512715, 0.8667261102412548, 1.2073889397741968, 0.19016446622054123, 0.5835339547453628, 0.520230725418385, 2.2494999884354674, -0.8062679103900304, 0.5967964421075463, 1.4233511327279305, 2.167709970410354},
    {0.7016942857787862, -0.3321674159769574, -0.4407096353985031, -0.15904132062708756, 1.446604200038402, 0.38901408084203126, 2.481452014714862, 0.5802833765803929, 0.5868489399514947, -0.04252250983850547, -0.22329936511185106, 1.318447147115984, 0.6052402038293125, 2.0726579028887904, -0.7359731245239521, -0.28092735596087326, 0.3202259400802915, 1.3062885740825327, 0.7563445937328412, 1.5424254340998111, -0.25383692374724015, -0.34020773323409553, 0.27904530543130424, 0.36620181701064736, -1.3072740502126872, 2.155564018134666, -0.3673741740741953, -0.7259753753668658, 1.331197283308165, 2.1301052853858238, 1.2091005259080632, 2.642788825057625},
    {0.8292904735584117, 0.19627673406946505, -1.2195052682812761, -0.8419033015423898, 1.2563235958063068, 2.4927350328666593, -0.34079177452024173, 0.9258021874796311, 2.5364366440993953, 1.4893535361119403, -1.1854861277924604, 1.9720668069498724, 0.5705854606191451, 1.7691932001763335, 0.5558139805365298, 1.3984650389661217, 1.8916077281792318, 1.5876665681982751, 1.7037802467766685, 1.902303303805328, -0.8212557024422602, 1.564619555402347, 1.9665937763055013, -0.24405817608523142, 0.13665968106058504, 0.21834589758103326, 2.5221712110548187, 0.39653847065054626, 0.7794352350259516, 1.4698375635495946, 1.81676878824371, 2.1911784180145997},
    {0.0850771146052334, -0.17585199219332232, 0.2645926172047737, -0.3041767733263562, 0.32877974211382865, 3.0641031562381777, 2.284580767667072, 1.6517261895861504, 1.3253782991622165, 1.9198839963394365, 0.400826927891682, 0.7142098028921703, 1.3958412681190835, 1.0851797612428855, -1.8010009815949783, 0.7360874356258578, 1.0591455444236788, 0.5084928061195905, 1.3751480861687198, 1.5903413802600626, 0.5412897069371991, 0.5992655877946076, 3.471456356039435, 2.2759068795500177, 1.2158007300651081, 1.6689812691357615, 1.2317199264752927, 1.765411844882228, 0.43040079133686315, 0.5952467092944337, -0.5248243472115602, 1.9328543266888125},
    {1.2506272010146822, -1.3265917770363105, 1.0588625483445937, 2.0709422228615555, 0.39545715253195934, -0.8712221823090666, 0.19373444488992614, 2.787188068156624, 2.042138967027871, 2.3360117411758, -1.3268692894573393, 2.1701148570365976, 2.866166296522317, 0.6008020368778862, 0.009691956640687442, 1.5504625188410497, 0.2292900942421574, 1.2203628593715319, 0.3354299369649854, 1.8562979711044243, -1.4884499283093746, 0.17607834609561984, 0.9888459550136145, 2.35399136663445, 0.01475263999481316, 0.5995314902939747, 1.4056369087653269, 1.721987549723067, 0.9284216490056588, 2.336803470053798, -0.05323603027885018, 0.7530750739904826},
    {2.9522330217754504, -0.9546913412770958, -1.1691497067348573, -0.723892761422323, 0.2520348601733888, 1.136839674571815, 1.4708795440767426, 2.012854565729218, 1.0038512997605198, 0.34006983721211587, -0.6208549990157097, 0.7802812651292116, 1.6656453085234786, 2.588888421731535, -0.32790320330610945, 1.5184558340760126, 2.166862456203778, 4.119571572909466, -0.06762995230709455, 2.5169132790155397, -1.2645745636960881, -0.14266956949277784, 0.40966769991880386, 2.667115641916855, 0.4001814945708524, 1.7354134923757285, 2.765319181788418, 0.8275837858652703, 0.14764758018595298, 1.1035718707045559, 2.2109476867523337, 2.828259524897885},
    {3.941766437683663, 0.21246665936516332, -1.0089295329482877, 0.8147509561226034, 0.9614487079328596, 1.725867511848084, 4.0699059937626645, 2.5464946058820295, 3.2089110900511666, 1.382006119994902, 1.1245858662986874, 0.9614574441257886, 0.8663237043495042, 0.2812014913300404, 1.0132646608934046, 0.3568627405092842, 0.37012129650437686, 2.7957991382772116, 0.6168839192742123, 1.7709365643526023, 1.3720417869440547, -0.46913365576032057, 3.1065080556684013, -0.10351885175167033, 0.45044741114046905, 0.909178220705949, 2.289285143121053, 0.5844732853773149, 1.8493309969987872, -2.27011480753377, 1.1342123140350664, 1.1739037355789246},
    {1.4546799193247002, -0.1937893224251129, -0.749783602542051, -0.11490972486199907, 1.4586604746177914, 1.337472486311118, 0.6260287077153774, 0.8849545632906621, 3.114728986659741, 1.4183707907127308, -2.1161538703888016, 1.21712980623239, 2.251415255570164, 1.016623085019761, -0.8118727716693894, 0.395262477745128, 0.1276056815242512, -0.2590756380266343, 0.7895623992483796, 1.2512110527639073, 0.9164489817876721, -0.31282655786011887, 1.5976183221820914, 2.074170010557564, -0.8129690309621773, -0.019261270221259067, 0.36764017005261435, 0.5981276501301737, 0.5234861301739911, 1.0115576695098634, 1.2432806078071483, 1.3843843096531931},
    {0.9917246735426374, -0.5965022562573223, -0.580582360459409, 0.13583741425962606, 1.685062775343865, 1.0989050038657968, 1.8390283994619883, 0.015066136475065859, 0.8016353376041728, 0.8691158612340396, 0.004927300788466522, 3.7938518794468, 1.6359062290040214, 1.2300110181302792, -0.8102580782544777, 2.284891391093884, 2.2432906212371275, 2.5916303954258715, 1.2891798802646153, 1.946975869103303, -0.6051416279683755, 1.2488023639455186, 3.3180775380586778, 0.5589008135865492, -0.5289298983623548, 2.2462262825466754, 1.8792777623307204, 1.0207914848059818, 0.514414758222376, 0.7153585562572649, 1.832576132745865, 1.8387242974137945},
    {1.9300188468923218, 0.07340761249774469, -0.7124866611327447, -0.874939667070982, 2.2053899913142527, 0.25210679180830176, -0.3997257306295931, 1.2399970636526438, 1.5764296454914701, 0.8274802727311792, -0.9351998530479694, 1.2086670815730323, 1.4019206161507647, 2.099803847239064, 0.08624616122432523, -0.7190276938941612, -0.22698875302124838, 1.2538019293332834, 2.894957264565406, 1.4825121766999358, -0.412016511658199, 0.49435792699137493, 1.9771136592854546, 1.1655400618021652, 0.2865702160863626, 0.3750378356941952, -0.32533028824318677, 2.778263240934512, 0.10338466545499593, 1.8728205218341114, 1.9390922028062547, 1.6448731858773271},
    {1.020769403065715, 0.11334291957215943, -1.609540626808549, -0.7533176113126181, 1.5694470702639474, 2.5943984957440045, 1.7389440821150397, 1.8417871646907495, 0.36286797120826375, 0.09658227172984084, 0.5905900383203517, 1.1403252326359756, 0.36350380824647005, 2.982416356584777, -1.5376911227261767, 1.0864807015137765, 1.6645574642698526, 2.4805821807304396, 0.30079792813199463, 0.24593259864614153, 0.38191027981882564, 0.894117503830921, 1.8051006680306172, 2.9496184617690866, 0.31569482365754686, 0.7763544382973442, 1.3268675730612711, 1.3008554728840285, -0.7778506277431086, 0.12512646101100303, 0.9260338747841064, 1.1599732980930364},
    {1.3505957500353944, -0.6991788126260412, -0.5217279775459672, -1.7717524442059693, 2.2750153973261114, 1.6793277629379904, 2.8074969159119183, 1.7956241860779256, 2.843067610417331, 0.25343208304025544, 0.8649330553604262, 3.8265189194264266, 2.207605034886859, -0.2425234423522268, 0.9869472171998608, 1.6284806641777585, 2.845401417066513, 2.5908277653117286, 1.7705342643321775, 2.070899590270211, -0.9087982739552463, 1.7810423764173415, -0.456704565869993, 0.5826611189684007, -0.5022969590654554, 1.815901113998082, 2.0505548230975172, -0.9834640097817677, -1.2707740020283793, 1.4647523281185348, 1.704935927634591, 0.9397942344889993},
    {1.8801029824236555, 2.3495497633395237, 0.06128471837130828, 0.5378560626299497, 0.8747798964423517, 1.4508496434793707, 1.5192476028658757, 1.0246337599589548, 0.41218711141227754, 0.2475235600878249, -1.2501960798592757, -0.16532289101977402, 0.8510644134684928, 0.9037924743609591, -1.5993637493423516, -0.22175705287737485, 1.1773645766349108, -0.008145822755362065, 1.4286313609003924, 0.17329891578642392, 1.6582474202382376, 0.0597400225037882, 0.28388355518227043, 0.8499399161923503, 0.853198424745084, 1.186228656772725, 0.477071294066142, 0.9299533338148271, 1.671411210329129, 1.7513979474338746, 1.6602524896297022, -0.13103673709136648},
    {3.1392360348314337, 0.0020685212851091605, 0.4768357279450544, -0.018417609925796226, -0.601517514665761, 1.2366868187112843, 2.1801583593723755, 2.0236017128982033, 0.25706050231721295, 1.2888558981000182, -0.46748381312535, 1.3770771538413002, 2.6881066232733413, 0.5795992165305535, 0.593765060924515, 1.521865619241437, 0.9335318565543914, 2.1331766313660787, -0.24424127263864356, 0.6468695888977709, 0.37965243271670124, -0.021994223043183207, -0.282537995707424, 2.4358377416453028, 0.23851122703932698, 2.2288521753286856, 0.32619513022634566, 1.287321194439852, 2.3852142001885315, -0.88555820203341, 1.994814999319846, 1.4092705536919334},
    {1.1677880826699378, 0.14253396526381965, -1.6518062747436588, -0.12727556152953062, 1.8262049291060458, 1.6502497484831171, 1.177810688523507, 0.7381668458369232, 0.44798530813555404, 1.71371565716133, -1.405669472319506, 2.552935529109377, 1.2581951361721586, 1.6091372341215076, -0.680857510624302, 0.8937140335890371, 0.6698612621274844, 2.111808185475549, 1.6861011896434757, 2.646108618553985, -0.6464915334620754, -1.072557255068423, 2.23058718596293, 2.5064791253178793, 0.18924577185383942, 0.7982866459449274, 1.988899528671066, -0.27613211727533815, 0.7799971117772585, -2.0853903408023156, 2.102535823630602, 2.179422569128086},
    {0.10561356855654205, 1.8021255316862401, -0.04857648400540643, -1.7334025360409828, 1.5029330350414154, 0.29779240141691693, 1.3019257114337268, 1.4722040461168175, 1.8074042231650624, 2.262977839481707, -0.14852285754610023, 1.0976070007085026, 0.6436165512108453, 3.026127796556529, -0.7884953073036772, 2.399205023786895, 2.4259277494381393, 1.6330331370048974, -0.7126358475478459, 1.553848894502036, -0.42827827933018414, 1.5507417009608504, 1.2127967194512934, -0.13445344059309655, -0.9351324929770645, 0.06576201116135796, -0.5777719063606802, -0.06883814693534425, -0.319448764749646, 0.5142329711841755, 0.5458967309855948, 1.6739425051081946},
    {1.0685109111217297, -0.22120620107177494, 1.6418988234329568, 2.146416418492523, 1.6327258249743246, 3.443844716716945, 2.2576206491236936, 1.6420978217153015, 3.1243991584219803, 2.033456348810219, -1.495003475397349, 2.218038619062071, 1.9716294394558438, 1.1342624286950094, 1.2803913494774928, 2.643467584307508, 1.8051564987983162, 2.73035400110601, 1.2962598758197463, 3.506885297217577, 2.1106792904051663, -0.33269307460214687, 0.3514815990414335, 0.9192331428393964, 0.14800297726946207, -0.31194488291742467, 0.31409724769146435, -0.3016603754485465, 0.22053759082564425, 0.9575200499977713, 1.370197766780357, 1.2094985004555578},
    {1.0457545014832113, -0.08450008502314202, 1.0159883227676914, 0.3149658322443551, 0.9798518536146362, 0.8624285051296833, 1.9163041633849518, 1.7809951791930447, 0.8047176968475992, 2.975235247680767, 0.7614866874763754, 2.4282396389886376, 4.340794920435551, 2.2526763598538575, 0.4599378542818788, 0.6791885660229531, 1.3345172122504079, 2.6684670863987696, 1.510896702998679, 0.24298004934492518, -0.10857555099502889, 0.03283204234308801, -0.015704534128254663, 1.1420664701030714, -1.7910046121527776, 1.0925100609846037, 2.6153841031947525, 2.418634070893129, 0.9984261960723906, 0.63116807602665, 0.1746622969726076, 2.320283828709757},
    {0.7215432987346655, -1.1574318394334098, 0.7023249107826661, 0.6228698528489431, -1.478342914958596, 0.8332962781822246, -0.37616342161525285, -0.6539696006464208, 0.4109448332828557, -0.3514825332321206, 1.7158300919846277, 0.9869176864594132, 1.5839736176668453, 1.8440599282931291, 0.5332449790211417, 1.7684816201225806, 0.8684210053106214, 0.16886698412560155, 1.017723178708513, 1.9490446031014554, -1.164874855180926, 0.47698299263406463, 0.8071531544665562, 0.4761272407563168, -1.539941388694044, 1.9082904161503862, 0.411386334405685, -0.8465078129994796, -0.15263099540004557, 0.08190004368584154, 0.7703588848769558, 1.5591695707631876},
    {1.3750983930971856, 0.6188630611316093, 1.4434794715606594, 0.8061781844475324, -0.5933164312602536, 0.4689379437476975, 2.464148469382921, 2.572081338944487, 2.3825216359512917, 1.8415048270328642, -0.3762930304253485, 4.293598498555906, 1.3813596580108112, 0.839794519052246, -0.12808626407008877, 1.5692919964270777, 2.144857099683548, 0.15547416065282, -0.25028457586366715, 0.3915950051127406, 1.7339532871372985, -0.21078351725333477, 2.747583900287273, 1.1862077472018204, -0.5347864972263818, 1.0054473732101914, 1.6537650836620201, 2.0481601171139427, -0.5849139363595693, 0.16795333384878897, 2.215303879391895, 0.20214379371238195},
    {3.8295559853396854, 0.4321884875161004, -0.7802682099882884, 0.9724815825078893, 0.20447265112322033, 0.7844795534990524, 0.5414840817462326, 1.9476192520796063, 0.17422193392937182, 1.6199954786174238, -1.907896040263659, 1.143012957505837, 0.21615478807986585, 0.675268772574452, 0.2916099615716859, 0.1533743083465154, 1.0858199790461567, 0.6230128141002383, 1.5742111164074577, -0.22949056464813253, -1.3575819240976432, 1.299543058243105, 1.1614577490694118, 1.0391157436019323, -0.16180232391773947, 1.964950617157454, 1.4327004076890564, 0.8791655787722616, 2.0002802213711495, 0.23231000969759216, 2.8231508278446062, 0.8556582429623868},
    {1.585375548655332, -0.12405930351821862, -0.9538818004372063, 2.0410598935920743, 0.4099764610324978, -0.41585667166716817, -0.26052574065693834, -0.28141260916821653, 2.3192724027884, 1.1138751917602594, -1.079783477967188, 0.6776189704031832, 1.4171426227432489, 2.470348062858583, 0.9692995449161114, -1.2649603195504058, -0.1533431983627852, 1.4581795070358539, 0.42213967887151976, 0.816621012172393, -0.9265518101898448, -0.16424195024525903, -0.2154342938995064, 0.8786933842455577, -0.501003550793129, 1.2950368560415542, 0.7123509232974713, -1.9000014419296605, -0.21174403074249196, 1.3950982099250007, -0.8645214483414271, 1.2963960757744473},
    {1.291468915702725, -0.39506580849208245, 1.2479972840241047, 0.7206949440083035, 0.5855521718152188, 3.3070688560205914, 2.1675493282362406, 2.3319616774499523, 2.2271697466471965, 2.5817003293104577, 0.7473061989798933, 0.6578908461466719, 2.332694745665448, 0.7693708494560575, -0.9129643251293724, 0.7254252219868432, 1.0036271212445753, 1.293362555142992, -1.6154731568793104, 0.5938503034364813, 1.4027629236512928, 0.12542123675470374, -0.14430378903764554, -0.3976940220938325, 1.5546198565141642, 0.7951948260584838, 0.7422347080297437, 0.9943626060536029, 1.3030234471118465, -1.0618200405307967, 0.775431223055686, 1.744197930038004},
    {2.6710117489436724, -1.0270513579773417, -0.3323542704182086, -0.6457050014205917, 1.5248294779815332, 2.5938638767474966, 1.7882215210705028, 1.6135773787632939, 1.2511407097040277, 1.5836233723429816, 1.5631453366012515, 0.3218217009137607, 2.800347334772346, 2.2437854458717634, 0.5914138959173829, 1.1691258720105213, 1.9494593085847216, 1.3881514661202055, 0.37641076120408257, 1.7894029057960867, 1.1825542547626804, 1.3069875624444534, -0.4806842486950179, 1.0486783030521716, 1.0626102399487596, 0.15400031143027162, 2.1236289204383128, 1.0163444150156846, 1.3784978155990533, 0.6462179144785881, 1.8183080844939905, 2.99058986500091},
    {1.4277130541439127, -1.4422360273381587, -0.19245422405517365, -0.17910107125543354, 0.1832789378165538, 0.15505348126475213, 1.2591324240047697, 0.8125024863826119, 3.5660378513335536, 0.9278650533290035, 0.09612329222048606, 1.4148931862219034, 0.486144188027038, 1.4985080679440133, 0.1786832591760306, 0.8119013099281355, -0.454510908476219, 1.753708973514532, 1.1365946262774453, 1.6103777130705268, -0.043711377958118254, -0.6354150217086296, 0.5524321866390748, 2.2048777023691533, 0.37247202004187935, 2.189266331035151, 2.7618335216506837, 0.37828103100828786, 2.8368088383629813, -0.1974356212918556, 0.16350410618470773, 0.7165415024657169},
    {1.8138421158154852, 0.8001685852309044, -0.8720063065110448, 0.17567419904996937, -0.16053750928029098, 1.5513422578361429, -0.35095596111457583, 2.0627209961372506, 2.5097666193738277, 1.4278940531107922, 2.10922986654723, 1.472622224977719, 2.603597461487735, 2.111126288342539, -1.9859164052581537, 0.3396010885533917, 1.5829861222988257, 1.080920845203635, 1.436693269118132, -0.5587845174954675, 0.12795589449009323, 0.4109268468950299, -0.10775019583579203, 3.0829821550004675, -0.15483148292685966, 1.4537270579735448, 0.483752563227722, 0.9341279313003916, 1.4410726763254142, 0.4879342459664071, 1.840877103946119, -0.5291574703322541},
    {1.362482217493072, 0.058811913811966286, -1.468229063937649, -0.8874808675646934, 0.6443546899808951, -0.04649168770086931, 1.3527116631144198, 2.6218230398894846, 1.0900106847645303, 2.0683420347508052, 1.1015655278629017, 0.44385305793698404, 1.1321352972176388, 2.1027635194517424, 0.3842886069156381, 0.717494272227598, 1.6141224387084667, 1.2721976572772793, 0.013358100520004234, 2.402554155882242, -0.5535865628507584, 0.3905739712916003, -0.3004695898459375, 0.8547318350033638, -0.605894246552152, -0.15081303574903462, 2.9755673733528227, 1.4508439379037368, 1.4921753012539705, -0.32499726552466107, 1.6837740066959117, 2.302912269300179},
    {1.6165861390820684, 0.6026542656267583, -1.4162284316372242, -0.7880764018537804, 1.7911822388673777, 0.6106289046365223, 1.662877145728117, 2.266167486112857, 1.5893522255072952, 1.5572589937359433, 0.6201201195685606, 0.5960278407361805, 1.6203949722771365, 1.6775266563180082, -1.1544336742023387, 2.6755477345936023, 2.0324415659544224, 2.911214603921054, 3.394809878476536, 2.0084199974760835, -0.929570158692295, 0.342330462863159, 2.109776889389488, 3.97541797777554, 0.23641515708377644, 0.849941436522566, 0.13431607272155274, -0.5426157032649451, 0.49423854524279887, 0.3377186628402713, -0.08190365856450953, 2.526268815007901},
    {1.5372718440740853, 0.8191605224992282, -2.466021124875227, -0.4716108222285829, 2.3556151339051996, 3.339981074072252, 2.667124444786301, 0.8412634287008842, 2.2766738382798333, 1.193756789101429, -0.279524949896232, 1.7265647443525975, 0.9695311104897704, 0.7099200827196833, 0.940513475058521, 1.34319051106353, 0.20876925752565367, 2.655919740283406, 1.6698846870804895, 2.740056596985528, -1.652445579382573, 1.0251455997561447, 2.9040111370362798, 1.6580124436678438, -0.2894316738846819, 0.5848224888897969, 2.4881522895639256, 1.305039714897638, 2.082650417935269, -0.4301225406141021, 1.2694560052364623, 1.2448827910573195},
    {1.8997777502507471, -1.9989221839845284, -0.7768330231664393, 0.37317330199868504, -1.42922100961701, 1.312224629227678, 2.689714391656819, 1.752254604337178, 2.6697883314496633, -0.7663447710868071, 0.7102486532713316, 1.4462348139642072, 0.7515762178172214, 1.656141855445447, -1.119696018270963, 0.1979710632784626, 0.9794123734215356, 2.6874927579788936, 0.3658267618441414, 0.07100510865868202, 0.4513747025037819, 0.8496367383670761, 3.155768273840276, 0.29475579236380695, -0.7151527012437263, 0.46213837531243673, 2.56173474347244, 0.7434455250695919, 2.075896095173283, -0.017350241216736114, -0.023100555943805386, 2.519200159873669},
    {2.4441666996306184, -0.17628623332991694, 1.2973736564337364, -0.24595431159052236, 1.6245529338418745, 2.6618337854845295, 1.2526953305758748, 1.4164574951310294, 1.381476755669284, -0.18002078874306854, 0.9425384594468774, 1.9918034451356184, 1.4256138761143904, 1.9746101260943847, -1.0081035437456884, 2.8096677994153603, 0.3195180470705928, 2.081395186525959, 0.17818608516058967, 0.7140785335806683, -0.6948264452289221, 0.3130904191394047, -0.14137819851987776, 2.4459849381646683, 0.19973166119804003, 0.37577835460984654, 2.5465054756198877, 2.6511293592233853, -0.6345169400844093, -0.8659733832112338, 2.4580546634593086, 2.6410641091533202},
    {2.0868150535368595, -0.6708931425822777, -0.40942216754709576, -2.6876934668757793, -0.2904288968575874, 0.905480319335246, 1.3419257649268923, 0.7615697481315833, 1.0407992148890959, 2.69914884758459, -0.19352101130893873, 1.4133129196604945, 1.1998649633443101, 2.088349039229235, -0.7854124071305874, -0.26807760313753115, -0.8452267354701222, 2.395248810338844, 1.328557476902529, 1.7231114574838489, 0.4673239730110778, -1.150035666187662, 2.3680106974509636, 1.2704946695333967, -1.1619960796981326, -1.0403192049362064, 2.888198721081167, 2.9061109002508188, 1.7108393683216903, 0.6539276181839743, 0.30095229070943247, 1.1897021620855779},
    {2.2955766924272387, -1.5952722952787612, -1.6933466619000834, -0.039616963396686966, 0.4327927983797891, 1.0439527141776896, 1.6510265942845115, 2.1663245844068344, 1.509733991576089, 0.43611011804440764, 1.27548812176388, 1.1641201745660488, 1.19513162402777, 1.6593122119623414, -1.109581432531721, 2.2086405691261244, 0.08869681088826566, 1.8516221347726263, 0.8512596523799528, 1.46123018045403, -0.8321457088993882, 1.9236399957758474, 3.079001249835301, 2.207949525030339, -0.564776809822321, 1.8219516477214164, 2.3115675016918082, -0.013634640348957311, -0.36156434993052533, -0.9775615741342961, 3.482834807623743, 1.7090047571815647},
    {0.8467996148137805, 0.4536143544796452, -2.769576808140384, -0.2756512883787395, 1.2073489475089398, 1.2868414533527808, 2.2915124308370745, 1.488664429728568, 1.33367671240211, 1.3906028385497413, 1.364257776486314, 1.330433230059443, 1.089685351947859, 1.564457272763808, 1.2523201709527054, 0.8983400218123347, 2.41126394906026, 0.9921587276812419, 1.3479471427563778, 0.9165731931186382, 0.14521859626844988, -1.2764530024610812, 0.6721889981065398, 0.9684659489871702, -1.6562239001774666, 1.118101028540794, 1.7748012427190192, 2.3559108583932225, 1.9495930456749366, 0.5547178609226139, -0.3768961689435214, 2.026429442136455},
    {2.3745846179092354, 0.56467302229565, -0.9607111727798412, -2.26913950617034, -0.055148396433866584, 0.57185489730575, 1.7978850782249016, 1.2466603356014518, 1.1119582012169575, 3.4145822637982506, 0.4409989667756867, 1.5381640173262612, 2.2466800654727295, 1.835479565776683, 0.4927159399667507, 1.9744530364095512, 1.599662631472136, 1.735770119258964, 0.006493327468471586, 0.9291219139389559, 0.04510089903284142, 2.7784659750813896, 0.7757091101055246, 0.17627227452849867, 1.0710400650175897, 2.215620610304626, 1.8303927580805952, 2.091706478708292, 1.4598308463702139, 1.5469380884500243, 1.009758165374245, 1.227635359655089},
    {2.191717405356387, -0.015272878378204294, 0.4717057386380733, -1.644863671616924, 2.3132919922412762, 1.835214161644496, 2.7173758245898414, 1.6767419065287459, 1.4665018510599326, 2.5646652404179857, 0.24449229511360718, 2.771396603917675, 2.4725616018897347, 3.1958327391618204, -0.7979920038606712, 2.353299361571203, 1.0051155631478277, 1.6838598888562628, 2.3406490742938395, 1.8827108981365408, -0.572132318043982, -0.6083391417188703, 2.781375516134994, 0.911113955201125, -1.0872029899292073, 1.5531843303327433, 1.9282884322458824, -0.07953439269131737, 0.40804029009522763, 0.7237183469701478, 0.8935491266522841, 1.3006094928327192},
    {2.4565650241769106, -0.8134828571670351, -1.2368488027964037, -0.20320568669145636, -0.4032085612775927, 2.8017951576727844, 1.6982164525524377, -0.4127173082454564, 1.747300056347128, -0.6998030054191791, -0.39706519775227744, 1.391346883110212, 2.187461380597767, 1.4617145117707835, -0.5506814606505732, 2.9101172583496027, 1.5432642556510834, -0.11642542492602807, 1.7199806905477446, 3.5529985248560476, 0.29914802776167015, 0.44392251844366076, 1.3477782512999583, -0.16933892159900166, 0.46830792371553925, 1.7511199085578846, 0.8182708571516655, 0.45933041765909494, 0.6898417055599912, 1.0577816158937985, -1.4270796661864944, 1.439067409588572},
    {0.5847390350170963, -1.9133251476853486, -1.3861270387249895, -0.16851073764837782, 2.1016371457927963, -1.0530565214431058, 1.652863716936203, 4.198167994016257, 1.0872198924513043, 0.3591577526729443, -0.6813626235108774, 1.740963094757236, 1.6427382870077996, -0.3298995520475149, 0.0318009546947328, 2.0783768270783636, 0.3085168942480313, 1.1247145037898905, 1.1494868192279855, 2.7766246685539717, -1.3532817452941805, 0.08453240748622538, 1.7491255150984248, 1.742472658112858, -1.0468577064968705, 0.7174289405394951, 0.8619400203686428, 0.7648054070525826, 1.50117191872763, 0.8258008611749457, 1.2900634517026492, 0.7150428319886882},
    {3.1113564080483207, 2.91677773552392, 0.8539218499872355, -0.09082192380976789, -0.6800119462658564, 1.6183472653720596, 0.6050963629441727, 1.731995082020789, 1.6622388418238498, 2.239862095814536, -0.14776358634198916, 2.3100348837869915, 1.461856735319908, 2.266488446877273, -0.16848237559657372, 2.7297465660263245, 1.89963170233254, 1.683380090124586, 1.048015962227452, 1.4194538098075231, 0.3514180820273676, 0.5983453693546216, 1.2567804471817408, 3.333057948099408, 0.5724164324126246, 1.1671509151117323, 1.2633416538676545, 1.343179840595449, 0.8124759260834413, 0.7500458103801213, 2.766994458380042, 2.668606722640732},
    {4.020997946504135, 1.2700970374737337, 1.1670880724646917, 0.47377925775091007, 2.4073361338505963, -0.1091102350807004, 0.16560979826989533, 1.8711534310982456, 2.3684933366985557, 2.4277475922656957, -0.47497697691211915, 1.6511194068000599, 0.6861523218710331, 2.072979098443302, 1.1506920737281252, 0.15370306267888725, 2.4968459946893233, 1.9707605522739535, 3.231255588690903, 1.7225009401072218, -1.607982095405721, -0.4726229414977771, -1.426223876661586, 1.3994197347950987, -0.654961950781015, 2.0437243069355886, 1.365228962444421, 1.8132941241823182, 0.7589576639352081, 1.4752638938721725, 1.774696969726544, 3.6301184070268446},
    {2.368485296463758, -2.174744389271585, -1.2059890306608796, 0.33112810493817885, 1.3059223187639022, 1.7119014364531029, 1.2344798855838346, 3.033062722809238, -0.21414718161175275, -0.9411055441568514, 0.383098762453527, 1.8623358506404526, 1.1532803275415817, 2.751890429805296, -1.5565354624539296, 2.862083136981931, 0.2871964502061767, 1.5757109668989346, -0.5973250680968161, 1.3310307968931037, -0.5432263126487558, -0.4302034553037399, 2.0476734691735627, 2.7840579111644113, -1.3365464999392975, 2.000458617227625, 0.517551884145642, -0.4811057052171646, 1.7924726510599944, 0.7718636013097102, -0.0717782782783808, 2.1021470608631168}
};

static const float b2[32] = {2.3052419632098196, 0.17713276707717485, -0.06605089977197852, -0.5490870612017681, 1.8573626131674248, 1.8522553583480683, 2.1525290546768474, 2.48419272973237, 1.9041511222256702, 1.9846646187877295, -0.0752067147203237, 2.5256595186267474, 2.1772829705479837, 2.476946345829981, -0.15668087229840472, 1.623171775701405, 1.8677500485260223, 2.601290864921725, 1.3370566398326722, 2.14100781829798, -0.0826756431883566, 0.4571060238169555, 1.9394627125973496, 2.263295139840052, 0.003612234498861197, 2.086841776178789, 2.3940653149672237, 1.4612747146667062, 1.2097108012621187, 0.45707289367975945, 1.7112045869755144, 2.600364706100491};

static const float w3[32][16] = {
    {2.399321698489139, 3.646671441645596, 1.8295420651602265, -0.8926784075817689, 0.3233415573696566, -0.450063155934896, 1.2850422848622869, 1.2050695754789538, 2.882321994638449, -0.049088605226796624, 3.126901030711853, 0.6227373832138967, 1.7538339745233322, 1.9608781581173047, -0.5818179964194853, 1.3112908614949474},
    {0.20427019563477058, 0.1541314233618859, 1.8045814713139863, -1.0083846417094047, 0.3443458577854467, -0.559097273911707, 0.39949946730264413, -0.5840396410358542, -0.9645419594028186, -0.7256920193140034, 0.2781653070340722, -0.3819006327988797, 0.0240075901594123, 0.2051465159164728, 1.473442376867311, -0.4322603571751724},
    {1.7249936389637965, 0.5324289593824002, -0.9732059401712402, -0.008989836449889894, 1.500237978758377, 2.079244403774652, -0.048587066202215506, 0.6302710828512639, 0.32768689152195835, 2.8245164324621763, 0.5406695119776302, 1.1028727640073723, -0.9247189943023941, 0.3458661253568319, 0.5927877410537673, -2.562027987466766},
    {0.469252271441913, -0.5787591334978933, 0.11667613207585213, 1.2484463628655917, -0.2731557983732747, 0.6789367016558671, -1.2321971446913687, 0.23058026402970996, -1.743193138349259, 0.7965830414921249, -0.41909668353309276, 1.2930704868560654, -2.1519081238323396, 0.11219188999014744, -0.4226451219333081, 0.31839829768137684},
    {3.991012739452561, 2.099128193831502, 1.545929881987074, 0.59692517276584, -1.2404191416389212, -0.23842875109571474, 1.9022364445850528, -0.3866334963758683, 3.725077176031433, 0.6713140948750848, 1.0151143198859682, 0.15883585835360617, 0.7126527156916481, 2.602988356528395, 1.4954272021614876, 0.2903470870698348},
    {2.866223108005826, 2.4568364294199023, 1.8197506967053938, -1.137397998310522, 0.03976602998034019, 2.840685601007507, 1.145926016314633, -0.3295945415807526, 1.6533187949505488, 0.5929630926023903, 2.250501577447957, 0.2884072768982574, -1.8371177583963891, 1.5159093792813398, -0.5443541644176974, 2.687253526041816},
    {1.2877612950591828, 2.896296122175553, 3.6342342595588164, -1.6429214457109675, -0.1727795524399033, 0.4207884475588255, 1.8571633023527563, -1.0326574636572552, 3.6983011604704985, -0.15533432094084945, 1.4411737303267147, 0.43972532532499914, -1.4738918965293966, 1.6270767212430157, 1.2260462681384525, -0.8748456665802199},
    {1.9538651780852057, 3.65694726696463, 4.785123559190661, 0.2951245607697134, -0.7724722865201747, 1.6988801228764119, 0.4698437690097971, 0.2134969674895433, 3.104582575974535, -0.22150296892621507, 2.502155066872753, -0.3300905434782904, -0.20881674477966292, 2.628250445622878, 0.25621846820493865, 1.1582810342215168},
    {4.216127710001538, 2.7050044479131117, 1.2990770032980468, 1.3207606715916578, -0.20269355951782891, 0.7349726631913701, 2.556136048592675, 0.5704282163812777, 1.4368657368296254, -0.28342446476864824, 2.238166308376534, -0.8191898282954032, 0.8760420620577186, 1.1961637320030922, -1.093664032717844, 3.0175788885771264},
    {2.0598657667760087, 0.3405403356242824, 5.484404835571807, -0.4784537918608921, -2.061194889376414, 2.5292034558354155, 0.028195752176325767, -0.07052940254031785, 2.320801340157045, 0.9905499670166922, 3.446336000598972, 1.5664883725564849, -0.02564308430618461, 3.5602740455627795, -1.3844393532517063, 2.4910553371114132},
    {-0.2820133663947948, -1.1555209836655815, 0.8705626460638015, 0.0017740229349841599, -0.7502099314958426, 0.040510949623742624, 0.1332071590002495, -0.13640208925556058, 0.4256586753513717, -0.059639641138322604, -0.43752659576847114, 1.0210619519664383, -1.7879697317421641, 2.550675079951624, -0.4100983876684108, 0.19257880940833605},
    {4.157322834958164, 3.3689401405285047, 2.0996334905991687, 0.5797454243220138, 0.14635295679804666, -0.040886944004863576, 3.248884234305302, 0.14013715262483467, 1.124545474344995, 0.10029496278454114, 2.2966929814353914, -1.9362666246073457, -0.983665077443013, 3.135923776128421, -0.0017342941508944833, 0.5632764519470796},
    {1.3973919566505906, 3.541591934821678, 1.742022885916377, 0.9504851038569228, -1.4400168210363844, -0.8172202549436512, 0.6024925503350175, -2.2604088207708415, 2.0850517905282238, -1.5911028219964392, 3.0074492512560433, -2.154065545113437, -1.2398583367029914, 2.201809217294873, -0.7970806563627726, 1.386962421084955},
    {2.406389122351999, 3.0312995674016077, 3.448504593009515, -1.2773965503449582, 0.5150666978837143, -0.5428792462869385, 2.5930318062530553, 0.4363120529903838, 1.6642899730181755, -0.9053708798065468, 4.099949615033445, 0.220670871401085, -0.47635821995824706, 0.3669465919124753, 2.1768778191767164, 1.2635981159985203},
    {-0.54964194365756, -0.6743135220895545, 0.6589798739278626, 0.2751871754592604, 0.4432570477084831, -0.4581659288103921, 2.098211825630299, -1.312040386441841, -0.01106630072751646, 0.21109529158556894, 0.203003530037958, 0.2782882455769168, -0.6576763709272777, -0.5025612358228655, -0.2767767261681634, 1.4141554875114826},
    {3.3128755429557892, 2.0741287475594916, 2.9192559467255945, 1.6995397716168261, 0.647817594586069, 2.270653130395792, 2.552677336358342, -1.2936908482715213, 1.5551702729466486, 0.2325848269124239, 1.693808791324358, -0.6140574423948724, 1.3912892876405274, 1.4900091153481045, 0.4928299414400812, 3.004258974654232},
    {4.023339050916155, 1.2646793649356955, 3.790751576549899, -0.80167526448938, 2.166296729473875, 3.0819742959151, 3.327581613124581, 0.3720549423176318, 0.8465401521217535, -1.251663420018848, 0.6417083088228751, -0.33634928903087036, -2.598367785138393, 1.5069634717676, -0.9262399721952119, 0.7186004881836751},
    {2.1293277447461927, 1.5409918712242505, 4.046813996860018, -0.76861886589196, -0.3524127934288067, -0.39839866063457297, 0.8506948134554921, -0.8252064214822529, 1.9973513249187516, -1.1102210474839969, 1.8773140890382425, -0.7754059187707727, -0.3464741396420383, 2.361775924785032, -1.2727540721081587, 1.0992915375380579},
    {2.5597839428985933, 2.1056410188112675, 0.48574142078297206, 2.0218969877124557, -2.5445485376285406, -0.013482357570576031, 1.1612581776502355, 0.24044339717406352, 1.409011870549982, 0.11388574152209921, 0.9516964583967492, 1.0045637738220632, -0.6287475758082309, 1.6801433414236158, 0.6051426522899503, 0.8131827711591065},
    {2.115970507674223, 4.070859687409529, 2.740743416091232, 0.5853634438762404, 1.0735077048754484, -0.18518506878966948, 1.3044594175033335, 2.874043035723986, 1.727733331883987, 0.03487423860013205, 2.438646057397639, -0.36413637859720477, -0.9805628587059223, 1.116910175568316, -2.0694800151251393, 0.7743383925944118},
    {-0.849080437646272, -2.3082107688147224, 0.5308815859837142, -0.958586647603548, -0.7469370430483852, -1.0027131066793533, 0.7892693651465916, -0.561599362216263, 0.11149596188110582, 0.28901311823730463, 0.2929354786688439, 0.5548375004989895, 1.3284141135189904, -0.5541602777743809, 1.0706452047054993, -1.055040204809319},
    {0.7965796684436179, 1.038114424376921, 1.2545427546375998, -0.09231870811410942, -0.7940718804742755, 1.730695098229283, 0.05983510821120182, 0.04646844893207484, 0.29659134180457297, 0.12131350791008126, 0.5729187579889427, 0.4151546531417351, -0.6472328116537712, 1.3753484574224215, 0.01583680383699851, -1.1977919779163353},
    {2.178300467001996, 2.1044901320988654, 2.551730605646383, -0.02034755822971324, -0.5274711912513752, 0.11041351989898401, -0.01601195849616421, -1.6511678967529007, 2.926738852488165, 1.3553502066501608, 1.0168912471274962, -0.29615903556024864, 1.3581139337033474, 2.429331862978194, -0.6344575631027651, 1.3254596866882713},
    {0.8582141407701619, 2.3373212783474173, 3.1704160045202916, -1.2880918034653626, 0.33751844437760875, 0.11166962413457464, 0.812147948160108, 0.6371497733548066, 2.908965422834473, 1.0425358900935449, 2.2336786610392254, 0.012489451104709766, -0.6824080590196082, 1.812227885553382, -0.6196194477120436, 1.2412227741805848},
    {0.11393865272344185, -0.5946659369764264, -1.169007393837346, 0.8132846317323816, 1.1952254012908086, 0.18761585580569964, 1.5871144951913434, -0.7796847742468627, 1.9573381530517746, -0.6504312516255483, -1.064280095377216, -0.5399390560721758, -1.9780962416804746, -0.7303848524602967, 0.484580811282669, -0.7776307933586042},
    {2.8892852120351566, 2.1453703463402207, 1.5976911137527416, -0.6574330687624729, -2.3421758638777046, -0.4964098845304862, 1.3256522079034456, 0.8405446016709077, 0.795296052249215, -0.38979061655444547, 2.495482395433513, 0.5531289778626548, 0.5222168800318727, 1.7152247140617989, 0.9702425746524964, 1.9009367054364152},
    {4.152515244473852, 3.110573853269321, 3.6741470178047564, 1.1445315855838925, 0.7966128728101517, 0.03560996003017823, 0.6751829502990232, -0.016049221043848334, 0.870222745647682, 0.8440104908960294, 2.2051535748550184, -1.606709661456953, -2.6634704904269104, 1.5695211807815503, 0.286174553922965, 0.7825969174847924},
    {2.1730830518918105, 2.5623525195486616, 0.2844443295581149, -1.0199196443166536, 0.29606761430867057, 0.2583877576664274, 2.1203689513177406, 0.32778599708634304, 1.5328025206735003, -1.2012208482580597, 2.550061332086772, -0.6951730530385933, 1.955789318739364, 2.109495181864551, 1.8508808247183142, -0.5152555543029633},
    {1.826664833785962, 0.4610293751521702, 1.4257233970137075, -0.01651390345424045, -0.1285743810745099, 1.5216099037668485, 1.476060390768006, -1.1239739813794716, 2.4026961240066993, 1.7469295684061945, 2.7501289250290224, -0.03184766581856951, 0.7722103912622392, -0.8101170780304826, 0.7157892149237518, 0.562089347250711},
    {0.5322770940163609, 2.4104832450370863, -0.6878564097373031, -0.7039424352001266, 0.5691896693432649, -0.2641587241716373, 1.9449434699585426, 0.24357532682964195, 0.3132029113094717, 0.40979563758471, 0.5717394530550943, -0.118749199914263, 1.649403536323715, 0.11832241773520519, -1.0870724081150127, 1.4458667032686812},
    {1.5769323107915332, 3.520554043544784, 0.3886156205701148, 0.14780993097040718, 0.4799841288539789, 0.6429766983744217, 2.5273390886291858, 0.1608206438900476, 1.6767227438932228, -0.024395523955296202, 1.846497795965472, -0.18352018716618035, 0.6140738676246422, 2.284013656351893, -1.2338685466070074, 0.7519873033347729},
    {3.054218140153061, 3.2704925347786666, 3.4808178914570846, -1.1247491281434252, 0.44714219725582083, 0.7302821816881745, 2.1879283165656696, -0.47624073320262905, 2.3481534991303437, -0.48138510278386987, 2.6785297553324554, 1.5082357874028285, -0.60547115531883, 1.8653472584825708, -0.23400002643490628, 1.6633138137218322}
};

static const float b3[16] = {2.094144520522276, 2.024535678227948, 2.1235869655584385, -0.29496417400823427, -0.3758188788942954, -0.013717641112534894, 1.4616396503088396, -0.011277670274106552, 1.719619181016098, -0.1174377871350128, 1.492131547518326, -0.19187969168624458, -0.22786062245367067, 1.1840914850137854, -0.05317052339785576, 0.738574368014746};

static const float w4[16][12] = {
    {-1.8710341207411882, -1.3150400030260663, -2.2100329189171664, -2.559295705288899, -2.379632322479329, -1.391953938110168, -2.8427263028144596, -1.7303445866597535, -2.1688553816645024, -0.9984734093708947, -2.002948240226139, -1.237234978021987},
    {-2.4946197284547, -2.1086237103145598, -0.9303812071927984, -1.4863636850718707, -1.9296548958257538, -1.1967956783828622, -2.596715071631862, -1.5042751677789536, -1.2142807096942292, -1.8766408885841332, -0.3757365610657967, -0.7680491883919054},
    {-3.2021691505834573, -2.4445352599670005, -1.4967871565584252, -1.9359378648319057, -0.7571842721220364, -1.7183404393271067, -0.5464269841899737, -2.1992793907053825, -1.8080387676140648, -1.3490948780103675, -3.7653862340937034, -1.7719654504082134},
    {1.017352600370272, -1.2032711508034808, -0.6672784814731235, -1.017515034011457, -1.137192645056085, -0.7757977751895369, 0.96519117597522, -0.5959182185501849, -0.5155548412978518, 2.846169609288027, 0.05863661684988657, -0.27593140031822055},
    {-0.8145391223317325, -0.6433174227094518, 0.5365160093055635, 0.07735198998819322, -0.5573320991763568, -1.9728972703866754, -0.3787449992718962, 0.2997598734089554, 1.1061794985687896, -0.6894956329684632, -0.8918254120299848, 1.2063919159497236},
    {-1.5706219560589965, -1.4597599691465346, 0.5989250214652245, 1.0553255041610998, -2.4262622456465097, -0.934650723433141, -0.018389897481022127, -0.48888449162958025, -0.35979933871704645, -1.2971514723721222, -0.8371391999064437, -1.2004674560628843},
    {-0.11731107048220686, -2.825057799240861, -0.7528160622022243, -0.6991355321452354, -1.4486657457131429, -0.3059801548673076, -1.2906206229704158, -0.6336210409286066, -0.14834104981798935, -1.6746177823185386, -2.212307435088845, -1.480468089408779},
    {0.2733916982876324, -0.10485991601618048, -0.29853974763945446, -2.1237527647148777, 0.9047841175497958, 0.39613471630583624, 1.0092383926270054, 0.2378911629777616, 0.014130944970489778, -0.04616264850660718, 1.5690285431244932, -2.370847702672836},
    {0.18963575392034404, -0.366096941103282, -2.0925997590227987, -1.51290256883457, -2.097218027320652, -1.603108763121098, -1.7844815801593261, -0.7021537567281929, -0.6043393669269954, -1.244002635113904, -0.8517597932257303, -2.4287137692190477},
    {1.5962198145720627, -0.5109205449059683, 0.8374510801720975, -1.2081930435712063, 0.17969747719106466, 0.8700690710330301, 0.8210594093442967, -1.1242238692816027, -0.3387102632400904, -0.5521724511456098, 0.3597115904353641, 2.1809169444867287},
    {-1.1125733592270197, -0.2265787854700707, -1.7498833326494734, -0.6837792174716436, 0.5911414788177767, -1.967230034753237, -1.4134178220378155, -0.7020496068639311, -1.6377842272314467, -1.4568424428146747, -1.8448912157659363, -1.952448502819286},
    {0.05151237396181606, 0.8746865675464968, -0.361234926009209, 1.0669902811631804, -0.3692423946895241, 1.703831559447287, -0.7120868197234237, -0.004806558572623052, 1.3550712052232785, 1.6222319234402423, -0.275288670535461, -0.34453487591000265},
    {-0.6393774844975121, 0.23809146025858427, -1.0714436777605256, -0.48612504443898413, -1.6002007231435211, 0.7597411454231533, -0.5268423431383832, 0.3355010422256168, 0.5278993709457624, 2.1407390852092463, -0.304238508622006, 1.0258816458066702},
    {-0.7730706925187883, -0.4761578834338294, -1.4346295247114003, -0.359103336815298, -1.635899489929043, -1.4651430702476642, 0.080570775721205, -1.9594220489028908, -2.4570909799439438, -1.105118870592869, -0.04013474514034763, -2.3944603907647544},
    {0.43873516402205787, 0.7011572449325061, -0.5184184006569663, 0.6650958739796152, 0.5221939884342245, 0.27102725362972624, 0.4348477475348509, -2.4668731719929875, -0.7917262618433862, -0.14817574003629141, -1.0325715099007065, -0.7917843350358256},
    {-0.011412369305315329, -1.7149526920539169, -0.8130153183643136, -2.7237387711674175, -1.7759940073582818, -1.7491623474081797, -0.5008606745016566, -2.154801521915129, -1.0463329909308139, -2.1343165355628755, 0.8803865741773895, 1.4178770010766852}
};

static const float b4[12] = {-0.45557403460255663, -1.0166874489913416, -0.8530084559705925, -0.936503202033765, -0.605654963623099, -0.7721017959112875, -0.7496207741545743, -0.8205036188878098, -0.8002886760206621, -0.8971175776634442, -0.5427610942775983, -0.9173381710657642};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
