#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.4865175990554307, -1.9953294914663011, -3.466410468659176, -0.5901991463513672, -0.7215647764317153, -2.6393292922025857, -3.1197797049351985, 0.18644773392159877, -2.2710085829584847, -1.0170428873053232, 1.961561396209166, 0.3526001871238983, -2.368334139090689, -2.1478395875462217, -4.424588380501513, -1.1115045937086316, 1.3151393087871082, 2.1991515309344254, -1.8620457579858225, -2.032300243003377, -4.482624205312377, -2.964819856222993, -1.1783085779149498, -1.6680457132533444, -2.705540927007412, 0.13932922474651907, -0.8150004589304066, -1.3960550020292115, -2.2785200528823966, -0.6255230176935369, -2.9113419398076474, -2.1785544840188797},
    {0.08411666652415697, 1.6076460862170496, -0.2815046888874577, 2.701971759089076, -3.15670105028399, 2.709274275431562, 2.558261231684252, -0.6725180678648944, 0.08885754497300315, 1.9157376218790192, -0.7345432294658949, -0.7182736541804271, 1.9461570859471689, -3.3439830389505873, 2.0151957118098234, 0.5928947819687806, -0.3161388068595867, -2.2237739898807516, -0.2846116899662386, -0.24497354714857014, 1.5959470465785477, -1.4285033717281335, -1.0185400828398896, 2.557665205442697, 2.1221310926997394, -4.53355222832078, -1.7032436496225618, 1.3527919206038483, 0.23550531881632072, 1.0890591184332612, -0.8444367408850124, 0.006369560783813666},
    {1.145108503014997, 1.277581712024065, 1.1581445909476942, 0.7205256266054924, 0.12329153176051556, 2.3565656577446714, 0.5418513476171154, -3.811148064475716, 0.4827102131968619, -1.2252136545269827, -1.037331075581484, -2.1200474143932757, -0.2798652757544876, 1.0402478525767733, 0.1557303842079107, -0.4541507552629018, 2.1926233227417455, -0.834208721722327, -1.0825448142326153, -1.7803058259230828, 1.8819004529477779, 0.53506247881559, -2.3762816182348034, -1.879943146596048, 1.9925203155716096, -0.8288622261398813, -0.7762467540477987, -0.37975961171454803, 0.8464896260591275, 0.9059518081839354, -0.3004009916213084, 1.265261393692293},
    {0.5888466693105455, 1.4515820227481593, -1.1793749667834408, -0.8390810817514043, 3.0928450807223102, 1.0556875145846916, 2.4417487251406476, -2.3969040268319186, 1.9396280221766564, -0.8912245002690901, -1.516016173854692, -0.9335769209648342, 0.27483690153731904, 3.0891612611641657, 0.464000555751301, 3.2825298659127786, 0.8844413777501567, 1.178645686875634, -0.642719730609404, -0.9844836069539596, 0.07923504353017319, -0.5697334189294889, -1.4413783662951751, -1.512807095916105, 1.5923243560480382, -1.7297619850024533, -0.7372817467752597, 0.3570488599899592, 0.8133568627726244, -0.5489294813976819, 2.0421053979972514, 2.3158036079737947},
    {3.2119894005991196, 2.9335860398064453, 2.4433663836393196, 2.0745518707023307, 2.4805312207964216, 0.9849003621157206, -0.0033602780666274266, -0.811431991963676, 3.7341176643117358, 1.144983757974833, -1.3730384292684996, 1.6341205377079753, 3.499570262164043, 4.7480359189373695, 1.4736638973058198, 2.4854444318782276, 1.986654609846251, -0.9163803209562421, 4.930363775320864, 1.0910834996258088, -1.3449106423898651, 2.0076117611230937, -0.5366442126402831, 1.5615949351763116, 4.361121546996228, -1.7923268460815918, -0.3243018295962441, -1.571422475872857, 3.8054366267344815, 0.6102806830160621, 0.03587053850921822, 1.526415148488546},
    {2.980144632439529, 0.7471020159820407, 3.7943222061316337, 3.404038868768597, 2.2556147591474995, 2.067218814994452, 1.8003410355898926, -3.605658660085547, 4.259545669784653, -1.3841643891013753, -2.0659211481309465, 2.0886551614261126, -0.3689217251017964, 5.066051866524116, 2.581702025114331, 1.951764988142391, -0.10779242441306584, -1.3958178786908892, 4.715049564569214, 0.7124694126275345, 0.5863376022785907, 1.2515697671814316, 1.3403427551090863, 0.6459196431685661, 3.398858875754498, 1.4067324642137415, 0.33665695378158117, -0.4140971025527854, 3.250623620837285, -1.07810447103846, 0.47775966864822045, 1.301555290120077},
    {2.8109618564457755, 2.8068181019827247, 2.8257060305965935, 1.2031303898247825, 3.234089929454226, 2.574069356094979, 0.9032963341776121, 0.5470578738814146, 3.9694366735592204, -0.08746130141836025, 0.6797429979177146, 1.6458832857314056, 1.750899083867712, 6.303587201167251, 3.406845142297408, 0.2066253491858013, 2.0894357557746703, -2.580068256990979, 5.255420371764507, -1.5876018537208068, 0.7922488834076088, 1.520985762428013, 0.9991505243956292, -0.0057745406593674225, 2.0141359361753506, 2.394756615938695, -0.14148948938314126, -1.0629088212070579, 3.5310378371595705, 0.13516668019987993, 1.5317770743097794, 0.11402264013958696},
    {-0.586925787308688, 2.758442493550133, 0.7708960394240897, 1.0870508735045992, -1.3332089768212636, 0.4655864764531973, 0.8355547217236226, 2.6478955907075212, 0.6338803509032908, 0.5859170003713057, -2.0268566761906617, -0.8730736278095578, 0.2933459130074875, 1.135798377020974, 0.5504491624457992, 1.5987747991633559, 1.4577739451879017, -2.848609696778692, 0.7381415425646515, 0.4590045700782621, -0.6647995138413995, -0.08572370010395881, 0.19483641346796024, -1.7990869290711902, 2.651415753692149, -1.1627027945428035, -0.6364138102449938, -2.0640101303439247, 2.8476193911240117, -0.10161860017669767, -0.3349164037860892, 0.7539303483162874},
    {2.06130710761381, 0.06168567293224531, 1.5603446807664865, 0.8153982430523513, 2.590774880044556, 2.295824128273008, 2.8773849916108474, 1.3829892344270305, 2.8540522270393587, -0.023268636525059595, -1.4876069146767443, 0.31067311565754474, -1.1999908788500053, 1.1641048569871788, 4.146676240305136, 3.0402928539598855, 1.9547254422804703, -2.3043538568547586, 0.9519821267144459, 0.018419966054604203, 4.018285214484874, -0.2310455168525905, 0.032941431231666714, 0.29156353678153873, 1.2925510575538606, -4.040813794212579, -1.115276289906944, 1.506938557704891, 2.0525441034019027, 1.8682366627545042, -1.9177849110950629, 0.23012546125356115},
    {-0.7366139917539097, -2.062692428656301, 0.45833789301141736, 1.1006565817333915, -1.7492817653867216, 0.57434982404548, 0.2353959975752885, -0.6879639543809543, -1.4123877020599076, -0.3480273289788169, 0.0010537598576116432, 1.706631561116269, -2.772525126204731, -2.2182209693380566, 1.4406673632246545, 1.3577200395922164, 0.9912157047274338, -0.1657591434339478, -1.3666024327831638, -1.7465959736569163, -0.23397725591185994, -0.7402834461162336, 1.0687286841626207, 0.2568099144759518, 0.26797026061031626, -1.0622603466252638, -1.0693325626036028, 3.0452868663745787, -2.1307936796672813, 2.9006906672104344, -3.4261419618745172, -1.2411025802201663},
    {1.1594376824410917, -1.15316115571054, 0.9213081901535443, 1.2270377441773082, 0.794912702674016, 0.3766009806698414, -0.6782112827378639, -2.7572868054394926, -1.364744068604004, -0.08331003687914167, 2.733444886311227, 1.4125016257571048, -2.274804725709094, -1.8196073504949266, 1.8115509570516544, -0.4194717720619884, -0.5005067713372289, 0.11910337474024403, 0.11258533735834476, -2.4909084467579694, -0.9996903237599909, -0.6917379998517668, 0.0513508622275291, -0.30404610353512923, 2.1163714934396003, 0.6149433293718882, -0.30814559835469607, -0.17985111669410953, 0.8969250960342586, -0.6824035048152064, 1.6522749100291199, 0.9061760853066501},
    {-2.3723897228555133, -4.227030671715537, -0.14345442581294815, -0.9187862631950064, 0.11284079167398034, -0.7997475542499628, 1.4943017714167683, 0.8725654131544058, -0.8729512954760319, 2.0423900489685, 0.013854722721296215, 0.7155401772389638, -1.6881688715778946, -0.478647276122583, -2.1996024885416072, -2.0380934292587836, 1.1289770975489506, -0.4213639655031999, -0.9230932878727381, 1.50945342691401, 0.502199171911227, -1.1507154800845403, -1.2832073796163908, 1.3335279331190029, -1.1888407717916325, 0.06945979888885538, -1.5917087791742133, 0.15255302716799474, -1.06041675595332, 0.6969208686528174, 2.5641862486140132, -0.47331999517219},
    {1.134736132579946, 1.7920751709066283, 0.7778858880101577, 0.4051156634846393, 0.35374877767700724, -0.12258184161776878, -0.6117647717939186, -0.8480175926582152, -0.7668522394789022, 0.00466691522096516, 0.9717111596810394, 1.1975726137265648, -0.5906064883549297, -0.955984670263295, -0.5874426062317204, -1.4637416127687388, -0.6609421591945224, -2.658836458745058, 0.902200514601623, 0.16338491031594451, -0.9152274264618525, -0.19992571712570073, -0.154102423575241, 0.10924180520243702, -0.16264970044166877, 0.8258274570731808, -2.5359335060970403, 1.808215020397999, -2.8538021658533235, 2.335181612722819, 0.5749088338933707, -1.3814399503812307},
    {1.4897790324869493, -0.7768163943267696, 0.3287680532697536, 1.1293936515627363, 2.123418531615505, 2.3036951846000506, 0.5770973224139329, -2.933165169901815, 1.0896850583133644, 0.6953585852680846, -1.7412655298328854, 1.6459902452974502, -0.11729823184482087, 1.5142226794370468, 0.7748200722556301, 1.2341154157301075, -1.0214057736474231, 1.5709654670765663, 0.03779300150491667, -2.7411590437921163, 0.9727914068604409, -2.51832978837345, 2.077876111542904, 1.9521584213916818, 0.003934801014971433, 2.577315785500714, -1.7187758196807459, 0.9824661797090946, 0.7074960061233045, -1.262179824401101, 2.9285574239185035, 0.25993306356330187},
    {-1.4970361311957507, -2.1613079194566107, 1.1657672113512256, -0.5808717495620286, -0.0059966852233398465, 2.792128200017115, -0.007604602925808858, -1.495815498804678, 1.761927134474068, -2.181141128920307, -0.3483189528395109, -0.38374261499518103, 1.1697247437443192, 0.667895851179075, -0.7950028246285761, -0.32348752438916945, 0.2993113807241256, 0.7585430925016429, 1.0553734679650186, -2.9359989396356534, 1.2226611600999364, -0.7617852532983299, -0.49595213048614584, 2.0238029149227073, -0.27194310169048286, 2.573574304318486, -2.214926585923291, 0.6719881462978391, 0.14381172914707743, -1.7399086404723125, -1.200539485572322, -1.3236956956853665},
    {-1.3852482098831576, -0.08376703439468144, 2.120155846746446, -0.188462352927713, -1.183714155527962, 0.40998442312152894, 1.0808918689533042, -1.7990127257721624, 1.6960302006224566, -0.236731788132855, 2.1264148199822483, 0.4686878920461578, -1.680100844253552, -1.696892849949468, -0.5356011251120455, -0.8056954631854732, -0.7991500761606141, 1.7954162589426583, -2.2299557677887143, 3.016363400789705, 1.5972919295678591, 0.4593604936614854, 0.9873542419678922, 1.847259011573408, 1.2799510807317598, 0.21501438989227656, -1.3952867480581996, 3.977859094412211, 0.46423667911936173, -0.9750106729275284, 0.14493241451289676, -1.0445399603828813},
    {-1.660540430892718, -1.4168526149456366, 1.8508355170060706, 1.4417500608884224, 2.1272151262185623, 2.942022516128157, 2.4304258508654066, -0.5431358606788504, 1.1172666150084358, 0.6960134325308607, 1.3100302335644018, 3.2897680358448134, 1.0455626182091138, 4.309298201667378, 0.6991772028903946, 1.3197130816091922, -1.4730346614243772, 2.391387405281907, 2.21598870743692, -1.2906531590388846, 0.24006396978564928, 2.810471796120236, 1.6682482325079926, 2.183340663675565, -0.09004346599178881, 4.298309758362642, 0.8692214288186009, 1.1512932925263166, 1.8868247985523485, -0.7533908617546863, 1.4357307273872684, -1.0268556709135992},
    {-0.22315600095332166, -0.8762607228549951, 2.530317268919679, 0.03889570528262348, -0.7009579098780032, 1.3080259929809204, 3.2373468459743227, -3.2873849298866524, 0.7665924785549971, 0.38916978372265165, -2.85506748815414, 4.674454381189509, 0.22984331687379111, 2.0222940710968813, -0.8479882319525971, 0.47698214231559993, -4.079031513692693, 2.229832281217058, 0.0017753826957425697, -0.48399911408082874, 2.1412778032372373, 2.533477280214407, 1.297619048199771, -0.24181493778440258, 1.270853860391639, 3.488380147411806, -2.1437885730880426, 1.5846084788979438, 1.1368899469140816, 0.09695592373460335, 1.880607812885743, -1.2782521706568746},
    {1.2878658393565123, 1.4271272086436642, 0.30359420741709947, -0.531548865450065, 0.759969693496453, -3.0992561948076287, 2.525010972788264, 1.3215364081098242, 2.3779533919596916, -2.5790757318368724, -0.06122806770583862, 0.8526239541325527, 1.608515940233373, 1.6526146387399456, -1.5978941140325469, 2.0193506729423025, 1.5381033362410321, 0.848608030920254, 0.2978594973475982, 0.5078096353417658, 0.8982783856307587, -0.9928870033905042, 1.9973038832736194, 1.3090710031754984, 0.935614678506364, 1.9017443304561412, 1.291937519566885, 2.927538776621804, 0.15925311330356176, -1.215394803209772, 0.7695586911224387, 1.4641188469366342},
    {-0.7962056049909896, -1.3301075021100168, 1.4102566664875815, -0.3191546283583598, 1.3483090824946324, -0.6265555139410756, -1.104800399628227, 0.9811225659381542, 0.2563069195043152, -1.3602182707037669, -0.4188076929030434, -2.3525873401859188, -0.11000099536028854, 0.28448007483142307, -2.1971291309460756, -0.0811929691156391, -1.00530461992678, 0.8210138723857195, -1.8575094725094725, -1.5445790526039633, 1.8975912601281226, -0.6229978826245693, 0.7775180826310695, -0.07078914042041703, -0.7170590616552127, 1.795547011732957, -1.3525969665270667, -0.7117033892526392, 0.5799013298121476, 0.5929384030515601, -2.5823153689118845, -2.149825630200385},
    {-0.4991131091620801, -0.02015034598701582, -0.5869115180033618, -2.8056394279097083, 0.9128570876936677, -3.3749446594764563, -0.9801604885407617, -1.1524446236251704, -1.3151920996868984, 0.13772845853213564, 0.7406037379053673, 1.1381353661668023, 1.60839178296962, 1.0689986692230724, -2.2125335584120136, -1.9563674773180746, -1.4372362060505735, 1.2873431845012224, 0.12352826016545855, -1.7842876858531518, -0.3441917567167792, 2.353769063832867, -1.029791402536405, -0.26883764313658365, -3.858481264210396, 1.6307918570358741, 1.0609681284931545, -2.2040298582510154, 0.8276366051281826, -3.0510043920012344, 1.8924315090545536, 0.9129132161829682},
    {-1.8357717071369564, -1.4261415204731052, -1.5771754380864877, -0.6865242401730253, 0.5488050834742464, 0.04399643811231907, -2.77758552111867, -0.09562202723269235, -0.7308696448011912, -1.7325122108570714, -0.9352110361060996, 2.9162804778187903, 0.4563308395136461, 1.269765501870324, -0.735441286206978, -1.2946249739840345, -2.2868311130492796, 1.2170850235571558, -2.2032064401761264, -3.488987300310849, 1.6077505172370594, 1.1648965757696599, 0.994424941319673, -2.03891085100454, -0.21043481942580886, 2.4708691984542073, 0.6538386480132494, -4.106054540175104, -0.6922874719876674, -0.9416064028025586, 1.7266275398693864, -1.1867791635511917},
    {-0.7151346574435691, -0.7249432817648734, 0.004816933162111588, -0.025262714394750148, -2.1809455878867214, 0.2467744029852505, -1.341295251955986, -0.5144830719064326, -1.8736465703955472, 2.406108767401307, -1.4298310625378077, -2.345591993416822, 2.0813306444191944, 0.5584587870558289, -0.9044270332209909, -1.2781324606731612, -1.514138050731199, -0.04743118639642402, -0.4729996596121935, -1.9830317439631309, -0.4135257115729447, 0.4624154808508697, 1.382430147591366, -1.7755860846197018, -0.7908098148204115, 0.41729910124226055, 1.4956072184582907, -0.6880809871044975, -0.6242246563630686, -2.1229153968304337, 0.18697763630265213, 1.3361467065771824},
    {-2.0858057111047685, -0.34466235775404225, -2.986909360942609, 0.3086463049928047, -0.7012935377862658, -1.804131561578229, -1.3010192998845913, -0.09573727334667513, -1.9817323286742192, 2.376833120295866, -0.25830596757563035, -2.276275390743382, 0.3554911575298289, -0.6039663685216791, 1.4432425330128715, 0.09108651713391389, -2.5083401728440244, 0.00510951344550388, -1.456567968258258, -1.5357147415713057, -3.121000935614588, 0.5987711085145485, 1.1253895731843828, -2.4406528345670706, 1.7206090315420632, 0.08145023192231034, 1.6394541810964316, -3.7275494657950534, 0.5357298530715756, -2.020337852241798, 0.6673229942881969, -0.9173574581012858},
    {-2.087439809776632, -0.9690378593241125, -0.4689142611517798, -0.8532931617534262, 3.102272508497954, -1.5572374103156184, -0.6805912673024369, -1.9579270818245467, -1.4695194282799329, 2.2842018581367425, -0.906399941454996, 0.9707779094129417, 0.682302692667941, -0.12856806854425337, 0.9384195632453094, 0.725246129039809, -1.7477287997162199, 1.9135958885596518, 1.2617283399392754, -1.9614217498437503, -0.5802132379482732, -1.237078243031738, 0.15825739733753977, -0.3099219164071428, -2.09275418310859, 1.4773631417259152, 1.0027138019208863, 0.8217835261798453, 2.5656023545788864, -2.357921546294296, 3.516101966087415, 0.04807777940073391},
    {-1.0503320921438755, -2.4713587074492342, -0.8405786837086441, -1.009355841031102, 0.03432047254086473, -3.6634455992212946, -1.908579188965411, 1.0396495327714068, -3.6490353523586014, 1.1003510044748015, -0.7604424862661714, -4.391969330401221, 1.3580765332553149, -1.4799444738652094, -0.8847285761386167, -0.6195580873744818, -1.5385638587369959, 1.5852395855642418, 1.395732297493672, -1.3258427847197078, -1.4721444186610109, 0.9950324289937243, 0.930011164625095, -0.42754710298353993, -2.3369540437979714, -1.3980791253861424, 3.3067764821436345, -3.2073889857744153, 1.8563564996308752, -0.1816463181579152, 1.3068642908115788, -1.4395230673071113},
    {-2.0001217728768, -1.0668215587395409, -3.573698207292468, -3.15540299070869, -0.2821315305698081, -3.838439821721359, -2.4758060105295434, 0.20859766413424086, -2.206986549964251, 0.01321581102838461, 2.0066069275476446, -1.3351922110779082, 0.36606303917140887, -0.9676466472601047, -0.8481652437210084, -3.1494873075300576, -2.6715757800101683, 1.0595445236033847, -1.6425579034758453, -2.5768981073120742, -2.323569615674765, -1.196344628038814, 2.100252798056673, -1.081650617657078, -2.52520678748948, 0.7362530393024664, 3.376515885088331, -0.9371745432604714, -1.9981755331541964, -0.5018250808957535, 0.5267255649408776, -1.3780493835260603},
    {-0.8585345491517318, 0.20704585926328278, -2.5478315332142127, -0.032738964253002635, 0.29649829940661676, -1.6717512875232936, -2.192242365357588, 1.3860471591381944, -1.6624246714375512, 0.22167191180169396, -0.4999970816543687, -1.9454554491352984, 0.954167351851412, -0.4128882433355882, 1.8702738813703137, -1.2749141355114129, -1.059426725340569, -1.083103128041326, 0.9677214253313032, -1.5273017799999853, -1.8840977349779582, -2.4495904087813574, 1.6074844466774416, -1.5333432269774916, 0.9337304306783978, -1.4404722945178898, 0.027124592538479084, -1.9426856523021994, 1.5828112662592733, -2.2115768848617328, -0.3848235689953798, 2.6599169175800443},
    {-1.7666693401217395, -1.1331441309568375, -0.46287258450965985, 1.3339323991291692, 2.4202376046307705, -2.396297359596259, -0.6268192907036149, -1.730453711482222, -1.307842774903148, -2.024707810312626, -0.8765397220819616, 0.2526957868069613, 2.166587438732511, 0.2449496383459502, 0.027197528445715654, -0.20374520654924408, -3.0217161314239336, 1.1333574039385788, 3.16661493911198, 0.7034032935726952, -1.8385686650869442, -0.49894455389726283, -0.23280127567316822, -0.49951079674111715, -0.014911204814057201, 0.3935587130442297, 0.3463045881389453, -3.2749988534673684, 0.647705068065688, -3.35487386104673, 1.6079818599645175, 0.49378139047033376},
    {2.3437517627878655, -1.27884172098516, 2.679079150165597, -2.1215937261092788, 2.1608854632412764, -0.7436990379181082, 1.337382143241871, 2.2033873716498493, -0.016269083802238286, -1.1913897911611444, 2.3079454828512023, 0.3910039688141523, 2.3493273077695207, 1.4277329478403933, -1.3254624802139412, 1.552194166936004, -0.5721575150786914, 2.204262324386864, 0.7900464663420322, -0.9132040886570072, -0.22590327482507433, -0.3797010826574652, 1.6366886424709353, 1.6083506639162382, -1.017163848748943, 1.9850351555902692, 0.36741859433671203, -0.6331919854973602, 0.7843365846751916, 0.026713943029850893, 2.3916104786520007, 1.4750744431593699},
    {-4.282175998243367, -2.3994858138872477, -0.656197345794115, -3.1565176000243182, -1.8869615374054256, -4.218843361847268, -5.485539676564381, -1.9612819137782922, -4.730744444392396, -3.0396576517171536, -0.7630495758210959, -0.7414630809489042, -5.649068856417403, -3.3921191151511967, -4.979411001138205, -0.16196372041322843, -1.7299200083216506, 2.4188143058352884, -1.2004823258506332, -3.5220670360226984, -2.5897374876346135, -4.662948799255752, 0.398395837224851, -3.979940579223135, -2.0064407399862727, -2.7360808384115414, 1.1672701834395696, -2.9882776464637155, -2.2104413802105887, -3.682948267637022, -0.6513970383985145, -1.4321508276846844},
    {-2.152907891823786, -5.170222468572086, -3.2536062663563508, -5.2537059828434876, -0.5558781406581718, -1.2218020154064109, -2.693750886288201, -2.4354569495277403, -3.799747357632584, -0.9242744166709749, -1.4666128661240625, 1.301677151849823, -3.5429451701612686, -3.074427428092296, -2.8605775020566546, -0.9098789937599391, -0.19627915719775396, -0.24289735675844348, -2.7301372688844845, -1.074647721907965, -3.749146632152261, -4.2543803478864115, -1.0957804270963523, -1.9352738274260677, -1.4620409919750077, -2.365929242840906, -0.40342730810878236, -2.241441948114243, -0.18397107789276265, -4.161610220836584, -3.0145010708209004, -2.010377187888681},
    {-1.5012126754126707, -0.5728871643730158, -1.4775491606924622, -2.2320631833537323, -2.6038507178743373, -2.0067083515798276, -2.021506422706534, -2.7018491029657237, -3.345231992107048, -2.0636674249593585, -1.3325753240194238, 0.6651852413110343, -0.7095143060079341, -2.375300255025806, -2.2100024181244025, -3.3450805695282995, 0.07038721963445572, -2.1935539045911696, -0.13397969504617382, -0.4168193252040296, -1.3492604180968926, -5.208444525642103, 0.09254196827688844, -1.8844135817036483, -1.5185412632364605, 1.5977935403295276, -4.838962456745469, 0.8802314947991493, -0.6198137391483495, -2.7851728691612494, -2.6902827747001443, -0.8662300222920354},
    {-1.3572954719918378, -2.8955255707599457, -2.546105154622185, -3.116028104438644, -1.5010122667647192, 0.7567534945163382, -1.055838614970831, 0.3198976984365628, -0.2752011147456544, -1.7070191663157808, 0.7341291972294772, 2.8522233424482866, -2.05719685235692, -2.752575733524496, 0.34544936146149174, -0.4710971680700888, 1.008894153979626, -1.29595985955293, -0.1718425880065021, -0.36394803981793444, -1.7640199234109337, -1.720730428327697, -2.0665752048005137, -2.6421842423338155, -3.270843510537647, 0.883235376821309, -1.5089366415270922, 0.11425843761643864, 0.10612708524763517, -1.9768974511191224, -1.636611409555568, -1.279315889620082},
    {2.2093097517920848, -0.7132850222335192, 1.9007486252583288, -0.8481920131536903, 0.7784516025253299, -1.0980115514578392, -1.0326215120563946, -3.3010090116832096, -4.395922926128249, -0.4860647492455014, -0.1066741392255576, -0.47107240431376307, -3.2234026716100637, 0.8543853710737115, -2.005261385968458, -1.0447676920767925, 3.2338402264982853, 4.2985385621041985, -2.482954115608611, -1.1617092137605527, -2.8183417575976795, -1.234627861609949, 0.3943325240987073, -2.245044435451364, -2.468687773332573, -1.824387158848836, 1.4392697678738744, -0.34619327827228724, -1.1181783952230373, -2.167360450031979, -1.1769678148871996, -2.567672410960369},
    {0.07316396195136328, 0.5554960256944168, -0.6493106210628468, -0.1626285223815879, 2.3046934765937515, -1.8517978219257643, 1.208499089692145, 0.015294881005395616, -1.8067321219439143, 2.6230562371594806, -0.2787173921449672, 0.40542807161004385, -0.23177665364115238, -2.882544333031263, -1.3930361137711795, -0.20491789439086938, 0.8761232885145043, -0.5954344879612071, 2.3098421978188037, 0.4139343640216219, -0.163875379557327, -1.7956338610328388, -0.8342315327257698, -0.30994960098598207, -2.6629544817913544, -1.1040823884890965, -1.2252139704660947, -1.8948370638043495, -1.9083947494309836, 0.001495940722184847, -0.2842012755639834, -1.470512196902044},
    {0.11106346395949633, -0.8578500217836541, -1.0837274147580647, 1.1987009571800273, -0.4940857963659675, -1.0022523075619183, -1.2258648259558846, 1.9292360893770504, -0.06520603911298242, 2.1919335174752343, 2.6540474757445836, -0.21297899337583423, -0.36926239228168256, -0.40837468968022833, -0.7759704682252945, -1.447091969331503, 0.5242644778025576, 1.4977251215657543, 0.49785496085486974, 0.960872160448531, 0.8990068995401966, -1.3207026032346456, -0.6678252574180604, 0.31336314955917427, -0.05570281267496408, -0.2766720677460119, 2.5041488463279884, 1.7296120630892535, -1.474385474293122, -2.3200717066688425, -1.8718666701942193, -1.6522818989444599},
    {-1.9160846658168675, -0.69539429708164, 0.1679331761487606, -0.2235785660517918, 2.0852715727276165, -0.9605947399403993, -2.446308647189084, 2.6811582684083124, -0.8405812741612615, -2.284382592803718, 3.5492904818716773, 1.0659837123802873, 1.664238429868867, 0.32588708775287584, -1.8834927550880396, 0.30148699998582623, -0.5168907587830096, 1.2217556698181078, -0.6066089261638715, 0.07363050618162804, -1.4813278422707614, -0.36350429263018497, -2.0009703677696233, -0.48053289178670144, -0.07085321044986674, -1.565765066914173, 0.43631478816640684, -1.5374465156750416, -0.7128645229183714, -1.863129456477076, -1.7976713299241234, -0.2734044847118252},
    {-2.8026649539182706, -0.5843260160405634, -0.32451711463522565, -3.29980154775761, 0.1675065885943083, -2.244774237165637, -0.06867463582550673, -0.9381051639088889, -0.9945589761446506, 0.22416503873241997, 1.6016995624901442, -0.565172673902802, 0.19005722010290396, 1.839985949879917, -0.08751134328594988, -1.3898906420409347, -0.9811854264802348, 1.9983017863905028, 0.03411777888311962, -0.6256635096532148, 0.7189891735373641, -1.2848501808378217, -0.562105228250617, 1.6757093067556272, 0.4577835643587907, 0.8077459171683288, 0.8295151563713321, 0.8454884710511167, -1.05459363498606, -2.378898032529132, 1.0663131528513652, -0.3116692742660968},
    {-0.5248357343656839, -2.041518033787618, -0.5403466785192748, -3.9844591973605596, 0.025195952475439744, -0.17990556388540369, -0.6070987660120059, 0.08627885967806051, -1.2223339094243884, -1.5647862898333629, 1.7757397527614551, 0.7279853207718661, -1.152789762386623, -2.679340108725919, -0.45626858134693116, -0.9448900388476209, -1.8196445431675157, 1.3019428546707832, -0.7847988716848018, -0.06706399511722412, -0.33458806696611004, 0.1479123153870261, 0.3776895570629152, -0.9201103755708769, -1.0614709194076017, 0.8736343760445279, 1.8042437334923087, -0.6907507544327129, -0.2783928111267667, -0.41534355104194237, 1.4192193635000656, -0.392576288634509},
    {1.7499246956978678, -3.5935373506766264, 0.6091808526292753, -2.0995878061984645, -0.09185094531622177, -1.797601737120649, -0.2235195422008445, -0.3254867630156555, -0.5178640435195695, 0.9761873825843209, -2.30807832718521, 0.8840219400090555, -2.7918746172050275, -1.4145116872438124, 0.3776681822460419, 0.38739075125310035, -0.5633013376320918, 1.687733908343537, 0.8383832902913715, 2.2771144010015263, -0.9942422081963841, 0.42403116271263624, 0.23584547880012047, 0.7956481652051719, -0.0364040838993793, 0.9663124038829946, -0.263431014454735, 0.07168106694840501, 0.08815663920532144, -0.45430095035051804, 0.9240784701025893, -0.36895150793619563},
    {-0.7596930004685714, -2.058456700771276, 0.2891447237286682, 0.8421570322883355, -1.409388635232772, -0.739505884270279, 0.4237536822757748, 2.297910095768958, -1.9779590488565808, 0.5962572336322534, 0.6091257386227695, 0.7469154678358993, -0.36362927152226904, -1.934329684487981, 0.9363101034974844, -1.1375110144647338, -1.5868409088740956, -0.45451428711766073, -0.6741887221451217, 1.085845269314963, 1.6526809448618442, 1.8462590645856238, -2.2073543470427746, -3.4382977717008525, -0.599715400221291, -1.0256879063961848, 0.832007820107773, 1.2930463536610757, -1.2440461959242552, 1.3262152954539983, -1.3725823369630754, 1.6444019653197717},
    {0.47500627059217193, -0.17061082843762826, 0.4456820991321034, 1.116460548903898, -0.06858876907883746, -1.7706501250280846, -1.6706901950018813, -1.0735496205486221, -1.5304908729889386, -2.218679294837001, 3.53514767268619, 0.47670644206344975, -0.6471613268511952, -0.5096324535608985, -0.84394278864181, 1.3335215625590584, -0.11362235547175537, -0.9645261959455405, -1.0284651398783322, 0.49792639352568263, -0.2860709641274091, -0.8360002402926241, -1.3973135904624698, -1.2315210732094435, -0.014667025912848932, 1.1090349028361672, -0.056317060218142694, 0.6372371652708082, 0.4342904760688871, -0.8296589095274228, 0.7968238298433634, 1.9669271251678113},
    {0.6551637490462215, -0.23025116855260777, 0.34167032924442986, -0.6988572833116244, -1.1569511100411702, 1.5252639607275464, -1.2904210697369805, -1.0764538350971367, -0.08188950471449102, -1.5304265898512457, -1.8239019436068278, 0.542685505307791, -1.2329024424062374, 0.03517184380235588, 3.051190616701392, 4.276689665572462, -1.0430915154995515, 0.9461558108402878, -1.4519232998252394, -1.3706772386575357, -2.9645109164883734, 0.6032049360894699, -0.7231856048445564, -0.15749661512403054, -0.17172132017096203, -0.0018955979953786985, -1.006409120242681, -0.8667101243128594, 0.08641466142602844, 0.8371283053112798, -1.1403859896210888, 0.9392877392779173},
    {-0.6076420605024232, 1.11925677000903, -0.7098579281940334, 0.5214167487168101, 0.763706643324261, 2.214502301989907, -0.9006967661597323, 0.6518986905798081, -2.3970136025309716, -2.0822012607203257, -1.9163353684149802, -1.9842698088537976, 0.6521837394884938, 0.662555814155278, 0.5579187025112355, 2.292724241468967, -1.2087844268639756, -0.7722299134152334, -0.7975315600010984, 3.2970466863175814, -2.9077693577875467, -1.4438078307998368, 0.5164434117879734, 0.16075706774653617, 0.6376922451713876, 0.6053818601522994, -1.182040187249584, -0.22089204964569395, -1.7778920889542935, -1.0753696788509897, -2.814894492175024, 0.6011366578704948},
    {-0.519132212890485, -1.137241898604526, -2.2014459026887936, -0.4691144851969865, -0.08070941768350995, -1.940096368971301, -0.5741723969104355, -0.43060164742078305, -1.0906098459092501, -1.729367713785332, -1.6658327249078666, -0.9642668434910932, 1.5368035184790547, 0.443450415392736, 0.8495336899130951, -0.10582202389189227, 1.8613319285977876, 0.34829168581013625, 0.6390846183404904, 1.0093844014118898, 0.5891205921037389, -0.9362366305382924, -1.9300042019302492, -1.3004793512026607, 1.5778218090868095, -0.04881940904076726, 1.713832857348554, 1.6889699395849238, 0.25376104870845456, -1.675537196035135, 1.4182821229090554, -1.0988119460820835},
    {1.3173778814787551, 1.588383516154902, -1.0365256490601984, 1.437007299451171, 0.5533704981012634, -0.4697570206989988, -1.0762933835281914, -0.5411394396492353, -0.7224723007475704, 0.32105955459701185, -2.3464725047964476, 1.487874409546591, 0.1454699731991628, 0.6871228708777974, 0.9460750016628582, -0.2206265299421561, 0.07659736674963682, -0.8867064102725513, 1.0245686344787899, 0.2162678258150158, 2.569775756251396, -2.55582824740733, -0.3283762105001205, -0.5360191228560202, 2.9113398413103377, 0.8514218780596545, 2.1249218879938194, -0.23704660467824237, 1.20105461421075, 0.14323033044754602, 0.26541077814792186, 0.7472985292013777},
    {1.976416292646855, -1.4928684762157554, 0.22740152868566868, 1.6921202674400477, -2.234133203133951, -0.7828250416956986, -0.30499418029300507, -0.9299188450838877, -1.0724857625486868, -0.8973919491741859, 1.2247908822298263, -1.115127618083015, -1.0140007672912987, 0.17275477196667532, -0.33527252573462646, -1.729645330531575, -2.2776903543681417, -1.3469849565996, -1.0068334766431934, 1.7269919396899334, -4.618877334829376, -1.3309010974670674, -3.948136199724736, -0.4016356314974234, -0.41033326736235165, -1.3601477403091013, 0.26792871735441487, 0.3274394117048402, 1.801203328921909, -0.0362547085704051, -2.0980224455676817, 0.7501620943779918},
    {1.8495018304794002, 0.1273729331671831, 0.7219412894615354, 2.09040283318536, 0.18695687230196179, 0.5166903679298916, -1.0412499651278784, -0.942584805673237, -1.3428674592665621, -0.9024596209257364, -2.2095841062121266, 1.0863670865878234, -0.6643240901060128, 1.5860914635469494, -1.6054193214297345, -0.3078110663855951, 1.6396072682555927, -1.518337319525166, -0.11345790622052383, 1.9080082162567336, -2.263072559963415, -1.1219885579836404, -1.1734257231303133, 2.201051356012197, 2.3047663194776926, -1.4310894220114325, -2.848042890746041, 2.8310070242862473, 0.5347465642589415, -1.6209003182923811, 1.708203333649282, 1.9060207225457393},
    {1.4922990763008832, 1.3120446443153824, -0.08538023499491727, 0.1577881770050488, -3.430269053415551, 1.1461798057416643, -2.4035304387845544, 0.5679791074485593, -1.8230430930293355, -0.3656824305066857, 1.6974856739141966, -0.109708384400785, -0.04133110730553343, -0.19914516215020014, 0.6695521199083871, -1.146267644646183, -0.7938378626329189, 0.9271762444510279, -5.086367095047574, -1.0135383309114472, 2.7325308226526634, 2.9802727042193426, -0.622881167776943, -0.03949127611572157, 1.2918817227953443, 0.8731723456059574, 0.5773261879080984, 1.3961611507720335, -2.3213723672790816, -1.2324413015676703, -0.48512712910105826, 0.7251618249671706},
    {1.912603426314153, 0.6871946804787361, -0.026756432853161257, -0.3787388730332343, -1.273676706911709, 1.2273191487518533, 1.6668487541420205, 0.3395334080738096, 0.29862240796761075, 3.391325343306486, 0.6194513468583243, 0.13713214235521912, 2.0080512376298816, 1.546271123129569, -1.9560356480348227, -0.9732878802739532, 2.2313196241881625, 1.6280465673304465, -1.8563457527578378, -0.020693329758451864, 0.8760709134431257, 1.0781758539719042, 1.395466876601506, 0.8020802990784126, -0.6451480926909767, -0.33017553910277264, 1.6951845612915915, -0.05241135075428005, 3.6526506245904593, -0.25160168628398166, 2.1223749988026945, 0.8902600040671418},
    {2.85543332432772, -0.8316246962320206, 2.1838492429222476, 0.9955639952832576, 2.063055505191443, 1.4080038316988077, 2.5022544711107066, 3.549138771398047, -0.4891453946034661, -0.6162179036099842, 0.9395367492058436, 1.4554907093278027, -0.9824952601000982, 1.2731448808831312, 0.18393208315708823, 0.0764949562193395, 1.5988025550996297, 0.42230406933608305, 0.5857704183819628, -1.0102871603917538, -1.060417843827321, 1.84042817498682, 0.2517100122724741, -1.8597818614186383, -0.251663042569255, 1.0264812909076966, 0.7854813633821992, -2.0601759628859297, -0.23366239980859715, -0.4862846599049932, 2.1309749409931578, 0.9741788100995219},
    {0.12010141966187095, 0.9485075546201298, 1.6758442174810182, -0.7709826013593202, -0.04879969918142408, 2.1354677944820835, 0.06606810687392564, -1.8152644836815495, 0.22432243065729968, -2.6681922279790835, -0.5245497772912503, -0.8894872570807089, -2.000919956193432, -1.2471353807972005, 0.17640896586189395, -2.484748971010774, -3.0389813458546278, -1.8385538247021593, -0.07419595522315707, -0.2765519279380853, -0.3699657470627825, 0.7602436382510153, -0.08774496795906941, -1.6707115150101346, -1.855581854585282, -1.5203821587522408, 0.38515298809903736, -1.3737439191014267, 0.004134209026775917, 2.046479971306988, 0.5183669939182142, 1.4047843352157903},
    {0.5789668948825236, -0.6404807102852896, 2.8676489771838636, -0.7687841335561298, 1.6222703933545441, -1.1811570993424556, -0.5141542466268976, 0.9645624739902546, 1.8861697235993646, 0.6142705498735943, 0.9041452308048099, -0.879884214276499, -1.430702395274352, 0.11508248177980192, 0.4123526501100014, -0.9048522524589973, -1.115911410789609, 0.5358193509440539, -1.832414688642823, -0.5454815396880873, -2.3636084431197895, -1.195216719972628, 0.8710832146009405, 2.144359395819588, 0.5109391992378289, -1.0346789325345451, 0.8948891664597907, 0.9317461872967334, -0.6620254368896447, -1.694195913327666, 0.3964342947597817, -1.9686483249345073},
    {0.016274674969493603, -1.6840376569606292, 0.5194964044075842, -1.6889833542481638, -0.34939070355664087, -0.38777462503196897, 1.975652943603357, -1.8090019576261365, 1.5114651376689336, -0.5441224791569012, 0.025206119898833024, 0.14284063321412005, 1.7672357430217183, 1.5967071314916745, -1.5665175236354671, 1.4931877647813818, 0.6428889525962918, -1.7350606129205612, -0.27822637689490654, 2.8927949421879453, 1.9086951208838348, 1.3587038257718667, -2.4537582987875868, 1.1190508742444862, 0.24291284151466444, 1.2844952246310561, 0.9381849441521503, -1.0365928840125476, -1.1269733325247766, -1.4901429913229691, -0.9296192352304361, 0.15446347054290646},
    {0.03427634528087009, 1.458176694536198, -2.2906657669466632, -1.3913218515258186, -0.008572678916556921, -0.4570982189431361, -1.2662654696876132, -1.4577691941241109, -1.2039908294852513, 0.31944782294963275, -0.04128275304471998, 0.29005209620676375, -0.9317435685386771, 1.8390077966756941, 0.9360738279111432, 0.5426408356136639, -4.690359732650908, -3.5576464923941504, 0.3070234744359141, -0.9931645371302624, -1.4947143361726654, 0.2823515879891944, 1.7232925425006156, 1.1913102663940798, 0.113636032126122, 0.6198451901392615, -0.06761874084480726, -1.2684537695198417, 2.6454679883500716, 1.9149053983924151, 0.03485821281033995, 0.7918836562398369},
    {-1.321366954124087, 2.323381645759839, -1.3470808903197686, -2.2247707042949227, 1.4634485428447133, -1.8387349521455723, 2.588309707645876, -0.4998209341102149, 2.931472256915928, 1.4432711523777746, 0.09624852678329844, 2.375399116052229, -2.5386990300775736, -0.06399227610854456, 0.7472555679148465, 0.9177517297101552, -0.022923077745129746, -0.4299852908093647, 0.3737385748113014, 0.21638328987874428, -2.3744412041005423, -2.9227269104306215, -1.7115202728738745, -1.1311001007626282, -1.2424977771742418, 2.795068895825309, -0.3951176457130151, -2.339609406139339, -0.3882528169085248, 0.31411163867623315, 2.578594480210721, -1.0085513232330516},
    {1.9351716535192056, -0.49792777944556493, 0.32398388009040907, 0.21181701248088222, 0.7379859603057316, -0.4424527722067032, 0.1444094598253158, -0.008684922632074743, -1.893030582948894, -2.2476555226835653, -2.4375295890208495, -0.00667507021864701, 1.1371082516176167, -0.030462819990288933, 1.8276096189113735, -2.587341025399453, -0.03875719367669781, 0.11049054594146275, -0.976961936005803, -2.693282764382612, 1.3246949788143076, 0.7199836315206054, -0.4957594231899197, 1.4685807766784615, -2.3726145745083977, 1.0559379747159177, 0.41020166542873565, 0.10602028192096807, 0.636036804272395, -0.7525595442549032, -1.6319944782758218, -2.5579066184386647},
    {0.4375033819489589, 2.1597187717963062, -1.3740732929943704, 0.20661707894967218, 2.1520602320722477, -0.4425162889025225, 0.17462936394104853, -2.3113873230493525, -2.3859878647313195, 0.84005576755919, -2.2394557746043833, 1.9158120707065949, -0.8819557115977478, 1.1351732806601829, 3.063134203079739, 2.8283742821755324, -1.7567853005021428, -0.3884626518860167, 1.3165464017737807, 0.4926619436439923, 1.3929948779111774, 0.8958824839663573, 0.3757698643618323, 1.952343522007273, -3.0754691482672873, 0.017435826309763792, -3.266605814866122, -0.5154073176507215, 1.4720999973436704, -0.8412260015294434, 0.1965369128531324, 0.969222355338771},
    {0.8013283519982151, -0.009927224809672426, -2.531167537920725, -1.1740346840669842, -3.2491049285605254, -1.0616594740966072, -0.6963163684428852, -1.5685489334299418, -2.3022103790204493, 1.1137296816758837, 1.2860035126914133, -1.6328290857218, 0.6960058444335457, -1.2899138442119686, -1.2325502001370046, -1.287165212031849, -1.380156083707328, -0.5038741582260962, -0.17879036477636037, 1.5566430221553345, -0.9500159759523585, 0.6117199906761199, 0.2966430832375727, -0.8982138571991993, 0.7711150157261839, -0.8198422367281692, -2.0567373430534914, -3.287356217467863, -1.154475725108064, -1.4079710091585247, 1.2122536015256709, -0.7502400826625766},
    {-0.18368435674689026, -0.03879541305789402, -1.6515669903695562, 1.7951631892838495, 0.741203805884253, 0.8528404527989557, -0.5220650664598135, 0.4456706614932952, 1.3788645921293496, 1.783161302104336, -1.6201214453511577, -0.5703924219450263, 1.4091784531435148, 2.5619675821112375, 2.835797695878457, 0.12571982511886667, 0.7453867472205795, -3.6035314546670385, 1.6962197555886656, 1.0098898967103431, 2.3889517392016657, 0.7687855655991447, -0.8324522419039517, 1.4904467461850075, 0.9084310263941844, 0.8170507948752511, 0.42520557000121517, 1.978255451992984, -0.02744161557945097, 2.99774138676096, 1.4190480462901705, 5.024979783373228},
    {1.1649777674463304, 1.302615586633018, 0.7156213777834727, -0.032877431175288886, 1.297827441581493, -0.8226869044364776, -0.2631760169546207, 0.8727871319013426, -1.2040887363573032, 0.9066341130597386, 2.2489718351002996, -2.089494796214254, 2.117779027514228, -1.695343901748866, -0.7254746276992693, -2.282690935100377, -1.329329468280266, 0.6095626404535939, 0.08856165193781178, -0.8882248307281234, -0.8044340093134235, -0.1770902214398354, 1.725371536450609, 0.6237874929718763, 0.15456555557225832, 2.3325283217867363, -0.6891286780344337, -2.434001643809768, -1.9911760689018576, -1.1641414727381245, 1.9393214765475635, -0.9221527108253449},
    {0.32347823364460415, -1.2371506829648877, -2.0779522597452313, -0.9333282656947058, -1.977595686013505, 0.38824964504404347, -0.11053159394616385, 0.7125332771267886, -1.254025069353353, -0.24355888276231683, -1.6692526994100871, -0.39997661789204414, -0.46964942348231403, 0.6099022075181497, -0.21478910142208227, -2.02986302073501, -0.6490116223596502, -0.19602774710856893, 2.211283089112412, 1.0657710537283667, -2.514738828813317, -1.511219882937048, -1.0918874091950241, 0.5604447934381945, -0.8775608267577891, 0.0052055401681702605, -1.0873548259265664, -0.2957163817132556, 0.7045114523793525, -1.636259215724113, 0.6180006695074064, 0.9989841923300958},
    {1.1986827429736635, 0.2475908214979813, 2.674275465846079, 0.14189631648889844, -0.29175767476069636, 0.6019148528530616, -0.751777469606117, 0.06826694246011783, 1.0707081354164283, -0.44234705612222475, 1.276636536129748, -0.7571210274172933, -0.2561568561931378, 0.06028630215457953, 0.12559219902400576, 0.08694432447487646, -0.34812178856905407, -1.0390009308979284, -0.43125672117553254, 2.0733841026075237, 1.4155404918333478, -0.10966233535204958, 0.2534656404947936, -0.007091427546585555, -1.9247569926967194, -0.19978025878470504, -0.6988380147056659, -1.0241621030300838, 0.7812623425306127, -1.377650339701663, 0.05781265277023278, -1.678321177119547},
    {0.4627449713910025, 0.5590664950689943, -0.7299163728029767, -1.6068163936292124, -1.2860805941782338, 0.12886424455877063, -0.5324296617697963, -1.266629003741501, 0.8257821047863961, -3.9285927807545686, 0.5023230621816426, -1.474621449121795, -2.40246311256084, -1.141895159450802, -0.26495479664352317, -2.1307219818085006, -2.272159140942906, 0.8785156220737471, -0.6813982595423117, 2.022209843328915, 1.3195725181164983, 0.21482818267612747, -2.3949388967398493, -0.7344489060120789, -0.43493479598445406, 1.3759653915880277, 0.8817031312672738, 0.9857768064812716, -0.3285896404510757, 0.1639092936833721, 0.6682735774423614, -2.1798893925055336},
    {-1.7368720945116658, -0.0736188141248773, -2.6493669458390214, -1.8193080201047875, 0.11036490525488778, -0.4479982452763937, 0.7170867242931978, 0.8087366684042764, 0.6287061529682871, -2.3232241149053596, 0.8600934144145465, -2.7541356317181545, 0.9012043516613776, -0.9247286047352384, -1.0596659366442691, 1.322796510830737, 0.31890783175846643, -2.9594189865780485, -0.5870896676963602, 1.8055514635194339, 0.15660181587963218, 1.8428641680379128, -0.4827990370494948, -0.49190409465532425, 0.7760585475580282, -0.6748711857296175, -1.4841094113523587, -2.3594223463645028, -1.8183425096880048, 0.20873043758341753, 0.418568996508352, 0.4844468516912003},
    {-1.1434114656012164, -0.9525204486997157, 1.0618233064476617, 1.386821406752798, 1.0301280706279277, 1.4673153720041296, 2.0125203887494347, 0.23166297848786985, 1.4299408976448973, -1.5652013192898186, 2.3245446461942865, -0.26713806796795825, 2.461328988265432, -3.0311892743400564, 0.13135414612524055, 0.3998808831096586, 1.85148830547546, -0.8028452985659593, 0.8194091505435682, 1.2147092311658714, 0.07830675993027778, 1.3088825925758616, 1.4308572736010376, -0.2130531892945535, 1.9805210882734499, -1.0525953130369088, 1.1297191615523379, -1.1694498246952325, -0.25534504822543136, 1.2892857589333175, -0.5420231488139614, -2.7644252465744343},
    {-1.5771733251142541, -1.3880186416406137, -0.27686126856163057, -2.094428271678925, -0.37740696878058105, -1.5153503451196184, 1.4682448825655001, 0.5758129097631866, 0.049802429355798046, 0.8095218237817611, -2.7395126212957948, -0.8045627436932787, -1.108993810527826, -0.7651698374894312, -1.6638471204553023, 2.1801784968481717, -0.9003255294741822, -0.4450587835095449, 1.2123284040351905, 0.8392876368828475, 0.5761065411845727, -2.102304016479183, 0.8372981137655428, -1.3171388430244881, -0.6843077187797667, -0.9199251356592966, 0.9286367979687531, 0.18929164554066097, -0.48512370082003853, 2.293351744618951, -1.2652967946952918, -0.13187188342223782},
    {0.5577654715311953, -0.21507044452903043, 0.9801314898526613, 1.2314658708315789, -0.3585665691338706, -0.1937726817611021, 0.22157257058785298, -3.831344868291799, -0.8391866061591369, -0.5098866494720729, -0.6446221122762656, 0.2894634780967019, -1.4385345027703256, -1.8032056189677141, -0.566079668437115, -0.1664572995615947, 0.7792893527779845, -0.6240017355658906, -3.252247425647809, 1.4543607246450714, 0.11342060622805758, -1.2127492406041203, 0.8454224588911167, -0.04048764241003818, -2.0361402409420606, 1.0915044498917876, 1.4722619619063222, -1.0565485853635255, -1.9289915948292793, 1.8295705998886966, -0.38011425346170796, -2.1299754518081024},
    {1.0573464652768012, -1.4049965370907378, -0.8364690711550965, 0.7325396057036461, -2.1342818329353, 0.3934914027226276, -0.25851518772237236, -1.7275069904589886, 1.8658431788545358, 0.080756857922691, -0.0983516207647816, 0.33857473947634187, -2.298064877737047, -0.0659073940976704, -1.3372562744251, -1.16208992836293, 0.8977048155243131, 1.3399348518877943, -1.1658387396607222, -0.46189198918130875, 1.12514464902852, 0.11398256930429441, -0.7529502280632734, -0.8695439384564936, -1.6866221224735753, 1.060993975317214, 2.1450884320833867, 0.8215514018098309, -0.7233287011244113, 1.1966591841690937, -2.129365769534045, -0.9953863383888153},
    {-0.7729753490283788, -1.2413772888559806, 0.6126831459538833, -1.9042796039733636, 2.4783760553861045, -1.2512812761703525, 0.8190214081755814, -3.488323251935226, 1.196105455580709, 2.5412955501171677, 1.4108035451675836, -0.11179088338860871, -2.8225782839239355, -0.9505445954818641, 1.0007892868737462, 0.5120446079048759, 1.4351723245076566, 2.6525571195287863, -0.16323539734261353, -0.19752228734222613, 0.9932880508992173, -2.6192712200487844, 0.2889338633794554, 0.34592213567377816, 0.14511044136926016, -0.5343648876488348, 1.0777659508767443, -1.4622559683579779, 1.22467465625736, -0.5668035770921926, -1.1744364796132825, 0.8382703562558266},
    {1.5877256996855165, -0.6126470453946655, -2.277596411605104, -1.1978783317810096, -2.6368337007725895, -1.3765543128302176, -2.5451130136786153, 0.4518137642876758, -2.4993252382323443, -0.7859479878752504, 3.069925197610531, 1.0774060480749659, -0.9137256937884207, -1.8373850936523863, 0.6190395823673484, 0.9381359522625431, 1.3993425851782224, 0.49206968516972843, -0.8315070381739842, 3.1278293453975627, -1.2673244254530625, -0.9616909703746287, 0.5437060601602439, -0.7875891672631851, 1.7686499421984552, -1.661993710451102, -1.1288891006628006, 0.6786174371989535, 1.9377953800702659, 1.1004754308188829, -0.5102541406492596, -3.256277104592717},
    {1.3879442259364196, 1.5917022735760098, 1.133971804101498, -1.0111676536131724, 1.5792185930125122, -0.8997515503957011, -0.14280432024043307, -1.5842861328511595, -0.46891095876918953, 0.05880990332284767, 1.6008881966653776, 0.25917574724010123, 0.6561007808127567, 1.1121056706662347, 0.6448460102643419, -0.7617687360877688, 0.6579459237139528, -2.427832013847078, -0.2465757025345086, -2.1776147218219988, 0.09700045223904871, 1.143090314659039, 0.2920501707991044, 0.03755664887497251, 1.172558926464571, 0.0702913464963625, -1.2594750407931548, -3.8643161438778653, 0.5111617397767051, -1.9839375748834276, 1.459618976064751, -0.40357540435181943},
    {-1.5037763350246465, 0.20387804775220136, -2.1582915999916987, -0.667460371008587, -0.36655387352986263, 0.28294740330419094, 0.7601564998890382, -0.3847842847669112, -2.656839114755775, -1.256712755540528, -0.018792647154685108, -1.4342346531692505, 1.1639358042696906, 2.5579960569046944, 0.15908908204530917, -1.7262998608159186, -0.7695341630860838, -1.407058130029788, 1.4468485081724265, -0.253092635140471, 1.818958038093669, 0.4118483922174892, -2.1175344987590417, 2.3048419786190757, -0.27062660518942994, -0.19435494992204067, 0.31275694939999926, -0.3841139795887141, 2.3440296051782, 0.6543423775376892, 1.218036962965914, -3.6991122684086055},
    {-1.0494372479487235, -0.13384491471770996, 1.5432107294347346, -0.5974274176863799, 3.1633192474695786, -2.6435127064168773, 1.5929685110605232, -0.48456678241397005, -0.10773605684793566, -0.7407927015220265, -1.6674469894589818, -0.3010214509752299, -0.4430094044543609, 1.1924958951640385, 0.16626486082878938, 0.7501931515334577, 1.0907625440144122, 1.3330234040708429, 0.9197540007130673, 0.3623160677936947, 1.6902113166510682, -0.7246870244848971, 0.38537381064631765, -0.9123678287119502, 0.9087753715347793, 1.0425752425014436, -1.017237271117446, 2.158111187171381, 1.05311386076208, 1.4175349173210587, 0.8686078672274556, -0.017243065020136557},
    {3.4450568479096106, -0.18682816995815787, -1.5503326893773723, 3.5025690201294943, 0.6683003073015436, 1.1626815300556341, 1.4732606424467187, 1.4241555028241217, 0.6859430041733404, 0.8608870020273038, -0.7117399154105954, -0.49447062173023404, 0.7688282370771711, 0.22104571285203647, 0.6640916953745575, -0.5145976872192162, 1.243179972988549, -1.1671256022439176, -2.6712876524282656, -0.6681691044474126, 1.8187593762077103, -1.67195683020156, -2.2209496250162775, 2.0532636896988476, -1.5013037888501917, -0.5429413263054368, 0.4545552350061494, 0.9503016533347214, -1.110709426609486, -1.255801449604239, -0.5113417034093731, 1.162189124443559},
    {0.9453207086817664, 3.369547271139141, -0.7946990287412902, 0.37449078590722434, -0.5911511126770385, 0.772143482834899, -0.061802226324611936, -0.8625901084752795, -1.4021506824767527, 0.3273848500460673, 0.06851541488935346, -0.250244864414977, -0.7167002531499373, 0.7778798413618128, -1.5843721792449648, -0.09467744282185189, -1.5987144716244612, -3.1605197686069797, -2.1123410946825243, 1.4250037266971713, 1.1682790028516816, -0.22882132617011444, -0.8123356368898973, 1.3829396622110017, 0.7181947071593867, 2.7400338356567677, 0.9672503394002697, -0.39230318161406835, -0.8504339690577982, 0.5351009315457202, -0.022257599075055878, 2.4640396732680254},
    {1.0180240635059947, 0.5410533259461638, -0.3971605802001795, -0.7250298125070268, 0.6918576464854823, -1.3978704160365611, -0.207174784215606, -1.83461875835023, 1.1516459330481703, -1.0664199041513915, -0.8646695127511066, 0.06774104372997938, -0.27916443125599205, -0.9175180761243334, 0.7532795962684109, 4.617347904015068, -1.987828388140183, 0.26814029679727136, 0.5980188408556942, -0.6847809009427134, 0.5026980141360143, -1.4492202291478171, -3.3019715061569594, 0.7451839916796922, -3.289305756040218, 2.072007542085674, 0.39741245449184975, -2.17609009655366, 2.2315992962876696, -0.18419131584187157, 0.5283679508951152, 2.449204570107819},
    {1.693393448686676, 2.749607612114742, -0.06779901206088976, 2.6684582969152855, 0.0862297103873629, 1.8064474679570506, -0.23925522800632057, 2.2477764711887263, -0.3458506130728546, 1.254773600165375, -0.7739447158990077, 1.6522122540684305, -1.5491421745928384, 1.9351984036337586, 0.15619513715727648, 1.5338051356686497, -1.7459926691977754, -0.06716089803069165, 0.49223686854450044, -0.683268750210898, 0.39903818547875547, 0.9105006203940442, 0.4332966635673397, 0.6511552139073504, 2.0765967212486913, 0.39107696695408245, -0.9832547568613034, 2.215461184415516, 1.1356567713899426, -0.5687923466769692, 2.1031043678727173, 1.145692511377534},
    {0.7032208896710607, -0.4525579903283563, 1.4710355142887357, -1.36696855760671, -1.2030389057622661, -0.3986562928229818, 0.9815778969201435, 0.10902975777448996, 0.85690957526298, -0.02206491147306108, 0.01938355390564554, -0.3063007792499383, 2.5028636293908035, 0.7301098611609181, -0.1511512321478528, -0.4155652353212947, -0.5600523067688571, -1.5605398529680565, -0.19310248277723382, -1.3850326701970503, -1.8463135391558605, 0.48981456207398316, 0.16134451794515992, -3.303378120364969, 0.1170496926604605, -1.0903132214579272, 1.1093617263913935, -0.5114209802555476, 1.7275720364275118, -3.4009378247280937, 2.1054627920675792, -0.01838834523030914},
    {-1.0586399655378742, 0.41219341607911564, -1.5084720681816406, -1.578037004259523, 0.8341839315386331, 2.791452885345038, -0.3831488775193162, -0.05323731530326858, 1.4316688843444794, 0.6293739563857876, 0.8600972901282221, 0.008002440780665377, -1.6515612055346907, -0.3210512575036177, -0.09621153799478369, -2.205026383051729, -0.6644140688979919, 0.3106604860610268, -2.618264883766474, 0.6588533138140089, -0.6679566399434703, 2.543782267223334, -1.4587445198562046, -2.5099840212853914, 0.25022845739591065, -1.1130454244447037, 0.12670703105063247, -1.439014114992735, -0.5817432546193297, 1.285171633275009, -0.6986588292477437, 0.37747285755213117},
    {0.567816262538774, -1.0359961936687427, 0.18583967470769755, 1.0861130177445992, -0.6194606233824536, 0.7898539460510129, -1.2802374364153213, 0.2092696749547221, -0.4775163764364774, -3.0033424124943178, 0.21252512468248413, -2.5976190497898273, -2.7410775500249125, -1.1940671003656178, 1.4096034136779616, 1.6110006704263817, -0.5724977628098739, -0.39909341646341834, -1.929932512289836, 0.8760844092248526, -0.47367964090834047, 0.8811229372202637, 1.0603813282429235, -2.460309609177565, 0.5569432392783894, 0.751877057911445, -0.5912199106372684, -0.7325858505967796, 0.3412049631524905, -0.7766417806288893, 1.1608058598448718, -0.9318389567527505},
    {-1.4323154749424838, -1.0433105998549355, 2.0429772953890195, 1.083491820929781, -3.2781794268602455, 0.1962666161824979, -1.4434169522338227, -0.9300427268120318, -3.7735353618155427, 0.8784587123008698, 0.7589498016843185, 1.8011146667510183, 0.6147740441608628, -1.3777811495700774, -0.09989334127887337, 1.1712882648708658, 2.153912162661411, 0.1649613591910827, 2.377002856031256, 0.7446363005930922, -1.1690578846829442, 2.837042791473538, 0.6156604259853419, 0.9021101970616561, 2.5571528070707656, 0.5159363726131098, -0.024103751851879185, -0.8978164333590494, -1.1698294973007197, -0.33847459203922364, -0.8993745416896989, -3.628145696369002},
    {-1.8007669636416088, -0.7116142284819852, -1.4258491843196406, -1.475292248318256, 0.38228836765105945, -1.2822120924373435, -2.004574574422168, -0.4299489093106262, -1.5725312464195111, 1.166384375286759, -0.804186794267681, -2.130312629508855, 1.3586394174374514, -1.614303150517026, 0.6015692450350661, 0.9367137763057771, -0.2381832583709663, 0.4025790619685754, 1.8133443727800358, -0.5669797719268701, -2.1478906683036167, -2.6177435214307065, -2.062123830484986, -0.4592120602903812, 0.0895156438329735, -0.8527590144722118, 1.5632514924284, 1.3574849260202202, -0.782430038367271, 1.5174555733683663, -2.001718776629024, -1.8684239663866142},
    {0.508332069008016, 0.2506589968883078, 1.1151348615117924, 0.9707473478274702, -0.04364641359638056, 0.6413388683229372, -0.40909689883658307, -0.6840309168720826, 0.11158179452139205, -1.5402051206805376, 1.3278880636657249, -0.7430511219934881, 0.6892076670905893, -3.4945685787470677, 0.9776944435465835, 0.20520363485421428, -0.07231349631996212, -0.9500662505164367, -2.159206656379256, -1.5913146672320369, 1.1211484406076526, 0.2458662708732587, -1.1819143371561553, 0.14014752542233852, -0.18951560825808345, -0.49741954035317354, -0.09579853496754924, -2.678685643274839, 0.6993862550223275, -1.4341107469307486, -0.25992998566301934, -1.3773876511358703},
    {0.006034988553229229, -0.7604939499621793, -1.4703329267794338, 1.3347905295499778, -1.605658242691052, 0.19623453634059496, -1.958965758759275, -0.3385232547624718, 0.3869243752272887, -1.4465445672212212, -0.7707035570264493, 0.9047076155225207, -2.4859877436393973, 0.06405722827707958, -2.286333294784269, -2.002614210202323, 1.0900231084795302, -3.3095885381749945, 1.4566803969320439, 2.073348337811968, 1.1701753326310544, -2.6479077159430826, -1.26900533504315, -1.0618080087401105, -0.5200160722573196, 1.3657056269020305, 3.735900732538276, -0.37224497154086694, -0.21856638515915414, 2.5568761625358483, -2.9557917511134275, -2.9337516879763834},
    {-0.07180860014213125, -0.9699513874037238, -3.133529625605223, 0.2320789736243283, 0.9786138376953671, 0.18562484865256332, 0.8958964874326014, -1.1160177099715574, 1.2658040116346003, -1.8572734534535071, -1.5948282388308423, 2.5925492216859016, -0.7025169199926908, -0.07462457552711667, 1.1734601536864677, -1.0640189613353264, 1.1462161627398602, 0.7664665888804265, -1.3093507142378704, -0.14648812693831803, 1.5044640531288471, -1.4937456908351567, -1.5418809118402168, 1.4560653044832002, -2.1760994907959654, 2.5390339130000963, -0.4551065395170525, -0.343095902094405, -0.036944623128904654, -0.8061145108478704, -0.8056045180954428, -1.328556915012102},
    {-1.7574373045950966, 0.770165186789474, 1.808452632206792, -0.5229866745506219, -0.7220205828731138, -0.2316230647576988, 0.8366537760648266, -0.5379754651948071, 0.14082613948795833, -0.22181831709443775, 1.631168883544899, 2.614856410693436, 1.5497916924638673, 1.3288203025159406, -0.4239194587858698, -0.44097015077524704, -1.5401257689896186, 1.10478717950905, -3.0218017032111044, -1.6032644211845495, -0.8392736461346942, 0.34364921945967314, 0.9257180946463069, -0.20748240054835415, 1.2937462935787922, -2.211379246555939, -1.1347220907405966, 1.4140031517502591, 0.1665002479045909, -0.577138766055097, -0.5039795546703153, -0.09698144754383468},
    {-0.6887139787326079, -1.6922564821824893, 1.3161216862127516, -2.2302695663034178, -1.272800161502504, -1.7025355126072148, 0.3176808263808093, -1.4703697618120821, 0.44897872631211827, -1.7651347844604526, 1.1454972979730815, 0.26787443351940554, -2.2011574925206863, -1.8307149185563907, -0.47841883105523036, -1.5761715533476743, 0.1444726464535604, 0.13238592192267973, 1.6333817890900155, -1.1980168218959417, -1.4759840495618388, 1.0406456145048921, 1.1526890365567528, -1.547813760747311, -0.6620468109444259, 0.08329166310267054, -2.9920335796878, 1.1764809995609884, -2.158002308377293, 2.8006493820886287, 2.004022396510609, 0.6521220979412761},
    {-0.16298415642265715, 1.574900131546818, 3.2377537868953294, -0.6093997613243927, 2.050510477464607, 1.1372436859769217, 0.45032769513231496, 0.6762918844417016, 3.113784591937913, 0.9405057195050996, -1.8963592228047916, -0.9437447238793415, -0.7190888354284845, 1.345141097157477, -1.9198168966715201, -2.4806706282171924, 1.0506451385775288, 0.5119830521364808, 2.102731969829331, -0.6044860059147363, -0.8483234622366452, -0.8144182885329447, 0.7224277771560019, -1.3792518263157125, -2.091397679883556, -1.0644854950231182, -2.074893831364311, 2.531472218197022, 2.1505088252137066, 0.11355530411550409, -0.8012841440793946, 1.0919023801135275},
    {-1.4759052221311542, -3.062662201820855, -1.209075498226803, -2.510685392729452, -0.9931875793044239, -3.286449676766621, -4.709792121117258, -1.5509686209329523, -3.4349390902231627, -3.5703310598998317, 0.6139495884262717, 0.6557542126920698, -4.775574206187627, -1.9345957395641804, -1.1802989440228708, 0.42506067612454435, 0.580263064515757, 1.3223004034355568, -0.788358515831561, -4.246431219190652, -3.788123746638925, -4.082235444068451, 0.8993101073067022, -2.4391014977794607, -0.9721165676903555, 0.42968842186915956, 1.1580820691684135, -2.236334688117628, -3.067507417885165, -2.4941305213595526, -0.5644632519860232, -0.801050552597421},
    {-2.138881472209408, -4.282120138248596, -1.7671508963319502, -4.040422671448613, 0.12191898097553994, -2.8552050625063803, -4.148149736029391, 0.3083061708101357, -3.0659558490871333, -2.238624102460391, -1.772982583659621, 1.5292027586186108, -0.14072454720581581, -2.235636284822843, -1.041133769765072, -0.7616550807014241, -0.08937494777147752, 1.889691970971374, -2.6933226300108655, -0.065222155126297, -1.3834866203435532, -3.6026905107779434, -0.8092896948732959, -1.8362913608443567, -4.8613083777122075, 0.5976039658094892, -0.7677025022115572, -3.500034095277111, -0.19857513295715615, -1.6523029557395459, -0.34996449014900427, -3.7301358375605513},
    {-4.027982093724085, -1.289742215321079, -0.26374808714167686, -0.1382469663929301, -2.5305743806103087, -0.6482964671321261, -2.24268842551724, -2.12539778558112, -0.8763369299354989, -0.4055953613254744, 1.6557946139486075, 0.6197398716803052, -0.5480425985333245, -3.249815832628548, 0.5953333299196019, -2.358692273688875, 1.1896311161056419, 0.6563662305611446, -1.0742098655264063, -2.6862979853987428, -3.761778073274063, -2.483112106564223, -0.7164114259560604, -2.707055459454308, 1.1034310395275813, 1.3591099821816026, -0.08397644315694477, 0.40695673625049167, -3.5528107124781814, -2.7893162701632317, -3.1360882473914042, 0.7258246299984749},
    {-0.08440506252665625, -1.6906666373144301, -0.7390187265218107, -3.058698532800913, 0.5391237180615429, -2.417490081563084, -1.3390693047246676, 0.8349608437116167, 0.39042943013041337, -1.0725782955525327, -1.8822113667806677, 0.8145580997956855, -2.496830030276951, 1.104944046987572, 1.2476986120338291, 0.03014033623806005, 0.5078775344047489, -1.809718559686692, -0.38697354276034346, 1.7644872511030274, -1.9997013875375762, -3.582800978714, -0.9238231336489395, 0.6057287284540505, -0.3001404405707401, -2.649340126808497, 0.6852129512563822, 1.7241981123584942, 0.26414525593968563, -0.3174715981971949, 2.7861679197958495, -0.8070276688127727},
    {1.5567533486042793, -3.6943679014617454, 0.9986844322920039, -1.259268701329997, -0.4922533020810929, 0.5127989418735958, -2.2635849396934957, -1.3845946572218788, -2.9994240938675794, -1.9137331389245689, 0.9008793012293697, -1.8149154749033587, -1.6433351553782858, -2.597014759955749, -2.6354320249463186, -1.2913569724610647, 0.6644692744111848, 1.6482686259610475, -2.3738746124519006, 0.44238343592352564, -3.252209992786836, 0.15290756923903756, 1.3859456989267156, -1.3525243727625254, 0.01424476793499165, 1.002266375296318, -2.557055263709635, -1.3276270244944282, 0.9208526809491352, 0.5154739857623641, 0.3236970625342736, -0.3330936207086268},
    {0.5633296931383992, -1.0548465268531106, 0.457984776475074, -1.0408622568248218, 1.730368546496335, -1.395686494161933, -0.6608078857871802, -0.1441224716702936, -0.11580632655744388, -0.11921797704501898, -1.2606891167063476, -0.35496663876135126, -1.4709938953247967, -0.9481844431692751, -2.6938730428535407, -0.9103689786843037, -1.5861444999661727, 1.2144876363120671, -1.628961096922716, -2.1549648295065618, 0.8402610200590067, -1.6543265794697468, -0.928410052365961, -0.5422991812646503, -1.0756249653747056, 0.4302669744174288, 1.260982234808183, -0.3791258104217636, -1.423151645230824, -1.5731089480449696, -0.5013642683123535, -2.9637091809984177},
    {0.9609279100831818, 0.4372785157917584, 1.9949904752903291, 1.1293617548062016, 0.9117955225255333, -0.7878241748709959, -0.0918212736659752, 0.6230462283514463, 2.7369797998253804, -2.3209602425462204, 0.5269575186212623, 0.691000780705411, -3.740993641275939, 0.6431297738267818, -0.10516687050047512, -1.5511609483578048, -1.5749505872078469, 1.6072165266880993, 0.715226333126601, 0.08361559037310165, 1.1974236441569954, -1.4728731636901664, -0.4032780522087441, 0.3826366221555432, -0.014812721030701114, 2.366421256066172, 2.3574573205320055, 0.00015438844095286899, 2.0854629708609687, -0.440588949395041, -1.8161000810748944, 1.5907059701878146},
    {0.41893689711262155, -0.5812078445991056, -0.3242384269759672, 1.3108731087272154, -1.6583309679396065, 1.4393500129883212, -3.020874494722576, 1.1383305997540005, -1.4962537783329979, -0.5230260066660658, 1.8969654615934208, 2.103187125165824, 1.4875942898268388, -1.7822256941767072, -1.916066103524454, -0.10554710787549937, -1.7002119867297623, -0.6234441155467351, -1.0166381707052787, -0.07959782598567089, 0.6845915248478742, -2.2287666414379, -0.504265769192137, -0.9641441938816122, 0.5736107340290708, -0.7450948409576021, 1.95629906725292, -0.04603636555659058, -1.0560810743332283, -1.0160925358453878, 1.1799379925343767, -0.10438051981646043},
    {-1.6735005958014282, -1.8626815001750916, -0.7904978160196866, -2.2316861583941887, 1.0966640914235655, 0.06149977519391072, 1.0554043427195587, -1.8949406398386137, -3.6877509924286653, -1.0389396770696473, 0.36918235365434704, -2.880416188282211, 1.871645811879535, -2.0724386134178023, -1.1652728903125245, -3.9595245977732207, -0.38891983742142344, 0.8087503027379027, 2.3549553757111013, -0.8354109875306286, -1.6813249585246057, -1.4111183107605412, 2.505046159577627, -1.4828291534271023, -0.5203078231461974, -0.4735651939996532, -1.2126421577139437, 0.607652248382546, -0.4768442308261883, -4.024387416560246, 0.6689004412006911, 0.5576242091084667},
    {-1.2286829376857513, -1.0956528290180867, 1.458736252452654, -2.2341178499385532, -0.16293490955346054, -1.3073356941899141, 0.829167017332558, -1.0152236822633978, -2.4140361594054847, -2.140598659886755, 1.3900494908545804, -1.917827925937731, -2.8811567687641166, 0.39383296671864043, -0.9449035106125417, -0.6554819525190535, -0.5390635448780594, -1.4490550388000885, 0.32958345399058764, -1.2876121074126963, -1.3021186032805834, -1.4226531769554085, 2.6024703278953774, -0.2261157513448281, -1.267749359269623, 0.11767005121865916, -0.4197882595233071, -2.814353414423196, -0.21820915862898066, 0.010056558915364716, -0.9555540664505149, -2.468105909539061},
    {0.8408659869093487, 0.04432523692362378, 1.098320346781709, 0.076658523301701, 2.695855345857573, -0.24156023070639518, -2.3112026735784896, -0.7010270994596688, 1.1479825650364603, 1.0535184849596295, -0.8512318837230214, 0.19607663704512002, -1.3760742471892398, 0.6246945700757937, 1.4161702821319473, -0.4645047024494092, 0.006137554898757705, -0.5767109637756578, -0.5223710675065102, 1.451826431089704, -1.321064147229273, -2.001692139013515, 0.7043420173408599, 2.999179580733056, 0.28226267179464426, 0.5078039976509989, -1.9562834816671986, -0.9686560404257288, 0.29189752833206944, -0.650218746017478, 1.6619770625095607, 0.5885989360343972},
    {0.7801609136795375, -0.630548888596677, 1.9061135894023014, -0.9700220198177529, -0.37441250822129746, -0.9143571252821842, -1.3808211495768963, 0.5746319696815043, -1.0589619591598605, 0.5335883694385753, -0.24414613715660197, 0.024476196562816657, 0.986116256749606, -1.2659710110943305, -0.7946077605141284, 0.6261642919748636, 0.04471963333877946, 1.6589260821357976, -0.7321611189709207, -1.405333406563293, -0.09376892668859405, 1.7339884328101045, -3.7256523840398303, -0.4262908470615674, -0.8562842913058383, 0.19218038485048877, 0.2796952945994855, 1.0141809925849508, -1.262307145716354, 0.9939189377138009, 0.5400685308494163, -0.16351843245384615},
    {-1.2812100545213627, -1.71516402437196, 2.359521545890138, 0.24838981065955623, -1.6327327489348393, -2.6136350244407964, 0.07177550190974084, -0.18473012688110457, 0.6678494790895096, 0.028859965977053276, -0.659372746250232, 0.06432915065964784, -1.6098215053152642, -0.9492562384636832, -0.19180163227829009, -0.23910879435313645, 0.4429918677897351, -0.38393843922290566, -0.024710030296896026, -0.9769320189566945, 2.3632330342278998, -1.3992314990671726, -1.0988722308879066, -0.7932288998464452, -1.0690100293756393, 1.096126322853651, -1.2935033463870067, 1.5041129646227385, -0.09122801326262665, 0.08611926536202155, 1.3121407865759789, 0.352742642118498},
    {-0.4438877695629307, -0.8377512689045691, -3.5854835487295476, 0.5013042732170312, -0.7464417346214351, -0.24812211679095889, 0.7394982986420399, 1.3501696288448566, 1.4973208689523854, -2.4237523946494357, 0.08184232741151003, -1.306373580598186, -2.5451630794996865, -3.3720141307768507, 1.5472992969553447, 2.4003846332172327, 0.721758470533004, -0.8628639913791, 0.7657937888924594, -0.8408841820238595, -2.6980471826672305, -0.3886079397370835, -0.8510773179269928, 2.443314754402753, -1.9093969079931008, 0.6874541585465195, -0.9311761227991386, -1.8786541261830527, 0.356942163370581, -1.2254929985455363, -2.735011624671552, -2.0262291135626835},
    {-0.6836984326443231, -2.171206598223362, -1.1417731197654952, 0.9363170115639496, 0.28656381109991325, -1.3076198733915934, -1.6451669166009253, 1.360654694039402, -2.2357053690934117, -2.898919173852684, 0.4053135197926522, -1.6577649839363775, 0.694797516650043, 0.6493711143707512, 0.6199791647339569, -0.26299787748109005, 0.1786087575840865, 3.4376098530253443, 1.1074410750003387, 3.1130028759548187, -0.5444066055888558, -0.6277901163106623, 2.3885080087420523, 0.19710869047948198, -0.4327310300718424, -1.822276402186135, 0.14903948099968584, -1.694171236913155, -2.5786734302955994, -2.9354861075129164, -2.4670114275264083, 1.13953760007412},
    {-1.2913531893422752, -1.9227865386578815, -1.0254210178332028, 0.3926514984790061, -0.8882066529461419, -1.1981200949359263, -0.5525987984874868, -2.5222690327679524, -1.0278925975622786, -1.3991868341953893, -3.8939696967762174, 2.02547524984346, -1.188195453134381, 0.4024006035453538, 0.851679534424026, 1.3655251276255198, 2.0562817086028637, -1.7542040283898843, -1.1685752584417186, 0.01792128870778726, 0.2278916114025295, -3.2937258909305327, 1.8315480787039278, -0.4258721675684299, 2.0562945076574715, 0.33713860697965364, 3.3873699241941164, 2.0149601655586897, 0.8819989730238109, -0.6991859283197744, 1.5125373340756763, 0.1169150225988132},
    {0.3109936218659115, 0.3984507393381565, -1.302781469262709, -0.7284118890678293, 1.1449142706720865, -0.006269144153421334, -3.696132277372392, 0.7874806963458308, 0.09038696203449978, 0.5733960251650023, -1.925736317794994, 1.057635118549795, 0.6630195982573299, 2.3843138673459108, -1.5735355696107478, 0.3015075912847236, 1.2120559108590823, 0.42618101235229394, 1.2308446997634839, -0.26937825840081436, 0.4449418924693304, -1.5481720338031084, 0.9698907284638938, 0.7799613719295824, 0.7612801562819149, -2.3727258591488627, 2.7223041998116497, -1.5581583597935655, 2.233451386318055, -3.1621452178227227, 1.175244030413757, 0.22547277420048217},
    {-0.1078968523140023, -1.406019909982521, -1.9442319909070602, 0.5475512198712172, 0.5966188671169993, -1.8668479360333143, -0.40957749159411916, 0.8506539076979103, 1.1994858005167108, 1.5215432157213724, 0.5564785116613274, 2.179985314599099, -3.8723880127742594, 0.44817227828724937, -2.1312000159004176, -1.8246466297700146, -4.411245249319391, -0.44810150646345537, 0.13771992629931, 1.0675888121127264, -3.0107479728607913, -1.7355339439360435, -3.4333148981255364, 0.49707763685048684, -1.139154365162064, -0.41724911801999887, -2.1437985436227867, 0.23841280424604758, 0.3526303023705754, 0.16436991921565214, -0.776046587768443, -2.6419436391882134},
    {-1.4646291559181326, 1.4909451296264251, 0.7465039494703024, 2.3225699106850173, -0.5718623540253803, 1.2137806786182253, -1.8902415148400271, -0.0644565062732821, -0.42725150642092063, -0.8651538744743557, -0.9514867945684715, 0.8496298918380643, -0.8749457815103736, -0.7147367151467174, -2.325276680463767, 1.0946501043115144, -0.8293502267639251, -0.08656768789799296, -0.7177326834557917, 1.2338843613429116, 0.1729420283222886, -0.9560349299996745, -1.5107392434305895, 2.0377896693880655, 1.0332343878048114, 0.8444956033394003, 0.27331374412536047, 1.0860777414271356, -0.2936614772042778, 0.5643109732764782, 3.843261036557106, -0.0018186014641990546},
    {-1.32924287614377, 0.43267835749086214, 0.9189575016400099, 0.37696064382254785, -3.251533605363253, 0.9817912556382948, 1.4659163875988126, 0.42980365448856384, -1.051548789372127, 1.064636359372329, -1.2898417927187007, -1.849142303977241, -0.5466565924230714, -2.0609124125746012, -0.6119283166655015, -1.5858069436435642, -1.255789375955357, 1.816239968864829, -3.8304012281598796, -2.8344203490510504, -1.5075628655446893, -1.3662749839240096, 1.737222775810689, 1.4183968931285853, -0.6955420125179775, -0.6452919470396872, 0.14595105173507072, -0.9489067408184418, 0.24615390381145788, -0.7081037953766851, 1.982924924608389, -0.10586397308059749},
    {2.7757947755422188, 2.6956979142068143, 1.728109642986035, -2.171709839201848, -2.6487180009629867, 1.3172427305364345, 2.2317443181036256, 0.8999672386571952, -1.0134754895462175, 1.2466892641884177, 0.5687471450160452, -0.7002826276196692, 0.3373606749317102, 0.029662275068754674, -2.9453828547211227, -2.445181026075965, -0.5132393872550471, 1.7500810527659039, -1.027851565851303, -0.39450548937651686, 2.0313342210577536, -0.21341070106255344, 1.091285456675633, 1.86688645113773, 0.7223812517693889, 0.8485780367504002, 2.765146670625402, 0.18313425673383915, -0.0056381506467649755, -0.35691288011236216, 0.8919256554609718, 1.4233020288994984},
    {-0.014927742689489803, -2.5479996545492027, 0.4487377131257473, 0.7536742725898776, 2.0429237832299134, 1.1400602838971454, -0.24528873481823674, 4.442038653741702, -1.9939697983863118, 1.8020829834327334, 0.7268791450861489, 2.2873813992814913, -0.3546900554499494, 0.6228521176497018, -3.9053408897487953, 1.333501020667488, 0.8819184806021974, 2.209678472918951, 1.2728034122576064, 0.7671404622779872, 0.9786364771489853, 1.1716766275443211, -0.3643480671578221, -0.19784215422462514, -1.4305683676355543, -0.46906654562902944, 0.5182828676355983, 0.9679733777354377, -1.1939088330074317, -3.116943887045671, 3.9169092865169066, 1.2035563878635713},
    {0.8037321832497512, -0.1839561231847491, -0.471746979656456, -1.8253619488042363, -0.5165654484316995, -1.0898094810798986, 1.5272485753633134, 0.6068458828563951, 0.5989683343149094, -0.07814571258398166, -0.6507178930445947, 1.4134797523386353, 0.11187489571579497, -0.14755209910190004, 0.18534713661765062, -2.983841637672896, -4.183607140597988, -1.3706356599443983, -0.3329599353551495, -0.5310879805673924, 0.1755067318534824, -0.8159364470986022, 0.835949807530819, -1.3858767715731164, -0.9399441781175323, 0.7560769855785953, -0.8126731681875885, -0.27349096801877953, -0.42959968652689773, -0.24887610949876615, 0.6800920617858137, 1.3408849048227738},
    {-0.8545062500047551, 1.5674850667901334, -1.0153810653411413, -1.8110235743563434, -1.0002667854372371, 1.7422438710987267, -0.07085837097540927, 0.7238962894075855, 2.695306792113737, -0.17732335519002718, 2.0663624024396787, -3.433031049446784, -0.542158893828351, -0.0803653416919676, 1.4464617982891088, -1.369162329556089, -1.3949945263066064, 0.11787119275016218, -0.16281290779602278, -0.3375015000761084, -1.9549611166662435, 0.1359626984431518, -0.544094587665946, 1.1775774978523645, 0.9144143921454007, -0.41147678740969007, -0.2459786511531592, -0.5648888547312088, 0.2516796080872285, 0.847290636425333, 0.6374000937907122, 0.036835845029060774},
    {-0.4214910052282019, -0.8757141508726258, 1.4102707288478316, -0.4398499039954871, 0.6814412673097635, -0.5125403744063647, 1.2639408873322215, -0.13344011326995736, -1.0316356186547153, -2.7850480581578805, 1.1419975825738402, -0.6654181004626021, 0.15485923889916375, -0.9961459864973998, -0.6271255329813249, 2.4467603937213904, 0.7873185192873531, -1.0121765880635853, -2.0826608054876514, 1.9185935715872082, 1.9676783162081866, 0.17239699429883223, -0.0815473679706286, 0.6249324624370013, -0.0025915722229157474, -1.9890852679551811, 1.3017681195086261, 2.2426564155043853, -1.8053753144541154, -2.8625786130825563, -0.16528732368460272, -0.11301380364457782},
    {-0.17421315391301595, 1.5385255195271805, -0.4178568419428845, -1.467801019701789, 0.9668999526878107, 0.4263182804026312, -0.2603403099776613, -1.4043897695907184, 0.2919482702944746, 0.4746351889775672, -0.301317839958388, -0.5300926810461848, -3.0414708268668553, -1.2860963539148638, 1.0225033229929212, 1.5797240253358142, -2.066178291572703, -2.826076449009505, -0.09969993633326085, -0.7404850549975442, -0.23503741833337383, -0.3583021404869178, -1.2057051616863124, -0.01817688150022486, -1.304021836577118, -2.1373796092539425, -1.3365103385766897, -0.1058361183556806, 2.7289493963191815, 0.3640329689245503, -0.15354028112456924, 1.4171207103590044},
    {-0.6159212929070775, -1.2983797502833516, -0.19820404812426295, -1.3559557536292055, -1.1166887263741605, -0.9300456377037061, 0.8316085943883935, -1.8765138029138448, -0.8620777620968196, -0.7192970848045699, -1.8700468494308753, 1.263320012403115, 0.025684601732387104, -0.8703708159023431, 0.5454831724313661, 0.693688978356363, -0.9685631689219415, -0.19260531926786417, 0.6417874168462763, 3.860559730464761, -0.41319891297530054, -0.44890129104640164, -2.8050802256643284, -0.17453683791512142, -0.8365038297308462, 1.0615028600839722, 0.11565966817448317, -2.345436581451994, -1.1755158200851255, 0.44299377768883297, -1.7340866208378978, -0.10893361757010686},
    {-1.7350848479925478, 0.11670529494178165, 0.4601258077100338, -1.0190747140909209, 3.1720280721589518, -0.8163872641783629, 0.6936171763362249, -3.101864660617794, -0.7692624184807059, 3.3992776978710086, 0.7548344531303198, -3.0310194380393543, 0.3796510647852459, -0.6916620933293953, 0.6544323745918291, -1.7686992495730163, 0.0526880891157516, -0.8789346174947225, -1.6751188946201956, -2.188247041024277, 0.17900690287645807, 0.06747151900737777, -2.250890319894785, -0.3303469332577509, -3.176586110050258, -1.449772295696506, -0.8772676597143181, -2.784997186188607, 2.3783998776745285, -1.1610358567429768, -0.42493736846898, -3.2103248733727394},
    {0.5073651248682598, -1.7216558708837366, 0.9100888516009477, -2.4154684327389258, 1.805442884091479, -0.9260510287174469, -3.2901732457193216, -0.4796571864958365, -1.9613062602985545, -1.075827957886178, -2.037082889967831, 1.4643235792653422, -1.148333720458669, 0.4275461069978457, 0.15727120479684273, 1.3066253947869173, -2.4153484415315183, -0.06830737413026376, -1.5261705020755336, -1.740804608801562, 0.3396374195983581, 0.9754692867751786, -0.8785124784735425, -0.06210798554621801, -0.5645656487662711, -2.5504023144056327, -0.321713824673758, 0.38911193090760465, 0.8553718424214735, -1.3062145870415622, -0.6773514577008862, 2.292129938783459},
    {0.965529401383494, 1.1289830695638805, -1.6766473121169831, -1.250312223594218, -1.3059540381088603, -1.7759563986856388, -1.7485944375473839, -2.905271268920062, -2.907342384013642, 1.1439097805055243, -1.15390342981894, -0.3596480403767, 2.524252767005097, -2.0980051264787942, 1.2139179990132596, -0.3789956892981201, -0.8084103993603781, -1.0579862203206345, -1.2193213977615616, -1.132964736962622, -1.9549143693465345, 0.25460138044064673, 0.6392476565750767, -0.029425869527106262, -0.5093024900097741, -0.865998668702095, -0.810469059636418, -3.949470856329467, -1.1456317433523309, -1.1388584835722324, 0.9017270531302266, 0.7697101674150961}
};

static const float b1[32] = {5.0737772056619095, 6.668109455702246, 6.545601202538091, 6.649501592916066, 6.7035319177624615, 5.238460552974347, 7.052068287659075, 6.496304026740253, 6.7323524105174215, 6.009706590687026, 5.618315025239734, 5.926861049976945, 6.675316422765205, 6.28175711219118, 6.204071984126023, 6.034850167953542, 6.729221801580366, 6.48666722652268, 6.4842565184434795, 6.3595792330405585, 5.844424777366838, 6.8379220963388, 5.882873776640911, 5.2703030572401275, 6.098725672741198, 6.040622105854466, 6.732420601701419, 6.422501714713085, 6.394152717603537, 5.894102309428545, 6.668310407213202, 6.594656591023198};

static const float w2[32][16] = {
    {5.072032448875317, 0.960412872874179, -1.6347415663081812, 3.913622311137322, 4.090907795900384, 5.6372286678487376, 4.598623403692118, 4.050797488413367, 3.549526161005838, 0.7922791650750276, 4.889394987911781, 4.6975562831204885, 3.8688343917516175, -0.23118420699036935, 0.5444582928156335, 4.229125329749565},
    {1.8468427766521196, -0.24992030268563997, 0.8561928337280698, 6.883974878976651, 4.538759778282182, 5.291017677405366, 4.379350083429405, 4.771931210301704, 5.919073849487999, 3.4350276717634713, 7.266229653442344, 4.230010600464205, 5.249234830941174, -0.3323307542305466, -0.6211073375098082, 4.786369206057308},
    {2.5842777127131256, 0.03531873487111665, 0.45700484216563647, 5.013869895737819, 5.479190093401275, 4.827010267701417, 4.7606012254889745, 3.905169403218515, 6.147236937717513, 3.5987751038854343, 4.87468319920278, 1.5470857369234294, 5.139636571198859, -0.9724844569539984, -1.274813964418769, 4.349969111114984},
    {3.520159829835795, -0.8000113377001686, -1.7660835851966512, 4.1269505965599835, 4.643791582189814, 5.634777376077689, 4.741082155291749, 4.136887195365532, 5.66449805242352, 4.568112630641351, 6.558059300326143, 3.525017114612082, 3.46381050947093, 1.5567177052130774, 0.08867560464448934, 3.1133593056283337},
    {3.764491890891764, -0.6195048040304745, -1.602373804667545, 3.992262227665676, 3.6665996087239945, 4.1376518310568375, 7.106170616924637, 3.8109660619922963, 6.522381040021707, 2.7585085874271074, 5.180817753172174, 5.098027893712259, 2.958397218785741, -0.23231137449237185, 0.3668324311178948, 4.521115701084879},
    {3.13364964537445, 0.42898086547421055, -1.1415424299384513, 4.634603375109801, 3.4063315837771624, 4.431784723807363, 4.982089781343895, 3.8753677393152732, 3.3491936147479167, 2.853592629724137, 5.460544216617487, 2.2042968051685543, 2.86952016230496, -0.6973324766174227, -2.0055854343209645, 3.7589096437060543},
    {3.349226066743966, -1.5191090083421241, -0.8121374412788036, 5.62256945762589, 5.441678869977391, 4.972902344951114, 6.174111195777847, 4.149924949720485, 4.764915910629903, 2.6857297697871063, 5.618748113587327, 3.2852618680103407, 2.7144241625676226, -0.43766600090089186, -0.0868414213450797, 5.094290947507773},
    {4.185052333316563, 0.6627440785254882, 0.035747524627722786, 5.305094840667764, 4.88413277550051, 3.997416084653095, 4.336944260585603, 3.915881592808645, 5.767585854904347, 2.4006601482589454, 4.543010483195717, 1.8803531789420116, 2.7230400279700575, -0.4078382132643867, -0.643424237765624, 4.686604114224764},
    {3.3429289771814785, -0.6310840853188027, -0.6748298587679484, 4.830911867297818, 3.829761868825344, 5.654775704527418, 3.6959081982573276, 3.114381955528905, 6.58421385208747, 2.994664680264599, 5.4187608361637345, 2.4724149349291356, 2.7382673004914935, -1.1468262622578498, 0.6988996619980006, 4.73582671615866},
    {5.242548873502585, 0.07016925759811096, 0.7856599827148182, 4.031394773623629, 4.6138728185668745, 4.746065973117381, 4.771415178576522, 3.3825677918376864, 5.730753220828965, 2.799540164789143, 4.674134746850782, 2.203843583762079, 4.50686512410596, 1.0087550224874386, -0.805727418178517, 5.2092143107293785},
    {2.6566043698988095, -0.9892635950641764, -1.3642849470582468, 4.365064214002777, 4.578981960176859, 2.5170703871748015, 6.315342288463329, 2.8457456580162392, 4.930548506903531, 2.3427880307904707, 2.367543098796494, 5.8658300778941195, 4.086051991589578, 0.29863575449661556, 1.1494461302625256, 5.412626812347607},
    {3.479737195376338, -0.20175258526294101, 1.676654718062308, 5.536926920464528, 3.8110547502442125, 2.831713498943318, 4.8303287307868485, 2.627106284238982, 4.78274688798875, 4.7160052323285315, 6.076313858163841, 2.688627901036263, 4.165376634836251, 0.19032676942052593, 1.4685244238310482, 3.113538233136721},
    {3.347160885651728, -0.5984256898442719, -1.7213779774971272, 5.628563880188899, 4.581182910541436, 4.336978473140723, 5.1344916094077355, 4.0136616779367715, 5.098676096726337, 1.616159078639199, 4.511712848286964, 4.013452507072409, 2.985164257084167, 0.12400150161735496, 0.14072514816674606, 5.205150273789769},
    {3.419531571009405, -2.1560209424733765, -0.5468094899318027, 7.750900965309543, 6.61500009469086, 5.632818707970872, 5.083616643606755, 4.841270989438361, 5.337957005021112, 4.163775911316769, 5.383434129012376, 3.3836390773852045, 4.739091708007469, 1.6638118706405713, 1.8189579251704122, 6.65792421337581},
    {3.0299032864400997, -1.2050259855587462, 1.6114026082310464, 4.670474371993364, 6.298187749683042, 2.077147131436469, 3.7999441152402023, 4.313966574047902, 6.787339216955858, 2.311088126950013, 6.448953967846859, 2.2884701667094345, 4.021007412085939, -0.36877819231173914, 0.5642540184105252, 3.6591772916168894},
    {2.0695192811344993, -0.33828417748188494, -1.266221126023321, 4.240328814689165, 4.7252692272706875, 5.533047310966491, 5.2841602079377825, 4.587520863195397, 4.036426625496356, 3.645645702150758, 5.107236727186387, 2.8303247432686565, 4.064240556348287, -0.6323909003533734, 0.9281140611875706, 5.365407072638293},
    {2.9205183610543903, -1.9446129318772665, -0.880209555817733, 5.2997029721513504, 5.577799699412845, 5.0429719153943235, 6.350004659175157, 2.960124256498166, 5.935231331785273, 3.125509735240837, 4.8228998395207245, 4.4494113168508544, 3.6637791780190083, 0.030664580852351502, -0.8284445941901611, 5.075615278634114},
    {2.5776971113078813, -0.9988940667142449, -1.2180392278902614, 5.901376661887685, 5.2967117123971645, 5.229101417508208, 5.179249724562978, 4.498365224586653, 7.3248588362993186, 2.65552365286999, 4.20137607687629, 3.729417824699688, 2.5239979758416706, -0.7043608805155587, 0.7089955202126624, 5.220719398432915},
    {3.02690242771202, -0.24758990017170407, 0.1089868112952392, 4.6778764213604855, 4.779693685802485, 5.325858408791054, 4.51172524734178, 3.334891006026641, 5.341246498383912, 3.4662295204167353, 5.206235635271233, 3.960968332311086, 3.2284038484332584, -1.1842880832456861, -0.35402831072981683, 4.90782428005912},
    {3.664028386431158, 0.10993308935774174, -0.06638527279040835, 4.46184563025367, 5.767193303098062, 4.7173711824067395, 5.005524231439648, 2.6572435477051295, 4.7746599512415955, 1.3515233272557419, 4.498517528771249, 3.0334605540040886, 4.394950563724832, -0.528522179546041, -0.6086055033875731, 4.621674472681933},
    {5.384776862298021, -0.04877249549304887, 1.1779421895778892, 4.814020426719744, 5.463865279435377, 5.121739327924584, 3.5840109012148167, 4.416350923930799, 5.632446970219066, 3.481665722738724, 4.834531600675769, 3.067463136828969, 3.4648355935143007, -1.282506163015285, -1.2252097977137357, 5.375041931411891},
    {3.2648362104171125, -1.9280519185753062, 0.85564713296953, 6.507178677837226, 3.4192627888055824, 4.442447987391121, 3.8490636253246446, 4.438755311738882, 6.9655244183819445, 2.8038511749614163, 5.576928204246874, 4.146116696744772, 2.6533422256762385, -0.8478404027404858, 0.049677585591408384, 2.7753364112977965},
    {4.677874622619948, -0.4964223575344383, 0.2647110378509718, 4.0844066427071555, 5.712684987003134, 3.2468057724215447, 5.137740309710255, 3.9831117531830995, 4.306893464154272, 2.5172511972870817, 6.14573872519079, 3.8190168913076756, 2.947607754137518, -1.480419609910508, 0.2594098541326834, 4.240018598005848},
    {3.495488106693756, 1.3663092500179812, -0.8060213939697938, 3.301010348502593, 5.285635960279473, 4.137525759360334, 5.903525267692279, 3.819401352064496, 4.323934520731181, 3.159331925308007, 3.997286502730272, 3.866446355456102, 3.356760550759748, -0.36719046880779965, 0.9496231894513125, 4.774254328590803},
    {3.5914186176260015, 0.1932243577131766, -1.432623859305349, 5.146270161031814, 5.05050338928254, 6.128279151434269, 6.646306358985311, 5.752097331828785, 4.996418086568748, 4.6060955019886745, 4.838110752418149, 2.796672042687498, 4.610492347918977, -0.6605614432375218, 0.33619185853320566, 4.981311566979128},
    {4.082950578619396, -1.0250002351796974, -1.866504205010208, 3.9549979943479907, 3.2419274948505685, 2.114683027077539, 4.1472452216946705, 4.18706491118347, 5.590175766261276, -1.0246582489767992, 4.891728860590326, 2.577358028456581, 2.200019082442053, -2.0933779539512916, -0.142939026199786, 3.472938353837498},
    {1.7142673946684326, -0.8887586071803638, -3.143766704250217, 6.9745559737175205, 3.5695270463446014, 4.93650803627382, 5.147545593411301, 3.9778813544636806, 6.29469840276942, 2.433056855461119, 4.806624102948041, 3.0566752117447864, 2.843619124504729, -0.9181020757378029, 1.2037191750624079, 3.6433132939526605},
    {3.4323749162166344, 0.11712782947844488, 0.6476990281215248, 5.100334628041171, 3.580868450483635, 4.146956310754486, 6.525471162158055, 4.0150375080801615, 4.523934336475314, 2.2435442469940043, 6.145289311839196, 5.105110911080694, 2.6230240364947415, -1.8697534783194023, -2.2962589723477898, 5.912363279480935},
    {4.357954444406597, -2.5796958522296696, 0.6402367797982175, 5.083950481975146, 3.954489592042035, 4.644564294557452, 4.789747018233468, 3.542136216016066, 6.392651959206247, 3.111257089859628, 4.5269505485743915, 3.0837926716458557, 4.006008340831251, 0.22963234485706824, 0.6502070428916294, 3.6237079477613343},
    {3.238048591666944, -1.4105253895441345, 0.5730115557022022, 3.9914258227578556, 4.336588618611004, 4.6761008869739555, 5.177897170026061, 2.490586656511109, 5.158995883717729, 3.109944042076784, 4.077072103063946, 3.2356084874355138, 4.965645948595267, -1.611518677246297, -1.1999234736741504, 4.0325495862000365},
    {1.5656697791447252, -0.3651113966868775, -0.7307291519299723, 6.091757322630114, 6.18782149875495, 5.487253628475239, 5.892978202090428, 4.435653796392426, 6.717820181998921, 2.9785995113016024, 4.686329312564485, 3.679935338194461, 3.5415362330778057, -0.32893358000061207, -0.13154124085052318, 4.140215134682169},
    {2.8767810859186236, -1.3985120677355845, -0.7250962965632147, 5.844085514119742, 5.107754323734332, 3.0501308568259837, 6.380570311790306, 4.146465045777598, 5.74492686072075, 4.301035955232254, 4.653108306082372, 3.0992599670959775, 1.5177332320087475, -1.4960030796796318, 0.24580462893310828, 3.745133945633841}
};

static const float b2[16] = {4.357535421228031, -0.699423676892845, -0.6524768276797485, 6.379174668982315, 5.4179316891214535, 5.702372092211306, 6.086672060495248, 4.646134336979409, 6.702422871042584, 3.5162388833312272, 6.489622263172272, 4.169736578348789, 4.472162852855138, -0.526683802531545, -0.15664159967667815, 5.30321088186469};

static const float w3[16][12] = {
    {-3.3955567881446527, -2.0421092613090446, -2.786097991770945, -3.559347149960687, -3.8220179960053686, -3.462875585338809, -2.617004750221365, -2.6204137747553258, -3.1713990589303904, -4.955663576862835, -1.9264126279599056, -2.2971208844476356},
    {0.3373056103044586, -0.08214433001422765, 0.8865737987174411, 0.5922137768775635, 0.18128884471332185, -0.5824306047901938, -0.009561537819346084, 0.7046127807663025, 1.2065659766754508, 1.0506294937050662, 1.3691842587310241, 0.5584476424483663},
    {0.5675709076677894, 1.0656103907068506, 0.37154715406879557, 0.3971255091230803, 0.4433058662214274, -0.25890659408229544, -0.998798842020775, -0.6921715229327743, -0.024431209118077862, -2.6092747749782212, 0.41537453804154556, -0.7274636753512524},
    {-4.9965634061243245, -3.483602382223734, -3.6693478613271266, -4.2945111121914925, -5.060801798076357, -4.379725331103523, -4.491581905272941, -4.585493896672842, -4.341279410695001, -4.601889465402314, -5.12312970135682, -2.8866477262216477},
    {-3.34603334674281, -4.223581513238997, -3.063542186838023, -1.1558099182158497, -3.662987334222034, -4.6795232847847625, -4.526585948615203, -5.973064200487739, -4.518005709536871, -4.314223873449886, -4.501295789980083, -2.9791782085507},
    {-5.131742386327043, -2.7883696038328396, -3.58994074746477, -5.795752321371618, -3.7119784640656306, -3.3388870833006674, -3.513044667952332, -2.5827099281059147, -3.5423853057515005, -3.6021068588773124, -3.804211081147408, -4.134093435355725},
    {-4.7164979539915795, -4.203398823681907, -4.46217879570281, -5.134652085054977, -4.364634378433041, -4.113579283062899, -2.9859727553552573, -5.408881694824452, -3.333678360197698, -4.604511932789034, -3.60916702945113, -2.2930224067017972},
    {-4.545198865107346, -3.0597939372254985, -4.0696732131565865, -4.468005244312834, -3.038061785782762, -1.9889066121269108, -1.7810311471809372, -3.909891897683941, -1.4613872496450115, -3.8540590237365606, -2.8958144911894386, -3.899081232457856},
    {-3.0152958340855966, -4.225422507413011, -4.232356849967052, -3.611115912294027, -4.455674087792083, -4.381705204216949, -4.448910543439121, -3.3532051123148565, -3.077986492403721, -3.9144551718032092, -3.6969319224310198, -5.273591828634835},
    {-0.6492798448244048, -2.5056977952053505, -2.4288791973287047, -2.9745498363837903, -2.6005741439362575, -2.5264819856488407, -3.57834081089896, -2.2198859679539997, -2.79912805776586, -2.589439944724345, -0.9382964170188802, -3.8798195796541726},
    {-4.469093172382898, -4.836209357894247, -4.528807931419394, -3.9949141029778006, -3.3427193699688713, -4.90532069937199, -4.484854843280412, -3.0926151852063817, -5.301886567800768, -3.068798220367312, -6.196916037487444, -4.096800021782138},
    {-2.569854653053463, -2.9537990193564467, -2.991522792728552, -2.0810382328857386, -2.4822892485817722, -3.5789379756729005, -3.4382125066866656, -3.607222086861749, -2.7426698607056097, -0.5984655699219312, -3.0731148740832985, -4.666022525198804},
    {-3.768295219288869, -3.501167840924938, -3.080532144295101, -1.179458265571003, -4.057659761995605, -2.7047161783181233, -2.2671857761611505, -2.843865195733576, -4.593576528471892, -2.7607181511367638, -2.936888086407438, -2.653289975656113},
    {0.2543494241920425, -0.023205209004265117, 0.1941135251959669, 0.9318608968798315, 0.22948375743437383, 0.2936228528553477, 0.28138082929578717, -1.805874821074909, 1.326071508320628, -0.602642346929392, 1.2138493735479001, 1.185676083401847},
    {-0.8485374926740219, -0.5582309534084448, 1.645589588569114, -1.2083768574736904, 0.049134312954036946, -0.5760957816330374, -0.9469615349595331, -3.3441891088977145, -1.9603964346124585, -1.5645248084430463, 0.16956881158674655, -1.7883050238739902},
    {-1.5837956718646413, -4.566540227748917, -3.6531718770867565, -4.058067380085642, -2.1607895961554378, -2.2620167417776527, -4.383687557202758, -2.4319141589657045, -3.9471303340076984, -3.641745412202358, -2.698694969570023, -4.42674133262081}
};

static const float b3[12] = {-2.765005503108136, -3.0320663747589194, -3.1819479158419526, -3.0671740959696887, -2.8022855786521195, -2.915182071058645, -2.978881963421597, -2.6901501425648555, -2.5245169604748936, -3.157538451363281, -2.8502952145267484, -2.9523975113172263};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
