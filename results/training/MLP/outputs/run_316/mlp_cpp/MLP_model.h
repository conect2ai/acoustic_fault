#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.31477309715333224, 1.9187215990332398, 0.6546101876401286, 3.1857883614497364, 0.6793798017232497, 1.1674311021510089, 2.123521113161177, 0.508880103261861, 2.988850297125744, 0.6168125551805581, -0.11561262723416224, 2.8822094041816055, 1.493299926824563, 3.0679257844424743, 2.8541330872296267, 0.757162538378281, 2.9829711026572707, 0.1252233042096541, 2.396828980241791, 1.1883489173268766, 0.19794376205305886, 3.0645840914633977, 0.4724529892876867, 3.019300430646124, 1.672694790418994, -0.4992039721772512, 0.5422746652754301, 0.8260353582110067, 1.6031863341871366, 3.2381465499510687, 2.7998687539467393, 2.9129152395790157},
    {-2.519746756549357, -0.511724872720366, -1.0887098140623221, 1.8699942207338496, -0.45742554184405854, -1.2966602986672358, 2.2105416419402926, -0.48753874725617874, 1.6672171084443532, -1.2092610933746997, -1.8346335794542643, 2.1892421801100865, -0.47751334135394014, 0.45131230772927056, 1.9132574089979812, -1.5048426347390238, 1.9085117221646468, -0.9056216954992626, 2.340227230004866, -0.1260622959642447, -1.141532434882999, 1.397613904620158, -1.6941577589451202, 2.578208642518147, 0.2821074167846073, -2.3534879512762923, -1.1756977199608194, -0.7465786026997148, 0.34548857197344823, 1.9512673802429785, 1.8342160949623019, 2.423818110850369},
    {-1.6033408125027948, 0.6122194893849336, -1.2834718376901817, 2.7055614186800283, -0.0594553464661204, -0.9794967626357032, 2.479691942859484, -0.3985492001205555, 2.755230765467975, -0.9933720304295118, -1.6729324212859746, 2.7555284680937127, 0.11377591535388917, 1.7866170161113129, 3.0922734062402815, -1.1041926389247796, 2.955234199948624, -0.9576783462946709, 2.5981230577594987, -0.7241288298276874, -0.5423177581135511, 2.2930104248589114, -1.1350081598513728, 3.029486058190128, 1.039160254865044, -1.9069411187324041, -0.9787977169931801, -0.5195422218815818, 0.9869519006647464, 2.931594436053605, 2.74781893491256, 3.2323380242664976},
    {-2.8094951298400948, -0.6727052794048415, -2.4697491104100138, 2.4584730619204413, -2.5088371772769764, -2.163163223441526, 0.9651450727498424, -1.9767897675747241, 2.2911190557366514, -2.2267360466254575, -2.4533964350765123, 2.3391049644370807, -1.708558295741356, 1.3015807852000894, 2.664693069183111, -2.3436243142964166, 2.7094077603317706, -2.6173769122935755, 1.9389449826576612, -1.729437311021148, -2.4845139337543483, 1.9627951671640422, -2.546570411648553, 3.052432897439618, -0.9460153822406395, -2.7535320108329464, -2.2291297682350755, -1.974583270959516, -1.0461115001400199, 2.507278929706792, 2.1904255119045777, 2.5619059174459644},
    {-2.3310443373932017, -1.499115790655302, -2.761733397602124, 1.2532109856296774, -2.7522283669679264, -2.4306052288497986, -0.3209287053519557, -2.033974193274895, 0.7938514119609864, -2.748595273547476, -2.7563369495565744, 0.9676644091588295, -1.9841208327764164, 1.0336241707896112, 1.6472791416819106, -2.631739965087106, 2.4095712161684464, -3.0224919746964036, 0.5397257472257164, -2.5868247651158045, -2.953163960607584, 0.24826500515144015, -2.522589213180984, 1.8059233600169957, -1.842377401169079, -2.820576204261128, -2.4671000643229672, -2.6487724572297675, -2.03044994826945, 1.3506094383676126, 1.3570992928657613, 1.492464008349744},
    {-2.4167051642281008, -1.7677670796206542, -2.966339791976987, 0.5787635680725175, -2.399993072580846, -2.358374278566458, -0.765799160797144, -2.0629245156923277, -0.1607689391452193, -2.6568874601311534, -2.58065055045495, 0.6237995551492557, -2.1224486983122843, 0.9314181759161799, 1.6978204981407168, -2.621443427775624, 1.9281872931161266, -2.8082975328667668, -0.07211596806037049, -2.777529015528823, -2.4412816189775697, -0.6209094428991947, -2.521341897883839, 1.009515509745962, -2.073141639954188, -2.7482795403818425, -2.665599784280659, -2.548395598248306, -2.1771105997849487, 0.7684715357559495, 1.0821928074233655, 0.6812089475345604},
    {-2.5744066291754337, -2.0420302173760545, -3.0723667083792563, -0.23377635787671475, -2.503917904204634, -2.628032085018769, -1.0456100715851586, -2.0113067788328727, -0.6931524304620433, -2.639193423150755, -2.8995128878577363, -0.02168097335703184, -1.9801380175814136, 0.2597713537911019, 1.290230325563193, -2.857130875897562, 1.5871475777066064, -2.6278123450218196, -0.38794238416645105, -2.948721741881642, -2.407516695526875, -0.9338947893424493, -2.4489502026239696, 0.15862371854503038, -2.137091646211154, -3.0750798797482304, -2.7463324422390047, -2.848367699776616, -2.2136595668885444, 0.03153176161128804, 0.7819943498665154, -0.10783012565514233},
    {-2.924269729323187, -2.1944422560419747, -2.9426134335055605, 0.5624495873315137, -2.928873884852749, -2.861342470799197, -0.8835117592632002, -2.403264560965695, -0.2472836161508145, -2.5761215430690716, -3.227679755692668, 0.6600979027557884, -2.595263168818757, 0.8100668178207802, 1.1631703942315061, -2.9123300156477385, 2.0408004762976666, -2.903132789315029, -0.05959558443112037, -2.6156700832995647, -2.619452986629023, 0.026391774424023632, -3.0309573986827956, 1.0152195679923717, -2.663477899156276, -3.35208729825256, -2.8637157473074617, -2.767344209947385, -2.4837211987696497, 0.8176300373426556, 1.1718201760316227, 0.7243464200884275},
    {-3.085498635351073, -1.633066224329289, -2.982307923729064, 1.311447060043262, -2.6422009355410347, -3.0934106405205033, -0.4588688994004712, -2.403980135545723, 0.7454059345172567, -2.407205950825911, -3.217243375931264, 1.229524567183914, -2.133458711377208, 1.0491791452389558, 1.4701359505624096, -2.4911226009132825, 1.9211444026767768, -2.7577754594254236, 0.5501472923963328, -2.2831233341121098, -2.774895652168928, 0.7389720132613958, -2.7757965046570545, 1.6020872525338943, -2.329097978319633, -3.094392963953482, -2.7613054947007485, -2.5410735257826835, -2.4858183293639633, 1.48712798874233, 1.376660358888363, 1.7782963061680486},
    {-3.2741214361465407, -1.8577868525029897, -2.7760710820980763, 1.544899311524355, -2.520633513929452, -2.938087110451499, 0.12060318241109556, -2.4343766955210566, 0.7764163422615076, -2.6153821809704874, -2.891994447717308, 1.4777351832191252, -2.2852106510433727, 0.7847165836029188, 1.763149172614248, -2.979203029971422, 1.9746205624066022, -2.8422572882165404, 1.0047190255230796, -2.583360757789093, -2.750085975549004, 0.8139479504783316, -2.8468516330876077, 1.8875889938734318, -1.8838183974635851, -3.065689196081526, -2.648615647963674, -2.5306710378450274, -1.7084972613285523, 1.5078121043547792, 1.3871681105642433, 2.0484846589543713},
    {-3.3344680325722553, -2.188342147737884, -3.064078535251445, -0.040419147089102214, -2.561861415081941, -2.8492013201227504, -0.3687183983121217, -2.5787887076030453, -0.41365185155698314, -2.5343664103517116, -2.900381438892663, 0.3161422964747853, -2.190707756958264, -0.7103367828260616, 0.23083406838495316, -2.746189550287391, 0.4451032096364693, -2.8514378869905763, 0.2376189884338377, -2.407416614142069, -2.860852525189233, -0.1885901248401252, -2.8907530804915194, 0.6595736805019946, -2.4415866732118987, -2.9385730364027247, -2.743494461553153, -2.6347421458769187, -1.9219561478190899, 0.27161334027105755, 0.41471705826739486, 0.9554540771328197},
    {-3.408748061858694, -2.0407364251095212, -3.0737492939244566, -0.009617276444926423, -2.5600131302780347, -2.861942119711001, -0.5174903548914245, -2.339032420075395, 0.019647585699031224, -2.7700324982653814, -3.0762684550512644, 0.9148836193918738, -2.350511079217876, -0.22050877934192922, 0.05255330495205632, -2.7762062887763883, 0.3422954129024125, -2.6157945809843928, 0.3654706098367135, -2.3389017281914226, -2.718060281932645, 0.39613856325997815, -3.086832883136327, 0.5993238284914252, -2.3784578518035477, -3.1190841110117247, -2.633040499281527, -2.6263255125925005, -2.3038040601511454, -0.19547382457097026, 0.43191767122768454, 0.858030549650461},
    {-3.239026169982755, -1.9249860560367682, -3.178401489328284, 0.42418143512106204, -2.436654336291114, -2.822249817989505, 0.13921904482470432, -2.054487257150862, 0.6336116324329231, -3.0641984563266513, -3.097598312154307, 0.8929833141585914, -2.115249198136197, -0.25115683538238337, 0.5332884539215991, -2.9030525244180327, 0.6464665147987892, -2.6890110117737756, 1.0353773418104533, -2.4445043720266173, -2.452074687287324, 0.4016011170394578, -2.7095033649671603, 0.9762560698708009, -1.5646534698965133, -2.9815439338123406, -2.4934893897372774, -2.663368490755476, -1.8676662675225055, 0.3732081729310903, 1.049262732921841, 1.3862084142923825},
    {-3.183575140342444, -2.10652447061739, -2.991853951319942, 0.40528809230810464, -2.458525151409607, -2.905047570313738, 0.7750824604074439, -2.1507651292272616, 0.7358280039732406, -2.778613526380804, -2.9646356645352143, 1.28504738730046, -2.120115922024449, -0.5634863578564527, 0.9073395665581808, -2.797278823817181, 0.8589985799196703, -2.458257353441278, 1.0062980328496858, -2.451974293776595, -2.824326724317444, 0.26134117889713393, -3.085929081736808, 1.1510760435108527, -1.6947772388085431, -3.220710805421556, -2.6986429020543325, -2.7011741458105414, -1.591379996236239, 0.8110019728119946, 1.0695121140573514, 1.655648608352744},
    {-3.203103764155868, -1.5335358092651958, -2.937210192798628, 1.441730315176719, -1.97542394284748, -2.881409228967614, 1.3835845694074311, -1.7870153917415654, 1.3362106006008172, -2.6790330782399305, -2.9729087544195023, 1.8001301514095378, -1.645514413088445, 0.3138096928654703, 1.5959923476606366, -2.9941438981587423, 1.7054243194244685, -2.325924022862657, 1.6358117056146637, -2.053318489558667, -2.6164473476413925, 1.3422755696743587, -3.1270328300371344, 1.6643144786793753, -0.9711524584120842, -3.070694410385651, -2.38927233137838, -2.428000074745844, -1.228518343908359, 1.3984555355680353, 1.6715871431313314, 2.348349931825168},
    {-3.2668813211593877, -1.7795551910905858, -2.754960495397267, 1.6124402838826477, -2.2874832032726506, -2.663581689510636, 1.1027942725094915, -1.9674677973379864, 1.5827788598411656, -2.60894274320777, -2.7113676675953364, 1.9549328447840988, -1.8997013461713628, 0.6378020818361838, 2.114201234553514, -2.6893361913297418, 2.269559918601819, -2.5752855610986995, 1.9280376755179605, -2.0838478874944086, -2.5739269132077784, 0.9875249453877463, -2.8060505022553754, 2.2110422718627354, -1.1885342858154697, -3.0844569668652917, -2.8674949878994775, -2.4026042103896477, -1.2543522174528787, 1.9232020647527652, 1.7793600777826892, 2.2788784076403372},
    {-2.969641494647515, -0.6983460632498432, -2.330899575746151, 2.514721409904625, -2.2123832371109042, -2.155701024889185, 1.8667104568896238, -1.790498673108993, 2.6845920071465774, -2.338808400743174, -2.6294707283428003, 2.4487612116253112, -1.3834724990301646, 1.4546799582991559, 2.6524406048687115, -2.1953281708364187, 2.822510896139815, -2.5615193538335435, 2.6438722521773315, -1.9276490948627707, -2.1815483033678293, 2.037331214441524, -2.712856120598492, 2.729744012375551, -0.44137308756596866, -2.9433632884800898, -2.2243680374173276, -1.9408094833183553, -0.6985769947981703, 2.402875273590564, 2.2062420697500564, 2.9404825406821167},
    {-1.9753037624762757, 0.6515248494273012, -1.556914475271541, 2.8212857725897935, -0.7898766024160401, -1.2112705927169205, 2.658422077431593, -0.7512536989570419, 3.2605227943848316, -1.2654580019357629, -1.762233089012525, 3.0143361431926965, -0.19883310794549813, 2.0894298242268783, 2.789375595187902, -1.2524646343432897, 2.9745015532478916, -1.4441442131818734, 2.8867123313783547, -0.7101566391146309, -1.4810830260991215, 2.913021257054942, -1.601121555458975, 3.1980327209225865, 0.9482257746908461, -2.0557990605735537, -1.1175543391480456, -0.8545745209093631, 0.6714106017074033, 2.909091935268192, 2.6959177342330336, 3.0784332504480725},
    {-2.00832999396771, 0.19262823647483207, -1.8976475287514827, 2.595959821508113, -1.0119288835282965, -1.7008776344129382, 2.0612261445396176, -0.9133664817333724, 2.840346668127653, -1.8491748551120948, -1.8776293522852157, 2.660508897867662, -0.35936193224797014, 2.0721170695685824, 2.8247480172077535, -1.7643776918615366, 2.604325354632063, -1.632765281188557, 2.698459120742838, -1.3271639252405105, -1.3850393355994177, 2.644402491027091, -1.792818907533514, 2.967453208925992, 0.8002666558550071, -2.087911537342805, -1.6330933054720558, -1.6294008582910107, 0.35323733671115537, 2.776046491364148, 2.5678622771869364, 3.2105758356979215},
    {-2.8257580321700035, -0.8793511965185428, -2.4364234665686406, 2.206653075810831, -1.6501563408704842, -2.432574615758962, 1.8536222797969784, -1.5217579282394142, 2.2026021552998154, -2.4396791000204257, -2.648290926455287, 2.563403264416658, -1.6881283690226334, 1.3546648113898718, 2.4987274435265063, -2.5161388492311896, 2.519109930295176, -2.272214487469034, 2.2459927242981914, -2.0264570716336343, -2.114428228562068, 1.6365197994289573, -2.6787677574213284, 2.714909843389835, -0.31838495807211803, -2.602812880393233, -2.1384796723135446, -2.159026045207395, -0.713113938396174, 2.27173681825662, 2.1946422954724296, 2.7916450980487877},
    {-3.0200777368617944, -1.0594124735943822, -2.8324574254455466, 1.9605343024030446, -1.824958030032245, -2.7351754785683493, 1.5682670944407444, -1.7191444139874523, 2.305397439094619, -2.3655035711463315, -2.729311801527704, 2.39679573194837, -1.6971289767538469, 0.5532652697413803, 2.2470558081572567, -2.583286479399377, 2.446196834850804, -2.31954961475677, 2.580240508306399, -1.890918141003415, -2.574306924700441, 1.8756961055760022, -2.7679304715250863, 2.754483633541214, -0.2972531554209753, -3.032944741467598, -2.5156867960585454, -2.2497052540776465, -0.8645229374560649, 2.2744146907232348, 2.290558856491746, 2.9561026433442543},
    {-2.7445579223431116, 0.2324693350891086, -1.721302744097711, 3.0975848762569225, -1.068917895028597, -1.324620256642495, 2.091687771411575, -0.9774753566853847, 3.301142063335656, -1.659044633247776, -2.267789752735817, 3.161309692021555, -0.5625043929910548, 1.9489542552662293, 2.71884958202055, -1.572129588930119, 2.899507690498872, -1.8312614580556532, 2.832136676291066, -0.832483057274019, -2.0379785831583197, 2.945740185446394, -1.9884776538712199, 3.382722291361249, 0.927436068988424, -2.348776467523372, -1.2442447997485493, -1.1938289081750466, 0.12275387234482305, 3.2366198095292638, 2.9622389155685305, 3.2169981305964654},
    {-1.5697811448780008, 1.3213172452795474, -0.6150112088983837, 3.2080005840249495, -0.0244077274077888, -0.14959334330151902, 2.561216252672899, -0.4045888441332595, 3.3374934039434048, -0.7972248085533463, -1.2039134903357436, 3.1697726577670524, 0.45537639417727427, 2.536164744620755, 3.1170399130871687, -0.7535872421049268, 2.9214410456642614, -0.7288883981181669, 2.9397002808661776, 0.21400075526766324, -0.7978596051329271, 3.2822402648240625, -1.1813794136091291, 3.528899552347002, 1.243011638965588, -1.6074082786917379, -0.6303719156849106, -0.14295902535808702, 1.1656980932878351, 3.314533482888677, 2.834375903249371, 3.498809822709798},
    {-2.5470745350309296, 0.2641668997781596, -1.3808991410279232, 2.9841194919155405, -0.9370918627641596, -1.3538740573942831, 2.427652422888064, -1.0648365556565067, 2.8166291869245557, -1.7724946671634005, -1.9972858046753035, 3.0322383910302695, -0.2322928089048813, 1.6517448273781445, 2.7538833676015346, -1.8194420475611333, 2.7182342730163396, -1.7210230674244484, 2.8085575909375162, -0.8640512812802975, -1.6363724010573926, 2.46410709410718, -1.9450540801388136, 2.9788873164131733, 0.7582972603890288, -2.239562861895457, -1.624140200283402, -1.0920491921556175, 0.40426968145687714, 2.7547177707993726, 2.6140110642274847, 3.2526068300225024},
    {-2.8961436588118143, -0.9328492867038448, -2.081548600605851, 2.293144949769807, -1.5798859003416694, -2.182025462471123, 1.9937845288203417, -1.4759888768218437, 2.154303021895491, -2.362437772370948, -2.725049441969866, 2.351869416741522, -1.0973710812002397, 0.541136338550996, 2.2239877778285075, -2.1942424761409427, 2.499143779866015, -2.289599788645251, 2.321829711633661, -1.605430900391958, -2.1621274356384865, 1.7893187543897011, -2.6094080834514637, 2.727074982537161, -0.188531852461862, -2.8295541289816333, -2.1801012836879345, -2.040262397408003, -0.5344621576732346, 2.258831115252981, 2.2905004647564895, 3.1344613176842087},
    {-2.3452429623431477, -0.3398165959305885, -2.0674580986448574, 2.5527606151101465, -1.4128774791433765, -1.921305968388215, 2.1577498677968214, -1.5959807010303984, 2.547001732251401, -2.0026500711746715, -2.328238564590712, 2.644422018219869, -1.029749969410428, 0.9321881076765841, 2.534711190573588, -1.9772347921413704, 2.588912729131469, -1.8157253118891643, 2.5832602777308367, -1.354680884007585, -1.8290290565574912, 1.99456635530641, -2.677228052904069, 2.6336621452820883, 0.44936514956120555, -2.5673648205025996, -1.9606027163087527, -1.6976505716320818, -0.07353964207630502, 2.4894981877016313, 2.2472935673378363, 3.171508215260956},
    {-2.4088726055557457, 0.024982811416418605, -1.6108546100954888, 2.7441544791536447, -0.9588054795944511, -1.850981984816044, 2.5220434249141954, -1.0012009532439248, 2.8047128681587146, -1.7520224390106631, -2.432408491111378, 2.7457017084981805, -0.5641659658637106, 1.6052774042694273, 2.649807709610361, -1.7782983883337595, 2.8261067073136865, -1.4766053132831098, 2.7240835032911463, -1.4223964223859114, -1.8520318890678928, 2.4241439798752062, -2.22900664207629, 3.0832193647692963, 0.4510564128330078, -2.6426286052068018, -1.7189432579489115, -1.2251533636010234, 0.3934764632600116, 2.7811274247657627, 2.6424895436457994, 3.1964686377837888},
    {-2.7761505656390537, -0.3513435163865594, -2.0127392829610566, 2.7600238222057145, -1.5489126049242985, -1.909595851060638, 2.3115343341271704, -1.1711135531004984, 2.710527294708168, -1.9707945921879995, -2.302769404777231, 2.746989478825996, -0.9546732875217714, 1.2024186864022666, 2.7185405524741, -2.0729186339671766, 2.7458530381121964, -2.0558836698825753, 2.798163238746273, -1.4428246404532952, -1.7130500221764635, 2.2632697584494528, -2.358997944072045, 3.2632746489450293, 0.45087233267650106, -2.6839553074851117, -1.955923351341656, -1.7227740346208282, -0.04925924424903348, 2.7976732130274122, 2.484474527273699, 3.1025452505138564},
    {-2.583884605447675, -0.40345287302248967, -2.1042467772095512, 2.4384754285805985, -0.9932817099584622, -2.143454336066489, 2.1927157857130344, -1.330849436206393, 2.38618632904349, -1.8752502635670218, -2.3120185005522247, 2.8928851151416204, -0.7411496934135725, 0.6054846319117271, 2.519837976776518, -2.3468538166348623, 2.563200323246969, -1.8230095815853211, 2.6012674722623985, -1.2207271037391905, -2.0162470894831417, 2.3580981880014362, -2.3943847846575155, 2.749729198398814, 0.5789182455526347, -2.6886387331543906, -1.9433261272943525, -1.5998562230944215, 0.22719179611634485, 2.5965826920989334, 2.308229765652527, 3.106082072872969},
    {-2.7883829310941137, -0.4300142279269551, -1.9596780549082062, 2.717158083123961, -1.0533339046224077, -1.7621845686429989, 2.441335517219405, -0.9377122073792472, 2.4546094751024774, -2.0449879515317186, -2.382241898057967, 2.5333507722853343, -0.449744514946609, 0.92179397474952, 2.740767531273356, -2.004745305441794, 2.4010305539767156, -1.6372746180046518, 2.6316993484832216, -1.015801594978772, -1.7981068229447619, 2.1879602563512335, -2.2974521405035206, 2.849672918645169, 0.5721305296604766, -2.631715391417768, -1.6040018081753014, -1.1359209101771766, 0.3517578169800637, 2.671893207874814, 2.3196913820794607, 3.1265676839399656},
    {-0.38861801018697734, -1.4366662211280385, -0.967666118835223, -1.6669647143903665, -0.16774629360552443, -1.3294947143464528, -1.0451053256394685, 0.0980176429978304, -1.8393600830536805, -1.0613987647140284, -0.8193066686071204, 0.10745450721377489, -0.9609906440695594, -0.6604090162807066, 0.24395612862720042, -1.2457666995016603, -0.08582080712407861, 0.05861075844062747, -0.5485162297636833, -1.407118221076283, -0.04226136671607693, -1.420460170538086, -0.7840576691439832, -1.6640386739287516, 0.40450314531067727, -0.625197955454861, -0.7389887380978366, -1.1402745532151863, -0.02378695741155953, -1.6408183749687977, 0.18118883683503947, -0.6486636286316102},
    {-1.8473562198124163, -0.25750658222545764, -1.0109183330692293, 0.7936824547670187, -1.0509097558304277, -1.107585559048606, 0.06377635369810421, -1.236777208766004, 0.8746212569800426, -1.1875593849470405, -1.5738379866563803, 0.8480063737344631, -0.7412091621686724, 0.2269625529109335, 0.7903023929602411, -1.082827176074656, 1.186401629069352, -1.4263890921824642, 0.31256995682153466, -0.8979177275264517, -1.1456490745333672, 0.7464554304941066, -1.1084324795808402, 1.2473143466945196, -0.5267468791686044, -1.8488398202145193, -1.5275958253559787, -0.9404870778711228, -1.0111669684342237, 1.3230630073830039, 0.7047026604726487, 1.20571415558339},
    {-0.12799555305122962, -1.1467388398618532, -1.3447565136671864, -0.889677727363426, -1.451175363221037, -1.21523756610295, -1.679378794622941, -1.4897458082714177, -0.4559829396327482, -1.2956271691143344, -0.7775902268194449, -0.38812339672124435, -1.31506603683908, 1.0802386867921265, 0.17746158507647386, -1.2747969941914719, 0.041810416932774326, -1.6716912902893497, -1.0882574947439616, -2.0398573368133874, -1.1294188541426704, -0.6784963278693609, -1.0121974507917546, -0.6381304674455536, -1.1715416519113555, -1.1288786624711564, -1.5562941332386062, -1.6763239128241567, -1.2496066339310834, -0.3249022836878022, -0.11930988836750009, -0.9651842735895979},
    {-1.1481450155321418, -1.3992904047651196, -1.3807133117387704, -1.2254412203136174, -2.0457540596406623, -1.4124361718063176, -2.095860292994287, -1.8066284884368529, -1.3630771058297972, -1.5960651946031041, -1.6099069811184057, -1.1719770940350753, -1.6722571180314867, -0.17447819110112792, -1.4714563161115888, -1.181163960408324, -1.155462425852477, -2.006704042391615, -1.5778670564625736, -1.4547520054246614, -1.8009662056196092, -0.7517567308560247, -1.3772875871573291, -1.2261155119361877, -1.9780607003534822, -1.4166776937907046, -1.645698328784444, -1.591179943236265, -2.293317004999945, -0.817557135574207, -1.0623585057586065, -1.282322683783561},
    {-1.6207945118279035, -1.9479871808376075, -1.985232413912497, -0.228026467120351, -2.0148083961102197, -1.8610078805984611, -1.7163344235072255, -2.3206364734334013, -0.9610005459504132, -2.029871005939284, -2.1250184166273316, -0.578868586162065, -1.9357269425601638, -0.06045967897834377, -0.7639540805361427, -1.8766335955407358, -0.33645320682603874, -2.1047383215487288, -1.1997232117262575, -2.2132867177483697, -1.83013420663437, -0.903113901348808, -1.7425069101997879, -0.4688883784647391, -2.0082276212663905, -2.2380765703526215, -2.2911374397472986, -2.144829955008563, -2.1973040124162453, -0.5104756773537141, -0.7903187891029345, -0.5179767029126936},
    {-2.046994689095638, -1.5301534255045839, -1.9021587736812942, -0.2952069385954083, -2.0879135544080083, -1.6298923977927655, -1.5718975191444806, -1.9292343529329414, -0.49403423288301435, -1.8062246295097035, -2.138755779274776, -0.6331781629507605, -1.6621017394547852, 0.47798227344647687, -0.21017861280168745, -1.4267901154796387, 0.005744578166030619, -2.15492100246549, -1.2268233941134197, -1.802869325589846, -2.0913791315689396, -0.34468256766447236, -1.752982675388838, -0.19645840609965137, -1.5455229472681076, -1.7901113548794567, -1.901707312585379, -1.9203383337502018, -1.8322569324609674, -0.13518241586260796, -0.5867968140627525, -0.9256275050318079},
    {-2.064349710340601, -1.9363757485133444, -1.929772972991992, -0.6565031086282099, -2.1669638535341744, -2.04130510998564, -1.9209173047757093, -2.110515955247286, -1.6890337325651816, -2.0608995355502615, -1.9897156876097277, -1.0664424018560337, -1.8785183732949853, 0.1238277552173813, -0.8565653519171015, -2.111775911270768, -0.6897578133262017, -2.4422097599707806, -1.5095971026165071, -2.01180015141218, -2.2189407356493214, -1.0065642889774364, -1.9138190431258588, -0.6829243146213505, -1.7798452454778246, -1.816276566981025, -1.9861344214006496, -2.151313109927855, -2.449941643630542, -0.6637200888292856, -0.6214395060330988, -1.1658887200476058},
    {-2.0536273074002693, -1.627606287711845, -1.8983194180152907, -0.68519321552663, -1.7718151153717798, -2.056271927597321, -1.7505075711954572, -1.6567889320308695, -1.0024886805558428, -1.8482183017829985, -2.0527121841139517, -0.6295507131162213, -1.7253530445512961, 0.41876082516900653, -1.012187386035906, -1.9117609044923296, -0.921613193395757, -1.6344252001132906, -1.2338490192949607, -2.123914048072905, -1.9475009470332838, -0.7044668940399781, -2.213451306061714, -0.20227883001454974, -2.0499204509641897, -1.9493858864043123, -2.078522166139744, -1.8791342542371088, -2.1468333436496487, -0.27132833857612665, -0.5639950943531895, -0.6594356799129999},
    {-2.03423874007868, -1.5487773181121451, -1.909408441960976, -0.40704722238736907, -1.6091992298578168, -2.2793472812829827, -1.5929263312961532, -2.1797565176593197, -0.9640691058112045, -1.9960230798099072, -1.9298359321564889, -0.814030047016611, -1.733408768847976, 0.34460423736295487, -0.7888399697356262, -1.9605416634510597, -0.5024875741239281, -1.9719084394666933, -1.2864616085201985, -2.25069617189017, -1.833138034082917, -0.7018615030259747, -2.1393631238686193, -0.5076593469083108, -2.1044102663027133, -2.0071611619156773, -1.955671791568535, -1.9354852325400542, -2.08667847264889, -0.26271149951982864, -0.8144070302983796, -0.8913351688277268},
    {-1.8665104051964403, -2.0281082785065134, -1.9965007990079353, 0.1787584973133533, -1.690128017291958, -2.1736518526321653, -1.3730485256256586, -1.709327493798604, -0.822038876978487, -2.1978241994682093, -1.9932496385541059, -0.10601160596684397, -1.8076682495555305, 0.7814236587350228, -0.05823921891682534, -2.2260235918858577, 0.21821650303876133, -2.333704801751372, -0.703038991340538, -2.427361207759834, -1.8809282791954838, -0.7245922232538881, -2.042120568149282, -0.20987049822638462, -2.0432432261292997, -1.978052551573593, -2.1916356714709613, -2.3023231798068933, -1.9618934861281936, 0.2864157711838893, 0.18156883793794001, -0.34443210505619265},
    {-2.1232402199426748, -2.1260048586949383, -2.315116079299677, -0.9037904001788718, -2.231740036180123, -2.3632710293251034, -2.1375410474890484, -2.439117198077845, -1.8459283816565384, -2.147886903149721, -2.2130508955080543, -0.7928304504187763, -2.358933413424283, -0.5559371444501449, -1.1095171264031178, -2.3566846217495114, -0.8740886271607784, -2.1675232319169266, -1.3260154520667888, -2.37142760153991, -2.29234406004257, -1.610349688185646, -2.2278543235577577, -1.4027255876337714, -2.178521041417612, -2.133832010868381, -2.2028458234045325, -1.9448613073069334, -2.0936434106429873, -1.0544164189427694, -0.6006958764434023, -1.2790995247007029},
    {-2.481168373470764, -2.105845965216053, -2.4467572525364254, -0.49351359079649043, -2.1550148213044658, -1.6732173060937787, -2.0286717497000946, -2.2846251506600384, -1.0969633587464473, -2.22747019599201, -2.4049155541337344, -0.7372172510461072, -2.100138325465246, 0.6888627466662168, -0.7484067336156267, -2.2400463364414738, -0.4168316198527073, -2.230537526692028, -1.2115186781942031, -2.3194374288159345, -2.130938956125988, -1.0116426266227077, -2.029615263347254, -0.47247811927372557, -2.3192743062759162, -2.4864713714929665, -2.4955381754471526, -2.1155222859452785, -2.001669312201331, -0.3847448980713733, -0.6112917070967678, -0.8835685122612144},
    {-2.86590804680085, -2.2794270435214075, -2.3970866809532327, -0.9842699159780206, -2.3094889039906765, -2.180074675399586, -2.158704101592359, -2.2860088917579153, -1.7832826728928073, -2.415199269656073, -2.3139805286759874, -0.8084145370475818, -2.1294264271900074, 0.15304149390026986, -0.8443102114996265, -2.408479497192273, -0.3934535257561487, -2.5987442471743982, -1.499376199206686, -2.577570612074645, -2.419435207337847, -1.4865134103843953, -2.1601103147666385, -0.7468448800850792, -2.000568243540349, -2.3442002298686817, -2.514824220397341, -2.5369242482333814, -2.3762292158324674, -0.8296030509588452, -0.7219667127223159, -0.9343571712259272},
    {-2.2885171896247547, -2.1701704405107587, -2.4999301101068796, -0.6012887169654898, -2.030094105885751, -2.3194138199786343, -2.1635524721135906, -2.149498126283405, -1.3965066883331354, -2.356069097718296, -2.203504121421565, -0.9523114174403108, -2.2606051687881803, -0.002902182070392149, -0.5857570316521168, -2.3324428404274022, -0.6913592324384287, -2.5088841104911555, -1.3294233315501942, -2.3476871575750455, -2.424802718169755, -1.0320404100689449, -2.2823444295291164, -0.4707494659986162, -1.8991582058499847, -2.3637630820665305, -2.378754022557676, -2.4088322598729657, -2.1405121068641204, -0.7164679928299899, -0.4848014252586006, -1.1708873159764215},
    {-1.9132472345896199, -2.157563205847333, -1.9611281231665876, -0.27143688421255, -1.9873867309189575, -1.746596031956938, -1.8772639038568395, -1.949546258200242, -0.9297681685679093, -2.2665083574187386, -2.017987535152254, -0.2159913570752541, -1.6038644201648105, 0.8807377320965064, 0.3168606525004465, -1.8456961360370439, 0.29539025764141336, -2.2188185310388477, -0.8699852834752342, -2.287090554533576, -1.891115598716861, -0.6909426225326005, -1.6945809816834805, -0.09680425237502532, -1.5376811378060034, -1.8389821666094113, -2.3656381493913328, -2.329524057162906, -1.7572021292633937, 0.38765203133741266, 0.25397585680252877, -0.7450164751660375},
    {-1.485046177799583, -1.4760539357699098, -2.0331155573050026, -0.47074104717624954, -2.3109752865330293, -1.4853572533179775, -2.0796279709481147, -2.1043882856975293, -0.8359167670134671, -1.5861869259961316, -1.490170538716458, -0.6970256789123216, -1.825236251161842, 0.7014120970235923, -0.38513484878859133, -1.5364559399897937, -0.3221616446171192, -2.128907086776023, -1.230061015693147, -2.093815914449761, -2.1320820213367764, -0.3807225057000438, -1.7281782742587326, -0.30063709738015415, -1.78654800974414, -1.9673688021018216, -1.9635742184746539, -2.017032214880709, -2.4565728322912066, 0.08215857568282572, 0.032401545864080464, -1.1521863316329943},
    {-1.0472402167311845, -0.8034805930864762, -1.1991444755791671, 0.720975789785464, -1.8613109177750098, -1.2817824966983646, -1.551687704195307, -2.007620443609862, 0.39487000018030294, -1.3393585047289103, -1.295573386073453, -0.12490327565297574, -0.9923699321983005, 1.0331035408103764, -0.3305304110319247, -1.369546481692364, 0.18583836673750015, -1.737217726929113, -0.5188055502852192, -1.6213785347655298, -2.0987350072687203, 0.023805357521290562, -1.3000143457876152, 0.37385194695785934, -1.2125336255250065, -1.3518939624067712, -1.6259574258859724, -1.366263853375816, -1.526461479303317, 0.6901421254055494, 0.022732718618936932, -0.3389066676400848},
    {-0.7204387122715524, 0.05705338345981808, -0.3896361587271405, 1.19835896928664, -0.9982430993711305, -0.4090257725974236, -0.5728837089313353, -1.343013352872701, 1.2347822456399387, -0.5589290144824708, -0.8016697603132131, 0.7101013949506108, -0.3814115237598408, 1.3507235133330597, 0.9720513434754382, -0.5572058428743354, 0.9800840395050092, -1.0923996874212167, 0.41102331844782114, -0.8344718196228628, -1.2992043559419655, 1.201626614395994, -0.8763261303254254, 1.1097158695292564, -0.2281021677942022, -0.8359723283063021, -0.6219301417614315, -0.7017540742156924, -0.6007863496484901, 1.7998311377069305, 0.9159975156703731, 0.860260216888929},
    {-1.1153878171186815, -1.416408444688389, -1.4611788693431793, -0.5478937891255158, -2.034762219142087, -1.40434413675503, -1.7657754976310474, -1.924966353159347, -0.5627424639508186, -1.3796324492049894, -1.5649257024912964, -0.7198031215783289, -1.5764685244636945, 0.7683402407618871, -0.9488939231700422, -1.3049983416097015, -0.58163113096881, -1.7962631279794292, -0.8867093883800272, -2.0172499294649056, -1.9530620770142346, -0.5132662022325881, -1.0070008650921258, -0.5325910464607493, -1.6822217537519892, -1.5869283427923675, -1.8843512884471338, -1.8319745631299302, -2.1049177693969567, 0.1231239501673458, -0.21356795573017864, -0.8077905646421143},
    {-2.1270414160117213, -2.3913758823985996, -2.151369944780666, -1.1343923183495765, -2.3239042748182395, -1.9202471248165982, -2.2193947103489653, -2.405306255407201, -1.516385971154217, -2.653743763779712, -2.343723218360638, -0.9195603088580648, -2.3901631511278953, 0.19936634513664225, -0.704383518154625, -2.3577404449156822, -0.7592855898957531, -2.4383245187596865, -1.354162871409325, -2.6970899624043865, -2.481737661901403, -1.6214781075281521, -2.1053768062043834, -1.107731589306971, -2.4150205119538946, -2.4714457174034443, -2.65447129216326, -2.480941467327816, -2.3860576137893177, -0.4905813968575012, -0.351728938729043, -1.4379045342994239},
    {-2.3409705579457083, -2.487859945992394, -2.5264488626888033, -1.3039037782463656, -2.596533493276852, -2.2745181510996626, -2.285783740378304, -2.623303575207533, -1.6932731095422502, -2.8224281004206406, -2.726637352376552, -1.185709384735497, -2.850907755179246, -0.3849080897394613, -1.0559862021352846, -2.7414434920804687, -0.8482658034980525, -2.6738933520128616, -1.7667738819983856, -2.6209447996154975, -2.6973809454909885, -1.4786513921937607, -2.181329443485646, -1.4651749816826418, -2.4136594308047723, -2.594919098669985, -2.622564707491971, -2.698384419556984, -2.657549959041532, -1.3922998466945316, -1.0933236041239884, -1.6218034539674802},
    {-1.0820630990807376, -0.6350334849165687, -1.7904060089494358, 1.0440427096049218, -2.220993427697213, -0.8681165888749328, -1.3123926700895392, -1.66197291054992, 0.4630861014624815, -1.5766311569960623, -1.1727446197986027, 0.8350528969357823, -1.5154337785635066, 1.9843880876605, 1.332834815069146, -1.1771553351704618, 1.4608048055253837, -1.8478556924592997, 0.003386171420458196, -1.6366866325600078, -1.8719980356822266, 0.5614461346834114, -0.839001064264201, 0.9901785851362781, -1.1605723880279961, -1.5771196767710165, -1.6505629993257196, -1.6885457314873131, -1.4250212337265369, 1.871754374890375, 1.2115643820772666, -0.08052272078125611},
    {1.0485048063396682, 0.573472822252566, -0.47095255533130975, 1.1825276407319407, -1.1106927880460056, 0.7009020116141772, -1.5779324147204306, -0.6664410407559461, 0.9867682412879427, -0.601633275967801, 0.18705560107809763, 0.7519508893480339, -0.1456087553153991, 2.6179708519269056, 1.6760385120494607, 0.010916712402052308, 1.68774432900986, -1.181268949509588, -0.2106588313093615, -1.0473623225499804, -0.11287672829291759, 1.2880350911978322, 0.5991165621789893, 1.0011220131043759, -0.0051077756242640104, 0.25870088540369257, -0.7974762363985635, -0.6481222099785254, -0.9466133224461679, 1.7234935235215427, 1.5804196712243037, -0.23890877351047013},
    {-0.6889605944632357, -1.168379240568823, -1.4934470453693705, -0.3502125720583348, -2.3205584936769417, -1.3257186188637224, -2.5921003452741274, -2.1464168098968894, -0.545008596773246, -1.7009787379301196, -1.3070462906928153, -0.6577163642446779, -1.6550858020770185, 1.5767664635891656, 0.19733457667188511, -1.5771002674704702, 0.8268589762244695, -2.2216619371726236, -1.0790804526704703, -2.183689552732772, -1.7233473596445856, -0.6416901583036604, -0.7849808987871275, -0.4770955429620618, -1.5389067749265697, -1.0259205827277018, -2.02996501916413, -2.144264045846475, -2.055679224771454, 0.3497849818741054, 0.36458304221009435, -1.3277663188170243},
    {-2.0564843279206624, -1.8169535620533652, -2.066714163437985, -0.020269372084265807, -2.0772067660907, -1.9023655589330974, -2.2037151480176758, -1.916976493907465, -0.9585834242534919, -2.6215661734952223, -2.3542657276275722, -0.5783573680095642, -1.9816698052434107, 0.7302186979979525, -0.08686299816187336, -2.4359089473042213, 0.09332931362515381, -2.6290395147564007, -1.4097606404557144, -2.3173620424790458, -2.1051115838200114, -0.877826771398224, -1.7845992250911762, -0.7931742468463993, -2.202700654538821, -1.9991922601630547, -2.2522822833185376, -2.6616432887564376, -2.0836045241984964, 0.035943874216421014, -0.3722499269447131, -1.0763349286696382},
    {0.19459477615111773, -0.5521016908592367, -1.1297112088186996, 0.11045726761871709, -1.9256131873457618, -0.6136220126038003, -2.354921212427651, -1.6538140850000624, -0.14080942035009575, -1.4609523340498805, -0.9722457704824818, -0.38484399276467124, -1.1653096274054193, 1.3905454831188262, 0.33400867176903387, -0.725150887283706, 0.46907544407407076, -1.7419263760986785, -1.1507060134448657, -2.1580686296369604, -1.2362489541554476, 0.17079394395223238, -0.21330281596208028, -0.17857064142070983, -1.2440848983757107, -0.49919714228494594, -1.248636389777358, -1.4348544640972445, -1.7796535880123514, 0.3152281066377298, 0.1701950168560286, -1.2256340724472055},
    {-0.6243157706758077, -0.7622389813387291, -1.7703531676618836, 0.5094453344656238, -1.799920898900146, -1.0283824888168918, -1.8884379570616097, -1.647439830640998, -0.3076127047170002, -1.6982375360946766, -1.2373342495003061, 0.2479846686166945, -1.4452054806900312, 1.5381755507515373, 1.019842513253204, -1.7048385071154109, 1.0093416360289102, -1.9436856883230726, -0.9863358795793266, -2.2612482389566826, -1.3954296098723924, -0.2793052613162708, -0.9824368159364131, -0.07585581117011873, -1.227060427187748, -1.259765489139075, -1.8248970666494897, -1.7170719224968167, -1.558561657071929, 0.45385761327154267, 0.8092971361547614, -0.40269224096682066},
    {-1.1180458406233087, -1.387100905439347, -1.8130366753743465, 0.33829703661379307, -2.150440406485332, -1.3635101305027872, -2.1492670643663767, -2.1056766345977684, -0.4457035938898559, -2.2524294730841716, -1.783851666481538, 0.18331862264695997, -1.4985343869034227, 1.393991831737167, 0.7290280199178336, -1.8928433664823914, 1.0082745762201484, -2.2479121057266647, -0.9022728833119301, -2.694644133748185, -2.0114881396001336, -0.5133716019961484, -1.1810910941081594, -0.08992864310730325, -1.4615510161834293, -1.6557421943066732, -2.253992017169111, -2.3065684972887794, -2.0960130450608823, 0.6410266194198716, 0.6616422542873475, -0.21130363928547938},
    {0.04412464025029191, -0.7734028296285755, -1.1781296699993873, 0.4764415024488959, -1.970845695537283, -0.7213181151349602, -2.28900658166027, -1.9032084197606183, 0.25555783509588725, -1.4658181539486534, -1.194009183539592, 0.22974689131248735, -1.2466521352762834, 1.8568638072796735, 1.0845385914725991, -1.503505804284667, 1.0693517117100855, -1.9899671234627856, -0.6594014737044289, -2.349743656363897, -1.5226930011923154, 0.01456143665229906, -0.8012023233810621, 0.4561864410571408, -0.7921385920839229, -1.0400116928305425, -1.4270236660314044, -1.9497313627800659, -1.54950737986837, 0.7454669024519393, 0.8278243587682944, -0.4337218159832872},
    {0.12101108943984126, -0.2219122759872297, -1.1094436536542203, 1.2261072345821658, -1.7058043876553983, -0.41997714448684087, -1.7095149866102701, -1.714102880083427, 0.8138692556537861, -1.5468861098055473, -0.7532111025688338, 1.0914640481281794, -0.7772973881349774, 2.3172861175758532, 1.7515578590606498, -1.0077503288521195, 1.5773254875113782, -1.8861284790984838, -0.43464279102222597, -1.9311550153984705, -1.5462828758503224, 0.9749460178444491, -0.1935870788777376, 0.7991269092347159, -0.0432306730663474, -0.8454948721718931, -1.2026125638556489, -1.5229476536372362, -1.1768463326403493, 1.5684511942667871, 1.5121745926805965, -0.12795910658229206},
    {0.3644908207811145, 1.342180459713719, 0.9299272099189765, 1.2018875484245286, -1.7096121147452834, 1.2671693032279159, -1.3502363754590454, -1.6691626935027468, 0.9893839030485029, 1.5355270202860485, 1.3294215888064178, -1.3736184179662214, 1.3937071422554044, 0.6834862318870135, -1.5373745890060677, 1.4735636762745545, -1.575286342817989, -1.150508986046789, -1.5165572401355654, 1.195048045928652, -1.9126169877246042, 1.3492571163844393, 1.3988773076494583, 1.036136369158499, -1.3844722150622828, 0.48493657109214044, 1.5385588681224718, 1.714698731767596, -1.0769985949168954, 1.364862297943148, -1.8315189101468023, -0.6028675791983714},
    {0.8611060055960174, 1.6913755947335583, 1.4378374605157338, 1.374555414142845, -1.383823569936051, 1.464605832183381, -1.1826300813961437, -1.3789502634525372, 1.37931552058376, 1.4815060749406905, 1.5877132780097143, -1.17249146163826, 1.6056512027335685, 1.4522348247399093, -1.6591615923329932, 1.3727838601505005, -1.0831612899045195, -0.5791751252457729, -1.3766583870211127, 1.3503614597363496, -1.042654024956783, 1.8537449081353634, 1.5550454619795202, 1.2109839778209202, -1.728614175015296, 0.4727095088117989, 1.7048333970223846, 1.9226156668012753, -1.5945581483843878, 1.3934347579319204, -1.7532139721629267, 0.3650410032896472},
    {1.2166140650908934, 1.823114494879491, 1.6792051483295687, 1.6355850450151073, -2.0354833097981255, 2.0389706236203886, -1.8704202803744505, -2.036022538070436, 1.443371524582056, 1.7327702171996762, 1.292623748107161, -1.8372206501526864, 1.7116105518476041, 1.3827566200834354, -1.8661325398394075, 1.8701778165580563, -1.8011368847063902, -1.4482680427256927, -2.243998198197802, 1.4860381406921832, -1.7298468984678865, 2.1110887333910986, 1.738562436388174, 0.9156281238267949, -2.066746666423287, 0.6141332903746183, 1.762985169083344, 1.7464153257339625, -2.202041680574981, 1.1467891000067985, -2.015802066090052, -0.7663434768589427},
    {1.064081352846371, 2.0079797079778934, 1.723005186654641, 1.692177925998764, -1.456106448858831, 2.1287167864535332, -0.9897031271259065, -1.785681798590215, 2.248824477949939, 1.7707101450050622, 1.6488347650224227, -1.6645311720751474, 2.146118454724501, 1.3471527117169066, -1.483458711854625, 2.062651447101903, -1.2056059047065046, -1.3813789847601006, -1.7267241364111718, 1.5620599409691145, -1.659994886545425, 2.041348158494092, 1.3818399425125472, 1.0995965038459792, -1.7828307350551011, 0.9194758251320437, 2.1195694528661764, 1.8219134776600614, -1.9494518184057108, 1.716403842531328, -1.8465293707370556, -0.5462698230760804},
    {0.9194102091161959, 1.9105704448882868, 1.4171246946115508, 1.5736992741482434, -1.5941937267308728, 1.8851977722092934, -0.6229968616164314, -1.6215124360703959, 1.347382399731454, 1.285370564858719, 1.3358895761898693, -1.289848931581439, 1.4311822790182087, 1.0892423376933198, -1.286249709714494, 1.390532617759001, -0.9529785651763244, -1.051987184243225, -1.257787203622766, 1.712121060112574, -1.6081258870162076, 1.773510527232036, 1.3807872919522524, 0.7533336612796806, -1.8052580735520904, 0.619808367431389, 1.5525710031125446, 1.4795360054305002, -1.7403668504080503, 1.307811835019946, -1.7136436266538342, -0.049031823230399896},
    {1.2055151325912372, 1.8711875600190553, 1.1750907375541486, 1.4006918082641164, -1.6983573862412056, 1.6533381073365694, -1.112474914051033, -1.8723576730330842, 1.9119909298415276, 1.4846176768950328, 1.495859804861451, -1.4464891121326258, 1.7397701333257873, 1.1779091924480916, -1.3516383976168487, 1.6085817952420296, -1.1794238921253606, -0.7790585380300206, -1.6546344428678021, 1.731495664761657, -1.6122114603836326, 1.3580554299818357, 1.5619185826266233, 0.5460247503711627, -2.191174851307096, 0.7155090201656152, 1.8554559657495349, 1.850334836981321, -1.7982557227888578, 1.194312113932346, -1.723202671669414, -0.25905081053223195},
    {1.1817562501555199, 1.6664999480431284, 1.3622426710355766, 1.196593756386631, -1.9938169769533987, 1.845307064670547, -1.410467212827811, -1.8865148893488424, 1.6482081454082314, 1.7139664724758314, 1.9180564256413404, -1.769556799020518, 1.731429124584038, 1.4980907830983443, -1.970358371069833, 2.235083611574089, -1.7895775033492176, -0.7823061663235373, -1.5837794475609963, 1.6653351560403238, -2.103503140235893, 1.6336274222700102, 1.7316920862094256, 0.7393481746308924, -2.1062619980173, 0.9998803205448024, 1.9722561935207377, 1.7808896129179148, -2.044484722954417, 1.3643299504557025, -2.020365278650119, -0.5093351616759708},
    {1.1235793467278359, 2.153343441495502, 1.401192003730474, 1.7293915552446069, -1.6994823248236277, 1.9707937565517333, -1.5376384466751722, -1.8609215830010315, 1.5724897333258914, 1.9041240078409365, 1.9543036928544824, -1.841244425529823, 2.2335275165838326, 1.4001223024965175, -1.8158114702252537, 2.16801474067783, -1.7596822287287932, -1.0474152308457612, -1.915402353044635, 1.8084368788700396, -1.873813971055278, 1.7050736225853937, 1.6074932926328636, 1.3204321955422857, -2.1259174994785237, 1.1905479671378751, 1.8144336377293662, 2.1464034832479286, -2.0227537466364933, 1.3575564656396188, -1.8294097676945678, -0.8771624436618001},
    {1.2389990660361623, 2.0333916585829828, 1.6711549731739428, 2.039067991302908, -1.9511776844041933, 2.1533377242099845, -1.484313173291721, -1.8905496480367572, 1.7065477153664588, 1.9258002789768902, 1.782326208094333, -1.840228236367896, 2.154212873207973, 2.069492156312628, -2.094352903388933, 2.0473406593943344, -1.8813603132362284, -1.518134146568128, -1.7499069315674163, 2.0017721973513285, -1.8564643046029985, 1.8153541381133684, 1.9118905163275701, 1.3025598880136822, -2.483940563674659, 1.336931774874398, 1.928839578042675, 2.0756623092554705, -1.9982137127939563, 1.5303960612853578, -2.0255885793266697, -0.8836137174846167},
    {1.4059216651540867, 2.0630507275152574, 1.5299095185975646, 1.7285128118617694, -1.6979737687778176, 2.179697982779892, -1.8831093387148745, -2.1383978733713653, 1.5130514699908788, 1.9322444161173098, 1.9003430763261369, -1.7650864194753801, 2.370413297767885, 1.4817787156183013, -1.9855606534754253, 2.177982725757242, -1.881002935147677, -1.355954491356879, -1.698933510652983, 2.0444933751175838, -2.013806248798445, 2.006117651069743, 2.052793580217531, 1.5409120915292578, -2.0247961708613267, 1.5030905717322878, 1.9792729736108137, 2.039476993511543, -2.272002966515202, 1.7126746438133456, -2.103611424856093, -0.5816824935460335},
    {1.1971357860144258, 2.1412077455506595, 2.019620356288764, 1.7750402698040444, -1.7204359039643986, 2.2203788373022264, -1.725614061012233, -1.9989249608170268, 1.8425867170205041, 1.8714558418444256, 1.6499183299037552, -1.498930963383153, 2.123531456836644, 1.3829910386228796, -1.994231654622827, 2.146186208418596, -1.7834064765887074, -1.509439172101652, -1.7898913235978278, 2.0596513374784378, -1.922355118143947, 1.8372857996480771, 1.8498074526605441, 1.3977881010045508, -2.0140016482244163, 1.3764128923931795, 2.057656587195871, 1.9461604621530948, -1.8713978661037047, 1.2248013360969472, -2.202203413849743, -0.8055220013879245},
    {1.3200606690677614, 2.2592334322023575, 1.8768881386943153, 1.985664292744486, -2.3194279826497355, 2.3237658073783645, -1.4454374050070873, -2.348491185015695, 1.876995418483024, 1.736930809688114, 1.8951920797092046, -1.2628511156348532, 1.8298689520699603, 2.0551903852877387, -1.7420068134309628, 2.2435951862542614, -1.689877640850579, -1.6373690156404606, -1.8788480882389182, 2.0576378784503087, -2.0809694359627247, 2.1060860431000923, 2.087728207672975, 1.6555594892352397, -2.341525252850342, 1.6193372076681576, 2.1859249711598867, 2.187841171281204, -2.08702047066972, 1.3862128242668612, -1.7119099226811736, -0.3461907618723227},
    {1.2431254637991607, 2.160583566312412, 1.9561785090157209, 1.9831028827743167, -2.156516457926852, 2.1350166562465334, -1.3837123166564043, -2.7182917233272823, 1.8937006398887701, 2.0218352656764518, 1.786838931896589, -1.7674951374220145, 2.019413077852009, 1.7096304744334245, -2.1568275879445222, 2.0159304033502723, -1.8190869911516239, -2.109298156865759, -2.270435303809431, 2.1479365904336065, -1.9418724281126536, 2.108257591858597, 1.9637042324427558, 1.084648991876502, -2.598404503557996, 1.805616148941022, 1.9085679741191905, 1.804418777558266, -2.5569971246239125, 1.6480373823128076, -2.2843209691820308, -0.5566898167813593},
    {1.2650732883416325, 2.3130151149977145, 1.6804536511706178, 1.8992446738733622, -1.5667077592497851, 2.3565826420341445, -1.4075319769754258, -1.8795990656822896, 2.041546206619593, 2.2160737366861873, 1.837762563518036, -1.686943814088357, 2.282149017903102, 1.34046150358031, -1.9452957358759948, 2.232591638685584, -1.8438033120583461, -1.7575672314402826, -1.654270978441644, 1.8068355869519148, -1.8851960358224886, 1.7177340709225652, 1.7943789047780636, 1.289143905179142, -2.1438533256379007, 1.523513281199478, 2.0862857063615845, 2.1066213920965913, -2.1592746889249503, 1.5145679047977063, -1.823229545907218, -1.0653433915707555},
    {1.7227553440279864, 2.22803869719528, 1.8236392281622207, 1.6466132554734993, -1.8883605390719258, 2.2330312736309987, -1.7888345970700228, -1.9742371549508757, 1.6988249671408948, 2.0712522164418776, 1.957839069376931, -1.6672272359498954, 2.12733677869772, 1.2262255474478119, -1.6863251711070992, 2.213590153582324, -1.9045327698262948, -1.3264649396837964, -1.9284445723418318, 1.608112998229019, -1.8984304441075508, 1.730465928522144, 2.1478049354835194, 1.0674777747371613, -1.9496183138791148, 1.5557696326711121, 1.8707694162886688, 2.240257007429999, -1.9862492974061643, 1.4130078570007438, -1.8725206745879175, -0.9894769325768868},
    {1.3584112267963433, 2.3919923475976144, 1.7629757277949218, 2.3547594928425033, -2.3947366104814423, 1.960379753515173, -2.0555936515026954, -2.093282148901292, 2.1425095884361003, 1.917708544140061, 1.4764111175910908, -2.0340818333088055, 1.9907279410925918, 1.2255459250982728, -1.9015408967195253, 2.0830059100949594, -1.69552260424892, -2.0560211212834716, -2.086631526803522, 1.6699612354791071, -2.2478362100421223, 2.2104581043692932, 2.318024128957367, 1.3557751313365867, -2.1164955546592754, 1.3324903966530994, 2.079746949699897, 1.6113148571174183, -2.346338028142249, 1.5926088944984924, -1.9649720699142532, -1.2273556310372344},
    {1.0129746396347907, 2.0602583176550033, 1.4882132060958961, 2.16465017241888, -2.3132765726961586, 1.9719847646911435, -2.0520747001527395, -2.322138423775046, 1.961558580293414, 2.0361560543383233, 1.5525272213983865, -1.6916512358579643, 1.8819487792453002, 1.3887810051649436, -1.8971565184879293, 2.2716489109063946, -1.572451312764553, -1.8975800871820088, -1.6525066665327817, 1.8245066480110492, -2.2308501054899206, 2.2138973243873514, 1.8378786948402164, 1.9037578255482175, -2.202761702234887, 1.4688600624495098, 1.8985064103481475, 2.007673211958858, -2.1563261467881656, 2.0759301688338967, -1.922288578622276, -1.0902402167575829},
    {1.4385151235739706, 2.34177486989131, 1.9043642110175278, 2.247688391610521, -2.3201730904060693, 1.9217629580198792, -1.9192882757023313, -2.3190119632130726, 2.017885918437856, 2.339850356942047, 2.008203429789011, -2.0357542416368073, 2.5415542301194645, 1.0698787303197366, -1.9549587977240253, 2.196090965481679, -1.7423619995959994, -1.8087362045095492, -2.2153732308773533, 1.9996488766539586, -2.098791997358106, 2.2340410043520746, 1.984095503948523, 1.7048888445004613, -2.042206095449429, 1.6871266357734782, 2.108972165587558, 2.0974975262956117, -2.233969664506846, 1.8964039876725074, -2.0866444136618827, -0.9955623444407475},
    {1.2826120983089457, 2.345237084442707, 1.600488703785599, 2.0621402279254495, -2.040545885640975, 1.9316658075953883, -1.7568369018071106, -1.9794566325578136, 1.9604183861074953, 2.0209886953428122, 1.4032772578394594, -1.9231048194521192, 2.3208168735538255, 1.3035763323597138, -2.374116861973015, 2.314999497839368, -1.7083261414577091, -1.6114126815829481, -1.8588199941544379, 1.9680127657855508, -1.9097380314657677, 2.2694087714347857, 2.074328851983288, 1.7834538168216632, -2.1645848796012466, 1.1229688422389474, 2.054725927462196, 2.3086127649648094, -2.2980414576923027, 1.5717962336744313, -2.2835644439160703, -0.8164212960405278},
    {1.2489627762586146, 2.506787311519075, 1.8841829770136627, 2.296577271910658, -1.9006687908862592, 2.029701395835945, -1.786207442034496, -2.2016340705930904, 2.140076086397164, 2.2417498119900414, 1.7130760798486513, -2.149696731428506, 2.4140832011571782, 1.735587710804066, -2.1926372637836704, 2.551339862804808, -1.6074035346206172, -1.3394051020790192, -1.9178116242180072, 2.0655240311526177, -1.7878743273618494, 2.3609778094414646, 2.03025548831009, 1.8701942560020826, -2.290149486809387, 1.3572014015258758, 2.1846373281485065, 2.353751774792309, -2.282116824925782, 1.8470686248233303, -2.0356722492871873, -1.0124559389301422},
    {1.5487136218450448, 2.3830844929790107, 2.0301565422329246, 1.943366995172881, -1.9877359385730586, 2.1704950427520866, -1.554748092232855, -1.959126265786073, 2.0752173068576427, 2.1077586907156154, 1.6319264736504395, -2.0823206449776586, 2.619301976215628, 1.673999309372043, -2.1643541373439668, 2.3431379641081493, -1.8765557420629844, -1.6965515903762862, -2.348104570368089, 1.9430286265007326, -1.8069311166741229, 2.107933825730909, 2.0855377620589164, 1.9869132018006193, -2.095004218158584, 1.4486499819504952, 2.314761790888019, 2.1612654946099057, -2.283779361739857, 2.11381151485393, -2.2831954639497036, -1.2011257258860062},
    {1.2701257696465413, 2.354126961972913, 1.9915115749009338, 2.475165001452055, -2.0581032582647536, 2.227408003130831, -1.769371992991322, -2.4379498561314112, 2.4276915510255574, 2.418877469555277, 1.9332119135800268, -1.9835299108782705, 2.6925969776450693, 1.452971204539243, -1.9138342919630054, 2.3218522214663895, -1.5944328662653295, -1.7410259605268448, -2.2184487359089204, 2.186699593049856, -2.058649974342336, 2.4126972451498903, 2.1676262349226194, 2.404436802994837, -2.0853458097624147, 1.3216345509480003, 2.33302297201871, 2.412474298821958, -2.2069820738346544, 2.1959235023847814, -1.7917756218476937, -1.3633110911469783},
    {0.9646536003352231, 2.3179565440788767, 1.6712890424399405, 2.2051413206886123, -2.3858538419921365, 2.0782708699247543, -2.4726057135941923, -2.542523829536748, 2.095715199440247, 2.0232588886631167, 1.8642834443942329, -2.401353788416593, 2.3686815758398514, 1.622078561302192, -2.1035899654489443, 2.0537767747418263, -2.2119255935633233, -1.8810326308401135, -2.5477288392241304, 2.2328595468590087, -2.4478557148643936, 2.0334371557594295, 2.1726134749481925, 1.6768678327102726, -2.466549243011662, 1.4409621329178, 2.1243041497884696, 2.1701511839412118, -2.6553884093287725, 2.1268901190345324, -2.2342215097510625, -1.9857422781735719},
    {1.4256403666076303, 2.4882222948735855, 1.7129882157992866, 2.235041263328227, -2.640626546271736, 2.3916174068583724, -2.3634556127323316, -2.719494571641286, 2.262204418291549, 2.3411831210564458, 1.7679697079186414, -2.4322729600789184, 2.245197217618192, 1.0310582195400726, -2.5687318643080794, 2.4075438886072305, -2.291596487561919, -1.9553310956359549, -2.406441520288764, 2.180901580297186, -2.2786729212586327, 2.2429766301216767, 2.4344766564240667, 1.6385204078540172, -2.5514295372713853, 1.4700255925118244, 2.4756745628090613, 2.2563243341720494, -2.6264294431082233, 1.778908617498217, -2.687346752932568, -1.8820362003231907},
    {1.3159689820071134, 2.234517061710726, 1.9208800528320304, 2.3844855790692834, -2.2585444218073003, 2.2414761908560927, -1.7160020135078247, -2.3386628181773133, 2.341198084466182, 2.334945673867283, 1.880528322613267, -2.241237610315031, 2.3433844806862254, 1.2870189072900908, -2.1235773986117996, 2.5221398588811357, -2.0721956411876032, -1.9299432760349673, -1.9576755910749388, 2.3130423706694287, -2.055986487434889, 2.2572943776951884, 2.301971537212041, 1.649794153697624, -2.3721080077148295, 1.6796925315988445, 2.191041062704502, 2.151842727425683, -2.20424537796564, 1.9635023142234536, -2.1562995725390652, -1.2353078574415246},
    {1.1384263530760643, 2.3830705551500846, 2.082667028366681, 2.0806239975868177, -2.7202467666751144, 2.2177236331968295, -2.1464980922243972, -2.4340746680311827, 1.7658560691346268, 2.2666950677760327, 1.873167852724809, -2.606038219721977, 2.4726911542234595, 1.455253759029673, -2.4923064029015936, 2.3421535888108047, -2.2261288960952856, -2.152333030222467, -2.591253183713775, 2.1542775956824185, -2.167398068071448, 2.463848763467528, 2.2573835979391057, 1.773128742674024, -2.533683829078565, 1.192487763321383, 2.4323281094350904, 2.1085196344062616, -2.7509733873096027, 1.9963658824478494, -2.2573298463720723, -2.1389259520702932},
    {1.2555890464649193, 2.35048856960474, 1.6665777648513045, 2.18280594255184, -2.662388935541216, 2.3832196814201696, -2.176247070547854, -2.538907235435538, 2.4191478533287687, 2.2146162961142024, 1.9334880634599994, -2.5730970945494533, 2.568909767804249, 1.4610147598589436, -2.2124404481044495, 2.477529249876788, -2.2122008470724097, -2.248346475180362, -2.5806579373729894, 1.8494747183814286, -2.5447577628333455, 2.2319073242000753, 2.073927112280954, 1.6474747366862283, -2.5590044416680526, 1.644422433263851, 2.1784356478648625, 2.5917706826299103, -2.636674045735874, 1.9044538046289226, -2.2820123722304757, -1.902046677290234},
    {1.4092559045550452, 2.539999313861311, 1.8842769123841159, 2.0826571240514875, -2.493862336070688, 2.29823700042626, -2.262700497804523, -2.4552030397137234, 2.44400553354239, 2.436878524254309, 1.9244300097393963, -2.3546487616756617, 2.491858745075145, 1.6343685244999346, -2.314048510391794, 2.4499616010004104, -1.7459818907923221, -2.3531020690039948, -2.443380831114098, 1.7400076482243287, -2.3795320544999545, 2.428034936596117, 2.2332741496025963, 1.8631330512285034, -2.5074912970658696, 1.8256177759701975, 2.1700685767517887, 2.080838543024377, -2.613270077193883, 1.8704454746449166, -2.385131329906718, -1.8054299466504593},
    {0.7718261599987375, 2.4353188231797342, 1.8527911872907152, 2.338264290046708, -2.7461003406325335, 2.2478295600749605, -2.5015652382039937, -2.6772842785406175, 2.0562480332417894, 2.1744889751164553, 1.7065820028534031, -2.3475753101587276, 2.4694747547108022, 1.5657523960606805, -2.276337633969224, 2.267756265069743, -1.7247261951857022, -2.7905697535766416, -2.5708855931094052, 2.0697854920161203, -2.50119124236633, 2.6380406024418677, 1.8541622268948625, 2.1070598916147145, -2.812770427664419, 1.3359599862176932, 2.289135204771839, 2.38630497564677, -2.906653423063049, 2.066612682857482, -2.3785513712662874, -1.9019771762268722},
    {1.033123984808131, 2.308935868285837, 1.9496900729368931, 2.287168648536493, -2.4006283899836887, 2.5235046579450233, -2.2018899041379587, -2.6015293555926102, 2.192017825626304, 2.388614190868863, 2.049519656993828, -2.3217250673625114, 2.09225916682235, 1.603524343456626, -2.1404126970512323, 2.2918500053386683, -2.064083784109511, -2.3551184102541542, -2.4642662574747614, 2.0849217133164992, -2.4523770613364952, 2.541051826944503, 2.1332802188874798, 1.937467783262272, -2.334095749079522, 1.5092628510366308, 2.2523950506455956, 2.458780055935844, -2.6755025786004953, 2.1246568867337237, -2.269122184263524, -2.0992417617227614},
    {0.37963251277660853, -1.1379683659780588, -0.7777776937618027, -1.9049784284415674, -0.5238877298098747, -0.3992843873897879, -1.691407749338011, -0.12771920433260556, -1.8215564632936212, -0.7666457867585219, 0.24700523427232585, -0.8181291902666055, -0.8030506976486234, 0.1376383195750389, -0.2895777334235302, -0.9936226647789589, -0.8040583520050703, -0.15948464265376447, -0.8786184168439709, -1.458190316503118, 0.26518864222820465, -1.298899027707996, -0.0022524110312691025, -2.1094138286528854, 0.05643048333788404, 0.3290383080487761, -0.6707278350135687, -0.862388916409578, -0.2864902578590677, -1.6798697553140385, -0.28575148940284784, -1.6458934582609919},
    {0.9029280472800991, 0.21773130587195752, 0.5079566412900753, -0.30912131866203396, -0.28762830191966565, 0.33112548936148967, -0.9772290179033076, -0.39564894237730586, 0.017717218171406382, 0.30739817955780535, 0.6077868900329818, -0.4334125876034184, 0.16647042616356264, 0.6902997676547822, -0.3836288324609732, 0.8201461346466064, -0.3645795406526946, -0.0993156026837873, -0.3193303159616603, -0.4441922016663512, -0.012688055652817748, 0.12905471281192546, 0.7574931634426879, -0.0885449991422988, -0.49715800451321024, 0.9251000255317166, -0.061075968278960134, 0.03363946985530707, -0.551380133378395, -0.022541687016353094, -0.3023807938363643, 0.29963293894380727},
    {-0.41883623549287, -1.1918794983014658, -1.608707964918086, -1.1146154949872946, -1.1412701011344748, -1.3650860029039102, -1.6203930312179584, -1.3252871667065114, -1.0393721071369073, -1.694425990380236, -0.8051113001521281, -0.1324038920010822, -1.3793952986308071, 1.252564238987589, 0.5817866915788348, -1.368299940221186, 0.5877118348422782, -1.195877649240617, -0.9982358453183933, -2.0275671446121537, -0.8448350447265871, -0.9676778997369689, -1.2133693064975821, -0.7903658553043778, -0.7083323679929836, -0.9889433005639573, -1.754309864861978, -1.5793415368039119, -1.1594459669004629, -0.5379590670033415, 0.7034387918658027, -0.9537422345208602},
    {-0.6041411097982872, -0.9157932310358621, -1.2542168977685602, -0.9231804899157451, -1.4283633020813244, -0.7290853862703707, -1.6493936343580098, -1.0438622952147827, -1.0588129707352163, -1.4115774406623427, -1.1615531881834245, -0.5774096487937286, -1.5286123035726649, 0.3660523636170883, -0.7873141705643881, -0.7555540693027006, -0.5003083329203769, -1.3420448857541851, -1.349679676355425, -1.5675810965832224, -1.1742781189930027, -0.8419701625885176, -0.8765679401175858, -0.7848301320214947, -1.365502604525518, -0.9166084020839085, -1.1679572089273371, -1.35166787857616, -1.3824107175445464, -0.6240504820123048, -0.8263724687978307, -1.7954584135958673},
    {-0.8809266216327752, -0.6521764295520059, -1.2890976777999095, 0.20061950927256822, -1.4273597842324444, -0.8638209571351928, -1.3633284024084298, -1.346563961910267, -0.24991351035985443, -1.6882306416415598, -1.274778513940996, -0.3810989070109918, -1.2931138619938922, 1.0757399515171102, -0.35419359300741327, -1.0823608663746536, 0.011131466100514352, -1.2851571951809413, -1.1245509663526476, -1.638574903376062, -0.9049022465703863, -0.1190603904837324, -0.8677735987672242, 0.19416540244697772, -1.4523493320267415, -1.4391157770746377, -1.7189723999932007, -1.5726899933845406, -1.6880238584177876, 0.6898721228734146, -0.014043264679192004, -0.9788358334550545},
    {-1.0030771674799253, -0.7986567739560877, -1.2212970423688845, -0.07296362665473519, -1.3209101481616077, -0.9290610056022501, -0.9177974404337533, -1.3455128899371485, -0.2602855938955775, -1.131505731071517, -1.2190572630793852, -0.40887149844284965, -1.0365660569143507, 0.6252548015265431, -0.2986464167578319, -0.9911346543389702, 0.22070775946923746, -1.4173224249230516, -0.8994652540080316, -1.0708340123405473, -1.538161517054269, -0.010627250553971667, -0.9017378903259899, -0.347688522683701, -1.2608497603825581, -1.0172598160062503, -1.2088990931648282, -1.0434764259289184, -1.0790340841108454, -0.043505549196379986, -0.3214814551790099, -0.7640956009518498},
    {-1.4062121751200027, -1.4753720789739593, -1.7359652578620333, -0.5876391439199228, -1.851521535413265, -1.8904046256741012, -1.7802168286909048, -1.9267835158519564, -0.9992979391213137, -1.8298155705354384, -1.3156528669837602, -1.0270395591206685, -1.7196321081967467, -0.07200396233531901, -0.9832814743513325, -1.780836810544625, -0.5276058720451626, -1.7525066062703734, -1.1000582131892267, -1.9852363027157462, -1.6882278990917954, -1.1871115724352719, -1.6501528014440563, -0.8084658716145205, -1.7118868172959052, -1.4373749710927075, -1.6547030850022326, -1.5489907689282962, -1.815673481560402, -0.8243322558456415, -0.695141006051657, -1.0658297606981855},
    {-1.0549020148799457, -1.3007082926613152, -1.3227269256604601, -0.11002448002680908, -0.9406145301695206, -1.3436115161383415, -1.2160270208313666, -1.3277713330566783, -0.6645922820539366, -1.3513102342927141, -0.9698550212756045, -0.36192163861371995, -1.271124288285281, 0.9310887270352499, -0.619558762664938, -1.2843819390255138, -0.4958904584313167, -1.3316455414752282, -0.665355023940129, -1.3752703155488326, -1.1244296919317895, -0.36244081428837815, -1.285392038677514, -0.09009807245474165, -1.3673005446829096, -0.9067449391495646, -1.1164532273429153, -1.0258885300372675, -1.3225136501913282, -0.2925288531082453, -0.5384294658478889, -0.6058056631119793},
    {-0.9789595203550341, -0.9870401078536506, -1.4384191255762362, -0.355402371328986, -1.1555932563877225, -1.2432286792373204, -1.291694825343754, -1.598929519515264, -0.8585962296594745, -1.7585505661861052, -1.4532020933018175, -0.5439893306391445, -1.3436573703725352, 0.5669894867361379, -0.7940191134381273, -1.3107840075018957, -0.3913168171195748, -1.5622092734678494, -1.2185840188624146, -1.7131998117569558, -1.3336042559697254, -0.5346621805302193, -1.305148250369325, -0.18625676075253014, -1.5956056255759095, -1.662360283571142, -1.5572313823517396, -1.3759918229922137, -1.3467711540964658, -0.044282826818865036, -0.4878461444513696, -0.6984519527029984},
    {-1.240417024099474, -1.0043775051376664, -1.563921671162404, 0.36711750054535847, -0.8698458136157711, -1.371707332654093, -0.922087012617241, -1.3496590197059215, -0.5663541952434681, -1.5798182079422762, -1.4996409898084095, 0.1057106894436542, -1.0049987680017376, 1.1935758348421146, 0.8093027577417848, -1.8463613573080544, 0.9022242779287809, -1.0107270106096327, -0.48476362554615093, -1.7512383016241253, -1.3118390977478507, -0.1987298727165288, -1.319633147653727, -0.3439863803442381, -0.7547607075342331, -1.636003091563735, -1.5573960048403688, -1.7470186543346626, -1.1343280883385214, 0.38098860156485187, 0.5955051832121794, -0.4685092945473793},
    {-1.4454714143533645, -1.5652324737267767, -1.9547793434564715, -0.5527486324026707, -1.3445719731601984, -1.467198410384961, -2.19107165776816, -1.329515338804319, -1.428084315033427, -1.6252291762723432, -1.819750963618433, -0.9193377702251132, -1.923367610173157, 0.16851262413299686, -0.8256164766959749, -1.6796678854395135, -0.7442307692483997, -1.7354283305940104, -1.5596298100064485, -1.8699353434543486, -1.2050435684565117, -1.659973857353415, -1.2945359154641793, -1.3823362003959023, -1.4484767371128167, -1.4673551559044797, -1.8459728180564041, -2.0015978288729572, -1.8031040465869375, -1.0766157424930956, -0.5060531831750464, -1.3024227344075407},
    {-1.367775275110436, -1.5801217782572492, -1.8418961814008303, -0.28247859988720514, -1.5959238294144595, -1.305074377023478, -1.743371811755554, -1.6637102023074608, -0.9590535135565117, -1.8766541418409528, -1.7652197659159632, -0.616839045541529, -1.4618328278391026, 1.3049175096245738, -0.3389092810878905, -1.5003687084469355, 0.020749218964641755, -1.467465926206302, -0.9003234854190956, -1.6164987759865, -1.156236612167247, -1.0465894841571322, -1.442437592964319, -0.37395030622544695, -1.2586278455667568, -1.582437419139072, -1.8374087454444112, -1.9031890476797952, -1.6628833149318358, -0.17540363204489268, -0.05770785583465941, -0.8662149245729182},
    {-1.5622628666854517, -1.359194325227879, -1.6440895030445422, -0.5196409616346727, -1.4488020735915235, -1.5019715133575762, -1.4920343485479874, -1.6096353894562276, -1.3236153091529317, -1.5153130106045296, -1.4149420497031104, -0.6133189782148366, -1.264778591010205, 0.7408010599768172, -0.7486107486110113, -1.5754720828149535, -0.1709983451580763, -1.4899517618460758, -0.9207356888869981, -1.4459866108858375, -1.3442996129903428, -1.3601011339215612, -1.3645843987573545, -0.6290893962571532, -1.2322997971361824, -1.4329865006155518, -1.7846631088170124, -1.3991353669416318, -1.6661420284553334, -0.693424943215651, -0.557589662906278, -1.101742862521705},
    {-1.0090685690269414, -1.2818058783044033, -1.5594461113646079, -0.4071905096120581, -1.3499840280524313, -1.2513234394579502, -1.6631280037169327, -1.508461543278477, -1.2540690641580596, -1.6731391977496468, -1.2288045624137816, -0.6187584264259074, -1.4530901900951474, 1.250485431015263, -0.33531089229246785, -1.147492103370582, -0.29029307053799935, -1.582833557589138, -1.2235167905305946, -1.9596107686112822, -1.2805100018850735, -1.2366705409782126, -0.9016460889676872, -0.22763983087636674, -1.590045515567697, -1.0422703607024852, -1.22220091081657, -1.6585689802889216, -1.4608068183417728, -0.14458623001465748, -0.10798098197312071, -1.2739943528348745},
    {-0.22362693538245615, -1.3767385585188028, -1.3308296298163884, -0.13409922192043294, -0.7932069587128671, -0.8199324579205522, -1.6228596701034599, -1.1370832099849837, -0.9688217564036858, -1.3913620618913696, -0.9911380546634663, -0.1591993993977155, -1.1101951694262593, 1.8173514888818516, 0.4866920206525463, -1.1189286831894665, 0.4962256448504998, -1.365813678599602, -0.9919682818595865, -1.9667159613540106, -0.9541747816119499, -0.49202010650691386, -0.44399275069811067, -0.17761126357140247, -0.6029297868123309, -0.6612536415331175, -1.5843955735978956, -1.7898773003547022, -0.9193689502626108, 0.41974040770420146, 0.48125313542560305, -0.5022770951184238},
    {-0.06630899707363945, -0.3813506142504398, -0.8878141165107551, -0.10751654962798567, -1.3671144456023672, -0.9902660971876609, -1.9694501764481862, -1.6187862771411523, -0.45221516130802847, -0.800702480700625, -0.5334728655318928, -0.4709355018257088, -0.84240574073026, 1.4670686746657067, 0.061788929454644786, -0.8476472895807545, 0.008183907122706974, -1.386938492238445, -1.2500635183127284, -1.4352694891496933, -1.1818098303538511, -0.31616811682599205, -0.7730256826676817, -0.03078262492050448, -0.9046470074029181, -0.5424603731154204, -1.08877839042303, -1.6766690502321566, -1.4990021149669843, 0.29449138170235306, 0.5707307046950454, -1.0548590317373732},
    {0.154117791436851, -0.6955438534807918, -0.5819401111107617, -0.003033145242455602, -1.699676895318089, -0.8855907726108759, -1.6958566711216259, -1.1090901776631394, -0.561808698776048, -0.5085526036342073, -0.5210947888524405, -0.49150305848432657, -0.9557749728671859, 1.3890439467548437, -0.19841440456411513, -0.805896999012931, 0.15778395991389063, -1.3182620522199062, -1.0193734947310014, -1.3044030863718419, -1.269851045415391, 0.008962193591481938, -0.3850034435948169, -0.41833706109275365, -0.8661713116993993, -0.3159900552946769, -0.905759751635629, -1.0425674952328943, -1.6076225948838456, 0.3764248464644242, 0.5210651997653477, -1.1214516938706263},
    {0.5812745139541415, -0.23022866542537707, -0.2564415962087119, 0.16426968971470504, -1.2995866431876073, 0.09800168917382757, -1.865475240027989, -0.8261909653432048, 0.42634370666760335, -0.474360165934761, -0.29457963790235836, 0.20971280119224037, -0.6778503346157024, 1.8102996206179764, 0.4724622400920182, -0.4145346385675188, 0.583284039376299, -0.9777830886573905, -0.591850629205748, -1.1196022259619596, -0.6343355661487134, 0.4020999340256442, -0.07234711192319238, 0.17653135262824857, -0.12278734843197471, -0.08693973699238768, -0.6102309903407093, -0.984710626438353, -1.0362849510863257, 0.8439181165171443, 0.6076226065787469, -0.7928063108887983},
    {0.26575893592840977, -0.8620844659571045, -0.6629069726051044, 0.04381413896831058, -1.593711891607731, -0.28794100262902506, -1.7118876453207252, -1.20696360519191, -0.3860378832381598, -0.65985027697839, -0.5567173161186351, -0.2493752427490057, -0.6764151211149054, 1.1947843674985275, 0.18298380444311466, -0.47917373517982603, 0.017806700199173738, -0.9890629012396303, -0.819867663658263, -1.3670793602671436, -0.9884496360848835, -0.682686757042313, -0.0217795500778775, -0.44759219415576995, -0.9549705469763913, -0.09896838242589737, -0.7460740005715921, -0.8806218635614782, -1.5653409039179649, 0.5074605284913614, 0.14647414386337357, -1.2220949722359047},
    {-0.8202498822212001, -1.4013517061954668, -1.6872552004988999, -0.6655037360748695, -2.047334464089879, -1.594816521453567, -2.1436556484022855, -1.7258592373588626, -1.115758913553826, -1.2141202630565513, -1.0012055162507825, -0.6716542927011968, -1.8371195186454725, 1.0055487544113835, -0.6349754363525162, -1.4611055559217823, -0.2622328536890975, -1.9031474949205287, -1.4140864813930187, -2.1631563163874423, -1.9911640647347544, -1.0696972373706788, -0.8122482774228521, -1.0848429073193433, -1.8042825452060265, -1.2514788291341865, -1.7816054744116085, -1.9048493409637173, -2.0075118512336774, -0.22371181902704404, -0.006663023874956502, -1.7739831745515804},
    {-0.13296400643175976, -1.1911078929729706, -1.595233509460387, -0.7418394979038793, -2.1633028069335016, -1.0284965673287574, -2.253648016934327, -1.5734383259126996, -1.0853497903567182, -1.4003403808058303, -0.7679487083176462, -0.8003598960257249, -1.6534058664852362, 1.7171743189035718, 0.03875707785691025, -1.3573872476516768, 0.272819425803514, -1.8050044082925474, -1.478850040407336, -1.9657088766130915, -1.2828535597145656, -1.121311158824981, -0.5376255228869484, -1.310009292447969, -1.2960300813896226, -0.8327709282881001, -1.7179705011215347, -1.7936220649690537, -1.6017923218521684, -0.322740232264672, 0.28668914242412374, -1.8334187293775137},
    {1.7338076169680032, 0.28455863166937817, -0.4453236437833296, 0.4955171826667685, -1.2771817021359742, 0.7047573209691822, -2.2057384929915407, -0.7533760831803504, 0.01739914499287164, -0.3616277463444615, 0.7352602560817941, 0.4449423821145855, -0.4175363883747656, 2.5118749279676544, 1.4355416498538236, -0.014989010172538786, 1.4893328745160277, -1.2165392437354248, -0.8583596862765336, -1.3242646337592463, -0.4462759376483784, 0.37474474175271005, 0.9994867763254518, 0.028238106797529708, -0.1995350273872234, 0.6904084580123062, -0.6573127655005804, -1.050084596161234, -1.060026909880594, 0.9266744473720843, 1.0559170123232111, -1.2945941538293935},
    {2.307024674891709, 0.7218427729532741, 0.48529394039997986, 0.9720772931419236, -0.42628792197645793, 1.447216016956614, -1.970408700353763, 0.21092421105733816, 0.37244858645785484, 0.42243900124835093, 1.5585819923159432, 0.4478520608602598, 0.3398307680803503, 2.9181327853717005, 1.7571494515568096, 0.9562937340279999, 1.91420662083396, -0.12417743271091207, -0.7952087505072102, -0.7678059551239532, 0.6032742693668285, 0.6966258405296671, 1.7028020780878321, 0.05668625669196992, 0.7844742817652711, 1.6991427341606085, 0.38394759400178147, -0.41332425155833885, -0.6586543649436869, 1.1692735246714965, 1.494180506007721, -1.7090083967594076},
    {1.4499517147455718, -0.29425519692093954, -0.5944669615438173, -0.15250306000182648, -1.2723153469618063, -0.06685138311983305, -2.2316604245470884, -0.9852093280343075, -0.7883913155465352, -0.7155977390097116, 0.765636932323973, -0.23873295105017717, -1.031388327547693, 2.072860514978512, 0.7056190894952308, -0.31472125817274227, 1.1233687404868062, -1.0790278338974313, -1.424339232950259, -1.4793150625209786, -0.39190152483119717, -0.46130002795407676, 0.5081858102902462, -0.9063691012849961, -0.6892877610456858, 0.6540063329070187, -1.0092759869711934, -1.3646965933570039, -1.2549876955887498, 0.3788414974371677, 0.8121004029285416, -2.1842528902709946},
    {0.3277573922452914, -1.034884508776336, -1.6076258688576184, -0.4392212764153128, -1.760502653466195, -1.036631025682696, -2.3891654446695108, -1.8092920648401472, -1.0383025507622108, -1.4853050610251637, -1.0246861533759413, -0.7482982909549013, -1.6919234283268973, 1.7020354191232918, -0.18816447814407675, -1.3908540163784147, 0.21486988935901416, -1.855988862201143, -1.5842619687046353, -2.1277934279427924, -1.3517588919041932, -0.737525892413821, -0.3400637739938449, -0.984601468893227, -1.5113475984863325, -1.0420898046975773, -1.8328107566081262, -1.7234436328548397, -1.7664735039079567, 0.183516252645979, -0.11223677970896201, -1.7450192734295837},
    {1.2766789015846418, -0.10526085837116986, -0.5336308588377856, -0.21322452720121798, -1.2853481189609999, 0.4032197447292767, -2.3050203420611317, -1.0528592722567383, -0.37121133264599765, -0.42502549064739026, 0.28002581676782623, -0.5571294781852472, -0.6397545793652102, 1.9176755419171805, 0.9595384306037098, -0.03891316504583222, 0.7129283993339223, -1.1223244629513147, -1.2577052675687386, -1.5833236804678343, -0.3123081922761352, -0.04987387088482285, 0.7844475112293824, -0.8513400043138692, -0.6523945647810762, 0.6931245780409008, -0.5421812593567706, -1.1989189892827565, -1.247093234134748, 0.28171686585481387, 0.5045270694710244, -2.0739452126870117},
    {1.7647806271797055, -0.5168748951466858, -0.817332952658863, -0.11566126065461066, -1.1459400660245551, -0.061210971712599066, -2.239516306431798, -1.0135710753648066, -0.6415528181926282, -0.7581222587157439, 0.3163609612828878, 0.04000192154565842, -0.6802273665102088, 2.3077638577478647, 1.192034159914494, -0.40187770591773664, 1.0015147573283187, -0.7700610039634678, -1.129880657290579, -1.9681889332546454, -0.19527283268605894, -0.4503078379637322, 0.5204689240361624, -0.9895157336958434, -0.44490531184878274, 0.5302402160688916, -0.7317537687908892, -1.2192163249261392, -1.0620231752662836, 0.3434917518682749, 0.9003812004347996, -1.866861509741797},
    {1.482224039600812, -0.6404575847651912, -0.678526846497282, -0.060165150717839434, -1.0412814165027793, 0.04293968401409178, -2.534664636390599, -0.929064614930542, -0.4942441224722901, -1.1030089122245559, 0.1302956297205847, -0.5577542656852663, -0.7460377638748779, 2.4201161675317637, 1.09866538968286, -0.7407702269018602, 1.1390309918554522, -1.2398738584409437, -1.0236582168286743, -2.0769838055089225, -0.6101414011561569, -0.4144696100859862, 0.1700090143207188, -0.5737563791240238, -0.36523216833121486, 0.21712863859275985, -1.2907140876395329, -1.545004593372479, -1.1774697256750888, 0.2431128327944781, 0.7445288968475503, -1.5339939108039764},
    {1.8590220187589388, -0.05305191187008835, -0.37749569616425843, 0.13272043308093928, -0.9435638429018879, 0.31948441361326624, -2.5254224443224205, -0.45078272362691896, -0.4854487176187022, -0.5865225916360552, 0.6736300542754545, -0.25278894275187114, -0.6406426876073307, 2.216597062613429, 1.1306695080952736, -0.060290994006419754, 1.0798405533824873, -0.6862382090092154, -1.4732452825746145, -1.8112339941329532, -0.25218850056896386, -0.24123723506300238, 0.7036666576174834, -0.41726518587016, -0.14279128180715409, 0.6917974229203434, -0.6737080239284715, -0.8790767241754693, -1.1012433130890271, 0.3327645462331412, 0.8860238725158444, -1.695137975478721},
    {1.8833243453358606, 0.12100929945837441, 0.10036556180402066, 0.3575136223256355, -0.6307560355955889, 0.6154141991501232, -2.118378442302004, -0.6010082985194588, 0.1863502152152671, -0.2824359802303693, 0.9010203310600332, 0.09936372275635716, -0.37386225527735256, 2.5489626836655503, 1.3687315464386323, 0.1281075605584711, 1.2204210672875315, -0.7034198228390212, -1.01184368932819, -1.2528211352163432, 0.021090452813765988, 0.2610051780323536, 1.252281628847353, -0.49629336579766514, 0.19044363797965716, 0.8881828244820458, -0.4134905778005436, -0.7782379593687369, -0.8194071303552095, 0.6325205334875124, 1.1080573119064219, -1.4718717942447128}
};

static const float b1[32] = {3.7337081038866047, 3.5595147164333345, 3.5731302895624375, 3.854092609694766, 3.854324236687237, 3.714569396187187, 3.8139062851690135, 3.73585215497082, 3.7214571982050306, 3.6541013861087515, 3.6348426780428906, 3.583391826440531, 3.6280627635189626, 3.860283609708529, 3.7834159361020596, 3.7097028173330435, 3.6707883510254136, 3.8124908191361984, 3.8521567404837227, 3.6667209630090647, 3.770414613072294, 3.69372560116239, 3.6190364673785713, 3.760323918412517, 3.717672987866759, 3.64626146530714, 3.6237868263376622, 3.6129274393068496, 3.830913632613827, 3.7678360134532287, 3.6023533121320206, 3.7352020831038235};

static const float w2[32][16] = {
    {3.5570439539861263, 3.021817525307604, 3.7561264384915156, 3.1938926074872027, 2.930895212795467, 2.860612089167614, 3.193446892148557, 2.027185699582015, 3.4448696450186955, 3.3082757324793106, 2.9405581862108123, 3.1895889986714674, 3.501733296468448, 3.3047361276033307, 3.446724426604576, 3.1348186108757936},
    {3.4916154505605577, 3.038496654115144, 3.1899417655875157, 3.0861410819965167, 3.6138709348771894, 3.357866820007764, 2.9243979168222785, 2.649317222396851, 3.055236369746282, 3.496422216669418, 3.6398176873849826, 3.3962190958070253, 3.1994705528934224, 3.514617861286771, 3.2174259285897775, 3.552566515727254},
    {2.81744915724161, 3.1860369526321497, 3.168644754913497, 3.547943787812427, 3.4387634135698484, 3.281233024467609, 3.3337022028805348, 2.5742619542731764, 2.8577160895865314, 3.707350624782185, 2.624364730990385, 3.4156241012507627, 3.4342755463507877, 3.500670999518562, 3.3381395291077, 3.313129832305069},
    {3.6926700197145, 2.935242801785953, 3.125004386532625, 3.4618248815525727, 3.4538619531593953, 3.3646218973850957, 3.0596686259023507, 2.7219683554871534, 3.694115049295076, 3.283152801669698, 3.1335752908422054, 2.9841689262171682, 3.137739747446909, 3.299199117597621, 3.219476093988104, 3.092629229523171},
    {3.4091152351322194, 3.4972500844292926, 3.2792102448336005, 3.571825589116503, 3.8508437168974057, 3.6965599956216004, 3.0518713763080254, 2.4885359256828563, 3.0166626865343322, 3.0792239491588633, 3.00519357987167, 3.7139598989042737, 3.340245820033366, 2.9385118983756633, 3.3334789831201665, 3.2837324816786206},
    {3.300292950512264, 2.9173574673380953, 3.302120327071304, 3.066850434229656, 2.9303618563478273, 3.1703508776333518, 2.864861063007075, 2.403731103686976, 3.1127682680023296, 3.477465217988838, 2.561914289689257, 3.160932214977318, 3.4191432790028666, 2.881681975917926, 3.2265591219917678, 3.541861452333111},
    {3.3468757400248808, 3.5021696509730154, 3.2639800633663567, 3.740329406603562, 3.410179368603073, 3.425389894777523, 3.4656952644879815, 2.6583093816360908, 3.423313327140429, 3.39421306863647, 3.4344368836258155, 3.2909477406002487, 3.568766040508013, 3.7457138605094236, 3.042305063705738, 3.5042180503849276},
    {3.6966879814910163, 3.1428435403035007, 3.880216100759892, 3.5636916988904264, 3.3229235416420697, 3.1908721586073847, 3.1998142756639236, 3.006417571036768, 3.413191406209253, 3.3206455073799876, 2.853743247308848, 3.6000853587742148, 2.9408446092436726, 3.7676584359574825, 3.5233428864413616, 3.562010010981557},
    {3.5687427538739174, 3.480129650567857, 3.212657646619989, 3.283153357194327, 3.3265929307063113, 3.4835822788609083, 3.326430732338159, 2.7160441274691287, 3.320472552130121, 3.4494628132002436, 2.843493655508132, 3.7948385283123582, 3.117113938876585, 3.2617796124927008, 3.3458716566930415, 3.696578153717358},
    {3.331405702960108, 3.254814319531691, 3.154549402733719, 3.151161851383856, 3.3464969736934687, 3.203488605076522, 2.9238669550602396, 1.9455203208498775, 3.196138935274344, 3.4940779892862883, 3.151725954993217, 3.3924534967034847, 3.1532775724493844, 3.0007025134157486, 2.823386641249099, 3.3899221148301013},
    {3.380339599437332, 3.263574850040416, 3.3811373024390057, 3.449311163257369, 3.3146678069988846, 3.1379805692864613, 3.2401971949068646, 2.5234298038817955, 3.197461180766206, 3.0307495010455834, 2.73779243946777, 3.482777629975541, 3.110346250683416, 3.0992315508540997, 3.429864910430989, 3.1603106434368824},
    {3.737911929844247, 3.6734384211731967, 3.6063456572729744, 2.8361221866470534, 3.0681456028850365, 3.14892684563045, 3.0127014897678697, 2.723405097262985, 3.1738876790727035, 3.5667312816392123, 3.2309558633960527, 3.119238179027735, 3.930409963101701, 2.969442184429896, 3.407096376211569, 3.5877314277148957},
    {3.122288038449585, 3.263080978678425, 3.112370368902976, 3.4552573156662065, 3.3097456024159793, 3.4340192055266683, 3.5193934146479124, 2.808483299742812, 3.8702544122015903, 3.826076484516165, 3.1780312840149803, 3.0441415029145893, 3.4054846779049237, 2.9090089072338476, 3.2534953944433123, 2.9702306854324068},
    {3.44892169809415, 3.2513282005960575, 3.1418823778087543, 3.40849403078634, 3.0526255737859276, 2.5788182457838458, 2.6569137500649127, 2.477133482700041, 3.3234498622163877, 3.1364443524439394, 2.94617602760979, 3.520526639877406, 3.165837177052407, 2.984208503138887, 3.092491540720026, 3.6989664527527637},
    {3.275678233587415, 2.561870153436778, 3.0943396268514225, 3.280998124895411, 3.5900008210564005, 3.2803740115872793, 2.972989717141888, 2.5164220301647258, 3.3343085178218757, 3.7138907363388554, 3.091187794328014, 2.936079294354174, 3.1951291517298133, 3.1853450047298804, 3.1899167745731396, 3.3414542131867457},
    {3.33867570647852, 3.159864988090722, 3.076009502308095, 3.31400184848281, 2.6969525445783766, 3.420160459588662, 3.260460292388779, 2.075984615306323, 3.1516129518213383, 3.153265347257066, 2.8464411426351863, 3.585235156057613, 2.683496150066599, 2.5658792805858583, 3.1169837027511904, 3.2892791723709824},
    {3.6035246260206755, 2.9380054867938945, 3.2166118253345966, 2.9155410834844058, 3.4397339244919403, 2.6761823062692303, 3.3064983314012952, 2.1888279270680853, 3.272136769496522, 3.4343591571182754, 2.940381714863577, 3.0182551483059097, 3.3771569390660336, 3.315570118765335, 3.1955706331321787, 3.1435589170959317},
    {3.4125049313802833, 2.920466817941716, 3.5060298560379475, 3.2146644783074927, 3.566997188561267, 3.4768690231210595, 2.7995718473494704, 2.4135369003233667, 3.207213590673187, 3.3156969667403042, 3.2154917539389998, 3.4950188539559517, 3.1982792454280293, 3.095118498503408, 2.8595470070134725, 3.5545430452036464},
    {3.3827801139735736, 3.0886083176272194, 3.400912754529247, 3.2762482973030367, 3.4103653074328153, 3.0923751832942727, 3.229837479534453, 2.471592776574406, 3.46092125498213, 3.427527783460982, 3.278100299546214, 3.7892904878093603, 3.1756705333225, 3.8010210618312956, 2.8271937155545075, 3.659249694091964},
    {3.5975736326490715, 3.068055426273701, 3.753188409179291, 2.938448000834535, 3.146903675918966, 3.0654232785115956, 3.1148833711556576, 2.022677428204358, 3.191739120424664, 3.318041810695926, 2.760076549791035, 3.2376119087398854, 3.2094300167941734, 3.2779956959661063, 3.3253391362578233, 3.097212113344205},
    {3.5558920835818313, 3.4752938701685343, 3.305943812787414, 3.239987281120904, 3.4324288101208698, 3.5436817861341763, 3.0634003454556185, 2.699134714656506, 3.0168106514687407, 3.611935197543409, 3.079256093909218, 3.7279028382578447, 3.332636961980929, 3.672045966624149, 3.448645349209804, 3.787708438199571},
    {3.4800146590592087, 3.10198512236283, 3.506156960452859, 3.5039389449138136, 3.0578748956377186, 3.3453474391909523, 2.7993380017475373, 2.5859962778553736, 3.4175625191219097, 3.3240996152104256, 3.498287654586916, 3.348831315540178, 3.7842887200088375, 3.1654774815028195, 3.4351536242651353, 3.084998278372422},
    {3.069482852027708, 2.948565639378941, 2.837113082459534, 3.4053968734517137, 3.207607682582124, 3.483610028730551, 2.9268508798421107, 2.924407002050964, 3.3880740287730764, 3.4025658534371805, 2.993564775795347, 3.2431264122690453, 3.097965052498715, 3.2108252003811644, 3.176153209529545, 3.4944776402934337},
    {3.7472037686977453, 3.1788863462814136, 2.9786257840602386, 3.364995536560905, 3.3806690710926746, 2.910042059214689, 2.688276568186564, 2.2222664862881634, 3.8105834454637977, 3.4437518784176846, 3.10926232990563, 2.674277841859478, 3.3816202208839488, 3.527886486850343, 3.6391223081391, 3.496584514367604},
    {3.7167190884481878, 3.557559837038842, 3.6597349562607775, 3.306538942454259, 3.4236990287760025, 3.429979005587229, 3.3399094681994157, 2.944871455723786, 3.5640232800347293, 3.4404993312293946, 3.679925825688082, 3.6824624260648897, 3.272838206228088, 3.3741635161892622, 3.55156536512221, 3.4663193595526613},
    {3.0714198991591704, 2.51197149494189, 3.2839709867181734, 3.127096097966189, 3.4964085453575717, 3.5356972493940444, 2.927647401159328, 2.377670127233045, 3.202450623782228, 3.511456883574768, 3.0735083947697017, 3.350974217729137, 3.0787119229346627, 3.3825726917475794, 2.982306355011998, 3.493389285332602},
    {3.3837398632894997, 3.265363623855598, 3.206895331627679, 3.3881601721752967, 3.003635819205577, 3.253263027998853, 3.322139059413037, 2.418013159406021, 3.2934711488030737, 3.2302939596227747, 3.066972361838109, 2.9697107459861236, 3.1768546847046, 3.0275468336873157, 2.8548787792148786, 3.3762143453150317},
    {3.166818934650874, 2.8039537917499833, 3.302817805740237, 2.8716496028375125, 3.2064230857886438, 3.533302809002375, 2.688843203458592, 2.602853297933501, 3.1131224585018265, 3.5727033960631625, 3.1013173679173645, 3.454290111818876, 3.227782620131729, 3.1873213464188854, 3.1671869225567484, 3.628856483308296},
    {3.7843989224350127, 3.5079941051908916, 3.623135298346178, 3.1554106814387075, 3.7530836266883263, 3.5561038424651916, 3.0688280662596017, 2.572570666395532, 3.109271762616138, 2.975242452594913, 3.66391841399396, 3.3230952430102767, 3.9260138377849407, 3.562138274919482, 3.2860997586872482, 3.267457925384394},
    {3.3053794056142594, 3.202402305372884, 3.35581718062077, 3.1879936459352036, 3.1047173663500756, 3.1580398749581895, 3.4100471358264826, 2.4750555541761607, 3.518100943483545, 3.0986194179007036, 3.818228697807091, 3.3063524231624095, 3.3082167790936374, 3.047444670209688, 3.8596318503110973, 3.3472070810250263},
    {2.9865258783799415, 3.0914653149988154, 3.1782057415468574, 3.462902764551131, 2.9187707459996197, 3.0800873169139837, 3.104861798593366, 2.569392737522076, 3.392023830275822, 3.351367868314686, 3.234647862614228, 3.2021223181150384, 3.866788880127714, 2.7852215475384288, 3.472862700682637, 2.800143733289498},
    {3.642251491387235, 3.530620892615705, 3.2717429169256254, 3.3536566856473518, 3.2991860133870317, 3.448554693841575, 2.9721643085631078, 2.81749972419531, 3.3427594130014646, 3.4788084306725215, 2.9446818123256455, 3.3876131165541707, 3.324173912235729, 3.3675996023337653, 3.348938154102531, 3.6045673460620025}
};

static const float b2[16] = {2.9046659557280354, 3.0243730063518193, 2.6976154831932155, 2.641945073078283, 2.843659927865781, 2.719598621097841, 2.858683637968089, 2.5199594064051336, 2.6053069016787553, 2.984114634588715, 3.0046241273084737, 3.0277383665672493, 2.86353956521484, 2.882119706682203, 3.0451053190575963, 2.7049888749746605};

static const float w3[16][12] = {
    {-2.4342064738167632, -2.7572647700105204, -3.1972354619107994, -2.819297401394878, -2.9307932572623323, -2.1312992671916704, -2.8850824358596396, -2.90982948101434, -2.3177722991235905, -2.3314403268927477, -2.690076818528035, -2.8292670276333483},
    {-2.4023884256305994, -2.271457774225379, -1.9919274279312098, -2.693692588500171, -2.9254931404877644, -2.9391631182270075, -2.3302262765527395, -1.9735360917416696, -3.3142476483698933, -2.5056103862410932, -2.606519691429589, -2.4358431139889323},
    {-3.2360601022730027, -2.097401910705349, -2.689694197661539, -2.9599179986228674, -2.8160817960335356, -2.427848095020168, -2.6647729315173923, -2.9112462078284556, -2.547462942131283, -2.731766731166721, -2.5738458482623243, -3.0559536359028496},
    {-2.9278655540182505, -3.4797445304012324, -3.677372534774505, -1.926273337915109, -3.0323625915863803, -2.8540666586306545, -2.143760645617714, -2.572021138445707, -2.238157549805598, -3.162603244644676, -2.653353640164657, -2.7044266067045672},
    {-2.3857584945166304, -2.8630966703299685, -2.800872609015457, -2.818351721958602, -2.589657603171441, -3.45877424957558, -3.0583958750801283, -2.9381131343735394, -2.3557579187258058, -3.368456417988828, -2.9047855372769553, -2.1364364607026474},
    {-2.627784767639635, -2.912538886862157, -2.843854006172058, -2.7771487627083022, -2.5134867797837517, -3.624538016614881, -2.840747353813363, -3.0125273453885644, -2.174997174663733, -2.3318149120536034, -3.325553306419035, -2.7067294031624973},
    {-2.6338627324145305, -2.4266685299025155, -2.97819791298968, -1.917708792154585, -2.325488388480323, -2.076979499242636, -2.3317164849360914, -2.504511717663023, -2.8436977828733108, -2.4722171938110122, -2.0155315162452667, -2.8247434153393516},
    {-2.343129535954705, -2.242464777814579, -2.30817585249308, -2.2672069827316355, -2.5502716998030657, -1.1676185386599622, -2.51226770979935, -2.788950180139082, -2.3303811746073553, -2.1251953878059937, -1.3856274248380458, -2.2373913271384946},
    {-3.3045510686093693, -2.6769262051475353, -2.9302746659444048, -2.8735955551341963, -3.163771658043989, -2.6435684928365517, -2.752274404102293, -2.725099954216513, -2.7807532210003316, -2.7654036415907677, -2.5482926869916365, -2.7980476552194466},
    {-2.522955712901322, -1.495733090722769, -2.6117762390250006, -2.8032960800223456, -2.3458397686409604, -2.9779140466597998, -2.1714795808738785, -2.508427504157373, -2.517954450717189, -2.998803853442108, -2.733194762834239, -2.531539860072499},
    {-2.0778648562065554, -2.3923060920583565, -2.0689612288598194, -2.833277036349692, -2.882579256989329, -2.645326651510885, -2.828125511833838, -3.0936110782298396, -3.299916749009565, -2.4906817721841263, -2.87397179467273, -2.4921773854966456},
    {-2.387676683492756, -2.786787004758068, -3.1938325423778555, -3.1826999309089423, -2.259750236403839, -2.076588472645164, -3.445364185477716, -3.1576276269921753, -2.6544488753251305, -2.516935417712366, -2.4780972247366444, -3.37690302855905},
    {-3.732359825772191, -2.855362303754533, -2.873350002718493, -2.2012694765809155, -1.9835591473691092, -2.3156104438657232, -2.7041369514597076, -2.872286226790449, -3.4595834298490558, -2.443501779233618, -2.707255326066118, -2.834198338509616},
    {-3.089644972287163, -3.4914085463783717, -2.021553657790769, -3.0138478983221133, -2.442689516024593, -3.038828900656188, -2.957065883751268, -1.6102554191857796, -2.2941386349201416, -2.6910406565651863, -3.1648630356904284, -2.6336452359871427},
    {-1.8757246102299, -2.266157986392132, -2.913011451299113, -3.2556838324392823, -2.879904501382163, -2.963439756782196, -2.318094909347365, -2.8696428597068633, -2.225539958913159, -2.808339874540173, -3.1277357679040847, -2.744044543937138},
    {-2.601589653899216, -3.4099866555809606, -1.555858282041492, -2.255649624891243, -3.022454072256846, -3.1090547473786057, -2.8916947516649647, -2.298543340796682, -3.38550184117628, -2.7926713129132112, -2.7174796291779977, -2.2796051563038544}
};

static const float b3[12] = {-1.0981018477879096, -1.5819867893972115, -0.998176109103646, -1.1938297814839616, -1.0281878625896312, -0.8177401909701583, -1.2925127225969095, -1.3506677776809604, -1.5106757910614765, -0.981684253453579, -1.0218172411935007, -0.9537060429129112};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
