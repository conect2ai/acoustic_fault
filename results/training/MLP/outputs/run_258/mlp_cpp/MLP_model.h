#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {1.8174471219132478, -0.7259590590880899, 2.28774373261427, 1.3640064237088811, -1.2781283074916217, 1.3872368342254875, 0.9909089312241168, 1.6502826738071277, 0.32997238511144017, 1.1015714190103147, 0.7698655420101103, -1.9247151080125187, 1.286254524293259, 3.3788505129380204, 3.4966922660192865, 2.545456191335154, 0.30862051677407826, 3.6937583329882395, -1.9190761057906673, 3.2119849003622347, 2.4129787540239156, -1.2269100887597335, 1.467232189452466, 2.1142326096821336, 2.7887359179821165, 4.29551776363631, 1.8453489274899166, 0.03714405763438089, -0.26909407021047993, 0.1571392485040579, 1.453234246578193, 1.1721918290434086},
    {1.548432313020681, -0.6331850852475615, -1.237637587682557, -1.326717886465599, -1.4332332928451879, 0.9088331145548091, -3.231733862365325, -0.25751666723178823, -2.4259192619527497, -0.25291645505108734, -2.6719360734170823, -1.7220895867569308, -1.7607885683617808, 2.6359991544922847, 1.6497283410267174, 3.2259146139398687, 0.0754280618136807, 3.249527649398448, -0.956771740593546, 1.0533890276222062, 0.03011595065419789, -0.08624071875391087, 0.29861786505118504, 0.9930469833598304, 1.0338037211824103, 1.0958929430256465, -0.1809185729279218, -1.5286653197217617, -1.337064456180349, 2.365651684263868, 0.10387879573866778, 0.32144679784994185},
    {-0.40448616454766323, -3.0080412294287893, 0.52112799514731, -1.8866224787162873, -0.4951054669472958, -0.43484306009549206, -1.098561322214447, -0.49841816481639695, -0.3941742710665356, 2.3820630115831936, -0.2255276851613412, -0.09106291383941036, -0.03676647675096779, 1.6065928403012293, 0.19338171890281178, 0.3229915442716824, -0.6809901821339994, 3.5543056202166516, 0.7481087025557634, 0.566626564692984, -2.1213392485566116, -1.565767988025316, -1.613556306151763, 2.179525245717676, -1.4081002071101898, 4.370494537183688, 1.320186399866954, -1.0112071211944358, -1.8731311321886697, 1.1820184025145275, 0.7817305037350956, -0.13855962223475138},
    {1.5587321340591205, -2.314044600824981, -2.924037619946345, -4.94878043099112, -3.0877630673511915, -2.150548515828883, -1.6936800815508348, -0.576972794650491, -2.732296524191463, -0.8026344775102308, -1.1879156969761, -2.401572974515451, -3.0610040054497034, 0.20481473576950854, 1.9620553747174938, -1.633245398695837, -0.3254222607298648, 0.2116465537240537, 0.51007965286732, 0.7856306544362314, -1.2874261027000913, -5.5588656719455125, -1.2768633636565991, 1.729523722959719, -1.90503925887725, 1.0190150219026448, 2.8917005647735428, -3.5433079368475653, -3.20680053790912, 2.53847210498713, 1.5871373920779408, -2.538778047141412},
    {-1.2314817869575458, -1.7597647593947119, -2.7775462330304626, -4.423163684034233, -4.222677366606551, -2.7832148996380486, -2.268274548354466, -0.9576849560466034, -2.088179761137593, 0.6324655228241394, -0.40635771374228463, -2.0707825573425582, -3.404946238215844, -0.4974894783814165, -1.555587221079929, 0.9691083478617176, 0.6276536565681681, -0.026528857152280354, -2.1932191262401024, -0.2569805969261454, -2.268102055668988, -4.023843664706882, -0.49671058544843677, 1.6671283021164889, -3.9459795366328017, 3.213746345260414, 1.5590965859879586, -4.11695800067035, -4.548008866831168, 3.615791140002901, 0.3860639739444364, -1.4064026134753018},
    {-2.9062018486343195, -3.2133682778457984, -4.304383802815078, -4.46009454202611, -3.906284109809956, -2.266134573434561, -4.65076348375671, 0.4113071218862279, -3.154101349404364, -2.6680323422373595, -2.016411237070194, -4.260884349850475, -4.260753100640365, 0.07550510167696668, -2.7391308662297735, -0.5293359247117715, -1.752864214829517, 2.3799623752109027, -0.8170795678973752, -0.6634107125594398, 0.9252959676183714, -3.201803038753775, -1.787597655650853, 1.3652172605507638, -4.136720829526423, 0.5354240852740904, 2.5547591283749407, -2.5975170691156526, -2.6376075292861945, 0.5861836946144758, 3.37498582420815, -1.3492838200118262},
    {-2.9294991050290786, -2.732966260333003, -2.069415366028694, -4.053375850133022, -5.66153226850187, -2.394798577972911, -2.9650907990457784, 1.190620992553253, -2.2251336746854853, -2.13944571111441, -1.8550497360520282, -3.601373859475306, -3.1699299520551922, 0.8268497190076599, -0.6651370410922977, -1.1792697741092126, -0.4891151431716344, 0.2820592829154622, -1.9517022724532505, 0.5175259759635763, -2.239049892076058, -4.984057555907716, -3.3225194925699326, 0.7995821057373952, -4.883936304458998, 0.21679578741950434, 4.125392732769328, -6.423992778616142, -4.549774470695569, 0.2537559459404806, 1.7013637767291534, -3.200205653334485},
    {-3.5126153287995603, -6.325241074503041, -3.1289165982166125, -5.4340224987925225, -3.504780270820756, -3.1237190159634856, -2.812386109305166, -2.2864241679266377, -5.007364014000405, -2.6331119755289683, -1.2497176017806508, -5.741481869941143, -3.6323099484686807, 0.407644053975321, -0.8644204072980523, 0.5234763911079238, 0.25863611858975355, -0.7290535635243188, -2.8349708604763784, -0.2401803998296262, -2.4557806801612023, -6.137351400554819, -2.2901959543485595, -0.19070078899719323, -4.034302246091821, 1.1249028018524776, 3.5425526512323025, -3.510415346269112, -3.3538563520275937, 1.8906968802822743, 0.0785360555984866, -2.2260747367808023},
    {-3.7840759030600446, -4.064225919950481, -4.624345945746307, -2.916020344675207, -4.162771833234226, -2.9191508691113617, -4.961224151552361, -3.0302286804853655, -4.472230674367603, -3.034505644723303, -2.3996756411691322, -4.8297929634275505, -4.8648735452899405, -1.6264516166595078, -1.7439359661024707, -1.6195706262989815, -0.935489497947278, 0.3605597033776886, -1.5384494647473048, -0.975870383595687, 0.48308417418759136, -5.24068427198037, -3.8848399866053693, -2.1445017248678435, -2.5238941288852303, -0.8025422959939615, 2.4794759429145556, -6.2051269298616845, -3.113750997326123, 1.4157140629456304, 0.7688638504113368, -2.606462039708647},
    {-2.953989365257005, -3.539752861577496, -4.099718204117426, -2.8530866948412954, -3.582321965046243, -1.3973545746886247, -6.100186463354085, -2.3769740847878404, -5.329440213741937, -2.307815011766391, -2.69969041087694, -3.5115840966686585, -6.111505475312112, 1.8717959173052803, -0.013312922832322325, 0.34753852461441104, -2.22237450126512, 0.8178819225158702, -1.52581998880247, -0.6640063194406297, -2.3069619786204623, -3.9728214353184588, -2.161003753355566, 0.4695155607265191, -2.2890205973366737, 1.0224506030319171, 3.6390185052423556, -3.0256003896609514, -2.83321019111785, 1.7660642267839686, 1.2297342930888253, -1.247298425002137},
    {-3.283821875136517, -2.6308358124145736, -3.094538370272796, -2.1395889838064988, -4.184095311940292, -1.3701687615602764, -4.565217680889857, -1.4905045090666944, -2.926138116621136, 0.6489741931790665, -3.132124121332002, -2.9216982840073413, -4.451553351628535, -1.5411310731630243, 0.045562702030411004, -1.5900767417820527, -3.096799103173559, 0.8512433584567418, -1.4139305709770211, -1.5595951113580546, -0.4574898352141275, -4.255560887429789, -2.196641970585399, -0.42747114396342667, -2.1186960226274523, 1.356190119730663, 0.6657425593659227, -3.644332277472632, -3.1046160564482026, 0.8752221636729524, -0.8309901619493746, -0.7041358910635869},
    {-2.6928763146413646, -4.451053403165336, -3.7508597260742667, -5.421314397081912, -3.6574511925989857, -4.274235534406773, -4.998893056582526, -0.14993406229434803, -5.527066657565193, -0.25631554247646043, -2.1970614840750504, -4.982252532782319, -4.393861124648864, -0.08923757410453838, -1.6675745423642698, -1.2683592145947336, -2.491531161398279, -0.22354725749426313, -2.6962469472060127, 0.00260801154278354, -0.14366101767385878, -1.9346389050001913, -0.9007306457394063, -0.5567482439476276, -3.24590750047508, -0.14687393315710653, 0.9487929737366608, -5.247959801240437, -4.3868873279149305, -0.44328858269763455, -0.4039480576309328, -2.504271605862753},
    {-4.109588383034389, -3.6319676543485793, -2.3555794635872003, -4.81061225263654, -3.742700825713377, -4.1832286925673605, -4.321964946647516, 0.6956141834751892, -4.503476067405374, -0.27766590598464863, -1.7771637904531083, -3.182676119684843, -4.121792063798087, -0.19033640299065815, -0.6057401794868555, -1.2701833525718005, -0.8308181154505742, -0.5802378195284863, -3.2716882222181725, -0.2897471090243373, -0.702730784946594, -4.717156514266965, -5.090162347316967, -0.08083663528108104, -3.7177969014611487, -2.419461521201593, -0.3528897600227112, -3.055789106004125, -1.2780548603132262, -0.3234665426149825, -0.7954866147183332, -3.0541802065190526},
    {-2.8584247435824706, -2.476396994504002, -3.908586660523293, -5.556348439778193, -3.564614083175323, -1.8598904234731255, -3.1874335222889485, -0.37095567340732155, -0.6207401347190677, -2.759113696821466, -0.439528412902205, -4.133851890673292, -2.3208258637230683, 0.5848450145540104, -1.2635672569529193, -3.505577244449824, -0.9782930485388043, -0.4031010707787046, -1.0290244405388116, 0.5376360228619544, -1.5500557554826853, -2.0687930842193487, -1.527071025543712, -0.6161640735465923, -2.488069831443304, 0.004436379588056296, 0.1355290647996867, -4.5027433077603956, -4.577353613428438, 0.6057905107844567, 0.22760146410162566, -2.038664689451619},
    {-3.2164287777452962, -3.660640264113894, -3.3339464926914433, -3.406968993155322, -1.585089123262083, 0.3859088947809482, -3.451720093622826, -1.3918461476912742, -1.7572997659223546, -0.856198735335838, -0.9586405876936537, -3.2260932308986914, -4.672880788938389, -0.6828606855798295, -1.5869758011574961, -0.6684470718349442, -0.5738808192603658, 0.24596260535132897, 0.2318872825658617, -1.6446903916848414, -1.5195977267700849, -2.953790258288132, -2.966839059819691, 0.3832729625547773, -0.17506429706908902, 0.49549963544516, 0.529521643587136, -2.8519186163974557, -2.868074102852063, -0.17433162614378878, -1.0644268613568062, -1.5337715638225036},
    {-3.3718671635667987, -6.075257520708117, -3.711728832286224, -3.4145061064789797, -3.4610466839284064, -1.1321110411082296, -3.8774857690650246, -1.4533425977608008, -2.7623805728491932, -2.1532946836603886, -0.8405972206400887, -4.512797924434969, -6.273474375056332, -0.9189735337648971, -1.5976339120452594, -2.6456442249570995, -1.1243671472321137, -0.2050180463217816, -1.7191350038968618, -0.00034725556651987396, -2.1327512883142608, -4.137527573078548, -2.809130999782367, 2.5800999091334202, -3.7753649191234486, 2.922766460175957, 1.0713306657568558, -3.613723922792256, -3.44592984783572, 1.208838712118131, 1.116071903388909, -3.105284256990908},
    {-1.0662908342102821, -3.9674321572431626, -0.5716277975151745, -2.7173205323432263, -3.6227188075478467, -2.686567694388508, -4.32945604670303, -1.615054229692151, -3.3791278002887575, -0.33687981394213, -1.5311572848402415, -4.318576140669681, -1.9111523116909273, 0.17364133743477356, -0.6489513611902399, -0.7108375613792948, -0.4874931121574496, -0.03950220409228242, -0.07784821281781416, -1.433855233823166, 0.8008585554375413, -4.483002623207519, -2.8630597875588095, 0.7283917725865933, -1.2829319480867907, 1.7924831060951754, 1.4667314930259847, -2.4167008249799147, -3.5232625431673235, -0.13283046694509346, 0.1405292942841926, -3.9284907334119197},
    {-2.7858505217331095, -2.67375766470552, -3.0658704592595316, -4.416781920255078, -3.140413702398087, -1.4515663549116946, -1.1477123251827748, -1.4430318344164181, -2.340631925015367, 1.045263485083228, -1.5722856875174374, -2.3880626675723975, -2.473898935869382, 0.600117044526608, -0.709297364909005, 0.31332513590776623, -0.6540190222729745, 3.9318515057044117, -0.8992673584876891, 0.005450277261577715, 0.47088105582329276, -1.540642698643043, -0.5344482977971431, 0.5342713960581768, -1.8934522525869144, 4.590815368368859, 1.3469035172231723, -1.557212948750734, -1.639043631931166, 0.31164646389225814, 0.3117565140267174, 0.08311561578738787},
    {-2.7471519693470174, -3.466908917007738, -1.2885432077750925, -3.04759587778083, 0.07025331192366278, -2.87526191059156, -3.4580011538112183, -0.4316007201848815, -2.588176419452082, -1.2508055332000267, -1.8466557008866344, -0.6491933177477716, -3.392505476607574, 0.21823271901875615, -0.11817454214966862, -1.1112685120562042, 0.25499336832245656, -0.2742519988761909, -1.4498111167569239, -2.232345803941734, -0.2241888541907394, -3.4687073175645127, -0.9328022874058863, -0.500961301199691, -2.3458391001785888, 4.600126572318176, -0.269951051720733, -2.022404017156361, -2.302726840875231, 0.15498424251074008, 0.18335728512588698, -0.5006141789401561},
    {-1.167996646889938, -3.997341970305852, -5.163748918044658, -3.7857951047006546, -2.615646394289903, -3.189342858100048, -1.9909699383110364, -1.3176447954591735, -3.817990485964894, -1.4005496054543873, -1.789181870068607, -5.6405107927243545, -2.922529296261017, -0.8770564894330067, -0.8489641960354528, -2.7478209238714766, -0.6463642364352917, 1.7534208023359006, -1.071291868444384, -0.5211538703602514, -0.4601209631775659, -3.632493403595365, -1.9913136978869497, 0.6726549141211621, -2.2914616099274894, 4.012684368417984, 2.2474661891924783, -4.581766667637162, -3.143664731491568, 1.2977662880981728, 2.21599813149289, -0.48053151866613847},
    {-1.8117399513235273, -2.958264865156648, -3.0746434639167233, -3.572158135388499, -4.708133974951832, -3.5502210396593927, -3.280872200544737, -1.2974854469369907, -4.82221215224456, -0.7311234838764377, -3.3359631614051284, -3.6967034638778444, -3.4898104808447634, 0.32967455787843986, -1.17703788943716, -0.2755175112511067, -2.5974769481268427, 0.11053215313415166, -2.64857677307068, -3.162008439536983, 0.11713856403642156, -3.688621316450742, -1.6603318149385438, -0.07546791453954271, -3.0820635068983844, 2.40889124132254, 1.5720890295844172, -2.2256722081031084, -2.1516881066712243, -0.43822418126728513, 2.238708406427161, -2.7256797725127835},
    {-0.5957383739547193, -1.6627586655702755, -2.043558153365882, -0.5099860548038385, -2.8865727300565753, -0.6122982632213579, -3.0797802820253706, -2.103858960667196, -1.1797503839913401, 1.1460447548132493, -0.8463878238071976, -0.3843139615935444, -3.541841557628755, 0.5235332228001458, 2.2228957226543513, 1.467813877430403, 0.9972923765975557, 1.5031649772908526, -1.8796089150347766, -0.4250644444329249, -0.7241308728950546, -2.740997291506826, -0.6026047722110718, 0.9713212019089845, -1.8888260043871485, 3.9222840133118853, 1.201902854768008, -0.7815015763583393, -1.7137976392999115, -0.6187940090121666, 1.8062376725335618, -3.5125770872779243},
    {-1.9907926545832733, -2.276299872597787, -0.9246703257152731, -1.072862908403161, -0.5611749357389815, 0.7928766268619631, -1.8218512214183422, 0.49396071507551204, 0.41254545321353164, 1.4205280517129801, 0.5765948787297395, 0.6229973048676972, 0.19715837979813858, 1.3293091713787928, 1.9118257962011975, -0.2874489089202368, 0.6987406486531149, 4.934534338971215, -0.35442441807770914, -1.015773324449124, 1.8079493433397398, -1.1206335015651685, 0.7527083467322866, 2.4586301002803252, -1.3240495235796093, 4.133188311325459, 2.2812116002427767, -0.4311591370154957, -1.0353482347468372, -0.5237909694937997, 3.686733162915895, -0.47899208441106683},
    {-2.309179807398387, -2.7411012241940313, -1.2776574696764358, -1.023934660103025, -3.785259991586703, -3.1407844614961706, -3.9539988365592333, 1.3122834997547899, -2.0301930023474855, -0.9962655921945074, 0.2444694919716759, -2.499661057189207, -2.8381602431903854, 0.6202089305393409, -0.021953295496174672, -0.6251032435741176, -0.16670814521922417, 2.436825952494786, -1.4393994248931585, -0.02540475401157885, -0.6228222847112642, -4.1104207405116595, -0.7710299506909216, -0.04217313691496583, -1.9634145398272431, 4.190467160626915, 1.676516501975633, -0.009330950961115593, -1.3529800660223712, 2.470295126133359, 1.7195070440659663, -1.3767530765802194},
    {-3.072374088694337, -4.36167250099174, -0.879251290611255, -4.397278692625605, -3.2360422434825247, 0.6556784395153515, -3.9240212847320506, -1.9549537914362194, -2.621836648868155, -0.11005596489469875, -1.6015313340301425, -2.706734282207614, -3.6629375476127297, 0.4243617789574338, -0.3723040962323896, -0.6081833677501545, -3.3469971528283424, 0.8034089954787562, -2.8756202597846614, -2.4794094176516652, -0.1914767858474108, -3.46996185275036, -2.0954895965186946, 0.36493750577670164, -2.713153460326587, 0.5533587276831137, 0.5572861867516097, -1.41015012002031, -0.768876085364053, -0.0621110820025531, 0.9339691723077618, -2.8015402123289483},
    {-0.47939325443322817, -1.9738163199095957, -2.6516556960584854, -3.3839681338737537, -0.5905918279732684, -1.9783239737290566, -2.1273089290257596, -1.2860379991351614, -2.9993333722911664, -1.7716153640530927, -0.47183600138639253, -2.2637921413611983, -3.809242963132693, 1.149815263579831, -1.5470733295512495, -0.8665719803257261, -2.184987248001036, 0.5388253548359738, -0.714989242421594, -0.8250337987151178, 0.4424657009318353, -3.8838957497204154, -1.2289091561835306, -0.23520040297794087, -3.554055506727347, 1.8643866256288137, 1.9923729615271584, -2.785839339764167, -1.4445165059199345, 0.34411781310919837, 2.3155494000109464, -1.8690229749033223},
    {-0.23918707361099187, -2.0189596583011085, -3.3649572964097714, -2.123286764959713, -2.6018334149727202, -0.685787641519901, -3.9426950415942885, -0.8831509920301536, -1.4492113291294608, 0.37860203337394144, -0.6145911396534436, -1.607202758210557, -2.7411231043041098, 0.5994375990400987, 0.821039440905166, 0.564648195224538, -1.2317571697546073, 2.1728790693069313, -1.4784643060142677, 0.8505458293506578, -0.8152177255442249, -0.2322651890760174, -2.4336904342936783, 0.635676294918068, -2.1748693540991626, 3.1337514394135404, 1.3365904989965294, -1.0218545157390184, -1.7867922231004818, -0.34505371809244756, 1.2449177574278, -1.43512684602197},
    {0.19745485063160623, -1.788746635031074, -1.9104686796109425, -3.075777330428895, -2.2242884539282657, -1.0928297394291246, -3.47109953773331, -1.176011968364925, -3.0664136421352124, -2.215488876981705, -0.24749042011944566, -2.6863642636799163, -4.366755447728433, 2.055405003210835, 0.8204960981336904, 0.5319324655362603, 0.9589784238021537, 1.7712060744218463, -0.9033570757833737, -0.1718021795327277, -1.01160285112673, -3.8385739157990555, -2.793531582324367, 1.843628369027837, -3.5488607938579686, 3.8036786490951604, 0.5766158961246031, -0.6054140751655916, -2.0176568043065566, 1.7251162687484165, 0.44390283512025086, -2.137532222210665},
    {-1.74854722536991, -4.634827929184522, -2.6148943434816236, -1.442753139827176, -4.340793446863441, -3.084873310039363, -2.9357775864164344, -0.9432401412044555, -1.568024734763426, -1.8248275783285568, -0.33694673098611366, -3.2115556736197175, -4.309388365394968, -0.966847849600998, 0.9887148443159683, 1.457647265566864, 0.6799784999553368, 2.7765725746709715, -2.1393876914369896, -0.22041813498247875, -0.899205825373865, -2.2704290798881797, -2.2451158799209567, -0.8611075734360306, -3.519833552150925, 3.836391151395099, 1.6533353528612207, -1.5407078381320085, -2.759024789932491, 0.9717645129593666, 0.29904586995023114, -1.514961326706359},
    {-0.5329813459358429, -3.278986236530839, -1.9405928155488648, -1.9058666456599238, -2.2242452700356905, -2.132996511915794, -3.1652960513292867, 0.2651005613543834, -2.5886796256561877, -0.7570858698122042, -0.816742653062636, -3.9406494763861586, -2.465819640176245, -1.9599171533490072, -1.3626098855237785, -1.4344531367589306, -1.5605113192653073, 0.17409815264053335, -0.5717658335950485, -1.5127218683072814, 0.7074418165379437, -4.176082149721632, -2.1526070343655315, 0.5800837066276671, -2.368874001616121, 1.3166425043896495, 0.8473844142066331, -2.954237481483293, -1.3832666473868729, -0.03606276852712182, -0.6447318218432276, -0.8261899882243345},
    {-0.14475634222906641, -3.0054751086724214, -1.7142399719642414, 1.5974917111534919, -1.3308941277216746, -1.7600313045942662, -0.8004238058164478, -3.041007609215046, -0.1387152314711548, -2.10598300055346, -1.2339171337539208, -0.07355512995471583, -1.161025480222237, -0.9394209236653515, -2.9497176655787998, 0.3776941096627658, -0.24665180679463256, -3.6529732924720726, -0.604923060996811, -0.7204319176129744, -1.135696222163901, -1.8932888674350772, -2.9236347659279462, -1.9629672285765483, -2.782449439521107, -3.6948216165913954, -0.41536823665439065, -0.21793501583732883, -2.4540949545253135, -0.183757410108273, 0.2698563391327395, -1.1903001012981604},
    {-0.8821879457741578, -1.9547883511629944, -0.570196768307146, 0.4477035476387654, -2.7549367296690224, 0.9983755793946265, 0.6735031094688515, -1.434591313851034, -2.4504418318479693, -1.8701823489351745, -1.7997846280224612, -1.9923032797690325, -0.30735939072055635, -0.21252195458452303, 0.7708178510138863, 1.2520833240652378, 1.4176755515566284, 2.021140363784429, 0.5164695500052504, -0.16241150636658938, 1.3125644055840742, -2.715356140117365, 2.120748896504789, 0.5282361733612065, -3.1537338626547493, -1.8472379982850393, 0.773787302910376, 1.972506089192437, -2.8076103920203415, 0.15556355669287428, 1.8672899010904753, 2.816004398076007},
    {-1.1221180030966655, -0.23271905198721407, -0.15661917734852476, -2.8608562958655357, -1.3270246981264866, -0.7252745828232559, -0.3631376174864607, -1.7018179320428632, -1.914665994319021, 0.25501969319523804, 0.6275965773931484, -2.453390494286642, -0.16734691511070532, -1.9063614635996458, -1.4264290211821757, -2.1901445496486383, -1.1949825342245297, -0.5008970811689105, -0.8778826782775004, -0.009948516889094318, 1.1314166545563915, -1.752348860770364, -0.5315385696938119, -1.5839253968813662, -2.42764493065272, -2.2381324659260184, 2.179562522945683, -3.903808364541218, -2.4938487151705147, -1.7350349490030865, 2.0193600761054897, -0.008101396564007034},
    {0.04109247734747737, -1.5787963632970106, -0.5329500070633423, -1.6248392390703172, -1.776184257751422, -4.534786231371855, 0.4988831144872781, -0.8622927227898859, -1.0094862628157557, -0.42734836346885124, 0.17909342162095093, -2.518154500212603, -0.6878382625431466, -2.4892147794758737, -1.8007375701230335, -2.1146517363903303, -1.1385919211126332, 0.5609976921090929, -2.475749738374231, 0.9057687654157404, 1.4205308094623157, 1.65308498429507, -1.3915668695141294, 1.5870902979303487, -1.395429108608145, -1.4634888618190585, 0.3730015545814332, -1.9328018851715834, -1.105671917796621, 0.2715422094807946, -0.800392565979712, -1.178505236595552},
    {-0.9948886759475686, 0.062381369920628704, -0.6752984501853954, -1.8305544264357283, -2.6563873625133896, -1.1389236227170723, -0.3751727349816542, -0.08596717958007986, -1.4628131890192533, 0.47527475132157276, -0.9605457711218505, -2.118454475746884, -1.6872049479312947, -0.6099692158339104, -1.350581122454534, -0.602312934583695, 0.012389159499136774, 0.31367392091085927, -2.731576459626366, -0.28090443489806305, 0.839327665171508, -1.2884680217926892, -5.153138947677139, -1.4819125689559114, -2.6909668092909373, -1.6702710416759752, 1.3257927459863947, -1.3122637507320503, -2.3977027201670444, -0.051789071510501127, -0.32190620832244343, -1.4743694230320357},
    {-1.7057487033666419, -3.359524213086724, -0.218939681083565, 0.9746409940761583, -0.7498872020408354, 1.6375777776697515, -1.0875769336161087, 0.7299784806610686, -2.254732060306368, -4.662276970867016, -0.727451694490364, -1.8417502594745965, -1.2575670613749006, -2.413460172708384, -0.7631770079782834, 0.7080144102054287, 1.3982099304820343, 0.5648686912241372, -1.9734392406909382, -0.7536607516073579, 0.05794045331233194, -2.812186198295564, -0.8381731211961401, -0.3502415437171627, -2.702331822171323, -0.3422132159766297, -0.7820378459965771, -0.08648858022587762, -2.443132231185245, -0.07831618472832062, 0.6902677476068171, 0.019872864971374436},
    {-0.3563070845951472, -0.6115357471689986, -3.0064703427126047, -2.1626738018384666, -1.23557757646533, -2.146962883281097, -0.9581806899107284, 2.351989982265546, -2.075881739163109, -2.5395784724353203, -1.4026192351273783, -3.843629316546941, -3.2022679554133404, -1.5898839778149436, 0.47491704662677836, 0.3798594033585233, -1.0171812288953757, 0.3930058717295833, -1.6204415735662774, 1.539119162381919, -0.21952484025143065, -1.6982210045915014, -3.1020975561375317, -0.6979652639162283, -2.1184178204452233, -2.0844162386206326, 1.8674446506544902, -2.378003194510978, -1.5712150107746425, 0.6537359747785089, 2.411567153993687, -1.7247193672952037},
    {-0.8619289537560274, 0.2518616805653427, -1.1585518011840612, -0.6537866409572931, -1.213899410042092, -0.7768621242181178, -0.2585106399761951, -0.7717522955908293, -0.37314811541699777, -2.305729457013759, -0.594627321034452, -0.11422688919275423, -1.102777364828976, -1.9199543523253784, 2.0028103231170427, -0.3592453312243137, -1.9256015678208867, 1.2233218056985786, -0.3862917988957073, -1.3586296345377733, -0.9378264913988312, -2.7298921437935344, -0.7127734804520931, -2.8552307365545158, 0.27011674528999075, -2.0750119089857875, -1.3817195008360545, -2.029555083793893, -0.8404818692501699, 2.335850082306847, -0.501950307064949, -1.032851016156507},
    {-3.3689861071286953, -0.41906439466340145, 0.04685240320384361, -0.451839342532773, -0.26070806091220283, -0.5316265882487519, -1.3429980081092772, 1.631329184848467, -3.2540431611543466, -0.6649980704315432, -2.4122632590308397, -0.8290743249549362, -1.380363682905799, -1.7335510202272453, -1.623611149919924, -0.3574274433533866, 0.8733350330634242, -1.874294163672512, -1.794426855590895, -1.0745173697506873, 0.8040965232627165, -1.625604769930802, 0.13187405517779022, -1.3911253614638341, 1.0504132821086463, -2.644573894120785, -1.5626184527644083, -3.7706770076567304, -0.9877054828475712, 0.04782774988339687, -1.492186130590111, 0.31374105443579464},
    {-2.3502764912001486, -1.6241346225504019, -2.4549999283250967, -1.488487411685458, -0.826725218595657, -2.2577561855998867, -0.21912059120304173, -0.9664587523455498, -2.148275742951895, -0.9392683359417531, -2.096078803437947, -3.7499977876240296, -4.795936143283463, -0.9328777175453394, -1.658756785966074, -1.7447322765838467, 0.04826759081373651, -1.5098684695612774, -1.6804265740900843, -1.6477771336029092, -1.1895196416356237, -1.4473230822515364, 0.6742120972320658, -0.6725207654599692, -2.962384952142682, -0.14248204736980724, 1.001198139055076, -3.7718749120318273, -3.1919554369397956, -0.9826694889430282, -0.4587456399949908, -3.215465472255921},
    {-2.690061883628656, -1.1171955979195045, -0.7587433335166907, -2.3234032900547916, -2.8362583256998817, -0.5376413697923929, 0.5148288559375229, -0.7935615520814745, -2.5487797236396297, -3.494109770468687, -0.4163950074714445, -3.7477960345307912, -1.0328475101992627, -0.8371961078160123, -0.7788777478814647, 0.06943199316961927, 0.5360864142885962, -0.9983956176385769, -1.2282654345053, -0.4796848385986811, -0.21178265216678543, -0.7538643512083334, -2.8888922240364527, 1.1240044195134533, -1.7400997538450218, -1.0067433647569435, 0.28770740326394445, -3.0865630279696914, -0.8167203531698572, 0.236513293494698, -3.677091064604563, -1.2113382311449268},
    {-1.9395127648799302, -0.0455079992456808, -2.5418893007387378, -2.7500045919320883, -1.8443848548173583, -1.130753490651464, -0.3450832937505025, 0.23972820859342192, -2.093429011653255, -0.03055677664371153, -2.436264909092489, -2.213028283997405, -2.664875772119141, -1.9495984397046895, 0.14194298950875833, 0.9776411315837531, 0.7528265443686966, -2.734895970851007, -2.4410986708984725, 0.21757622503587715, 1.2421587280787763, 1.0541160790531015, -1.9512609202340816, -1.678613522452538, -2.9846913113556552, -1.876863821004281, 2.061641966967456, -1.637527047210953, -3.3011022403238734, 1.7730895875306494, -0.6671132811031754, 0.0234235818229814},
    {-1.8704547243210703, -1.438991239835372, -1.5954311642798715, -2.66358935081611, -2.992298205979709, -0.8463638782109311, -3.285844517975316, 0.26699052901611264, -0.5620303754948532, -1.1217022963726502, -1.2263335831360818, -1.4517201507089872, -3.2420982886929264, -3.119313813021603, 1.1376633052693248, -0.3441899323054919, 0.5655284431023481, -1.3261087693239042, -4.068486436182083, 0.26329204306037923, -0.5673165648880781, -3.017820975087502, -2.446872145488194, -1.2062780393172081, -2.860478184684557, -1.8700096502413976, 0.17648672643971514, -5.338576590429489, -1.1312166803472417, 2.0359659127590493, 1.0486626870704312, -3.403854610455338},
    {-3.4825296087563, -2.975190500894171, -3.201827314942862, -3.239541818423114, -0.165184440624207, -2.1878417031512813, -1.9875424947286378, 1.3463066067123424, -2.912587636752304, -1.1928541858652182, -3.492413196627742, -3.4796668128434396, -4.014978009223925, -1.1856027282228236, -4.188121768714763, -2.395232091067166, -1.3431801744816465, -0.7016156862373534, -0.8548533733589668, -0.278858160658706, -0.31722875689523, -1.628861274382141, -2.632502849564163, -2.124359226320897, -3.6718747234647298, -1.0965830252618456, 0.20663196995904265, -2.445983945060288, -1.6381291436677432, 0.3992704803283933, -1.9817432198807463, -2.7782601613415214},
    {-0.18286603593055384, -1.1721547714659772, -2.947146898939474, -1.8995326961233776, -1.5138727045864975, -2.678937630913953, -0.9863478694060945, 0.637295543899304, -0.08684783588403118, -2.5316617452811054, -2.2470754875154557, -1.733490447979007, -1.2974079288384592, -1.2675347325765818, -1.382769264755987, -1.3056508327948073, -0.3619243229668999, -1.2792869077618834, -0.8518066168862534, -1.4809383087366221, -2.5414082210636653, -3.465006646091469, -1.7621625309992037, -1.5133621490152909, 0.0749656036794275, -1.3463318153404544, 1.2989059775376328, -0.7718344807747756, -1.2435726163945497, -0.5028410658850815, -1.0349042256974306, -2.5974966822166716},
    {-2.925805471990807, -2.4888503571539085, -1.008803431404969, -3.5575015030261485, -2.9694336452964607, -3.1834563924230523, -2.2836452920255668, 1.8003080186369118, -2.24937584200538, -1.2432603628557133, -2.6552892798364405, -0.7202365945607678, -1.4994918844963687, -1.9549442724184811, -1.8470277943094369, -1.429625455016142, -0.85275032884404, -1.0568539015397675, -3.0288728957964537, -1.0258212834009546, 1.124407942547247, -1.3679694839990915, -0.42122729599015396, -1.5790578203064534, -1.8207839046289236, -0.3342020128723133, -0.9462467264922735, -2.680097216133336, -3.5706961183854373, 1.7569660146589847, -0.8472963092740458, -3.603524771986501},
    {-1.563819867649158, -1.314895447182199, 0.10859174314595237, -2.319265279685939, -2.1752757289066516, -2.6567960731675577, -1.1954709807891841, 1.0619709927966867, -1.046202864736701, -2.1845470806889775, 0.1328191339974311, -2.213048234140695, -1.5456867144550621, 0.2887074147953293, -2.2052296754180714, -2.4387378619010196, -1.4357691159157058, 1.5840532165646557, -1.791982338340275, -1.5401887153472094, 0.025232688225143744, -0.8672454726144058, -2.4317165348085354, -2.2419467609341406, -1.7657646599754193, -1.5969502525042283, -0.2322158775612593, -0.5252399498142557, 0.6681740882486602, -1.384747728752503, 1.3926119667954926, -0.9031728178456397},
    {0.677217452363066, -0.5621481342337284, -0.25279928501473337, -1.9647482923499557, -1.9907611103757503, -1.7352549907399872, -0.6367663102791081, 0.5416148624096193, -0.9901650525990622, -0.24935310239944616, -1.7742893694556447, -0.5351026126446569, -1.5242433975131793, -1.4501588705377668, -2.344138912911952, -1.0823397065964455, -1.564492251439531, 0.2507476751134061, -3.180426582388299, 0.9187500807412564, -1.4018702406007513, -3.1022902776192263, 0.42080287665790933, -2.9865417270011965, -0.5751701032218676, 0.26547164078517016, 0.08375632688073817, -0.5361960932939686, -0.932189749066519, 0.17698050420568812, -1.4647633349609057, -1.7038077731257322},
    {-3.531289555232358, -0.8992184133408367, -0.46712039414294204, -1.736294907400832, -3.326254057792654, -2.2970941424463507, -1.6399319768465719, 1.7681860143908754, -0.7215864279475248, 0.1205442788682509, -1.3262129380353844, -1.982499349852089, 0.5962268805570887, -1.8049518142766106, -0.07812573938100265, -2.0634903927899844, -1.6775057852132904, -1.489895058004713, -3.1592891036413, 0.5440858706260698, -1.8288182108775888, -3.8741279357227203, 0.28726398998254066, -2.3063108430217074, -1.0916762408055167, -1.9670434253553968, -0.6736405553403165, -2.472652417161175, -3.005697853067659, -0.9932874064454645, -0.07939967239475659, -1.5215933638610633},
    {-2.183376645078289, -0.722027859642999, -2.1413212612977954, -2.3666174790785734, 0.4367385715381265, -3.023616486074017, -3.3515332747788293, -1.1762119220535119, -3.278665318167762, -0.8910036347723896, -3.344657222343244, -0.0352190130159189, -2.514918690254821, -2.2622653984586574, -2.002132556036737, -1.8073471847466387, -0.13293129041537116, -2.1066066172669378, -1.8461227626102903, -0.7150850750664937, 0.891280205192302, -1.2571692489975037, -2.6909486120934156, -1.6375531028595502, -1.0552014612225915, -1.8198728552690866, -0.20895044352142894, -3.5673438232735797, -1.7769861767841246, -2.0873202769752734, 0.5448562325786142, -2.9391328729727277},
    {0.0743714451148054, -2.9894329694493442, -1.6178879047461636, -2.478774305670324, -3.1099996382255, -2.315885720342406, -1.079798752696666, -0.58330648943665, -2.7423240066213816, -2.458481489806193, -1.1712024491028052, -1.59342346469107, -2.6952514382402493, -2.8633853702512666, -2.5236411948116197, -2.787866541063055, -1.885621373392133, 0.7636285126565662, -1.9328121230662059, -0.032467055670422816, 0.10499272442293901, -0.7940952671811412, -4.543169694352972, -1.6138063372337126, -2.470112570506313, -2.0539372480712563, 0.10854729105461863, -1.3497674129112016, -2.573633829142018, 0.06346545536341511, 1.4742376469811724, 0.7801133839330031},
    {-0.9214589279427674, -1.820493654418414, -0.2805248526994173, -2.4356866325564295, -1.3750577228826466, -1.5235987761321228, 0.06808994657317871, 1.0427669354261775, -0.5223609041952415, -2.018311566224594, -3.5363999916425906, -2.1705273484477496, -0.9722205272334287, -3.85514935675165, 0.10108698739824565, -1.7442213756044467, -2.591493519464613, 1.3126920383889604, -0.13870164576751762, -0.12289325718274244, -0.9046638339685652, -2.7308093783939933, -3.1493636360216812, -0.13204144440664828, -2.226915721193561, 1.7367637701512282, 1.5678784956894847, -2.314692436618571, -1.7003127679761927, 1.4583798920902096, 2.5954928720618393, 0.36455093020308116},
    {-1.9989927200648503, -3.2606514830330964, 1.1901259813199956, 1.377885279998455, -3.9690831033746603, -1.410613067449649, -1.8785852003275518, -0.5787796050351328, -2.9473255240652882, 0.38487408777262894, -0.7272470878352173, -0.17384835827246511, -0.4868305650625609, 0.6336606899708237, -0.9022611873917735, 0.04069007584475443, -0.9093168434561542, 0.4441087573134462, 1.079543068403289, 1.218743828730436, 0.8670781495149537, 0.211299782164236, -2.485838417592732, 0.757990040031915, -1.8444381737784459, -0.09240346252890534, 0.8983717329388156, -1.0174681672606156, -2.860534287585769, -1.1472446684824367, 3.379516741699914, 0.11867114651436357},
    {-0.9443909227305287, -1.627602062352706, 0.28391994189509856, -2.8161037289118656, -3.4388018588899825, -4.451866287283013, -0.7037618484822195, -0.12693506599569657, -4.233015654306776, -2.7655235637828914, -2.8324747921305065, -0.7621360667797656, -2.7426427808776586, -1.0594438713461918, -3.1924954254612663, -2.1394709035311057, -0.16692814259472502, -0.23166557807878554, -0.33856302918796954, -1.8980516285224172, -2.294853388303248, 0.975276937183112, -1.271315051111518, -0.0954576572795222, -2.9971846009246645, -3.8817193214201566, 1.5758331092168698, -0.8539557082322539, -2.2206625569853364, -1.042144223065405, 1.473900330229245, -2.046693422878503},
    {-2.787628080047464, -0.01599933845702817, -1.5051516124822681, -3.3789049408390786, -3.3477770198394183, -2.9838930098863545, -0.7329835246281914, -0.48180729223364743, -1.8249809715586878, 1.4359766587764828, -1.9322097440835286, -2.1150001404941583, -2.6323072445570044, -0.5943097870722601, -2.2520326402734474, -3.343178019111723, -1.9784558736415396, -0.4673377614842088, -2.9566906744110932, -1.8036656284420731, 0.856732584061211, -0.9833403829009753, -3.9946735522145533, -0.7733782941788617, -2.20923854077635, -3.1509452436111602, 0.9793293084403206, -1.5709178190368167, -3.2479743951233573, 1.6333973234403358, -0.6224905086444998, -1.4626925584235666},
    {-1.0736816966093436, -1.1447204862218512, -1.0619392400726133, -1.7435767246111125, -3.6217682239242235, -4.826498907392678, 0.4660747853560245, -0.6982312379301505, -3.1101854020128665, 0.6169207882690613, -0.4328416011298485, -0.37846546459524766, -2.590390902930718, -0.8785383344990599, -4.556942652276543, -2.195108493903591, -2.819689713788354, -0.16685361108106234, -1.027896582733393, -1.402218017131343, 0.30558248321918413, 0.9672158005459192, -2.5292445351417223, -0.9446341872291, -3.9871101820308343, -2.192422865342346, -0.5438828599453523, -2.967645305751034, -3.1405836451919718, 1.717833122937194, -0.14430755622604413, -2.1733946359001117},
    {-1.8811570690974437, -2.539923071831816, 1.3789613400611045, -2.3788636130095893, -3.1954006275162743, -2.263853793554901, -0.6668815382796018, -1.6142973332624164, -2.830056802852301, -0.9427379460345954, 0.4180290227194323, -1.2761880084515131, -1.2142631089655262, -2.1024122644115883, -3.193057063371157, -4.0954101138392005, -0.6586962285872308, -1.2732913245022563, -3.0787966823376416, -2.8247149232922553, 0.7977421141359468, -0.8987915769189379, -3.3322916661013866, 0.5375345552963715, -2.072703557271745, -2.590349670930148, 2.101137554445535, -2.710411678712594, -2.5732389597939433, 0.13541746785066258, 2.483125518662827, -1.9491134624395543},
    {-2.2856014372580833, -4.097318743921946, -1.6350481949374618, -3.302231814174023, -3.473850387445063, -3.7594397468593024, -1.0960093314620523, 0.10188810325341147, -2.906694472783276, -2.0375111726943644, -2.5914991586022653, -0.4975130834386139, -2.6269956854839376, -3.026149450362491, -1.6410475299294351, -2.94726042798748, -0.9100903086120519, -0.6543987289047163, -2.856276620105781, 1.7839527914437836, 2.8910651857055902, 0.19281828337439713, -3.1039356685776394, -1.6355491459375593, -5.787311649515365, -1.3943130696678507, 1.7588182874606064, -3.7260130722576164, -4.356331018687955, -1.0015982638126981, 0.4643302785955885, -3.5695413053612577},
    {-2.2327715808175297, -2.897125326713825, -0.995892993736959, -1.392466694170924, -1.8925937266078499, -5.114658620574869, -1.1886523491133978, -0.613760071780611, -2.836568212934852, -1.02125093996749, -1.43812039879921, -1.6577189028851467, -2.260813991536131, -2.497446264254231, -0.5332904433241714, -3.122573466781295, -2.8140926628969214, -1.2574347575244853, -1.8813146356477546, -1.1668883476984362, -0.6245484940792503, -0.7586312160123292, -3.2383111613011324, -2.0443016332236037, -4.227197311329209, -1.8564839905300257, -2.968465414277551, -4.264601281698143, -3.3547143606779124, -1.5660871352269428, -0.02366374580403556, -2.1569142566589643},
    {-1.7617027472380564, -3.531275600599485, -1.1665128271413356, -1.0125862048757999, -3.37662348852073, -2.836619679681016, -0.370411260200738, -0.4753869031238358, -4.443423990030201, -0.3886820908564682, -1.5874533271316507, -1.9671890801026621, -1.060692786051572, -3.620999038822656, -3.9443214641214768, -4.555139877736474, -3.004168546499304, -1.1214972784676802, -2.958275522865048, 0.40645768830556356, 1.028404901125223, -1.614224072781626, -2.8662292641923326, -2.1946928463358355, -1.3769761381171335, -0.6072559284974558, -0.13481100828442025, -4.6390415879910245, -2.7471919213924156, -0.14045163801013008, 1.8560713364707668, -1.2156614865094708},
    {-0.48964058607793354, 0.3948758872143177, 1.5222533395709945, 1.2359861764801536, -1.1096910729624618, 0.005607796396531003, -0.658768862683441, -0.5970875168151204, 1.4560140812746674, 2.135693660087721, 2.0340625129425516, 0.5840016362369922, -0.3827734593698352, -2.0240304721258493, 1.7646768828160337, 0.3946996904746093, 1.2295037325911609, -1.144679558190446, -0.3001842393608989, 2.6067656280758276, 2.6262126504244376, -0.6815173290512839, 2.5451029609129714, -0.6510557227118369, 0.4623256552429957, 0.9913703360609415, 0.3395311304086164, -0.5171355930515513, -0.6596422378340038, 1.5835205053444346, -0.3571643213907722, -0.5086341210327373},
    {0.3988322914403819, -0.3847983125618526, 0.9225836765991771, 2.064938450120391, -0.6209303953584641, 1.170195076430305, -2.1211898989088405, -0.48816377048802057, 2.8112052167152086, 1.4621919273737956, 0.8430298517940956, -0.85560032194097, 0.5829482703710107, -0.31228021256020816, 0.8419536992656999, 1.7701641063339202, 2.5094679619682427, -2.7621360241981727, 1.3889048172350575, 2.5439980307324035, 2.489596555464724, 0.3729977973775875, -0.32229164962010676, 1.6893168119336501, -0.4283531500485557, 0.5965605164720021, 0.9086081785470743, -0.3071453611471742, -0.6583329813227292, 1.9099630618269032, 2.8980312376051964, 0.36806089188426777},
    {-0.5236893815371787, -0.6623911477584554, -1.3259655911119936, -1.5859765606268073, 0.11766655575301666, -1.7082806022944732, -3.579181110593239, 0.19397683776544006, -0.12290420320231238, 1.3908701705944575, 0.8041543949210153, -1.9600716093425483, 0.7222085220745131, -1.2378211499649212, -1.1387618242243283, -0.30822387272067137, 1.9638397690430205, -1.2437438240256546, -0.6809389363351978, 0.06529778259409656, 3.146342768215621, 0.020564250580039863, -0.49251646465620746, -0.34920039647307544, -0.801744553825653, 0.7456552273156998, -0.5544626608869442, -2.494768057447819, 0.06979008585104979, 1.071763488988808, 2.1178844144797804, -0.8200013697169547},
    {1.6456643826347712, 0.3803087415222123, -0.7972289580205557, -0.45394836310903874, 0.256348793314111, -2.691840978132051, 1.0383891567652745, 0.38858688420150783, 0.5100085168415607, 1.5380595202866678, 2.6079536216250636, -0.2915387509503113, -0.7319333082487223, -1.5730535021403598, -2.6058341052254472, -0.45530205537766366, 1.5292759297227232, -0.9376587858819813, -1.4117636878401916, 2.067485209978417, 1.6009371141874282, -0.750452960434115, 1.7026472865890538, -0.580691221095377, 0.22115730146785603, 1.119442548452996, 2.127597578655492, -0.054663860318523404, -3.1144625423209993, 0.7644016213130084, 0.2054783712801047, -1.4112425320006299},
    {-2.0945734700265506, -0.37336461628143425, -2.1353111588258646, 0.2970312811935834, 0.6213645811853, 0.4475313776299524, -0.474704018388656, -1.1675499426270635, 1.8724335432575547, 0.6849512839650433, 1.887233745529693, -0.14055582570034594, 0.12526342089615744, -1.2626816475279996, 1.0446805603199631, 2.4596418831383615, 2.8148761327820555, -2.1712093433129085, -1.9279494041910719, 1.1406194682189006, 1.1829038706302069, 0.23739966211338911, 0.036818259684198246, -2.1104392512087284, 1.7424039105364624, 1.4897416482536405, 2.625446095315465, -0.9505674471533062, -2.0226577928123053, 1.8127546943420911, 0.40293434930699357, -1.930157494042465},
    {-0.6936863871458002, 0.2667210662533533, -0.747533668277558, -1.3367636232415123, 0.09154499844461465, -1.8324801266724393, -2.144559810522758, 1.6868828728539906, -0.27747831723146504, 2.3813430905530475, 1.8189867776735962, 2.287734321843708, -0.7872665912716963, -3.3009699224684286, -0.7791303708824581, 0.11028489510542125, 2.1041598950327622, -0.026663730138290237, -2.278850037895191, 1.0251702031692882, 3.3593846864280663, -1.045373836614524, -0.49772943116750484, -1.175724806295638, 0.30010567166835295, -1.1738300602543916, 0.620440301234121, -1.3970166906131942, -0.5433592918062234, -0.9260287036752715, -0.30833334870538687, -0.926483410876855},
    {-0.46501521696584897, 3.113784154241897, 0.6675221328233852, -0.009773790757077794, -0.9395132188873112, -0.9939197593640491, -1.8987312178578675, 0.523331316095343, 0.963585968688763, 0.28300311235239806, 3.47162609770469, 2.1144547187429907, -0.9645681784603547, -0.8903413135752036, -0.8664275906320458, -1.5438029168052758, 0.2315613623486153, -2.0542020414586175, -1.7043959158676765, 3.1225996919619385, 3.901238769237485, 1.339628681631921, -0.25298072424636664, -2.4819051734740696, 2.7142048864271207, -0.4854324261468144, 1.239400013517441, -1.4555856550390158, -0.7990444510397634, 0.4565971361885733, 1.2135098109001414, -1.4124479716664617},
    {-0.3473224089064209, 1.49268070519391, -3.5424945884291685, -1.1619543287166638, -0.3437519529072993, 0.6009306775628644, -0.10829026941443978, -1.2955606830931905, 2.107949283366378, 3.5422829678479966, 0.9151826830877486, -1.5351184780440694, 1.1732619995915041, -2.759221834718316, 2.345774891824163, -0.8751699913637528, 2.737648329867526, 0.3974679477516206, -1.6784258936799066, 3.2898194992173666, 0.175228704006822, 2.22311445396386, 1.6941712144780898, 0.2756797966406968, 1.2917377377651305, -0.21629084815159902, -0.7598263953115324, -1.9032496734472018, -1.957622852718052, -0.9046659027612538, -0.0906745164120701, -0.5554908543025395},
    {-0.5089715486921261, 0.8143747810640142, -0.08840655332845235, 0.20456351874254677, 0.1408790234625845, 0.8368461430772692, 0.6428641110334002, 0.9292279817351021, 1.3199617064376308, 3.1723231729521353, 3.5132332792013528, -1.80888754849876, -0.3719714455535252, -3.1053197676270994, 0.710381791895141, 2.3847459050479567, 3.7712631183899683, -1.4483490306752986, 0.3714251861393099, 1.7666775894921614, 1.4250766938250234, 0.9670676277940092, 0.3968302794879185, -0.9114290619377683, 2.482890487240132, 1.4143304082241195, -0.9401052649084526, -1.5795888762261603, -1.0557213833692676, -0.022053282245451195, 1.493269969603909, -1.6654067926219427},
    {-0.5786527776649012, 1.072253728747942, 2.2200399450951784, -1.098892069317268, 1.7402960376999932, -1.079063483953152, -0.3398820548652329, -1.419855950841526, -0.32760831059760714, 0.30194686730980763, 0.17241637137590704, -1.7121035698581168, -0.9357534085219368, -1.9306164320932857, 1.1273877453912406, 3.0499949333867353, 1.3850421448960812, -0.4255132193640351, 0.2815977905631724, 1.4342609404677746, 3.7056041857664592, 0.007726432734531182, 1.8278160674637414, -0.6967265448851367, -0.3803162125052979, 0.22914980696938964, 0.2606168954473216, -2.2868547256641434, -0.45093443245068504, 1.9255783079715292, 1.0329935419845955, 0.7155129644672971},
    {-0.31296086795883704, 2.1527452640111004, 1.19872073397012, -0.17925208638687934, -0.4197604346333843, -0.8886384767536928, -1.215162680710601, -1.3936339945716534, -0.2997305706121609, 3.0096691178461046, 1.048053441848385, -2.0237094275951075, -1.1715620171462564, 0.3162682198910297, -0.11074893320664615, 1.3720137651037052, 2.478833301576864, -1.3906963757773825, -1.1096357295427075, 2.319986412061834, 3.387296093529974, -1.272991050704067, -0.8373239111630475, -2.7252171982525106, 0.15419245923663438, -0.37991787168358576, -0.3912941085321369, -2.5100357474904236, -0.6104229170155103, 1.415967557784804, 0.7025357803014148, -0.1911941291346622},
    {1.0631060914719743, 1.246984899846563, 1.192594977320932, 0.865212647820974, -0.25315248206395313, -1.2174220825094961, -0.7210262907087708, 0.6316301515657876, -1.5714730203331204, 1.8064176245671781, 1.9209036776243134, 0.6130753325009322, -0.43179556588017254, -3.285103010617, 2.366665075529261, 1.0073907569355376, 1.8248939779455655, -0.2275371893920634, 0.775932881878999, 2.879187903410896, 1.8106199311687243, -0.9934489811956542, -0.13892017228011577, -4.656338932862424, 1.9338439542333115, 1.0969493708930096, -2.2399863190395894, -2.3676269485948804, -0.03722283707674436, 1.112701240882227, -1.6040399306608117, -0.12300877892891886},
    {1.6483519876091894, -0.6969149619578476, 0.3573244706742065, 0.395791746236322, 0.022417127079082493, -1.4502772121139529, -1.1615483895124972, -0.49819409887029126, 1.1009242289734888, 3.881049778132866, 0.6845786213495799, -0.8948814855060587, -2.296447292734157, -3.225312454461231, -0.025276918276357033, 1.735300334756252, 2.4000449911180413, -1.0332406525525852, -0.911685969122443, -0.5712596619970914, 1.8132622577094724, 1.2465739894935313, -0.0846576555262405, -1.0789274009843972, 0.9405238041954548, 1.3703015117384665, -2.6304495071386977, -0.4073000365288681, -1.1250376723135165, 2.3698360770855946, 1.4794959885260313, -0.319965558877896},
    {-0.03045028367341873, 1.8254884796515527, 1.3354446576906287, 1.1743685793389609, -0.5724338762782327, -0.36824823701449755, -2.3482935773290303, -0.5956368241356699, -0.5019107684486841, 2.1763673250321616, 3.780013500258945, -1.5363732051352472, 0.5833274545791142, -0.9008713699795708, -0.7051394092425801, 0.5782657732939394, 1.6677208352384678, -4.287622809989434, -1.1498928976018428, 3.8061749445009134, 1.6181753924680802, -0.6266686359521979, 0.38723769079795006, -2.012183443949949, 2.580558516223982, -0.5847991140641219, 0.5596427695739987, -0.21363962619138607, 0.4080437406773248, 1.2657537878242389, 0.006909524395481626, -1.29794342935423},
    {-1.1767649752389882, 2.3835172347652254, -0.028651530640033028, 0.6468673328351531, 0.728239049508226, 2.818698425278657, -1.622153950813114, -0.5212286581349455, 2.383043487403481, 3.177354724853641, 0.7634048600650389, -0.4362079302015639, -0.45299263564832815, -0.9229386899437098, 0.07326804463799688, 1.0059094508910782, 0.27195332578265313, -2.669993055958155, -1.0030933527739945, 0.702808064998969, 1.9675173430215538, 1.7370084679660958, 2.0046869017196007, -2.8638196401870544, 1.2551216038180644, 1.748313449596288, -0.7399494995434347, -2.625621033884793, -1.2368388840001234, 0.12772415948379506, -0.44771168664687844, 0.46049270405335335},
    {-0.21708570579431877, 0.24743924699117065, -0.5598722296163281, 0.45976331284421373, 0.7572878859633312, -1.206385098988674, -0.06616661135640388, -1.5794088210437676, 0.16616894031173624, 1.5378706518943934, 1.2562873858442853, -1.9813621319547459, -0.24755293098008463, -1.9569992102249856, 0.12506371206289768, 0.9490594098554958, 1.4837265234235804, 0.17218228769407307, 0.23747278820003564, 2.994112890277859, 1.1858551303302696, 0.8719102022235592, 0.9129107052139854, -1.2517305263986682, -0.5017622712689151, 1.769289292466859, -0.01908866547588795, 0.3012559577291221, 1.3370346987813932, 0.10899391635087101, 1.3185987643994028, -1.2505955288143245},
    {0.6861825602820528, 0.47584747245327647, 0.4183307176994451, -0.8542168357662145, -0.6521479468910174, -1.7550898235107097, -1.4301624993842266, 0.6642842475650755, 1.8370632294569171, 2.941459801820093, 0.0021700250873298533, -1.9413064137734957, -0.6550391803376506, -1.8161109532821693, 1.658579219844495, 0.6034505527987017, 1.414193552818016, -0.0973823585415257, -1.7618579431292973, 1.312996918080722, 1.8289473082179395, -0.45286679117791157, 1.6480886449614753, -3.1248848308763666, 1.0731176242481408, 1.6686462950393064, 0.5896014751178892, -0.5332601286549783, -3.364430316030481, 1.854943258069541, -0.3788750518772059, 0.07312095556971791},
    {-1.1865370531014081, 1.8262530938730428, 0.19438669774501732, 0.6586583824071008, 0.7408256467493176, -0.4317660878842081, -1.74128939103249, -0.3456262589863549, 0.9443852376565156, 0.8622944957850986, 2.710487757541389, -0.7225202790910453, 1.7791353281165705, -3.270944915171434, -0.9383831562386349, 2.5153269649554484, 3.2718311626584713, -1.3842791368939797, -0.9924951194889663, 1.9922933264289229, 2.443882303821139, 0.3713974422507779, 1.5287671955443576, -1.6914939085791207, 2.1753971660006104, 2.1877389781411307, -1.2346541363402284, -1.5759851780663046, 0.7428450467748008, 0.986205785893559, -0.32411298287719337, -2.9388959281507216},
    {-2.7052017871918066, 0.8424777498872553, -1.9736396025193514, -0.980218102339485, 0.10921473416074708, 1.4018382517125252, -0.7600391217291593, 1.2737200131667292, 1.7178166426444872, 0.9119497646621942, 2.1328595320910453, 1.035709046976812, 1.5239314777289517, -2.2007870775527394, -1.0247253487486205, 0.47311711390972355, 2.807028590767932, -1.4504256143956646, -2.766130744099556, 2.080408637162813, 1.7329604156143579, 0.17923203578207145, 1.193456663540315, -1.6693036319443135, -0.18985048342067948, -0.0958050192137849, -0.9272310853760989, -1.0447235308817289, -0.8372737705881427, 0.8536078645482161, 0.6350824020085089, -2.1149962275407406},
    {-1.348344168628538, -0.19716622502323322, -0.2648761598505848, -0.7638994833451263, 1.3721274541113897, -0.5767764081705492, -2.522496224230971, 0.4831444976577204, 1.025612848331209, 1.9575691793867651, 2.3432861491131733, 0.5640757671982499, 0.360058116470482, -4.527304546105716, -1.2584219420799876, -0.2109916997692367, 3.4962325229245628, -1.927983168499191, -0.6341253889463906, -0.5532641477378817, 1.381095409965003, 0.1814714853793135, 1.5933706504381082, -4.917349890630006, -2.0604843703133846, 2.2849997492763627, 0.060097251957971345, -0.16348378280096598, -3.516862682176215, 1.3734821704135523, -1.2328319443734386, -0.006606553586228374},
    {0.22202135126816624, 2.3136064647830583, 0.06518745755623111, 0.9318737971724861, -0.9872317341993024, 0.19626845899524573, -0.35544511144961155, -1.6900597446837673, 2.1320759796151614, 2.0261234742528744, 0.4123467126409293, -3.7911880668036817, -0.7172460126181955, -0.719053489012791, 1.0988117335594105, 0.7638148418299235, 0.8165418914923963, -1.7875527650909329, -0.46401780681540494, 3.2668474382507857, 1.303573310736797, 1.197505841651677, 2.5661352638515753, -2.3756640335716295, -0.4981693432389831, 1.9636407723563707, -1.6714245014486442, 0.359871233863941, -0.1446336064035662, -0.8982018069576022, -0.5749578624764711, -0.5572467991717162},
    {-0.6159534375210591, 0.5389117183173053, 2.1911224215029246, -1.0884037668655524, 0.35022873234456764, 1.5387413274565294, -1.4254792737965387, 1.1729241096812297, 0.894259115528952, 2.6630319662687905, 3.1946116251503054, -2.314588112613085, -0.9425723467195318, -1.6667382009960396, 3.728222099383923, 0.15885819489271188, 2.3331206367429704, -0.7651307071681602, -0.2522676920780027, 0.7948623519787912, 1.6219381683630703, 0.02964948184387558, 0.9658386144626353, -2.8466124290022843, 0.8862421861872896, 0.578686620433494, 1.8700861265764457, -1.4773584929411796, -0.597699490764452, 1.8307048683410363, 0.6275039663746798, 1.857507412839267},
    {-0.5531796968044944, 2.349178111705924, 2.203335345701512, -0.1303584925717261, -0.470702189069612, 1.7337160753698655, -0.997602268985088, 0.38305780114382404, 0.8150920214224704, 0.5290310404723215, 2.517100371188651, -0.2531956725675938, 1.4166044805138702, -1.8007557510894348, 0.4465665119241464, 1.790070245743465, 2.9413525786156214, -2.1698848933161368, -3.006552760508488, 3.3230930004508723, 2.184917719436713, 0.22314009661614878, 2.384820074970657, -2.0923668579903785, 1.230415764353891, -1.0339790143638885, -0.7971775129138855, -0.2197028695468372, -0.21631927081862715, 0.007748804891642307, -0.9534187998802344, 2.445574492840372},
    {0.9066146325056462, 1.4198432688627467, 2.03111162750519, 2.274799500893046, -1.4137928290762374, -0.5638677429227881, -3.0116688752286183, -0.4131774741574333, 1.5534216927312807, 2.3086784391121085, 1.1831098405989082, -1.4446262925815847, -1.2220160598450434, -2.95567577774446, -1.6020331100064025, 1.4842142669399416, 1.9487337174449377, -3.217711949187077, -3.529693222619086, 2.842636462599904, 1.0361381460264476, -0.638400035193859, -0.17793390999939632, -4.277669984726958, 0.055703861099109665, 0.6274755570774533, -1.1792236484494372, -0.8442982395566765, 1.225107464819131, -0.7563953746898345, 1.611848670777933, 1.5805374294383987},
    {0.19820754070718571, -1.1119953041263622, -0.9078842037939531, 0.34185918429719553, -0.7880813723858874, -1.8375182293145444, -0.8493835046903437, 0.3129014655976096, 0.8618408433491129, 3.454746940680742, 4.041382652650092, -1.8129468544720493, -0.18500976295430221, -3.11029932867913, -0.16628279434556217, 1.128438883868177, 1.5361482624734375, -1.045947509572855, -2.1552522535210143, 3.6665409748638185, 0.9997664518865722, -0.10774557652174316, 0.755712894954551, -2.9299336781829446, 1.737746559040571, 1.3347272857156338, -1.564148095225212, -0.8110453836941116, -1.423832628399604, 1.051031682452887, 0.1789597298178823, 1.390262153300118},
    {-1.2798541587198025, 2.8548738344503546, 1.5612307071956706, -0.29717723669740953, 0.5474809387638855, -0.6412952226892665, -0.8615263122752802, 0.44490730288179625, 0.044809334376758145, 3.307133761666706, 3.2912017316077447, -2.084766530322183, 0.485950091156129, -1.7180225031194247, -0.10338390856369536, 2.2801633345144454, 3.9096270742186525, -1.1318173548964119, -4.78308830651032, 3.541929611006442, 2.90057954182926, -0.04227430243597, 0.7595571512430086, -1.7209469833349198, 1.375329454091963, 2.084259189989754, -0.7856913938037786, -1.278909264298434, -0.8046489759891543, 1.5865736854127666, 0.7323580976568287, -0.38570852751055107},
    {-0.0054118607612452995, -0.5487968500859707, 0.2930552875795519, 0.3978536000693915, -0.18068240053945614, -0.10122518715583571, -0.3712068830800626, -0.4243261242199263, 2.342434219691306, 2.4351891135542183, 2.458833502791645, -0.08785213487890162, -1.090412024908586, -3.35299558788824, -1.1462047777872941, 0.052361720438718694, 4.981083671129721, -2.5458483982752, -1.6402260422928392, 1.474326009093932, 0.5494122994362101, -0.07269474541603232, -0.1744761714226314, -0.8798379604759488, 3.6926860138310125, 3.0410901081652195, -1.532749314362931, -0.925595132089139, -0.9915684398049384, -1.043782261222699, 1.9392878545110335, 1.5155897121015935},
    {-1.4890308038786448, 0.31215936132429106, 1.6586335271274384, 1.21796462930979, 0.7442258007758046, 0.158745063695218, -2.729382101908094, 0.48149061705171803, 0.4360697859675665, 2.4368398050201105, 3.267023339880794, -0.9818806029034727, -0.887731971203976, -2.7199939914146425, -0.13301208395502406, -0.08628060991313867, 3.930704408765024, -2.6724823157703335, -2.7228022516244694, -0.43783281399882173, 3.777210614668769, -1.9924946751882626, 1.640199831486033, -2.1544494825218985, 1.5000949879608136, 0.654787603944322, -0.5706758390501893, -0.2935868722116273, -1.610967299870658, 0.5904268057474984, 1.3597583269959184, 0.8849114313807066},
    {-0.4502349773776235, -1.104457140319847, 2.555904614822073, -0.2638803600331824, -1.9348938748511295, -0.14956049442980732, -0.3980871786801364, -1.4107143977785381, -0.6920282544609611, 1.0207743637313043, 1.3661397080517927, -0.6027072929571509, -1.5229740058317414, -4.398018831832004, 0.5003879300502468, -2.007099374889473, 3.795746392071092, -3.843270801557583, -2.5541675817711726, 1.263003312638407, 1.8019616999750585, -0.37252616551450296, 0.7960136207263708, -2.5428535234746077, 0.5260221528089385, 0.9933149481780774, 0.6005319090366477, -1.6342586265811458, -2.4076769416870403, 2.1263992878506954, 0.8879172227550088, -1.2128630739541344},
    {-2.0051533875348393, 0.45824097837999, -0.8917444385862972, 0.6994803330899069, -0.8239998527231621, 1.2001575011310537, -1.6056115497897254, 1.112876329287598, 0.7515853103135386, 1.6323153719251324, 1.7684558501164214, -2.552636316567268, 1.1135857295794769, -2.613314942163165, 0.6914758438752523, -0.5242482157348591, 1.7211774713683161, -0.6454951376275513, -3.0062333177993597, 2.205602845484756, -0.8044844437294075, -0.6643524012374002, 2.2008103451238474, -0.9142331657900854, 0.8693193176870624, 1.9784914671409475, -0.9151392849854391, -0.9176838909535727, -0.2109535793436647, 0.20292267931617372, 0.23799103103250313, 0.7597065336037095},
    {-0.31735192045356414, -0.28354694153841853, 0.6182492979177455, -1.47854185840975, 1.380091789839619, 1.0942690395827284, -0.4636557876036216, 0.03661750057876207, -4.0838700489926705, -1.121399623077265, 0.19443910957960234, 1.548703189856338, 1.30253893458454, -2.0965268727621513, -3.6565618837957348, -0.7210716115350498, -2.208146535624658, -2.526883069660788, -1.1961286875258634, 1.1717773899748904, -0.49349831441618763, -0.2608911520535407, 0.15051611855142408, -3.425425636461555, -4.240017074078503, -3.9766151068052205, 0.8220092112566231, 0.16369020640917073, -0.8825149687917254, 0.30994576394472956, 0.5431108323817935, -0.8435066835142715},
    {-0.051643881137977084, 1.3822711591975316, 1.3629652865508375, -2.7366052682880286, 0.6083058732970383, 0.3813193317606319, -1.3983856174695697, -1.713166595294877, -1.3739325668588511, 0.2204934872380325, -0.5542871344098678, -1.0392246226934654, 0.20258329451624524, 0.8676172095008731, -0.11214872859827495, 2.011803846078984, 3.241169396753525, 2.6365628180187666, -0.07389306018892382, 3.1070021670280914, 0.9438260372318804, -1.0447279853871707, 1.2019248389209474, 1.467090759110962, -0.1179351218896074, 1.4475866725010462, -1.8770724225300752, 1.5933984574663236, -0.3950281339134479, 0.9651878564444089, 2.1512125581899575, -0.6511767476168743},
    {-2.1562703227433313, -2.175565046502662, -0.0002545661518557448, -3.6388194323577463, -4.65558848152743, -1.1237321181477122, -1.8429869392805607, 1.2766326330588724, -3.350741853556796, 0.09314578399191344, -2.262330527352947, -1.2078255895612697, -1.3971313026159542, -3.8855802723606487, -2.94236307518034, -2.6693306365602534, -1.363329943548009, 0.2490240963842368, -3.141269691321843, 0.10040552115831636, 0.27371303462395447, -0.4946385708431809, -0.6962041023428174, -0.5499888276746449, -2.085937885143482, -0.6746894932670875, -0.04109066921069213, -1.9708076257222649, -3.805088960696368, -1.0056343352561161, 0.42810986203646273, -2.210597316848477},
    {-1.8329325505075051, -1.6057698348915965, -1.23364415619782, -1.606153554037062, -1.1987722039920397, -0.7650659026549412, 0.6718511975785992, -0.4925006394435485, -0.9058454965313215, -0.2689821964042721, -0.8830335142215608, -1.2917964396352695, -1.7880964714021714, -1.900843154211184, -0.6882596259862247, -1.7314700131611307, -0.8193859877630506, 0.9882627277176366, -2.5712480664390815, -0.13119809043975064, 0.39648207398608565, -1.8551373831562725, -3.5036208424435498, 0.8273299743443401, -1.5933527166872592, -1.2778972052053186, -0.16941065165836383, -2.2885305705496775, -0.8157251784320692, -0.15302392315003066, -2.4584476723015656, 0.1349999624686806},
    {-1.7099380054200721, -0.8802942743664172, 0.8311871059721566, -0.6515136627566884, -2.294330237045146, -3.3930918439294486, 0.2664277224452492, 0.4854513821458375, -1.6856203154632645, 0.26216014201591403, 0.08530232377993048, -0.9834160012102003, -3.344347758517301, -3.010539348529403, -0.9044369401972066, -2.597679900733021, -0.2772251499314581, -0.988659395640257, -1.407134107314352, -1.0511157933090052, -0.04681413200068639, 0.38352586020586665, -0.41119865309787906, -0.0882114426806522, -0.6095712867887207, 0.8364426767588272, -0.04600559498609536, -2.483630216287551, 1.1025714918813871, -2.0914951252641645, -2.044672856790199, 0.13734908475092225},
    {-0.941641280774873, -0.9036339583315508, -0.22860938630982441, -1.3210168594443765, -1.19122838908305, -0.8556704756497154, -0.16460265524685128, 0.6576790478374145, -0.4653509916990503, -1.2235747084095436, -1.6759641916409345, -0.6422169189355073, -3.111654543681839, 0.05107978819183873, -0.14074239030170743, -0.3353611803280294, 1.4510800048583807, -1.708445736634465, -1.2067710284763793, 0.20599538525116545, 1.0066953752440289, -0.14266427730499015, -0.6871667894401835, 0.055304724055779485, -0.7850734329102687, 0.21223550457351467, -1.7447193622206054, 0.37258918094240095, -1.4530030783581753, -1.8082386322847868, 0.22035924568522303, 0.5896650856513169},
    {-0.6827862610237425, -1.2486166635436906, -3.5678828025510034, -1.0726915715607435, -0.27351323388917725, -2.5513701041622583, -2.396902259028695, 1.4483189260829092, 0.15398708318065882, -0.4297794144000196, -0.15609981402159973, -1.6704156692718763, -0.42734626412203397, -2.161332659929621, -2.2287274828172454, -0.28068634045660534, 0.20010266917529962, -1.0644026377029692, -2.280315259167517, 2.0027702042688325, 2.1699292730354145, 0.9143921345205714, -2.559467476019194, -2.6196102133200596, -0.5491141215882056, -0.2961681277081339, 2.1810122018594957, -0.5153859589294209, -2.88188422331891, 2.743407910646929, 0.1247193848065573, -2.4343449036009814},
    {-3.091384074627288, -0.9265157787012123, -0.7560979452795531, 0.7428622373823422, 1.4534970534182772, 0.3991050227526691, -0.7726517040375667, -0.487919402937403, -0.7082192141625733, 0.30302237975525814, -1.332928833081782, -2.0960314752434672, 0.7254749636826996, -1.5216002423714103, -0.3945757047360836, 2.018243045389657, 0.10248763704157125, -0.1320159964511017, -0.8198979277752758, -0.7753232401560659, -0.1518667200172058, -0.7547843215406459, -2.387811157960011, 1.1473927712063536, -0.025903779571616773, 0.31560625223725797, -0.8733643697603872, -1.0843836681681265, -0.30027665894908756, 0.5372308314931106, -1.4120728673519187, -0.5683331378737206},
    {-3.4510063088914626, 0.6905657722819429, -1.9965520774986976, 0.09800980971737602, -0.0192474612944886, -1.1291589044180237, 0.5743899482645869, 2.0875802008655646, -1.6047956953344953, -0.9422939090482273, -1.8276686249382037, -1.6346970483629515, -1.5485869050768732, -0.6267096367765218, -2.049286452571165, -0.5755149993135712, 0.21076213283653245, 0.6598669115357194, -0.6297980597999416, -0.17353594068701989, 0.7231320266263485, -1.028995267653503, -0.7539652897702886, -2.544227597371828, 0.20358757461016178, 0.2163959729414941, 0.05059846966065449, -3.561261886832982, -2.360080231534377, -0.04425971511539681, -2.9526798806625028, -0.5402709696933027},
    {-1.350331901591645, -0.5498237150617095, 1.3866238467285692, 0.4706516705209133, -0.4196829443308907, -1.2655124932550597, 0.9710285111929853, 0.44700982841628506, -2.522530137883698, -3.0947816771228798, -1.5922023179350155, -1.8234328943534879, -1.302399910303895, 0.4034372795934528, 1.2690420202770982, -0.20883168347634015, 0.19881061463627991, 0.6272083922173864, -0.38913655848877643, -1.6117857918500011, -1.8019404647890105, -1.8268628202287291, 0.3020914418009678, -0.1641061204745794, -0.18023315331547016, -2.188104074696998, -0.45854600431601017, -1.9947459534869363, -3.7093891490633237, -1.1743809653649535, 0.7075206268034836, -1.8929372653743157},
    {0.2853838903408157, -1.34012453330457, 0.035396371093998465, -1.0243759576903297, -4.171766725401108, -2.830940532982602, 0.8345685045383617, -0.006857273822456291, -1.9429108631003882, -0.2743913214115494, 0.3133908584448063, -2.8467493392893815, -1.222052691975988, -0.6446689980293638, -1.9061337203912123, 0.5560149728110424, -0.450988171268106, 1.8667418494965344, -2.8955467800203483, -0.038290025511269726, 0.6605843930563747, 0.838648090778575, -1.4525700269549287, -0.2887225675088398, -0.7931365311889941, -1.1490608242082494, -2.172559554563402, -1.369175565747637, 0.5689084963772677, -0.38386708471786674, -2.1950538733713247, -0.1152883860715811},
    {-0.48246844494988483, 0.35554736850824536, 0.3318808896297196, -1.1686526524906378, -0.2014202952730379, -1.0497569023060682, -1.2529708686765848, 0.6733658563060615, -0.5916669146273861, -1.194572067960692, -0.475155197186955, -0.1383745623380306, -3.4844523982382305, 0.763352211510099, -0.7613260524751524, -0.24062001721871634, -1.1716744553280078, -0.4471312945528067, -2.441256269335102, -0.6264329444745996, 1.519523132916387, -0.6300401363641768, -0.6573179771093357, 0.12013256467537908, -1.723983120305836, -2.026259970306659, -1.5029310834393714, -2.3693098466403706, -2.297039658860745, 0.7418905169224598, -1.0404350713292965, -1.0834413790883959},
    {-0.31837889867022356, -0.8292001547233788, -0.2533446109945557, 0.04352183401981599, -1.7960842083604476, 0.2092356069693061, -3.716355611093899, 0.1835855638658735, -0.6087687720460107, -1.09163126852584, -2.725590576592487, 0.9791114267236942, -1.9336880714897597, -0.9756787275200871, -2.5590031832215314, -0.4070316399214276, 0.5923213616330628, -0.6466698854524443, -3.145975354504871, 1.3098442165564326, -0.6147959001718944, -0.21611994605997983, -1.9950295460829413, 1.2712989647785076, -3.4608341380845604, -0.37614719065792196, -0.7604691452496506, -2.714787972703763, -1.1478623015314515, 1.9255538628892759, 2.265634509712489, -2.9966342099384162},
    {-1.1096974187259434, -1.926442740758523, 0.3060639379907054, 0.3231587227283253, -2.0612327494462415, -1.4773083980292379, -3.0868795354517466, 0.10902197358809887, -0.7454412874019103, -2.606811261087679, -1.6325557562434632, -2.549735395987638, -1.8001100816941533, 1.4840982391554538, -3.1007289253060604, -0.7329133424068537, -0.5311943521104789, -0.44406187618514736, -2.037290206791125, -3.359664542692668, -0.10803261143331504, 0.009334397822893414, -4.703383706490211, -1.6116897339806646, 1.0368225576015566, -0.9672151044711533, 1.4266697316415815, -1.6263814018625633, 0.19907747985519428, 1.3062689845417514, -0.08922910716070903, 1.397812282935815},
    {1.3784746398720975, -2.1191858719336523, 0.32701320968635766, -1.6728430309220739, -1.6628262430793972, -2.6898738153528265, 0.6653107094245724, 2.1142116499826753, -1.9745898603317367, -1.4496954311649322, 1.1278520543705177, 0.8248111561820703, -0.6381520055224575, -1.3894127118611135, -1.876566676990383, -1.375285692801461, 0.7919817240182593, 0.3476569435137837, -0.8059015836173635, -2.975484890180095, 0.01982528440730305, -1.5041665669767383, -3.6182205320428373, -0.051037748367412185, -0.8210170426319887, -2.128459217899756, 0.6758288518465261, -1.2952081724043027, -1.1653752011105782, 0.8058194244787323, -1.3711420106138827, -2.8720389150446337},
    {-0.7473296163614372, -3.8755462019693274, -0.6379713670048124, -2.133802710432928, -2.250253631148863, -2.7491433090551993, -1.7707056853411705, 2.2198151384754263, -0.20311495310570502, -1.2257689717404607, -0.8098170155339177, -0.7889513022014417, -1.7227868040462524, -1.8089398390672393, -2.6510246779321633, -3.1009136430287776, -1.1160258739998563, -1.0659442620115687, -3.772820877553954, -2.1416659375422924, -0.4367374025645491, -2.839385154879003, 0.8174518564818495, -0.605077117054253, -1.2700652598469038, -0.8648842340482213, -0.4401257527543524, -1.827447919510813, -0.8203789151064315, 0.03445375044239796, 1.2441024346328238, 0.14051290249300538},
    {0.0018990168914835381, -0.22475830231667243, -0.45847481527038075, -0.34015236100633195, -0.4099823650410582, -2.6462740604227823, -0.7548789503642601, 0.6926187438997454, -0.3695604813255962, -3.057815210735976, -0.7128061345295433, -0.702625536310845, -0.6012879924169405, 0.5287178606368967, -2.5809363486083368, -3.691406355173467, -0.9399203716723927, -0.4962326773771073, -1.5440901228520454, -1.6082145713187734, 2.183659329935273, -0.7304980824330931, -1.7845560071691462, -0.8717449806036361, -1.1257806407295523, -1.9753347475285101, -1.393854814873333, -2.176419856499011, -3.3182810135196505, 0.11246740496595334, 0.9324778225730342, -0.9870254513324702},
    {0.17701306990288726, 0.48021278954917634, 0.5864561525355013, -1.5999106156827045, -0.43788184150463166, -1.7899208353161413, -0.32000673361001436, -0.6328987477396516, -0.7644548875462934, -2.4162896333669606, -0.6237680775869702, -2.3835456182281316, 0.27340772301361643, -0.8077232950443883, -4.975423405644672, -2.4815741121049797, -1.8688333190187874, 0.24962524653732127, -2.909898647024313, -1.6970698010188356, 2.199030780377273, 0.06257834900050968, -2.424405885006876, 0.3319694021051338, -1.059416067012692, -0.9785799626966368, 0.45574365201942607, -0.8806783504742169, -1.9201442843598673, -0.024362550462130685, 1.9820159633168817, -1.6216502324169704},
    {-3.739735832809038, 0.06695483052833169, -1.18712388317019, 0.6412553636456136, -1.9797362524408804, -0.7592626159137498, -1.348673080445229, -0.005409535573639481, -1.836739245493941, 0.1726844380870602, -3.109799688297812, 0.865884505182293, -0.4610207657218739, -1.4837643832279825, -3.3521960809100277, -1.0688523078340044, 0.321398818013118, -0.13392593870529276, -2.444898899193001, -0.4904104808728022, -0.4910824742254017, -1.9737543830449085, 0.9665228846842112, -1.3614790182336518, -3.25552910381711, -0.6604713161049914, 0.029059255313256392, -1.2989749558861592, -1.6142298995636934, -0.0377522685691035, 2.8728823128713854, -2.8939469983534987},
    {-1.6911595224096863, -1.252707427195344, -1.6904772789591296, -0.3203769670950794, -1.175096807900939, -2.272291787275147, -1.7587473992898943, -0.9103274550886437, -1.568388198794681, -0.724774514039932, -3.152835029063333, -1.3280794150833959, -3.7327116856418128, -3.381128070191091, -3.412423951003727, -2.7001554999203963, -0.7974940727990724, 0.09108090665073058, -1.1826419555003174, 0.8439719810128032, -0.304448022345525, -0.23797160606894147, -2.1205203584790207, -0.2924187727316133, -1.8981696043607559, -1.2515376706108898, 1.611018108998337, -2.1923553189018103, -4.506643224801804, 0.8916327272499749, 2.2428750776446043, 0.012387147893676377},
    {-0.5478019164567792, -0.5249062173741492, 0.027103579745768873, -0.08837138543322993, -0.9663215266148635, -1.9963710650290825, -0.02310797823921486, 1.2316278281102724, -1.5965989356457018, 0.6786598860868768, -0.655502785780431, -2.779315854604714, -3.094551480135883, -1.3196584930112831, -2.1208143121876213, -1.2734519147666807, -0.6541034948987482, 0.8850025066496605, -3.16296538054285, 0.7976849835968952, -0.04464564065798913, -1.279903980322707, -1.8245479728395018, -0.34524222611765665, -2.339149080143832, -0.6488994955188705, 1.139759316039937, -2.7602418851533024, -2.8426408945608777, -0.07403111846568017, -0.10054253015532356, -0.35443042802037616},
    {-0.4373281488401483, -3.19392273369119, -1.206094886848652, -0.7328789996519576, -1.7472437060688621, -4.203947575168654, -1.9282849404713032, 1.4068384812127375, -2.011742619944154, -0.258252401027588, -1.1621906288024464, 0.3202908033631724, 0.4773252848809844, -3.2798866518347416, -5.152095082566559, -1.527236661138603, -0.11145875856944738, -0.9148526717755929, 0.4338883237323341, 1.3579846356162808, 0.4643544321108248, -1.405239632973094, -1.9870729423151194, -0.0039168462313024744, -2.2132296304745296, -2.4871335023963956, 1.8612215670863121, -3.696155978741087, -4.423872224159927, -0.4676689131476236, 1.6816514283413189, -1.0551862919826176},
    {-1.359117025088081, -2.0758478905371605, -0.22182446371944167, 0.05847466809825352, -2.8011168933319266, -3.9492447266085926, -0.06719772680825158, 0.9771498279150628, -2.6446676233316926, 1.2433186163459649, 0.12306387823856739, -1.0834934103902139, 1.3182677491239676, -2.873304768267116, -3.2474591050835135, -4.832173885614561, -2.225579964236674, -0.7700939081381687, 0.7609438964281946, 2.0919789034092346, 0.6250031532431255, -1.9539647834743, -3.571006969943165, -1.4802357844654872, -2.3524558973017187, -0.8508953812702429, 0.3584372912668963, -1.4471439841777574, -3.6799271384315047, -1.8036316912951165, 2.252626744535416, -0.636831783406377},
    {-2.271834487095944, -2.6968109521327888, -0.13285955258573984, -2.5343078710717, -1.4447737786234485, -4.7787557993817105, 0.8463067164623388, 0.04573952448258316, -2.6853509751510742, -0.8437524619237562, -4.747700095580411, -1.6320542703045837, 1.7834335078204526, -0.3191591010833736, -3.370007204652118, -1.9700997156863953, -0.7162656411602711, 0.9213951499704243, -1.5461768539205563, 1.5563531226433136, -0.8656214204398734, -0.31285231762601284, -1.3263737258550155, -2.243802282061636, -2.035235721406815, -2.235189644296517, 1.0695923733509154, -2.500638327335111, -3.498011857854136, 1.2463228384688778, 2.100804362345648, -1.5304734477893183},
    {-2.305349535438997, -2.656855213582005, -1.9938893572882999, -0.16698766693194186, -4.004792406077981, -3.968994384326158, 0.6457773041960116, -0.27791855690131195, -2.6791321292799846, 0.29483389613427635, -2.0648071262159617, -1.0308857590789997, -2.0650780302469363, -2.569823196686416, -4.935824304109975, -3.184437063948757, -0.019339008207045177, 0.751679348133308, -3.816095297542383, -0.08751146344092815, -1.2620722592001115, -1.4368232605489955, -2.0989069937898446, -3.2033771563090245, -5.311000361191139, -0.4814273540971279, 2.7621122739405157, -2.13501823400027, -2.1062200780118543, 0.5251652014580404, -0.21327734521109348, -1.3755343760947691},
    {-0.8644888080176282, -2.560114835026203, -0.042184415825400896, -1.5055190967379561, -1.7778461317996725, -3.946214487577393, 1.1774407366600548, 0.9974174757355629, -2.900152307217526, -0.07562797586622519, -1.9474214451276421, 0.15664187951513933, -0.1768959691774195, -2.664427524675145, -3.059913057688028, -4.599101086600392, -0.32459438136531377, 0.18735836889153318, -2.919161086750931, -0.6852228064065273, -0.9263848588782733, -1.6179801291832605, -3.3615498585995494, -0.5562608212969306, -4.303058224614342, 0.05860874071763661, -0.5714448776844318, -2.53350572825535, -3.0419448124929733, -0.12119746456347325, 1.8214283039931518, -3.8854922042188993},
    {-1.429292961414176, -2.1354129711442984, -0.055469550840757956, -1.0174380758516677, -0.3243598089071836, -1.7438899902544174, 0.5583864899889062, -0.3211394029448707, -2.6983923562266727, 1.8610501667852999, -1.5424252336712738, -1.5154305961455157, -1.4712349825435354, -1.6522738665442258, -6.069722357459889, -4.097525749051315, -3.7305077579051034, -1.2441718694521118, -1.62474729119038, -0.16460749275778144, -2.143895513867074, -0.685116525288061, -3.047015739242721, -2.9240225271007296, -3.0122849677310906, -1.5186973079033304, 1.0675335268501844, -4.065894687310778, -3.953925677371502, -0.6231141404621519, 3.982776977822784, -1.7109571789937443},
    {-2.3512064369018217, -3.083854741718971, -0.728903237317415, -3.947258620873941, -1.3586183685353812, -3.3244826119964013, -0.9600448723977154, 0.28924869763096, -4.380044048418088, -1.9501781872612598, 0.10979462626057773, -1.1768895598434488, -0.8617259000017027, -1.2210963575798686, -3.6181557875363324, -2.0808394014686984, -0.6154892191541965, 0.7666572283237535, -1.3908536689389845, -1.6034360768168185, -0.19236521738766138, -0.6379418953909477, -1.9734389280067093, -0.10963678130804856, -3.825288966919324, -0.5791306231774975, 1.3357882268397636, -4.729212328325926, -2.147784061915538, -0.37256761792753323, 2.510351111297747, -0.9002558230699648},
    {-3.69719484390115, -1.7936514505530794, -1.148109795563966, -2.110531066536321, -2.2487182719738557, -4.704469741054375, 0.37513852015897353, 0.40924702922750955, -5.577362071923484, -0.8095741620735973, -0.0669631057007309, -0.16803348786337116, -1.8656797644071594, -0.043227439564121214, -2.7500898010440222, -1.4075123501870606, -0.9409705023703974, -1.0451763176820823, -2.578314941359288, -0.5632193271975766, -2.020759708713426, -2.716196300580691, -3.2797519359089877, -0.08396700026482584, -3.1208431084390265, -3.5950027313080883, 1.6783788215105788, -5.225999460771068, -3.7443559087855642, -1.067343592631329, 2.2871135981152464, -2.9955442621586794},
    {-1.953132392035358, -0.7244616158457352, 1.0874829495067249, -2.416212594489139, -2.6910798078059157, -2.7255660822160337, 0.515056842833734, 2.074863287941929, -2.493019665338991, -1.401855557537832, 2.150459728451108, -0.6581158225529935, -0.721653361050293, -2.006813461735569, -2.3999281228818705, -4.566686256279322, -1.0306460006689842, -1.9624828985394183, -2.082391206782159, 0.1036353817632214, -0.8935351355183148, -1.6802020378443316, -3.235221812828504, -1.4659294862569616, -2.3200425595031895, -2.0142868382229824, 0.2901726438759066, -3.3084440373983757, -4.324866201866989, -1.562106281255394, 2.8248239428591244, -0.19995973742483453}
};

static const float b1[32] = {5.5239144875231565, 5.321611020470061, 5.288462272107346, 5.84963031062401, 5.456087092793573, 6.055484146107035, 5.250542560200897, 1.8165866819846412, 5.722501503812733, 5.242441002073656, 5.0908603483052834, 5.946207798708756, 5.703154781993819, 5.673625836605903, 5.6367536903683915, 5.540388942796417, 5.731353094587599, 4.976204174771287, 5.980684225789372, 3.60146356998164, 3.8234257803360645, 5.494517608125217, 5.985267236978374, 5.119544654404966, 6.144864863281993, 5.900700789046026, 4.601798618893539, 6.06707053389839, 5.957534443498208, 2.7257354124491324, 5.200648702941253, 4.659647686793748};

static const float w2[32][16] = {
    {-1.2391089068682972, 0.658331068667869, 5.247687669625518, -0.08800945227486479, 4.642365214372538, 5.79912879460468, 3.5241915228040797, 2.749531988080423, 2.886375897108167, 1.1494940724071423, 5.860506125035374, 3.12337733344021, 4.192363707872962, 4.112381507602634, -0.6115075144829385, 7.506958391348264},
    {0.36747817307049113, 1.0840368313949384, 3.8093259144433524, 0.7333317571777351, 3.54438727244738, 4.007879688749151, 4.958465183136906, 5.0051191674520075, 3.030147802012029, 0.27862304043739333, 6.817002392414522, 3.499013714009242, 3.620086565454705, 3.770224775711199, 0.18285277351190501, 5.305094519061448},
    {1.6858869613135694, 0.44837250978069554, 3.5732760387426867, 0.6316069345456677, 3.6894199447291403, 4.207387144837317, 2.7766143396243925, 3.732966704495396, 2.418799980175749, -0.8477917996855558, 4.616918202108085, 6.033212137612679, 2.6589144207706075, 3.224422665046062, 0.18845659292906913, 2.999346591093084},
    {0.1543014958470903, -1.496818531041799, 5.065466573009175, 1.4347621114631306, 2.241618572920965, 3.092346438899985, 3.6987732701913782, 4.504773519888966, 1.7633006960667228, -0.1305863905820682, 4.53436679085309, 5.4625706297018715, 2.1840498113215925, 3.947263948411126, -0.3538652089202631, 4.263132343555581},
    {0.6787779564809041, -0.10495279674049678, 5.229526307892485, 0.13302391577674308, 3.698131496815979, 5.080771017965092, 2.1864915660525095, 6.13389177303921, 1.8107862491067275, 0.31189440514735894, 3.4633107291014045, 4.032132350600924, 3.203040565211592, 2.7484172980823987, -1.8423375620991067, 5.161512994427248},
    {-1.0435761056090862, -1.4278779576560745, 4.50626646335832, -1.4110332369387766, 2.5589577381211184, 3.8213311823586524, 4.1525389452708215, 3.2260252006223555, 3.5910215920938935, 0.39255839105878504, 2.032736694931968, 5.7361793453782095, 3.648706934955074, 4.232939985512195, -0.6126861749396911, 4.643937162817203},
    {-0.08958586227677241, 0.8537011077823802, 4.264221471997481, -1.3231669596201585, 3.4020644315839155, 4.985516533589477, 4.420228909797311, 4.950366635394772, 2.546183130335313, 1.0742347172823437, 3.880805750310677, 3.8794029840972653, 3.064843353943264, 4.248491577415386, -1.9444060176412667, 3.809673477350209},
    {0.4701033304917529, 1.2297393724485826, 2.515837304945564, 0.5950170557916888, 2.497754486413396, 1.1860376771101675, 2.8914818116452805, 2.3101067951755296, 0.6933013337472661, 0.34188900374469067, 3.6105344847271543, 1.1512753790285843, 0.08181873941621036, 3.148604293612027, -1.7731815749633415, 1.1449012903707712},
    {-1.7738259845749123, 0.9278167441019839, 5.664450770628401, 0.4124916253179766, 2.7629411608188605, 4.796302850933875, 2.99799648020423, 6.178429952389767, 3.937619848842351, 1.7814917802860706, 4.909070441231604, 6.458624697527427, 2.961924097417932, 3.7569256779656777, 0.8441460133632407, 4.4382847326560855},
    {-0.28818579148657764, -0.16250155226141885, 3.706215542004996, -1.9080395042362273, 5.175203714824624, 6.1061313393274945, 2.260709073545877, 3.020020393224511, 1.6673918105866947, 2.679663962479115, 3.288596589429309, 3.876589370077499, 4.078825655757651, 4.928813238690033, 0.5216086471087382, 5.312867165492685},
    {-0.026026270305976772, -0.5498587608600444, 3.9832755301632883, 0.16847310369970414, 2.0795666217774267, 1.552367428138963, 4.147509769525203, 4.092877980268073, 0.19187565542024482, -0.4867164763334912, 5.21031151285975, 6.0386176219617385, 3.0884496737716676, 1.7655942399119582, 0.1626795094970653, 4.154613069574038},
    {0.6732278434409248, -0.4773815640803896, 4.113955059756414, -1.0790530636723221, 4.433824967435123, 3.9337287157002527, 4.932601250635942, 3.849005699678894, 1.2586988515631483, 0.5413941816792515, 3.9426273886515544, 4.691551595113595, 3.8725292563057883, 2.9694242104888056, 1.3379079793593942, 4.856279561127185},
    {0.11143598654672442, 0.1695207852494354, 6.7365320302320075, -1.3111397057133873, 1.7795636815217426, 5.245925523844751, 3.3539366813937534, 4.152424074806828, 4.1129423896926705, 1.5574196692668278, 2.2473848745893963, 4.165450281958667, 3.621301866032447, 3.989077752947402, -0.12025167741020151, 5.232511529737825},
    {-1.0404470676826585, -0.33579291090116054, 3.3734064074094805, -0.3128237074197627, 4.053522338732263, 3.221604822062784, 5.069592741964481, 5.469060214949358, 1.5256339872252984, 1.781706650041483, 4.452469545506571, 5.083235715826181, 5.269600169447973, 4.593280398585148, -0.6928934496298547, 5.059303155705611},
    {-0.42737703191803156, -1.0419576681557319, 5.88461217505426, -0.11771865909819876, 3.398408438180914, 6.254818697631908, 3.2679074852574233, 4.364643315247872, 1.6079399304426376, 1.5545654526771913, 4.062141921102956, 4.512060538114984, 4.472269329135513, 5.077390817903432, 0.4083875491607415, 4.609038006869234},
    {0.15114264972138175, 0.33568787018452334, 4.359152053201463, 1.239294790645318, 3.8685751904544414, 5.764670586021329, 4.763138742973283, 2.980736372756261, 1.786395187740731, 1.4988128280492874, 3.288747228238931, 5.212470886343075, 5.190760013314148, 3.0983949664049653, -0.8472388281407828, 4.878152450075819},
    {-0.9631572099078307, -0.9434659378262333, 4.932517223280964, 0.3099926687280502, 4.97167332580785, 2.1952249612580177, 4.657090214464295, 3.0525326750635364, 1.8811575542603785, 0.6225546920263306, 5.620217260913651, 5.553700823054841, 2.1273345250477784, 4.565272871645506, -2.5009592467821466, 4.707425996537069},
    {0.507684510764606, 0.17128227242188704, 5.122112545659629, 0.7125289990193754, 2.5339632862309003, 4.5100246687293675, 2.654474595515125, 2.6034197132284755, 2.7296884124513525, 0.0891486121128803, 5.315358098671109, 5.012028217217834, 4.00546934838571, 4.642702055505397, -0.9149608262479538, 3.25619914433308},
    {-0.2855946654502659, 0.09287524564248101, 5.6090758427708405, -1.0927928142523902, 3.51700968842787, 3.061863496676442, 5.3971048260067835, 3.856995290704417, 1.5331611497916962, 0.3455098823738382, 4.091746430529187, 7.095945529446003, 3.1469864417041977, 4.765633203804854, -1.0413022887557248, 6.511685388641375},
    {1.0979524438637602, -0.2265365047532551, 3.2645436759829853, -0.44360588923970634, 1.4697975609479195, 4.500808739937818, 3.617261824686936, 3.5984102852958197, 2.7833020590566497, -0.28061932665529116, 5.762098583875388, 3.0013378367731445, 2.1641603426296974, 3.2139480277247223, 0.016435495819190238, 2.4299690265285374},
    {2.140196089517889, -1.1451770407849802, 3.655430264451126, -0.5360252808267538, 4.009872517760548, 2.7959982500914764, 2.6919420086599968, 2.650122723302359, 2.826101255568248, -0.24555886855443113, 2.859530946653321, 2.5376708456048767, 2.931094411810092, 3.2093561904524703, -1.3904056713300679, 4.106177839291122},
    {0.7003173086794054, -2.1647174859342666, 5.293821110455005, -0.8444997065478835, 3.3906717412730494, 3.669699034298038, 3.1139795653220377, 3.988422585477911, 0.7590079713468674, 1.6191292880925794, 3.536039972390124, 7.261087717788061, 2.677768273304317, 3.340153244590931, -0.9914065867561344, 3.8092524320986616},
    {-1.7322078798309883, 0.4499987364279365, 3.8724231277664005, -1.512360672335477, 4.621499675428231, 4.254888445217211, 3.0731728671349376, 4.147920892552747, 0.6603881184240614, 0.1601522894710389, 5.225232960592322, 4.963313025614684, 2.8771152342215505, 4.336458984100688, -0.5284920369593827, 5.13509368816896},
    {-0.44991814963166415, -0.08797592093580507, 5.009561962824569, -1.7303835491931083, 3.7733534111445906, 3.2935977424356686, 2.2788804427746463, 3.296635852132997, 2.701537795079661, -0.24715305682942318, 3.8731511144012156, 3.9773138017343257, 4.0575365048277305, 3.47276932179995, 0.6437876440969946, 4.863963783520053},
    {0.7755869349196729, 0.34736590578372184, 5.157763344420297, -0.9325670444040165, 4.982610939019406, 5.308760747022473, 4.821921256366564, 3.533451315902207, 3.1228042770668636, 1.3955882501100543, 3.518326634838715, 6.288398573316479, 4.1017508050452065, 4.745479604292874, -0.186133402450622, 5.514361073281724},
    {0.731353571685522, 1.0374648207190083, 2.6159464067606675, -0.014626260157098767, 1.2881298865043906, 5.0274851593217065, 3.8346089619447628, 6.199174010032005, 1.6077189164543646, -0.17148793998751335, 3.0188578588555854, 5.14364618313775, 3.3504087025137, 5.0989941134337355, -0.7327818393488541, 6.093256450066266},
    {0.8740524566217353, 1.6752272751997805, 4.115387481871839, -0.25906157594853757, 1.4368082692301871, 3.780433307256838, 5.2860554634805945, 2.192538534822398, -0.3083462721888282, 0.376509409533167, 2.4414239824054653, 3.1562083710866626, 2.1821677605575434, 3.5561013551018124, -0.9173262800449761, 2.749956293875153},
    {0.909415375542994, -1.03080614746715, 3.4526528178334543, -0.8270916641522164, 3.3139017763991547, 5.398829490067677, 2.795732319342262, 2.8030328187593296, 1.6886836686556392, 0.44232413477838, 5.098777198949679, 5.647731804901767, 2.1238877077018956, 3.475413950175877, -0.24165223476562084, 4.68546422475109},
    {0.7186449716641075, -0.20574972366201744, 3.6463734021221184, -0.03393032132874963, 2.9262502995249955, 3.8868058798678304, 3.1433185704053273, 3.91185757107085, 2.289946283473771, 1.5846768742889001, 4.715636265112288, 5.337231974331781, 3.4115880177534605, 4.166095349358929, 0.010958650143858642, 4.993984519933396},
    {-0.22484208764055455, -0.4693978227451278, 1.3666045837541343, 0.42190969623936253, 1.3124276697155544, 3.687094488428584, 3.157993832358346, 2.852802790269231, 2.1743108283690877, 1.3166522875594444, 1.7336894965055145, 2.805654637742618, 2.090437647332896, 0.9031364871730407, 0.9937177562345961, 2.338578266159434},
    {-1.5053446131299855, 1.1634678526664692, 4.154375426305515, 0.9307664076426375, 3.407694699167889, 2.41943983025612, 3.3781179027029764, 2.1346662554812394, 0.8861049797145003, 0.5612345930964584, 1.9035889558241654, 4.2518819068581415, 3.2491666450014924, 2.9829082991485714, -1.0266419415354564, 3.922898258308538},
    {-1.3354139680993922, 0.9401772643755628, 3.721154463859066, -0.7468591912452625, 2.5520586046532117, 3.3973713914391017, 1.5706021118711702, 4.783836878659499, 2.379280702209438, 1.2481284412813891, 1.6417204095284281, 3.53244667830061, 4.278489677436478, 2.46654146172361, 0.48861538627792495, 5.796081919119458}
};

static const float b2[16] = {-0.19473140317636545, 0.29184895085862445, 4.8836443641097675, -0.36127402367733324, 4.2466302775444875, 5.3616901217472, 5.070335153148572, 4.9170593672612055, 2.4188136878693838, 0.5768906473355302, 5.111578841793354, 5.544078499912964, 4.350995760416797, 4.729449220586174, -0.10279444060270368, 5.405747814099757};

static const float w3[16][12] = {
    {-0.18688772316575272, 1.2787030995685265, -1.4222983548094548, -1.3100901740429005, -0.8462242237135741, -1.9647321056140965, 1.6941880877793152, 0.3738287339995623, -1.0053182390260107, -0.6555362046690895, 0.6218343085049179, -2.093230178322344},
    {0.08901521881627456, -0.38604769162418373, 0.40501080331415007, 0.40523303271644834, -0.7208187994481706, -2.265759690029505, -2.1776545609137234, 0.11775652059968005, 0.49000694903022696, -0.7146514753481094, -0.19346283185039068, 0.20892240387243702},
    {-1.8473897632855252, -1.8608508903826653, -3.334113283900737, -2.430823207494103, -3.72122661747414, -1.9938895980238212, -3.25619019380936, -4.028653401387453, -3.1653820627943765, -3.285087294097102, -1.3777062348005336, -3.1644543471833604},
    {-0.7603698208846257, -0.009077167325750533, -2.3145856302169285, 0.08058254890741458, -1.4183662269026347, -0.028413600318241635, 1.8262522068027707, -1.3127918093761783, 1.0030701355528657, 2.1899760022217825, -0.7847903202726885, 1.5408001279269141},
    {-1.7265953473298106, -2.2092227250104255, -1.2326870787553394, -2.627524254067558, -1.3558275805794733, -3.5775969320714434, -2.244626831596527, -3.9590105777834115, -2.3341794899372386, -2.678208677065385, -2.36402978183644, -1.835942424873737},
    {-2.718566786188278, -2.193993802125944, -3.5682604970405944, -2.1043173419119983, -2.4749966406363946, -2.1630607782052547, -2.3552646256826177, -3.3062976708331484, -3.3147643738277837, -2.8974828761202103, -2.98691691920899, -2.632044717986608},
    {-4.395438401555682, -3.4389496505874773, -3.0608742571711227, -2.9760626289183127, -3.1141782563996543, -2.1678881080410584, -3.7152092504336403, -1.5629227887142592, -1.7042324301635274, -2.5278531063400935, -2.720902706355939, -4.322684622534864},
    {-1.570495301051949, -3.388095243273782, -3.2920168545146073, -3.142263658542375, -2.634596440857061, -2.565717768936796, -2.32529377169259, -2.035245965033336, -3.248952283186876, -4.0905800742611875, -2.8503173291267485, -1.2361701703170087},
    {-2.0490846221274808, -1.4178920745998356, -1.267816719063459, -1.8384829238556366, -0.16758547780328878, -1.2760937082166712, -1.892110355533192, -1.0570684573055578, -3.8579919037841264, -2.0281037004432343, -3.211564180287277, -1.7023842769312882},
    {-1.081497682041256, -1.6336155572609996, -0.3158103999227254, -0.7737527559751114, -1.6525955717726861, -2.013006217045828, -1.738451012956335, 1.0527826314026385, 0.012347528068966045, 0.023743069038840665, -1.8995835529774947, -0.6640301155787321},
    {-3.046329495514671, -2.836999331154217, -2.9143037976603168, -2.720528897937076, -2.5378014037370176, -3.783359942325663, -4.1542560377548226, -2.8995603615528687, -2.886899646451722, -1.6655421913433923, -2.992624491921218, -5.094543279279957},
    {-3.7670030360612143, -3.6809560294986126, -2.890457171315269, -3.284155296232891, -4.292047522983899, -3.7007021939673255, -3.151036582496678, -3.1989236600846045, -1.7708335019790318, -3.9837912032401053, -1.9550341573111218, -2.374578796093151},
    {-2.1822183641126376, -2.9329556575843934, -3.301746063447719, -2.7775829730506625, -1.890591950557951, -2.6459885908642833, -2.32919203296843, -1.967516064580004, -3.910160049432421, -2.7239412428546954, -1.6763026994617158, -1.129012699530186},
    {-4.39738601674673, -1.6361417790460306, -1.555261013489832, -2.772116454189547, -2.8124952460894006, -2.6745600312824265, -1.4040739713834394, -2.0806447084345097, -1.907969452465738, -3.059682982092679, -5.376636791185235, -3.2463191052600844},
    {0.39473493823948447, 0.4765955257605944, 0.641504981619921, 0.8234067831691494, 2.02887770929787, -1.8482876621351558, 0.3044124519082522, -0.5185314525745888, -1.1255854551836306, -0.5993100101838716, 0.2248373855641539, 0.13648365600303028},
    {-2.8310137185746114, -4.373215947728861, -3.5915927596570025, -3.783188973196354, -3.8023550730476785, -3.4400768906303623, -3.3439323227064426, -4.1105001919893605, -3.685043504837195, -1.7844203074269425, -3.735375741677878, -3.5779321208088}
};

static const float b3[12] = {-2.459129999538833, -2.520902553535483, -1.9906685145852914, -2.3523089370050645, -2.6084383170343433, -2.1938344202932663, -1.6276922545518164, -2.034990271135296, -1.457293978342829, -2.325500515574406, -1.5451006646016814, -1.899352652403107};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
