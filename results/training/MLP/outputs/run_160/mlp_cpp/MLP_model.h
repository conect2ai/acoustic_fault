#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.09686193803618282, -0.03865770367028097, -0.37846274207314784, -0.36863548351367265, 0.4445844772857455, -0.78038435984803, 0.1400067761001964, -0.28226163159890244, -0.26462255844011856, -0.014087359714999107, 0.09498351828215013, -0.030107446252366252, 0.001560169478992653, 0.5145440686912672, -0.013912242570743617, -0.5938349699102384, -0.7772539246012128, -0.37808730592853057, -0.7847088767911946, -0.03775529728794431, 0.3039330315785105, 0.32177481932944063, -0.6685545152469794, 0.17710596872746123, -0.26318013579422544, -0.4724927252454416, -0.46226361205617755, 0.2704340660639575, -0.7563644737305242, -0.6581257383140712, 0.2886416068820858, 0.26075719035516537, -0.7935160299481687, -0.6902672026079726, -0.08190648928045194, -0.007681630918098608, 0.22824120994189712, -0.5971528518286435, -0.8067808907900577, 0.08245804822679924, -0.7351825110525403, -0.321622241131137, -0.16304524932507705, 0.28660491563232654, 0.3828537876291755, -0.06494215418312155, -0.8024688773820348, 0.11630118777543644, 0.4483229235023494, 0.4858054121834788, -0.11106935345873677, 0.02733663149453827, -0.8830228077776701, -0.5885290473204163, -0.06953456210491547, -0.6879520674287171, 0.20037024840846246, -0.5502060548110841, -0.12134776858487109, 0.13880363769963103, -0.795354968486723, 0.4923876470337217, -0.8428561612031589, -0.557518130255313},
    {-0.18686477101270535, -0.6734803268497518, 0.3468307752513173, -0.04336508864663923, -0.7775816861646517, 0.12614984610999966, -0.7124335126849509, -0.07008320553619803, 0.4001996368771282, -0.25192718725005675, -0.45002981301639755, -0.31920689223785126, -0.4319375044517429, -0.059192443277003175, 0.3110778910473824, 0.5730361793362909, -0.17093679222662828, 0.7097187718506573, -0.013377265357529984, -0.08833069753877093, -0.170840170726051, -0.6356828509801091, 0.5757566647695241, -0.21173215311553337, 0.009579555600360643, 0.47335657836704864, -0.0490804768697767, -0.5183778533876582, 0.06668529951644357, 0.6323163025742252, -0.6582182990125032, -0.26546353946016915, 0.21257724280909848, -0.2695382179581817, 0.2626041982226985, 0.5185132124980032, -0.31418461047098417, 0.013811114633047598, 0.2719758191628033, -0.6719136527141957, 0.05105728345630885, -0.4273213400907424, 0.3235891058172843, -0.23804195306130904, -0.7703974631996192, 0.13116742847241022, 0.45349098149548706, -0.7901724640851796, -0.45254513347315595, -0.6337129527972619, -0.24280101244134042, -0.32317587544869764, 0.2625753048097606, 0.04782534335179556, -0.2305448006682811, 0.23824554467637205, -0.7142761984358251, -0.47783782361279575, -0.14640752290946513, -0.5331172831328044, -0.10057142244561408, -0.5856449993312965, -0.330437395439118, 0.21717230270328625},
    {0.567151441768633, -0.25518352618690415, -0.04267676222049557, -0.541405860571419, 0.0496793909160383, 0.4643533565365771, -0.49392527957695026, -0.6336621725692303, 0.44725674116382064, 0.17870463272910558, -0.5693770585941025, 0.3791151721497785, -0.43718624516944016, 0.1093157905134236, 0.04602677588784497, 0.479151033220723, 0.5241421324331315, 0.666226335587038, 0.6177290970447953, -0.2679026952869321, -0.5814912208239105, -0.2698153385548876, 0.5849160996869724, -0.0017315828273950578, -0.10863253177428868, 0.4648365546711307, 0.8157722501608394, -0.17377888608194428, 0.37030535224382966, -0.19261308617628514, 0.21900904479921005, -0.25677542688288546, 0.6796698324785975, 0.6199234606903348, -0.1566178691686447, 0.053266946039760156, -0.2341639644498724, 0.07475844793663426, 0.6627822865998606, -0.5952637974390304, 0.7361377670314563, -0.30077998462780303, -0.4017845739006311, 0.026118060541331835, 0.15277738416073983, -0.12540499212011164, 0.15715663625446477, -0.2287952130970394, -0.18359078525168324, 0.22920651158004382, 0.16437281046132002, -0.327894838550708, 0.12400863170695985, 0.22505878574648358, 0.5311512673796109, 0.454438955239949, -0.695276290711168, 0.2717789036349773, -0.2899771292632017, -0.09304331450836019, 0.42841087267833095, 0.4267888424646337, 0.08749254626025463, 0.8527616513077121},
    {0.555438770708435, 0.3481742411424847, -0.5511440249756141, -0.10642018984998636, 0.6325448106410045, 0.040832653496932624, 0.4841292440663763, 0.10828618333383233, -0.20186035365316304, 0.5654094205714755, 0.1442153935749684, 0.4986716034390476, 0.483382147330624, 0.15627214354935753, -0.17850867917622348, -0.29849421050803243, 0.518696288091708, 0.19204312976678956, 0.5783157094848796, 0.09598080227177634, -0.23191264930128977, 0.04006148127616115, 0.12110880912471728, -0.2370975961244134, -0.19670617402386173, -0.5952655720800032, 0.8590723658539757, 0.1771913047753255, 0.5808197631908871, -0.032781907584985656, 0.5464019275826522, 0.48510080155441954, 0.5268519167426541, 0.4757237600424016, -0.4343545739994123, -0.14055095541961685, -0.26925214965841915, 0.27911149127011037, 0.6517766466543048, -0.007913126937350138, 0.2786958115386519, 0.5035611335503466, -0.7130852845416443, 0.22001947262032892, 0.6252137218668871, -0.0492012816906121, 0.1957499684135689, 0.25412499222907897, 0.6030308513981103, 0.2967899383026529, 0.562786718836731, 0.5231015548885961, 0.5516826786626686, 0.48780182483259077, 0.8612012697713607, 0.517666952047757, -0.09911917399136187, 0.8321551358146453, -0.12576178563233006, 0.261467763579859, 0.5955579999820564, 0.7679241020554954, 0.4157036460950008, 0.7767074793756822},
    {0.10374878387219483, 0.04108692361342604, -0.18770650402824254, -0.04352439566758382, 0.08306917986195182, 0.28304971210998714, 0.10615815996443122, -0.011200094575426672, 0.1996726299156532, -0.03803031511433712, -0.054110458512329644, 0.4887605958409693, 0.2492406595487342, 0.10281154652252467, -0.25446025895841046, 0.3623421873556681, 0.602502567163153, 0.03359527984594253, 0.36908537160555427, -0.016895117275769287, -0.42511598120531485, -0.45332647190748243, 0.32213074959890503, 0.19929174547065653, 0.4189667988117096, -0.044524877702403765, 0.6128262129051075, -0.2037657707284693, 0.4280280690413809, 0.11040390245013094, 0.02818270061151168, -0.2808204392494618, 0.8650306491360231, 0.4725836181163765, 0.11623553103439664, -0.08867923074779462, -0.3883242501999917, 0.39701717202247166, 0.6281232331319642, -0.3263198789593775, 0.675940743861596, 0.26613197840981895, -0.30712841805526864, -0.1144450824280708, 0.13694054334130867, -0.03869672483487332, 0.3842647117247473, 0.22374270910708127, -0.179665627578081, -0.22796229548178948, 0.4871446502758564, -0.20134480286049106, 0.32087672894860325, 0.6504614491911936, 0.7049093395793333, 0.6968590528800455, -0.4529831705147181, 0.3820356469639888, 0.11249748375342161, 0.07376967264014318, 0.37245716122412953, 0.3089844561486045, 0.3156884342769319, 0.8054762184050577},
    {0.6502865151811267, 0.17697154461146836, 0.4691967808956206, 0.31026813504945133, 0.07308344642631602, 0.8846046034763075, 0.09071250080200277, 0.26549994765922846, 0.7129247315054508, 0.0815951068165286, -0.26750627787784165, 0.220677023373898, 0.2499323664354848, -0.18253211756387264, -0.16814523755984592, 0.2882709339114367, 1.004848351569344, 0.7459206990029644, 0.9737985098772043, 0.48935755213203225, 0.33149514477656006, 0.23730810377743927, 0.5977027654129071, 0.4092535640105498, 0.6203641623698979, 0.3049983107339862, 0.5447102137598309, 0.6612625087527478, 0.8529348617649265, 0.7192668313555443, 0.10566837958716925, 0.10001607025821393, 0.877581148184228, 0.8386681750904915, 0.17329067356537464, 0.061502081656136035, 0.316283633032243, 0.33575592335856147, 0.7624064623746148, 0.06930549368355464, 0.5976401050695933, 0.31826322627275755, 0.25964855190339753, 0.2346347348220105, 0.044716986564251895, 0.3061070644378821, 0.9522906003482311, 0.002592291227718202, 0.009490118679398538, -0.21140717365845133, 0.8596478740344287, -0.09685299678482437, 0.8310833925594434, 0.9061116061954588, 0.5352292119730083, 0.8879397168898374, 0.06483124705504774, 0.6422871876623127, 0.26746323030230157, 0.22932816069755693, 0.5162446357858527, 0.3226490535675589, 0.720148344423563, 0.8087900277812508},
    {0.8407819320822594, 0.3686771097725159, 0.5486443925223222, 0.37275874632697653, 0.24065383415690195, 0.9094255184304395, 0.3982808389576354, 0.22557896840501113, 0.48437689390119365, 0.3170956157707257, -0.3062141936995999, 0.3768910332341017, 0.34439972249001244, -0.2918146669905938, 0.10873609027778096, 0.3102691284892607, 0.9110682411010717, 0.6913012896912565, 0.9875679658164993, 0.6031799916902277, -0.003391489701074429, -0.01039957634455949, 0.36324765084712923, 0.07151129341989416, 0.741678611351542, 0.03319172174829581, 0.5102883714272107, 0.7316862636294509, 0.9701772250002803, 0.4351593584128873, 0.05628511023891396, -0.0919837606301872, 0.8617602934611206, 0.9535104024058397, -0.011561469783378978, 0.40638048707487884, -0.030164411089711, 0.358169099797702, 0.9591706418193999, 0.03407363612348658, 0.8490094824950448, 0.2769743249976434, 0.19518408774859508, -0.028906149376840648, 0.19541512827657326, 0.2159795259912658, 0.6464831522982905, 0.23614066382242097, 0.1683608123293782, -0.12279244181865799, 0.5434280414406797, -0.12853866602872466, 0.6086540883298449, 0.7511473759086718, 0.5507498959302273, 0.706692173524571, -0.14560544012555995, 0.3788405145254102, 0.12410441336912827, 0.21679752982675005, 0.5192172832805286, 0.4651093145564371, 0.6745626519677774, 0.9359014346166518},
    {0.3845209164086256, -0.07803479780602571, -0.15222980303962916, 0.032000881156098525, -0.3801268292903478, 0.20456389562385785, -0.44302694914587804, -0.03798396309045259, -0.0296223351812394, -0.5864716846879806, -0.48675925354296345, -0.3373854692803673, 0.2341741283475365, -0.3988286670001911, -0.42268450099234905, 0.3542052139580036, 0.6128136165519019, 0.5872109410709377, 0.20213883732544877, -0.1304231868400057, -0.10248664722597306, -0.27491385923954315, 0.4240805275893674, 0.19892030025539356, 0.43407642450608686, 0.12608627170101755, 0.3480718048533473, 0.02484459836676367, 0.1706643297535273, 0.24407194010269914, -0.46987476108479403, -0.7836364027347809, 0.5960661712253826, 0.3508309616713484, -0.18085516308076588, 0.3489730378834427, -0.2361075988294984, 0.1004885234435338, 0.30616962436529943, -0.7884340171911702, 0.025842546835855504, -0.3308841847410801, -0.23424631882433417, -0.2961913794118246, -0.34008883751530233, 0.2775051948161902, 0.060987348053039576, -0.6409144338455198, -0.3422760335546213, -0.13963620979720046, 0.3158803899909851, -0.5859481010174642, 0.19261576455595536, 0.3125509413527798, -0.1317710373092847, -0.09219629227716795, -0.5781544474350669, 0.23245422684768371, -0.019714522925005005, -0.33355018494032795, 0.5042682799874271, -0.08660975118002048, 0.1021728171591006, 0.5724746621515999},
    {0.08051332795307095, -0.6363447202335144, -0.3529462741085682, 0.06241673453208754, -0.554949983076548, 0.20995651534767057, -0.6904310709443514, -0.13981275989464503, 0.5337655601562575, -0.22065021983605887, -0.5943383957575987, -0.2713015062753135, -0.2756109253113337, -0.2914272951980114, -0.23467109522948956, 0.3760542078289486, 0.14725755103465424, 0.4778192361623758, 0.591923656686089, -0.09112235112000495, -0.33260688361055707, -0.5363788194583364, 0.16645900119416546, -0.21925664169030165, -0.2716236865527753, 0.043058576399235306, 0.5147173838889058, -0.3321124949018505, 0.4794635596578216, 0.5667546596662755, -0.567320674016088, -0.5259270722559014, -0.2891116694457255, 0.10076508121081242, -0.20039355602738193, 0.02062920490152929, -0.7561051545396392, -0.5503065903739486, 0.3102852243779912, -0.44457553702765623, 0.14631380200211053, -0.0503478602994854, -0.15708250586436048, -0.4625466747872834, -0.2518543885650688, 0.23987868238645654, 0.11385601215173083, -0.57399648039795, 0.032928734312329004, -0.2237916335915127, 0.2595896676980634, -0.7779716986006033, 0.031987301179767835, 0.26182913127578755, 0.2956210979804995, -0.05662546604171677, -0.31879259860364384, -0.08573102478023463, -0.6583918178090769, -0.6250138650250666, 0.502021118814147, 0.039436625675529385, -0.06082365660892796, 0.5845965146474639},
    {-0.17497277687465654, 0.12194112728742156, 0.3647858552041111, -0.302522961453732, -0.5270638809411294, 0.3776022553879963, -0.24376397448380338, 0.783415732428049, -0.2576846827444063, 0.03286249013389035, -0.2556060030907317, 0.14889957117806918, 0.3446882035085856, -0.27883461162635015, 0.32615739694439255, -0.017026861992859025, -0.4429102491011185, 0.32662527560221727, 0.19308998505346248, 0.03589772046465482, 0.09093824782674968, 0.037586298720364564, 0.6056216319526398, -0.6546609975213274, -0.33698233232722236, 0.36273173487959476, -0.25232293425004365, -0.2641956287743122, 0.09499371992345504, 0.5621378212523513, -0.16409862195544336, 0.22217505992261444, 0.0715596397089145, -0.5129795071972961, 0.17096378232456416, 0.546270136089747, -0.4418553270582267, 0.22431346433349642, -0.2989557682155764, -0.35102562360896533, -0.07109484960731267, -0.015469997110995745, 0.3891530810198431, -0.2280788603604059, -0.21755711291465674, -0.07961336833744878, 0.2511320535306459, -0.3472487930032713, -0.17155218340207687, -0.17276344145573963, -0.3208706838046787, -0.39194598734910074, 0.12734685800396506, 0.04667520214785467, -0.31473909332711353, 0.001368441183177245, -0.18447483150378896, -0.4192321215098186, -0.053727599968975755, 0.011163979887162676, -0.40703497581668774, -0.15240102816941786, -0.033909051734083574, -0.3830783598881794},
    {-0.12759886180070407, -0.0690791748743643, 0.6137814823735793, -0.1782823574890831, -0.24176775374503626, 0.00834931762651655, 0.12662321759922615, 0.3906724474482367, -0.41484928169081153, -0.0170826383485903, -0.24979748050529035, 0.2794824309697219, 0.573178732779993, -0.06421198696865035, 0.13915498874085697, -0.16381655275755427, -0.04007179912675288, 0.30892848684183244, -0.09694110594159926, -0.008115130351134784, 0.03372963881490973, 0.33194941768417086, 0.005254509241396384, -0.6616288562807981, -0.05935416626220512, 0.06224508463405836, -0.017099628958515238, 0.02848925347896124, 0.4540701782626801, 0.4675908872905315, -0.21418003955723225, 0.472865769081651, -0.09779188788624307, 0.1953397826560016, -0.2490826303212162, 0.5103814099753218, -0.3778729305645862, 0.19060587829542588, -0.06267274467991639, 0.3129837432407228, -0.1636160404363884, 0.06324194070153671, 0.3859017713512281, -0.2725402896855414, 0.3021878088953738, -0.40677240167202644, 0.4664176235697787, -0.08370404753234818, 0.10902130539421451, 0.1657156822659666, -0.03164238638873826, -0.18267274604060563, 0.1288461207234784, -0.209087005481719, -0.23734260014120837, 0.11596919505826564, 0.25293113199261935, 0.3938158534103216, -0.19624454271328368, 0.3472392841555522, 0.03566805786871388, 0.1683021229193543, 0.5737811910133204, -0.2649816701126339},
    {0.2061308783530484, 0.01193937618453354, -0.2113018360299835, -0.33591024361576055, -0.08196314864417804, -0.4265787712211965, -0.03550947379130097, -0.30630530655264787, 0.3181161115312118, 0.6300855445521334, 0.19947696920256494, 0.46265866871076006, -0.36919251323940955, 0.21589629763797197, 0.40039437550466467, 0.3885012594144875, -0.4466602640498071, 0.3203259177313441, 0.09747895265923927, -0.08477003061807899, 0.13854875510585493, -0.16559035072681622, 0.11719972893862445, -0.26276888415405725, -0.48967898558286677, -0.09466695992221658, 0.1902006033919444, -0.3667195168932679, 0.416512320669709, 0.009301583328569302, 0.22835170171097038, 0.5520931274339446, -0.27693587061592634, -0.1893510579590416, -0.2598337626394121, 0.5405881384837882, 0.28233465414686326, 0.2809044969697902, 0.2644971741898337, -0.08663607473006937, -0.14090097776347493, 0.42842468137516715, -0.029058942056876126, 0.25155996930398566, 0.4388810592998113, -0.06143148911169591, 0.28518683681784596, 0.167743712889119, 0.31948843336694643, 0.5696532520041948, 0.29631456407836326, -0.06329785418522546, 0.020309034564918435, -0.2381947293065197, 0.24834372300646063, 0.5055156117991225, 0.29436531358259166, 0.5468815030375925, -0.49209328621461845, 0.1189284053114022, 0.0034195187892268808, 0.6501416932592766, -0.32844934651728674, 0.2403693755884025},
    {0.48865158348745524, -0.6937383752744832, 0.48694730600811714, 0.18120036053615945, -0.4292760682029344, 0.003153566466381224, -0.5017669318527838, -0.2980243195106601, 0.668488339532588, -0.266421334288161, -0.39467697191784906, -0.6795155823731295, -0.5255466737721738, -0.6671832161528933, 0.04166418539959828, 0.40982701599216215, -0.16669156260912085, 0.42277483956967515, 0.19271995324270366, -0.11285050076947865, -0.36417291923737133, -0.09335835605370846, 0.1869216751542437, -0.031048009858769897, 0.12641665401518376, 0.7857393760363648, -0.6467691546999618, -0.4169527296103602, 0.37763948257731667, 0.3408060227989195, -0.33162391111139816, -0.3702450206909775, 0.2439446920764993, 0.20953794763896236, 0.5484569521718438, 0.3616901860153526, 0.1950985223579174, -0.17961898484238015, -0.018988216381486622, -0.22883499160445048, 0.038974827862251475, -0.5762602864602526, 0.38581777871695094, -0.4191399155161335, -0.4647922703963992, 0.46042603549092487, 0.31750804368899455, -0.4814632326864847, -0.47687435467053507, -0.25301188802296265, -0.6499329159775113, -0.32055447653541264, -0.22168599904543226, -0.35107645906567964, -0.447883507491859, -0.29976178729116765, -0.39334185701810204, -0.4527561033514187, -0.07677377934772742, -0.4487505520204422, -0.10134908873389505, -0.6309146545082344, -0.5272144003401484, 0.11281371619112132},
    {0.247616958695276, -0.14718763492662063, 0.10829344952367344, 0.6959403217736521, 0.05874147376150711, 0.33865655617380963, 0.6915816814220188, 0.6840470720236208, -0.04221463370939794, 0.5267917048600894, -0.08010692306073815, 0.5445382939404642, 0.2935742818725649, 0.21196337074030255, -0.035628153570786435, -0.14711649164398832, 0.5837204524451163, 0.455068025894934, 0.5323139370149503, 0.7441631363497335, 0.21470988917697262, 0.7303824166445015, -0.5281626843048722, -0.563032212945009, 0.1317426208052745, -0.2284845517291602, 0.10170718642625057, 0.7366740029413811, 0.5170457601108464, 0.6855562870230457, 0.3913580325176491, 0.47900342438256666, -0.3852449433173011, 0.7450533489409984, -0.543713843874148, -0.14523564785959187, 0.14160071934947607, 0.3413823457836422, 0.22067825701048896, 0.6221006336157495, 0.026434644060873515, 0.6244989405132266, 0.3027071186352692, -0.005330692888330215, 0.29088308785015665, -0.21827021269758545, 0.10056693738379291, 0.3559746577341136, 0.36528130953758214, 0.4785006082454378, 0.21546473859088924, 0.6028389954727076, 0.8259641558619812, 0.2728699816154717, 0.585227006973092, 0.5275296960837553, 0.21061151167385114, 0.49601328923576127, 0.00489038461016453, 0.3136659139962202, 0.6790480703322344, 0.2879241823140964, 0.5865797898642016, 0.13491368073652468},
    {0.25034721638134483, -0.07659179280211109, -0.28819979649729205, 0.879329672692782, 0.14663971438346762, -0.01895376922198357, 0.6602392938117956, -0.27988074900485266, 0.2984371909646945, 0.06496168064730296, -0.07056453662629193, 0.06572949738060863, 0.38144178805899415, -0.3501279974403403, -0.3068620322568362, -0.6877064938384744, 0.5257054031326832, -0.13822073748731878, 0.6040109099826748, 0.2832648892266409, 0.4422959768317313, 0.6663898337824538, -0.866858591232182, 0.3938575338561514, 0.28538578925241515, -0.7376854606858935, -0.29963099349329186, 0.6822428974769407, 0.4679510147710775, 0.4436414787515852, 0.10829999832017038, 0.14031372351102284, -0.24364769233373273, 0.49564361666497114, -0.28811413102272015, -0.29359501604500754, 0.4617992043068171, 0.24304116631364867, 0.4341738727006984, 0.668391645047084, -0.3179281385783617, 0.726234176447405, 0.2310218052629298, -0.18679769465672066, 0.3634894505488143, 0.07586614956879767, -0.34591435502870793, 0.2801133185562223, 0.4377995672918299, 0.17691570784077024, 0.2734527363200353, 0.0999296986372245, 0.4355910466844496, 0.06422719892633157, 0.5544156140768829, -0.4437406411259408, 0.47912042599595145, 0.4936464724038773, -0.3027714945680709, 0.48932258632162023, 0.616133643116982, -0.028556217381792898, 0.2164736875359486, 0.5493826243156794},
    {0.2895970803701364, -0.4998726380900268, 0.2506979603004965, 0.6836367772425325, -0.5438421899178483, 0.04934408032144467, -0.03259098621574808, -0.17906837853253194, 0.7049989024532123, -0.423232409649416, -0.2860675153452187, -0.697930622100157, -0.12531451275261224, -0.3869178547034588, -0.23305763723177927, -0.02650413750456196, 0.38125166077992945, 0.3754603217407793, 0.09868655170344362, -0.3746771690628523, 0.15537559728613, 0.2679911502208145, -0.6607354327448317, 0.17767310085262356, 0.5840332189925761, 0.5174804335740943, -0.4742418344383301, 0.4884898056584009, 0.3623160761088393, 0.8038507595010864, -0.42049887375423417, -0.06179311926055584, -0.2783931408496816, 0.4330983636946898, 0.33023170898825815, -0.5417964350067966, 0.6693481650981583, -0.18938924055281972, 0.4012321027762111, 0.22805850839658912, -0.4387425491561703, 0.26880586659936323, 0.8777628399150409, -0.4208090667135248, -0.2439484952078331, 0.32020558376440084, -0.03925402872799699, -0.17605111266682366, 0.19706314493113464, -0.10782886215143503, -0.4895813017884714, -0.38806040171524764, 0.5847611882241979, -0.44070590381024327, -0.3899930035768908, -0.6865206635536839, 0.33513799647306086, -0.4364265759243396, -0.4866910805791799, -0.05717154222820468, 0.10303575680628194, -0.6037699128142989, -0.06035910244836543, 0.3505185607235659},
    {0.5715287773446078, 0.23804879858761283, 0.0072537770753053205, 0.9424806391876903, 0.6864983693366425, 0.5716311586486071, 0.8268933025630506, 0.7083194591546983, 0.41149452762662103, 0.6932393603101258, 0.40442310403575416, 0.19162173733682744, 0.7583084300595853, -0.3579693407894428, 0.22093450436070625, -0.4113355217900873, 0.4461330372855891, 0.5720714870166738, 0.8095369280747572, 0.6736731780327937, 0.23424120347764352, 0.5108631526958952, -0.5481904797431033, -0.03390857964790256, 0.14290558563215205, -0.6003873172020024, 0.16482348125679872, 0.8537725514564684, 0.6733466556218155, 0.7052125995587242, 0.10559145483895155, 0.6157234365239116, 0.31057553029011215, 0.5825216089833711, -0.22538759209395665, 0.0032040375370599324, 0.4368871257031496, 0.43819507428678334, 0.4817662034674314, 0.7468716972127025, 0.11202795368949182, 0.889892714111801, 0.3859755396016406, 0.07229785415786909, 0.40246202043193563, 0.07877210493583164, 0.15164133845327377, 0.6931071883116753, 0.38200309053888676, 0.46721015678183153, 0.467034989013451, 0.557850154333212, 0.6834204866532859, 0.768070874078425, 0.44504643799676685, 0.6444265840809295, 0.5658444402320583, 0.4797821045749191, 0.1128435517281591, 0.5757609214842728, 0.8040916109947289, 0.5234893033988627, 0.7878096763436394, 0.6242358911119509},
    {0.5344389023202568, 0.31567455529457716, 0.4811508642182792, 0.6839989311856544, 0.33171118495893054, 0.5162256051958345, 0.23356648332912577, 0.5557087325728182, 0.23164087143502232, 0.4193866150424444, 0.40441707786638714, -0.05468935987364343, 0.37674798956606087, 0.04328890723900064, -0.011511066003982225, -0.37154070120644944, 0.2305878524071336, 0.4379546942406003, 0.5468344248864453, 0.6767778798519393, 0.5680120588875636, 0.6729635329721342, 0.0029278695591288297, -0.1144988713121113, 0.2798445516646372, -0.2406415656534119, 0.4944711130431025, 0.7012710666782763, 0.5286286580985988, 0.4303848884240001, 0.14901647428550852, 0.3041940600467943, -0.12427810136362438, 0.6321089711737269, -0.21705043453776945, -0.27185353869550893, 0.680245154377823, 0.26700491397735965, 0.2540326834421739, 0.6091534568727085, 0.28535232394695725, 0.8056551703941128, 0.2198792673793759, -0.07209313154204462, 0.07551375169563071, 0.3408009650575434, 0.31575406409212425, 0.20080485425738098, 0.4755214261995895, 0.08063676314199959, 0.6343434051953464, 0.0735267792918081, 0.7437457943166436, 0.6848737119613332, 0.6891349469740603, 0.44713679191524025, 0.3831276385843004, 0.4149382548579795, -0.010596237071189799, 0.1580948540911869, 0.3037587051033098, 0.3525623065195214, 0.43853806014628943, 0.275232371391337},
    {0.2587165957833254, -0.2561659216313342, -0.3837525051730794, 0.7827277354347502, 0.6188007809159602, -0.17498052927215127, 0.5842726480791836, -0.4031838360357351, 0.027838772719256274, 0.6176743558389135, 0.4734491601313504, -0.21553360483292489, -0.36207414967797585, -0.14793577618059942, -0.11551364405441397, -0.3999092443837041, 0.10179064086791836, 0.6103106690633179, 0.43755728405009053, 0.5418626860670694, 0.03533141470395103, 0.26878068626480783, -0.5217445639640541, 0.37842858614660424, 0.21233925437726311, -0.40380063973679564, 0.4049181102923097, 0.7249912713133663, 0.421045109895151, -0.2933255404377852, 0.013642593033805593, 0.021983316155854624, -0.32992190628652857, 0.6528334934489209, 0.31398592222492633, -0.003171585303479115, 0.7150140933057403, 0.08968721333555121, 0.2946770878717828, 0.33005376727047664, 0.11928629118783282, 0.46538410171786254, 0.0048891072618836035, 0.30737583449175443, 0.31554722589174516, -0.10927805289984904, 0.09705450449831966, 0.12622644844177752, 0.5277461888400602, 0.41856619190832267, 0.31346381735116796, 0.45084579252174467, 0.27129378001350984, 0.37962571963053426, 0.35074015134455566, 0.07626491337535433, 0.03866701624779223, 0.6019237191316701, -0.2842957792858196, -0.08997586994345882, 0.4124143262085964, 0.3066795535013574, -0.04104619454201474, 0.38983568747946845},
    {-0.20369958424511236, 0.29182833795756785, -0.047369197725779744, 0.6139280612688104, 0.26593482532947993, -0.04903383997462489, 0.5707364126630644, 0.47306751472563136, -0.40382533259805053, 0.6415741979651484, 0.4721199593702978, 0.42762315567704673, 0.018911160906364903, 0.2970855463365249, 0.5493723620804075, -0.29110421456737107, -0.03403889090385817, 0.2567546908954012, 0.026584528494568892, 0.5816748615644854, 0.4501558543449162, 0.11283697914355333, -0.12902919748527247, -0.3948729869350318, -0.36007308109033853, -0.49321990247491715, -0.39256703949202215, 0.4487529750932609, -0.41700165543983675, -0.22133752242479313, 0.5053976864127713, 0.33572654419226566, -0.22768869571210637, -0.2431526861950265, 0.0744908431282775, 0.42466983108544587, 0.5012307928802249, 0.5930567360213541, -0.1491695581183978, 0.49119531326154425, -0.28963389194837197, 0.10973607132756295, 0.07707382143599353, 0.43748261157507806, 0.46368486610473686, -0.20626548082799948, 0.24250294078549495, 0.47082617961667295, 0.23100232550686484, 0.032690948474093214, -0.05875920967728679, 0.40339732549706114, -0.06556871257081981, -0.19321291869612142, 0.3063938200679046, 0.28318008935380895, 0.12651186000196984, 0.32402393741125335, -0.0709172188860683, 0.6074464323136826, -0.07290987123699391, 0.28147065224650636, 0.4797337802323593, -0.27318617823955615},
    {-0.15057764571689053, 0.07110788017473851, -0.13582379583272122, 0.6437564798524587, 0.8017672175523055, -0.21416756691306438, 0.8736150906735305, -0.07451717029975007, -0.6442764490247606, 0.7235120791575463, 0.6977438615301682, 0.30139319282963795, 0.09122958692683339, -0.0054568660488589875, 0.046243300249622823, -0.42816125523887255, 0.020635114049927704, -0.09965791023557621, -0.2285123238284521, 0.5610718148066617, -0.01885754459296107, 0.5191336255335446, -0.4737598915953715, -0.10011500532084533, -0.18715898375841447, -0.8218089128757847, -0.02882174124078589, 0.3559421232431342, -0.40523469643882293, -0.5842984002631647, 0.25387220782342795, 0.6092218527897642, 0.017835902289457233, 0.19184745500669226, -0.11935540503058337, -0.22918527038859998, 0.15630844711980219, 0.53789105673334, 0.22526745496992878, 0.5195577001417547, -0.08546436751816891, 0.5158635478899567, -0.5583727258182111, 0.46159395689863475, 0.6636560421270211, -0.0062576004878949635, -0.3919284391607034, 0.8018507292884144, 0.572247960478852, 0.3841209688549687, 0.2844087862540612, 0.47012739495396766, 0.5002933409149571, 0.3256617361853862, 0.2044138485700393, -0.49128665672601357, 0.49531821569014345, 0.38993433239408093, -0.11795851243697061, 0.6373149132769127, 0.3806204485821319, 0.03389836133344958, 0.6763880943403012, 0.19373011309799598},
    {-0.4191734867096124, 0.35551948013101425, -0.08275763074934162, 0.6387868422400678, 0.6733936483224651, 0.16796350271699975, 0.6353718837663671, 0.5094814547610278, -0.8852166188433387, 0.5141991013552349, 0.5372997511905696, 0.146942525939604, 0.3547165680708698, -0.471519083208845, -0.06094502951386207, -0.6185625968084236, 0.15382876804504772, -0.41854498253317945, -0.10247594110594639, 0.6540352030889474, 0.27838212105163623, 0.4646306153322835, -0.7468519811720506, -0.5846972764294806, 0.04768719674354834, -0.7746666842186488, -0.18870111993074393, 0.41564383235705354, -0.13200591225717645, 0.0732812109864234, 0.12700474068812884, 0.4387736125278686, -0.14743106030396516, 0.12251168747620865, -0.7025806883356677, -0.21109870719122004, 0.1943449102452652, 0.5984853920410682, -0.011625355212817011, 0.40090298763385657, -0.27815571718769394, 0.5158260018971326, -0.06204425070791952, 0.45441676938393355, 0.6365970306115545, -0.48759111057072, -0.3798449902411342, 0.7552040791185758, 0.3588906443525014, -0.05140569280159783, 0.04844808042768637, 0.7205853727774091, 0.27767532297585723, 0.17546655802241443, 0.2111530566714192, -0.16856030025344462, 0.5131631840391934, 0.5552715895543205, 0.09046552269090616, 0.617951420824589, 0.2617436657637599, 0.0003176952127782754, 0.6322964794788273, -0.3832745013156705},
    {-0.24307757892478393, 0.422078320981175, -0.4250019910461191, 0.19342002218684062, 0.6459725137753034, -0.20036901999322373, 0.423767201285622, 0.07933904576965062, -0.13382675395875057, 0.5891404132298779, 0.6336341930104519, 0.4148697280574304, -0.1868365629386782, -0.1477916438593376, 0.09790093302070346, -0.6013771691482923, -0.2553005631470243, 0.08468682055440625, 0.1076605707088563, 0.17953171382234498, -0.04223304117508416, 0.17934546719292802, -0.5761410729489643, 0.041785112697252325, 0.29529482781314037, -0.515565820973883, -0.07639085071661189, 0.3486990994202655, -0.27348772963028845, -0.6455979417545776, 0.2163758136633578, 0.43251543101489454, 0.10940574747748072, 0.05090438611236489, -0.41795563137265124, -0.33535825920987433, 0.5619026209858232, 0.4757380203221762, 0.2601773900049831, 0.6915223240485951, -0.2953789279328492, 0.36048898062648016, -0.4450584399117776, 0.392791665911463, 0.6219945823167016, -0.04132130783638835, -0.5395877729305459, 0.7802943550028522, 0.4021743653372667, -0.035711063677548296, -0.17733326304255048, 0.48194669339926616, 0.5391256313388056, -0.3887407444861793, 0.2844581669031625, -0.43268880511703006, 0.29548970117880885, 0.5729476255557725, 0.3586624278930738, 0.6469823947898032, 0.14504862527002202, 0.15768945782882016, 0.6481743219026144, -0.16166646232310827},
    {-0.5439581924559751, 0.5849315356478489, -0.07065217677409368, 0.06362164501842854, 0.7697394559459757, -0.07981038014560274, 0.773365188539699, 0.5347166096552742, -0.7230180756292746, 0.29707316583499294, 0.8320524499222236, 0.6273372785337277, 0.21102663197361818, -0.24483165650751423, 0.6210937410670639, -0.6485255609531642, -0.5747719645672125, -0.5138704896541224, -0.43483812338627453, 0.24899267489664068, -0.1492744666033495, 0.5205085883886881, -0.47621620448603597, -0.4469957018196515, -0.13930517209888213, -0.5808069072820344, 0.21212087457222134, -0.12493396909659366, -0.6347133454034348, -0.2518738221224167, 0.3228795413323894, 0.6612726230051779, 0.07184520494845624, -0.43367909960817164, -0.11462275316641335, -0.12842775554839017, 0.002701778620125252, 0.5381942690428405, -0.320284590821984, 0.31056892073887676, -0.2520043151290251, 0.2134120874037198, -0.1767906209816205, 0.7640967327479858, 0.472217539848794, -0.22897892442498066, -0.4570469052460181, 0.3170935287498556, 0.09035221049754813, 0.14422873595614352, -0.36330628559908124, 0.4569807344131208, -0.10950608820111643, -0.272148087166951, -0.08736305839538396, 0.12137362702702764, 0.39379400897218453, 0.12418081380504963, 0.7452946757686504, 0.3821236565607364, 0.18078678021969108, 0.053777609666098215, 0.6470354173068681, -0.6133960720749242},
    {-0.6370652520188004, 0.8820759020719854, -0.503439825253744, -0.2337316522404492, 0.8309701948377183, -0.3088394217805789, 0.7632466813663873, 0.8682607518130105, -0.8291272894274633, 0.6175867984887365, 0.5926707503789275, 0.6851986588296938, 0.04247648838590973, 0.34537735478932496, 0.7466560248762533, -0.5070471930588443, -0.44125460613528994, -0.11855926506418453, -0.2959615015629162, 0.4403827790078209, 0.37198968271620747, 0.5851701904671663, 0.1352435858283974, -0.47791632007102713, -0.3527561305920119, -0.5703922032665942, 0.297106937306379, 0.6309848056399697, -0.41356844494645906, -0.38283606997934366, 0.6228317420245796, 0.8190544884494237, 0.11815508396781302, 0.02919491488712562, -0.37944471498736493, -0.01806910358166792, -0.02419542769343174, 0.5652618810319283, -0.4110137652530761, 0.370355564131523, 0.20649778233355612, 0.5915991431523207, -0.4332641212426483, 0.5962009536542008, 0.5822167704837455, -0.49079608794370816, -0.2718281043585093, 0.6682272723931872, 0.6286825321571753, 0.5728680341781522, 0.4831071494144517, 0.8438759594419522, 0.0634665567341271, 0.025900721919903374, 0.7720663785375458, 0.5427396241070872, 0.6896584887885455, 0.27729699193791546, 0.22829903659248224, 0.4247265538616632, 0.22422671890975235, 0.8113786642984734, 0.7155082505204086, -0.15281360953718687},
    {-0.5929049392460739, 0.9066976675642853, -0.4390774390725603, -0.47779206654246764, 0.872400044582849, -0.7598055868506126, 0.7994724403382618, 0.5670388780707579, -0.655306932362146, 0.6259187056209081, 0.8213268866158326, 0.7570803861264528, 0.024027700062036198, 0.6572059866078069, 0.6749892098844489, -0.35192700554733364, -0.8511414033044165, -0.3356469309012419, -0.3107158916217711, 0.12181906594424333, 0.48026600625514604, 0.4963574960620346, 0.09257144018974708, -0.2414645366679788, -0.4807700589422136, -0.7190767563938751, 0.5139858444125271, -0.08093082599664563, -0.7594985231240424, -0.8835440235309389, 0.4634283255881768, 0.6868526381464903, -0.5027644987609234, -0.5087970778562114, -0.10106834024162978, 0.5009966713218508, -0.0736525191145819, 0.47927514760058604, -0.5987448145361446, 0.25856892838253365, -0.239032569632309, 0.2842021697938071, -0.8675399837919682, 0.5472895687873495, 0.727876797745529, -0.6030130458624854, -0.3095081946839049, 0.6088583373661053, 0.32667287969944925, 0.5558041350712201, -0.024876886354037887, 0.7060826109937561, -0.38905745523875845, -0.14018850062100738, 0.30894476967381634, -0.04265832170823674, 0.44322513690999793, 0.2012863141708903, 0.2946058675950871, 0.3831513747476119, -0.2699042650598457, 0.5812615475612113, 0.08266624561386732, -0.8386241593896697},
    {-0.7576597473235602, 0.8082669565278312, -0.18248056069347224, -0.23597447306182978, 0.7268443990078505, -0.6467780222146737, 0.8547360589904167, 0.7579842740716372, -0.8813987905106662, 0.36048584918097737, 0.6137449562063335, 0.19304641239789308, 0.3651110084965098, 0.06692820332979436, 0.5623379245504646, -0.6124296458553702, -0.8884431437654787, -0.755429743130888, -0.7785251316881764, 0.21217675808035233, 0.19983861248875867, 0.5507386139772055, -0.6049552570489977, -0.4972099984096213, -0.4871571905639739, -0.932001117865785, -0.1243269745946493, 0.024452234161714582, -0.7758847607852959, -0.48343416822063345, 0.4718655156616794, 0.7952694214561776, -0.4489557891998076, -0.5817289483153024, -0.42653612826766857, -0.16687346347651447, 0.15369026967667687, 0.47910044118478545, -0.5411399995180876, 0.42218054291289675, -0.41600245327175106, 0.026618244168315555, -0.516072255629817, 0.2607347958240784, 0.6585805802082733, -0.6804354254420742, -0.7184322860003096, 0.8507852302401583, 0.46370437324986213, 0.5040955697507205, -0.4797235583687669, 0.8041979414688597, -0.2947699780786431, -0.6451265022668552, -0.012736685066422674, -0.2634807819008603, 0.8077917369893421, -0.006322522084595947, 0.23994174845747301, 0.6915277710771079, -0.533217018849181, 0.2857366983530627, 0.48691973312256065, -0.9042119473736548},
    {-0.6870064450771727, 0.7288326581756052, 0.04058083800930698, -0.5855225031129123, 0.5783302749713997, -0.41180883978299165, 0.5623862773412922, 0.3128903732426118, -0.6340840134040073, 0.45176768957022356, 0.6611761753760895, 0.6066312295193038, -0.4765674622897315, -0.200516204786437, 0.44173054030283776, -0.15232950537061077, -0.3974255657228216, -0.3231710001498625, -0.48688094191211917, 0.4201931389742678, -0.23058110612727337, -0.11652286802143784, -0.30343181516123735, -0.10325799198141249, -0.3288215050495969, -0.03703308168931663, -0.1122877560646702, 0.30859918803847847, -0.652752662689739, -0.5292225621577274, 0.3268765053911715, 0.2757983495098221, -0.1550416855833175, -0.4582458372391893, -0.30071410221475564, 0.34681592467365635, -0.35410261449711194, -0.09583071247457522, -0.4886120212386377, 0.09187453949204838, -0.024529216966144168, -0.3813422096206715, -0.7770720496497029, 0.1668013077530773, 0.44991877023230387, -0.40954721825764423, -0.36856446444110164, 0.380696186499138, -0.22521010119967647, 0.3258283929474229, -0.30864954447208987, 0.6537418535505938, -0.1825143769739908, -0.43664614039743943, -0.08151949869563194, -0.06651496955320776, -0.07795828466137139, -0.13350712453584013, 0.46946281630385944, 0.36185909584719383, 0.0493376481932991, 0.206223251365288, -0.15498349887112858, -0.31131011525842156},
    {-0.11088725189231155, 0.8911525275526195, -0.5881222251981433, 0.06712162312952763, 0.650234889964681, -0.1810122974652578, 0.9147897005603945, 0.7208933234789332, -0.7788604258752885, 0.897223968425064, 0.8560163696423615, 0.8066580206404707, 0.532878640783226, 0.0826817357017286, 0.5744644693659438, -0.8271163701827108, -0.24754588905879185, -0.3347536364039995, 0.12386760484932141, 0.734690114584298, 0.26896106940421, 0.6688801152320887, -0.35259059730495323, -0.5165528660131095, -0.3371657047305566, -0.8891198096366193, 0.5214727981105948, 0.39941630933626704, 0.0619558818846312, -0.47867767765705305, 0.7284119810784763, 0.8309333797714933, -0.29618846100770374, 0.09429991167127949, -0.33288332635148243, -0.18918677309713605, 0.2389048096722624, 0.7662793499868616, -0.28666664135571435, 0.36472247126667556, -0.05404923490855716, 0.748424520042965, -0.7022274869334101, 0.7349507378655129, 0.7903926350234233, -0.3722036788855849, -0.5796865357150857, 0.8551278368350208, 0.4656841288842237, 0.5290943819376034, 0.3015853363332165, 0.5353734437889321, 0.3103683725752251, 0.06643936467487599, 0.5023459619978213, 0.441721579260276, 0.3170619521440794, 0.5524911891021793, 0.5534643638007102, 0.6993383737328309, 0.040022099404265134, 0.7560393958198866, 0.7552433847954287, -0.1487125945547564},
    {-0.1493212662269397, 0.23118945152062992, -0.22753374652475616, 0.4500175055453319, 0.4350697454280592, -0.21034221028089983, 0.804209203008828, 0.24893585584751382, -0.653921179153269, 0.6409204978602483, 0.29062351813495574, 0.45934734289675877, -0.07258594689058812, 0.12912329323616106, 0.35808168410301877, -0.4221972763364345, 0.13217384613437352, -0.17875055918194926, 0.09280913170060584, 0.5709005477394622, 0.09965412021411031, 0.3224222884434983, -0.6315830140522762, -0.2320345390777908, -0.04628754235739776, -0.8247837176489773, -0.08000592329049082, 0.6016937888401727, 0.3240149537252178, -0.4268488976376168, 0.2798163951421935, 0.6653263534728671, -0.44259644324175634, -0.034121274232716964, -0.47273031309369934, 0.1000985322542791, -0.17016310172957574, 0.20746769612329904, 0.26221992834999364, 0.0774785423351502, 0.11275563716190455, 0.37069543082722717, -0.6236229568581556, 0.20612217994244963, 0.6936419473466467, -0.6951419043171527, -0.5498084617602386, 0.6041518145150375, 0.15093106389118463, 0.3279817956678412, 0.46297774651328455, 0.5879480207480836, 0.1536335027877622, 0.3753043487889464, 0.546057375523923, -0.12144064192404946, 0.39972915363973105, 0.6467059171621005, 0.19447135012991412, 0.39326451323305567, 0.36763646839082376, 0.25670313925427296, 0.1179387368183129, -0.09330070660035883},
    {-0.4807223347970477, 0.23793865360414138, -0.5758593096465051, -0.11024866631102835, 0.25300869404457127, -0.7794122633083962, 0.09984168944406119, 0.36416316598903714, -0.8229357621790827, 0.3052066202504067, 0.451562392877656, -0.0011497198703614665, 0.35520393373124404, 0.13158208599618354, 0.28289020303730605, -0.8323464945307862, -0.6324525504259101, -0.5105410457561292, -0.471274325254682, 0.29403362892248125, 0.436849773903013, 0.15774883525772845, -0.34961620831889767, -0.05149571243067796, -0.37849089326793106, -0.5940933100776159, -0.6521078758552882, 0.27033433147534053, -0.7813899742466611, -0.2961653474306336, 0.06639864145456431, 0.19879878418151875, -0.9453711940084136, -0.9229614954402582, -0.08848558648345688, -0.14795684234899223, 0.249002148109224, -0.38232689648496593, -0.937583373753476, 0.3238629507781556, -0.922405660552684, 0.14482356991523082, -0.7445229869677893, 0.32363178414840976, 0.5030145451181405, -0.5543898911329613, -0.682065257795259, 0.3939884558413184, 0.2615688634491365, 0.078658677726417, 0.2761966926873791, 0.3177107365131945, -0.9251720653831688, -0.19726845631918194, -0.46426965628826083, -0.1686603528190892, 0.4345261684231001, -0.5741201550934792, -0.14941389711302594, 0.38533275628908176, -0.6260139043725534, 0.43863795017088186, -0.6826665019617907, -0.7658947831805634},
    {-0.5015616070664581, 0.2900509984054983, -0.4345940280729534, -0.05292653641814545, 0.5945455954394175, -0.722240855838262, -0.028595011689438274, 0.2721553658802703, -0.8795767143874668, 0.6154306037505011, 0.45832878975196445, -0.026207350715046106, 0.3741362517530695, 0.37714053174891043, 0.518333212998782, -0.6664380054603256, -0.7810422384856273, -0.40820022494646163, -0.5552183503140345, 0.2185235159397788, 0.33379215271894824, 0.3404403711747829, -0.03993524933528019, 0.14703320431494485, -0.691824695614194, -0.8498786545909526, -0.2946366284829572, 0.4430483467556069, -0.7177405881632938, -0.1476181926755553, 0.4323659414172796, 0.5384520360615945, -0.7954200611401393, -0.6367134308329445, -0.6681114839876499, 0.11580828122021118, -0.007480498782605817, -0.20348156921665408, -0.4296084979057219, 0.14681470324034043, -0.8487374769647124, -0.05758480607265328, -0.9000211139981461, 0.5459542978191588, 0.6285267203869686, -0.6606459629151842, -0.8592545189935948, 0.24229534329617117, 0.3376791923478307, 0.5641220776136545, 0.16892339925915792, 0.3366901658520809, -0.7693154440937161, -0.6498167858490523, 0.10201139132541943, -0.18253307931801355, 0.6027438675688405, -0.015550801583089625, -0.5259849309998433, 0.44017044901738683, -0.7617859723567372, 0.6213730804456333, -0.31321904274053003, -0.6392219989000071},
    {0.2544251136982406, 0.33901563733199835, -0.5027417487883455, 0.16326303997308209, 0.4796394183277665, -0.23355785241517887, -0.20461786981632415, 0.35971175073234046, -0.433789245876562, 0.6239873190613787, -0.12452163786443654, -0.17482594153891268, 0.4060605226899769, 0.5110464898176232, 0.5840629343449819, 0.01494064389389126, -0.7277547751853415, -0.07971976817752977, -0.41710056463228606, -0.08557312066914509, 0.3056196128054474, 0.47588516987259183, 0.42277298263293556, 0.06791007407035657, -0.4985986564577442, -0.2584636142711552, -0.03326122122082288, 0.5655471834544278, -0.21823881124693945, -0.5144066791536576, 0.2482626687676211, 0.3074566183610589, -0.5071613874646113, -0.6649756630331609, -0.13171307902167506, 0.1282532253796381, 0.19103731362119888, 0.13294874118827466, -0.6694199855087858, 0.2795065170980589, -0.6976720432432532, -0.16610798990477144, -0.3868394417630959, 0.6161908103501589, 0.2669169295597616, -0.5437197372711473, -0.6084455481835864, -0.06247849706013739, 0.3937073086076525, 0.4947698908305052, 0.23419691891849506, 0.015793107446447577, -0.6165682717974995, -0.4805284864110146, -0.2916286068376259, -0.18274201656845326, 0.12270128293782163, -0.2173547806133687, -0.0331798782008375, 0.08515030226839997, -0.6253666071893438, 0.30488745749558516, -0.8607134641263683, -0.17817978717131067},
    {-0.32266160964636026, 0.41614807574758833, -0.546632507650075, 0.12874555824277903, 0.4982113236988151, -0.2656024922534851, -0.1256650925981117, 0.31722844679420426, -0.06150503669799336, 0.16454525785692617, 0.3575094640536164, -0.115044681594422, 0.15672677128808774, 0.5470950670651491, 0.4651102099300697, -0.11996504635813858, -0.7775522782217907, -0.43726518157700367, -0.48648102749248867, 0.28202094738510136, 0.5372146921267602, -0.01698475930447633, 0.5169728771317627, 0.540872098885415, -0.06783299947936797, -0.17336271275159618, -0.5374545931868492, 0.33395081625451184, -0.21590524610315495, -0.5897783742998546, 0.2568453923859749, 0.11134225077611672, -0.5731781651158804, -0.5104971694090992, 0.13203076269828226, 0.05279876730795336, 0.08900967287215793, 0.04626624075082436, -0.7256602639839028, 0.0747174695446661, -0.43958424735053364, -0.4488162177574861, -0.03347228998376764, 0.28205518882822006, 0.39638025750972783, -0.4893289298727323, -0.6916479562167739, -0.2196156153247562, 0.4688013030118583, 0.6394166835115269, 0.07864173251440736, -0.1651566987810992, -0.8190975619484907, -0.15370390402227377, -0.2684086448411788, 0.017260302762063317, 0.11515604892920685, -0.07864386768109896, -0.35034638130596246, 0.06716004150004283, -0.22505303796749968, 0.422609883606097, -0.7961080133209698, -0.38566852499003657},
    {-0.1816644090179241, 0.4559022892796404, -0.2179998710778335, 0.28670235494274265, 0.6315691433411925, -0.29103872903218897, -0.09804470578621316, 0.3006104697761768, -0.3810460838335848, 0.025565222618365288, 0.5206116701607784, 0.2629672145461811, 0.33859896801320594, 0.140421944302088, 0.7773977331705412, 0.32529191834694776, -0.655810192840482, -0.15875136402323292, -0.37830821817993365, 0.5442644605208424, 0.4526464804517282, -0.09417147807882148, 0.40157639719743105, 0.5173525883597259, 0.4371883936462785, -0.12104905350828557, -0.4577755839926174, 0.2845573781865998, -0.5127492499809104, -0.39007570857, 0.5220932843466537, 0.6212543389270822, 0.05285031682575413, -0.5835725705668188, -0.13407425906108622, 0.5800866868024299, 0.4787824447285926, -0.18741724357929623, -0.5342268927037175, 0.13068071070763007, -0.330277609958549, 0.34133988156823036, -0.486434753645267, 0.5937643530667525, 0.5670390782563017, -0.6446511244717889, -0.12486592987091506, 0.4017978004112456, 0.28338812307990935, 0.37623879998798104, 0.4914565259084838, 0.05507975737408896, -0.6673137112059805, 0.0066906474159898035, -0.4548783158554189, -0.2433601485290493, -0.05677624335458062, 0.05551222307464344, -0.29969096395100187, 0.22939341551407083, -0.6040198585902312, 0.13770210977565317, -0.610129580305491, -0.48661034855133095},
    {-0.08700819374328156, 0.14152303582254663, -0.631406915755326, -0.1548384557234121, 0.5493648828577271, -0.6737508023446458, -0.1481085080888489, 0.31590532787636305, -0.5825982440003945, 0.13675983133631506, 0.3610640452403214, 0.12597823771205183, 0.03464162258025113, 0.6244981871260702, 0.39533573756140983, -0.1914353276891486, -0.6072136284118098, -0.24004087075445418, -0.6973705025414408, 0.5501584096998523, 0.6272829208000887, -0.3015736878021315, 0.3112259318022089, 0.33137612599145266, 0.14770702518682807, -0.3169027082024616, 0.1448061063174756, -0.18826861050926227, -0.18155003933451302, 0.06859487373138329, 0.08995269602907802, 0.6197393266597321, 0.17036567408518621, -0.4411410637104228, -0.4280638260182959, -0.049339374654183976, -0.36011321354333486, -0.5572609885659294, -0.8117567569376206, 0.2113509305009032, -0.2005046653482387, -0.5845752075254825, -0.4748986843168236, 0.6713510135020763, 0.21689528117892148, -0.2802601989727127, 0.11927643092334417, -0.14052829945691794, -0.33547416292606824, 0.2708618912512385, 0.5640936993605374, -0.04918118797423378, -0.8468324851877336, 0.15903311535895967, 0.10645414502741267, 0.4699508541670407, 0.3952750819528567, 0.0900561321118784, -0.4963567056100109, 0.15650591670162337, -0.05568735886443259, 0.43542675428262967, -0.15335567748434256, -0.058120081803901755},
    {-0.1814485733601051, 0.14847692773008944, -0.3865156987123994, 0.14709618352016599, 0.5196683977714703, -0.46798872907784156, 0.09317580791726895, 0.046360722184361894, 0.1375432203810801, 0.5853885163639182, -0.18581182726669979, 0.2854853838103273, 0.25073004553570594, 0.526586159532569, 0.6263314829647701, -0.19187368936000893, 0.018420824707962306, 0.013037266599772687, 0.089307545962151, 0.08916611994484339, 0.37244749554372353, -0.3192776199445986, 0.31453476853596807, 0.02315741575664069, 0.2240019740902035, -0.29500705582860665, -0.0929369472725688, 0.13569812093777017, -0.01682084882947617, -0.6140973528460416, 0.29356407933444306, 0.5646980865686226, -0.0160606741549473, -0.012059140486466583, -0.23207557125136843, -0.15257926352195647, -0.06356871472838406, 0.2394358283755964, -0.3943058361803814, 0.06543159292924036, -0.5897869982000746, -0.3569880831448089, -0.3927997663930879, 0.23929228875052788, 0.26452948020765055, -0.5754843653238756, -0.18147751480562238, 0.1159425712749216, 0.17321162782692268, -0.00801648599670828, 0.28139769565524253, 0.0285170928823398, -0.29624225642873203, 0.1282518991451412, -0.3157764353116748, 0.33787694729450746, 0.6413194269247351, 0.2786045114054034, -0.4097357497932791, 0.02159328296417684, 0.08686783519130697, 0.6023801399326014, -0.6153310607137398, -0.25259327589972685},
    {-0.025201179495599902, 0.1423213150257298, -0.40280128672313203, 0.1517417099303914, 0.5013886466882421, 0.04778141903791919, -0.007582061370087722, -0.10554295197544278, -0.6033970404311885, 0.03171736504245517, 0.44449832652389126, 0.34651072542062766, 0.2763117188776944, 0.28303318640810926, -0.062287944278407725, -0.18630412422098652, -0.043374216734444186, -0.09363163668054775, 0.2695353379490305, -0.14451236809387283, 0.05398330849579046, 0.3061057498083718, -0.5085468976222893, -0.2842356507846011, -0.20300059911890025, -0.5503045204343082, 0.07192039499007237, 0.10716701135924239, 0.2986719590630079, -0.29501648547213005, 0.32441822746363425, 0.10336472562659167, -0.31092042216181326, -0.02695885776021757, -0.6295368767215161, -0.3459059737382926, 0.18128437386575014, -0.05935244734354194, -0.5331785110087601, 0.29090439495631604, -0.656021750165155, 0.21972916876775583, 0.3061471980646639, -0.14972880941571437, 0.2789042625693074, -0.48351902597798585, -0.6877152119506308, 0.4585731093585958, 0.4624069022625489, 0.0007078299551763438, 0.34978179800170034, -0.41696047890323773, -0.037325222379417565, -0.2677312124513971, -0.029728778711276382, -0.30096850623769167, -0.06430595266144938, 0.07851597331718722, 0.09209148605093692, 0.2291884736940752, -0.41559462078606674, 0.5010568895220429, 0.0281476507191352, 0.015302338738422988},
    {-0.35104042704942484, -0.22301418682120805, -0.24013842678393682, 0.20444414081332757, -0.1555493164996882, -0.08960623163509403, 0.08144953461964811, 0.5326032535558215, 0.054350875560707355, 0.02535446234480418, -0.10716303452045983, 0.2037096711513597, 0.1729838982053114, -0.16075922944276924, -0.06202207186033332, -0.11669598489984251, -0.6232181173903042, 0.23192859857648326, 0.35487434231019055, 0.15967090036101447, 0.5737228007680956, -0.15062871476642017, -0.319967040236261, -0.2872632826127671, -0.05592539439200735, -0.10301508861904199, 0.4580544230715161, 0.4922327761408146, -0.2336342593528872, -0.045413496831128226, -0.0346562086371984, 0.4513547790201112, -0.1925187622307394, -0.4360743366852261, 0.02792853721964623, 0.5678502189997285, -0.2058836286783003, -0.39857865872705883, -0.591262311317027, 0.6029100000627745, -0.7034013562199383, -0.5173796866854374, -0.17491810173105377, -0.027253712314129635, 0.3689368615204811, -0.4491771377460882, 0.04213885940965571, 0.17761541484442062, 0.4190640677164598, 0.31706581852023435, -0.053722500133336404, 0.2823250207476293, -0.13438730944445626, 0.05416731464672312, -0.10490065076121716, 0.4733422278642404, 0.5550350635887686, -0.29941457348336953, -0.6229326937679014, 0.39292407094036214, 0.20871301365333933, 0.24594995010756857, -0.009325108156939804, -0.21104123101284622},
    {-0.18621845078342017, 0.025895608366821563, 0.2891228252389029, -0.05759456243396649, -0.3785880477228255, -0.5870407659677574, 0.30934271486590403, -0.0787678847249015, 0.06809472090613715, 0.10888851239744349, -0.4293565076316588, -0.23825326981798106, 0.28585846185863684, 0.3659870024888677, -0.13528078966558513, -0.031794575017614325, -0.3277770644173867, 0.11706031529141123, 0.24995782520451743, 0.17340296146486808, -0.3400054731878657, -0.286022401546462, 0.04143169160770999, 0.16067295392374273, 0.2543138626609605, -0.18913660727386877, 0.3264660887880652, -0.25047231329414105, -0.21705296480295885, -0.3793498426762893, 0.4900216976468089, 0.21657337913868133, -0.5061359498879457, 0.1054183910003536, -0.1369346733213637, -0.026555565606460926, -0.39977650480439975, -0.5340133608054192, -0.11212733255484246, -0.0896016820177124, -0.2108908263161341, -0.617923195448032, -0.2180468939925208, 0.2899124257083815, 0.2848693147353862, -0.3967396711341836, -0.43575238511204567, -0.5670930220474959, 0.05578215067302818, 0.011868144274585855, -0.11595671619552687, 0.14848254513175313, -0.5547950205694965, -0.25582419671574336, -0.38425250011097845, 0.19009796205256954, -0.14722969697192206, -0.07466870025814583, -0.058019568377033565, 0.37038356521311333, -0.15823577302280173, -0.025915040931667983, 0.16661368402062768, -0.3198846159272618},
    {-0.004523862531040919, -0.022224409508931467, 0.029519348337333884, -0.27584065420438364, -0.17568803523418855, -0.15485381197581627, 0.3002985157567202, 0.25575145779758934, -0.23973124488794487, 0.5644503717196233, 0.10888222520385472, 0.479952405371961, -0.11937909100791727, 0.1726109563861419, -0.030601258242106077, 0.4125448694234815, -0.2779681928681557, 0.046777169883876875, 0.10473046450980775, 0.020218191501858884, 0.057100443993442274, 0.26204884756475266, 0.17489507981147054, -0.13867582475486706, -0.45974001006000415, 0.2263294217738363, 0.2948848168949029, 0.0886945759082745, -0.04119013453589077, -0.3226523505144013, 0.5027212431721618, -0.049603761992126134, -0.439670192143059, 0.22951483788596863, 0.3349246494679023, 0.6230918088809413, 0.12358882439101289, -0.08032496011645782, -0.37833592973474345, 0.3537073860948065, -0.48019443571807735, -0.061059658239802105, 0.22678875342376273, 0.554312620966329, 0.45712237271494954, 0.3721872365130961, 0.45144811426423725, 0.14176341521598707, 0.10813426111165476, 0.5492172252840293, 0.6541782323717902, -0.4249584826538423, 0.0025485581934413973, -0.3254319204952548, 0.4603723065534282, -0.5090357503430674, 0.14274802712182458, -0.17322518812334645, -0.18095987329690935, -0.16080532205704579, -0.2901450968829725, 0.6271397010093497, -0.37239278923953345, 0.028289233535180838},
    {0.003398489028872995, 0.21876008471222916, 0.1470914753039969, -0.22558914233281796, 0.5175251063649791, -0.00867301991499759, 0.05200975796918181, 0.1613500985890118, -0.2414798526406292, 0.0859488692626045, -0.08891106375050145, 0.534358610890709, -0.08815528528412897, -0.3110424825981012, -0.17312867538264418, 0.18121753057514967, -0.11074846738931707, 0.046214762816260524, 0.10763491355673102, 0.23602489851782338, -0.1624903140877669, 0.1431165016748022, 0.24222082908711245, -0.2908215526077215, -0.22634649140754068, -0.10393728027684541, -0.17141407354714275, -0.00837242399721086, -0.47586497177699766, -0.26547782068705617, 0.12989833836508682, -0.10046237848508799, 0.2873914654787491, 0.10433205889991388, 0.38374061435662243, 0.5963908498159529, 0.035832144993618566, -0.023642343598953366, -0.44807940111591255, -0.10651197936463869, 0.17126571358282122, -0.5347594059077809, 0.18070508562636395, 0.03336442522124803, 0.0565007519798437, -0.13326696683722128, -0.2510716095544479, -0.42337735451948494, -0.18161269205375288, -0.2618423444877332, -0.14710482059808214, -0.0475638205948106, -0.3209861549292167, -0.2488703663536173, 0.41237046882280565, -0.27133648821491674, -0.0421349312304616, -0.0382338330438087, -0.13043122085008474, -0.22036382506802957, -0.400421420569531, 0.18953970159728112, -0.26386208469438993, -0.38375760404850884},
    {-0.3580838492943039, 0.21916496635715157, -0.6675163344194074, 0.18293932026880821, 0.43082789982810277, -0.02056044545849544, -0.0830770873956003, -0.022451292840318902, -0.3039491018665564, 0.42554448582648047, 0.15316629237899348, 0.6393485760212259, 0.5305097991806517, 0.3349661822799425, -0.08153212733271913, -0.28964383489767326, 0.2431374077067616, 0.10002462986297656, 0.5009587384394798, 0.18969210521045707, -0.1982292494175086, -0.03596577519175176, -0.36144391938166476, -0.029499485280076808, -0.0949100164223355, 0.07864038163227263, 0.5940635436881214, 0.26078901297922974, 0.3419044002476183, -0.3519590343695398, 0.5351404563306286, 0.2760491289226485, 0.22572020192278436, 0.4376851166233518, -0.49974549092768367, -0.2741583554989171, -0.36570035666216233, 0.3364874661111475, -0.09967962081294805, 0.4324596588395668, -0.08470423660441666, 0.4902681078800689, 0.26537948281773904, 0.07784211024402528, 0.22997334286333007, -0.529008189053117, -0.36626685970134776, 0.12408334600416492, 0.2923864496088409, 0.25057594120332716, -0.08589789997100314, -0.014752773900240978, 0.12480055043843657, -0.07207404581070899, 0.14077609192400603, -0.07080045309573653, 0.04580059419107889, 0.1990916646882812, -0.30383266795864683, 0.24433682443802726, 0.11504946038693277, 0.18182886998687428, 0.08492021158088434, 0.46975691723487406},
    {0.36069132716909047, -0.21364325005970708, -0.1158771857298206, 0.10744512741019344, 0.3138997115079714, 0.1960149764856376, -0.2371002298219087, -0.043476139828884215, 0.0399010250445336, -0.07838555880322191, 0.2772422079060461, -0.2149968937526396, -0.2848182082475757, 0.3977993301421647, -0.13397313023477897, -0.2664839208143805, 0.09552700599963244, 0.10772195441471105, -0.17076368789745766, -0.16852936585612768, -0.38812989087241334, 0.058076624388689546, 0.2699622816755931, 0.09022736505938488, 0.2806691688135895, 0.15858181095968665, 0.11222836832831896, 0.47336604479133254, -0.2558899147321809, -0.2596867136452563, 0.3879847144545844, 0.37171449859462496, -0.17921858053949505, 0.0008699358939460176, 0.3601262957387312, 0.2730261502262816, 0.3022945498025188, -0.27348307944342615, -0.29479500301674516, 0.3278286293615427, -0.4231370440215876, 0.2431193932505386, -0.13891573481731104, -0.14550830298757259, 0.3303647830715862, 0.27319069405709673, -0.4615859074817839, 0.20758412267489804, 0.47875228501485734, 0.41735152235670564, 0.06255537337283516, 0.224271956281341, -0.2923610839886278, -0.11942121614092285, 0.15602148704113805, -0.20606863830267255, 0.3758249714516322, 0.14327035104456015, -0.1501502533894082, -0.11323713072356432, -0.24786259918843176, 0.36052870780106755, 0.2699041091501738, 0.04341512531314473},
    {-0.116608921137233, -0.4493743511668108, -0.6702166531147017, -0.24923500808466123, 0.2547636838064859, 0.06873880797548614, -0.3931406617954063, -0.2888396393347568, 0.15251796230055867, -0.12638538726239093, -0.07433824047814015, 0.18863075820447292, 0.10733655235400741, -0.18218241586992534, 0.27114769583459875, 0.5904174242095013, -0.05941846513050984, -0.1389567923723483, 0.3351518380056595, -0.5250139930581551, -0.45053653396648213, -0.15222153778306652, 0.3332735494656686, 0.06762613818551813, -0.4950432721291557, -0.390691502833073, 0.5268595160616273, -0.1991523652389675, -0.32166887080708045, -0.03705672362114773, -8.908213259522953e-05, -0.14420574823669405, -0.40341697474196314, -0.2276369123214908, -0.0854940186066814, -0.243802742581856, 0.18583723738093125, 0.25548575794739853, 0.3225856525193232, 0.0875055696807976, 0.37148080075648693, 0.08796981645057345, 0.24399574079054587, 0.1057474675490228, 0.27151866839352373, 0.42053941659464505, 0.42084867548035304, 0.32606381633154313, 0.3070014923382355, -0.0005188588238106658, 0.5269789952459609, -0.228715174962038, 0.2777204871281379, 0.0793310099767016, -0.3354568095480921, 0.5130818292665716, -0.2234751205499977, 0.18220515653707836, -0.036126817628095255, -0.3607046141803979, -0.017260367200353344, -0.29274250328823376, -0.44858706362399703, 0.26741097309709166},
    {0.138628248815056, -0.10496519448174027, -0.44051333358873057, -0.1435474805066571, 0.5141875570155119, 0.3079415223654621, 0.3330473766823174, 0.299112658306573, -0.2889741521788156, -0.12689524012158013, 0.30380856162454595, 0.18217550769200647, 0.20359573050006766, -0.3501790138234597, 0.22242166964281496, -0.23390315091539146, 0.14334082561466413, 0.05568843515844386, 0.15876751027825092, -0.18739768538447651, -0.6656471048558635, 0.5385713474836625, -0.10412149147612942, -0.2306006300960926, -0.45190564327518834, -0.6061141441917075, -0.164679687284974, 0.12118794551369552, -0.5136093188001085, -0.4954920875002646, 0.44379503495043676, -0.0568597769203569, -0.4683542051263796, 0.10237511567853641, -0.21358292080324878, 0.030251344441212965, -0.39124255911119116, 0.045558321646333125, 0.3519058127629549, 0.1298012175342394, 0.26575137307510155, -0.31741027616196693, -0.0066565365006293915, 0.32772246645421116, 0.5676478668758732, -0.7242073642259358, -0.03053489687759831, 0.14227937681154276, 0.4263559921700182, 0.352921876593838, 0.037234824887251834, -0.03779209477766014, -0.4982060184680391, -0.1878010493576215, 0.01602942417134105, 0.058528479132692886, -0.05880197321817745, 0.19797042779190802, -0.2684122594534345, 0.415591866752383, -0.38740874706531014, 0.404926649562776, 0.32126544624849873, -0.1021552071849143},
    {-0.05463033849993062, -0.331021441816902, -0.4350640661388628, 0.39615170484959766, -0.02503491629027789, -0.1008241662345198, 0.08526163831612749, -0.3384189742799115, -0.14163574216312427, 0.16780525788887163, -0.25867205727707354, 0.22185350076117574, 0.43041498461829414, 0.2056059174008928, -0.20172203589382642, 0.387128080116598, 0.11900374979688531, 0.06809309860426754, -0.12118074675740986, -0.08038515673972496, -0.3980282193370761, 0.28169358314002757, 0.377195809082546, -0.15576760633393144, -0.08269506598169543, -0.17109819868112386, 0.19696688216640162, 0.07682500801400229, 0.2751371055699683, 0.025908065543401495, 0.14274401058499603, 0.20143816659242256, -0.1700813054731479, -0.29054979631782557, -0.3681512058539396, 0.033518809984415865, -0.48804992202534114, 0.49108404873699596, 0.10977065754660506, 0.2376991526372168, -0.19785369658648436, -0.05778226361855793, 0.18016363391036433, 0.4984208690554509, -0.1681511154057706, -0.5328615756880496, -0.09434942011326398, 0.07094215401870957, -0.33430598555617974, 0.039425536997134414, -0.033893712692973164, 0.21525557120099448, 0.017118560534519094, -0.09390835170268233, 0.4231836228192274, 0.13685550711311978, 0.24723289953084354, 0.4092272384384855, -0.5850487620838667, -0.30591686468307006, 0.022312194919861607, -0.013039335259035358, -0.1942168539582637, -0.0903324532336277},
    {0.330031813176832, -0.5834211634381609, -0.2300702444996648, -0.29387974829317565, -0.09116292864122283, 0.021460747137684148, -0.3067393734802039, 0.10641764718449731, 0.05740429343920346, -0.1512086523404648, -0.3547757519055901, 0.5637883196779655, -0.567341879629218, 0.376990997927864, -0.01158296332734169, 0.0005525759827856787, -0.26019311007682056, 0.32127767561381076, -0.19160409971151665, -0.03966940826487879, -0.5460728742562435, -0.2775968999597426, 0.39277094276094277, -0.19103183379280697, -0.07062797783757806, 0.2620229598046719, 0.24108595800090696, -0.019591799101330423, 0.24568701829198136, 0.001993980991922565, -0.07210804109861561, -0.3825996077906067, 0.2595773728166239, -0.08669218224125223, -0.0938280422651339, -0.1325589834376933, -0.4059611891259764, -0.2495788723404458, -0.3933524443432056, -0.4201502457063237, 0.06182764719336685, 0.166444316060899, 0.4115471063701904, 0.6070212650045269, -0.35603327484554176, 0.24419124860841532, 0.20814109815425816, -0.02378906096208252, -0.3603138367952767, 0.023071443675591122, -0.10251801425194618, 0.3210591128930429, -0.4760656902877836, -0.20494041456214643, -0.048269943040983636, 0.378084043344751, -0.27778540055719275, -0.2421688176523353, -0.3459938104589509, -0.26917858464028177, -0.343601112912942, -0.0924807445718986, 0.15543069734269943, 0.36752617281804745},
    {-0.008691037764972235, -0.6483302491900543, -0.057208186154529585, -0.36880387473727055, -0.4047489154360864, 0.48696377742511826, -0.2363526238367628, -0.2731849134072677, 0.11945112709953985, -0.07546201352445776, -0.37139160781482594, 0.3588487483868391, 0.2883694114380648, 0.44283999212901637, 0.23361331472325836, 0.38208702575183445, 0.13167176166229508, 0.4946946395237101, 0.3358846269205032, 0.17317998700239257, -0.4298434386140104, 0.24422227765012594, 0.6536675533436812, -0.13346035182196997, -0.4138561076580351, -0.2518598609436359, 0.04174954122744174, -0.41647754055744013, 0.06746364098761898, -0.002047024202950647, 0.3708014331549028, -0.12195572302681203, 0.2887437775920211, 0.1286284303713263, -0.22882686792830206, 0.46019778915626003, 0.4972825515406943, -0.3480765853262244, -0.054348708581233925, -0.3814640182713069, -0.2997389346872343, 0.20558526523851647, 0.4712127067262891, -0.027820666650844723, 0.2348442306508588, 0.5694037036332384, 0.08508755474232826, -0.5068826065581965, -0.13082139719476038, 0.4092023065898172, 0.1685077932011277, -0.24975192832928858, -0.0686689938976278, 0.2666901125994249, -0.12391384332976586, 0.4778853562058095, -0.5065488571353136, -0.4162889196215549, -0.2795843273178254, 0.15040701132352968, -0.09145603517300241, 0.1398154358286626, -0.40423395506054255, 0.005211349096290147},
    {-0.29340718354943784, -0.11218239555004948, -0.2610103473351149, 0.19907971410095882, 0.030122282905208048, -0.1766315451933145, -0.24028089118151744, -0.47895462343069345, 0.1905979352778878, -0.3610768787954304, -0.47888449663456045, 0.4406024974171173, -0.6792422291491236, 0.5560835458964614, 0.3456361670886653, 0.3753892497705821, -0.042750381827519765, 0.15740825335812733, 0.401904629627255, -0.05198901061685206, -0.32859364465944313, -0.3566569993351613, 0.4847718601980243, -0.16929387007133492, 0.4409620339811389, 0.5131184353157658, -0.19271155590633463, -0.2343284249072749, 0.12565522030419296, -0.13114914607482442, -0.13108159158260116, 0.1460024111952388, 0.46115550679192385, 0.03352409585411996, 0.3206493687116036, 0.0909465805673014, 0.055311664337958116, -0.079066210007389, -0.22535377600937823, -0.6814696840532409, -0.08002336681894087, -0.15257232242560853, -0.1206568397827948, -0.2848293500994536, -0.2063077382329509, -0.0919963226776098, -0.10884684267537927, -0.3977290531896781, -0.3553523592085154, -0.08445568175769055, -0.4276186094695926, 0.30686324248324576, -0.3373730066563508, -0.4445044863228625, 0.1829679860229402, 0.18800030480549, -0.4368626432674721, 0.2764282258853894, -0.48836308196775047, -0.08517806838527772, 0.1752670845381855, -0.3549505997612602, 0.02036816269269473, 0.2726817364356456},
    {0.16805218941132768, -0.3637155872577078, -0.14719244896421435, -0.2006815551674723, 0.04676590580099044, 0.10477107853781176, -0.2612440329342222, -0.2630630420978499, 0.15437579431332177, -0.016017583214477445, -0.3873692059737715, 0.5577552968533981, -0.6256871188717532, -0.1594570498872844, 0.39931998507379285, 0.2207089983695484, 0.04396519184743565, 0.6109950721587394, -0.2808485445947322, -0.39753479264210084, -0.4755789207140537, -0.033202992974249064, -0.028106030449427447, -0.24598907940485085, 0.08975350916559308, -0.0010605088664038685, 0.6227829149190328, -0.36868102288361726, -0.23589297530248735, 0.2370291991548699, -0.05702111090298258, -0.49070786533077915, 0.4457200938341888, 0.2521748358575325, 0.5339393042667584, -0.3790196176629954, -0.4511871647085058, -0.29913819642042744, 0.1630094538554963, -0.40929810438096215, 0.05310385120282292, 0.3107544158903645, -0.08710730377009675, 0.06175015547002794, -0.4397755302378472, -0.39343413194747207, -0.11108210876712277, 0.13993417546617373, 0.1077345447276618, 0.46929644450170466, 0.5091326421817589, -0.6702559615895162, -0.1057943323638287, 0.010183165268294022, 0.40457923745456514, 0.23881987259900195, 0.0032224099920105144, 0.30646217066897685, -0.7128124579251036, -0.465280925068262, -0.40368337641331037, 0.1792323941221104, 0.05043108922221076, 0.33043023560750695},
    {0.10178412265476176, -0.4083046462091421, 0.43183961330839205, 0.23368821366019193, -0.017697619433533637, 0.12137766351207244, 0.12212463857400653, -0.18467786294610236, 0.1954603551667446, -0.1422838289606133, -0.3888152457387562, 0.3856747265699653, -0.40167695092539546, 0.506226392454294, 0.07547784758742991, -0.14605051629632515, -0.43067906657787597, 0.1885853180036763, 0.10516361665507219, -0.056717760418897804, -0.24202124615806037, 0.15189616228135797, 0.7569215742741243, 0.3037869347237701, -0.513035546373238, 0.07298220522004227, 0.47751097576870316, 0.04993823703447752, -0.1804141611689251, 0.2139618369498039, -0.07828973805440802, 0.07664060446812689, 0.03230866604592093, 0.3278707243310548, 0.5937639431458446, -0.1543255804448547, -0.08559357208760728, -0.23494938998672701, -0.32640193547876256, -0.08715813166028248, 0.1796690735241179, 0.03978851749398728, 0.5036698229889756, 0.3163509603263679, -0.19342393146364528, -0.1574803832799704, 0.1878057131244833, -0.5897467119995804, -0.3726054443050022, 0.45418142011052853, -0.05732658513936579, 0.013825644646882991, 0.03434456671960257, 0.20937003937907667, -0.0858114767875682, 0.4572041076688269, 0.06400175508550451, 0.5960444727244443, 0.08774472945582636, -0.5457786010876462, -0.0634433768715732, 0.005216042119207424, 0.0979822409342792, -0.03202923962133344},
    {-0.34874950146159817, -0.11858402504000201, -0.05505966781360169, 0.3095697880719132, 0.31452680417995005, 0.27102661893121865, -0.16397715084646264, 0.2795579808372375, 0.38064778261055915, 0.2350105064442072, -0.4129179790202029, 0.6411648296644331, 0.5745968584508134, 0.05209721069058953, 0.11368395813042516, 0.5268022767229065, 0.018597799944736308, 0.23344573587099626, -0.30594608747057067, 0.26868237681947155, 0.36428089139425607, -0.014323451804513393, 0.604883194716716, 0.3314970022372164, 0.15821453456144627, -0.05992477592718626, -0.37034976849878104, -0.007780167687054521, 0.05715337608371414, 0.08346272487151792, 0.4320537431415463, 0.32259935549672347, -0.03996067938252124, 0.35616558118052244, -0.5463985730327026, -0.47753839347414606, 0.08650341541966243, 0.5087304986418364, 0.35940347127434985, 0.2446705535539838, -0.08534363403364494, -0.34416916949635623, 0.3493892078837849, -0.2595478924557568, -0.262850936343702, 0.2853827783663418, 0.15580439978423005, -0.15878795500318982, -0.24625537792300234, 0.17379133708279676, -0.07203149089370404, -0.20474680675921392, 0.35933034888262566, 0.08977216077733587, 0.15187620590487239, -0.06370271782793832, 0.25920736922041626, 0.4967061713786081, -0.22520956891458954, -0.15283035953917287, -0.380824060050723, 0.34400382057741663, -0.04553336526416647, 0.13123341308780048},
    {-0.35686301374802787, -0.19783347285535607, 0.15299544911375182, -0.3806193991632, 0.01081429865158023, -0.32794009873804447, -0.3915177998865084, 0.45519300353926484, 0.010048238552071953, 0.24847269481764478, 0.2774962526017994, 0.3546007100580076, 0.010782939427566552, -0.4377851779014281, 0.008978694491741579, 0.1821700381367463, 0.2499899895137756, 0.32679989180262464, -0.19901649750783418, 0.28020270198480896, 0.39173370040400846, -0.0736675491192521, -0.1300143301839027, -0.2928398725412443, -0.494486279618974, -0.1801450486807255, 0.1207907492421118, -0.1330240166906778, -0.19829395789476112, 0.43101221477105944, 0.26633885036055477, 0.24377025052582638, 0.1920806052383741, 0.1781041323806408, 0.2120504128339406, -0.21454447532599022, 0.34936866683152684, 0.2571461728344232, 0.31585314800502434, 0.13551488691557456, 0.1669426316138602, -0.4796883963723059, 0.19841738055491387, 0.15543473633077132, -0.27751503088034235, 0.08333065700998468, 0.32874838603766365, 0.19733456943660196, -0.3443006394127252, 0.20921829583076737, -0.2123215235017642, -0.1973066874986626, -0.28510133870222265, 0.3308406591969859, 0.42738082494573354, 0.39793397890228493, -0.3008585265127715, 0.04500432436759577, -0.37480698834136267, -0.0974965402965003, -0.3495143686115351, 0.2436038870150018, 0.009014870288960081, -0.13211024828287515},
    {-0.3580451325882975, 0.14450826575047107, -0.2533270253590461, 0.07066023686351032, 0.14151461950729255, -0.09812095262719452, -0.028373171871195934, 0.3155224729357065, -0.4529408925352546, -0.2036875659819569, -0.06590264373536828, -0.07239226740703669, -0.5907341572239456, -0.06699254349894745, -0.08829441433388027, -0.3667886501645085, 0.1319416207129809, 0.47207484841011277, 0.20783854033705015, -0.12330324654924871, 0.0419436289886129, 0.4208011666737184, -0.4396440625803243, -0.4498909608603888, -0.6866173826300712, -0.09005219018351626, -0.32963218025837826, 0.23725701051106138, -0.12944345251373152, 0.10694633527036344, 0.07578873963704794, -0.19277038140590436, -0.31440761132843853, -0.2588897551946652, 0.4863007957623617, -0.28916966214345513, -0.5632820736457949, 0.43295665858726856, 0.10962049087566074, 0.09838364161313688, -0.2422903264942141, -0.19679983038603202, -0.27451722541768786, -0.5546381036268739, 0.05476754113901555, -0.5188395431132, -0.18744227177043246, -0.1253057351384631, -0.02006043112677653, 0.37099272042461423, -0.1588160515972353, -0.5182323689936809, 0.33593832381790334, -0.15768922632063365, 0.22383734608148018, -0.4319730889351538, 0.06876306608459669, -0.10365685856454238, -0.6690114360528461, 0.16382569545986933, -0.048293403373632665, -0.2951894728711025, -0.09544109442778692, 0.05688589625658685},
    {0.19984501678167946, -0.16520554813160915, -0.08168721017128937, 0.35767343744957913, -0.10589513059771423, 0.5335574458200405, -0.26632194037829465, 0.15455306636420663, 0.16782608818116368, -0.4731989093389965, -0.09706137907104792, -0.03659609539116029, 0.41380377509679217, 0.06465281168063206, -0.12958938811690088, -0.267709731593898, 0.03561263841934049, -0.04533205366263026, 0.3100828248891853, 0.3212491378133875, -0.42839957856377925, -0.1644973026734631, 0.37074845641852927, -0.01533303334923042, -0.012456825158024808, 0.09607599023338614, 0.6279993882411521, -0.03891422760995344, 0.08937866785221586, 0.06876108116246811, 0.3955597222780676, -0.3394302034878814, -0.20817117849832664, 0.06958809282427326, -0.13923752877517007, -0.39872702222292106, 0.19220602901339118, -0.05623175679956773, -0.2253566234754703, 0.2267828113612425, -0.23522054206342635, -0.24328653148764995, -0.2620593065912919, 0.4250272464456173, 0.12460203858978369, 0.4066769512898613, -0.3713334279447845, -0.430179190473139, 0.20812894050541872, 0.46084708884293035, 0.30186684710852113, 0.13893640757348177, 0.08545688688461348, 0.4543321193003125, 0.3451615568183667, 0.22603770683404542, -0.2946881650288515, 0.39691478351263215, 0.018465543604616778, -0.09404980542977864, 0.15141119552603574, -0.28844779375469487, 0.17695118415525637, -0.17644882795656577},
    {-0.37633117028797813, 0.3351173405764889, -0.41015903006336557, 0.26127536179369765, 0.31845820827221544, -0.3444391815599646, -0.12597499317888666, -0.04036585625184966, -0.15965815035774464, 0.23751153123538646, 0.3699512663964575, -0.1602590112843503, -0.1389491773345266, -0.4577787973060301, -0.06883617262493906, -0.06964895890044287, -0.5400214106967389, 0.2662638102505336, -0.09473855946658154, -0.4058374498210684, 0.5918679753850326, -0.00048248258284686014, -0.27810107535268097, 0.24590481473913745, -0.5650924827376158, -0.26157335122057906, 0.28430140576758445, 0.1665010630478612, -0.34095108480021274, 0.20310334592278848, 0.10801347226713129, 0.6082376657620555, -0.27522547203567704, -0.03744652667754724, 0.09479106423546751, 0.42291147594772505, -0.2082675126489973, 0.035700630752722215, -0.09871379623713337, 0.23188535823266018, -0.1541265879425131, -0.12689212362520041, 0.11477697492776098, 0.37266669838052785, 0.028553198487755557, -0.551954161473386, -0.23155685688353506, 0.08254324577133337, 0.26802724920305077, 0.06420872987669791, 0.3195823879084557, 0.0209233048320199, -0.2629227699700563, -0.07445277438743608, -0.04801227575177813, -0.0059165630225743475, 0.35817859950953534, 0.246929455793817, -0.1085426224198139, 0.32502273024990397, 0.24174213678815643, 0.43018810603088653, 0.38423099061820126, -0.32150337704934095},
    {0.25158751903277893, 0.2251348320801047, 0.5548196043491687, 0.08091996261535313, 0.08757699074881233, -0.2958645748085686, 0.3349202088435801, 0.19208498017485762, 0.0859714051104375, 0.14125865653213016, -0.13180623661812443, -0.25272657340506616, -0.38177735294176685, 0.4771295199771525, 0.3703039284382919, -0.11469293698422259, -0.06738039681088238, -0.17723927311308083, 0.01819905242088722, -0.34068287846643797, -0.23595313209432708, -0.008925303591028586, 0.27619820020835684, 0.127947666363408, -0.10442993464851162, -0.44553646749045256, -0.1291067457672115, 0.08162656945158582, 0.15496534490845953, 0.08990856214631487, 0.1946595631869487, -0.12755615649197827, -0.31122362552849614, -0.27609766179942113, -0.05213272730679742, 0.2714123331830486, -0.16659973170724862, 0.04471670467328267, -0.27943212707558945, -0.057840562958723266, 0.3827509578566813, -0.15289734649712533, 0.029506035537395975, 0.1299159309119792, -0.05519967945220639, -0.22451066710088335, 0.01320582280240999, 0.3638840401475337, 0.3095850778821471, 0.3679003200827343, 0.28726836337695605, -0.15429719866294367, -0.006605207025311377, 0.06564443609253519, -0.054040044458219416, -0.4166655823296846, 0.5727144437724132, 0.5165405938549461, 0.2596492202020228, 0.22001702584120247, 0.42658236770113345, 0.19009265027141337, 0.23357664457338034, 0.03738359875090825},
    {-0.11387552508120463, -0.16770693784399512, -0.0038529045187253807, -0.45049386692214494, 0.503693381317412, -0.1505749425444064, 0.2229192325527226, 0.5361685275872726, -0.07707510619327283, 0.27402078458054374, 0.3264208963064937, 0.37110694638027314, 0.10936298884627345, 0.6078448151575336, -0.2592808281417315, 0.32238543469850034, -0.1876786758432555, 0.3885904701505068, 0.09675711223475007, 0.18618798784070353, -0.030129976089033932, -0.26266788638842326, 0.07609289120623128, -0.0285821046173604, -0.3864912082632785, -0.3854206783336227, -0.05304470729968557, -0.08451365496869198, -0.02087811990984278, 0.08025810891851058, 0.3925352638899474, 0.17294677083615928, -0.003741203197894081, 0.18756929108580073, -0.11572826960354772, -0.0425709899048524, -0.16660461645097263, 0.45996002821438375, 0.10112554382336607, 0.5144053015868206, -0.19642197274910347, -0.15772776719840395, -0.1304028440929745, 0.14227260086287982, 0.40714970125107874, 0.06949370502612053, 0.14560794901599092, 0.3178755841251727, 0.3341699518362097, 0.42695262693328007, 0.40230026279961056, 0.5330602093999602, -0.19504090433219448, 0.35147649025153355, 0.29229887335094856, 0.6444323349287318, -0.16497087737980273, 0.11947658322352601, 0.004088104140605595, 0.47851813643875524, 0.35770736155471883, 0.2650583166266314, -0.12509009845630586, -0.19682981733387653},
    {0.30978506124004096, 0.04858138206190161, -0.5879356037638166, 0.2035574735630918, -0.23439468783231573, -0.06792952100910771, 0.14186099523624163, -0.08409141505515653, 0.3239771210397288, 0.5923514484671012, -0.27157993168620415, 0.2542889047897824, 0.32995039723242064, -0.3849053445643251, 0.23637495563629876, -0.02352972457798986, -0.31522704223795295, 0.24163138497771436, 0.3524949464502067, -0.4713308915797691, -0.1097906631850234, -0.16054869982974082, 0.31345965703219825, 0.31472563526851094, -0.28724055768074247, -0.30334353368218225, 0.21966764106631853, 0.2832245509786134, 0.4076651793976859, -0.45752867184249946, 0.13866212208011022, 0.2917260605287159, -0.11477974187661859, -0.2401984230620123, -0.15494399592185368, -0.2792664625045758, 0.21343654328259046, 0.16061297571515523, 0.17990153286596466, 0.4046348125199199, -0.02442876050245117, 0.2837070510422023, -0.1502194960411673, -0.2661524091900262, 0.2086488447878034, -0.07708092894543941, -0.5846658175512784, 0.6076727458094052, 0.19512609284614832, -0.1925421281097883, 0.023969631624042812, -0.07923357054719223, 0.540823827336196, 0.38540530648922966, -0.26123741023738234, 0.4488758107433995, 0.49439512352813514, 0.6466588232116994, -0.3681970504806259, -0.06359839317465561, 0.614576421196685, 0.13273872572902629, 0.0030896988892328927, 0.19537999613707502},
    {0.030128466741896148, 0.20466420296481413, 0.315609070943302, -0.2242279563983133, 0.035215584805108655, -0.052768395359735654, 0.15149794092014174, 0.018345014380120636, 0.3898324485011135, 0.057161349068171476, -0.07621102233779038, 0.4366298042285658, -0.05845814507188272, 0.39597607812784014, -0.18302044595843556, 0.28001658969235627, 0.14441735157929844, 0.10146211220134524, 0.1194370852049515, -0.28869580161806707, -0.1088843266520559, -0.11748883951974046, -0.2552686822340366, 0.0793771631686781, 0.0550473503207033, 0.1340675317758146, -0.16346132101350658, -0.04994684451607569, 0.43392854572495965, 0.0978708648736741, 0.2316027566903396, 0.06560507508655393, -0.18112838617733312, 0.20963935941183381, 0.1459511104964875, 0.3413423603625992, 0.21750166050116368, 0.01748578592429116, 0.1214742944506726, -0.054217871859839464, -0.16591414379130634, 0.3135249328069727, 0.03762656201681472, -0.16481675545935867, 0.0552590868209466, 0.033299195979824864, 0.4087354849666863, -0.22006478853800818, 0.26201344611579463, 0.004901482125917568, 0.04794455422738576, -0.3331499090419071, 0.2736340315807304, -0.12892997735344228, 0.1188710288860122, 0.2598732353660549, -0.1573031333488374, 0.47597835752672507, 0.100773503725535, 0.15969239464433216, 0.24440798173532918, 0.17942866895212276, 0.4255949907688871, 0.23972266049437502},
    {0.16080723654642068, 0.21243038721637345, 0.5199940530319829, 0.03309392081655295, 0.12926446372405043, 0.3069508209014218, -0.27028907614201203, -0.016323955042766968, -0.1376095396587356, 0.32206526299995675, -0.12160875806707706, -0.34986013982813513, -0.2468962011947514, 0.009348865204094569, -0.26825284387300374, -0.1263769655666356, -0.2078872619114143, -0.07639907590238156, -0.08661236885711691, 0.42601042615698864, 0.28413654836130653, -0.2548399670267218, 0.4942115987359093, 0.05982737368431353, 0.11033911143930353, -0.14273904180343747, 0.21650459599441588, -0.21837414185298093, 0.18458807442069505, 0.11188582123191178, 0.022736584216278534, -0.11571896417403442, 0.1379530747212933, -0.1215178514719239, 0.2673726067672099, -0.2804599295862684, 0.11734169182603602, -0.013324821303655443, -0.15090726313232208, -0.28476158544379016, -0.18636954720950338, -0.016052163959775174, -0.2466043172916389, -0.3339063115564326, -0.05840486218216511, 0.262382244177362, 0.09152511720026721, 0.04680974768629292, -0.06380028085556927, 0.001436476442706568, -0.4428233399828467, -0.008109334213425521, -0.3048398565516636, 0.018208250170672114, 0.3495682826535002, 0.35258408824939097, -0.16636833718179006, 0.25069297913728716, 0.40611208999481735, -0.22687053515157463, -0.22250965847482962, -0.06606093871276893, -0.5374524104534627, 0.15691958222616098},
    {0.2528987204045328, 0.17393352912639012, 0.2744035111795345, -0.08449581360561347, 0.18046703182975343, 0.03536065449022213, -0.2938126512193086, -0.04016387867771141, -0.2589063572143191, -0.20391505766120732, 0.22690829121057557, 0.12765316422417397, 0.03344702885235541, -0.4613070723360812, 0.1868563349048282, 0.21363281162077824, 0.007773008769917618, -0.29282043356346305, 0.2587591602352677, 0.3329268103910431, 0.2820893466252762, -0.33590373240035065, -0.41113514497623743, 0.05063269947107631, 0.09096574152590738, -0.026876182747572194, -0.23202568528624568, -0.2229154463111623, -0.06618272466132087, 0.4074900370293181, -0.15129716764486234, -0.2695715762681299, -0.018879654049742515, -0.14459500463104866, -0.3548734117281581, 0.21206037816643508, -0.3795667422085001, -0.14580354791986322, 0.20631990034305764, 0.31676596917693867, 0.053027482153574335, 0.16017167458023782, 0.25422933089893096, 0.011175685906131652, -0.0468783176845277, 0.17953495840268907, -0.48770548388027557, -0.12536631789064004, 0.3880074266177504, 0.10311946298270958, 0.037265890793878424, 0.4214549101872933, -0.16559454012879163, 0.13779759473652695, 0.2793711908184371, -0.27138564979702645, -0.24490918659291924, -0.4199686860949427, 0.06617600486910416, -0.1018686762823516, -0.084241347859591, -0.12004157849403518, -0.17694151020749282, 0.07570119291425208},
    {0.043371930358751795, -0.21667577951837036, -0.10104296588973243, 0.09582979937466173, 0.36727506615981154, -0.3345929462229254, 0.3495905562318943, 0.021890464472191423, 0.11366725322308256, -0.2911335628653396, -0.016657171961227967, 0.34847153813697485, -0.3000107246829689, -0.484172577988734, 0.37374092486108873, -0.001541139895540481, -0.13158915425486087, 0.06374537598801419, -0.1545279524754206, 0.06706431116472224, -0.2427544206329914, -0.3822943670982213, -0.39616143459562714, 0.3333090835716154, -0.2665686202510265, -0.03535297339356009, 0.14130144061715547, 0.2804914289065586, -0.28429458250556927, -0.03447627784469658, 0.18154630069360447, 0.06825949506127131, 0.3519908572849982, -0.3266768416811334, -0.10500071690674706, -0.15562288046289627, -0.02979696537250757, 0.1755540107807138, 0.43617866799185123, 0.4585429635879886, 0.0608954895270689, -0.3103668988122548, 0.4453794446908689, -0.09366623110444086, -0.05326572500204114, 0.3277166379692707, -0.43660415349386206, 0.1935227742018607, 0.17751565912558906, 0.29919557236449623, -0.008442417312033457, 0.42367978618059116, -0.2624542741159163, -0.03321432734714021, 0.051679239087227734, -0.3097682176389057, 0.03931475551348301, -0.007441748219917012, -0.4210036370608475, 0.17328390657969844, 0.1338073425397171, -0.12880610046209032, -0.07694843343830092, -0.19790500217092902},
    {-0.029750569890419583, 0.05640923393825527, -0.614448047574919, 0.29989050785762883, -0.010604401820304442, -0.05829968097689313, 0.2691302800155532, -0.13943842628470815, -0.1670455052456319, -0.4219917917890483, -0.3661608144839748, -0.049174704309818774, -0.3636279674226154, -0.3750204639289328, -0.21539753527871908, -0.16102367994621064, -0.30471654576193713, -0.04893298646802363, 0.2661686743348088, -0.054921067620772784, -0.37189379653838106, -0.4700537545353951, 0.10051938547720198, 0.3294097537730743, -0.40207908813280824, -0.03278548395254556, 0.09855235510063022, -0.32989107183454336, 0.16341873518830813, 0.10614367056002177, -0.030827266863865777, 0.16544461119590848, 0.143452727571833, -0.13993080171683603, 0.07261358721389052, -0.2802990190353225, -0.4199219986522837, 0.01132447180248876, 0.055853293578608985, 0.1148547246669292, 0.2616519518794541, -0.48244694212377637, 0.19695263731480186, -0.1824092981857514, -0.41951724754905334, 0.17936029290041217, 0.07935746199784396, -0.22233819678021421, -0.433362107374936, 0.26372127810780444, 0.3386674411431398, 0.34879148748754385, 0.03097483993857198, -0.25305238853489154, -0.1461291454297691, 0.024806486818407757, 0.18300652501941525, -0.09184440771774612, -0.32578146630216037, 0.1684064700860752, -0.2731742156062185, -0.11391133555869377, 0.3392278052327178, 0.1101564698573135},
    {-0.2299359970612872, -0.06332084084786986, -0.15144600074404588, -0.2621449849254062, 0.147431457335494, -0.3587162129235176, -0.004011772708106777, 0.23757214934859452, -0.2630707585490766, -0.06173147196283063, 0.07508293480095232, 0.1379926331117632, -0.39421765957529215, -0.14605326289896567, -0.1639803627127881, -0.47818269167176836, -0.04211560864605452, -0.337694328046863, -0.15215314613091002, -0.32901960218355847, -0.05855458498108906, 0.34735569463510046, 0.3175756714091449, 0.11374474071242473, -0.39899961007978846, 0.3503662692803217, 0.27742770820759094, 0.080927453307854, 0.11958527495415892, -0.43966378308869936, -0.27753864429677916, 0.05893470302217733, 0.14347162832785973, -0.16832353887968277, 0.5806797071060095, -0.11886774053144435, -0.02044157835296182, 0.3179768509644346, -0.3192008527867031, -0.2641232499296744, 0.3059115077296622, -0.44134553183387487, -0.2797325157016753, -0.24157157204984367, 0.3149578366854345, 0.06321672502077434, 0.3599798852316288, 0.31210831993415455, -0.5472219351679367, -0.06556937633155208, 0.5243701675178815, 0.33784215718457095, 0.36678822053029136, 0.3893913644284261, -0.4067576511469499, -0.3039092047492381, 0.010403357255133808, -0.472736217285465, -0.12988353783830886, -0.02578060710748485, -0.21763275655758807, -0.3425970819389975, 0.28492268767936446, -0.40915654453884825},
    {0.0399629844008081, -0.3200086174567254, 0.25633935686310516, -0.08680734814504132, -0.10135629489274363, -0.10914751118007465, 0.032442379268490217, 0.3346270059446379, -0.2742271170150107, 0.20797452512930126, 0.2751872138593905, -0.33765285199106077, 0.16919328387723925, 0.490240158431895, 0.39426186048297984, -0.4457529040370328, 0.17651976411679504, -0.01075806618862137, 0.17750924332681006, -0.09288472982857716, 0.030007996616677326, 0.560904277678255, -0.20233432989256014, -0.30804105536538656, -0.20789374072660563, 0.1878923604404888, 0.23676570187992102, 0.22726790889740625, -0.4008167812405622, -0.1815521560108469, 0.26053728090957956, 0.2906887488550791, 0.2563874976387375, -0.052265289919018146, 0.32319115660273073, -0.4556442113152545, 0.08752055172495192, 0.15756208476607889, -0.19298823826194186, -0.06998947206379849, -0.08973483529505505, 0.21281325682931024, -0.31835049579741564, 0.48857851484846204, 0.42343350492516185, 0.006687381934235607, 0.12591829768184012, 0.0713198314111322, -0.1091298248187389, -0.2962084470531001, 0.42375833767338156, 0.237741468667775, -0.08740057496885936, 0.110814099324384, 0.218983154615626, 0.1693828395553315, -0.19579773829306016, -0.017870536992275404, 0.16274102577855562, 0.017115043689910046, 0.05335102085748018, -0.05496158893586261, -0.07513170555318063, -0.24297110704821862},
    {-0.26814648329876306, 0.3544831707752391, -0.2861023818313517, 0.18410073277671843, 0.20581475928948997, 0.39743335729940843, -0.22416948354211605, -0.38711278594983006, -0.3309715201959508, 0.10316503872357871, 0.24049140152812093, 0.12195626409679254, 0.12700243275723225, 0.3385686465080745, -0.25438104408130313, 0.23730456063506142, 0.19338271934665166, -0.2850774622506106, -0.06370065124633506, 0.006746408605798673, 0.11592682898118335, 0.058618537091582865, -0.22458234370932442, -0.2150672220617576, 0.09118295707545644, 0.06002883481176084, 0.38163637010929774, -0.1329586963272112, -0.39080731676987684, -0.2737983602701677, -0.05403063252695545, 0.3040090731029784, -0.07038893493907467, -0.11133178704660725, 0.03989154444909831, -0.2645156640678935, -0.3965617166140209, -0.34412430563585295, 0.14298737755030003, 0.32178608244863244, 0.1799647934173139, -0.019988204623989692, 0.06712450674057403, -0.04960811937329996, 0.23888441451591974, -0.26410313449185047, -0.4012717055422787, 0.08358870398765128, 0.12374667901985476, 0.22123234337781084, 0.07780672160742108, -0.04077138914609697, -0.14489360943248225, 0.08332884822786644, 0.07274326848612656, -0.2592955669845889, 0.25495338184629984, -0.3850611699245333, -0.26269701982326193, 0.13307287846532892, -0.45480087229768196, -0.19447241705369167, -0.06059849073341553, 0.1732582020708294},
    {-0.2965354582634929, 0.25368796749124384, -0.523815566366741, 0.2838240094714551, -0.05777423787595808, 0.22505556826165068, 0.14127478058385295, -0.36867784357032046, -0.12103901089249407, 0.06321086207154145, -0.06078725942473947, 0.38723247246329723, -0.37898630920498794, 0.2546524656861172, -0.3917182008941099, 0.12137647620954845, -0.028747960389625096, -0.2871954302998227, -0.2277520344523967, 0.10541919457344497, 0.33383888456262495, 0.1488331012453926, -0.4234455355402935, 0.2588440844237046, -0.20324441864097048, 0.39830043273921456, 0.2610554783550596, 0.1168567580420303, -0.2047742630766649, -0.20696195892061375, -0.010763101763121877, -0.0411048028305958, -0.08322374850396623, 0.27426756020167276, -0.35351123684105273, -0.19930011542843543, -0.3554276843669153, 0.392678050977347, 0.12123734759257145, 0.030596385491416227, 0.2787323109076895, -0.17170045818030258, -0.2907140779591639, 0.3799359145837152, 0.07632929294255905, -0.1997592635810032, -0.2634809574872388, -0.4224828566620452, -0.15838195071344674, -0.2934228145066322, 0.30246962782214376, 0.009982928090657367, 0.24399083634095675, -0.04922707947643838, -0.2395870914992181, -0.03437315905470002, -0.24785336513569284, -0.4042213126826861, -0.3656664650018295, 0.1635428103461345, -0.21718245400391267, 0.020398692437542585, 0.061077715636516254, 0.31162306014499735},
    {0.3291255227698518, -0.013579666066064335, 0.056393437581275095, 0.17619715888939633, -0.060028035461744525, -0.04286718370637247, 0.3623986784150102, 0.11941722923777447, 0.08494876550721453, -0.23874524665295396, -0.2139147841175867, 0.00838458115426802, -0.2698903772931137, 0.4001160761881491, 0.22949531400597872, -0.19193224970661085, 0.18219139970370948, -0.3521348821756235, -0.25465160598084324, 0.10473239013668778, 0.2051612433265602, 0.04993435742130137, -0.2840355011028786, -0.09099254223543325, 0.25156761350625484, 0.07243019376924109, -0.1948625746266265, -0.015750822323275324, 0.022962647313974054, 0.2906339895546311, 0.31865187925559185, 0.2585837157750619, 0.08978171287620147, -0.1087087302365305, 0.19220397507339945, 0.31830841738131277, 0.33789736849950025, 0.3092327723998439, -0.3808463037908338, -0.3109463575165993, 0.07120330818268332, -0.15618690518399014, 0.16639539906343973, 0.02565854067794388, 0.12327338690372845, -0.06519960115117118, 0.1515651369634085, -0.43265122985495885, 0.09600984440844446, -0.01573477920909023, -0.1552506187680482, -0.04273999391612383, -0.14577355527977146, -0.20095197644334126, 0.15604650139683335, 0.04115396888774954, 0.034274397854731936, -0.329935073954939, 0.3152618669307149, -0.005935020973560202, 0.3795471448488121, -0.19861571695366081, 0.1272462270325402, -0.0900346939932242},
    {0.3928247205877692, -0.1863711874659824, -0.0017758990558220053, 0.23372255918872267, -0.29484643466339566, 0.04334461434595311, 0.21111896704962757, 0.16576195346359254, -0.04117313926031882, -0.30423212713299924, 0.27418003736549584, -0.35886077479367995, 0.33340870523874483, 0.19239448123077627, 0.4010497157312809, -0.12057047068603567, 0.18270123490365495, -0.07614984467540495, -0.1124279509125205, -0.262592568640137, -0.015062508059353611, 0.30924197408113535, 0.12640703062369568, 0.1232919092544954, -0.07987074993233187, -0.15984909400758324, 0.1299411958359289, -0.18885464965151916, 0.05696492808586708, -0.16722940519620566, 0.040875557085150976, 0.029232245785218474, 0.013190995988501507, -0.16905868115932504, -0.23093654895698548, 0.25307051563194455, -0.1012105136027368, -0.33086272233848096, -0.43185966984867513, -0.13985383922606787, -0.38514628541872464, 0.17496311047583166, -0.05935355029301623, 0.09382549168584467, -0.03541205799143812, -0.019135371210488805, 0.09619770271615424, -0.2412810489331484, 0.21078159472159352, 0.3861784396890424, -0.3504625959497461, -0.06658511926422599, -0.264884522220451, -0.27002181270503156, -0.07568945895222215, 0.10211576753228778, -0.29488778347901007, 0.03929587818718228, 0.2673409265162626, -0.3087038648821374, 0.37240098974073776, 0.35550697140882015, 0.3312696221404491, 0.0345671938136707},
    {-0.24371247281741382, -0.3523437338810302, -0.09251233289877876, -0.04675182562397438, 0.05569928585058509, 0.25295017898390465, 0.1983619900679742, 0.4281562469072493, 0.3814075424289921, -0.17737352341949264, -0.22050749355611024, -0.5483104289790597, 0.41036906023895475, 0.26485024690627107, 0.33549011056679395, 0.452291934041747, -0.11055311860817973, -0.10524534635014653, 0.2842557548608539, -0.42523483762766556, 0.37958495505644274, 0.04709706934828806, 0.1818248623228415, 0.38233128146622086, -0.2225566158756649, 0.17783667020793836, 0.01958065415302999, -0.2175148494334049, -0.19430898042590095, -0.22742027889782, -0.47029841192967925, -0.34620559405668255, 0.5086342742013941, 0.018026916222846117, -0.471509722065478, -0.11810715422874331, -0.10238402117707343, -0.19067181015277113, -0.291391876978384, 0.06947900724233416, -0.015242836647411438, -0.401348883753166, -0.45337748106898185, -0.1727901468865265, 0.13637973123806252, 0.12719935772661756, 0.36805901977976874, 0.16495040111629614, -0.2473570261338345, -0.27927228658126335, -0.3257178770435262, 0.00958906382015009, -0.3295365658810635, -0.21343066159796428, 0.30548875139716813, -0.11456720753471412, -0.33792700822652605, -0.12879564403204574, -0.4039175708864125, -0.056923488638827055, 0.2989251126558544, 0.08895645694966249, -0.3079635348075308, -0.3408701342915872},
    {-0.46620363757771277, -0.09950408111418309, -0.23330560994535202, -0.29476643206709013, -0.2434074191267885, 0.20103357868989552, 0.15982431223259902, 0.08691457951400382, 0.11055508173631619, 0.203115279207761, -0.16213035913570117, -0.3064177258386898, -0.203099126620291, 0.21273505490674632, -0.3944908925272606, 0.21534095389149516, 0.12945040865000143, 0.1133043907089011, -0.0377547510226105, 0.5318207877458974, 0.45856879372890935, -0.3453327124023585, 0.14818526436337043, 0.23658756447470444, 0.28982181240189603, -0.3434293826751225, -0.416518963520828, 0.11679275206159094, -0.02106841242282472, -0.24843273590457104, -0.29313349843566844, -0.16117213065003377, 0.21381605878050494, 0.34257086829060807, -0.37925837912024946, 0.23992134128243403, -0.2787393801066427, -0.36541611353915876, -0.07832766823149888, 0.07210182134031522, -0.016869556412567422, -0.44173471486590105, -0.47626294622037, -0.45584795418369733, 0.1394538424567299, 0.3611673349789149, -0.3011995513731145, -0.24970959569354992, -0.1734500754410854, -0.25730440148586664, 0.16726887714744348, -0.018814720235704015, 0.11655300649980369, 0.08077987145016807, 0.2255540773515026, 0.2812229923691739, 0.035934299760404624, 0.384052532725336, -0.515335100467822, -0.35652595639532614, -0.341641899498042, -0.05911485197373968, -0.03027113298981781, -0.39046785626041614},
    {0.08882193137178931, 0.21400562216063748, 0.399643054719044, 0.3171077634976103, 0.04366838214991897, 0.08310529678901601, 0.0045745770731404276, -0.4756623907058143, -0.01272609351131769, -0.07412402787386298, 0.18977419250355482, 0.3146839842936449, 0.03323078457906132, -0.3801533666549238, 0.18320463701631465, 0.10644224748900688, 0.14495064480376466, 0.08719426002756941, 0.0752127674081541, 0.37627392639043306, -0.18243512200035705, 0.2617300371423749, 0.013379192300431691, -0.20649433973218173, -0.33500165387554237, 0.011843504514895655, -0.5594700043224422, -0.1577266785182667, 0.026291361199806518, 0.06605655414149313, 0.11045739602908014, -0.13510115434290515, -0.30964843229367617, -0.20171728945104794, -0.4011115032884429, 0.36923292771716576, -0.1828566662592433, -0.2684374998948634, 0.35068080446155514, -0.08118568792183442, 0.02055799692852627, 0.18455021445062827, 0.25217368359029146, -0.24777583541507264, 0.021688900008905925, -0.0594703575591163, -0.38372944525171554, -0.22646931909136997, 0.19960845743847927, -0.3723114612396719, 0.11355003121012963, -0.24251263412897991, -0.14261779220301649, 0.3238402792970274, -0.14454382086694179, 0.0583477552909524, 0.250456719001371, 0.042502331714420076, 0.03782619598603332, -0.36493201549687254, -0.2061422501937494, -0.4345194155223968, -0.3572439355207303, 0.14490165267103614},
    {-0.2834668153033452, -0.23789717430376653, 0.36716949744238087, -0.13658738882375684, 0.19629500840244155, -0.06729489642092044, -0.40362353420797614, -0.1633864190426327, -0.02776546723362331, 0.06332336074009257, 0.13760000618114868, 0.5095854739419547, 0.31829780002760616, 0.046150105855920824, 0.17914394913954826, 0.3690366005791074, 0.16080664501982433, 0.11196639834613185, 0.3177131809769963, -0.3694903727525097, -0.5174702650379881, 0.09832683864497817, 0.44812449450818187, 0.16189545989583237, -0.2038693181501511, 0.09783275885476758, -0.41147561710369196, -0.2932812962393162, 0.1340942389574041, 0.0037825572531770095, -0.01134683853060407, -0.1847735813094348, -0.40788104740437264, -0.21627239922188393, 0.38709185515718236, 0.39605789398325136, 0.23829645227411153, -0.274236036277791, 0.1066742295188152, 0.14185992705295206, 0.35143292874807325, 0.370054809659521, 0.4459895727835634, -0.1858614764760959, -0.1553290720979442, 0.06340039920958677, 0.15815809363581732, -0.1134443595562082, 0.4327584349131529, -0.3120625792954846, -0.178267634122214, -0.5135831465745854, 0.33769289208435566, 0.11113513059851891, 0.3553084662474172, -0.22005340587717365, 0.22674739650635953, -0.3313899308296961, 0.45265104021887403, 0.13296981496764054, 0.3317843623831998, -0.08500868145593392, 0.10097749836575924, 0.43018117758524094},
    {-0.36502640694360056, 0.010113414593009079, -0.41896391744297, 0.19891004765017403, 0.00012034486293043559, -0.03414876841420267, 0.015906924071146616, 0.2191452467723597, -0.258858809267289, -0.4651498921685187, -0.018843883834471525, 0.1994647372674319, 0.09856215020097052, -0.08212812744818947, -0.034077870872153845, 0.43298734338730965, -0.23085148284414847, -0.2350780016977843, 0.09081196599073198, -0.2812447345236222, -0.16340359037843127, -0.3189776894614704, 0.425916316883689, -0.2514189245067241, 0.40372579453835666, 0.21271944154912487, 0.19073330562610777, -0.1329184957218223, -0.22614918581485557, 0.19584126917707398, 0.047569479380705784, 0.10834275669829321, -0.36650082996524647, 0.07865991605865427, 0.29504983928640394, -0.08797715870267603, -0.32857471931018345, 0.14320424034084744, -0.3319645327803599, -0.2628996330603501, -0.2664484043443739, 0.15452567944287743, 0.13201228923653482, -0.26398050776105003, 0.16634482371742304, -0.25237399628724605, 0.06975122606420504, -0.14160818886661583, -0.043169557456857806, -0.19449100830278895, -0.3503334664773813, -0.2635550090836901, -0.04549487418530923, -0.39875917992370224, 0.4438851938821153, -0.06987171857025468, -0.3809166199051327, -0.3340970314676147, 0.18650330267858345, -0.12164608051803517, -0.05782633942306605, -0.20318146837866832, -0.0032744438288834746, -0.18821061717149304},
    {-0.2734341113159026, 0.32983805493353746, -0.39314965297780285, -0.2189007823321984, 0.23743202221737789, 0.2577464628397004, -0.23795143847664682, -0.05544145723607695, -0.35356117288870514, -0.3144685959459019, 0.08568643189366575, -0.2005032642564479, 0.05951299269342236, -0.4278209406488067, -0.3191022166600329, 0.08603375217178298, -0.2842647898674248, 0.2710886960176501, -0.3514886094560227, -0.3132413107191893, -0.5059192414932492, 0.2422214894580733, -0.03754727391070685, -0.16692014198291946, -0.23516841582216463, 0.011191448564627622, 0.5551642675840496, -0.0915164740279373, 0.14226873266905388, -0.5178563969732649, -0.08653449801277067, -0.21568968450149675, 0.138550665988527, -0.05857555201484374, 0.2579534849222375, -0.4920153542872254, -0.08572497756125723, 0.4085636154345804, -0.2587726982426996, 0.16124203907785903, -0.08753895173235643, -0.32921842372098326, -0.034404491606705834, -0.4935497607963967, 0.04875207358441675, 0.1942761196439466, -0.0620159960818708, 0.09444679666602544, -0.3544836534141211, -0.4030182909122679, 0.4319573842028606, -0.3022608370312025, 0.3082281925673853, -0.039118988823661584, -0.07781696866386059, -0.0017969587606289138, -0.26914208651345933, -0.0014370985134980595, 0.3337587111846534, -0.13961304995227217, 0.07609120407149667, -0.1025412146638228, 0.2615777993659832, 0.1767288400397007},
    {-0.41993422787666457, -0.4161260542657242, -0.10426568062604782, 0.22345543827784825, -0.10514075523581029, -0.3796459043036736, 0.1267204067439155, -0.2871381804496094, -0.3097223895407932, 0.19292709950932255, 0.10687384315398811, 0.06654687130132561, 0.13619835816819467, -0.12409411179416731, -0.443132806668395, -0.3568546578147158, -0.1259418953035518, 0.079111967644969, -0.4415761053151022, 0.05000635600273685, -0.04891123325828425, 0.013478402306014008, 0.2282428785507128, -0.19055758323635535, 0.22655952727322734, -0.31552000220443377, 0.13611687337792014, -0.268664329206154, -0.42032599650724006, -0.0052495132627081685, -0.06469776270335917, -0.2886474277487398, 0.14421825226989946, -0.1829846392793413, -0.3413348811059191, 0.10040742390130117, -0.2896161314134225, -0.2803334553004387, -0.29026857255718214, -0.3685935110155735, -0.0004249404469145156, -0.36762702737232117, -0.43334043719163917, -0.1509723391042394, -0.4322753231211226, -0.27012893059192356, -0.028362840247167453, -0.0373217588131181, 0.13431169624242237, 0.045886500527142514, 0.35576526211246157, 0.34994903169268643, -0.0566881141425756, 0.4019096994799064, -0.3193125315685675, 0.49197672952111104, 0.06695454594712597, 0.05085617464604485, -0.3741227307195218, 0.25904066277767307, -0.19456667217140428, -0.005477903952606721, -0.18381022586595172, -0.3416549220379507},
    {0.20800851636261333, 0.005251182610409716, -0.3115075910214783, -0.3345130835627768, 0.05291615871445473, -0.24103934142818464, -0.14463316857872838, 0.39121633836284747, 0.27690666053802904, -0.21583110352061965, 0.1319249235661482, 0.06205291219999848, 0.09552184980289562, -0.2269965605450965, 0.10153216206343824, 0.30035485267944584, -0.16861643649256794, 0.1045564425174289, 0.007187311452494075, -0.10652407232586722, 0.29746688466231036, 0.15163422583332456, -0.32892191704641627, -0.33546246780032957, 0.365913183766695, 0.2536588329094069, -0.32572563688763817, -0.35961506007994976, -0.3386160947222358, 0.2965342345879619, 0.22748038578341512, -0.09256581589083993, -0.056736709263633826, 0.11466769668829042, 0.47160694829142236, -0.07952516544147974, -0.2019031561420987, -0.4128473985000966, -0.05759288861201191, -0.15706445571323463, 0.08713135503831197, -0.24492073285702903, 0.32709504320279864, -0.16793206660084348, -0.16776798091427925, 0.1884937950805209, 0.3061437367220189, 0.03774772837651562, 0.23552603239214134, 0.3125658405700919, 0.01010735484554984, -0.22940042900189664, -0.23610209600246815, 0.39443216816882637, -0.17945644857322968, 0.252727561964314, -0.14018666759507253, -0.11964209531664076, -0.11641781790869757, 0.06750412661724639, -0.06577489203528394, 0.06373132867492486, 0.07645801837839439, 0.04430058878561679},
    {-0.18731157840746815, -0.05279265062981517, 0.20273836259201222, 0.2126717735297441, -0.11275504674986818, -0.19706435910934267, -0.011317054956874602, -0.21721054323677863, 0.3396200821851892, 0.3037103464275276, -0.22784014038850392, 0.16961552497442647, 0.127085855152042, 0.19244858777280638, 0.3994429320542901, -0.19484860480579072, 0.042780841576210406, 0.04697763529392249, 0.4330227100605579, 0.19740343571466878, -0.30117552526104946, 0.057476734904307665, -0.19264380874411846, -0.07381236596446837, -0.024227916251339746, -0.18563579986406295, -0.3930398812755266, -0.2298193396631045, -0.320483902358434, -0.2527687483186849, 0.25976391004198024, -0.31512294937717494, -0.33885437828082204, -0.3317553394528471, 0.4680948461976525, 0.42147109782028574, -0.41509910365846414, -0.41882406242534775, 0.014814130277100001, 0.3671766357776314, 0.2958743347183944, 0.3456736486044656, 0.4255967209110632, 0.42474889636231705, 0.4121814131447804, -0.07540959841902353, -0.3575602981530486, 0.21665936565488417, 0.26428713531171705, 0.4617478494628442, -0.3905141236969146, -0.06356567738197844, 0.08669764597854139, -0.2274391758576567, 0.09886087337992332, -0.2355213236881842, 0.09421533524196651, 0.32599730420963435, -0.09944810983766218, 0.08204273703986727, 0.41104363168586483, -0.1754304620419941, 0.047196880438685425, -0.1479922665436297},
    {0.15803205608549104, -0.20539299544384268, 0.3517586785114577, 0.19070825232035676, -0.053337029090142395, -0.1481626213591376, -0.30675864112860074, 0.043147147022647526, 0.16036241061116435, -0.07838578663804353, 0.3285399708779775, -0.2653703517307831, 0.2386310221452037, 0.3767918217355826, 0.05955836523452826, 0.20772060881973634, -0.339420000463661, -0.16780533059619526, 0.008563210466694811, -0.29217424350043825, -0.31535110050252646, -0.4259807942480008, 0.12813569563350638, 0.06787266020830884, -0.038431842029464244, 0.15208017888405312, 0.08730053815749914, 0.0614609410848802, -0.33632221875457874, 0.23486890420026052, -0.3841396207376324, -0.027537510131882822, -0.002763859752857132, -0.20766271020881363, -0.1531923608827615, 0.03730804016012531, -0.10992004091874588, -0.40030894941287654, -0.2538850142604813, -0.0874863965778975, -0.3928891014966441, -0.06436874978021188, 0.1755820743275106, 0.20694039866887173, 0.33575023366576323, -0.5226983840356604, -0.030403548428991598, 0.2521770467748727, 0.34589667990655, -0.2401481265162748, -0.1335951316724445, 0.10333912208769062, 0.057549154825561354, -0.14079955006148065, 0.11528729232512447, -0.07549338559035168, 0.050810799084030356, 0.13085193674813922, -0.2591407054381861, -0.1526221983769339, -0.16295482910506368, -0.4523183565693497, -0.13828873537078085, -0.03205927550043076},
    {0.24594874166000114, 0.1538045350111255, 0.3733583007205447, -0.35362002593338, -0.2380006427806367, -0.13762529557909384, -0.39141975834433695, 0.14015052839185557, -0.17271879082719338, -0.09744079013508561, -0.0779013575157335, -0.1028439337324126, -0.18155843788150183, 0.04517769233927308, -0.25582991017047674, -0.23113492792963752, -0.019027712428294825, -0.20679685675524215, -0.033011888875680566, -0.15483069688770792, 0.09696448301019249, -0.1353418375117055, -0.33011342800778226, 0.4120350592053119, -0.35889424906632456, 0.42814464674048214, -0.2712968382449575, -0.1934273886707155, 0.34885133135872104, 0.4526813944041185, 0.22226524187581098, 0.3351372027935928, 0.07366023384016401, -0.28240883081790724, -0.23611177674479872, 0.3178721963525129, 0.16072017655710819, -0.05367559592290684, 0.1617466266102422, -0.24527193308895506, 0.18255563496787838, -0.06556527601822112, 0.24117661846836302, 0.20588427763325262, 0.24760368988756332, 0.2887447903605535, -0.21367533182588408, -0.061350427516354104, 0.38297746702760616, 0.04168714967121133, -0.0594830171779809, -0.16349406324653384, 0.1980374414724788, -0.3446767806949323, -0.32800867511728415, 0.14114360759587474, -0.0005229070543783435, 0.32943400995115274, 0.45111976584107183, -0.001562156587778396, -0.31140196508003753, -0.26991250576695436, 0.24049545474906783, 0.26343758594234434},
    {0.41534422437608987, -0.3397968368307586, 0.20832874682285463, -0.041858832350851645, -0.23779201698329225, 0.4121604055767778, 0.5361937981301703, -0.23424027124975397, -0.07920210996869123, 0.27811545923295916, 0.03756699308293504, -0.007207696692872516, 0.18874803122264305, -0.11371831352264238, -0.0026875484315675357, -0.2615010468205064, -0.032966340777231096, 0.23159722078056003, 0.4234594686736456, -0.10771225172160631, -0.3021724066965936, 0.4074593205471246, 0.04674033568461985, 0.35325995944318683, -0.2067718775359518, -0.1952213941130865, 0.03644483875199483, 0.47031341252237213, 0.3392814039338087, 0.16717795210929157, 0.3274995608084525, -0.053893892063051674, 0.20589437561911356, 0.03748751773866928, -0.13564993126616876, 0.07677237811585766, 0.4597844529650912, -0.030239575353682914, 0.09872127569576457, -0.39007816224466296, -0.08530412900681913, 0.4355989581403871, -0.3147535209683694, 0.40112968175701097, 0.07761247522217349, -0.3758027066242497, -0.22966610799705986, 0.12874341865283548, 0.27690456739082625, -0.07754198227331865, -0.4093726700483162, 0.049234785108943864, -0.031109385575257078, 0.17137937505849768, -0.29428667637439515, -0.3773536676691994, -0.035731525513375106, 0.1844088426465277, -0.24155838944397381, -0.013150334947781353, 0.054698520163426204, 0.33558948248982634, 0.211215494141223, 0.33138974475483585},
    {0.40447802042303793, -0.5001257688736237, -0.11937454410754021, 0.18457143152081237, -0.35253035713819214, 0.21285004516551578, 0.2808074931878652, 0.13596002731373663, 0.07018133413024973, -0.1254277648613085, -0.17399232143528115, -0.30085830859835516, 0.04626510803553419, 0.38609353840594157, -0.1713256589684092, 0.37170114908789975, -0.0790195354837913, 0.04777613145200676, 0.16985141158980624, 0.28580248240681727, -0.3376541454154212, 0.2935018201634804, 0.28759417271612303, 0.15987942957212464, -0.16071866150600456, 0.1244173901979716, -0.14639937822837037, 0.28838302854861064, -0.17272319572594905, -0.2463563542065669, -0.013357893628062745, 0.002273022058523929, -0.2277504389202234, 0.26687427220223564, -0.012838264923659037, 0.2489418581803281, 0.5347407341783792, -0.07697917809241633, 0.23220040415711915, -0.011528646035393665, 0.0027270082203095414, -0.2794272199987304, -0.3788291027199139, -0.40889465996176233, 0.1510760210923671, -0.2754371866802345, 0.10811373171569423, 0.024000179306673634, -0.045856816549344495, 0.2040105082527979, 0.4195263747569601, -0.0557532139870574, 0.18333732900688338, 0.2771540279611826, -0.08543540282909351, 0.043355504984558306, -0.456385835804391, 0.34729511763207926, -0.2837289494838014, 0.25595316049316735, 0.2270429458901952, 0.2136920612451486, 0.4109568164545953, -0.32057883007706245},
    {-0.2962773444549121, -0.14060203479645667, -0.2996663733842449, 0.07545082339567043, 0.18490520799636717, -0.10439552467869236, 0.02963721058978792, 0.1692367170444253, -0.3028817055678414, 0.2802287004786779, -0.029980081600883144, -0.1384222844346836, 0.0764433105750233, 0.21765979933448223, -0.26881656531601444, -0.3044068054088911, 0.10882699526687468, -0.3851176093866365, -0.21923965158091832, -0.07738960418409745, 0.07980575099798236, -0.20449032905760567, -0.30515137898666395, -0.04647581530787271, 0.15514949941904377, 0.16764469151462952, -0.45709925147335584, 0.15840589743377967, 0.13294344149925316, -0.15874529577992924, -0.2507208067359184, -0.10441116955264339, 0.09621260087659896, -0.26821437002032045, -0.11230525685763282, -0.06669684772066864, -0.07562502339946636, 0.27458685393605553, -0.04147850515600537, 0.3894182194787377, -0.11273934875646881, -0.2669260138777548, 0.4463246056088357, -0.010069586144807166, -0.0551074040095608, 0.2065444376487486, 0.4745589146560141, 0.044542488751467574, -0.4146876187328175, 0.28314188242598837, 0.4272799819898695, -0.14666205355794162, -0.008704610992036087, 0.3372793607950109, 0.3553258362623585, -0.0616552932486146, 0.09249674440120134, 0.47585086615758676, 0.06852917850989647, 0.34008229771478043, -0.33661650768389134, 0.2820015871612639, 0.21679573616119416, -0.2141317298782058},
    {-0.300960764231456, -0.02779311791489014, -0.32664449741854396, -0.1165352908063582, -0.08747767384926045, 0.2773161288029049, -0.09342264048891076, 0.0681364095493174, 0.2440352592269767, -0.37430928108937567, 0.25153307182903606, -0.203787183059236, 0.14280025640824265, 0.49410984287462645, 0.09158653929672608, 0.0615587171901874, -0.19050365793576676, -0.33158189572313435, 0.22791658609400664, 0.11713269979798345, 0.21896829300661544, -0.04897426370345302, -0.10249855094041697, 0.21904463613524175, 0.0751844933314898, -0.12535030821438523, 0.3989575226896636, -0.24418406604955317, 0.07574902893792926, -0.15502210739675076, 0.03434421156029084, 0.07142467981862102, -0.15391246874125813, 0.32211929934452094, 0.057751395554849046, 0.38392147857277215, -0.16691616053291156, 0.10161505692264515, 0.009326340175859683, 0.18991365760967208, 0.11865455834994569, 0.033730940681472296, -0.007631253149096433, 0.16707624482506772, -0.067878785883612, 0.07685572627418721, 0.054973327257586295, 0.1992229798161686, -0.34447695970892755, 0.10803553835967585, 0.09018157789311496, 0.40575967136097446, -0.01069198207509485, 0.12136432693996872, 0.39873792425529136, -0.15535064906812274, 0.5129277616166029, 0.3378546732012532, -0.2317971427749045, 0.07840785586738255, -0.24890225773648159, 0.20938318111828233, -0.018261232697007912, 0.2528814272731731},
    {0.29621089930054695, -0.1718044360002061, -0.36111130447032497, 0.10441382524651571, -0.09963368807664866, -0.47962550079130106, -0.3038248562150859, -0.16213769820080165, -0.3320181453855098, -0.11526828182451535, -0.2872052637062963, 0.2756850749110461, -0.18132953370155366, -0.14187626154203503, 0.4845387273651816, -0.05309462368476041, 0.011805001419191035, -0.2599460767431437, -0.39491577855650406, 0.17684858802937428, 0.22342588632877294, 0.06959338734839669, 0.1514815374336193, 0.27042073134123207, -0.2821819125294152, -0.5327332660332528, 0.024379610596934626, -0.30007765320502106, -0.027558318012392006, 0.0805851410597045, 0.36151867998799286, 0.23085928154591745, -0.3053355279181122, -0.35939061766139524, -0.4479817481556523, 0.29158029400241986, 0.2824059258710037, 0.1443282319650749, 0.23624849642333542, 0.2346284544085162, -0.15318836131147348, -0.38198520038211203, 0.1348160244662914, -0.10838332686514449, 0.22910264182439471, -0.25492939023166006, -0.437508948321254, -0.2121521257421606, 0.2703051928676528, 0.3735922388524062, 0.3628620710913725, -0.11355818310244958, 0.06013028338107482, -0.37306676245900394, -0.30471267983680134, -0.12628758474243315, 0.31517814829193086, 0.1619811439441631, 0.1189002515619934, 0.23952477526290628, -0.32700074947603136, -0.12061895423635945, 0.17923685127598027, -0.37456355420609194},
    {0.3011892395173409, 0.35787467187700084, 0.5210667188400314, 0.24884695438757765, -0.10779413576274957, 0.4515327292866826, -0.17748657736381307, -0.2734837029016529, 0.23467396036806165, 0.284062478224246, -0.13474855476100212, -0.2981836594002959, 0.032055598700321174, -0.14614282122775646, -0.3466787129465686, 0.37868867436656417, 0.24836178715913165, -0.22569481763627255, 0.23825592283742747, -0.10349426225129518, 0.30888338379924357, 0.11627727344413626, 0.00715669156720527, -0.04928513729066183, 0.4004554683399777, -0.2561644291746238, -0.03154406435513365, 0.0065090251120435896, -0.15269771616769806, 0.40913219545698465, 0.03919654769688956, -0.05793737091540772, 0.27097627745250913, 0.013256507987028767, -0.24062341533158424, 0.32317435063327626, 0.5241645528718631, 0.26996629917445253, 0.5008499694129166, 0.33240194525938616, -0.10416125126014016, -0.3017879822674382, 0.35821722785395127, -0.059452868509358776, 0.23290559477332684, 0.3628589552372396, -0.0953770597909039, -0.2786655324076032, 0.3600002753266538, -0.07323458886784238, -0.21684968324175036, -0.27340799017704237, 0.026637775646630325, 0.05780586970484161, -0.27521526502544186, 0.05859708643815099, 0.14766453251209644, 0.0810089494628239, 0.0426905116626169, 0.022166864557018693, -0.19807115226745264, 0.16610449199785568, 0.005103744219347522, 0.22614195400213427},
    {-0.14434140406371074, -0.14141374202238263, -0.141473943991006, -0.33912721819907576, 0.1500699701646407, 0.06478983102492646, 0.13312903836749918, -0.1600728377288641, -0.19466297835641558, 0.01759674570037107, 0.13108886819420015, -0.33855746724684993, 0.11578262974012711, 0.3419347514407571, -0.48955704730744104, 0.1774716588023959, -0.1581737443265049, -0.10035667776043387, -0.3425725693794656, -0.3703824319449709, 0.10812064863875921, -0.19538264202484837, 0.18251850577977627, -0.4161918795853732, 0.06418892861325723, -0.16888925990453899, 0.4447847518532753, -0.22383174484593446, 0.0647575602817186, -0.4397641629869756, -0.1661294742569861, -0.05823035055397854, 0.33953768427432535, -0.03627247237733462, -0.03191028673280624, 0.04087125016672101, -0.25409555133857376, 0.13334987808550153, 0.08769980163203833, -0.287679503253164, 0.27759072074426533, -0.3076587740089209, -0.3826172216217828, -0.19115759713511557, -0.1378949512357957, -0.2405821166579105, -0.337936437852788, 0.1995164263338321, 0.08204161965489182, -0.14142525262466046, -0.06840828599219027, 0.23842854615372563, -0.17896449535171732, -0.2673796686998716, 0.17034815099002115, 0.10059314879645068, -0.24884523781742068, 0.19884348957161843, 0.00810141620066492, 0.2419260634094301, 0.0751359242819368, 0.18593456519180288, 0.16054147194885188, -0.4172664145378039},
    {0.41694023312092887, -0.3371952409947055, -0.19528805668476987, 0.06155117669223532, -0.08146464159146634, -0.1147463019629429, 0.21454843588807476, 0.03187277249449076, -0.3384589115389631, 0.3626889371302386, 0.43151597404503983, -0.23748697239970326, -0.2232884079704611, -0.22594760977236078, 0.14081658068469552, 0.14082360087290657, -0.16751128888995523, 0.2023738114804473, -0.14734824591676446, 0.3180205205349129, -0.3148595496027483, -0.04533190762832596, 0.19663057841363213, -0.05922401696569783, 0.015512582917300805, -0.04225889194078335, 0.5135030125195945, -0.03870980748224838, 0.3542194980777126, -0.3933144862818716, 0.20098598963745273, -0.2572620372250896, 0.03906430729071299, 0.04946842911598563, -0.2447273187759232, 0.26861833521134304, -0.20216164894793964, -0.023982321430933585, -0.37468397433696915, -0.08440710230791096, -0.20243462131060103, 0.20340681999435967, -0.1003958010598413, 0.015758768618158846, 0.004962451834263619, 0.117998114952358, -0.10309022678023555, 0.06948462295791091, 0.3034429947299458, 0.3370739240989359, 0.41375061387814766, -0.003367400068129765, -0.22438048614219436, -0.11961619515544367, -0.1250112017572529, -0.23315970976120692, 0.3865795529194322, -0.2189034381156767, -0.2722937497247323, -0.27018085412089626, 0.0639922802629751, 0.39361735037137324, 0.35419263644091153, 0.14959077793003014},
    {-0.1365589951425083, 0.3759056363428625, -0.41663610934799505, 0.12358580692467556, 0.4878317685008754, -0.8740294577915035, 0.5066383706789453, 0.4584482631037863, -0.9391370800276717, 0.40524555836635245, 0.39746216165408865, -0.1734323087225639, 0.4954628547253224, -0.09888513237924254, 0.5304233964637701, -0.8534678354624614, -0.822769099321483, -0.5084081723298438, -0.36456240754527447, 0.4138667228642287, 0.5361041207916905, 0.33244525019559495, 0.09845525319400525, 0.14109140913872703, -0.2666080246873779, -0.8629055832509971, -0.7030611008211289, 0.4273333907820598, -0.7827195297057427, -0.22109362004776614, 0.15783477716948152, 0.4365741019777668, -0.6831763465269888, -0.9007528633450549, -0.30802789531708824, -0.06497251041134151, -0.04715638782012343, -0.015689320352883736, -0.7302539511721257, 0.37052112937401654, -0.874821558129939, 0.1789859773492813, -0.7263088624223286, 0.3421245425438438, 0.3617967861857511, -0.6586378999841757, -0.7474957494501268, 0.39695557358020284, 0.3926846078927401, 0.22151163645090383, 0.06781789387501976, 0.11873178731985207, -0.7987038873183757, -0.16857097062332385, -0.3770683477634343, -0.054080169343477806, 0.4092222551729023, -0.28644280953055395, -0.048954925057477616, 0.22333034580458333, -0.5602630155461623, 0.3947222705941917, -0.3183030493331624, -0.8723130752099361},
    {-0.5750174072228967, 0.3669372655145857, -0.5037328296148142, -0.000788956301684607, 0.2553751111308813, -0.8146067177865784, 0.1912116814888005, 0.44393437562983085, -0.9740618482112147, 0.6769283566349685, 0.6553059593923178, 0.1804586041343275, 0.41353912651957186, 0.11614477990120552, 0.43295958338516666, -0.4813152476205023, -0.8288052525059338, -0.22582540768387513, -0.34834276566191513, 0.3524121701366411, 0.45167166420040566, 0.15193340480050488, -0.4060893228552, -0.27808151651608204, -0.45330293007825406, -0.5308151798783312, -0.46850023346113523, 0.26082452246709154, -0.8962816216921645, 0.05695695082098064, 0.48936507976742255, 0.3885969641876919, -0.4682620165364012, -0.6246943762571324, -0.6050971376331831, 0.4797663561927615, -0.10955236746350686, 0.08516429393888038, -0.3173766500881786, 0.40944704694539635, -0.9659451560961086, 0.02239357360019593, -0.889203253039629, 0.3789946817603738, 0.38621409063938683, -0.42702989711972744, -0.9101182181082907, 0.5110962653667683, 0.49999686498711865, 0.22928645542900203, 0.31990029599096315, 0.5493890046024376, -0.5801594863966542, -0.4164030299840792, 0.21016135562357907, -0.08409045565145862, 0.5000763402500205, 0.07810172687355421, -0.6300048715799904, 0.30890201794217803, -0.5442981699739994, 0.5915052779648854, -0.20895787001686958, -0.6012494294269332},
    {-0.04623292722014935, 0.3340214279996846, -0.40532072165791155, 0.09153224830909612, 0.4290559674024274, -0.2715114300922718, -0.21142350919571645, 0.4258793596815256, -0.7497385276965902, 0.5474068306590012, 0.12813567879753598, -0.2662033654599885, 0.3366512232301813, 0.03718632080074977, 0.2554443381404545, -0.47669173471382276, -0.7343180367223123, 0.019971692989586995, -0.18792885570030377, -0.1906679827904057, 0.37432570522748204, 0.4703596360774204, -0.0918765475167824, -0.1438925638905956, -0.6336856446042035, -0.2598345849047835, -0.06290261180682793, 0.5667591451730682, -0.12045414451675197, -0.4787920999565556, 0.3724942461196625, 0.26999392762145713, -0.15837651868080913, -0.6909790073593384, 0.20571391969978334, -0.048050923030829085, -0.08233485245245688, -0.18283759181433268, -0.41716606162357434, 0.3584256836078018, -0.8446975747824181, -0.4090566711661295, 0.03978603217147355, 0.5122356587396477, 0.17381452662403196, -0.7128037770436211, -0.2507480869250333, -0.1473821121263294, 0.21922018590434858, 0.4964282495092696, 0.19621698890768668, 0.34553287368513846, -0.5712101388087193, -0.6255831164976348, -0.4109435372198997, -0.17606719977899227, 0.48518557561357345, -0.1302065837080451, -0.10815537405044297, 0.31347432734802316, -0.6967511152400762, 0.5247978925762958, -0.6576534593491394, -0.1274527571433984},
    {-0.1546360878819923, 0.31703597217951857, -0.19994547380918826, -0.30469834723264116, 0.4049329420980127, -0.28193358846788374, -0.1844203409587599, -0.009455532824076348, -0.17112895761448932, -0.06053769357579441, 0.23645800763408054, 0.0051198834742815, -0.02401918337547873, 0.03826057941444882, 0.5471128392798514, -0.10644482958879685, -0.6075732797436161, -0.19859105926921358, -0.08976703700219457, 0.13894507573621465, 0.579757139940282, 0.05665522307815347, 0.45644442168049254, 0.5880058551104994, 0.03818842540657124, -0.271867254817994, -0.537710323010087, 0.29535897580315573, -0.4669807794217839, -0.2707481398920689, 0.19880331450731265, 0.259036577594417, -0.1543688389866245, -0.2766459397467928, 0.3013425655723707, -0.30520470775722996, -0.2724742032882194, -0.17341869165218954, -0.6081758164413312, 0.11227001746708969, -0.3885678192260089, -0.5041801581179293, -0.14024184597114905, 0.5184027057804924, 0.040501868871512074, 0.0003458535316984536, -0.6421100012208654, -0.3122610434921827, 0.08027525203630428, 0.5950675403006884, 0.13056737759930234, -0.13553477778912945, -0.46845720565286003, -0.10462043045626881, -0.3411753798005445, -0.00847324225800743, 0.1695334001454706, 0.07585806583840884, 0.1545098639861648, 0.2933131964353903, -0.35864013078170354, 0.40755569271921055, -0.7074512360505308, -0.6229233418333754},
    {-0.10606075544598131, 0.5287147875881, 0.07097795372242403, 0.14168666693574844, 0.5042302689681323, -0.6196069415861453, -0.1053470948170552, 0.5041408505752208, -0.3593957382967115, -0.18781481541172285, 0.3242807515280687, 0.2928503386208668, 0.21813418872620285, -0.21747354006344144, 0.6154592560604499, 0.20904924425936353, -0.5021129897089208, -0.3495762110889338, -0.5354523527955074, 0.47577302815660305, 0.5640424893942481, 0.055781033608251825, -0.1935906013962006, 0.3568247957799379, 0.41685112621610615, -0.15405010927598453, -0.586221347879742, 0.10998758284308001, -0.6814008602333961, -0.11920536154687099, 0.12017499974802531, 0.3031088166640987, -0.29874674463473705, -0.20325011513675917, -0.30691188901011096, 0.458492898648873, 0.43474643791474393, 0.2003641705788093, -0.1347513168518311, -0.04411281916924344, -0.5409326926023246, 0.16009867401484337, -0.037731881196612915, 0.48699608113575077, 0.14707179563837425, -0.6765343535171902, -0.08064194221789882, -0.19049518738770607, 0.05478409491623352, 0.43147406417711787, 0.1592893704130167, -0.047947888465781484, -0.47060001567864396, 0.09144504616226162, -0.49455852363024144, -0.16645637228565996, -0.18407440351685248, -0.0044062753202142495, -0.23077936842842697, 0.13230172178177735, -0.4008832921719035, 0.2576090690380465, -0.6978599467420596, -0.45753490580274203},
    {-0.23906082319332497, 0.10340795586940138, -0.6021732796263248, 0.23960541474812536, 0.008045104341496601, -0.6205947342729581, -0.07642795260780917, 0.3368173473840856, -0.4252567083696709, 0.328014798224313, 0.34801115617248063, 0.3315401916226885, 0.3353727004754544, 0.47174493575477955, 0.01724180515303263, 0.008823791988190728, -0.3172585300706629, -0.31344534916216654, -0.42574554940341813, 0.5633594325163167, 0.4498098031152087, -0.19399039998917691, 0.22788445778825384, -0.1562727589938274, -0.12736608014979187, -0.1543195260687909, 0.13044281248473935, -0.017201151593107783, -0.4897140150024492, 0.08483675556715208, -0.027280800360425718, 0.6384885128446366, -0.2406187633444644, -0.6006032166857235, -0.5536028341924134, 0.3081354956022452, -0.0685723877828361, -0.5939453941563486, -0.702956041020223, 0.5769217943625115, -0.4173755593214269, -0.5096993050416959, -0.12107960656525753, 0.26702778839035485, -0.006844699799386704, -0.49587785721960487, -0.02365444089524605, -0.3055719019933964, -0.2026478357787907, 0.3734479723442164, 0.47017965605554, -0.24125667855249114, -0.6479644237063813, 0.03673988857423, 0.11239385635887322, 0.2851406737275113, 0.4745864574935381, -0.334839068773825, -0.3130635931622678, 0.44149972717850033, 0.08873613120938081, 0.16518750204447205, 0.12637717365591264, -0.15067692915600114},
    {0.18883580716849882, 0.17967132263253388, -0.35513047175010626, 0.47403549411669305, 0.6665468108303688, -0.26104582024263323, 0.08897759748750618, 0.021389234691105576, -0.12256045382630099, 0.4796460597169132, -0.18304617720027958, 0.3422685330869563, 0.41876897277253056, -0.010757488514819289, 0.24011809070607196, -0.3969655789139157, -0.08377360588358246, 0.021273154366180325, 0.11884321650919619, 0.40245130458089307, 0.5744392445532813, -0.061674915286589714, -0.16504440181473637, 0.1381430297516839, 0.33131896544100475, -0.28739056522057044, -0.2585068131187446, 0.4727350057502472, -0.19323130246367376, -0.5602631441185613, 0.4216162883399742, 0.6444228617188645, -0.3003804495464246, 0.18214199256547076, -0.12110561824488089, 0.0382839744257749, -0.04681971898290465, 0.47000519017397374, -0.2411857194428932, 0.21979283414333692, -0.6456056414335068, -0.2999077060641777, -0.3606443193666321, 0.02415169379679425, 0.1436273467911371, -0.40388620127467234, 0.0851745329335221, 0.27818327605777277, 0.07383784084612119, -0.0880605333281186, 0.10196544469624184, 0.06131277659445425, -0.007005499632753316, 0.06985034275940162, -0.21126084400610196, 0.5611186651585098, 0.7013496074989638, 0.44564404060833185, -0.5765518153248966, -0.05307511599195038, -0.09931457710462928, 0.584501668428585, -0.42575909802499945, -0.03432344389418449},
    {0.014743572112700866, -0.29479325951032176, -0.2946897613999699, 0.22275544339476486, 0.4464419178261925, 0.15888596271373867, -0.10721900110975212, 0.3476314347946831, -0.5275413047415103, 0.32256099159778273, 0.48954337180476243, 0.26700482052500035, 0.10123248202505129, 0.14462939053200463, 0.09616120166951264, -0.47023955942198975, -0.31857017464034987, 0.15709498492842902, 0.3620880048262978, 0.3233439340837915, -0.047895784020229024, 0.501859588390836, -0.15467300524654573, -0.3516274800412778, -0.27904333291708155, -0.537312127319425, -0.08386216421708026, 0.22715974502947292, 0.18944963006437934, -0.215319028173592, 0.25625317584794005, 0.22456409184336196, -0.2731680454923442, 0.182594931243448, -0.6502283655084448, -0.3104416189425437, 0.43788955124018025, 0.014692068640024487, -0.08160453146041449, 0.4365471630996154, -0.7445796005030083, -0.09431165348457965, 0.3616635575414891, -0.24449952689507098, 0.5223630278296109, -0.12986585743823637, -0.5235012904700296, 0.39571039806178193, 0.4840452739135697, -0.05658914658987293, 0.483440822108344, -0.3314551661725085, 0.14492484678189615, -0.14898138728817997, -0.22047458310169624, 0.16643156230195089, 0.13096748442278058, 0.255147185003558, 0.24109365134955255, 0.44002604877238144, -0.2586957312682229, -0.02012494042854433, 0.005347563888528843, 0.20100222259241884},
    {-0.35975213087396807, -0.10376245358700709, -0.3246035906483322, 0.5253926207708872, -0.3792350663398374, -0.3849002938525666, 0.40994441054066383, 0.4203024561767526, -0.03052964958955718, -0.0031324974891037472, 0.31266378737507267, 0.09920590567917556, 0.2426871166282689, -0.07654013009965432, 0.0628124519535566, -0.31695635533551375, -0.2558083730617945, -0.03706098612695381, 0.4129444057571378, 0.4812312423902689, 0.578320677794443, -0.26388032430343544, -0.4254638709076341, -0.38994908335895373, -0.02769437726042382, -0.35213967845611527, 0.16416799970387802, 0.5489929990952548, -0.3926495347260721, -0.2895031883894235, 0.18665451483916337, 0.4012834553944561, -0.4768447250684769, -0.5039843403091524, -0.457285210881923, 0.4970167837275819, -0.08933500745532387, -0.3967703659162411, -0.2087244255047806, 0.41780495015031816, -0.43453102964958434, -0.4581767392198962, -0.4925051552122904, 0.051964800240741765, 0.20457509410451918, -0.32219105461161, -0.1470330921163278, 0.016283237008891466, 0.381033722392191, 0.3178632168154385, 0.2004183363992934, -0.16259385435509596, -0.15002859898061577, -0.3444979537128126, -0.3303004769631075, 0.1924425027035423, 0.6815022446947696, -0.29890711914484547, -0.6259654866068466, 0.1701062963659167, 0.29335491649824413, 0.17902489046090525, 0.007708742299983338, -0.3610623177903445},
    {-0.1690297022734986, 0.2888308737837016, 0.2861930284314347, -0.1424635025195091, -0.5372849650308202, -0.5636391299681808, 0.06867372915881845, -0.03657709276554224, 0.02152260072574694, -0.16074870577887254, -0.5747669828885913, -0.47971770997274643, 0.26355077947168926, 0.1917566202464065, -0.4239351582446456, -0.32340158948052966, -0.18968997864496162, 0.2088615680649042, 0.23633574803635096, -0.14171289537778606, -0.2933892030977598, -0.30423451428828957, 0.2820823254515736, 0.05729283825099664, -0.016083805554301087, 0.0720883011623963, -0.09871875526179649, -0.30163449208837007, 0.23346265231416286, 0.18900618796588736, 0.42757604707958236, -0.1431791580318066, -0.4556084144997052, 0.23833480952147276, 0.27953162196632525, 0.027519842527435293, -0.010935218601863184, -0.6498818671717191, -0.24308972199374002, -0.32676963550608884, -0.23281359626331044, -0.6376700211938716, -0.27343194428601997, 0.29643220591237984, 0.0007359380303339395, 0.028457056700828362, -0.47086871439572625, -0.6442852877840691, -0.2066208564999253, -0.04486153508216589, -0.10110344811037733, 0.019416731680184072, -0.5636595505214436, -0.4011912375383869, -0.1180781622784678, 0.3311880002926153, 0.19735146360702205, -0.41076365955584804, -0.27540247307895316, 0.1701771870874367, 0.003019021701382416, -0.17523640599205226, 0.19889755584909224, -0.33937853506425564},
    {0.044360173791923224, 0.4413730724504702, 0.12735107226796621, -0.07147607342718641, 0.06895775414273615, -0.004830630577095477, 0.40646957840397835, 0.5297120849540714, -0.17940089856965158, 0.4999425338141175, 0.23864790917368733, 0.2895306080383615, 0.2014678761457017, -0.1137335398949603, -0.06352779266736122, 0.2735650582969136, -0.3028889973633071, -0.17838819399669809, -0.23602936138061364, 0.10986072073945255, 0.15978753271065838, 0.4883570141862345, 0.396568806488553, -0.17613180027269076, -0.4031818953615337, 0.20808156675137648, 0.169509109017507, -0.028098603579413167, -0.22048673540244354, 0.137575502192106, 0.5064090749476077, -0.0940291909771239, -0.4369296080287365, -0.009939960776244846, 0.4685084510789858, 0.19171649164061977, 0.3769169370019939, 0.007603959384152001, -0.2178443255346464, 0.17300249440735713, -0.333035476671397, 0.15902814859560793, -0.13232976737242305, 0.5991412074615169, 0.4750887648570185, -0.11785646524970389, 0.5523769957783787, 0.09072613973763675, 0.3585016513686165, 0.31711707626506985, 0.6809183916046629, -0.2668198119413395, -0.2384185346695601, -0.034646880922370095, 0.480434723888527, -0.44283046691785344, 0.06346140318323916, -0.4208178401920106, -0.13435569642317585, 0.2620061868135971, 0.08410145352582096, 0.3413536679815851, -0.3510903637623924, 0.13588360461336588},
    {0.10972861416924354, 0.03892455732027104, 0.30586804678306884, 0.24092629663371368, 0.49552535636143163, -0.07016467367179953, -0.026776060920740277, 0.2426958915727461, -0.1293985261732082, -0.0879683506116183, -0.20273982146544012, 0.5362011408937828, 0.21949581826771236, -0.15066967591665514, -0.35023206317756295, -0.156925631953254, -0.24035129849638168, -0.16666523791969282, 0.11458603650643277, 0.3317426688660472, 0.2869748473982881, 0.07761113861840635, 0.06723168994102899, -0.22831297468519857, -0.01269370849084528, -0.13958913794407396, -0.189923778926364, 0.06350690318972288, -0.1852941725485841, -0.24113955229722311, 0.1250596348967287, 0.2725128355477043, 0.16732177754657895, 0.009088715072432392, 0.11001032201731539, 0.5678056332233297, -0.13211992018510293, 0.08639867660366546, 0.000713301223118836, -0.14735250277651027, -0.04376499361691601, -0.5210756177483354, 0.35124086902586443, -0.18784508643562428, 0.3631865192689152, -0.20042619282195573, 0.09841108076022213, -0.44473879817388107, 0.18864853327247263, -0.30158390074750563, 0.2307086273339605, 0.1685685988835854, -0.02942330355431603, 0.22932761327037074, 0.44513765702691316, -0.24094010074082042, 0.3201028956767482, 0.3804388972401157, -0.06063639699360112, 0.29965133545687755, -0.2817592539371883, 0.4437450248150069, 0.20063895799987624, -0.2869350111746219},
    {-0.33746882093440395, -0.22422676463715513, -0.6217494878310652, 0.27042869553291216, 0.21412862015611736, 0.12225708171146145, 0.1451539749322412, 0.4136912867537748, -0.606395697328838, 0.10504844061314954, -0.19236324883009034, 0.5542087900586461, 0.5376008971264608, 0.029618906928400277, -0.06776303713352479, -0.4107016613681653, -0.06197423453351538, 0.23049996589302774, 0.5203687403816356, 0.12703597521423235, -0.1384403885458429, 0.29228367937380334, -0.5310411844083245, 0.10566042627979899, 0.25010457015412707, 0.11163155217217464, 0.5230526044619082, -0.02284875343258274, -0.011802822120958333, -0.40675049771808774, 0.5321137460181806, 0.47531251471766917, -0.08689340768665456, 0.2573401445945255, -0.27669987207989805, -0.1273588953286792, -0.48699702395411865, -0.07329378774249341, -0.027314459551303943, 0.41247672496689025, -0.5383618662483816, 0.40430361269975146, 0.13542231672463959, 0.42962571194797056, 0.07994487217745738, -0.6622851118142693, -0.28552045368248424, -0.08635340689598457, 0.37967600142891456, 0.17821263546578553, 0.08361331323922164, -0.17117700345103265, -0.06663004119916946, 0.04453687016551158, 0.25062406586695735, -0.1566468286879076, 0.3959124052313913, -0.20935215181311523, -0.5437137387592106, 0.053143107738135756, -0.09877433809173408, 0.028248479776398504, -0.0001276496782773121, 0.3174616943161018},
    {0.38693293058649847, -0.08642916946755248, -0.3392070065100331, 0.10419698236015475, 0.09607350116429024, 0.33390959474803805, -0.15888226757306922, -0.0569156432434705, 0.019941399420558406, 0.20145443291118886, 0.4385257777103692, 0.02229075378323464, -0.23649598413969378, 0.2986634248869835, -0.25752923872155825, -0.508814294816794, -0.25585937230525485, 0.19122851315798903, -0.03572062215816463, 0.07090070622559869, -0.38815744727648605, -0.11283469940745448, 0.2688789449810188, 0.3769699476602592, 0.062345537984215424, 0.23197373062161536, -0.3098817102951157, 0.19866838535288509, 0.07338019155884257, -0.4149801972204489, -0.03407306734667657, 0.37326895304697466, -0.35461640155713875, -0.20648522420954665, -0.05101015014509585, 0.2886479640676622, 0.22308491291062535, -0.29902341430438134, -0.3715318119428075, 0.24356340601734905, -0.21600791311264803, 0.3021059077654014, -0.07655096355174057, -0.1156990931947864, 0.14607751408582545, 0.1221364467860575, -0.2032897975915192, 0.2720488414561856, 0.5363341154828039, 0.1576035861744409, 0.013912365771182315, 0.3291478940781767, -0.03688522160956681, 0.2159586498656536, 0.3617439575992962, 0.22300283543880278, 0.3906094456206157, 0.3988235964382771, -0.07360323420501141, -0.030383191935118178, -0.3486893424315224, 0.16101185422152367, 0.2807780947527893, -0.06538170867549233},
    {-0.42173170774633684, -0.3648464484282794, -0.6006240341883092, -0.13777397197500754, -0.23932953711904065, 0.13218735366160894, -0.24786067571060985, 0.1293392427019862, -0.43226006886800916, -0.3570436058779112, -0.15190936617211329, 0.23066815134533283, -0.15433329687608355, -0.1984836331533226, -0.2936117036561466, 0.32422375426739, -0.3288101753956271, -0.3751755642834508, 0.018686452191466866, -0.39918928651884344, -0.16209495784932548, 0.32987223101805374, 0.4547931741198642, -0.288032347165872, -0.5612918682517986, -0.5062091064845708, 0.26927095771401305, -0.12114339229157213, -0.25785873923293884, 0.10057006712563807, -0.15044411968487734, -0.03263006082487135, -0.6042821512977262, -0.04465366103039924, -0.13094737644627397, -0.1879789119496669, 0.43637622675866383, -0.2879922784160548, 0.15079931549256398, 0.20502268585932054, 0.08901777849459983, -0.4315746988094658, 0.42478408591836775, -0.00801884392443284, 0.22334852239994657, 0.11732539850849531, 0.09753213677020035, 0.2972377931091625, 0.349223325173634, -0.2614348790359707, 0.45453399721743304, -0.3320733679547128, 0.35881393472089207, -0.28990358270584243, -0.4083603656588108, 0.1338047825496432, 0.09394086494811801, 0.3126423715433346, -0.23671501208270723, -0.2913691685773967, -0.22489898362373636, -0.32923163116287396, -0.3796355215445174, -0.12239374880182655},
    {-0.19243335275537704, -0.03447394631423388, -0.6027253005133598, 0.020768982223322484, 0.27508906482344836, 0.1208876103605715, -0.0948755071319995, 0.1035238416708879, -0.25024693616810767, -0.15265145593605375, 0.23533231781221994, -0.28463433985076, -0.09128014697833081, -0.6096030135207436, 0.16722570492052816, -0.6661457523858411, 0.24258742008570539, -0.12566210705709177, 0.06833497436187795, 0.1481484948593106, -0.571586156470773, 0.46602471285675806, -0.0515320374690568, -0.2653591474670168, -0.5195180402753296, -0.679166405877809, -0.006205448801684665, 0.1290333353896186, -0.5322841832621875, -0.48264957969701217, 0.13051468797448335, 0.25854283056919647, -0.6014490551465248, -0.16064552363299603, -0.39074090459429217, 0.1819065858917862, -0.2176583925034467, -0.20577861367105543, 0.3006379998804385, 0.4278152480703475, 0.047647179461361044, -0.26837142064482084, -0.2989125042336638, 0.40769069837349053, 0.49315351392001494, -0.7731445676038013, -0.04639093122232998, 0.3925680629033853, 0.23343224429477238, -0.01347410282049974, -0.25408995977189264, -0.29994381112572505, -0.19816502543718492, -0.2637072384568998, -0.3554908526669913, 0.011015675200013926, 0.23933517634969984, 0.16341959378742657, -0.4447771596351321, 0.29107290875790853, -0.09158697341211536, 0.322295398850867, 0.40354456203044553, -0.17840077139495772},
    {0.01336397725274981, -0.02265703554040138, -0.47049926142388354, 0.006929313475978951, 0.08834070233939238, -0.3196989910140322, 0.25835232690127413, 0.07499948665213546, -0.42918263270799184, 0.3033626497979905, -0.3056827890778082, -0.29175753627996676, 0.39622738495626564, 0.23781907964369883, 0.0782127559194684, 0.42058488409715045, 0.007205864635715031, -0.4097493706887721, -0.05816820174917825, -0.04528300026264641, -0.1980864591760072, 0.3131860087078137, 0.060389032712250545, -0.3486984530199476, -0.3004626545705947, -0.23049072485834268, 0.18632692137024653, -0.1819378821570227, -0.13417282097169106, 0.2224891168194067, 0.04765348014458376, -0.09837944649822468, -0.5312740480500443, -0.45102856874033265, -0.31057179576785265, 0.26533994665290117, -0.4251350805628298, 0.30155472313837445, 0.18752272246113427, 0.11998438098317454, -0.5337512573758264, -0.19376432219957987, -0.31063564739570737, 0.39373626307836573, 0.08735596963743883, -0.664525950346508, -0.10789483578541956, 0.19616398616861072, -0.3387063032481442, -0.22586816777084293, -0.3184894704337428, 0.19659626635389763, -0.21283461569250736, -0.15998033252994823, 0.28753407616380217, -0.38115418484267705, 0.4122753584985352, 0.3304313573269477, -0.44924957672226823, -0.15138723501827472, 0.0574819544093819, 0.058236365307642854, -0.25386798082288536, -0.41789157804893867},
    {0.24696998715734703, -0.337539363409083, -0.31476453382587216, -0.23953711372927353, 0.2088105620921294, 0.031443917474209056, -0.06055614077956954, 0.38476563252756957, -0.16092216037854934, 0.15726904580714812, 0.1873928633453094, 0.48620602873301655, -0.17294765336348483, 0.318336434836725, -0.08308475228554045, -0.09307678015249236, -0.2252312938075717, -0.019982093801281388, 0.060780869589642454, -0.21328164133923336, -0.3962337851907117, -0.19643058757699366, 0.11834366118310968, 0.00010027629463927287, -0.13446525308985402, 0.04259379198764033, -0.018479680468528513, -0.04056531196434351, 0.25120519941153446, -0.009773788470071038, -0.1422246619634513, -0.38118543486019973, -0.20863629917254292, -0.11331983118094151, -0.08785597905171973, -0.07983612079379707, -0.14612867079199007, -0.21225671017378867, -0.1700382828278748, -0.05954863757755173, 0.1295627068485758, 0.14790535617145653, 0.3905151798040481, 0.3999172151136066, -0.4039888103201628, 0.09356491543790106, -0.12837447626570145, 0.15559638776460127, -0.2153144412052518, 0.41090862916302573, 0.0018037830730338448, 0.21331132832593022, -0.4957539089906702, -0.2624932676676089, -0.24853523871209696, -0.07319896239402268, 0.2927455763016496, -0.3010615567143527, -0.4621361465090234, -0.12281128111961263, -0.5429005751886409, 0.22223823561017655, 0.33058048105529975, 0.15673373929044188},
    {0.20740178945822743, -0.503719796370486, -0.3194937393872116, -0.29846696107143966, -0.39586038156968734, 0.10414208981638937, -0.29552588428605076, 0.08246749986640108, -0.27155660965248335, 0.1792924643404924, 0.09944113672321377, 0.17872608050768907, 0.5509600627507009, 0.5206926838026075, 0.3507649180560063, 0.46528205629855046, 0.01690829314418653, 0.17952166270613876, 0.09559432963062375, 0.20088603963811574, -0.37272691953532366, 0.2901677423753846, 0.20607921329088122, -0.021634109842091857, -0.49703333734913757, -0.41206509250650103, 0.15195026508444487, -0.30881474567989003, 0.18107626317163814, 0.21799797517342026, 0.12744379329589514, -0.1653595190345193, -0.28971333556424383, 0.25045798669964475, -0.3757397481842837, 0.4448321046793247, 0.4678567190006413, -0.03742600304744633, -0.1340007663500632, 0.21927492712219784, -0.4908250214673481, 0.2820676196398301, 0.5148903353481848, -0.19241052815527945, 0.4152764285099692, 0.448994316459227, 0.32446168565488875, -0.2873971811360544, 0.1259120178337193, 0.3680779823149091, 0.22128565808321035, 0.07360295992020403, -0.18152218078050483, 0.40327531473164585, 0.31026267511428984, 0.2878150402528647, 0.001588373494357778, -0.4295050516060332, 0.31589574380128504, 0.3693543726514038, -0.13137984398605418, -0.04516071629431846, -0.38148335629699387, 0.2074749264220581},
    {-0.09032559775810907, -0.07255406951424634, 0.07043450939604864, 0.017833373392408678, -0.26154662664632977, -0.4413849394820963, -0.2525712008776763, -0.08481137769457403, 0.18279686696912323, 0.07561598401521359, -0.29155647421098685, 0.5367203171716511, -0.5213196324462787, 0.37289313647515526, 0.15888564195486832, 0.5041529062370379, -0.17411410230768357, 0.3754734538317242, 0.42750886645437525, 0.39387593962561757, -0.09390041006906702, -0.4372027670916539, 0.7251568566516751, -0.12325672559550105, 0.3495526316400631, 0.22034912576696356, -0.21836066591031872, -0.35256965158639136, -0.016331887561110633, -0.12917826225807447, -0.1350877310944906, -0.14758960133669213, 0.18662391455805394, -0.19447780883340607, 0.3051514322475644, -0.03896133637338232, 0.28600606016467855, -0.33583892913556607, -0.25208896926739566, -0.5773024464104944, -0.06211108752404442, -0.4408797855863748, 0.2240634345354881, -0.16701974695878505, 0.2923624621209269, -0.1624426939836854, 0.012550743689334525, -0.11803580343994521, -0.28103459406002707, 0.49071582894789295, -0.30308779218197435, 0.48221775318784926, -0.39778237186512466, -0.5119287692190319, -0.09693901677627124, -0.22688556734930718, 0.006251703112289936, 0.08737967340572657, -0.5057460346232807, 0.08094659571258617, -0.16367102380940218, -0.16680282111058542, 0.12423085181810424, -0.008403891697337408},
    {0.05699621384278409, 0.1574769051128849, 0.19188823539937305, -0.38657823195456203, 0.054825004709610416, -0.39945846463404633, -0.10605602880094564, -0.24933837471110593, -0.009882377978321569, 0.16011143986628792, -0.30392075306024324, 0.5134303619753705, -0.5074965846811426, -0.2900670305849422, 0.5521674557081184, 0.28680022980216474, -0.45423893839919244, 0.3279198124415662, -0.35739380483432925, -0.11943060534108822, -0.4980955999207137, 0.012748392703252594, 0.14296307019923804, -0.3233646428773699, -0.2541392367297006, 0.23712636898849665, 0.26537501802225943, -0.5583262569168748, -0.31599728907886016, 0.13076139067574066, -0.14113601566148984, -0.49443991714869723, 0.2993913551656447, -0.2155217715854542, 0.41919719563767105, -0.26784180966039667, -0.6316912676722395, 0.10776966616697659, 0.0788868693788324, -0.5204042480264031, 0.018025836480344403, 0.11451847618063965, -0.4190027278466769, -0.006541384545630649, -0.31373328091548647, -0.12094371543601103, 0.03948655817383276, -0.046007793202093285, -0.288214342051689, 0.13946013920418937, 0.17862544557076837, -0.5768920999317663, -0.15636532051436802, -0.032543422518198396, -0.035521745134098316, 0.20113941117005762, 0.03333889478344491, 0.22384108305219547, -0.6375113496623536, -0.3414525147314612, -0.3594024532308925, -0.029161036762107868, 0.14773321402205594, -0.0805863938371858},
    {-0.43630604439951787, -0.3221701414613695, 0.5539594001007667, 0.14538011729028225, -0.1820341673888296, -0.41306560512198165, -0.006921671870567163, 0.08964009833648973, -0.13427993496833218, 0.03503900184386987, -0.16244511600450665, 0.29959254696655346, -0.07391723032635049, 0.3170856938033149, 0.3469150000014898, -0.2820665268016037, -0.4544161444953182, 0.33479470527740707, 0.21943177262085423, 0.17287775797916893, -0.07888646427736917, 0.10571604135945828, 0.4700465544849252, 0.3407013425910743, -0.3956328082646998, 0.021368491146742177, 0.5261700344594626, -0.33942828162909716, -0.3902640197633474, 0.09732840943406705, 0.028276941794213296, 0.15996151294370084, -0.14000990318982742, 0.0877971944753421, 0.48849857316072204, 0.08045818042580304, -0.13012383503028743, -0.13762623489613396, -0.2946164907262138, -0.015687553616707525, 0.3182759590817681, -0.33254719841602215, 0.4536603448907588, 0.25784436399995403, -0.18706575531475125, -0.18823329664483868, 0.15147352593932062, -0.3728812308217214, -0.20104229087415879, 0.4657786072344249, -0.37816779247783333, 0.18213034602608286, -0.26682256812589394, -0.17781682656143044, -0.2833407605281523, 0.20686216475145605, -0.15456526392676817, 0.3567605894449597, 0.4149946638058267, -0.30275228750262995, 0.30932329116961577, 0.15754917033864985, 0.1821964699600812, -0.006225938184590094},
    {-0.5230502029996461, 0.30974961587099925, 0.23068353578586143, 0.09341967577617208, -0.14212599202992332, 0.3789925790155276, -0.2659715193764938, -0.0862906887249629, 0.14794349725656694, 0.32542471550169627, -0.4027129080873342, 0.34201916874040744, 0.4892167886958607, -0.2524980507047403, 0.06535462866180486, 0.5320953875163437, 0.13482117686241074, 0.29595079219244086, -0.35330205405114024, 0.3027966681633386, 0.026839507588490016, -0.14746476600284927, 0.49820901625435193, 0.1358811536946673, 0.1938077388674363, 0.22580098560469158, -0.31300504026593445, -0.3651958068765241, -0.36981431816391636, 3.133591873061637e-05, 0.0911054252403155, 0.387590269227891, 0.017045940046640232, 0.04006262997900703, -0.37117664084125424, -0.603511189874669, 0.293418313523375, 0.26157520839194054, 0.08980107162230538, 0.3072960701160544, -0.4853882178933315, -0.2250077291676701, -0.11937813830751785, -0.0898453996994876, -0.11802455300139533, -0.0008877186291398945, -0.11194314791114318, -0.0614769567948191, -0.1509271187281782, 0.22426489519109225, 0.2991092988060724, -0.10450626482963751, 0.26251225543305684, 0.14545219511659357, 0.3700618091035902, -0.24718416931163203, -0.12368483386607261, 0.42630348354505654, -0.13608091050411986, -0.07527377044983581, -0.46978985626303443, 0.2672890775557466, 0.26683689398690164, -0.38389481025998673},
    {-0.34695078167652005, -0.0718731872697726, 0.1984252889834637, -0.5089555474493982, -0.31409047280005264, 0.04775563952250025, -0.40850914728079113, 0.015008111386547092, -0.13774149460540897, -0.32188650777853073, 0.10759842212580185, -0.034275539666909, -0.2946684782237533, -0.4556425442058616, 0.2672289431021078, 0.4141929656243874, 0.037496253220705725, 0.32352097156776277, -0.35068917462881244, 0.07638731601954331, 0.3517322551231707, 0.2064340465052044, 0.08874610725490498, -0.4138862616687155, -0.011103512695006472, -0.11687600731340723, -0.08846999792922892, -0.4876608431263253, -0.2430653667463291, 0.253794747596951, 0.16361410917362088, -0.0883752780952235, 0.2345381493161344, 0.17594066045595005, 0.16043108780033724, -0.1754236825425688, 0.27130458820494874, -0.08286484581248356, 0.10175953126627271, -0.02945921644623145, 0.09808936905382623, -0.5816746952539246, 0.07790236251448192, 0.15854440934351754, 0.09453271520593777, 0.39818216929011124, -0.07591754457270103, -0.01752598711403052, -0.4110313564007897, 0.03835907176253622, 0.01169503370366297, -0.23549941942917627, -0.297778116048822, -0.11530838027427902, 0.2898278785447127, 0.2510998114264805, -0.37238826744979775, -0.35040232517520487, -0.5650663506364059, -0.33561646622120717, -0.41002127898658736, -0.10562899925293767, 0.18414271894459067, -0.41693887005113045},
    {-0.09250564766120005, 0.25513502648323083, -0.5402112524456782, 0.22033732533055042, 0.17919637433359453, -0.15009478208326274, 0.14704430684567546, 0.1474593032094193, -0.4642999835390149, 0.30389091665121387, 0.24826065809660172, 0.1295181994016993, -0.31502159162776455, 0.1274438412209573, -0.16779935088569278, -0.29376830812261323, 0.08528047487971557, 0.23612643899997415, 0.01644535060791764, -0.29539907594961, -0.26096346691430594, 0.30832941159960464, -0.08614068883985539, -0.38427708508736647, -0.8182401427930862, -0.07136315529478078, -0.24409817011094037, 0.18502269985510272, 0.002407017261870068, -0.023475564717100023, 0.2888032302933495, -0.12129733253246325, -0.4674796137115978, -0.13947459207793328, 0.5191928822829659, -0.22164311784808416, -0.524849176148318, 0.4595459716991958, -0.030162942459206355, 0.3302719236925987, -0.592326339800653, -0.008126963247800649, -0.393325787785026, -0.6130083782919564, -0.19641796511316573, -0.4738165825597554, -0.2773654289328286, 0.34112625194249235, 0.364072334995251, 0.5485179658106807, -0.13922658811456118, -0.28771608622592465, 0.2671714789413039, -0.40207980516942615, -0.03201881509785456, -0.35508036753280675, 0.4488770809682982, 0.08270644807686536, -0.377086343265089, -0.0057630719906113445, -0.33039814359501385, -0.16296263705137234, 0.011087565088800192, -0.22401336569609118},
    {0.28029429278800544, -0.1200488033782988, -0.31930263596051883, 0.020749758107320077, -0.20881853208801282, 0.402467450823579, -0.3616190400673924, -0.017239962333702483, -0.2699749013823059, -0.5668835313032492, -0.02792368127515575, -0.28101267154315673, 0.46924697315787517, 0.41503285878961554, 0.018194845670656865, -0.24713761282384786, 0.05083437144384907, -0.09947777293748662, -0.028689800216131333, 0.0034728726841676593, -0.4171580113429689, 0.29641415201453414, 0.1447868463274644, -0.3578208869572066, -0.07271794165344671, -0.1300908778295206, 0.23571003246785632, 0.009529332088922192, -0.29296933976160044, 0.22448124365597855, 0.1375075390468216, -0.1908432340982905, -0.15859474613990998, 0.11723193387073409, -0.22323125653673648, -0.09209006455781896, -0.16197574253620525, -0.12216718999163104, -0.23923922296560743, 0.17156769456909643, 0.15766801872090197, -0.14651265975748556, -0.31272981773889796, 0.24370366545778288, -0.18357101174816265, 0.43633024574713825, -0.46356966330875204, -0.20706066634428336, -0.07251475864672306, 0.25692992136450377, -0.1424785340049429, 0.1215944181607681, 0.26802018610730843, 0.3092870007043164, 0.2761635960943363, -0.0664293769682875, -0.18699114332181418, 0.3391177135678541, -0.11698129023487881, 0.3339559512684699, 0.2652889672771134, 0.19128629433495378, 0.28371843511312944, -0.04479033000169174},
    {-0.08008909770430188, 0.27672638496657037, -0.1573879862231652, 0.16082020180819487, 0.14083653285755512, -0.2379455164641077, -0.1294734701303571, 0.22277734321781723, -0.3143554923985022, -0.1772221844438374, 0.38211342917973795, -0.014252500656857249, 0.03597837657335583, -0.31338947835107944, 0.30539794620315336, 0.22159428557593572, -0.510922606009336, -0.19599097803632112, -0.14905708904308515, -0.4741988483399952, 0.5716404105327259, 0.029886189460079825, -0.23927699880230083, 0.13517032555117364, -0.6503233697445794, -0.5133297020648158, -0.13744615437192545, -0.01889696490384767, -0.12082916185617146, 0.007704656986127232, 0.4293958870650574, 0.4974695821707493, -0.4362528211435074, 0.04476373477540685, 0.07763232245415781, 0.41213224404977233, -0.18571286478073698, 0.035342415179969375, 0.09283252708973776, 0.09415872504537387, -0.21652394477887976, -0.382845159712798, 0.08016989141435114, 0.3332451932250603, -0.23589099333441552, -0.3185986112439779, 0.04480942353850522, -0.023616889498574607, 0.3896064846924105, 0.18932665866196488, 0.08951647081348929, -0.3362323322403667, -0.11105048553964163, 0.010641074847965514, 0.07550084748329973, 0.190188775236474, 0.48049067527766176, -0.20405594743433614, -0.13064213417583037, 0.255566328856233, 0.2738638385492728, 0.3475375573829336, 0.17983682498488873, -0.22377628207796507},
    {-0.13638768460878256, 0.34673334251545335, 0.42375664434473176, -0.21752115181745818, -0.21788886630086632, -0.17380130817355488, 0.17722382265838327, 0.17409120632864555, 0.16521424261712156, -0.10572561377577577, -0.22972704129741411, -0.2829402613157459, -0.18397478402550516, 0.3366995214152572, 0.12811382033844873, 0.2830164054373436, -0.3912469858570098, -0.19214832285973804, -0.31563043962794746, -0.2652347633879608, -0.12619663253929353, 0.032320149249643076, -0.11693377967902968, -0.13449455618270356, 0.16657683904051665, -0.5182905437981294, -0.056731118792120644, -0.07082188708888396, -0.3872583043149306, 0.0069593026220245, 0.42730676887768787, -0.13742896552538417, -0.032656165346240086, -0.2872314468223332, -0.27623009438448864, 0.3592692810030676, -0.1107082393408515, 0.28662133033522946, -0.5863530147603602, -0.2129854542435519, 0.3673562231272016, -0.02466558321844552, -0.3112818788550375, 0.19858828029799647, -0.051994016932925845, -0.42270252560351856, -0.19674860627087837, -0.027487885879761597, 0.26252965479670914, -0.08500628652924609, 0.19755524822082848, -0.37521389416768713, -0.46529299470206353, -0.10335228006031555, -0.02911661575654049, -0.26698677942506194, 0.500116031682152, 0.3289585113826195, 0.09307273132849408, -0.15452655786139702, 0.13940119601295742, -0.18980636074258236, 0.1750332643069612, -0.41006807275182044},
    {-0.10706701394510779, 0.17107872096505594, -0.08320171069807937, -0.24672640386639094, 0.24657084638411708, -0.3268173024424496, -0.19335732401324557, 0.2269105734286298, -0.3655503883612036, 0.06769396883039004, 0.11023960544805361, 0.49691064050098577, 0.15824072086110624, 0.5413718526384966, -0.416964010658147, 0.15497296036108807, -0.08411897648252496, 0.3168773827680629, 0.11194969579836565, 0.2955438349242688, -0.3262637866207742, -0.3185903528973016, 0.09733137622735778, -0.1996887008057387, -0.3503381811526309, -0.22955919511327966, -0.31722735554362297, -0.36651842312107297, -0.03931164105141274, -0.34436483389811207, 0.2988631025478879, 0.42459886395982593, 0.1787101787288517, 0.0004463441333760353, 0.07907127918460506, -0.3823718135038076, -0.4802184290277509, 0.3146158979622029, -0.28284767482331774, 0.46824793432632517, -0.0747927126749653, -0.07046138264360478, 0.10307278725178581, -0.10434082465770793, 0.029389496160919973, 0.20342173773741234, 0.10914072561373647, -0.08960985154250938, -0.10641561813275503, 0.047765072729150274, 0.11442753651519236, 0.43130239345796073, -0.08186797777833195, 0.2105913801757081, 0.4732009926053823, 0.49975776878466266, -0.2817980473177708, -0.28786100109699675, 0.07554755058502864, 0.43768383684399165, 0.03176396410286145, 0.20503398302648118, -0.006373009322787481, 0.2067671148010479},
    {-0.09526276578942594, -0.1546742808558209, -0.592944869580565, -0.11737069921125061, -0.2168580893126642, 0.13668189176134157, 0.11762949551166378, -0.1610802827260575, 0.03466966036585853, 0.33182520677649485, -0.34963203966504514, 0.027813944105331837, 0.3540221549934542, -0.2406955597704103, 0.10230330206228751, -0.13606799729334862, -0.17574287695865165, 0.4210472998301768, 0.38149087137895504, -0.2786657701174279, -0.3273020484702422, -0.2950435272057165, 0.20362818237756972, -0.07574652708363983, -0.4657202643409992, -0.2988731107312974, -0.2983679304639956, 0.2302401602103429, 0.05397653200658116, -0.5870879178548957, -0.16185200319737555, 0.06515161197639781, -0.24676684609070684, -0.45048487074855537, 0.09046663703676983, -0.33779273006389166, 0.18590943249051436, 0.01655950026116055, 0.02451228226380212, 0.201826752870186, -0.2571533280142229, 0.2620378873483928, -0.2348510791627904, -0.13757771795077783, -0.0012584314987416146, -0.26370219294391223, -0.5946947496575221, 0.23206363487424586, 0.021953853576780615, 0.06197397300998488, -0.12765013522616347, -0.2187296192509451, 0.4813023794249204, 0.2037252320076399, 0.02207638916410235, 0.2764561520018614, 0.27521837933872045, 0.4780523127270742, -0.2604518391553342, -0.1168881043163146, 0.3961921601407592, 0.06349026855036792, -0.0571297775180355, -0.019674621265190356}
};

static const float b1[64] = {0.8730648783563955, 0.9700386306335422, 0.9697987307278924, 0.8918472099488229, 0.9233901927107305, 0.9612633084684027, 0.9230862484221002, 0.8824979331932575, 0.9558829257124616, 0.9131473609783527, 0.9080605881755481, 0.9206158760237814, 0.9305999321954999, 0.9462724151010757, 0.9664376259490194, 0.996130385919352, 0.945056643425526, 0.8401944380312397, 0.9457794687084491, 0.9290873407431435, 0.9322415037653073, 0.8595175693012352, 0.9914092830036357, 0.7581846677266876, 0.9585185781689814, 0.9959065440901864, 0.9549775604617496, 0.8341774622680108, 0.9701213772725727, 0.9951644394663095, 0.78144512275234, 0.9150471802486612, 0.9673396845929999, 0.8830543725417843, 0.9668732136581522, 0.9773796517466266, 0.9419076784927201, 0.8119644287813522, 0.9712474623725882, 0.9147446448577431, 0.9464217844410409, 0.9241489932524126, 0.9703236685196455, 0.9712158039385467, 0.8261223515791928, 0.9792044409618705, 0.9278733305128982, 0.9477090378963687, 0.8301874746365999, 0.8646965608385665, 0.9687039076703493, 0.9348501709840488, 0.9696913194258324, 0.823545848524413, 0.8697273022323617, 0.9358911887310669, 0.9246568257418633, 0.9365140879124023, 0.9530155323657806, 0.7661286830710453, 0.9552687692601396, 0.8302333349601599, 0.9570663537541091, 0.9548463649556969};

static const float w2[64][32] = {
    {0.6561756050948742, 0.8688617864138243, 1.024891869332412, 1.0409881648741517, 0.9246207335013548, 1.0173567991997365, 1.0345226918339598, 0.9036247638937124, 0.8087456956404833, 0.6470322678693652, 0.965153645807463, 0.6488934872017098, 0.3840067172973362, 1.0242455782980555, 0.6061672100115, 0.9749911465148139, 0.6713528467551216, 0.8352161073345225, 0.009329025181187691, 1.060551968996377, 0.8614383679908147, 0.6939993291893384, 0.8874893052324387, 0.9229427407329012, 0.7316077728004995, 0.9149029340674842, 0.650905291544244, 0.18755671955632558, 0.6285242837668799, 0.9346247760580825, 0.6641266767613742, 0.47625078914863944},
    {0.6981512839749632, 0.8208134746552854, 0.7993676386360337, 0.8042610794369475, 1.053155103745651, 0.5819049629067685, 0.6540832438236471, 0.5796824274135741, 0.7105244424306407, 0.779596493716855, 0.6232586846320823, 0.6999067950322466, 0.2715024980431977, 0.7175635142135156, 0.9419401755308507, 0.736679982615175, 0.928684096330544, 0.8826142193784313, 0.33656886023853066, 0.849039395555962, 0.7873089800782826, 0.6319470943056247, 0.635913681706291, 0.9731350273478985, 0.673926850437248, 0.862374256474313, 0.6411970441234777, -0.21629953605604113, 0.568784760666726, 0.6754679366624161, 0.9564444965605652, 0.505616445769334},
    {1.0331960602308392, 0.6735348032244917, 1.0481951404782737, 0.7517990991757257, 0.8882687231081392, 0.944561525741544, 0.8878266509920393, 0.6106461391814807, 0.8856128533825316, 0.6311503036945199, 0.9002335033588805, 0.6172457513412106, 0.35260976628314017, 0.7734145107842125, 0.9710728533087626, 0.764492241706218, 0.9313194673455806, 1.0743508124225676, 0.3021104984171882, 1.108694549464526, 0.9506870934189059, 0.860903896947521, 1.0083671591458556, 0.9341078123912137, 0.9306549185883761, 1.1243290161655746, 0.5528767896143265, -0.029172970462475096, 0.9789104980999386, 0.8639192209471872, 0.8193145706261864, 0.8087853925856158},
    {1.0416891732787956, 0.946985926580278, 0.7746414008229964, 0.6817956399394685, 0.8833891381872887, 0.9950822554690976, 0.8092185251915558, 0.5585931112738418, 0.383324671099321, 0.8318176834986022, 0.7753458057953477, 0.5892793658429707, 0.14085352846221363, 0.6745987264946895, 0.6931302040132703, 0.9711597517233422, 0.9557796474850914, 0.6287747693932106, 0.12967542920332734, 1.0767500093956874, 0.9442132845374249, 0.7312775929624843, 0.6869218233726933, 0.6301496714199146, 0.8615738175629387, 0.9479537395147243, 0.5348420913741733, -0.08568625016752997, 0.9913841302621694, 0.9632174592345443, 1.01340431972637, 0.4861588870558437},
    {1.02850464754488, 0.6648971652095784, 0.9509207811081795, 0.6235541899103697, 0.5992061033267004, 0.5807775554061516, 0.916212084666468, 0.8569943273936489, 0.40897925459707396, 0.9004041067310953, 0.5464995355318499, 0.8825543447783362, 0.1535900842630218, 0.9001555988228422, 0.9981958770767602, 0.9477830413667402, 0.8601067369863995, 0.9550678783347821, 0.1255566375136168, 0.68076954556705, 0.7475002798514054, 0.6959302426287415, 1.0315687439076247, 0.6692331449668093, 0.8593581710582927, 0.9465426613610248, 0.5951617589065304, 0.08842621551553081, 0.7374350699201869, 0.6559992414261903, 0.9064477993331276, 0.6983489114895419},
    {0.8977204420376151, 0.6513455326492366, 0.7360531044496985, 0.7990776045495449, 0.9294702353373632, 1.0531986251935754, 0.9366101788807407, 0.9981065986252785, 0.545250686169719, 0.6703902572588398, 0.7918683001981649, 0.9386401459127715, 0.4608859951658465, 0.912002285286583, 1.0037919750269575, 0.8956502919304711, 1.121355277731578, 0.9828292634646718, 0.31737192004006726, 0.7001885880285371, 0.6968759796879327, 0.6147306192524782, 0.6416156859779513, 0.915273280998795, 0.8862119435736855, 0.9464337163884325, 0.7960747271994995, -0.17667413114863087, 1.080286701761306, 1.1123863140190569, 1.0948490764503043, 0.6112071644810895},
    {0.7834086654315876, 0.8118328907886495, 0.589990980680321, 0.7059594816470622, 0.6106421197885618, 0.8749620216518946, 0.7543931703915565, 0.9897669573638453, 0.4415360887382006, 1.0581043502975516, 0.7201033140186001, 0.7777029871711164, 0.266051072769122, 0.9433466038050957, 0.9890068570814247, 0.854925282936214, 0.8545873420394878, 1.0109463462525414, 0.33510755856117047, 0.656709842674114, 0.7489713338426581, 0.39710035870179816, 1.0032792735208782, 0.725447238417743, 0.9375924365465805, 0.6106232994115504, 0.5568440593179229, -0.02895544150853718, 0.6460366487742518, 0.8780245664953554, 0.9312907990518162, 0.6358451773445195},
    {0.7866323507682678, 0.9112983892982048, 0.6215142202647125, 0.9315173604797579, 0.9507986267286582, 0.9496757749395685, 0.5858341344543523, 0.556914904262974, 0.5564651882060933, 0.7793434943878881, 0.6801129086691057, 0.9423860914858605, 0.34935676533303484, 0.5796376604121486, 0.6053724713748383, 0.6995728317030394, 0.6171986936227264, 0.9638440382372023, 0.1512939397385709, 0.6883927401150062, 0.9222715740382955, 0.4852430714778998, 0.9051512007414783, 0.6060283441662332, 0.8240862101752784, 0.9582643692252591, 0.6600453264219516, 0.13362140161551306, 0.6496428664948104, 0.8366901660083749, 0.7810828605938928, 0.49509996019336855},
    {0.7319714762596139, 0.8306273978936755, 1.0547269758920013, 0.943186342034927, 1.1116548795152692, 0.7182515212357772, 1.0176688097114157, 0.9259316781766344, 0.4166470932901663, 0.7864125053240284, 0.8773000660876362, 0.5973519988062724, 0.3487482358201516, 0.9465116338322593, 1.024131141078892, 1.0274750401039627, 1.1455144525825571, 0.8246388464776121, 0.28722481765301977, 1.1281396318164507, 0.835385901702142, 0.8231325572579195, 0.7835091071827082, 0.6358685171547366, 0.9157774167282614, 0.8240169252768837, 0.8430839321436833, 0.14376328146127518, 0.8189107208913362, 0.6675168302172865, 0.6474695784266321, 0.7590567792578171},
    {0.6906589898616202, 1.0539814071064646, 0.6608939303572907, 0.6363272092752389, 0.7747883361419728, 0.7961717788286481, 0.7382400185899182, 0.9683829933117742, 0.43056667622916694, 0.9585222917304532, 0.9214332747337981, 0.5966589219315536, 0.28480267370482465, 0.9252279870638139, 0.8255196395163792, 1.0828174509341684, 0.8931666021902412, 0.7605382417949341, 0.23038619681751227, 0.8858428219972968, 1.0220506702676586, 0.38684531486805457, 0.9452855752250158, 0.7499304616961412, 0.7349152143804045, 0.9660756321209123, 0.5669743489825111, 0.20071664114482182, 0.571510244897336, 0.903403813753575, 1.0543379305839644, 0.72090248131151},
    {0.8826042375558938, 0.943078921433882, 0.7868541665290171, 0.783314270684763, 0.8939065981033619, 0.664564405217938, 0.8467489173854496, 0.879890043085944, 0.6765449488077884, 0.9650464509251608, 0.7757517840409374, 1.0034794896042105, 0.10962765098046594, 1.0357358168020399, 0.8216019171059354, 0.7279843175807515, 0.9805113386231247, 0.6192214590807434, 0.03537930207140393, 0.8159704370258757, 0.7300214902861455, 0.5887169012071639, 0.6104271255444572, 0.864146476110354, 0.9442560819000593, 0.6371377705153254, 0.812564645012422, -0.266223457489786, 0.6544109435406341, 1.018851641177522, 0.7685202439888855, 0.6009076151966107},
    {0.6842021633376592, 0.6162808168195247, 0.9001045961164506, 1.0669250758972635, 0.8573104826406431, 0.6260016285005001, 1.003065268059566, 0.569675976423889, 0.6379415392996955, 0.8239210408540226, 0.6115962342076405, 1.0357333003620082, 0.032537006828834376, 0.7374612561520224, 0.840265641356634, 0.959816441452083, 0.9119994844701065, 0.9597530898380267, 0.2760358318670686, 0.6563437093674099, 0.9720210125653012, 0.7475416715620715, 0.8416464982348224, 0.7112976072911392, 0.6535522388889305, 0.7339857865494543, 0.5573425792185828, -0.20751542623138866, 0.647146770176651, 0.6571584887448944, 0.939309909321977, 0.4370864644883056},
    {0.6568661600238123, 0.7781057118868657, 0.9942778478566309, 0.8408141622583758, 0.8034937929967821, 0.6648362728078993, 0.7072660162539101, 0.575597981416867, 0.4792313544904057, 0.7141558704468849, 0.7475096344063379, 0.9914973071016568, 0.40080142196732144, 0.8889969547143837, 1.0006881849240057, 0.9936556705221107, 0.710776286059204, 0.8053455717597701, 0.1069254200382566, 0.9936616839247661, 0.7004108020752716, 0.7296615445462814, 0.9774220626288367, 0.7550253978758104, 0.8347670697509278, 0.7266759313561075, 0.7780459827390068, 0.14822479547613926, 0.5396142185312577, 0.6068583004411583, 0.630343946092125, 0.5335821833077418},
    {0.8554247167628621, 0.8298525208990082, 0.8942182964809479, 0.878490477621706, 0.6410387681328794, 0.6830798050025542, 0.7482245395622691, 0.959571121101903, 0.7029476820845613, 0.644585305838777, 0.8372872466501224, 0.9270621938190425, 0.2830604131714683, 0.7669625763111266, 0.9693620101904423, 0.7167626041418278, 0.8858000391257107, 0.8706961790642825, 0.2506680600844541, 0.7262313581299181, 0.9639666628094109, 0.46458765218976833, 1.0855481031061445, 0.6947805271079756, 0.8992479621908923, 0.8050472265473505, 0.8767801858230095, -0.26200893100906897, 0.6789315590153507, 1.0861757936776824, 1.0122945380816402, 0.4528137498958682},
    {0.7879962892735297, 1.0281405938879433, 0.6598245916668125, 0.6896915441119826, 0.6199924658682933, 0.6698497949128774, 0.6279503994531199, 0.733283683380722, 0.6013222423382428, 0.8105874134955573, 0.8943258037248873, 0.7624895067386727, 0.11677379150420503, 0.9097405286205202, 0.963272184344359, 0.8118750369375365, 0.8267695135200775, 0.8999520451417916, 0.26969984814027165, 0.6854607410540021, 0.8651390347357121, 0.6879395188335999, 0.9667335273827345, 0.754770107349744, 0.7341669522979011, 0.6358551785194788, 0.3822871561373308, -0.22744429319762544, 0.9188751920050722, 0.6336167053153308, 0.7928694293303212, 0.523471669754989},
    {0.8301245558530121, 0.7165145918519668, 0.6932777945694776, 0.8773228572386382, 0.7667844009201684, 0.9908279638230003, 0.9908106600500247, 0.5746986440936297, 0.7721474329965621, 0.7762551133472608, 1.0080024289617036, 0.7231509404349418, 0.27671353356148976, 0.8186040550519121, 1.0078039183379408, 0.7102342761070322, 0.7464317544579602, 1.1565096021182315, 0.15640379541905303, 1.0756797215671492, 0.9543586677735735, 0.5174139242395225, 1.126173509772757, 1.0320313419649563, 0.9996605099965229, 0.6743052631046244, 0.9815417714109715, 0.1144897092657515, 1.0899412919773626, 0.7241144453225551, 0.9754698344139162, 0.5176484006800414},
    {1.0087479958525614, 1.0433422517797433, 0.7996876124746448, 0.7161461376786469, 0.6524674128545747, 0.9089034820066676, 1.0342497460749045, 0.9991252842934787, 0.7891172123136503, 0.9018362107992596, 0.8225269751390559, 1.0539771649163274, 0.501771894536492, 0.8551114541650272, 1.0464112651000776, 0.8839206425995134, 0.8655479218891314, 1.0784939066989976, 0.4293952139806781, 0.8044961342022684, 1.0337676737502688, 0.7634557100807429, 0.644517268917601, 0.5596739324945866, 0.6784581961951184, 0.8212488146621482, 0.7485802560607718, -0.21690146384266026, 0.6136004155366722, 1.0078228100617854, 0.6275866605721698, 0.6524510965124242},
    {0.8344759471750482, 0.8956463224608734, 0.7110535434519362, 0.9284181287402585, 0.8072768814995639, 1.0739619885298894, 0.8801525576369854, 0.5774701088218921, 0.6808413101446762, 0.9852970914172205, 1.0074718170495156, 0.9459556373642481, 0.4790161485733962, 0.9820183001222144, 0.6482357984372346, 0.6526581706761623, 0.7575288893375485, 0.7069962159754841, 0.13437447081377688, 0.7814810708114497, 0.8972945991130883, 0.48372987997861777, 0.7757505518676168, 1.0333654940561692, 0.6636850792250981, 0.8321866296650332, 0.6439162582635606, -0.2356666739837245, 0.8684516919798586, 1.0109170245351344, 0.7233333824149842, 0.49822870378025047},
    {0.6822266532060905, 0.6320283888531776, 1.050850916330131, 0.6358718162777576, 0.888161067893884, 1.012099207133463, 0.991476428905818, 0.9101061294121348, 0.5511074734446302, 0.9525953021626666, 0.7408565873216175, 0.8663607964598257, 0.21092034868314066, 0.8183987497968672, 0.9216210191092468, 0.6605758604390523, 1.1206232936579705, 1.0124915724863595, 0.32469313920982995, 0.8206129855623593, 0.6540893762007944, 0.5526016599964364, 0.6997011167519848, 0.9971852788755783, 0.693380952132538, 0.8050305472588724, 0.6594282167929473, 0.07151453441331003, 1.0259750758539559, 0.9329040105214087, 0.7907260909299174, 0.6075588831108918},
    {0.9758417765446731, 0.9561136701277392, 0.6633189103471511, 0.6536590325184926, 0.7015788844855194, 0.6316950079277973, 0.6756497167119104, 0.5234634929511929, 0.5516446410167516, 0.6888883327013919, 0.8080167847202675, 1.014300197026622, 0.15861991990652008, 0.7490539101522415, 0.6219492839962777, 0.9721448950472875, 0.8178785094995668, 0.5782617001479818, 0.28756025901027343, 0.6824675506655692, 1.042310570558034, 0.34900193543930064, 0.6557727113476848, 0.607495960965283, 0.727859052705825, 1.0111207508330116, 0.5692348135039614, -0.2334244430317614, 0.633961100932547, 0.8328905297501957, 0.8661303583530872, 0.4286255276964319},
    {0.9062429324656817, 0.9318799814241573, 0.6158840077021437, 0.6151440380355662, 0.9864858154453497, 0.6821181600977317, 0.6056711634714463, 0.684868810772492, 0.5772281737195389, 0.7422371991185397, 0.775935220035619, 0.7407771458017528, 0.39624921294936677, 0.5931001517414437, 0.8316800328663078, 0.6861047848375358, 0.6513103115183307, 0.9599863415296781, 0.11287596567039025, 1.0225310266288081, 0.7763891579241814, 0.6803899832769873, 0.7453084870250999, 0.7165821143546676, 1.041271711693338, 0.9793138821698799, 0.6623885993826683, 0.11079786773616442, 0.808827659767273, 0.7279655679548936, 0.7461606281210592, 0.6361174383798346},
    {0.7403432627754664, 0.7213145302057586, 0.8299855770525205, 0.83661249510231, 0.7650457855870479, 0.5543048674631865, 0.9095469880118532, 0.910181900222473, 0.647277982843238, 0.9217232888498209, 0.6656359613229016, 0.6791658428560238, -0.01913569113982781, 1.041314768857252, 0.5573471817286846, 0.9029215473893122, 0.7525985287883231, 0.8187337432656039, 0.41694364323459243, 0.8232469212327307, 0.7986252963519258, 0.5272907091484219, 0.8953306892766701, 0.9049953589718464, 0.7170053085249929, 0.7490273193410332, 0.6893414002432715, -0.13803791274716698, 0.831888707463706, 0.6132884357244224, 1.0186727323791491, 0.34430707210318},
    {0.8281244205904951, 1.0070612705736064, 0.7764267751118578, 0.6860384387205465, 1.0290725614906255, 0.6465042744654961, 0.7315086191891018, 0.6009410265134598, 0.5629114733217248, 0.9093096958914272, 0.9621800860951859, 0.7405249884035586, 0.2616351767970947, 0.8320956275273003, 0.8846826402891518, 0.7764134324756224, 0.6768315309148439, 0.9982235568651902, 0.32341548983408236, 0.8579557217710582, 0.968240998028898, 0.5313185599125548, 1.0077283380010686, 0.9545408065869965, 0.7186537152801896, 1.1034048369192013, 0.5180961013995987, -0.1086986528644971, 0.9142307449837265, 1.0103989226901133, 0.8860438726730039, 0.7670543069252339},
    {0.870900770020154, 1.0277039388782607, 0.6112787279593977, 0.8921348699589514, 0.6252793619055056, 0.9463803240169354, 0.8503033294164541, 0.5922889893219295, 0.7189766290158863, 0.6541058348267242, 0.7735660773705068, 0.5922873004498589, 0.2849758389425673, 0.6434193348024995, 0.5735280950185975, 0.691660067058437, 0.998800857737987, 0.864615339999755, 0.37102988838291745, 1.021049319506263, 0.6967102311172898, 0.866896754147686, 0.7639854242525878, 0.6476805546153299, 0.9454494550566527, 0.9765776279947086, 0.7689568793220658, -0.1887793138674736, 0.576517533519847, 1.0523836037722185, 0.9985437932672324, 0.7324498255402213},
    {0.7513278386054885, 0.961223270369694, 0.9831433666760473, 1.005897435060043, 0.8932231550899298, 0.6310161608216177, 1.0065502498858638, 1.01642475027849, 0.7474693387578611, 0.8756794880120199, 1.083301207460075, 0.7924746067260072, 0.47547026439374135, 0.8744210154898366, 1.0261187092363404, 0.8693118825346487, 0.7948235494222253, 0.7356376389587749, 0.3555151633440201, 0.6585126921693839, 0.8143725413403339, 0.42723796179842827, 0.7408111288371326, 0.8879096006693209, 0.753529124549425, 1.0815575400898407, 0.4669649226462132, 0.13536777351815607, 0.5707968740415879, 0.9150832763935347, 1.1092554075717225, 0.5218687845062271},
    {0.8839807601835514, 0.8032172582400697, 0.7051175524911416, 0.7926318856253184, 0.9602110084838883, 1.0805239119404368, 0.7882061989248517, 0.7974776290261094, 0.7855592123102159, 1.0503715270850427, 0.7371208120426562, 0.9121299812391042, 0.4660481350234023, 0.8864429872679346, 0.8821924394645216, 1.0154070517364493, 1.1546574379586334, 0.7117298367042625, 0.10624965419038693, 0.9970910240475066, 1.0043632933141462, 0.5844960168375296, 1.0157312330119757, 0.8907190971389043, 1.1119028043390944, 0.807000114757517, 0.914181919682502, -0.26428410815948683, 0.9503813261842253, 0.8030441867385391, 0.7119810933452239, 0.6130399020230358},
    {0.771136078499191, 0.6512444638102787, 0.892916368957191, 0.8529076523060302, 0.9570829800291921, 0.9611344083469416, 0.7703979272009042, 0.6655632151265862, 0.7343032067130824, 0.8025203836752876, 0.8538178172712223, 0.7936826923651092, 0.029038768867529173, 0.7285846272699791, 0.9478452939850898, 1.0373225659549052, 0.7599650311871418, 0.9667499825106627, 0.3850093983914927, 1.0276405433678577, 0.6385751733841087, 0.3796495887032799, 1.0057204420219146, 0.9115095753719716, 0.8698601533449478, 0.8734869024430932, 0.6491115874721913, 0.10364255107111625, 0.9815741694242096, 0.8451851505651211, 0.7988143088503761, 0.6596133202860663},
    {0.7272169832624582, 0.8113796956100371, 0.651561392584854, 0.7295092518861578, 0.8405981238845729, 0.6563607514542334, 0.8577698088619887, 0.72124174599452, 0.6766765755211217, 0.8106426493923454, 0.8455392942620208, 0.5763407846504609, 0.0936722604379371, 0.7252117288090563, 0.6781079152586704, 0.9858493327675295, 0.6683336176536783, 0.6545999534367716, 0.2810166971793742, 0.7827245633314843, 0.6842562493711016, 0.33835999639782366, 0.9092454610904223, 0.6592871119547323, 0.5942554318407779, 0.8960770989545878, 0.3815564489474877, -0.2298992461554041, 0.9670462050060489, 0.9148739784753647, 0.8712043941934464, 0.7706449117889973},
    {0.7386148041497721, 0.7823513574342282, 1.0166431191933996, 0.8381642956309433, 0.7808624747718433, 0.6898302683485301, 0.790558733983979, 0.825899412298902, 0.8083662182100387, 0.8744165116962099, 1.0841103265712857, 0.7008276877119175, 0.37490149485289515, 0.7477086423928639, 0.9612123697478882, 0.7956350882174456, 1.0102341920965174, 0.9231055725065926, 0.4214491484650598, 0.9238995068545031, 1.087158194098893, 0.6607401273272265, 0.6268356969255795, 0.9813609196171074, 0.8395760661482731, 0.7957563073482498, 0.7155142241308936, -0.022728235342644384, 0.9822184640337636, 0.7312016633235259, 0.7271413088940575, 0.5253013068224707},
    {0.6183571958673855, 0.9874403297519975, 1.0427427413421686, 0.8128361875929455, 0.8752627657768007, 0.8495732036600077, 1.0935872678287129, 0.9244665745843648, 0.6858599749368164, 0.9416825611757182, 0.8200364218958329, 0.9495380983421035, 0.03561014681585525, 0.6412739456833952, 0.8334850448296184, 0.7289656906319871, 0.9006803522435627, 1.092501676046499, 0.0803042662388504, 0.8432596242591127, 0.9899106217721719, 0.35836793816858686, 0.9676700033349626, 0.6780055664205715, 0.6838901171106854, 0.7459282159812373, 0.5190287450620339, -0.2744858914201662, 0.8145944915534881, 0.6774405974536634, 0.6577178971673012, 0.6672251285124633},
    {0.9392747218548663, 0.9984401531556365, 0.6052059253477238, 0.9037386040010281, 0.9208789102873064, 0.9085159818494504, 0.6369791666785943, 0.7944014329093294, 0.5171706781769252, 0.8384680771289393, 0.573116645997964, 0.5771209344973682, 0.08658637603345481, 1.0748171482659223, 0.5745364616470376, 0.6041657180495765, 0.7299592697191483, 0.6953411945978846, 0.04591539590491519, 0.8874140113044788, 0.9827329373810817, 0.6860556151258441, 1.0087355681814927, 0.8546231156545093, 0.6405580115783326, 0.6453881390411157, 0.4139649519668291, -0.07560672811513396, 0.6981521411411736, 0.6132168254900318, 1.0457786714395993, 0.8204203179052239},
    {1.0568522520369716, 0.9635740129233282, 0.954270108805197, 1.0118329761872025, 0.5780559011956841, 1.0088962112639046, 0.9291907728963087, 0.916992857605271, 0.36404756485803996, 0.6656633237633709, 0.7441735578725613, 0.8978409750745613, 0.13663535078852138, 1.0515811034911746, 0.8939044444489708, 0.5937403795746972, 1.0746987804035928, 0.9002704894590197, 0.18652885339620773, 1.0879461265054249, 0.7007452829687146, 0.6324471609041025, 0.7765586214868208, 0.569014205317126, 0.8331577278409543, 0.6551737182700345, 0.44439284757712577, -0.1271055976989081, 0.5784776432850075, 0.6864444364376927, 1.0052491940400539, 0.3861774685234018},
    {1.0182863624581755, 0.7643097185308602, 0.6010858178948628, 1.0631891401710585, 0.8344794827269945, 0.7869855450222015, 0.6278289907877772, 0.9297581603891744, 0.5914529728475345, 1.1003485056268352, 1.0760439073762407, 1.0214040304694998, 0.5410180471705169, 0.9864339259103959, 1.0147815449734947, 0.6758578253856485, 0.9333748719601159, 0.8021320350778222, 0.1487138901888473, 1.0398435435384497, 0.6906133462095174, 0.7917848177010349, 1.023946514666168, 0.607513081803372, 0.9004145521497646, 0.9959803582505291, 0.6900380783819425, -0.1280630209256921, 0.7672624225473147, 0.7503780714223486, 0.6553482552014751, 0.6993910248299855},
    {0.6273092919383472, 0.9064077590486397, 0.7254716711798322, 0.6843442611170472, 1.078471589886941, 0.8114685481858135, 0.7921038011031101, 0.9640727435505229, 0.4944638971987698, 1.0662017888148558, 0.9032317225592765, 0.8498106610976506, 0.4436618964763977, 0.6859263273989694, 0.8370147274505658, 0.6456172305489791, 0.86031438163211, 0.7498726605962455, 0.3609650130157754, 0.9806286914989506, 0.7925070184812063, 0.3636351183314708, 1.0212704838547157, 0.6165535922947444, 0.7252107296881097, 0.7111127866595619, 0.6783698254860976, 0.017750676399559517, 1.0103498251702185, 0.9510048863010476, 0.9056093535067326, 0.6821422330121473},
    {0.9571781921251608, 0.7025778913737719, 1.0291896048388804, 0.8545175813722151, 1.047398315116554, 1.12289337707235, 0.766312095171918, 0.9041196952700373, 0.9202625160109352, 0.818320621210244, 0.8252005677743295, 1.0576513530215672, 0.07814452447598914, 0.6580823223548913, 0.6629355699894252, 1.0952537100722073, 1.0953436892422717, 1.1148197971180702, 0.5739676337214544, 1.1079176086155877, 0.9578561675906121, 0.9081477335553186, 0.7547389676995763, 1.07895269630498, 1.0119984250804144, 0.9986083478334361, 0.918501093695843, -0.13041765424361398, 0.9142619337650891, 0.7481030722947807, 0.9383897072666278, 0.8851355644810911},
    {0.6287792494636865, 0.980822802169262, 0.7864596368751621, 0.8200236543955706, 0.8022271777872465, 0.7463052975084965, 0.6753875655070456, 0.7465925702055315, 0.8754284201247075, 0.7750355290862542, 0.9463960371257335, 0.6295163524764442, 0.3839077428564043, 1.1115881936206344, 0.9316014032706571, 0.9994891095822318, 1.058102505143377, 0.6715577025635289, 0.17764845160061637, 1.0254263421974033, 0.7826856955110024, 0.46932594504834246, 1.0088169341500142, 0.9159602849998038, 0.7710327486484088, 0.830880737198583, 0.8550752461738329, -0.0609172489599407, 0.965733499575802, 0.9197490605748418, 0.9788213992438449, 0.7141887215445858},
    {0.8878291419102096, 1.007422231045958, 0.9774616087986236, 0.6005592385139542, 0.8043912642684571, 0.9171809259226752, 0.6577015457662808, 0.9211789474408236, 0.40845433452893937, 0.825815778845459, 0.6285700911440183, 0.6303039102913061, 0.4935207749516475, 1.0674158697310365, 0.9713985946845484, 0.9498752394379028, 0.9448210925408295, 0.8222602656585326, 0.3615207588816727, 0.6987845270202259, 0.7340785846744583, 0.4006043912800443, 0.7075367884731418, 0.5501787086176937, 0.761260227018996, 0.6453345635007369, 0.6144251807268557, -0.00428943007434347, 0.6240184341331318, 0.9773064151146058, 1.040318789906827, 0.4991519834752167},
    {1.042635309386309, 1.0053823037906633, 0.7991808963015189, 1.0772624977818408, 0.6109809411020093, 0.8308920323027253, 0.9852342318402586, 0.6945774842164247, 0.6706253803495622, 0.8340975319019683, 0.7497930795882608, 0.7541543947871194, 0.18321943620751793, 0.6474906200840977, 0.6764179177806249, 0.6407307095326592, 0.8058421681763425, 0.9483215205354976, 0.4560714304028115, 1.0031684000311623, 0.8431603927183586, 0.5199838375453445, 0.6879098518142183, 0.7148194706191334, 0.9018883890328063, 0.6566167945364477, 0.8391352988847859, 0.024375778066315777, 1.0120327632591302, 0.6515281310129367, 0.7412988963423387, 0.7901468834687321},
    {0.8346406218179094, 0.9426081800342552, 0.8482063591867971, 0.9453036075066664, 1.0825883338640194, 0.9795629688327893, 0.7143593721756591, 0.7314325437898979, 0.5221900878933807, 0.7134141372124551, 0.8502886527295357, 1.0117235298482692, 0.11785036701574456, 0.744800608068328, 0.694730245454924, 0.9875717533263192, 0.6918737071203678, 0.8355175167641526, 0.12586711127813927, 1.114303177021324, 0.6634692271457813, 0.4100463378390306, 1.0366418943794455, 0.8393197369478995, 0.8469738915990628, 0.6766035707511399, 0.7288253439036415, -0.22385861484545522, 0.8036663064015604, 0.9012665810269644, 0.8622604097071265, 0.5521638702202722},
    {0.8106303412932492, 0.5899634955387651, 0.621194287437602, 0.9758550666735196, 1.061577972207593, 0.5554084158547796, 0.9447638063211626, 0.7755242131825983, 0.7445284701942423, 0.5990887556961058, 0.942633390215162, 0.6798657292033997, 0.18711396781635592, 0.8812643964588099, 0.7629044880740623, 1.0507982208417965, 0.9982134490285872, 0.9953789298504612, 0.15287651556235735, 1.0231168535363737, 0.5933551875786818, 0.7853473467350615, 0.9187516313502153, 0.6665784222583143, 0.9389289331544076, 0.9761889450239595, 0.4038584098738636, 0.0827471304372316, 0.4776003319201962, 0.684121762199463, 0.9279058391345948, 0.6247332339965969},
    {0.7247319584109134, 0.7623827126607021, 0.7106352760401807, 0.9919287093544559, 0.9948599301362986, 1.053243685747115, 0.6623749897893245, 1.0145035743867588, 0.758322915649241, 0.6771505395174531, 0.6974706563536094, 1.0840865905265404, 0.07210846654892125, 0.9345098618228557, 0.6367681142313676, 1.056433326886778, 0.8847170197524028, 0.955777371485584, 0.38578093183676254, 0.9582704952463114, 0.6475588314214799, 0.714787490081643, 0.814727628898125, 0.6765289552482511, 1.0441685524860962, 0.8888869744758817, 0.5669989751031401, -0.2459385312440025, 0.9956272577078192, 0.7224330335958531, 1.125486050623227, 0.7617626827161769},
    {1.0402782857771105, 0.9437386795093982, 0.89175446504542, 0.7985349902321023, 0.6132337699546313, 0.808060485616571, 0.9395060761984554, 0.9233800334567221, 0.6986228945855788, 0.7548794073922355, 0.7356078614448108, 0.7357914785365495, 0.4676203625145636, 0.8943575579105724, 0.9803334889956877, 1.0523146325371877, 0.6164344138971224, 0.982728043340876, 0.04368917808739337, 0.6075147070956681, 0.957959554051037, 0.514727514261008, 0.9168265815719006, 0.5660311057271507, 0.839538711420118, 0.8132856227831681, 0.46803172175464913, -0.0393109761531817, 0.6038214758403687, 0.8307443524696587, 0.8859666844630728, 0.7295134416552166},
    {0.9499013137803748, 0.9650012694400245, 0.8660564707671062, 0.9952458383428977, 0.7990758547751442, 0.7104397983612231, 1.1201143062943453, 0.644629766580818, 0.45538247813076804, 0.6373999108699081, 0.8021742438439142, 0.8753147335831132, 0.47186843758045716, 0.9746589999547693, 1.051787879827998, 0.9504322299647828, 0.8966324108940769, 1.0490611485737906, 0.2474888049005606, 0.8413672791189493, 0.8129107967253281, 0.4405162911320578, 1.0163736827116772, 0.9219321776797476, 0.944396460408212, 0.6819585818766836, 0.917215139776517, 0.13389252390364387, 1.0024376504840757, 0.9758329588417042, 0.9762974765942986, 0.5710641707092988},
    {0.7839454416320616, 0.877318836001493, 0.7834847171721631, 0.9528898190654855, 0.7296408584659055, 0.7402343247177786, 1.0003804201614999, 0.9347695652219153, 0.41680226249128666, 0.9120364854897068, 0.8238471466383464, 1.001338970675103, 0.2011745131453633, 0.8570101968337814, 0.8397217719259943, 0.7711657658453246, 0.6357735225089627, 0.8912387975887911, 0.02265557605457993, 0.990820964234337, 0.846495217804431, 0.599364064622472, 1.0328775654003386, 0.9115317138773317, 0.6192600309650504, 0.9737503005525777, 0.7448216658333007, 0.02084975922169138, 0.9614885941283701, 0.7072723447369804, 0.9717711608572597, 0.4503443611473012},
    {0.7323654562108486, 0.556703829526338, 0.5938349948545458, 0.9146975998830765, 0.9345158167776462, 0.7776307840555101, 1.0254483927461608, 0.5847733878373106, 0.7088896862617452, 0.8245003439799691, 0.763544662686752, 0.7485108408033799, 0.229790099337218, 0.8620773061438501, 0.6407613665220122, 0.7328983236489256, 0.6665255913957114, 0.6540187725307107, 0.035278858175448055, 0.9587519518602811, 0.9552022674800471, 0.39261988602604025, 0.6689404097742552, 0.6900838896908182, 0.7307920034185269, 0.6949630247015336, 0.6926049287710812, 0.03477274672860858, 0.5780879005523333, 0.8986828504521036, 0.8138919767061036, 0.664591002498693},
    {1.0880438432902677, 1.1013090740117353, 0.9377209586248841, 0.705310169634848, 1.1172397607225737, 0.7064888695539309, 0.9542883102490759, 0.7769033639332141, 0.6053068640299735, 0.6733257086482416, 0.8900519162035596, 0.6868632351160856, 0.2333619856933205, 0.9897870387896567, 0.8729726733972573, 0.6762491994040212, 0.6537091476204209, 0.9901107152161308, 0.43549950486345584, 0.7582884026976006, 0.7543768689750749, 0.8337514639750653, 0.6715748747199455, 0.9803421991855157, 1.1160247484395642, 0.7912291644067896, 0.7067272069704365, -0.15399636654202434, 0.6958203413785308, 0.6957358501685184, 0.9006163486943668, 0.5564773030625253},
    {0.8825138781936938, 0.907738459457784, 1.0416400555337604, 0.7805946818919619, 0.8369409838001081, 0.6368010927873544, 1.1103281210714777, 0.8365218265982788, 0.6541941390979878, 0.944551648066034, 1.0182034825713926, 0.8045309798716339, 0.1472344304890298, 0.8861122076092633, 0.9461107712802128, 1.0679959434126571, 1.0496772161715635, 1.1243983336780292, 0.09651832506377474, 0.7614605323682985, 0.8657713671532185, 0.5476856184117221, 0.762189285437319, 0.6611559934528415, 1.0980072154970644, 0.8846565111378358, 0.5906373494719244, 0.07628241540221913, 1.068879629233632, 0.8647065642312964, 1.0217459344210276, 0.7845613046134516},
    {0.9192017390076672, 0.7959371296752817, 0.752989185358698, 0.9504393217714088, 0.9017291674806868, 0.696865972977677, 0.6113180145930799, 0.7540001520132394, 0.5322350272869842, 0.6042224716852483, 0.6890977598260603, 0.625715666961113, 0.324633326826637, 0.7205010854646067, 0.7606885363411083, 0.9843039353808081, 1.0764996016827253, 0.6632457451864009, 0.03126180892613824, 1.02960466707578, 0.9439991878647794, 0.5484625593092298, 0.9227252492842429, 0.882841180038791, 0.9386699306320498, 1.0915034530348078, 0.5186584657446163, -0.04300089521081583, 0.9185335445525568, 0.585064286604396, 0.6295672729104815, 0.4061525823890016},
    {0.9750626462541465, 0.5906636550502437, 1.036415338927568, 1.0096930735911607, 0.6224371319503021, 1.0594118050620733, 1.0384826691688784, 0.697929793627629, 0.4986515085241374, 0.7977373385392257, 0.5988967874877059, 0.610332333969978, 0.3366218972411508, 0.832103605046704, 0.6086996881776084, 0.9845777060724031, 0.659684707555826, 0.7360788686719194, 0.3335640807348693, 0.8611020933620424, 0.7759119847538943, 0.6280023808116556, 0.8577712900067676, 1.006342155948689, 0.7154217639544933, 0.9612353467906706, 0.7610984890886862, 0.21639130078403573, 0.8435548528506843, 0.9431953194203448, 1.0582696810715166, 0.6931309027509678},
    {0.8105114386330735, 1.0681280897109928, 0.8869829170336768, 0.9691520578189133, 0.8844302921367099, 0.7007094815022542, 0.8142869659355464, 1.0088886805681134, 0.6172851453136116, 0.8721863802789777, 0.8203364596042001, 0.6475640374238067, 0.35764963799931443, 1.0808865923372957, 0.7310341061155391, 0.623350917918744, 0.796223827441994, 0.7693568489338156, 0.24935465591547004, 1.0137095586236664, 0.9380356169525665, 0.37227509330599745, 0.9240365389838534, 0.8435947702130487, 0.7329451866235615, 0.7808965818638641, 0.7995747561579369, -0.15171724845044499, 0.853282019776125, 0.7456090666944577, 0.6553385451629633, 0.8040701047466817},
    {1.0533306970262986, 0.6039843465249419, 0.6611801656371503, 0.6567470488735433, 0.6170451980450066, 0.6887818588221524, 0.7432352105136947, 0.8978768150870081, 0.4038420470735212, 0.9820545926596634, 0.8666041965912727, 0.9885701531531954, 0.2497696916818661, 0.952416790572179, 0.8788244468877789, 1.0133306958783574, 0.6263885339116494, 0.6985492142731163, 0.24219663255098536, 0.6911772323827189, 1.0142842329709485, 0.5454373892348977, 0.8869444098391246, 0.8095092693611505, 0.6559528581716081, 0.7793542850457843, 0.3796049643544324, -0.20339044932688474, 0.8617116197240482, 0.7744164121896315, 0.7523180228501545, 0.8587904700450409},
    {0.9990922017046933, 0.9357359376386808, 0.7437566622000215, 0.8392108623009994, 0.8995436546339329, 0.8411435708499693, 0.7050591398874507, 0.8315116520132428, 0.4386659445768876, 0.5979964782459853, 0.6367391663343941, 0.9267049704829635, 0.06129439170965787, 0.5925675015443482, 0.81817538975706, 0.7338372427423854, 0.9467183813803923, 0.9873663773477762, 0.3024692263823555, 0.6690691517445079, 1.0213244886950579, 0.6646524909801497, 0.9031229092720966, 0.8422040883469121, 1.0642430959971456, 1.0235737339186397, 0.5672336639340568, -0.11384793034176677, 0.5990898131486171, 1.0023829864488176, 0.6625868431521164, 0.7944255547927204},
    {0.931518793240632, 0.8740182011744972, 0.6444114259148407, 0.6266044536332673, 0.7470595947721805, 0.7106809710689033, 0.8806975058872267, 0.7478244311669447, 0.4531082766695925, 1.0016120338955798, 0.7188519075609023, 0.9010849484984054, 0.12200051107159957, 0.754233555938899, 0.8783385855893484, 0.7887114424504501, 0.7795871367388231, 1.0922012035155033, 0.22535261584892946, 0.7803880968907151, 0.8034929313692384, 0.7279561341073139, 0.7662763477507192, 0.8547401183853685, 0.7737256133012559, 0.7718714122620212, 0.5658443917739614, 0.03917448515070457, 0.5983725226827119, 1.0943024413055742, 0.6275947393593994, 0.4435789777244644},
    {0.8176956650339491, 0.6471244834072795, 0.5878068542339684, 1.0659133434675871, 0.9363711236786948, 0.7527696917532316, 0.6147532428624699, 0.6723073119111994, 0.4483233730615697, 0.9481611956748515, 1.065122751612642, 0.7658490055820186, 0.27473390751546517, 0.9222462971404064, 0.5925164089608039, 0.7527644356756455, 0.6773600345292576, 0.6663974079047528, 0.384708342744347, 1.0569528000615844, 0.722689929674753, 0.5457760841443603, 0.7557474911039918, 0.8340484722488211, 0.8037335665435348, 0.8701721545330586, 0.834320270251002, 0.20999158611910307, 0.55890938847138, 0.6259148421232379, 0.8322865645876929, 0.7031863569534559},
    {0.8111394114073154, 1.0043314675281174, 1.0342056328774907, 1.0351017122447261, 0.7969799494697234, 0.7191508512601186, 0.7030083895209746, 0.9345682131097102, 0.369085541191108, 0.8482054223376907, 0.975178043567511, 0.8689567783786801, 0.33384320093847114, 0.6937497817784551, 0.6007901715175085, 0.9219494201066304, 0.8207268123272362, 0.8996343478399031, 0.04735537696610538, 0.7559603040273127, 0.9625123927720235, 0.496359290006926, 0.7675380506833313, 0.9514023092033382, 0.786446397670685, 0.9178088528562438, 0.6245163012316851, -0.25300558587586824, 0.6182768924206831, 1.065525269997366, 0.7287934970810618, 0.5439780020097825},
    {0.8293610635463178, 0.7551161877016604, 0.8319654889735665, 0.9856032327627873, 1.047559307275203, 0.9031312604338122, 0.6327032753661208, 0.5314464361440775, 0.861623258995129, 0.854324163829179, 1.058493290992738, 1.0260467552448878, 0.44921612726980037, 0.7752759278471688, 0.662904170222393, 0.8975193523256262, 0.9019085864610974, 0.8656554395773784, 0.3356324978927579, 0.8004541142155834, 0.9555767381952703, 0.8019720599062057, 0.660389224317527, 0.7278186326387512, 0.9628859758740453, 1.0559238326163856, 0.6034552618369142, 0.0672712308115154, 0.9829734101662739, 0.9114464177695188, 0.9426940797403941, 0.5799071230130812},
    {0.9184507042650318, 0.9752425330976396, 0.9998671624058784, 0.8004425308523992, 0.9828179528247216, 0.5729688910733791, 0.6510500536023569, 0.6834656726914868, 0.5175896469291101, 0.9915093073384343, 0.5722691742762902, 0.6880985961332465, 0.14679664510271484, 0.9080314658311515, 0.8786115008655304, 0.7052909881418037, 0.7146548975689035, 0.6221974787557748, 0.01812187961707786, 1.0684312368217894, 0.8386219783297719, 0.606761998022966, 0.8916847289392199, 0.5219153887777478, 0.9495863820965045, 0.774187170369213, 0.85197886795697, -0.07979235770475178, 0.6378547915827887, 0.5986299561487174, 0.7996358039707935, 0.6424345889609239},
    {0.8553081806865251, 0.8456451421072142, 0.5954701510198246, 0.8382016301286412, 0.9089376292327355, 1.0024136352611193, 0.6316096407495175, 0.7284222581351305, 0.6445789710571768, 0.8827402762048895, 0.8422628805053425, 0.919830757245107, 0.24106560671707417, 0.8995699132977105, 1.031349005530798, 1.0585809846857186, 0.8571595778849694, 1.014575607569522, 0.23507457946134355, 0.961828231208505, 0.6130243162139386, 0.5664258850596933, 0.6834164888169612, 0.822741632723449, 0.9104434396082449, 0.9023045968786084, 0.6002219448781803, 0.2260704186737575, 0.9439434839773597, 0.6095177104227064, 0.6385217015601885, 0.8387467399059141},
    {0.8341796171671202, 0.7064666533468279, 0.5739093840839926, 1.0695698252044694, 0.650381453556572, 0.7036071368987787, 0.9191834748078629, 0.5644055628065837, 0.5811715741964197, 1.0386794265221677, 0.6587708067633313, 0.6182446535632411, 0.32862054933497226, 1.0559535136159217, 0.8673479321162954, 0.6400462770661447, 1.0122072989319897, 0.690520596942965, 0.055441189888319205, 1.0462327890872845, 0.779450696516911, 0.8452674768068464, 0.7735906012300602, 0.7243909920982076, 0.7992136736049466, 1.0035367279849903, 0.7321416496442095, 0.11343974824642858, 0.7512224838342959, 1.0510367940365468, 0.9359078629272768, 0.5414242343844621},
    {0.9225723077335708, 0.7634181953881353, 0.7928777236610993, 0.8265641794762959, 0.6073046121843435, 0.7044825737915987, 0.9874004775838048, 0.9408002011912063, 0.7251777645099496, 0.8814040178392039, 0.8040834599620165, 0.5462561235374481, 0.29149318172316274, 0.6723731222612482, 0.5392568895024275, 0.8682175943534357, 0.9375055179363406, 0.7151733711993452, 0.27412841545363753, 1.082565859984641, 0.7737011145921464, 0.5679269153723386, 0.6129588810145902, 0.8167845282676779, 0.6731465655022368, 1.0171571102449117, 0.5198219620615807, -0.17598591724373208, 0.8707385470062796, 0.8400565359151861, 0.7194251488390154, 0.6460354158186684},
    {0.8999249476088448, 1.0775049140262902, 0.5965897060166844, 0.6637683692888012, 0.6901690116149728, 0.6327889999158618, 0.6646379814426353, 0.6554629043744503, 0.7804163074525606, 0.6235381062591305, 0.6683753538065563, 0.8008631468569907, 0.07725629534332867, 0.627289565007468, 0.9199177271397819, 0.9846459843334993, 0.6448623932752975, 1.0566111351065401, 0.2553280485335009, 1.098982532494074, 0.902419315325144, 0.48074411640904946, 0.7656098934405139, 0.719670209016489, 0.7521257857585415, 0.9724044771225673, 0.7449195432910728, -0.08190070541726902, 0.8346002849218501, 0.8454967591584798, 0.7527098613719746, 0.6985403745804875},
    {0.9503537684716991, 1.0034763388925334, 0.9269002966049396, 1.0264615968337456, 0.7739210640546501, 0.870577557171737, 0.7762765363196329, 0.9719413830467972, 0.36553231134833986, 0.6060293181918416, 0.9742143153788355, 0.6149787116945901, 0.2774903118617233, 1.046300070459848, 0.6914950920332315, 1.0236796553583258, 1.0701778012093939, 0.7863619931148079, 0.29835067023622314, 0.9660288706654453, 0.6753471492863515, 0.7059115220062441, 0.7621944758982353, 0.5317292009143098, 0.7156510362997531, 0.7367285504688712, 0.6905014779147312, -0.0408914122737315, 0.8968980925543186, 0.9249947712845504, 0.6470389244613254, 0.5789238682939281},
    {0.8669917099387571, 0.7149560370227449, 0.9881278110156355, 0.7869188059238406, 0.8272220316583958, 0.6887052237745755, 0.9055172656338967, 0.5496777751876424, 0.7051781606216946, 0.7947366603788684, 0.9955032173411164, 0.9441478020593429, 0.0009353256977071011, 0.9789259849927591, 0.8604821825444153, 0.7083269260727529, 0.94653384712419, 0.630387610856937, 0.4478199362837938, 0.6226830528656861, 0.9011715562274183, 0.7626214728932359, 0.9396996599829057, 0.8143869405373378, 0.9888293522364541, 0.6225671967520857, 0.4230858464565296, -0.22480140697908563, 0.6268741769260681, 0.6988086581677476, 0.6141912270794009, 0.5017730668575654},
    {0.9914413460626124, 0.8576816336700728, 0.8024947371890141, 0.8922770657014601, 0.7242627450639708, 0.7416153048553161, 1.0056027185386451, 0.8154390147230276, 0.5495854857509869, 0.6214479086661888, 0.7837595310148727, 0.7179456446345861, 0.11474172455026535, 0.8116476678976974, 0.9659357650468774, 1.063985736343215, 1.1120025393882158, 0.8720195320200328, 0.2031152504563971, 0.7999228211476822, 1.03966189213292, 0.38551013660778244, 0.6898423571064438, 0.7789052441356619, 0.789340280742613, 0.632345328451653, 0.7679583007872673, -0.22026285103087379, 0.8044529113627048, 0.6920911187655956, 0.7934650288612404, 0.8546786018252513}
};

static const float b2[32] = {0.834581236995212, 0.8526910697149069, 0.7685449281063839, 0.8258557470002731, 0.8022737405601811, 0.8046715141614559, 0.7899552393647824, 0.7505970917764964, 0.5956229297015313, 0.8129965111435818, 0.8196187787844206, 0.7862187689895634, 0.28668768731046584, 0.8142234873774539, 0.7494241032737896, 0.8055122695553677, 0.8495828024844226, 0.8017697926440954, 0.2974402074120488, 0.8505253644371824, 0.7984218307123131, 0.5746851873644313, 0.849163468077868, 0.787150420802818, 0.8463128330773603, 0.8416169121589178, 0.5974165649505871, -0.04317468610487485, 0.7955075951506628, 0.8109666410036278, 0.8252797177359548, 0.6194584980971584};

static const float w3[32][16] = {
    {0.9774810858717059, 0.7457984118929442, 0.6052331676620573, 0.919790180987586, 1.1309954519983347, 0.2253607231854737, 0.9650631026634908, 0.908241497764106, 1.120097043576854, 0.2109004911378275, -0.3745879040078674, 0.6545305517560478, 1.173412128995884, -0.3648231947397882, 0.6710120022820335, 0.6769614934630659},
    {0.9872301611010053, 0.844082726888152, 0.6136883682177692, 0.8541861871287151, 0.8205142452818246, -0.11678374531627456, 1.0144814620428897, 1.1169427873892952, 0.7425366553892105, -0.20078683753101445, 0.035894374024095003, 0.6834398067334357, 0.7058228762403012, -0.09514319853191182, 1.2451856743926877, 0.5763424638890038},
    {0.5961870039341123, 0.7959822827041461, 0.7372896456043366, 1.125459728268778, 1.1575801506057868, -0.051065557129416364, 1.0570016111532186, 0.5927229101118652, 0.9104374045231682, -0.22573577363148598, -0.04468862636023251, 1.0385092702791552, 1.124432959366912, -0.03731503044065063, 0.6660797528063973, 0.5918382830915392},
    {0.8637133510662539, 0.8123626748576868, 0.9119474664568936, 0.7875018706902642, 0.6077681124598481, -0.03377282926121588, 0.8776313080557933, 0.9940345365036636, 0.8369162078877439, -0.03477534120366229, 0.03375418137650761, 0.8268613334545788, 1.1590449842260886, 0.14068647883882443, 1.0500087992066158, 0.8627809566740025},
    {0.9004658713355124, 0.9195814873409395, 1.1181079342998037, 0.9849150429165844, 0.9195027297705562, 0.07481989028522265, 1.0903364465906509, 0.5827874164120632, 0.8815925488041632, 0.24145908728258092, 0.12072611607315374, 1.2326640432246099, 1.2232768508725247, -0.3269040772018522, 0.8275617042629178, 0.9823270914357664},
    {0.7626299557285301, 0.6121984037335388, 0.9074785575791103, 1.210076707768025, 1.185807775187149, 0.22300497968884053, 0.6019588111766128, 1.2109678972334783, 1.2529964012451762, 0.2826149381785014, 0.2731670271088274, 1.0123262551671794, 0.8633710633297579, 0.2774240929290127, 1.001951981510253, 0.5874044764747421},
    {0.7804680713711395, 0.9872946800441762, 1.0401107468915614, 0.8008368588911077, 1.0935552139611227, -0.424284788482802, 1.1853851341882764, 0.751948129418445, 0.6243757670781311, -0.10706366572729109, -0.24631613384968432, 0.6111570400575608, 1.054046059134406, 0.1839049744687891, 0.785999996917699, 0.5617600610285548},
    {1.0695019496854572, 0.4550758704752139, 0.7085357103824969, 0.8637580917009575, 0.6488003106312547, -0.3697021462597823, 0.9444548848779077, 0.5462565465097734, 1.055353117443465, 0.17515631803318107, -0.0799038018255276, 0.7871160017701675, 1.0359194385766237, -0.27642725551794994, 0.5455197562329354, 0.6225577613156398},
    {0.4206999038533995, 0.5684481161813154, 0.9674415459171577, 0.49429298957448353, 1.0203444067273446, 0.00812055618421819, 0.5595394266930294, 0.690255997597364, 0.9291514951683988, -0.2301747677173451, -0.14611353079655753, 1.0017878108833638, 0.4324489618961077, 0.03381642391823341, 1.0612853660942745, 1.0080402708203058},
    {1.2206008572307088, 0.8095385917029231, 1.184063080561495, 1.1590442679326156, 0.9812298423617747, -0.1706951880402018, 1.1480916071658964, 0.6435866801139875, 0.7161742595730176, 0.18515861740146922, 0.26166717601309086, 0.835373306207967, 0.7061820437310897, -0.09274690735674214, 0.7433924450562818, 1.1951459172186356},
    {1.023788252556711, 0.9359818899497906, 0.6193786354607286, 1.2286927444373883, 0.5990584334637814, -0.41388844437280253, 0.9106275208775189, 0.7066262575809384, 0.6555694478628279, -0.09867926105672477, 0.07438270095906298, 0.9718669556908501, 1.0915188650095977, 0.04878233938189375, 1.1550603309032508, 0.6498681485627495},
    {0.8574102628948049, 0.767966999340806, 1.198976146637618, 1.0249435429637301, 0.7020213838463681, -0.29206863852690157, 1.1016278566070616, 1.1160788840067335, 1.0266617883959033, -0.09668931559856563, -0.1533473756775793, 0.807003610105097, 0.555186737101347, 0.13800740742095868, 1.1806909717492722, 1.206642755094519},
    {0.26391683044696634, 0.5221057819177289, 0.3521649844561089, 0.8029449786230158, 0.3916149873289157, 0.06660059122815794, 0.16791304619563016, 0.5915581874711524, 0.33094159701346243, 0.11957844591482304, 0.12464650208313101, 0.6940589442960001, 0.13639494264085353, -0.06705414134731946, 0.19295015129128548, 0.7009309785639403},
    {1.1303087251061337, 0.9025073791717652, 1.0022371016089395, 0.597870648465339, 1.1226163575951076, 0.19774212253815832, 1.0320435284886222, 0.597002736937563, 1.2500037331515625, -0.37236824656472733, 0.042586277638041264, 0.597517084539219, 0.9020020436716956, -0.2166576149024225, 1.2331514925398117, 0.6833580089975743},
    {1.0786319603015166, 0.765132893642249, 1.113832803897284, 0.5650298728879396, 1.2403735808998375, 0.14234512675354657, 1.0686056201167253, 1.1228291997317135, 1.08311955508276, 0.028904829945386595, -0.1518971274132115, 0.8027002211828251, 1.0152973370105407, 0.13513677854737804, 0.9881378693130953, 0.9844111233085444},
    {0.903675864726679, 0.6910587906788246, 0.9529541645348802, 1.0697064012524566, 0.744178518679477, 0.235722262297361, 0.7515647797405318, 1.2214018218196319, 1.0739769943249582, -0.10654860632046428, 0.051163537253960965, 0.9028385969950464, 1.1528463309672041, -0.3199400303901576, 0.706258109485447, 0.6222479730601039},
    {0.8807370245192998, 0.7155783712797545, 0.992783061374053, 0.8614799387115644, 1.1259653961219942, -0.19379087648579446, 0.6420596092238673, 0.9666751491285863, 1.1268418783705685, 0.25880186198955996, 0.19839336551932313, 0.8437825639992003, 1.081315861753189, -0.3651825822778374, 0.659350799465547, 0.8679794144182881},
    {0.7729554485074497, 0.7058944289585223, 0.682089862255507, 0.7107986102116445, 0.9689379537983329, 0.1915992418126635, 1.013001692118158, 1.1644662578208818, 0.7731620546817687, 0.0006331691260283252, -0.21790756424706403, 1.1313839483408037, 1.0737887129058343, -0.34480009911134785, 0.6712240869314625, 1.0212557898000512},
    {0.3022320387910921, 0.5222018276304298, 0.23043796543136563, 0.1527455658203379, 0.24044331989192969, -0.2379850856683106, 0.710268527141213, 0.4210351263651917, 0.43692097238332217, 0.019133255837646756, -0.3653949776077009, 0.43393697451641555, 0.061068282279117064, -0.0769576750442364, 0.31586262417102184, 0.45999087591682886},
    {0.7161054513340063, 0.7344343406909584, 0.8274712835798527, 0.7032413914565623, 0.9982366068872444, -0.3165824102857633, 0.6645175423894024, 1.030433350897399, 0.9228231119159677, -0.31821833899064783, -0.16683855505099146, 0.6443705531585411, 1.125948700107963, -0.3022138873900397, 0.6128745042616425, 0.5877608919325681},
    {1.0113894208413514, 0.6197824072436151, 0.8143738985181336, 0.5920324583182448, 0.7201474739811499, 0.13886147531405585, 1.1667644870407108, 0.6884744173452445, 0.9248092409398128, -0.2820424303459566, -0.3424615201844285, 0.7258058523465338, 1.1649367643260877, 0.28371412004710284, 1.0046807058860627, 1.1245711325624534},
    {0.8551105570538339, 0.43994741036151847, 0.6128391069174314, 0.6317624842982836, 1.0805709892356796, -0.2788337613659204, 0.47004524586811325, 0.7086097841694472, 0.38702383442409233, -0.13271749498839158, 0.029428300898689506, 0.6014419674437022, 0.7595220090521306, -0.2786563334672346, 0.7614253854448614, 0.9427948747073924},
    {1.0720047745241428, 0.6145223238281065, 0.7954027452618367, 0.7257893063530757, 1.121959185075806, -0.31111600850022697, 1.0637043610361452, 0.9706206857667891, 0.646729083071283, -0.01642449597863726, -0.29458289545794664, 0.7076852862446186, 0.639779121394763, -0.29555032301310125, 1.1768110213550096, 0.5499117733097201},
    {1.0596881753469207, 0.586580627920016, 0.9383697961007132, 0.5851717764076239, 1.125128024734684, -0.175023365908427, 0.7138161540958878, 0.9417157015489979, 1.2755131135144455, -0.2815771286674414, 0.024838699947223382, 1.0039127262939953, 0.5957320846564833, 0.010995843225285257, 0.8192484392389803, 1.0849369002274352},
    {1.0022031990259324, 0.47586722047706603, 0.9725809537055342, 0.8107698458196948, 1.2587812820284479, 0.09265515346425966, 1.025122698218994, 0.6426332222520086, 1.025994234473966, -0.15905083191792913, 0.2936915073069813, 0.5979400211487058, 1.0980779097535587, -0.3278911803972699, 1.232950567919812, 0.512985103150629},
    {1.1956355222837818, 1.019623773869177, 0.9068303448129479, 1.1831788854725802, 1.243392725752842, -0.06693320271781981, 0.9598626883202673, 0.8381233534728498, 0.6489789037171455, -0.201391028496381, -0.07639775263603668, 0.9890309608323753, 1.019746728978241, -0.1565646462347412, 0.9896661622220767, 0.8720695259981031},
    {0.5878471796183347, 0.2221459937646997, 0.5508849933234476, 0.4239522537130353, 0.634054086337749, -0.2394933482110797, 0.8219040960687647, 0.7650213289469108, 1.1218775366955922, 0.2200193184949887, 0.3062018707518971, 1.1248297311913316, 0.4796940021860523, -0.1248307920525317, 1.1062076258061309, 0.846380764886017},
    {-0.07112481211101301, 0.27404159997977545, 0.09423362341071116, -0.13051394503098238, 0.0845997311909362, -0.18797426518044844, 0.29703958285452525, -0.17297739524997116, -0.1761623223262772, 0.08370364305150725, -0.28437997079960325, -0.026702905770672927, -0.0831820422112284, 0.01341447962047317, 0.2495726974358486, -0.1527702039186305},
    {1.1636649022432306, 0.5757092647573292, 0.6992856542047658, 1.1105298978268536, 0.5749234084148898, -0.22517885276633662, 0.5673226533454333, 0.7727185350592887, 0.7171529825774902, -0.30846134131171743, -0.040426473936339316, 1.2224851064184188, 0.9780252276234983, 0.11336468379105298, 1.2062656823615243, 1.1403030027733985},
    {0.8300212361114583, 0.9259641239394358, 1.0356309174237024, 0.8647510052180064, 0.7014465871028478, 0.043119071571188126, 1.2339792988772231, 1.0100356671565638, 0.9435405274072953, 0.02208722391755141, 0.13254584412307394, 1.056904205996039, 0.8369078015933253, 0.2586149671933964, 0.8372489096709808, 0.6241449100642741},
    {0.8069911552314863, 0.7477417171362764, 0.7318587065140739, 1.1947709843799046, 0.8692616178495515, -0.40818260285434543, 1.0143042531542323, 0.6725634490282884, 0.954484269464479, 0.12016776186892703, 0.14782014872493607, 1.104911103759727, 1.2552008971325002, 0.29402468305393353, 0.9183094427576494, 0.936531672290133},
    {0.3971159855706601, 0.8946394013049056, 0.5989912712213357, 0.9374931931908561, 0.842053349246703, 0.09558111937850518, 0.7107494198272712, 0.4487891432617545, 1.049500904896374, -0.2924261874128382, 0.15745910661486612, 1.0860921399081895, 0.6749946135624028, 0.26263056880035873, 0.49021793055470453, 1.039832483980536}
};

static const float b3[16] = {0.6157943037575166, 0.5709614549057228, 0.5442624191792137, 0.6958849285931225, 0.6789164695496019, -0.0782250970506449, 0.5291282605538807, 0.5525713788512531, 0.6230361956008921, -0.024887077062708263, -0.042927197331067854, 0.6875682834960818, 0.5220772882711014, -0.026212341516618904, 0.5843932484984538, 0.623750570242375};

static const float w4[16][12] = {
    {-0.5342659112762728, -0.9606504022393196, -0.8403390150383167, -0.6494491704681923, -0.9077051990083082, -0.9639064027642625, -1.1221815459496662, -0.6385379146337624, -0.6405405577845953, -0.31050619610517466, -0.9771276539273633, -1.0212855884469398},
    {-0.9118156334440298, -0.3597658852116234, -0.5017174613149743, -0.5163429139658147, -0.5684525157907958, -0.6295348778465878, -0.6325540998915521, -1.107014067724249, -0.634956487633499, -0.7378431121688287, -0.4330606110498412, -1.1485161403941926},
    {-1.0527266895837035, -0.5542973087582407, -1.1255641003284418, -0.6005529900829607, -0.8242521724295808, -0.8971417574745538, -0.6744117709925017, -0.9153171927224417, -0.7741847027935536, -0.9992706406985993, -0.7818885563699021, -1.1232640555024258},
    {-0.7868964386520286, -0.44955520681425787, -0.9133780109711744, -0.9101317052244797, -1.1891587027932906, -0.33862110851143584, -0.686138152459958, -1.109075840646321, -0.8782966767471106, -0.6807288821779013, -0.4822264456122933, -0.3819448048515859},
    {-0.6417999467889174, -0.7866047440239986, -0.4940947012545701, -0.7494518828840154, -0.5376779429589943, -0.883554283958638, -1.1196516884680503, -0.34280468796941554, -0.5137002007924192, -1.0267012347440123, -1.0738501528159676, -0.6072924301018012},
    {0.17895357240244536, 0.23545834891797698, -0.06329970624066693, 0.24197031101502367, -0.13253067880157982, -0.26680658062639234, 0.32791441437057267, -0.10321636809724534, -0.09676168312770682, -0.13553008694380747, -0.4630472224563867, -0.13259943980957192},
    {-0.8906674708113224, -0.8579359552627545, -0.697457508853005, -1.1450922597667654, -0.36434047193847346, -0.6332407709142588, -0.9336126730327711, -0.7137689019892718, -0.6075961230208599, -0.9620263789916219, -0.46506813529245355, -0.8205788438398646},
    {-0.43416677027439887, -1.1343873196423602, -0.2507972492922256, -0.5936255604156049, -0.9613283506607831, -0.7640329374054827, -0.7457661731289046, -0.8067542199176504, -0.9928396234818023, -1.0015798260506452, -1.0166530701185599, -1.082041977794137},
    {-1.131879380119061, -0.8443946567856468, -0.8151682728496813, -0.8632665211389177, -1.0885341811692995, -0.704758969648538, -0.5456713882796803, -0.5076541181775891, -0.29364238107824614, -0.6641171342036031, -0.7764974135207299, -0.6154618950445053},
    {0.24069213705183307, 0.19131972252169252, -0.3849967959738269, -0.03988490357932346, -0.3872747910931149, 0.39941782509038387, -0.17167864966350022, 0.42888799324277266, -0.3412866441077285, -0.15361097956134198, -0.16204111276158853, 0.3288007772002968},
    {0.19417546801699434, -0.32333184052802383, -0.12566612508617475, 0.31681642142944494, -0.3654050589622421, -0.36718099368063056, -0.22977351461127873, 0.42587185993592597, -0.17368234380340694, 0.24488447778637462, 0.2594750845115319, -0.4600269031157541},
    {-0.9515327793830053, -0.3398954403507612, -0.8165965548562923, -0.8067472160796701, -0.3595308259880493, -0.9336792464560091, -0.47273127470072107, -0.8078207597216075, -0.7429436070542638, -0.7802179260481868, -0.9616748175028301, -1.0804586429485123},
    {-0.5205292145051528, -0.7505030904727873, -1.0809936181565103, -1.1793900976496066, -1.0009524620729302, -1.1225491396347733, -1.0863857547692266, -0.6995876214049148, -1.1192765531410163, -0.31759179228820794, -0.8622920122085002, -0.3975466175922611},
    {0.2783893083543176, -0.017173713954727093, 0.2617244561412737, 0.36346080591715374, 0.006264851630531265, 0.060157706680672336, -0.09409317767895099, 0.2756819660880043, -0.2160877521462452, 0.23667094176927037, 0.2665440332517318, 0.07079986569614508},
    {-1.0773933198954972, -1.1246961839455458, -0.8063537314516332, -0.566809947180542, -0.33309887255566184, -0.4331600038952675, -0.6484400678035849, -0.7158504497232475, -0.9558747318481414, -0.9899781099313573, -0.8024614331251125, -0.6076567106965384},
    {-0.33712288893837666, -1.002388599900283, -0.8572310999112063, -0.5245382743260516, -1.1053078407813621, -0.8849627932228818, -0.4605299651183435, -1.0496669142742854, -1.0869032681715478, -0.7276648487017213, -0.5050863232688803, -0.4377683796197278}
};

static const float b4[12] = {-0.19580234359543422, -0.2776291962968665, -0.17990626203983243, -0.29522346120090287, -0.23134088474384126, -0.2452324768114587, -0.31342390698634476, -0.23883895523620433, -0.2950695512410666, -0.2245404958566526, -0.2044762703811208, -0.26284987559545514};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
