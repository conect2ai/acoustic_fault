#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {4.120983472931108, 0.8691855963285178, 5.229327623259458, 3.848843127226413, 0.8863472628358635, 1.5991645485103303, 4.163972599563305, -0.4051534435552838, 1.9991026691126126, 5.7257401248402955, 0.183835210930874, 3.048146800023457, -1.2803935319588318, 5.396765851789227, 4.1413898100169115, 1.4051473682074507},
    {0.7625693678869311, -2.1232121574486476, 3.6695951902223953, 1.1504133515535877, -4.174636012983645, -2.022416506799997, -1.261654468429578, -0.572342252704767, -1.086422029978221, 2.7029982556374255, -3.9855455605061825, -3.7442343377149636, -1.7520649199159397, 1.6194639190987152, 3.0078457050874823, -3.8452460424969597},
    {2.121906985744628, -3.856578462445756, 4.156417948783225, 0.7450379307797634, -5.265539712174246, -4.79873437248849, -2.101521290517901, -3.294925292331414, -3.3246161019306624, 4.444544634787118, -3.833037428016271, -4.961317278024945, -1.7292180984922292, 4.908106019277211, 4.5793203096457304, -4.487790275568983},
    {2.0587836514768996, -3.902182886536375, 4.076967271975861, 0.551601936388035, -4.3954590194285235, -3.974246399289722, -0.8903763394020195, -3.9789076270165955, -2.0407958555021515, 4.458048979810394, -5.2416615895890795, -3.5040466970096027, -4.22698256350155, 4.179404491501339, 3.7803716872360567, -2.993558429323146},
    {2.500319270159389, -2.2847463119885085, 4.232351104397024, -1.4762700159671955, -4.896122599363935, -4.550635641986663, -3.0962959838156006, -5.957842877859138, -3.467628752670582, 3.9550360018555804, -3.7375784746610083, -3.817431986790238, -2.1788252004883084, 1.5729480868529362, 2.7072450364344904, -3.6166490473919204},
    {1.902857146323648, -3.1728953222916276, 3.895213699067401, -1.6744019671520909, -4.141455328114077, -5.643439476758451, -3.1442225978176555, -4.477343930307118, -4.6364944450259316, 2.9302568748278066, -4.054744797272683, -4.691617278485346, -3.193307742058528, 0.06609508194458412, 3.9152987226631892, -4.373395864196307},
    {-0.07130640631343763, -1.5673379354223862, 2.8336021485406215, -0.9316059894962243, -4.054881489301085, -5.216091934253883, -3.2672922658495223, -4.539593901488861, -4.790531875733654, 2.8127063627964097, -3.486609084042887, -5.071034281733528, -2.6996021850772087, 0.49624406491676243, 2.5465274049378794, -4.616021373695844},
    {1.4361548370394226, -1.962740261501391, 3.351766848495094, 0.10415452866633394, -4.4995613366560026, -3.2748808145484944, -2.1836875512920306, -4.702988536075083, -4.159902238733624, 2.1332867017047032, -4.981473101341134, -3.2585015029292475, -3.323725283493591, 1.334657820566623, 2.4292920284604347, -4.6532689524680535},
    {1.6640496085902152, -2.2748781124099917, 2.9655134204988847, -0.8133170404798875, -5.491909802737245, -4.519885082966373, -1.2208093570029344, -4.019144167018314, -3.657181110436749, 2.911311540309834, -4.309664056931103, -4.597863077785566, -3.4577429511943154, 2.605739598343524, 4.320579625142274, -4.1507006532540744},
    {0.06468603496455069, -3.701868486104287, 3.470001594439758, 0.2608399029080696, -4.128290981503522, -3.4292323629362946, -2.6432935894165634, -5.0423400782645, -3.592448635332301, 4.05710636248556, -4.5834981779785675, -5.452431072281995, -3.9709812852443966, 2.218020069285772, 4.418176358052149, -3.4507322644703406},
    {0.03003848994721171, -3.942269480394283, 2.8461097432542646, -0.844415335574467, -5.128633622353865, -3.905255304855722, -1.6477688018264625, -4.665947297473071, -2.7934264667423836, 3.616729826070884, -3.9504099409009523, -5.5087131974326775, -3.334662674627059, 1.6431302983351737, 3.9532908306746317, -4.454319774637882},
    {0.5500813052628609, -2.664262372191921, 3.31302516389665, -0.8166559947395733, -3.3906883922723874, -2.957084849779844, -1.0008343325260212, -3.391060197397368, -3.165832587929266, 2.511095100177681, -3.886259970161931, -3.6404600651899996, -4.6896919834650515, 2.4992005104661983, 2.68157952942871, -2.9630757149979052},
    {0.7920740320237517, -3.797560711127896, 3.358864832145644, -1.4246361968041446, -5.354129175567831, -3.1834183681793364, -1.8218682288684835, -4.3285107837540915, -3.739224022741445, 2.4911870297957557, -3.8134111362857173, -5.721605310282847, -4.376786932444174, 3.6879594032517864, 3.47757570366023, -4.058215729851024},
    {0.8029215287595951, -3.900948988485877, 4.348186407765984, -1.519333624267784, -4.407335228062646, -4.529351110263742, -3.576301976649254, -4.106632288238337, -4.230265732444905, 1.19986739505284, -4.044206991060037, -5.345635457846169, -4.9819296245093385, 2.2679024032823683, 2.364701632938277, -3.7552152126833067},
    {1.5270194928546639, -2.154692911150095, 4.702986432339272, -1.2827508487613482, -3.3602904775774434, -3.9888675926011583, -2.002687220272873, -3.77865891786477, -5.08976296801973, 1.4494838669517867, -3.788105611741012, -4.049938450073617, -4.866771751381609, 3.250514704326014, 3.128367757118239, -3.3963413659508417},
    {1.245059702419837, -3.33158316308843, 4.733272327933927, 0.34004648585894504, -5.053548322286074, -4.355477004512077, -3.9341158909535383, -4.365195424208813, -4.17619332104625, 3.6026745180770026, -4.863688342241743, -5.779695626521095, -3.0264460640118735, 2.522899967419273, 5.215624937769652, -4.30020785307718},
    {2.961609754852013, -3.2714030656689697, 5.5943443181945405, 0.12660547839681852, -5.011401249054803, -4.443992659216182, -1.73213800336266, -5.119960063705739, -3.461717021684105, 4.51710444765521, -4.233807717764945, -4.275691856782337, -2.99069637138945, 4.930724683750946, 4.071188661084815, -3.664807890500011},
    {2.16227412302949, -3.349691070530134, 5.835359210851971, 0.6621028747884944, -3.4033116741074796, -3.3995352173536975, -2.3401344083047113, -3.487957417123511, -2.4722983250885515, 4.185930960695393, -2.038313755999476, -3.791367727205809, -2.518088442350272, 4.257379092228204, 4.6857375239651144, -3.7710055493027004},
    {2.8259518247533015, -3.3217752721732454, 4.134971177707446, 0.8139661784423025, -3.5886282614600655, -3.3054082974500423, -1.5889317891522128, -3.8836955511425733, -2.9507734721951464, 3.8228500045860887, -3.017120243240469, -2.7247942112977332, -3.258166146040051, 5.688449125922592, 4.851916253344685, -3.6281009154520842},
    {2.4511547333312502, -3.803852229946828, 5.4983975392823945, -0.5731936173061158, -3.1221378482444564, -3.4213180190293953, -0.9495750022178298, -4.197799163247793, -4.069319396975105, 4.995587731406686, -3.379565134185764, -3.556088390349347, -4.62907826270563, 5.469171517598758, 5.836254810890145, -3.796658979404161},
    {2.061187403869335, -2.8085562795619223, 6.085436433570081, -0.6406400368018054, -4.515946913776101, -2.2746928328641323, -0.5840153165915783, -5.043683519214875, -1.90819583632235, 4.062306887036998, -4.064601404248874, -4.146506119314, -3.717492699998412, 4.088071618196949, 5.756089844863941, -3.885243021066284},
    {3.2947744446269587, -3.7007322656788215, 4.928534443722424, 2.022317006732464, -2.6219565446802466, -1.7684485491009088, 0.4650898215521919, -4.282155419773655, -2.5283175695828293, 5.496415883674532, -3.70373686425484, -2.5739295488005336, -3.8234545106865676, 4.643458055480176, 5.148786076375823, -3.5735657066417184},
    {4.430648469738869, -1.5027768507659496, 6.148382862059893, 1.7345354257917478, -2.0158043494374143, -1.9692524349355853, -0.28704356268853715, -1.9670660811556324, -0.1934809400520838, 5.665919048845325, -2.8794159545227407, -3.2092855098321977, -4.0057420385609666, 6.634707342155333, 6.229293131189198, -2.597463624290846},
    {3.536733816575671, -1.9849194059275719, 5.702838532278394, 0.36988848524506107, -3.051028512666447, -2.60093678771058, -0.8783223976962888, -3.024321067653511, -2.7451136853705105, 5.896039778881532, -3.550135812164565, -4.158298248253374, -2.765632693250907, 5.20728268161771, 5.160750589140956, -3.3832520018662113},
    {2.150065512580436, -3.275817145723066, 5.203793952018014, 1.00973370261957, -2.991974475643766, -2.6893073008927866, -0.21634137968330627, -4.022284188456273, -1.497100642707543, 5.304830001678728, -3.311272663421004, -3.528770870966658, -1.9560209079264292, 5.068715782666122, 4.380706971549838, -3.4547711036555424},
    {2.6155451075244804, -1.4814936666783942, 5.279906186011655, 1.0170346657073208, -3.2712015316450858, -3.025515515320702, 0.909269880879441, -3.954307837914545, -1.6163812780299853, 5.518501752525677, -2.885926907552923, -3.4360403917980196, -1.8478076118850373, 4.791646245764481, 5.5249961165342025, -2.225596972323122},
    {2.906090240403233, -2.936790794392865, 4.502288469390312, -0.3102280185422203, -3.5060133761766656, -2.3736517697233945, -0.8709214885342206, -4.377584860699406, -1.6281923942066652, 5.648004308822131, -4.480620916170807, -4.329045909990969, -2.745578779366516, 5.070653399369615, 4.508081078234269, -3.3415540505340164},
    {2.9632610414579212, -3.01571783274682, 5.953628819725585, 1.0686905774739395, -4.229310038638681, -3.8224158339468874, -1.4080903295738003, -4.7284512079394885, -1.37958161150854, 5.5265946617707895, -4.953799984983841, -4.562759465462507, -3.2035512182679478, 4.3834089262287845, 4.370494561455459, -3.897632054424848},
    {0.9074202527523901, -3.6500453902799554, 5.354046830746884, 0.5915808980587672, -2.802764305125979, -3.1660153571493814, -2.2937732137564426, -4.64023284461749, -2.4031688359485863, 4.903425508921136, -3.4093374408826285, -3.6905043247304614, -2.541203389836473, 4.942875585822879, 4.122349390304058, -4.283709291827647},
    {1.2600283139025223, -4.319508037482335, 3.6216718636140697, -0.8574182715627878, -4.32254326093783, -2.8901795775153882, -1.414032075454398, -4.194431590174106, -1.1114971410057854, 3.877708074754127, -3.3836878039443694, -4.768839888773953, -4.093094749507622, 5.6128971473312665, 4.7170216413929005, -3.3245211390996197},
    {-1.892982372909342, 0.1862625099624377, -0.06227835372440674, -0.7939646316311997, -2.0595428259790913, -1.4907230081371412, -2.190514077584707, 0.08984215512576532, -2.252506107991155, 0.14247663226362645, -2.3304713130073798, -2.324715691323601, 0.19510455484928776, -0.0019328158491000997, -0.46923219772065466, -1.0192320921055131},
    {-0.41153118714567866, -2.7487608607499134, 1.4656001543249415, 1.0140134592664274, -2.8847420422061893, -2.528821109811606, -0.0725024564338045, -3.094189602625938, -0.3307706057239447, 2.6284740142407372, -2.2593075216314547, -1.8009412195032097, -2.9884197744388126, 0.9565980563973994, 1.137108948210298, -0.52377030559653},
    {1.2584943742996468, 0.9281215676239956, 0.6174428174471597, -0.9209398601202011, -0.6524963675754795, -0.46647441902402564, -2.0668238209749945, -1.3909569075189883, -1.2991445054797377, -0.9610334628797902, 0.3818472532203313, 0.05250578799229221, -0.5238168269931774, 0.021763450360624898, -0.2766613444763587, 0.4419336101611167},
    {1.7298465197996065, -0.5064721828180871, -0.6337682619419692, 0.061606029809490134, 1.2987280237865775, -0.4587922340112483, 0.057366992179707435, 0.3345804662813765, 1.7872499970647444, -0.4706915841880683, 0.3707018504259641, 0.06150207187406071, -1.3924993706190887, -0.6040930282820556, 0.15292119620555686, 0.3162695668006298},
    {0.6336347311311833, -0.8864711417478619, 1.6852227890871168, -2.307687717244018, -0.9428937767640425, -1.666675610874632, -1.0206508204955398, -2.4690650218125496, -2.1524203440890672, 1.0180976788943552, -1.5107398803299497, -2.7465988818019107, -0.706627253492323, 0.20772089467174468, -0.6713009378342515, -0.08621403918951973},
    {0.23663350681924822, -0.8145871488247661, 0.8814023407705047, -0.837855396412409, -1.8210402852199936, -1.4453414282948238, -2.9543665449982943, -1.6549171261873366, -1.1591138594511934, 0.833208761699453, -1.7162545281573331, -0.38998428756718245, -2.2963397046485454, 0.0603450437368909, 0.7160111328391933, -0.74193059201115},
    {-0.4878650182582395, -1.0513746860960258, -0.37208222088734755, -2.1071361386190963, -2.3148523171635786, -2.292257004902077, -2.942448063677104, -2.1539445723744146, -1.3782148416440378, -0.9797585108073067, -2.2389955355624447, -3.1363024074044112, -2.011685744180876, -2.2974062673284896, -1.7653236161155965, -0.6759715966260975},
    {0.5668227920677079, -0.43420081904999486, 0.18338383509704687, -0.5221500604189971, -2.624967656685865, -0.915714373068187, -0.7737214843787261, -1.3139229120219884, -2.229084547723907, -0.3779785990519705, -1.191949794335522, -1.496824988432255, -1.7094562802249562, -1.0627133959077726, -0.17233341336001337, 0.019490349048099417},
    {0.36955755597593953, -0.48412128425404904, 0.2150408860326375, -0.749979644238643, -1.2902059379203403, -1.8519196546718917, -2.2283780161432936, -3.3378149856045645, -1.3657910362094576, 0.3010303199145656, -1.2490820567126044, -2.4781328348245766, -2.5159212829979065, -0.37456565592026914, -1.6198677865752449, 0.27234851390162795},
    {0.17247351109807166, -0.7527226971133228, 0.46212954705063564, -1.4408004081377168, -3.808596855183567, -2.5911136198491387, -2.958998507059186, -2.0830628647574945, -1.850190274285145, 1.3460573421457904, -1.5088787972012998, -1.4155823192551178, -2.182622087309366, -0.08856088555839627, 0.9041010948047781, -0.2658385956877258},
    {0.3035677400114961, -0.8695235006738622, 0.5727634385743758, -1.7246976668303342, -2.0650337123237072, -0.945291669375321, -1.1379061742207208, -1.9122826954037342, -1.2256990365544833, -0.5317681899316399, -1.2295927945293035, -0.9808590781472841, -1.4939118540298506, -1.9471008202319189, -0.7548631999852435, 0.6327147486313447},
    {0.22354342494093069, 0.16725577482750426, 0.1639143255050692, -0.31174569056486673, -0.9053189128145848, -2.027382655192685, -0.9050959405600976, -1.2891339684516472, -1.0115404759465259, -0.1751326461821792, -1.1002092515601025, -1.4383594991993012, -1.8800331611509116, -0.5745649834019428, -0.26408612587163144, -0.6738781065632976},
    {-0.7401977919526951, -1.0951837889627725, 0.021181738639445388, -1.4273679621897903, -1.6042053411478456, -2.385778625303944, -2.5027395996263864, -1.7720044117841154, -1.957500502595169, 0.3183995264118832, -2.821694969738791, -1.2589243242987211, -1.9456011887881737, -0.3494003070300533, -0.2762199596105805, -0.1796912565922996},
    {0.17733116538095392, -0.23378071264671327, -1.0749205387001204, -1.425279484316464, -3.4154705412270974, -3.1585832387339656, -2.2935119494735985, -4.540962387288247, -1.6679310085986008, -0.15509869077661986, -2.3421451147457923, -2.696127726788931, -1.7909495973243112, -0.824724343586149, -1.0879916156728737, -1.5650397291653997},
    {0.7507277234311288, 0.31992248228539794, 1.0111206274843656, -1.6512594144576602, -2.3278976127595925, -1.8768047222026638, -2.139322304213701, -3.935260669455846, -1.9014097286110996, 0.10185107126619729, -2.3347020850363815, -0.7408949296633043, -0.2469867015657402, 0.2045978198465719, -0.8454930241678684, -0.4545564734564213},
    {0.1573212765903114, 0.7389236366251405, -1.2319567344431321, -1.9114215691694476, -2.074984947290319, -2.213915821503549, -1.480055032938949, -2.929718933842536, -1.4095340792107631, -0.8243432208358007, -0.7521847036824576, -1.8140524202129527, -0.9842821017693351, -2.660030987025069, -0.5637281559636469, -1.275781560871141},
    {1.1799103668870594, 0.8369494964854584, -0.6024051732440785, -2.207581993869333, -2.5835613409325884, -0.8128337275878756, -1.2851148445570517, -2.462849989619545, -0.4850853003703733, -0.821691314693024, 0.2178519654418106, -0.20820250281790714, -0.8376079451301027, -1.4757526863281978, -1.9000565574080184, 0.4182374115361225},
    {-0.252346991788383, 1.208726686534842, 0.5605130156579801, -1.4101226824886792, -1.2052294396804135, -1.0653733228862534, -1.2879090583564214, -1.4536985505730529, -1.4827144026531125, -0.9057769213403837, 0.0068150552682136566, 0.22362114980984338, -0.6458763816957749, -0.7240124129701083, -0.04115919455635558, -0.5767850429831121},
    {0.1948659633184889, -0.28992453778675703, -0.2441621618819705, -3.281113701928417, -2.357937190500416, -1.8335944025312632, -3.1875140464835376, -1.855437405724543, -2.1886469016931303, -2.245884410088601, 0.39413686669631354, -1.1315409065592115, -1.1906416304251264, -2.200178354496141, -2.4592164331659636, -0.31652853233361183},
    {0.579489518842461, -0.1863514072520379, -0.15412832518603287, -1.70014417451776, -2.676420943539963, -2.8781639934414236, -2.2922330342413573, -3.680045802789571, -2.1684115862520015, -0.7144352577146427, -2.3011580828485725, -2.05866310747589, -1.178155463478037, -1.9133889275169538, -1.4573114020655313, 0.13831527191683618},
    {0.22551719959625313, -0.49358521902699254, -0.43167850388959406, -4.089135228657975, -3.505514404346733, -2.309575901905606, -3.8667385792430746, -4.033446611753941, -2.530837240288211, -2.1353565783362685, -3.31614839908468, -2.053725389764726, -1.6572370674795516, -2.333297728860741, -2.5569349785826727, -1.712917148045062},
    {2.101935389224642, 0.6523285939614287, 1.99565191496437, -2.1402122740456115, -3.1954959320980034, -2.7549135443496713, -2.515848815407927, -3.7261453699299873, -0.7575204227319201, 1.8147801292069485, -0.11861282066913341, -0.5377549835792508, -0.8072801553079277, -1.3867124059022595, -0.6626167635682569, 0.39274763572509774},
    {1.4797697901870035, 2.540213477161368, 0.408747025040677, -1.5013704069122351, 0.4518679338727658, -1.3247406449336923, -1.292152438377661, -1.0786668194741746, 2.3394462824500692, 1.3281660599925391, 2.082056142975292, 2.4013831227186877, 0.8296499738362733, -1.9740962662068589, -1.5312304233832628, 2.963501711197511},
    {0.4158254825266757, 2.5948690641429537, -0.8249900983622654, -2.7589657082363606, -1.613200757112419, -1.5231651515495317, -3.3404336655957074, -1.4037504819129936, -1.1303671160133946, -1.4756783695932971, 0.19895739834934867, 1.326556135182765, 0.5410339748765891, -2.39244252770131, -2.4180332022369515, 0.9268926306630373},
    {0.7023222347521814, 0.20678573413411128, 0.594702833491218, -2.3046069369074136, -2.746122267932378, -2.4452933834914377, -3.6616368565753294, -3.9265280550017225, -1.863763211571067, -1.4875045949430592, -0.8507048694157694, -2.6038461182897152, -0.6651273775394329, -3.124706264412378, -1.2082671627452597, -0.892733138320453},
    {-0.1370833007202035, 2.217464417173808, -0.17608724222672925, -2.8737898113909908, -0.571067431485341, -1.9742086107775296, -2.00990953316838, -1.1713100457463115, 1.5133765182010261, -1.0951431551759645, 1.3949094968710483, 0.610982882136264, 1.5749268565677697, -2.4277165440832027, -2.0931479523260874, 1.255741127113668},
    {0.6676487925861093, 1.0922575732371458, 0.666942326335075, -2.4355043725508865, -3.2822196700458908, -0.9442216837183395, -2.532516214644266, -1.5435437332562296, -0.8171765753446969, 0.48232731233942616, 0.7443720784252943, 0.4841456783813364, 0.06820678508990288, -1.7107615272588812, -2.0789014864309907, 1.1367608324034817},
    {0.9084534854094242, 1.4241609815082699, -0.6790910674937813, -2.669815892121618, -1.978043855982591, -1.101334351322276, -0.9870761048269723, -3.3028639370071544, -1.4086695698326588, -1.3327558079529, -0.9908438306757179, -0.445327936448372, 0.9297343861231661, -1.8826550320936966, -1.4544306964369975, -0.362864720132487},
    {-0.2882336590010142, 0.45974150532531327, -0.7447910565644025, -2.894196666534637, -1.2418761750032974, -2.391804598952545, -1.737851944578571, -1.1502082392391193, -1.0340907080453443, -0.436972487397919, 0.23700944565029475, 0.2829813831312014, 1.4698772455412201, -1.5730488105043927, -1.2839578819076256, 0.10113359058293778},
    {0.7127204354141042, 3.073250698045718, -0.42136589871836233, -0.9796300665147214, -1.8445786393789245, 0.35362578688167884, -1.2282183603406656, -1.527836925300278, 0.8227206600603987, 1.311403638351189, 1.0838915747097129, 2.311181403653827, 0.11995740911499846, -0.2800765167702186, -0.931243639647268, 1.6487801618219238},
    {-2.852839514869026, -0.9969342197332808, -2.445357333347191, -1.6188919083454953, -1.2599860953050583, -2.391755621723103, 2.0369488267329765, 0.13171007679341395, -0.0318181108093475, -0.8830138570686757, 0.29669158055795125, -0.30598158526084, 0.3960780241153114, -1.0791890317971948, -1.1525757104687453, -0.8751912271076128},
    {-2.937709994621808, -1.7417518758533919, -1.7969358927820114, -0.6305531237130199, 0.43962007866157815, -1.6748461761729487, 1.9473329530226462, 0.07656393323284823, -0.40520492047855244, -0.762645464725703, -1.0759952461100284, -1.2067465691366517, -0.31369315026035804, 0.02837527894929583, 0.22359042797665094, -0.5506413605372922},
    {-3.1026382130267707, -1.1035579322217017, -1.9401971326516103, -1.3891231519727505, -1.5956057665336638, -3.0009672557307177, 0.6990537002734641, -0.8751740271607585, 0.261232662372016, -1.4137893201869804, -0.44285324311277435, 0.044476499517048164, 0.03715555639811251, -1.1804910313330255, -1.2829495552468804, -1.7213592680932333},
    {-2.497023743229944, 0.8808188282673706, -0.8388464478569969, -1.1813230874390972, -0.15282971782833843, -0.8502587062136387, 1.3957313414080936, -1.1590517479688454, -0.8602309160556721, 0.5182782076164604, -0.7917269919653014, -0.8442724283497854, 0.6305006105315173, -0.3238318562859086, -0.9242332846967761, -0.30789484282999824},
    {-1.9061962691361212, -1.0384746336517057, -1.2946149936192444, -1.3572140685547007, 0.28587839279861765, -0.7673974923350763, 1.0431315983153402, -0.4577501393793046, 0.6161229878535294, -1.0134556755657214, -0.287543339075166, -0.3447022889977157, -1.0135284754923142, -0.36428065356215106, -0.7546334924267499, -0.7249033748436934},
    {-4.2190175391410625, -0.3290700976073298, -0.6102203586046785, -1.2680395488210627, -1.1084542681185292, -2.5633322094532227, 2.6030529313526447, -0.2057456865026626, 0.8039292640528464, -0.3854897862653123, -0.5574575445265504, -0.2001589396089833, 0.11731557153484018, -1.1433264191305843, 0.15219701383871712, -1.4758052423031174},
    {-3.967246010862845, -0.5350901000907384, -1.9758783647530995, -2.437284923927391, -0.620058929951723, -1.983311737363053, 2.4504709904467767, 0.955470915933588, -0.017474838852509392, -0.11328897564222422, -1.7163653298588832, -1.0904435126841394, -0.3990567553852236, -1.6519509063060647, -0.6477333936508495, -1.4961672725357527},
    {-3.58425397540826, -0.8884300148073466, -2.7275071918559712, -2.012806796417854, -0.547329265487216, -1.782721521209521, 2.0437648929263186, 1.2476475036565258, -1.523547996780456, -1.007872256686073, -0.8107262882055396, -1.287496062597887, 0.0971240012331198, -1.6077086679654478, -0.9909763396068944, -1.4247283651028009},
    {-3.9225510330632707, -0.9367658219850398, -0.7820302211768967, -1.5632840282810339, 0.3083785063978159, -2.1696834122997046, 2.432379903521187, 0.5701580953704426, -0.1463276609440625, 0.15968665105205748, -1.0749226553196398, -0.4349853741516705, -0.08394976607405036, -1.0636316853798569, -0.2953698863107093, -1.2984297319719638},
    {-4.1227448104209055, -1.0020268250794688, -0.691370046803513, -1.5137305279157143, 0.2287593489740507, -1.4414929954683107, 2.546889289262497, -0.29186129884689405, -1.0621515835258923, 0.5572273865390429, -1.7553471426594232, 0.15944554317421927, 1.4543072564923742, -0.036992381365441813, -0.0314183171003247, -1.1583423068144405},
    {-4.127153387424179, 0.545864670550922, -0.2353358733698256, -1.1717900718601133, -0.45381374602275953, -2.7323270888933773, 2.913408381747948, 0.3347534917464481, -0.75524039863301, 0.18884753291111422, -0.6111175597908904, -1.2451483907465426, 0.7135569632330854, 0.004870566174076085, -0.5570259371473937, -1.06654900538637},
    {-4.561106737078021, -1.595227824913884, -1.2073061677491632, -2.035759630266243, -0.9375517327535866, -1.8328738733707397, 1.4420074920040082, 0.11320699557584712, -1.2298756691321673, -0.08994111809680173, -1.68254291092926, -1.7855194131111531, 0.49881604489748776, -0.08871433213245059, -0.2905966954345569, -1.8174642288120981},
    {-3.9958591445062606, -1.7251982661028635, -1.053755790519652, -1.4072319269313498, -1.7391810876647296, -2.064244823861177, 2.259473930388871, 0.8403074312433702, -2.2178486340833223, 0.7092147133505436, -1.146228359955821, -1.2855020007589282, 0.12038780628596417, 0.3573223897734657, 0.41930279345986626, -1.6497381418787076},
    {-3.8879535956802367, -0.6248675841939869, -0.3780129025926278, -1.927238801516153, -0.3915791435661496, -2.8024577272002045, 2.8002504770060908, 0.8104037013832384, -1.5065691981004294, 0.19709413825628969, -1.7078785432819499, -0.9605588067799125, -0.6688667394587677, -0.5021817662084853, -0.25286145154135925, -1.254610671172701},
    {-4.51063806073677, -0.6935006876786166, -1.1503240429104504, -1.3734142912911915, -1.54893051992682, -2.582571668920956, 1.7603763550927598, 0.19847813417621568, -0.37643537406662564, -0.7437083946983652, -0.29291030253973366, -1.1749930900880519, 0.14364298769081507, 0.1556243215670868, -0.6339673145079296, -1.2146577795053184},
    {-3.021246279156934, 0.5399847516116906, -1.403085001339847, -2.386323153951295, -1.4827672765150963, -2.210142151488212, 3.3083561513094852, -0.479795969327782, -0.8284010680894633, 0.535262461053436, 0.11791688553579008, -0.34137999513848355, 0.5838355039158829, -1.0332747929297161, -0.8961233072637859, -0.5931080178671757},
    {-3.901266464855334, 0.6115549661281525, -0.6039523291542519, -1.6669250379640266, 0.5319974768402482, -2.2040342563183897, 3.7905449761796506, 0.6744547891986101, -0.4016866320091162, 0.4382302536429561, -1.6491934255674099, -1.7029639261427236, 1.318965238061741, -0.671811728502603, 1.0433563178670984, -0.9293081034839042},
    {-4.3106820951063645, 0.7202266034813228, -1.8243618621460587, -1.1237617201272356, 0.00405763398469644, -2.680738832150613, 3.421154164208041, -0.0986069783909967, -0.49440178507672744, -1.3572944912105092, -0.9106654584755262, -1.7836649604716415, 0.9136903001373136, -0.6785494249943249, -0.4424505495868332, -1.426384227628486},
    {-5.293994691018512, -0.7133423860863957, -2.95193208130106, -2.5164958108920206, -0.8199540388451143, -2.448239881999204, 2.6663720180396115, -0.1911176358108148, -1.6021755633461032, -1.1924040466307522, -2.030928041615284, -1.6245695041682184, 0.14069942873969685, -1.4981264907635339, -1.2520929244927148, -2.1947752640108886},
    {-4.209795516034909, -0.7489977542601246, -1.6615380768463122, -2.2361669816772647, -0.5862791868809618, -1.3506117017977513, 2.7339708322555754, -0.6493246311877329, -1.0682560708969797, -0.39700376968149526, 0.1186020278752397, -1.4594005650248454, 1.4813699075926277, -0.6310692241967237, -0.9594589364937066, -0.811649831419327},
    {-2.9734291347381006, 0.8492305300467057, -0.5725816458149476, -0.7782830335188872, -0.6590010569649444, -2.423565576414256, 3.2626334586160715, 1.0321338170054684, -0.31699588965021597, 0.6615700222070764, 0.04829180317903907, -1.0794800180011166, 0.14161173617687836, -0.4924413563734975, -0.2549663356891838, -0.1835087215852173},
    {-4.195475385889336, -0.9260957639503916, -1.7609946495842084, -2.3088585171513643, -1.6533520697915531, -3.6022993640308685, 2.8507939990694737, -1.2952107516220985, -1.8106072522167154, -0.2050184090157773, -1.4816047731425719, -2.1856513079103057, 0.2643056072043862, -0.8286314402674234, -0.48782962410696173, -0.9185409748518774},
    {-4.379712002921164, -0.23693636015555586, -1.4547121073562541, -1.2943511219736954, -0.4969131627187091, -2.8498351579069783, 1.6572063461246116, -0.9267408804434089, -1.3717997763513492, 0.5490532304030067, -1.528867305552005, -2.0830778587137337, 0.07143349164578723, 0.06738749107569005, -0.9150147421698591, -0.5039317171505558},
    {-4.476992586058442, 0.17024316593615535, -1.7504292058120283, -2.0773015365789016, -1.5217054657840368, -2.8513830512680403, 2.927417509310498, 0.0297697024104517, -0.5316029660330689, -0.7315599371106942, -1.6835155038303393, -0.8970060959978047, -0.8558719987518296, -0.1552155739195602, -0.9515040528582873, -1.2406142160689333},
    {-4.47804480122367, -0.5544674214269463, -2.025121689099463, -1.4312341088669185, -0.6361427184867958, -4.2791796413854835, 3.6385775196485612, -0.9298464290694275, 0.10471895531680117, 0.6219193962453883, -0.8428540942778773, -1.1860960645299228, -0.0025476241026178665, -0.5069697735944457, -0.21857852901116492, -1.382936701164805},
    {-3.869627670065238, -0.13998452619921092, -1.6634002065677527, -3.502481350366151, -1.100895891862036, -4.460069903946306, 1.8761466211394888, -0.3981032706082741, -2.038789328051095, -0.06564935140081367, -0.8530045162602164, -0.7199426951936693, -0.25561563064656706, -0.7623214283768834, -1.0814937888503215, -0.7884869896220192},
    {-5.393351709494346, -0.6947862635918224, -2.0161724179646905, -3.3965800473675944, -1.1542557048470838, -4.235061640414255, 1.410062859478375, 0.5484439369094944, -2.2298437596614353, -0.36992053897923094, -2.933633776429871, -0.7792260339226833, -0.34867176292860474, -2.115635009189876, -1.3279133459654429, -2.4432184946725353},
    {-3.6951599584403594, -0.47757738553317086, -1.4014018101735173, -2.400618167684464, -0.6124292141946476, -3.8378961416368647, 3.845544144559234, 0.3130722870528236, -1.3886448618334972, 0.3420938251458185, -0.757472375955298, -0.8207315067237881, -0.35820057027704033, -1.2321096544339898, -0.7123554775748453, -1.1269734088668892},
    {-3.055847630256833, -0.6941560766700049, -1.238283701643242, -2.213147674306124, -2.1747650348179333, -2.602993026017238, 2.355244393710595, -0.7505831608319673, -1.0439646010943713, -0.4481707487944862, -1.4504931661184501, -1.6552028218234178, -1.0397763445373671, -0.5124645328218258, -0.16286115603082946, -1.526080047276608},
    {-4.734619249090666, -0.38607388643678237, -2.890918484952105, -1.8951293781400003, -0.924810121283044, -3.464218695677478, 2.998158830539581, -1.6212310659243858, -2.6227011043089803, 0.48187211180684925, -2.497369906614976, -1.6644288594417114, 0.46851982971744405, -1.173429796950945, -1.7317085549887994, -1.1846780556336673},
    {0.3253333417718111, 2.379519802651003, -0.455229361674738, 0.14604212301689679, 1.5889269081769253, 0.395098061799818, 1.299235460765414, 0.701797563522408, -0.021453577206712256, -1.9839313266013217, 0.46127061074896863, 1.476877275022168, 2.9309970216573897, -1.1512573833913353, -0.81624923403794, 2.6926001588326938},
    {1.0720198030308086, -0.4427013975896064, 0.6550279184502655, -0.22224670946046068, 1.620715052384847, -1.7446725942754229, -1.6737623430085902, 0.672717594855188, 0.29280121718098284, 0.5496320180508496, 1.547482427232448, -0.7237900015325333, -1.5121142444547624, 0.2810965373456781, 0.14225326504111932, 0.7994978582903313},
    {3.136004666485102, 1.0599119118049234, 1.0853614913351177, 1.1620324438202088, 0.1396636116849131, -0.7109062534824249, -0.3395919369680234, -0.2643918992609246, 1.0486184023876333, 0.39631669097668804, 0.8237006293951918, 0.5070430024916593, -0.04864298643703065, 1.0851873836499362, 0.9497120373501263, 2.1617570898970584},
    {1.9853356234348, 0.7454504042779334, -0.6114824142449702, 1.0431194301564257, 1.4052178607907129, 1.437427390401614, 1.0877027990203765, 0.8452270260883782, 0.22429138721678998, -0.864802467401337, 0.42705692239145454, 0.7801097741213753, 0.1612451400175924, 0.04378556250957804, 0.7295318099718167, 1.0090264807125655},
    {0.0879321898225951, -0.23948025461469544, 0.48934314418517366, -1.2864133457475782, -1.7461195232107083, -2.2864445572108956, -1.0643327019342896, -0.4377275614826272, -1.9120594182179198, 0.6373597227669201, -0.7871955994002499, 0.22165701642700708, 0.12717684711315025, -0.6657422258456641, -0.2506213286185729, 0.6615192453896988},
    {0.656461662578524, -0.2715675306303219, 0.1367769954912285, -0.7732944214055456, -0.8506923946535274, -1.0079921981884048, -1.7782405245651882, -1.432940025911244, -1.5068420892027725, 0.9731022993816244, -0.10280399719971513, -0.18051305841651905, -0.5726976559958176, -0.04371934242424403, 0.1755185321568981, -0.3960207250390404},
    {-0.5355293897060563, 0.7055894200631281, 0.7438475601767669, -2.087995101151668, -1.4473908274154128, -0.9488490945079834, -1.2544419172437236, -1.637186624636457, -0.9880671364009388, -0.8422357435074518, -2.2313522996904194, -2.5202649854798223, -0.6212492140865029, -1.1447899820307341, -0.5086272234179168, -0.2008508052707918},
    {-0.9538252477910776, 0.5738994962975358, -1.0776833973636075, -0.46733010660115815, -1.6528117433187426, -0.5033706436248857, -0.033048358725407324, -1.463369431911538, -0.8277221548398404, 0.22709748462408336, 0.4167955348633404, -0.5841620566345567, 0.021305942905169475, 0.21551931494613522, 0.0340728213690049, -1.229283368695288},
    {-0.5441606485790159, 0.39423575479129874, -0.8526480953074238, -1.1076195854690596, -2.221874759317895, -2.3988139417891654, -2.1083614673737627, -2.8841320663902725, 0.3831529018657046, -0.7192407779248031, -1.4009985474818456, -0.781402440153519, -1.5734772560212023, -1.3982457555242886, -0.9230995680319001, -0.281178174886807},
    {1.2270117072057536, 0.6517172808506192, 1.37508722903481, -0.8844852242239319, -2.8350282854378177, -0.18440472453644438, -1.5444449360455592, -2.061131946637779, -0.9671483100787309, 1.243501972314194, 0.13415447020517263, -1.1677031608518431, -1.063369816706041, 0.3753672397657848, 0.23671541578505692, 0.011938057681494847},
    {0.8552073581133026, -0.4259721652985791, -0.8394512988226263, -2.0168069061045757, -0.6616420647413851, -1.8730344529577319, -0.5230778971377136, -0.42409905289654215, -0.3696520111156244, -0.036124245598825634, 0.6234431537325669, -0.8717581083129423, -0.285167878961378, -1.745513002562079, -0.07444139172693905, 0.9565656682661166},
    {2.0642223244201996, 0.025202719886761357, -0.397844026337526, -1.1425231370560633, -1.4972266194062136, -1.2084663794001878, -1.723171838803586, -2.179240634604345, -0.3536183347983699, 1.3218113940744245, -0.8653324680325967, -1.0678835325615095, -1.3879120790063533, -1.236790727287765, -0.032350357109436366, 0.18193316995275577},
    {0.41119490641091183, -0.4471894020820966, -0.8762571918417824, -0.41617821117042075, -0.8687117927102607, -2.0453962762434488, -0.8033701522455251, -1.548726820780805, -0.8565289199126206, -0.9996583686834942, -1.8823195503890722, -0.8957264477571502, -0.7945514872338766, -0.9994464266951242, 0.31985867931491646, -0.6024220301409838},
    {1.1884175665804217, 0.7071179339990681, -1.4111864337143527, -2.117938815037661, -2.122536507864915, -1.704722096644251, -2.0385257441621247, -2.196499981345452, -0.7396375162625969, 0.02052203607411208, -0.6951698590933477, -0.40474216186786266, -0.6503108295547758, -1.2796423419997205, 0.03533617843390287, -1.005964980286762},
    {1.9105826559931498, 1.5644846843657776, 0.6998277758368971, -1.3235403432081778, -0.9928565068929788, -2.4377294513465952, -1.8356977473227682, -1.1706873958615116, -0.49815782368465866, 0.8560558733194633, -0.1498874586602609, 0.21591046763018293, -0.318907152460996, -1.1657936737807348, 0.26632889067334636, 0.7228768916050049},
    {0.7509206144763193, 1.990504874204773, 0.41343089457902965, -2.2079665193522047, -2.0142616705651144, -1.8593195002391916, -0.19120022554336075, -2.322941479828671, 0.5350677808018119, -0.9841241486519152, 1.130897436061512, 0.5711613891517727, 0.9372865515079201, -1.58391372327794, -1.9981857630769198, 1.2059824483818344},
    {0.3817633790051216, 2.6920522935974605, -0.07479075493299606, -1.8829384305310475, -0.06889236642370208, -0.8005275511603289, 0.1668639708087738, -0.9874404155893665, 1.2574603618499254, -0.7268571319814174, 0.87206644037038, 0.3469532674051368, 1.5088767376624797, -1.7748943667614445, -1.5166810851354389, 1.1234536531952315},
    {1.8814246322461516, 1.4698935559026793, 0.2654827977684088, -2.122958837847165, -0.5600523263540779, -0.3776382055493316, -0.9509686220900617, -1.5733907795884345, 0.4160782341811581, -0.07957313771784373, 1.4468884114968668, 0.6059543074305938, 1.501859117898807, -1.945637787703317, -1.4852289398820773, 1.7514354892176867},
    {0.8622119111338141, 1.0325797687502818, -1.0424318451772563, -2.2883191161452743, -0.9577640207599016, -0.3100826872608584, -1.2014254901138495, -1.61848336976059, 0.17742259216757225, -0.5894648390074744, 1.3355019468704152, 0.09625597139100762, 0.9915984231490633, -2.162986406018208, -1.294220681033011, 1.2311172777024733},
    {0.3149659650935021, 0.5598354067474076, -0.9042058121858855, -1.4846113954516946, -2.6795125177203034, -1.7051257380955378, -2.039126000760389, -1.733254236854893, -1.3691939755204994, -1.4143693885965647, 0.2901800011644189, -0.3803205650635291, 0.2843336643297504, -2.8030541519853185, -2.083410512788756, 0.5825821119311392},
    {0.7428033143669613, 2.520927314300515, -1.1978460508535171, -3.1227447989313655, -2.556108481527711, -2.56550584170621, -1.9802983331820656, -1.7492364413696633, -1.1686545341579628, -0.7599181914259203, 0.5714077633517399, 0.7636702078446812, 0.2015207886756619, -2.814721421053413, -2.5309911966581606, 0.07130741278589829},
    {1.6047356241355748, 3.3653531029753787, -0.0864824033108202, -1.51327289121755, 0.0963889872211481, 0.11737443811487655, -0.8373551834840518, -0.7936676326139339, 1.2151090969601743, 0.33648264511837467, 2.266517484847448, 3.4588552965533306, 1.9410059504977775, -2.1683864223021225, -2.1447153848520837, 2.5201128322883504},
    {2.50817985166293, 3.794852988691464, -1.7394504801505546, -0.7075549892855756, 1.6318587774019715, 2.2977886579915707, -0.0252035624710042, 2.174493062573486, 3.247056112328109, -0.7237195877145629, 3.9534002169128044, 4.140222522606733, 2.701765923154643, -1.9466929040539838, -1.4616299820388012, 2.6815900579961425},
    {1.061714210432941, 2.2482483874320733, -1.9521323298552227, -1.5538569430825102, 1.7592078687862192, 0.8539930043859109, -0.14921297922230448, 0.6547384642025803, 1.4724597567089874, -1.796495128471998, 1.5529555046561632, 3.234983564084522, 2.9612466455334916, -2.4942270374181734, -1.83010959833705, 2.462738254623687},
    {1.1098107770468686, 2.575188177892304, -1.157300809660391, -3.1319655266947777, -0.1679206711003056, -0.4426798418487991, -1.9269933939476693, -0.8548124137628588, -1.189806245844455, -2.276872177338944, 1.257241815206082, 1.6015386385330426, 1.5516431603020333, -2.9884845560635616, -3.1148411105910965, 2.261975397607397},
    {2.504382662916472, 2.838684600577074, -1.3921516696967877, -2.4274892558362042, 1.4729312835559145, 1.0602460852684208, -0.5623789745069863, 0.9898100608868673, 2.819306587403925, -0.07129204412363632, 2.4367943842862516, 3.2356598218852386, 2.4925200865483936, -2.5141914633417097, -2.652726409839704, 2.963492199762192},
    {2.410915410839319, 4.261213949588023, -2.4265495089944573, -3.2158515228068163, -0.4508613355424494, -0.04990348748483995, -0.5954147714704541, -0.3679757427850588, 1.9169279669135926, -0.900495103310315, 1.8604439358036278, 3.0876104933208777, 3.41201584309517, -3.243376858156663, -2.9093067594232576, 1.8717197741685134},
    {1.7566069140892162, 3.4239219471526687, -1.1944329837529652, -3.330491700910132, -0.44612630288854793, -0.5710283136861585, -1.0742137589519694, -1.137581407664248, 1.4322667549142014, -2.1831085622974946, 1.8328295426389498, 1.8165245980025817, 1.6137255214467143, -2.152664287246113, -2.473389677183415, 2.2914554488480956},
    {1.0744016068709676, 3.875176734967479, -2.259650678406062, -3.3998189621345483, 0.9384998367167525, 0.3763121539009727, -1.4708183886032682, 0.5258999561612863, 0.6282770931482176, -0.45200793964882463, 2.360884170187554, 2.3280915153208546, 1.634272967111489, -2.6532842801281156, -2.878572599077044, 3.0884487979722275},
    {3.1058560441088217, 3.8868548822148523, -1.6726328966095687, -1.6443802225020911, 1.176804640649769, 0.5231004801813742, 0.13784380310410121, 2.5606980196828246, 2.139853630121223, 0.06748487610999022, 1.7777160797971314, 4.148255943670836, 3.1914742521113624, -2.728615539919455, -0.914277313462425, 3.168649770686478}
};

static const float b1[16] = {6.302515856345065, 5.835730693008593, 6.294179972941133, 6.14232487275803, 6.019540163089843, 5.846187769700192, 5.895471035667558, 5.996292964410527, 5.345312752829737, 6.431021850959241, 5.770197223829662, 5.872100539379309, 5.28269086258824, 6.395091575245787, 6.488857768139397, 5.20321318698502};

static const float w2[16][12] = {
    {-3.5267489674484014, -3.3990457623318298, -2.8288151029575586, -2.92833113035579, -3.326763107596401, -3.1460430539293327, -3.515206230455944, -3.583102421984524, -2.8022348670127526, -3.1936787092455714, -2.709154582525873, -3.6488433811289327},
    {-3.4311043098831218, -2.9081758132666264, -3.3981455351185224, -2.9163635676797517, -3.9938868993756853, -2.3606723543900365, -2.032763027494903, -2.7320833372784032, -2.835714780700953, -2.9626044869124533, -2.5817715360004656, -3.5505398386264706},
    {-2.4201954499438094, -2.1242468117476188, -3.15566862395421, -3.3441627551085062, -3.096306186293221, -2.5098361502799746, -3.1902493686679856, -2.7275479637365425, -3.1249657587317263, -3.216128862364407, -3.847677324185094, -2.452869248573306},
    {-2.2635612132227254, -3.225971534217926, -3.3719729706527444, -2.1623794812969144, -1.8175370556955686, -2.8466280139075195, -2.538807346129638, -2.744684288928629, -3.215124900105752, -3.0794785271664504, -3.5721968257942787, -2.119076863708864},
    {-2.586900825960301, -2.7222229906366278, -2.225881644785792, -2.354286462701526, -3.3898633427618776, -3.19120299493592, -3.975721346154145, -2.6026665845306134, -2.2341138726305574, -2.4355411516200314, -3.244553964499628, -3.234468152675475},
    {-3.0250287833707903, -3.5160409214151276, -3.3771488017150735, -3.702012431707993, -3.292257122283308, -3.0268802629227847, -2.160985498329618, -2.8411313638650233, -3.519617161147782, -2.681019697006162, -3.270535071046577, -3.142619824732496},
    {-1.9972724591632052, -2.5304214140487735, -2.5634921604620375, -3.035437046670767, -2.3642248513171213, -2.4309348669118807, -2.610051159220586, -2.710220947386363, -2.685765953493387, -2.4141105839417945, -3.195028916396252, -2.590998744854776},
    {-3.0889371638828256, -2.733236043770057, -2.6799365117252525, -1.9605227433337282, -2.4598431475305116, -2.296554805890911, -3.602164574640221, -3.1910897636620232, -4.013394016800432, -2.8958721292028566, -1.9155432066254117, -2.598865901897082},
    {-3.467296172516321, -1.7804123060154018, -2.8672228304344647, -2.7908869077118426, -2.451255784592169, -2.4578234955129816, -3.43774179919584, -3.5249556823185895, -2.635638234753044, -1.9457720911344236, -2.862784945593845, -2.3484732465016314},
    {-4.481280505263143, -3.1188498800146123, -4.210683193699921, -2.72715728896, -4.192216435416989, -4.259301360917381, -3.1318658638825125, -3.9108562721821745, -2.703324550920459, -3.226338623480681, -4.481256850709081, -2.5424956772082736},
    {-2.111676612594995, -2.834930437231607, -2.1719346728858815, -1.7979725874170633, -3.157375771986295, -3.7746766688459346, -3.590968619956344, -3.628568410374651, -2.9558201350740188, -3.920210730752034, -3.0241781708728768, -3.3343776482005905},
    {-2.7176774114984825, -3.317189524232624, -2.9107581488394225, -4.185530569262224, -3.30754841870216, -2.1066913500486617, -2.2454774630969223, -1.9232237083234531, -2.5004831623727393, -3.367396884167778, -3.763296910803468, -3.123557340544092},
    {-2.9576630108437283, -3.0405931160212742, -2.626847508005643, -2.207680890756273, -1.7222840662367376, -2.878851358518155, -3.406078571501304, -2.9675060568248366, -1.6678455259368787, -2.550074704867802, -1.4526878119849451, -2.026500362526525},
    {-4.016797644602426, -3.531983883332061, -1.8230556369323605, -3.844937435984923, -3.8497986153060015, -3.129007139282748, -3.1013923739520837, -3.7005121026546344, -2.7849398003035493, -2.8288038371784605, -2.237750146713843, -4.218672072765877},
    {-3.1520704143758858, -3.822343709971666, -3.698577829473954, -3.5023484379002685, -3.637076736835094, -3.290857651070704, -3.113863134045797, -2.230211119983172, -4.232184814222127, -3.4366108212165365, -2.3424837044229174, -3.3875978316844404},
    {-2.470011817226747, -1.9554326486299234, -3.4792395829442855, -3.378907744838599, -1.6903336918744905, -3.0840066072137913, -3.091902573098845, -2.2982069315325173, -3.232297678746082, -2.4303364879100564, -2.6680419079470394, -1.9750922264718886}
};

static const float b2[12] = {-3.6844730664775223, -3.72074506389361, -2.1465898396357552, -2.751043297104484, -3.275794378352056, -2.680834862729656, -3.071855107015397, -3.3800384118309434, -2.4937748769444914, -3.0723333674635307, -1.870578946441121, -2.9131277642850066};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
