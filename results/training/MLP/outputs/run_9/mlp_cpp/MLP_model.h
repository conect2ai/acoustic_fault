#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.5271187357875371, -0.7616825094430816, 0.19945638239280616, 1.774250266416499, 0.7074443883424111, -0.9287464593534385, 1.9213047535952321, 2.014530673638965, 0.42507534627217247, -0.598866799469078, 1.119274627322138, 1.1445690831726196, 1.6353595268200392, -1.2940310412127818, 0.7260677571386469, 0.9307593388549404},
    {0.28631643318347555, 0.5046295850838286, 0.47837026192143706, -0.4880306170885309, -0.013098790477433593, 0.27422343545884964, -0.6513107591588386, -1.684167513089338, 0.7599741078585226, 0.2867605871557054, -0.10619420788507158, -0.41465908632945464, -1.7379284388407754, 0.7101765338507737, 0.024094724668856506, -2.464021610978284},
    {-0.44800039499852, 0.3472191419112394, 0.9757472593708012, -1.6387044148806944, 0.7757208052607162, 0.515068070693305, -0.6502509595763718, -0.04869118042413761, 0.5135209403640945, 1.1386476542180877, -0.39813366051938626, -0.29622245291336025, -2.615118846234529, -0.24156308361231044, -1.517373118827076, -0.01465785302172728},
    {-1.8581718677452839, -0.5422137169602322, 0.30376495576737456, -1.5067615483637735, 0.9610863782520833, -0.9147312340988486, 0.06268123524362286, 0.0398887513649623, 0.1545990647601717, -1.4040857232316994, -0.5496437086315425, -0.35965989244583685, -0.8390926036100258, -0.47078713543085665, -1.0906186597030099, 0.654778950355792},
    {-0.6514191623164919, -0.11831648789720176, -0.45171414050054925, -1.782927772011811, 0.8125853754220962, -0.7446159152079573, -1.916093529986198, -0.7462651059445453, 0.02064277868666706, -0.19649170924413922, -0.7723768350473448, -1.9925217409117206, -0.10441811290820854, -1.3283352922278213, -1.619579910438991, 0.4512458031501585},
    {-0.7866868666961547, 0.3274359374822443, 0.42902950857024574, -1.621628574033732, 0.7937988884229187, 0.719501940100897, -0.8017108970043074, 0.2571192679507088, 0.0795223957654469, 1.3440228596086763, -0.5463042355028193, -0.8623475713940211, 1.0320566360857408, 0.758617509307472, 1.1342462894760732, 0.7662629057125955},
    {-1.363589083580512, -0.20299299339762472, -0.3930654651290129, -1.3460562682785895, 0.3733436908194999, -0.16193166538081485, -1.3318522589958557, 0.5922242059303124, 0.41785455110245107, 0.18624141879003184, -0.3957855258371197, -0.44942367980435555, -0.3075792399797403, 0.5228079599383264, 1.1188482498551138, 0.9273942763631994},
    {-0.19035386064504736, -0.1497555774530349, -0.26312271880192706, -1.0194620351666108, 1.3080099734813826, -0.6370200028174569, -0.7595708142685498, -0.24180487294052114, -0.07926358414565632, -0.4484311626332894, -0.6970906556097, -0.713499639745931, -0.31392700445494204, -0.724797997679545, -1.1299242563519785, -1.2843710531295607},
    {-0.36585282837967703, 0.6368429967210884, -0.15086400376755335, -0.282056872678225, 1.9854133496522686, -0.33238977385180896, -0.9005744845021502, -0.10115744162504223, 1.278374543940239, 0.057746185773124216, 1.4595803593829826, -0.48079197364123516, -1.4182775165325012, 0.40831424840431696, -0.25042247494152214, -0.5768571649752647},
    {0.8472345926667404, 1.2949475919595859, 0.17718327323385613, 1.0029551519327145, 0.02574430463308093, 1.1488643872804856, 0.07411611710059493, -0.3708118345264364, 0.8165454550645284, -0.5322119825896602, 0.2715527871861239, 1.1071409198533684, 1.4166721999098288, 0.9204363518632676, 1.6153463838296578, -0.5866707072588699},
    {0.2425272795763649, -0.6847693781575768, -1.112084323139777, -0.2385063176179483, -0.6443599297259787, -0.6355505081794486, -0.5695095578684685, -0.5735844342226889, -0.7818788775822342, -1.1293119345436406, -0.813078239194673, -0.5613547757439372, 0.8127619671525521, -0.5400328866739678, -0.1536363679974668, -0.8866522192573507},
    {-1.3283463546280876, 0.6546919720280244, 0.8862858015054291, 0.12327337365268112, -0.6314652765483716, 0.2486542276797479, 0.3124981435316987, -0.8844154843733915, 0.5616150534057813, 0.6896769504759286, 1.0244051173122142, 0.037230083092632336, -1.0568311595907025, -0.03556939834046054, -0.07633742484688574, 0.3476744437904708},
    {0.9381491967527904, 0.5770079284554412, -1.002663409481912, 0.48515190084735554, -0.7191442064275845, 0.29210032934466507, -0.9901305016586999, -0.2942411346944534, 0.904349129980487, 1.3185525644309355, 0.33249908870745293, 0.07666674618407533, -1.3021876070811929, 0.7296738054392762, 0.4949502082296132, -0.6408973609932567},
    {-1.6031522482933915, -1.3096028121659726, 0.5725945579256244, -1.873764396198136, -0.5595179212334154, -1.1013386912420287, 0.7763524224254157, -0.9853560244298284, -0.7148153768828437, -1.1417948785849887, -0.8520952707270082, -1.3362975303261946, 0.3109810988431476, -0.13045673560100718, 0.9482233325716932, -0.7700773911100653},
    {-1.7505174097479956, -0.09579857175598579, -0.7130904096357344, -1.0885644044640854, 0.07799274461151419, -1.0858620856087264, 1.4170631981927146, 0.6362477683790625, -0.9859762423777962, 1.3419631254932665, 0.14211938110980873, -0.29309113903251877, 0.330945400935801, 0.47374249239300986, 0.6839120440761406, 1.516025543432696},
    {-0.29057373654766777, 0.852334197571279, -0.39686249186271944, 0.21633739587766798, -0.19398482315902785, -0.21149103686642662, 0.8176142588831061, 0.5909117609091535, -0.4562042652444223, 1.520677087757354, 0.8639352241195682, 0.08826000811778496, -0.12231113942519073, 1.9192504296352346, 2.246301201180076, -0.07234019626044526},
    {-1.528462968108411, -0.8803435161287079, -0.1571638736455105, -1.3421216032163528, 0.4816606823552599, -0.7987651075350912, 0.6957057000700542, -0.18230842819391588, -0.4337706589439552, -0.9386891444862355, -1.1687765760633373, -0.6650468777456272, 0.6998263399678305, 0.09008854358060721, 1.278251359009632, -0.4540775777064686},
    {-1.3596346307551324, -0.030537388647067547, 0.050127375340360374, -1.118633523034476, -0.0589226456860775, 0.4659513259789907, 0.2683656439667542, -0.6330744604595828, 0.5338919053371624, -0.08922486236489838, 0.29384690019278825, -0.6738331789689974, 0.356502961166011, 0.5015200146095213, 0.873370361999654, 0.3011716853626793},
    {-0.8246823816997363, -0.9662602409114424, -0.45391191912648027, -1.3041806341204294, 0.1477366727376713, -1.2735017979411314, -0.4846637977244168, -0.8253669797291799, -0.05447535279913217, 0.011460797701655447, -0.3714519004062248, -1.1686714500813513, -1.4687368764745037, -0.4748172764539948, -0.7826915678782006, -1.1275459105854257},
    {-0.7601875530881399, -0.05277457575242815, 0.22198697688703029, -0.202941235496427, 0.349479599014354, 0.0643129939137294, 0.6305830408493327, -0.17094037713009877, 0.49232578605546284, 0.005779713152606811, 0.5997493217499723, 0.685295329374059, 0.7068687790927854, 0.2590487835735303, 0.02523586524139397, 0.018510679666297},
    {-1.522312189737502, -0.9042186114050271, -0.34430443490766016, -1.4421227676000064, 0.3766298420012195, -0.8447718469511379, 0.0639631587059188, -0.7292461541919119, -0.47873570436227203, -0.43168849330161524, 0.06014816679574221, -0.8346775633883143, -0.2233915657853726, -0.2488606206257427, -1.192118787555439, -0.65724741708135},
    {-0.9951857987019749, -0.6787125695238866, -0.1690817386102944, -0.9818047676091138, -0.6512030161943879, -0.5455507657021048, 1.0034375267607851, -0.3978698049784445, -0.3335109837714911, -0.8226504714798499, 0.18836502001678904, -0.4561733343454405, 1.9551269956141706, -0.27978875753273297, 0.6609840372648967, -0.33180585933352774},
    {-0.23508855492343095, -0.40206791664026886, 0.6459288152992736, -0.37061530111042895, -0.6325469561351892, -0.5181540941231711, 1.610075473208544, 0.13722352604322158, -0.741993306758242, 0.6490212079948232, -0.28279236350821124, 0.8369161426428174, -0.04625989032432698, 0.5371785696612691, 0.34667741067919206, -0.08340534408856742},
    {0.6278596372499482, -0.5891325729788659, 0.5406729945371119, -0.6567487060490728, -0.7150253062358592, 0.2832018964880915, 1.0001771229461518, -1.0140158538191926, -0.34082148418958264, -0.3172756043496312, 0.5741938928642626, 0.022667910315376093, 1.5108428080734904, -0.4229195198970288, -0.5581164286917731, -0.44911582846364195},
    {-0.36865971586669327, -1.3988493080491737, 0.4314102426601748, -1.0080113524161978, -0.4348495715993102, -1.159507154190558, 0.5583767034013433, -0.4792321769368013, -0.5759110147812203, -1.1360171667961918, -1.2382847165140207, -0.2657271757662123, 0.8096840885049192, -1.366240151561698, -0.03270900160644993, -0.4287691723791271},
    {-0.012263334039344976, -1.7991014862091774, 0.1290435027686776, 0.0037066724002750703, -0.35908822059431883, -0.6559801737634252, 0.2651827901228107, -0.8117978730339771, -1.180264780051297, -1.2884104271931118, -1.2351226559479178, 0.32362332457368836, -0.4933839295077238, -1.708581421893877, -1.1529414686663055, -0.6723870944517512},
    {-0.5193577716945271, -1.0703673876423228, -0.6690226217902431, -0.11997115850531904, -1.7687887772254949, -0.20746011914919985, 0.7457500844330717, -1.2481551425712472, -0.8238213500104358, -1.2297270097644413, -0.519922120553671, 0.20255819208159756, 0.7434704053037414, -1.0140368634353636, -0.379689680977894, 0.446492882664158},
    {0.8634323605679822, -1.2113319307872845, -0.31631466886805065, -0.42800323907233384, -0.8931863128988308, -0.8271256342968114, -0.1687802677915272, -0.41542821291603643, -0.4400021743736265, -0.020784129698331717, -1.134833940437557, -0.04177640722208249, -0.8477683836343657, -1.4257009164497203, -0.4871381850088195, -0.4381568793760298},
    {-1.3757932007463405, -1.1501137363949065, 0.39631128977350216, -1.139819954317665, -1.5704033503595967, -0.32769400342470045, 0.3719856005831625, -1.4661000414931495, -1.0395088633017906, -0.8648933912686679, -1.1100871959863403, -0.4583764015044679, 0.5067935480191895, -0.7398406561680871, -0.5911338929496686, -0.45131139823021404},
    {-0.6112382118203058, -1.2045925325939753, -0.24343425318449893, -1.460053068778026, -0.6471442377933913, -1.0084958475880688, -0.3897008014495401, -0.9870299046276886, -1.0821643946500612, -0.5696060611430017, -1.3226237182152076, -1.4918844611611008, -0.1468835535965119, -1.4935700774265233, -0.44729168846645384, -0.33352725067271716},
    {1.3508415029166523, -0.9038931074215971, -0.037910649556422045, 1.2689131937357971, 0.06445720333725308, -1.70750401394508, 1.7529384633664575, 1.9504637347324048, -1.3981064333134916, -1.721020977009436, -1.974625881910027, 1.4413080174548127, 1.5080229464513781, -2.0367726032249487, 1.6553024887770003, -1.1383596214682055},
    {1.518689160623375, 0.2866605481108656, -0.15134329035377964, 1.4225794978617563, 1.0761569059430236, -1.6749593030224237, 1.9783803910565658, 1.895357166966746, -0.8449391306943067, -1.572510844470985, -1.5662009100975895, 2.1070069846970694, 1.5210662988342254, -2.029485466420049, 1.6498828056564117, -0.983074251765424},
    {1.8560943344616665, -0.13725334564429498, 0.6485739554970191, 1.8376783036857833, -0.08678928833516109, -0.12807892540051855, 1.4335145637408053, 1.8490591256591278, 0.21491883039780543, -0.33620117331046095, -1.0360848642364509, 1.6307724104729908, 1.3868714461562177, -0.8871474251507067, 1.1757632139540521, -0.2950360315110499},
    {1.8644683320321798, 0.14182699902775528, -0.15177457567891117, 1.4010836284827315, 0.27862711776411336, -0.9887797251040135, 1.78864606331053, 1.9853435720082022, -0.43893208301140885, -0.778836780913475, -1.5735937858581739, 1.6304005578411744, 1.010847709232861, -1.4397782547411022, 1.1304496570796356, -0.601534309949155},
    {1.3382750786908708, -1.0551964247046908, -0.07154295598362168, 1.4603433650783648, -0.051699914252263196, 0.1153888550200507, 1.3189854896360247, 1.4093330021879664, -0.5377679386690949, -0.2247691245590477, -0.9851830647018949, 1.475055714922656, 0.9877341879159562, -0.5527507270417887, 0.8061070743379488, -0.16872398471298955},
    {1.066817473063145, 0.11698609092380612, 0.18354531951649855, 1.8184977449819164, 0.1906468672512182, 0.9071065949153855, 0.912901174103685, 1.3545452855031213, -0.24897494974892007, -0.00974030390449658, -0.45089200432655796, 1.505625043486016, 1.1145103319920107, -0.43457663191102475, 0.8207509098746196, 0.3293438198521559},
    {0.7133374635105437, 0.34454741388263127, 0.02632608966254466, 0.8952869815804314, 0.04340655788872151, 0.31188645235696777, 0.5568551623582104, 1.0063911440784132, -0.5409395409575729, -0.003612195587374118, -0.7953841058513047, 0.8043594959571968, 0.4028302803153138, -0.5957002669526826, 0.5190458088493572, 0.2281304096779879},
    {-0.25265792178644586, -0.4188330603043229, -0.10549364643911799, -0.44542603313251483, -0.3575105807873498, -0.09744466866777748, 0.08729359293273665, 0.2664898547291752, -0.24732100567692414, 0.12350145793498048, -0.16083277767810378, -0.4453605102243451, -0.042125356535603696, -0.40622539409301445, -0.06445523526071383, 0.6324756170944554},
    {0.8177315506669605, -1.278208001534349, -0.17026224440575918, 0.7338333493363681, 0.22590441379447093, -0.7680302794103667, 0.49781044022511495, 0.7285465556646785, -0.8973844177535232, -0.5109425958110517, -0.7011199498716402, 0.5136059722021394, 0.11648181082477316, -1.1274085551023825, 0.2742714873341713, -0.14815281900799676},
    {-0.24981348871772072, -0.7338985268229772, -0.10335111307703976, -0.06798118669156264, 0.18372649805866312, -0.11724087477643404, -0.13635299667211542, -0.19216516459497027, -0.42604675253140734, -0.08242241926498074, -0.1362094521894686, 0.06075009114539355, -0.3811432937308821, -0.3326278252510652, -0.0719004513043103, -0.47482064660858636},
    {-0.5415105543267832, -0.1775748832238214, -0.05382349644327057, -0.21854665183907115, -0.20018679653333235, -0.08974606209352966, -0.11392776513130219, -0.6041391925036498, -0.5429616029877274, -0.1805960567950241, 0.2524284239380908, 0.02489582470193481, -0.24040650345379425, -0.7079853454841325, 0.032280863419088424, -0.23552879551482386},
    {0.6806652108280442, 0.2439477366403803, 0.17900392036939472, 1.3090297299353773, -0.0776490314969499, 0.23996717956434988, 1.2153664843564875, 1.1671864247169037, 0.2265670801924453, 0.527698582368604, 0.019460336434393603, 0.9184903163141861, 0.5952915421281427, 0.1935657171784392, 0.5452132024912163, 0.0335110101936398},
    {-0.9626681967215412, -1.024205571483873, 0.3793413215742289, -1.1485369327958357, -0.7241133991586712, -0.7773559858283732, -0.08991112602256711, -0.7657102754531804, -0.6400214188154625, -0.5021761946078339, 0.22139504263852003, -0.5350395043074693, -0.4546499152900352, -0.4057629124794471, -0.20978779209620801, -0.32309714042443327},
    {0.04687534173499243, -0.13537108172490434, -0.3268215370887615, 0.22071094650884182, -0.09775218496698361, -0.23521855494105745, -0.12440887444304861, 0.03682871221589676, -0.3142019044334102, 0.05211798989410507, 0.35719373052304326, 0.14889194848377, 0.07615093096192715, -0.11749919871362512, -0.13308625066691288, 0.10664216339721228},
    {0.3614826815063099, 0.735862706834027, 0.22221804102692852, 0.7714339457119916, 0.7506223775638142, 0.45624214778657607, 0.6731703729590106, 0.8576227298567841, 0.5054128093847328, 0.4252035669194966, 0.6072377843235328, 0.8685980199354808, 0.5313919579952058, 0.026570995023393953, 0.38255759741026696, 0.006748039840241116},
    {0.6292549895951377, 0.10167824449821655, 0.381475348630734, 0.7707250283987892, -0.050277928203971714, 0.11181695906065159, 0.9525658004718902, 0.6738255171827904, -0.21398735549007267, 0.06733526120695162, 0.16169550490305973, 1.1386401554478034, 0.6662731749663234, -0.11727242001860247, 0.37711441447305766, -0.16879651424769276},
    {-0.5599812292386407, 0.09790777458325407, 0.33803039135348695, -0.47166302719912523, 0.4189748172668532, 0.33035062879325194, -0.02914452959877428, -0.009622415979243374, -0.24390857217075013, 0.45604076623740647, 0.38831764646843675, -0.44260434449870795, -0.11908854883423807, 0.515745353736001, -0.39136935615863755, -0.11608872698727507},
    {-0.5007704398694789, -0.5060642603395499, -0.06697281693753135, -0.7425382327602807, -0.5389350826928031, -0.10709883780424354, -0.9826323330386322, -0.7749336253291209, -0.44940194798363736, -0.3934850318754905, -0.43743928204984533, -0.6993895999812122, -0.6790992369446808, -0.14587949823099305, -1.0474692343877334, -0.1933446754846607},
    {0.11156058862149025, 0.5946774609114359, 0.21536536728294123, 0.09413217959172487, 0.3937646777024692, 0.36728059248765205, -0.13477064386784493, 0.008623410424523468, 0.4831459152610892, 0.4293430281450771, 0.3440589384599271, 0.3498112143948076, -0.11973311146241909, -0.22249202030747223, 0.035092272598315856, -0.18695137742948356},
    {0.10989515687709452, 0.15579549477915938, 0.5257546329003668, 0.39642877440818497, -0.15215867039164624, 0.46493735175599493, -0.06984063182057836, 0.20235167249784844, -0.581938191533676, 0.6854295184832304, 0.23871689465778623, 0.13961499934252172, -0.16659096483930264, -0.43114328194931323, -0.2114326934776161, -0.1544201662492975},
    {-0.6009383893039288, -0.020097461539164106, 0.4373954862256371, -0.2410039296223339, -0.4774770314955579, 0.45083464381069793, -0.17536930795130914, 0.14455139440061876, 0.2713438301443046, 0.5972829391162484, 0.3273741557944299, -0.18603271831344173, -0.494660846909396, 0.39830282527909705, -0.3734989566858166, -0.02310015518587914},
    {0.2935561372876258, 0.6163730894834754, 0.29234932039983014, 0.1173469719027852, 0.2269328948608652, 0.29818516710627563, 0.39381399100712183, 0.9375931513082439, 0.7366008752009434, 0.5767048515574037, -0.21348275505245407, 0.6937138091494844, 0.05077197587990697, 0.9836936780142681, 0.15220071173443056, 0.24661148968105545},
    {0.34683143630224755, 2.997434361390596e-05, 0.21698217579934886, 0.28951865962340534, -0.0010809094050916036, -0.4343571429683507, 0.16926387181136673, 0.39182050762689097, -0.5397317703580572, -0.40621075939044754, -0.34127096951844194, 0.8027913174414633, 0.28258162719837815, -0.03867017192010801, 0.39031456124938446, -0.2400607101536671},
    {0.3512944388585241, 0.06501884801620388, -0.12835227330821486, -0.39887452874381707, 0.44999693431122945, -0.16183575694149493, 0.09350740258368251, -0.08451406326238874, -0.47478955364430925, -0.7459992000511619, -0.7130280678437988, 0.5937634772589071, -0.036208049748877466, -0.16790327219825954, 0.21046588210807285, 0.18808461069404833},
    {-0.415300691417866, -0.3287869054335253, 0.07863973455053967, -0.6290745257861017, -0.07706933352536273, -0.91058508313429, -0.43564560757800663, -0.3510636390586044, -1.146648617130803, -0.49686907836052063, -0.9448180441779137, -0.3564921261506477, -0.6364321589026074, -0.6164733100242188, -0.5368562566936856, -0.44207320897764335},
    {-0.23691113778550504, -0.21014980831702673, -0.18315576650488313, -0.5343831873831029, -0.1446464772352595, 0.6367371221091475, -0.28625058496501965, -0.13378871263260642, 0.036108270082629824, -0.4804845513771435, 0.2737841365670592, -0.337996921253288, -0.26592900799654784, -0.21327047162356716, -0.32849790690169745, -0.039597611111712665},
    {-0.1713304564614555, 0.09767504316342689, 0.06589880620604954, -0.04424360317347396, 0.09428887466487691, 0.2003739642381961, 0.370259717185778, 0.25144523322933476, 0.10793455837086227, 0.43302759622474607, -0.0014998272027711202, 0.7327517172453646, 0.04965342405190244, 0.014834684658625722, 0.5405005334241589, 0.18586647307362925},
    {-0.7166464449209543, -0.18781277211647907, -0.0062489978892224666, -0.6868549399923525, -0.40879538415006444, 0.15752921235387007, -0.528933902166879, -0.8891217809721198, -0.7558928843045808, 0.12357997211388687, -0.0997636607172438, 0.1767444599659008, -0.5829113098235914, -0.6617931713392853, -0.17844620685627124, 0.027347621026670724},
    {0.7151008443088056, 1.1020165924747345, 0.5982201113943851, 0.6459247865028606, 0.4428249048959935, 0.5110470757971206, 0.7998495751034883, 0.6658513692522637, 0.12521475368610194, 0.15512694975993177, 0.5126447617449581, 1.1467018832323719, 0.613945700547443, 0.44519793012174713, 0.8837428563305032, 0.48690163704818606},
    {-0.35520693504703316, -0.22822049737477867, 0.32147015787822114, 0.011118656339071706, 0.33685977096495506, 0.2295790634476192, 0.4588554740162956, 0.2863416264651707, 0.45698168703081765, 0.39063286600961405, 0.2316543508725886, -0.1085823545433142, 0.25530737248955604, 0.18062622502581002, 0.23705746049134147, 0.20866451597695398},
    {-1.031818650443111, 0.33820883591241496, 0.2202092367558422, -1.0307990546235475, -0.21658156829712225, 0.28938986508273956, -1.1143546687167922, -1.2821597828831177, 0.14342031673538416, 0.16366540386738498, 0.05172015628411784, -0.9962584991540556, -0.7555403096876967, -0.3180221939996353, -0.5923840773135277, -0.06487322427228896},
    {0.6367842598936178, -0.7968804599709246, -0.19625885027372691, 0.5646070940083365, 0.3350937862319438, -0.27302641868583205, 0.4641022877896994, 0.30384512495413263, -0.18015246019830614, -0.007990022515588422, -0.2542183442495035, 0.5381972264469385, 0.213661475161641, -0.45353791624305734, 0.362311105788055, 0.02461649114458499},
    {1.1297245652926136, 0.2709346403253378, 0.13102483250542354, 0.9118749174832324, -0.17350039887735974, -0.6170357637784665, 1.1180210910641608, 1.030101285100966, -0.07521122395326087, 0.034693128046416, 0.02936979007457516, 1.369850417084494, 0.8802325589729332, -0.0874113084836552, 0.8785503384177726, -0.11119918328944105},
    {0.9085918882653157, 0.07341435142720291, 0.08279007765716781, 1.0245161637917057, 0.3862806711357967, 0.13949767205328867, 0.9476809951624221, 1.2046122805381265, 0.2809985069270283, 0.5183920361102252, 0.4206134282139831, 0.7593014049496587, 0.7070151625235855, 0.07868562641399114, 0.6697680606588938, 0.05886619518946777},
    {0.33132557854885175, -0.5129112390998687, -0.429527337445369, 0.21863993073855756, 0.13781503552667349, -0.3175872845225747, 0.33544356747714693, 0.1973075864445123, -0.29548196213329836, -0.15560838645589073, -0.7715758483834291, -0.11396149366899541, -0.2071474045081374, -0.24217728649818843, -0.02968995722497147, -0.46485201563212536},
    {0.5021787264772468, 0.08487071437831241, -0.16863471565998928, -0.30719675864693524, 0.21793531349975115, -1.0087438685198284, -0.1314447057540357, 0.12804831950661383, 0.173015195462088, -0.5739739497566169, -0.6811786740331687, 0.08675249144921347, 0.09722796254972411, -0.5883784372948503, -0.4420280970444936, -0.5148944242630468},
    {0.9479606485737531, 0.06385897989437833, 0.25463051841887024, 1.074038598234642, 0.15270027091743474, 0.18731006190126687, 0.7071604121235455, 0.9345617726801976, 0.7646994651140815, 0.6442193726053883, -0.1269727833312699, 0.7424269848707855, 0.9224950769058181, 0.46834956990122945, 0.5946049545306424, 0.03481262797517753},
    {0.3004567553018915, -0.5532676300343867, -0.4619458711460511, 0.4476390504758006, 0.02935866092622294, -0.4106982605146308, 0.09007023715452159, 0.40982037432360324, 0.1498687884702728, -0.3958072263050278, -0.44940353422824564, -0.4194497057073975, 0.10250628456649587, -0.283500791584916, 0.10221940330192579, -0.2937703038631143},
    {-0.29664323212332233, -0.8718035960640623, -0.1273874503404034, -0.3305322016627566, -0.25413197635213286, -0.1165417808749296, -0.34544657698806586, -0.5999521924165941, -0.6966427509875782, -0.4488228085261732, -0.34031354208797254, -0.6346688593889721, -0.7539860284773268, -0.4539821025432091, -0.24831323843935216, -0.07506621242236473},
    {0.6105761077917216, 0.19199807943756841, 0.28212341027391563, 0.6693391353572583, 0.6262665504382792, 0.7021658635947695, 0.7877593744073224, 0.9055863139069523, -0.039109574147542014, 0.18933859235013198, 0.7722292412510338, 0.6866467195838675, 0.9426810837946646, 0.2673596138640552, 0.8575040799513363, 0.4756322087756192},
    {0.9218524789814624, 0.5746168391111149, -0.11824698731042975, 0.91600135647331, 0.1419291755768755, 0.3717928454835779, 0.7939211884220797, 1.252387317671202, -0.014112627699572378, 0.1292510502076343, 0.15222008596620598, 1.2679464935050606, 0.7320204804720626, 0.027779790109388858, 0.8968032116076312, -0.010502244005814466},
    {0.9371420747479787, 0.7104492476396129, 0.272471955129918, 0.8556138233225091, 0.2446511887614312, -0.23462961302560761, 0.918248262636076, 1.1616298560865754, 0.3253897897072261, -0.11029464066469226, -0.14540093990860356, 1.489982963427662, 0.5259259056871152, -0.20856905752214103, 0.2157013724130163, -0.3922452014850281},
    {0.7402774386760888, 0.5166216680922947, -0.019986747942454624, 0.47575072444394434, 0.5967579617519988, -0.1421055622793828, 0.46834101078997376, 0.8906929703089435, -0.032074775052534955, -0.06985793506430465, 0.11422364062246951, 0.1498956209871786, 0.17344691202310147, -0.061200620896739354, 0.27849251236264116, -0.2841317929652205},
    {-0.16521674703364775, -0.07420257183600922, 0.20307829759440543, 0.37246209558337345, -0.11444340268437911, 0.27928563219168906, 0.48952062417288533, 0.1607024144902453, 0.39162201225940463, 0.40550536117529346, 0.3285216885602475, 0.25160037389185613, 0.3080733533777478, 0.3977358532711662, 0.1318263767549985, 0.2727749378022606},
    {-0.21517602650135728, -0.5495773741282289, -0.3810558485615539, -0.4807630147880884, -0.14277635973587205, -0.6047635282617588, -0.1560499520492091, -0.6132307758994734, -0.3421043514199966, -0.6306149346060129, -0.3674890904234215, -0.17085487783403014, -0.43871391383703706, -0.5119753728314856, -0.4046765147749287, -0.33066756255664},
    {0.5598618730376943, -0.31997411967149364, 0.0705788781477376, 0.6776387002399261, 0.18287109933642529, -0.1366742708764396, 0.4876868635651941, 0.7435072346565312, 0.06281711350665625, 0.20002538942467293, -0.19474689094516118, 0.27904425587148735, 0.3862734074905973, -0.05046066644035258, 0.6408495970583419, 0.44632491251524004},
    {-0.39327539207378487, -0.10487893094971973, -0.004216048082746999, -0.9534333029359918, 0.04237401358555491, 0.1863313662452315, -0.5227463273631681, -0.621663508761918, -0.2162961701304344, -0.17487488022074907, 0.33894668997251676, -0.4193437485049843, -0.3693441769448644, 0.28495647680208896, -0.37413257862649996, 0.29051114947580814},
    {0.5533456944944225, 0.8226146382048295, -0.41256804987339124, 0.059248744096456085, 0.39190160332651913, -0.3328080269036881, -0.04326979198107421, 0.48156555438727244, -0.02183081466436974, -0.4489862801350899, -0.16809755829052617, 0.6119007641681505, 0.22716262860852687, -0.25046178421071624, 0.15324562166393638, -0.12314320064553201},
    {-0.2659470939338466, 0.09300181736667207, 0.09922460000889305, -0.1032002844584594, 0.0510697758841041, -0.3131777839908133, -0.20534410995515567, 0.23996961664135433, -0.14521776598017802, -0.2673117297195094, -0.22849316582936996, 0.23012423933832668, -0.3192732833977407, 0.13803710722910517, -0.32025374747449664, -0.11821890065053148},
    {0.9142082722142952, 0.26036374546512675, 0.3061552509689907, 0.9385865946400455, -0.07540800603377223, 0.08648164093747887, 0.7369160005289079, 1.0761255750854375, -0.13968839004672526, 0.0635534789757014, 0.08932945739111114, 0.9644951551416671, 0.4951229662117267, 0.5124549125650721, 0.5753830940774521, 0.45949889149303663},
    {1.0834011389610727, -0.5203531836024695, -0.21924156479390386, 0.08386089898560493, -0.13765310808865047, -0.9815771871107042, -0.2022776312340659, -0.44054137324571724, -0.20849607866846553, -0.18975523553099807, -0.28116263101894, -0.03445910707820291, -0.0844891295823419, -0.37536733790416044, -0.2048301870129797, -0.5612693139526287},
    {-0.5979964398407619, -0.2240565290249654, -0.6276372983961322, -0.8305407196747034, 0.38988242424528313, -0.2865882759985374, -0.33069741907825245, -0.830111042300609, -0.37168208415664516, -0.262748959285369, -0.16832133135965954, -0.8877536329727047, -0.30975772270987384, -0.23291787092357022, -0.27347009898114516, -0.0037044320526943993},
    {0.4191639735614098, 0.3062779381840246, 0.05486484062522865, 0.6360955292733752, 0.06940013247472587, 0.8257668269603814, 1.1792402125952448, 0.8203951355358129, 0.217902896178494, 0.21115733979458398, 0.5881323013143632, 0.36344076581666646, 0.6755544018299763, 0.33195028154980877, 0.5519360255170448, 0.5329759456551506},
    {0.3868252016074289, 0.6448626293165993, 0.0291855697126016, 0.27436267965907474, 0.20557778244075747, 0.9993140348611783, 0.0864818395636969, 0.6069534574679141, 0.5175017659946454, 0.1797187383027821, 0.09063623531043832, 0.40370926223360526, 0.2435073016172747, 0.38517268163827173, 0.06901722103426261, 0.3432244055772077},
    {1.0618822003397266, 0.6737575555341931, 0.12399931563137871, 0.6039450123978988, 0.42581955244213265, 0.22045227218834446, 0.9675797630810706, 1.0588644825362645, 0.34849326813612813, 0.20687827853242988, -0.2558187624061664, 0.7968012324888699, 0.7758458912697705, 0.29737226381435466, 0.5223589160855939, 0.27497643708773406},
    {-0.13385412309259637, -0.40481823691399144, -0.1552524987491635, -0.60650800040383, -0.2034024314170185, -0.28839890788247624, -0.3774672389926774, -0.42912808042200085, -0.6970149328364215, -0.2591610061430045, -0.2430636359238721, -0.25348792939321285, -0.340671414427952, -0.5915302143359604, -0.26962651906607327, -0.34221330565422586},
    {0.0011115767056576191, -0.10289586508947006, -0.24349822659671783, -0.7652080335555849, -0.13448429519217114, -0.6394181469051675, -0.3103359172901182, -0.9906988400453718, -0.6680813476816959, -0.8837282210651324, -0.18969353635893538, -0.1658136159514273, -0.2841204560156914, -0.4864332456689788, -0.5455908413279291, -0.2906668037685265},
    {0.5014191449089056, 1.0354091006037043, -0.006261563526447184, 0.23676203673411939, 0.7032160380560261, -0.1555678824507339, 0.10309389898773255, 0.3375591921370891, -0.06970459009247083, 0.3466504687857848, 0.48597353103618496, 0.3018022631042625, 0.37612192755651314, 0.5761240384604362, -0.07257115646720178, -0.027649543757021312},
    {0.028525127264001228, 0.1282636811029829, 0.26131089032869187, 0.34195712434407693, -0.3399954520641135, -0.028561962855778916, -0.038129394405712766, 0.23267750576166174, -0.6641821832158986, -0.35615044304881255, -0.017295778467769474, 0.7480609019720507, -0.0558909002564709, -0.1688222692959659, -0.11911746644493369, -0.22098955960529823},
    {-0.16234884838691294, -0.5847869183414551, -0.3089684457133921, -0.3371062530086709, -0.5769324363330781, -0.7079503695885756, -0.21632898180852383, -0.1884535535128302, -0.08449413574635772, -0.21455845069322493, -0.8180970644715051, 0.0737153254458828, 0.09685939463198254, -0.6417174740841903, -0.49746565174531465, -0.1580463987716268},
    {1.6913087130296773, -0.679840823626789, -1.479429333050805, 1.5206785200329056, 0.4325209043525565, -1.1794279148537221, 1.946031092379489, 1.6492917082958223, -1.4812814836829922, -1.6525403526398332, -2.1550384360568957, 1.919228583978325, 1.5464734938682474, -2.111705305074905, 2.067046784947081, -1.1555694285422076},
    {1.593626295396025, 0.36936841834213363, -1.583639244107183, 1.2739070834220545, 1.2383262069813339, -1.2674532192909327, 2.3667413140887947, 1.1700761800860793, -0.5787849407831765, -1.2146145662379808, -1.7804443808689885, 2.458019881936131, 1.28282902942778, -1.5025026496360676, 2.0625112715335643, -1.3285097441053162},
    {1.6784463822380378, -0.3750665716104999, 0.012976817570327304, 1.6029199579891595, 0.04832607530610026, -0.625642309771526, 1.4418785787500745, 1.884081734489557, -0.662197446122999, -0.5057602285079298, -1.2053312196910515, 1.589744939547647, 0.9342206995811654, -1.1377197868856053, 1.0950437693250084, -0.4825410104757985},
    {1.875198633593542, 0.4705451758640643, -0.04542504523192121, 1.394606393956646, 0.18683775157034296, -0.8393350942719772, 1.2154649551466894, 1.7142280750936887, -0.25168513642771856, -0.5897107531429739, -1.044870242609684, 1.6988643964791112, 0.9384960120968945, -0.8817192307122059, 0.9751140653638005, -0.3836937216744122},
    {1.276246051616235, -0.04482243828735024, 0.3537523986860309, 1.2207721801332938, 0.1268621266989537, 0.04878654634112897, 1.307968691137846, 1.1954640492257345, -0.5537928197856098, -0.30677866225908, 0.35285764867863784, 1.3619129135097385, 0.5469070741999023, -0.016444271137569303, 1.3132841217794342, 0.06808576128826518},
    {0.5440483877713914, -0.06982621667480056, 0.05044414627873931, 1.1582517902178875, 0.22323518700053877, 0.646049107574686, 0.9473937580230147, 0.9183623222413008, -0.9182551114749727, 0.20301449086007772, -0.39231710761139693, 0.7014431958979094, 0.750245516027482, -0.42917026364625394, 0.6959434330575658, -0.11249838928960665},
    {0.5653648625055988, 0.35604490021542345, -0.037239015662108896, 0.30600599331794853, 0.2338391503731443, 0.2351570120822516, 0.5149135221006235, 1.0288978425642032, 0.23030778876697497, 0.05354071481498147, -0.2677997089829601, 0.22838630114418915, 0.009765460719310197, -0.3332083303501273, 0.7418896125918114, 0.0020349404450934827},
    {-1.0403553897148863, -0.16910137114937518, 0.018065413144610593, -1.0830266119401688, 0.17222782233900805, -0.2312264384062199, -0.2573017222503256, -0.7212835522627533, -0.5979925231272508, -0.17659639686133324, -0.036658738815950546, -0.5758952722365996, -0.125661411013515, -0.5281839712651073, -0.3178044534205258, -0.2614371143603367},
    {0.4695343832685096, -1.3345708041637332, -0.6258450391063164, 0.4492433159326211, -0.05079563963024021, -1.0116635747560025, 0.8089120608433936, 0.08379318979053821, -1.0383600480580457, -0.43662669826145073, -1.270304676638102, 0.5873617616085648, 0.04638032331627991, -1.0282261483856465, 0.6956001643467894, -0.9805148585941729},
    {0.1491559834958733, 0.4108319543984227, -0.29969038979435497, 0.007082244816598386, 0.4208482773237215, 0.2248043113901059, 0.3095838956461288, 0.4309356182702162, 0.31447656080826014, 0.07785173151309167, 0.4614180694902477, 0.39593647990990755, 0.46100308759599146, 0.3440515872494711, 0.6207488071357999, -0.2299263776599271},
    {-0.7517527889665521, -0.7967253137615121, -0.38504558756324, -0.7138322802631812, 0.31072297093384793, -0.18347115586805945, -0.9028019996775938, -1.1727984668198048, -1.3738597186178896, -0.9680247116913673, -0.7017853741647311, -0.1762314596786287, -0.38922466939691774, -1.3117048191935177, -0.8991415226589397, -0.4741976120339311},
    {0.8868315991677785, 0.10644308240474927, -0.4038554934256147, 1.1124513888482686, 0.1918156668959124, -0.19105249758449602, 0.9597938019369016, 1.1680993746423207, 0.3858197412991015, 0.0731660046337416, -0.5177423883336559, 1.1606330689091886, 0.8128554444690907, 0.0464955305943651, 0.5813270135247797, -0.285651735314034},
    {0.2112071570338248, -0.5808074951322241, -0.15687122615875831, 0.11665408066684155, -0.30295693375673455, 0.20864378891248606, 0.7851474924525711, 0.4533630835452429, -0.1841613711443531, 0.208644107617354, 0.27246915294429586, 0.6826381502442288, 0.5533992315089914, -0.13091075691137166, 0.6063100771286896, 0.11813047844002943},
    {-0.05606806702251695, -0.37543717493358153, 0.20805001557226255, 0.3173113447397425, -0.6224066365000089, -0.13439103491188137, 0.47460370088481796, 0.29368304827134417, -0.4206874495679837, 0.09932485079310513, 0.4371583974643424, 0.1233829639130657, 0.15090962252794063, -0.17056609008372045, 0.20217821069706868, -0.22694605253652506},
    {0.11526285481657998, 0.2317417212370857, 0.4608871556764864, 0.22704695467347166, -0.1412784696454545, 0.09086175232698286, 0.2850830487386242, 0.1293357000218448, 0.03161751859551854, 0.5599310268169255, 0.48788316938360426, 0.8979250468944378, 0.47194434907047833, 0.21318390568468704, 0.2906099385589217, 0.001729783826177082},
    {-0.09023740380894454, -0.08801309601150847, -0.0029871651316119587, 0.11278549181737546, -0.2861210282674225, -0.27797515627672315, 0.24396670972184165, 0.2255569668329741, -0.5380365511997106, -0.12444123289583585, -0.026729658235538016, 0.3636657652926848, 0.6040919882737037, -0.18353788301427137, 0.5267622357180854, -0.3579572217170931},
    {-0.8555598668415467, 0.27519237539149566, 0.04099072854426808, -0.4572308326546781, 0.17388336383598674, 0.47814767829667787, -0.13536038218801427, -0.29944556232387515, 0.1757538452998539, -0.033915027396622485, 0.7884155053685282, -0.20636108210613432, -0.2322001152498563, 0.20431227188641185, 0.02875241039120023, 0.20669037602749088},
    {-0.06010593706819781, -0.40470094160799736, -0.3423940093743839, -0.400082460976955, -0.26660863206290686, -0.44449143083752674, -0.44471957322581823, -0.7687570819494507, -0.31775006306270764, -1.0239212606383072, -0.4944025679801882, -0.024010580216406775, -0.5665078933340219, -0.49219605144187567, -0.4104445114131407, -0.12247547004415071},
    {0.21207894023891186, 0.8773578774669729, -0.15466047035068084, 0.019470711661943356, 0.7134002269458509, 0.564075294920126, 0.630775589473291, 0.12415131498203108, 0.31343912322716727, -0.08767800435615469, 0.08196991434495612, 0.12384105026065081, 0.4976030424583465, 0.1442805697786508, 0.4265508232040553, 0.22444406542029888},
    {0.18653607779792672, -0.7102098861495152, -0.2603848960029255, 0.31134472051206286, -0.07650614702427586, 0.5799283152256051, 0.30107287088240947, 0.02706220863488132, -0.6205627150749757, 0.02905949097112201, -0.13804610712563764, -0.12800861137184613, -0.06698184106376853, -0.2700729353143568, 0.2365587278791047, -0.3855419248165598},
    {0.06592411852248539, 0.7690479457083372, 0.13280163746429982, 0.5290020374732247, 0.007200543256896207, 0.9225140673037643, 0.28025849083861826, 0.2436754447210665, 0.7790409336941961, 0.2292969232754707, 0.6111021213216483, 0.28910804647657673, 0.2691527727518192, 0.3704826385867575, 0.23280761859838436, 0.3577389033477066},
    {0.5683564554828946, -0.02638230509317984, -0.30970875479668725, 0.46253255579437536, -0.035087340295955276, -0.151209102895943, 0.01654792015644431, 0.5399218135788965, 0.6921781914869192, 0.04660693150691227, -0.208504303743059, 0.8970798433263701, 0.1622302226695065, -0.03799875990486333, 0.15616159942405666, -0.06927696179329518},
    {0.020854164188635834, 0.02390426856091229, 0.13649667296010312, 0.628511355633815, -0.023583158661691087, 0.010851574892454677, 0.29065215546044404, 0.16273145218102464, 0.0608764156338937, 0.45206048686618217, 0.20213444897785762, 0.9156820413041107, 0.013929288336576114, 0.22387669639560226, 0.1530528617155102, 0.3042835145427504},
    {0.8367965329871315, 0.15643304310215067, 0.009252785928133988, 0.36665083225799766, 0.16289285857260055, -0.26754389847678983, 0.6118272231021, 0.5389258723781623, -0.38232430804640466, -0.5586212153720163, -0.40700970346508947, 1.2463112453431349, 0.383340724522783, -0.3085981126584659, 0.3649843578083909, -0.11996031963018967},
    {0.1959250948589639, -0.25885101319054593, -0.20614332477475136, 0.14132343333797892, 0.23310997777633102, -0.19455147776002432, -0.1969031367072079, 0.08517804941815806, -0.9815580284971575, -0.6434481664807012, -0.46254654456064, -0.13233132384565452, 0.11737792722260441, -0.8285879720790519, 0.15195018618275047, -0.31510560102826024},
    {-0.5128088050418638, 0.4947994024395193, 0.1773470871321629, -0.41613994363097084, -0.036799030186947426, 0.7060222687675841, -0.24599939396982168, -0.29905457278449477, -0.17762311839916128, -0.23280271711538958, 0.13427854896037528, 0.3040288541150221, -0.22848154472261462, -0.024066281670741162, 0.24606669103028472, 0.671431369420693},
    {0.46049115178367134, 0.06666664298468411, -0.21047637044324807, 0.8747259849516218, 0.2561650104023537, -0.4481741572139078, 0.822022276258231, 0.5408314200796409, -0.23521713389127408, -0.3956233686768773, 0.07174664982594343, 0.849319722661651, 0.46304815275477734, -0.3809163217988701, 0.3661644919444186, -0.0041618782470880305},
    {-0.3879322281523152, 0.047244390513618575, 0.34930121224782534, -0.40752751858723346, -0.10735231263539304, 0.2495016339100135, -0.4541672472160563, -0.6539506275897656, -0.5143873973678503, -0.019708902191144313, -0.016441318022064996, -0.12346927658542226, -0.23022103114714237, -0.2358144931541474, -0.47652082012106767, -0.2770538759483695},
    {0.02294636492179918, 0.6681336631322563, -0.33229230887299455, 0.0883146095990691, 0.05144543234121725, -0.07614974632891193, -0.17149002542008943, 0.11112045132113395, -0.38133030787548317, -0.00813758930080809, -0.1581607310932203, 0.06863728535683007, 0.04775727257125465, -0.23372329275542864, -0.18182879915885966, 0.22188945363038529},
    {0.21208905521843907, -0.605975503511534, 0.2993842135495545, 0.15313956893458172, -0.29071301128827415, -0.26827200998962814, 0.1324090217068311, -0.21297631025101602, -0.09154878677357958, -0.05029489069248701, -0.31730572498684606, 0.25313963019660296, -0.24747886910682634, -0.23278155865334874, 0.3052488659834461, -0.47683454477174425}
};

static const float b1[16] = {2.4660762002508743, 1.8310291407855956, 1.421419436717597, 2.4378434649290517, 2.359858004104827, 1.9288543509096223, 2.7513655991144836, 2.877159636269414, 1.813390389757706, 1.833406944089117, 1.9643852092423448, 2.8194901612047496, 2.6874153521768314, 1.8756773578952257, 3.230496894007709, 2.441756436572857};

static const float w2[16][12] = {
    {-1.6112971173070103, -2.1710040831503745, -1.2733002604799004, -0.6704584776281506, -0.7918116212733003, -2.1528334662100628, -2.3230263706470775, -1.4996523974633995, -1.9312595073401588, -1.8277686335181609, -1.0626385106586567, -1.8227009358894097},
    {-1.2946359703515624, -1.083529567213503, -1.5658724267217485, -1.2531260429425666, -1.280871039534521, -1.4707513439108268, -2.1015746382814897, -1.0373035732631772, -1.1177395741798326, -1.2133693068803861, -1.436123961847855, -1.3695091616812785},
    {-0.8492473184576672, -1.3046292118386353, -0.14479633360115207, -0.8206663026441411, -0.3224452394807832, -1.583197674647913, -0.4345229478471877, -1.6860340539818388, -1.0076808411507088, -1.989390714119308, -1.9607319303308024, 0.7551640611001224},
    {-1.9335493461987494, -1.4505673272765265, -2.137593563202046, -1.3940275910943398, -2.045503527759299, -1.689218807128826, -1.4841535650754594, -0.5329781715589481, -1.5897661029342198, -1.8124082123545846, -1.3211293395298382, -1.0240651190730976},
    {-1.878824923722243, -0.9015104525213534, -1.4588760898498168, -1.709827548598206, -1.2838097981628787, -0.46142857313440333, -0.19488308275456004, -1.4789013915120217, -1.0128525817455794, -1.7646348969307122, -1.58298642422529, -0.8945427317326907},
    {-0.8215540631658209, -1.4294582632265356, -1.7876042557975915, -0.8491026511687595, -1.103556507545294, -1.3366140291104762, -1.7265739421167223, -1.4375723456863032, -1.4572957366331631, -1.511686587973876, -0.3179833383295771, -1.0093115901549192},
    {-2.148376993537152, -1.5328102847600626, -0.9039902912829916, -1.6498936023361095, -1.2953650742758342, -1.4960302591179604, -1.7579506135914864, -1.2938861209387187, -0.11703170675074619, -1.8655214577645158, -2.0137823807192623, -1.3956003482786798},
    {-1.3392554398525238, -1.7452113049177365, -1.5048995676428978, -2.19809604331384, -1.4934260087399038, -1.4221323308110252, -0.5217474630176495, -1.6770441282120914, -2.215737777095004, -0.786547667278452, -2.3972669839087355, -1.676750163455113},
    {-1.1752764113558214, -0.9693020017899411, -1.3546980201315237, -0.5202819350134839, -1.4267917430006352, -0.7216837428711865, -0.9393997172323644, -1.1066727525359288, -1.2393341372343663, -1.3594960768649884, -0.9721287842753158, -0.5186605935167247},
    {-1.7110375773279167, -1.7215144591118454, -1.5802797706558187, -1.445476376264446, -0.38098707553749617, -1.1975355893689914, -1.4764342058849118, -1.206562937735816, -1.3876257741832254, -0.4441277027539127, -1.8327466231340017, -1.4400621877876405},
    {-1.6461181081913918, -1.153843521932635, -1.2956643577565417, -0.4648160822027943, -1.5495778306210228, -0.9906391744957858, -0.7316775192483024, -0.5546757408926948, -1.5493948046978199, -1.478165067142564, -1.6850666151868159, -1.141677795374389},
    {-1.4899968453376369, -2.1861186355876177, -2.011932792011219, -1.7661653415740735, -1.8464655276661295, -1.402859478688868, -1.4852416901115184, -1.8142217775758422, -1.2537212802521145, -1.1937296877332284, -1.0781554113290055, -1.2139722918169984},
    {-1.6515895412721098, -0.3640496751105036, -0.510144909332098, -1.6679321447099746, -1.6781512091112905, -2.317173792618996, -1.358901839656344, -2.301539267520667, -1.6059272233165196, -1.978228430114364, -0.7920675459704056, -2.053212281176063},
    {-0.2544798984300068, -1.1736115730144434, -1.6533030155157589, -1.6773059667024999, -0.9222920263901386, -1.2687168713714085, -1.4112018532508233, -1.3907582442689186, -0.9432669552580026, -1.8426441014443415, -1.7610182266786187, -1.810797189255844},
    {-0.3837266952899121, -1.0369511898354256, -2.466683574245227, -1.4588504991750906, -1.5816426573184759, -0.47929597794312634, -2.307430397045762, -2.024968778313073, -2.388412184009621, -1.383369041391085, -1.9762023757598648, -1.993459875139637},
    {-1.931651332342323, -1.1510054460470263, -0.20263636185056585, -2.331408366281135, -1.5466828419185548, -1.6219364123914461, -0.7826935349586446, -1.026011099741483, -1.7390891655754814, 0.23569620157121923, -0.6364163489099929, -2.000355410406831}
};

static const float b2[12] = {-1.309189760692065, -0.7289106691481629, -1.0714046381687834, -0.9284356006363478, -0.6146260076476118, -0.8137630728645638, -0.9195706791938126, -1.3500285116311015, -0.6203146344605905, -1.069259319974932, -0.16694656574320585, -1.294794099592105};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
