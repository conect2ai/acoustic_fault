#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.5677523150736201, -3.8737820207768094, -4.257253150973713, -2.232304051509958, -2.5922523256920185, -2.2353857290567536, -1.8719607416891648, -4.828751730948163, 0.13299584474347192, -0.29516121914320775, -2.1433256683689184, -0.7234324125560999, -1.8536249980495436, -1.5464589808955687, -4.759423713335299, -0.5200157480569467},
    {-0.8837919825349281, 1.6205212219085154, 1.6811820329959186, 1.5611588459124885, -0.736876183416755, 2.7223470143241264, 1.3698141983698913, -1.3686368015309702, 1.3882120095158197, 0.663249958017292, 0.572217444561229, -0.573566409140492, -1.1904479725543615, 0.6306054509867198, 2.843407928568411, -1.1502881884226404},
    {0.9631058756802466, 2.674683439031648, 2.3110232568522466, 0.8072009223561676, 2.890283405218694, -0.20732683493359003, 2.0216531705382557, 0.25711114817231484, 0.2902940240732106, -2.3263225084864776, 2.2865249882345307, -1.9884774981561737, -1.8865954309106678, 1.2453314158163216, 2.5084749514554123, -0.0017330903093491633},
    {2.5244702849931415, -1.5247758803366913, 0.11443230254157205, -1.7324376045064784, 2.2437952387358657, 1.740240550452086, -1.984721709223589, 1.1826871095027685, -3.9182687222826607, -1.4389027919814819, -3.152886153335005, -1.0136213477167129, 0.4261623566383213, 2.6196225709916305, -0.7362019710081356, -0.5661286493883526},
    {0.9907539145634412, 4.535837126561025, -0.013014453615521962, 0.5478482372988261, 1.9177164294787723, 2.2550638106804377, 1.0961854522634915, 2.8849036367368366, -1.3467668082593138, 2.9366052409043326, -0.07930052445896577, 0.6970156695300738, 0.5826078979160553, 2.782589075804313, 0.8052863615856488, 4.4593513017975015},
    {0.8755752131960844, 3.723813860989917, 5.6756421761069475, 1.1280269319448364, 2.6685414072173574, 1.8980018221350026, 0.8729716329823101, 4.835898756532908, 1.0152598832778446, -1.0220664742895724, 2.450349988465493, 0.4108990041353313, 1.4342582589680353, 4.261132449580053, 2.944002529434322, 2.8227149106130223},
    {1.5284560472885427, 5.468186588614589, 3.397426364823236, 0.22162218279269083, 3.856108618581013, 1.5381433263083055, 0.631709110510775, -0.20972596869806467, -0.6934376309057079, -0.88503646438451, 0.9010601165381644, 0.10099235714557485, -1.4624694837443755, 2.757649911610875, 4.864281205677882, 0.8207059272228012},
    {0.9664978337169732, 3.817216849744548, 2.699482684173673, -0.7419761273940194, 2.026125017935036, 2.0093920327440387, 1.8102620238835099, 1.0647491559401663, 1.5898658468992282, 1.2235157775159908, 1.3849544043561204, 1.1623487249191844, 1.6222122658692315, 2.302226651422947, 4.006787371434464, 3.0068223819562294},
    {2.141995016020353, -0.8855405470766731, 2.1337671907031535, -2.1107792260021085, 3.9797014302012834, -0.8714911348767636, 0.6248507563901177, 1.170955335093675, 2.878214855517438, 0.2898354465265841, -1.4405029383745278, -1.631132646909091, 2.325457810407553, 1.6717417790205542, 1.0550524313575844, -0.6979085817914422},
    {1.357217480746917, 0.01391203762303335, 2.4176670399593907, -2.667970149468007, -0.2267421735362336, 1.4139701309916377, 1.4699726077565838, -0.1800801789151934, 2.777197572767848, 0.6660300102227668, -0.39892871368892713, 3.3405463096103456, -2.0517251107395635, 0.01769887080868107, 1.1434498409142988, -1.194314611299042},
    {3.330552446082376, 1.0778433787724067, 2.658540200735651, -0.4427997611080958, -0.15078155121965525, 2.058306202251069, -0.3394612736653663, 3.7555786307249086, 0.25767045461948657, -0.6009260144750954, 1.3798841660112586, 1.7611255062551723, -2.382856827362811, 0.4113345732538395, 1.7137846578462985, 1.605715144631325},
    {2.3833222135342305, -0.9043721247363657, -0.9876467608132965, -2.116560254022123, 0.00020143749480354672, -1.1804795442481333, 0.7263296728157568, -4.792020918307756, -1.6925790111438455, 0.43624094911794226, -3.124123270229109, 0.20010312439141623, -1.028040869471371, -2.3136175165370245, 0.1743235438458824, -0.9017928186094971},
    {-0.8113699961312432, -0.39957059893326435, 0.05586028535782513, 0.5674041736724387, -1.0471478558908227, -1.1302284137817933, 1.2049498957662028, -0.732488036819338, -0.49338125218775536, -0.07642584731841692, 2.031876356993006, 0.9502187740483935, -2.4140192196052364, -0.4876892274726183, -0.006688478386302818, -2.1001613983878284},
    {3.517265010163375, 0.07884945918803755, 0.1531814712217511, -0.2549604218624325, -1.1764254266460183, 2.8648083424752766, -1.9064193648967378, 0.9368235790606926, -1.1900687812440587, -1.786588685705516, -3.314281458487011, 2.3983646686485525, 1.1303804736620897, 0.6976799129840668, 3.0353396792894474, 2.3031137916840243},
    {0.3890605529913118, -3.4282218212698217, -1.3056447744566537, -3.6931540885233343, 0.6013914526591546, -0.6888296479460408, -1.4190346694819929, -0.06207159356350862, -3.804797784663574, -2.0801971676689948, -1.6657876112703662, -1.0982196377341407, -0.8614983621346797, 1.4977201523705932, -4.615454323472427, 0.3064482057632682},
    {-4.131652760040748, -2.3800876661010752, 0.7261070631919191, 0.3939474518051221, 0.02907870759111141, -0.1082400709329358, 0.5970234763973835, 0.6341757874883284, -0.022154316598116317, -2.0138043589556616, 0.7373115332879062, -1.3500596932962852, 0.7132848740586941, 1.4285376696848817, -2.270488952985386, -0.3080398988080411},
    {0.7743813824062694, -0.8080988500339668, 0.45564710010202913, -0.05049409140060286, -0.748357740801064, 0.4581141252553726, -1.4719402939067519, 1.051714016395878, -0.6862054492311347, -3.211459888381758, -0.1704122724577246, 2.35575048654977, 3.406978226818919, 1.473614361388418, 1.3564599807571638, 0.5407816952290753},
    {-0.09164521274938303, -1.987785552318353, 0.029986068918911347, -1.4452161215777093, -1.3012529928572796, -3.0520762855278036, -1.3369043807935173, 0.09473501393580475, -0.391401733775751, -1.4129956423638925, -1.2735656358386944, 0.34352454126716275, -1.143477272561606, -0.5316680473438771, -1.976772027520016, 0.8966733966716444},
    {0.7418664039406493, -2.0606042282258343, -1.8371926499267632, 0.6032389882654187, -0.7678828337453851, -2.519688996842157, -1.4175720574155097, -3.1567319260879456, -1.1386432125322603, 0.8113466625101443, -0.1714186267088158, -0.8783113000834576, 0.9521822128287849, -2.9308610023522053, -0.43952512151853623, -2.209638860437186},
    {1.3612157237816191, -2.2606037944213844, -1.8728337377485391, -0.11807965620551553, -0.5621656866748282, -0.8478203862883217, -0.5827021999797236, -2.0302966276301797, -1.5535668553482773, -0.11998519680698284, -0.78965690885933, 0.6447306695319369, -0.6534202051150159, -0.49108880385036396, -1.4619291651886668, 1.2097986419730087},
    {3.4408524086119012, -1.5475332077621269, -3.5729162292671486, 1.601025282878701, -1.9801671249757393, 1.7488408942751013, -1.8618405058971033, 2.9326174791759816, -0.9279614279833388, -3.738830431173986, -1.4546739700751794, -1.7035133702359249, 2.7570127061277043, -1.9633089898838243, -3.3748625607856257, -0.8101381617556982},
    {1.6023434566681258, -0.961442280594999, -3.8074556208024575, 0.40272115382979295, -1.0952265523321771, -0.85784952456332, -0.4091341964562934, 1.2827869736823365, -2.381054992508121, -2.0227838399912144, -1.3160976123593258, 3.0302082159020984, -1.9609848832813352, 0.877203158031246, 2.434679260548787, -1.006186969432111},
    {0.9885965954554595, -1.7317175652756296, -2.3439713127374526, 2.208561511736498, -2.365221010113598, -1.8570199836781043, -0.33217212573370225, 0.7754480272247651, -0.25569494585333546, -1.9184998087563618, -2.0273668148601027, 0.5071805436901886, 0.023752654856790616, -1.6813480594521202, 0.07861806233001595, 0.8527299646463021},
    {1.577146375740811, -1.1926360321554617, -2.1335892250959545, 1.7726484116764953, -2.7933791638223795, 0.5316998726313494, -0.052561870480148924, -0.2558943582136046, -0.5004342917298255, -1.322408342656488, -1.2601449741798885, 1.0122232110228293, 3.7400089024337366, -1.9257919923415292, -0.36253963989847626, 0.8968979530141388},
    {3.712658961391157, -2.79596068907042, -1.911444665415441, -0.24682994455738735, -1.6312825731346083, -2.9052153420848525, 1.9589718746870606, 0.30190438807056974, -2.0413470425466826, -1.3179460049625535, -1.2602595474506817, 1.4399228525208125, 0.6392012172708619, -0.02378439882745318, 2.4678683426333454, 0.8162850230979827},
    {3.200758886024258, -1.243068898942829, -2.3990554746577417, 1.8261589081890413, -1.0697868369519576, -3.2304175089326193, 0.5466656475030797, -1.6950563960193599, -0.10195841581349212, -0.10487673322563207, -0.07716554093983746, 0.080284599208452, 0.8077516982703675, -2.7468801745853435, -1.4140612395223175, -1.6583271731296236},
    {1.9500467527747434, -1.9181700582407573, -7.44765087104725, -2.534576343984091, -2.3356363876965425, -1.7748095044038719, -0.8402474399721546, -3.7246120725918233, -1.7019769485696894, 0.36201104305379694, -1.5433552054836903, 1.1636549286890856, 2.326602955418952, -4.632452115059027, -1.6202988698264242, -1.316589011149852},
    {3.3519178274867762, -0.518742000843502, -2.171743824319097, 2.3234509396135476, -0.3495360045001513, -0.21224062796248847, -0.9434758159141252, 0.3400109165107572, -0.3313542983761146, 1.4448402150764208, 0.8084641255986715, 0.698242011381157, -0.10947011295071266, -0.9957248664997493, -0.08454824693720223, 1.076651318938365},
    {3.4219847144330156, -3.2561269166944298, -2.5784471805101346, -1.313586245986085, -1.749967106027541, -0.5246183157011994, -2.03385648734375, -2.928901547308481, -2.7155236397783535, -1.3871183981308814, -1.936091525360471, 1.5073612637210798, 1.1921936177261687, -1.7820607859992985, 1.8486039860214838, 1.8798415101178172},
    {3.442552245129259, -0.38414432618806144, -1.3185167257377715, -0.6346092603944609, 0.2964551806849524, -1.5453756711748783, -0.5437616822673331, 0.14750947931831276, -2.506264874268347, 2.747251816347439, -2.422279720597611, -0.10296900309143706, -0.6465160430920293, -0.2013561159800115, 0.6894969055719798, 2.3877750137927727},
    {0.6910037484768342, -5.374215162601493, -0.23493428825310547, -0.24432893672094977, -0.1450091045984926, -0.9616004516346807, -3.3439863088864787, -6.1323247057059, 0.16095305288979705, -1.2871086187593594, 0.4266033414055292, -1.3399076151804488, -1.7527103454017128, -3.562485734081129, -1.3791087569789537, -0.7255427750478599},
    {-1.0713307773316358, -0.39617032716376277, -0.4869253918288852, 1.6639845081504723, 1.7585284374099228, -1.2376845820482483, -0.031265271819242935, -3.254574227548845, 0.6574032369158546, -1.4248029835973484, -0.1813319134339995, 2.106834548285524, -0.3057861471990838, -4.405012258725213, 1.1792147548335945, 0.3436173537635399},
    {-0.31368021166352544, -0.24432143414832047, -1.5307754777262663, -0.6001829838262074, -1.8474907780829153, -2.8125415006441146, -0.25489272006786695, -2.5305498312557826, 0.9885151390372412, 0.07864173437607218, 1.4440135800415368, -1.8328757875914714, -1.3309141142541567, -1.6580913702550926, -2.9002480869337646, 1.4537771563016797},
    {1.3786716911082786, -2.303080163130712, -1.2519241339823983, 0.004314019209893165, 1.1090593479381694, -5.732495470550557, -2.2826953165822577, -1.6376817142934628, 2.9796991643205777, -1.0004551539126956, -0.4963016649200622, 0.08273888304687037, -1.7035047283539955, -3.0288573884399743, -0.7416890479871555, -0.01174380279355258},
    {0.8980466748954383, -1.176417432258161, 2.034827639788112, -1.4035402416213993, 0.9832627316077602, -0.1834368648994915, 0.3457565606887879, -1.2366609168443945, -1.6581921963754858, -0.32591484693558925, 0.4691318019920288, 2.148833627548815, -2.7909068476590404, -1.8007750595740697, -0.9507996943775947, 1.7444702597173907},
    {3.8419379898011146, 0.36945351377579166, -0.6141303539427578, -1.0637967665904442, -1.3804830846469869, -3.5902900182666193, 1.2765351116652546, -2.638344268580094, -0.35462275458378467, -3.284233043307315, -0.08369684269099646, 0.4890326949645616, -2.4295011686044727, -1.9654343568876727, -0.38901769157391947, -0.38200578818652725},
    {0.22410882120353678, -0.5065734482863454, 0.6831925782023126, -0.9439560386238, -0.9902004151834329, -2.3554613364890744, 0.8976146395555392, -1.6482784020468528, 1.1505412049012826, 1.4473436419549883, -0.9626524120995306, 0.10523897508186793, -0.4590108659901933, -0.2604452550732515, 1.258068283965064, 1.7102303747409482},
    {2.347781687781453, -1.7975480642303243, -2.587397672706249, -0.9235664086768985, -0.7801253502324464, -1.0381420380867334, -1.3589713873623432, 0.3197778818414233, -1.8431184140746864, 0.4996839270979302, -2.290565300575956, 0.38577625146563455, 1.605427902021783, 1.629743122607063, 1.8252173310857045, 0.1989175344684882},
    {-0.08745982030246045, -2.038297343805693, -1.6483291576489179, 1.2559741773406057, 0.44612024380885806, -1.2425283134435898, -1.0264757753759444, -2.311714498678359, 1.4922857890207224, -1.6539215404094751, -1.0913351909995175, -0.4498011000935312, 1.2855700618775252, -1.3224824593347912, -2.096308839552211, 0.35447049182871576},
    {1.369798405105908, -0.8191677483222423, -1.786966821896425, -0.7855568368199786, 0.9935872359997753, -3.163340409728089, -2.808255719248855, -2.0718700320891674, 2.331635377613037, -1.3768793942199788, -3.3788370724554753, -2.381231153088962, 0.14785769261177087, -1.3395526990384792, -2.569253247005695, 0.16207041972068734},
    {1.9067465327993773, -0.8281120764716721, -1.7498222548255107, 1.5838443486730212, -3.8360305545480693, -1.4452402947763079, 1.743320402530224, 0.11352317382072688, -2.6471226089865105, 0.2654210603662338, 0.6130926669602453, 0.23197094488036674, 1.036481630478394, 0.009669234732635383, 0.29857358914092413, -1.7019966605563244},
    {1.9700554523367888, 0.9083719720581314, -1.1135072188570578, -0.8210043453920168, -1.971222370785634, 0.6102464746931615, 0.8630112076389777, -0.14983587914498595, 0.5390368788859685, 0.24299197792113078, 1.4399293592839235, 1.5568515841572865, 1.5934852552030272, -0.7799344653932879, -2.2793147037595554, -0.04250268468559487},
    {0.2598757663668764, 0.9152071218920226, -0.8784738523830088, -1.9254888114553097, 0.3631417225980059, 0.13572097923126467, 1.3051845322043343, -1.2777716691546963, 3.2676234184357726, -0.7851530087834762, 1.9435009611923928, 0.2661773560135314, 1.7094236420410416, -1.6014157227608126, -0.005489780208146839, 1.0716164643915307},
    {-2.916588497892519, -0.7223229633183633, -1.4751345341705169, 0.16377345651651554, 0.7500745424518793, 1.7119465435710706, -0.373375227077176, -0.37404568825348405, 2.0608311166959075, -2.2671534157457054, 0.34962965466635476, -2.102078491732564, 2.1848169252560776, -1.2189113576658763, -1.697890827619676, -0.6857180386200673},
    {2.236240010922917, 3.6601196278218806, 3.495226654527504, 1.5768759485719546, 3.4491701112017847, -0.2721046350559718, 0.7091965600674355, -1.667849582109554, 0.9786504305785559, 3.420077774340694, 1.0484138388117645, 1.1714526026948775, 2.1174300890485744, 0.15376166215510653, 1.424034420888761, 0.19904879601400916},
    {-1.1522169477083883, -1.09006476247838, 1.1488676783293448, -1.3838256048363249, -0.36929918676817347, -1.5807351366473386, -1.9214154230571339, -2.10439078616952, -0.8400331882319323, 0.183476069296291, -2.843760208216964, 0.5254880265247264, -0.7731091807754858, -0.8795203690419359, -1.088878217294945, -1.7801209909150022},
    {1.2880040476972479, 1.0508787224609013, -0.0007168967951910748, 1.242500738494032, -0.5036215805809457, -1.2429985080274435, 0.4467437733627618, 0.8115413990974701, 2.384395910576897, 1.4782334655630562, 1.6845545134237674, -0.18998572538011052, -1.124459577289514, -0.5008589386881459, 1.0736659499784633, 0.5828662614175496},
    {-1.0896821350053987, -1.5987632119905852, -2.9630730968032557, 0.3252490082449394, -0.9441004879237184, -0.9565686861295127, 1.590128083827643, -1.3828796882325383, 0.7573908935887003, 0.26616153067988974, -0.763770771200478, -0.10417787678920187, -0.39447024137272096, -2.1031963772180244, 2.102454365970786, -0.6118346014031919},
    {1.5917092884669666, 0.49296248908180584, 1.327257473811237, 2.2422985813119247, 1.384509563872412, 0.23970258614394677, 1.7527074594428327, 0.46526980219229064, 2.311069995484315, 0.15447856415615582, -0.6483351150875561, -1.6588190359341295, -1.816440035311566, 0.7483471729976253, 2.2416551370090643, -1.2293307363511832},
    {1.6543731574319125, 0.4477247095414192, 0.6939860847740607, 3.44953642380435, 0.8750421206823908, -1.9882193216300625, 2.1736868958852744, 0.9151919255597397, 0.9011524948516396, -1.5317058645805315, 1.3904761376896755, -0.8891519228087287, 0.6903158732983639, 0.06691424927621406, 0.20828480201312854, -1.1689705616292336},
    {-0.053085403437101004, -2.646567834790868, -0.1777940872811827, -1.5733344919839962, -1.96431331873537, -1.200991453358766, -0.2988319839337119, 0.3865473521994622, 0.3976824059125013, 0.40795277513938155, -0.3172518518039302, -1.6989693545890177, -1.5272903179787363, -0.5062875496034368, -1.1417221811619767, -0.18651612730141634},
    {-0.25638282875498203, 0.3061276973359462, 0.06977486685245683, 2.4196229153260758, 0.6651780122422888, 1.1784399949045459, 0.4462984336379455, 2.1925197515675197, -3.5545063500862004, 0.5171388728994513, -0.661619394172104, -0.4161246603677084, 1.9173411061772547, -0.199385140432952, 2.151815362528643, -0.3443541513316795},
    {-2.272146531465098, 0.7261416382297062, -1.830586313918258, -3.204724203468875, -1.1756429038619125, -1.728162100417669, -0.7028483764026912, -0.7153273449309328, -0.41372442461152553, -1.9064309320487252, -1.2873258782923793, 0.9565425214806628, 0.2252879788784383, -2.4411319266061895, -0.13433762158194623, 1.7615776604991966},
    {-0.8548924357191727, -2.838737624581373, -0.5416534846214207, -3.1818540957063877, -0.9049269844711427, -0.9729435670288417, 1.449239975040908, 0.04811561022914059, 3.4526449051434116, 0.183910406874409, -2.2192507674344046, -0.03808331479815009, -0.1998229765841362, -1.5410853743656592, 0.7002037726471187, -0.8487392736069664},
    {-0.5300816882180747, -2.90897776554089, -2.0036781767000105, 1.0218019793550843, 0.42956456089016093, 0.16116780466939926, -1.14367303679504, 0.39101689869538037, 0.45944336786272527, -2.45842502529009, -4.3254203971674725, -1.8425783573484562, 2.665467538464986, -0.2574563417223133, -0.4595547936334643, -0.5253775467540068},
    {0.2679464421735266, 0.7689109157105409, 1.2298066702956982, -1.2129718027576255, 1.1652799673930827, 1.674194278730786, 2.512329140132241, -0.9013258904623668, 1.3029128839761757, -2.1565631740701345, 0.8524594232116436, -0.40323101583917775, -2.0559565351983755, 2.059236335886606, 1.679150292001252, -1.1680117164979464},
    {1.7103713139404177, -1.0725675485642825, 1.3013833845897242, 0.27870768051936856, 0.028147406900585994, -0.7096939844402811, 1.6738851261588357, 0.0018693160489370805, -0.762689813453514, -0.08759511260674488, -1.349605744477709, -1.15879735185312, 0.7233911361543576, 0.3612783817033331, 1.572835984432812, 0.3617929589316881},
    {-1.5512869597678907, 0.5856928529702881, 0.9402187466132138, 0.27951727054859793, 0.2564876609035179, 2.1057594363311836, 2.8115893568121066, 0.07648972911888931, -3.077018685377499, 2.580025672766737, 1.810145548721906, 1.0065450763557546, 3.127641646347133, 1.6639272168426076, 1.2378254610255235, 0.36288437396355594},
    {0.6349832963588, 1.1661116783291796, 0.8868732303175578, 1.5924452032839072, -0.7319069673204899, 0.23688094062605025, 0.6769533738030423, 0.9947835787782703, -0.11623829105474776, 0.9102282171376836, 1.8727841864885317, 1.4916257386673824, 2.3245991935013985, -0.6434498894212193, -0.6455980084113792, 0.7192848078889938},
    {2.5077748187270004, 0.06336230563727317, -0.028317014878527308, 0.6026229941951426, 0.41930510454133296, 0.47398706695345744, -1.0036563609478693, 0.8642615622088263, -0.009946346555397294, -0.8354166832654264, -2.059931685121719, 1.0621754264904786, 1.0739041232296744, -0.2573077662570626, 1.0312584586519378, 2.2266439318221685},
    {-2.1467932935484524, 0.2850022533684879, -1.5902885003873353, 0.987773291881965, -1.2197304816921943, -1.5335211587796982, -0.5281349785384574, -1.3215605452164931, -1.326197883824029, -0.35441300521434377, -2.674910463513231, 0.5875082991131665, -1.051615011027774, -0.5309744316167246, -0.5304901835409699, 0.9120620230654997},
    {-0.7661980582949577, -0.2759147541560136, -0.8051272915388428, -0.7694400396343376, 1.0089732028233032, 2.0008908338171327, -0.223340701520098, 1.9978494225123742, -1.9300575772637167, -1.7325206605534735, 1.8063725809512503, 0.5270198885170475, 0.9247112156224991, 0.6292309049484559, 0.589725791374267, -0.3528852579422704},
    {-0.07415896897479544, -1.7145403754865343, -1.5871296277185436, -2.841216758584935, 1.686527356579104, 4.896528086434715, -2.239210327892206, -0.0817718084312148, -1.013745235750735, -1.0037290970115968, 0.8799305470252045, 0.34529886588641645, 0.7241213134719175, -1.1462472277171387, 1.7432634749145575, -0.029723437050986203},
    {3.461128862350876, -0.6929652274117839, -1.861097593517492, 0.17681601970764088, 0.6973237867529851, 0.5585817145301921, -2.167538917557673, -1.319686429660768, -1.9059087004199262, -0.23744214070532565, -1.9033182373849666, 1.0050007519250836, -0.9127387373898824, -2.5350167323099857, -0.24732690775713773, -0.7513727310281634},
    {-0.6024171933967485, -0.8801497511192179, 1.8239240359517448, -0.14090233962210783, 1.1699904104412564, -0.5079161451703668, -1.3486923381891351, 0.29101831499064584, 2.466529548378218, -2.8454204857366836, 2.8433813308430174, -0.9803640336798254, 0.3237637344942639, -0.6840440297223824, -0.4231315422516586, -1.9306048389471153},
    {1.5546482527126126, -0.5903828887062026, -0.34275075304280345, -1.2676292891675134, -0.5311374391594614, -0.18425222640128858, -0.9938125576406088, 1.774191958878539, 0.7433814751601259, 0.6397297105854147, 1.6093811560260347, 0.4164700074596413, 0.6223040179339911, -0.021319901073356455, -2.6765362891405333, 0.5305753292326384},
    {-1.4970220444113265, 0.8019556248727603, -0.031291900945436754, -0.005706080860057395, -1.0295715908895222, -0.8166488999229575, -0.035420791898332735, -0.9715349350136022, 3.4985296496849343, -1.7076099065272834, -0.5999611330606806, -1.1978867794702388, -0.8677290716797391, -0.523144418755423, 0.806590417059731, -1.0924280286479946},
    {-1.901815719211839, 2.620768861084206, -2.945514675690333, 0.7771987938879834, -0.08133973232633443, -1.0868184028687902, -1.9492355074267624, -1.902180353127986, -0.4527353204750145, -1.5116498501599207, -3.773812334731554, -1.627736865138634, -0.32593343156191956, 0.03637492316822735, 1.1639245170083121, -0.3547825636176942},
    {-0.6440684887685474, 2.3537829271580706, -0.028114688066437507, -0.6341138758708088, -1.9962248038909953, -2.293728440192172, 0.09858231662045183, -1.6457487862031484, 0.36901408197455215, -1.4695798573535879, 0.8785656018794894, -2.4402039880621005, -0.672971117258562, -0.643086084501481, -1.6760549074167732, -3.3510538346227983},
    {1.2346846425629778, -2.0847855922551743, -0.6443057748353096, 0.7479648151090552, -1.098655441364156, 1.4376095878048647, -1.559306650774412, 3.197312154897692, 1.1287150714739105, 0.5175162179439888, -0.6643968369394225, -1.3556803024744786, 2.7317270463304477, 0.6964958719750984, -1.0081943307252565, 1.9328467006554944},
    {0.2663823341426581, 0.574323468779495, -0.1475119935447057, -0.3609051460437098, 0.24700761086201908, -3.217066109755425, 0.642536119820178, -0.3262468726429276, -0.07370779659687246, 0.27248113319739076, -1.1984952925544365, -0.25991889881336455, 2.113476206445428, -3.96451713186168, -0.5805018314299436, 0.402776051401958},
    {-2.1063409558608828, 2.519640953240159, 0.3432668827784605, -0.6786415522708092, -0.7665626045908462, 0.1505359428821385, 1.3637199084881138, -0.5549504996488508, -0.7004036804604424, 0.481077484177033, 0.8022999408377298, -1.9423835324314005, -0.41145835888810184, -0.3095396498348868, 1.5833878514645467, -0.06367204700330956},
    {-2.646680289383826, -1.2123609673518536, 0.5088820826617939, -1.1068694054217998, -1.1526129425831735, 0.9643882805944751, 0.49260750744729376, 2.9995992197846912, 1.3042437957800461, -2.08715639249344, 0.6897523442513377, -0.3115300725368936, 3.251932197936561, 1.3463292028355331, -1.0289077573383834, -1.2546679240731449},
    {-0.5796633960778134, 0.3179333332927758, -0.21185771318936536, 2.1983978770413253, -0.3618520047629931, 0.20334739626955783, 1.8098628399018237, 1.6067682704965578, 0.6428817652006381, 2.0817558195409442, -0.21429173755008515, 0.444117221186731, -0.5010141967340577, 1.2313977742670381, 0.9739137276174212, 0.6551113734619635},
    {2.0021512482576145, -0.2404531513762157, 0.0687301437714018, -1.0395003328268142, 0.8744551256406257, 0.7540087064244038, -1.2965027062639967, 1.2000606060006702, 0.973167709502944, -0.9588106229700928, 3.736644161740688, -0.7894070043896063, 0.3703824349588797, 0.16640865123600287, -0.8202254965380169, -0.4120454501096647},
    {2.3163723453585634, -0.16187017331839612, 0.11804296332571745, 0.41697398071025193, 1.3369152665501756, 2.529719608898487, 3.312795726855705, -0.02281275975901355, 0.8219209480607511, -0.49934784833631385, 0.2857180078559472, 0.4895555233652454, 1.5280342686198696, -0.5052901585811747, 2.4101034704520443, -0.8106917406123648},
    {-0.7339747912673427, -0.8445657209374244, -2.444560798017905, -2.381314057194904, -2.010719428434769, 1.752502900928106, -1.7276984282017454, 0.3212005986488313, -0.3982114261368781, 0.41253289857911885, -1.4211959444702593, -0.08838697581746105, -0.18956841030735458, 1.0348321736290995, -2.4196272966225276, -0.21851449722031463},
    {-0.6417276582356723, 0.872605957123606, -2.1515120440268944, 0.3635318373390024, -1.17752459855997, -1.2390038303075455, 0.1213915590048102, -1.1532597891557352, 1.107606511311319, -0.0028192737246367848, 1.9993239934205165, -0.718768010035892, 2.080462474545403, -0.6025069314633854, -1.4679628844309192, -4.871651358245232},
    {-0.7472787108786672, -1.110595559382161, -1.0003601878097181, 2.5690808471587174, 0.03720609130194419, -0.08113000500054685, 0.10887034818950787, -0.9838486044882474, 1.7857368257671165, 2.5884233381077992, 0.1845335145051154, -2.385671336564572, 0.35305409496618284, -2.5100758430323435, -1.700928498179249, -1.6322584858861315},
    {-2.0873753678752043, -1.7308648969031435, 0.09895620442645164, 0.07406779122928941, -0.8340917855230159, -0.4277964171880865, 0.029733733354400913, -1.2472804782740208, -1.007293718582209, -1.367759773722597, -1.909606695096221, -1.2854793555428745, 1.3135459995517185, -1.8394578832062205, -0.7105487084437633, -2.183098922672921},
    {0.38697586116742616, -1.3587052338594994, 2.9569236693059056, -0.5354398477234317, 1.3908758588314907, -1.1289968581846235, -1.119804095023531, -1.8404355288185803, 0.6636277913508131, -1.7901503795946003, -0.5078433236365016, 0.7871956911525939, 1.2342467707929068, -0.7971827994701559, 0.8034314850493779, 1.260330062643085},
    {0.0791258654400787, 1.9681679787372877, 0.2465301643377807, 2.5325537026754694, -0.2703460559368606, 0.13253013391542529, -0.21461009216220228, -1.070897076403243, -3.7498594326125976, 1.234866176582696, -1.6998274145608037, 1.1235156525264702, -0.2621167714600903, 1.6014576378245124, 0.1506442680859776, -1.1122532132795093},
    {-0.49419014334448386, 1.3520982533877839, 0.5444519020922491, 2.2991455708495168, 0.22581274853270686, 4.270064870536418, 0.6497173972931028, 3.7483909824877193, -1.446211245855109, 1.5734218006441048, 0.9814454609896653, 0.9135015790465972, 0.2782360382438186, 0.29634963124780633, -0.3765293966179321, 2.2010602255858087},
    {-0.7282737534704664, 2.752094466508565, 2.5910957667876833, 1.1169775231856007, -0.48311651577109477, -0.12647915575144633, 0.7476024164735514, 1.2489200048427422, -2.0326630718243326, 1.098719258665789, 0.25218330680049483, 1.363841026673154, -2.007244395903338, 1.8333006675948833, -0.041488475858385374, -0.451697677359374},
    {-1.7413221934787861, -0.3086085842595123, 1.0218842412408415, -1.4022909935149526, -1.005898075670111, 0.6547442836740923, 0.9352486647159247, -0.2778656249604313, -0.18685260525050723, 0.33353481594807716, 1.880546098890174, -0.1352354651380865, -0.9113739696559671, 0.1665615490895177, -0.0719153095985871, 1.8107162485689388},
    {0.2808935032414732, 0.7190429177069562, 2.266668620117285, -0.23144882853314086, 1.5438624615359346, -0.49435970847399063, -1.1234132424834307, -1.644183549876129, 2.8959812253754316, 0.7217240194685478, 2.2656398754082967, 1.7658410649439575, 2.0761326618136553, -0.8119267105208077, -1.349833364455105, 0.7099058394030104},
    {-0.8533084572480202, -4.026452139790358, -0.3568389741004325, 0.4284731248325525, -1.9926669333616527, -0.45195573923346377, -0.07261580614205618, 0.19255506273756007, -1.84262558527711, 2.2843331202402046, 0.5027122886209401, 0.3514746757816178, 0.08493182178333855, -0.8339863085426358, -2.225167495923669, -1.1317274310918524},
    {0.9540657466981859, 0.9762836475217826, 0.9816952200075949, 1.630035241968722, 0.5311137646100638, -1.983323521438613, 0.1935541003782089, -0.4716261987961329, -1.2021043308533135, -1.32007846406663, -1.4487693337406884, -0.7495606742860091, -0.8986436518150044, 0.7033432864887993, 0.6641144205512979, -1.9739768802684208},
    {-2.537515064173304, 0.7383323859189806, 1.354123842888194, 0.9114120147237108, 0.2907060644880767, -0.6338343405212297, 2.0922696434952073, 0.24848147291634795, -0.5830428944782939, 1.1704931870514566, -0.8991943303307904, -0.87043410597396, -0.38401522492855655, 2.1186775157973248, 1.0851439070809208, 0.4270738356757461},
    {1.7815690031444622, -1.3005789309142683, -0.7249408811514074, -2.0501716271311197, -0.8174264222428056, -0.773937118788581, 0.9657647583519424, -2.010293019269413, 0.32594765847149726, 0.2633943822727298, -1.8172211940659369, 0.531738582300668, -0.9688492152985939, -0.3283605134397195, 0.23264208138264367, 0.6203620175143365},
    {0.5922917630205645, -3.8383363552849565, 0.027097166117038163, 0.6969601228759472, -1.5210754996747384, -0.5723684381870772, 0.7787516671478272, -1.6914203087680428, 1.3983841199397937, -0.06643029045817195, 1.1696920366078247, 2.549264035199437, 0.3009165989553584, -0.7443476547835296, -0.6578973673329206, 0.4424306440455008},
    {1.03024795115319, -1.5042013592919423, 0.2937429589620858, -0.9461730263909558, 0.19662646899311195, 0.37459806205010926, 0.5904971491043381, -1.3996949729203103, -0.745787926070678, -1.3883724124631043, 0.2368121172865411, 0.5108138707392721, 4.36928345608255, -0.9340904409640515, 0.0029683520283965413, 1.8505500165436461},
    {0.44874100060321376, -2.1856408308593145, -2.8290942524079474, -1.3665490542524739, -2.1969637663217694, -0.8674234519705571, -1.4392489680474285, -1.0229168079445632, 0.7719156486608997, -0.3267635558812774, -0.5700955476884038, 1.2561304641214943, -1.349097094453176, -2.348805836782273, -4.176840257175117, 0.44477857516474584},
    {1.6844973365365314, -3.3378394803282765, 1.5949959304178676, 0.05095235010489369, -0.9902308596099709, -3.4325438487772524, -0.6244111694757204, -1.7798280148665984, 1.9343802582501477, -0.5885138577528156, -1.0105900917865125, -0.33008188474696853, 0.41587323989201697, -0.20289721178643536, -1.0115800142747835, 0.5556999027657382},
    {2.7338129969834593, -2.978236562848456, -0.7008381151163968, -1.6667344488408906, 0.5588009915589549, -0.7790067350295544, -1.3898075421394345, -0.6434605952157585, -1.1748277455663019, -0.8317094109583347, -2.636631434212421, -0.2096193746705967, -2.6425193339330337, -1.099113624402768, -1.1398082119025965, -1.412758840351067},
    {0.8510920210141097, -1.0962405163795659, -0.6447627148691594, 0.3621473199183178, -0.4626855230804853, -1.857436751029538, -1.4261774724671479, -2.7539862175122027, 0.9076887604770815, -2.163173659489189, -3.319937157536829, 0.9371419423127657, -1.6291905657871455, -3.0742150802296515, -0.46621697810608614, -0.2255165687132363},
    {1.3281995317783128, 0.9322161351342649, 0.17747577403674553, -0.7461432849803468, -1.3547205118236723, 0.918443087314494, -0.9802093382193611, 0.4636624104935916, 0.8323491970503759, -0.6470594168749069, -0.10450202043392855, -0.4864105638178124, 1.3154076730612352, 0.27517912844070236, 0.051295189264675106, 1.1284712198310813},
    {1.060114403975944, -2.801711293950022, -2.376753610582254, 0.15698717515941665, -2.3191268689814795, -1.28907598098376, -0.7048535391234098, 0.2576539943918382, -1.4290993402025112, -1.1833248042290225, -0.5884812297125493, -0.2364385751708895, 2.556830995905729, -0.15958357104721096, 0.4676843398024672, 0.762275428069902},
    {-0.10048788926335413, -1.654036743052581, 1.5183075538471877, -0.9986167961158746, 1.2965943022621207, -0.6116926665761627, -0.06384708528261207, -0.819210197125237, 1.217947980845806, -0.86419357385957, -0.2650438126773353, -0.18404083896657886, 0.5790906092421483, -0.6359978912629057, -0.7311455994030566, 0.39448403631914614},
    {1.2074976284116776, 0.559046422629541, -0.47107642057993626, 0.42512777118154566, 0.23478642291340937, -1.2686863526857595, -1.9330473966840531, -1.3898112374001186, 2.280697731619377, 1.397805449194667, -1.2405401024654266, -0.15494576097184454, 1.351963764178685, -3.3950153780387557, 0.1913743245808849, 1.7038729468951335},
    {3.7333488946796085, -1.039168490133101, 0.08765561310239459, 2.530912984448442, -3.0712030207134213, -4.270452970983471, 2.0265822353046428, 0.7627662856326991, -0.34905684612557386, 2.324529181342266, -1.7326226304601913, -0.03765065752526605, -1.206115790934272, -3.0626971645244443, 0.03341984731853894, -0.20356683318603377},
    {-1.2381350913046105, 0.2764759278941117, -1.4363382493567234, -0.06799587594130231, 0.6638567156567458, 1.7231245672824584, -0.46195852133101756, -0.7388763926839484, -1.9346595143143093, -0.6313077113457228, -1.9075629073180047, 0.15512134424057186, 0.6386727510941224, -0.2461571493669236, -1.7082674908648212, -0.38068823581759237},
    {0.8638091491407861, -2.801941509557756, 0.046065245009392346, -1.888990838822221, -0.5132623683259452, -0.05418798518917385, 1.379554040036914, -1.3328449377146057, 2.8155715562050982, -1.1144895958244405, -1.0687380379400315, 0.4130598575732323, 1.1744053717079919, 0.1992711043722376, 1.520588661583834, 0.7733272967148546},
    {-3.1317860485203046, 0.6986210156042227, 2.0253962508211956, 0.5843412872882932, 1.2076200393865713, 0.3512307692464298, 0.024567617626328208, -0.43647895363737965, -0.5061912284365423, -1.3256612342604024, 3.9986763594692243, -1.0615327754193555, 1.0244349005498563, 0.08689515896347326, -0.6747167877695353, -3.745063776837092},
    {1.0081132125674857, 2.4134482946503533, 0.2948416743974754, 2.9786686089503496, -0.28430433776606256, -1.4026525159457814, -0.5793724535444975, -1.1646153171917848, 1.5254298671883664, 1.32747382018746, 0.3598141261916293, 0.09118853323065253, 3.5966905786142096, 1.2125408014344337, 0.6946564665229134, 1.3185935585927024},
    {-2.2364353206704437, -3.1213205431958055, -0.15551282470879824, -1.2342553246295997, -1.2339252309520443, -3.1576470536085615, -1.3664789066627627, -0.8877064192249072, -0.6005823602515102, 1.1144533176605889, -5.7610923118870145, 0.1866279920628824, -0.4957646339772302, 1.7424188351192789, -1.4067525446502969, -0.6930674666106069},
    {1.7546601840504665, 1.5539829148362656, -0.3213261312201883, -1.3926051177465268, -0.5859328317972582, -0.16559863897763527, 0.7137176959984699, -2.859759380728659, 0.9344796456097957, -0.3405604205704051, 0.4555675233194233, -0.986251925648824, -0.738957701314161, -0.3582994478105796, -0.14699295703547144, 1.4676222417199474},
    {1.1814008008848527, -1.3714320783129328, -3.474559337666312, 0.9464551172800781, -1.7721449292476883, -0.9132296133693629, 0.07615815924727481, -1.988678833576463, 1.022086271710443, 2.9856704417882116, -2.246265206089992, -1.966603104931149, -0.8159922121064728, -1.9406130131037473, -1.4231308376496994, -0.8564237038834477},
    {1.4060571438724634, -1.152324141760413, 1.9208889658632384, 0.35728512477526175, 0.15812193672077388, -0.3063546714699533, -0.2229904715135448, -0.3942798431735153, 1.647119843923597, -1.2964867702896354, 0.6201548775299899, 0.652610477001783, 0.5522796995441024, 1.3943051118712853, 1.5647653959004788, -1.460687576320953},
    {1.0416295636722555, 0.4811124025336335, -0.4693625756022494, 0.23047354110406792, 0.9863210217067879, -1.8967528790877604, 2.402997971501868, -1.4301190383122901, 1.3472122671592877, -0.531765330723392, 0.4265801346295581, 0.7911874385499762, 0.6000975587597343, -2.947750236494939, 2.0468261829542307, 1.9584808799340379},
    {-1.340677943793123, -0.575171009631166, 0.33451207287465484, -0.5411651345312483, -0.6838705771237031, 0.07765387510911348, -0.8709239118124633, -1.403470672750401, -0.23697884061211902, -3.027190611884758, 0.44054055556318206, 0.32508190366908846, -0.2386105855632582, -1.5812391096481127, -2.2604454118825545, 0.5636096322903279},
    {0.4121528562874818, 2.110502011058892, 1.6034714523765605, 2.5507525670506723, 1.2510207547791345, -0.6028993033175953, 2.4330431235877903, -1.8461121663329736, 0.2883812449090498, 0.807021684567302, 0.07326856181184896, 2.038695278082856, 1.5705077388518809, -1.2401108808153063, 2.5680766695994452, -0.8806182373527078},
    {1.8709161538060561, -0.35941642126787615, -1.3759960563024065, 0.3789279961207254, -1.9026453976948179, -1.8439397894893126, 0.019570666451626532, -3.099194120030499, -0.28578964725002004, 1.5294666944796391, -0.4792327928647282, 0.4664168811249675, 1.1070639721336288, -1.9004713001184896, -1.4622725056510844, 0.46500411596159014},
    {-0.14585347531895856, -1.7192037711849966, 1.8275539178383493, -0.5423545482641081, -0.5061992487593772, -0.21273304661038286, 1.3880045903209213, -1.2320550869593825, -0.7815613443756209, 1.3127203028291958, 0.382568625541056, 0.22746828742831182, -1.1750337095222745, -0.5600368633564047, 0.8546255201878398, 0.4579004381937944},
    {-0.16104709265802422, -2.832852088975458, -2.7215806215229477, -0.5584971372374778, -1.069196306971111, -0.17257219657972694, -0.132961500512448, 0.48325349111444393, 0.8036273494179735, -1.0175007764226751, -3.3758422309484595, -0.12467728436865523, 2.2970116913334513, -0.8764922568479299, 1.761735780257514, 1.2115848187612939},
    {1.7394435524501721, 1.337958255649312, 0.4726059401698208, 1.5886891254533524, 1.5031729022111133, 2.5108886380455964, 2.4598183146614074, -0.6014905627046947, -1.9219837277470047, -0.45489476755100383, -0.4534274534952196, 1.8459164517098912, 0.9640244052446568, 2.707583889637905, 1.5276666940690895, -1.300299893708218},
    {1.1791614390187564, -0.951883724785399, 1.288656658559471, 2.7067053498046083, 1.3284397631095102, 1.6023393968235753, -0.8950535610041627, -0.9298320560222278, 0.7412137743175841, 1.8291976101056642, -2.3114270314828653, 0.1405806141982604, 3.2450641734098213, -0.14533772742187628, -0.4392122277011664, 2.1000350366329243},
    {-0.8410672982148719, -0.2769722381194822, -1.2971856939140718, -0.9039075525895053, -0.4930090622971076, 0.5914584975236954, 2.089657007523069, -0.9698156075487961, -1.3161901704206622, 1.2705209629672853, 0.656861157217025, 1.682722859154931, 1.2103260953578427, 0.29017353020341213, 0.953526317302278, 0.08689193489959157},
    {0.3653597731006192, -0.9296575826882045, 2.7927439542358745, 0.993622456346182, -0.4522179800496166, -3.816669843058694, 1.328822295562538, 0.681533576370353, 1.5851936473002382, 2.3056506802976346, 0.7986739449765584, 0.33295066221614855, 3.9175526930602125, 0.1725531383194691, 0.8337689901168203, 1.7899608110349188},
    {0.3755177907344149, -2.498155995480935, 0.5079615750109169, -2.5361489729647158, 1.451483176752537, 2.415740176029375, -2.3292664048892515, 1.6232718590076949, -0.7796006509335052, -2.7722005644157024, -1.2976355961114452, 0.6247598853067426, -1.0594686069092323, -0.4298075394171424, 1.0952386205203084, 1.849681054657525}
};

static const float b1[16] = {7.602136470599569, 7.274306615608404, 7.152060842892846, 5.304647032886989, 4.883458740685077, 6.237700334649638, 6.11483727938369, 7.092968636487416, 6.7928261084626405, 7.238256207416895, 7.187548062107983, 3.5384200939512254, 6.796506851624472, 6.647684587914439, 6.653969313387833, 6.373661868510381};

static const float w2[16][12] = {
    {-5.021235177850701, -4.27590135069664, -4.031448777441285, -4.650467343929211, -4.48570083276921, -3.8139803770007417, -3.685169230772696, -4.449618255954762, -3.8694085926310176, -3.9829187899270493, -3.9142870716674407, -2.911307677614524},
    {-3.2827668810017396, -5.0858136640453955, -4.33662374224851, -3.4109671822326013, -4.593383213402355, -4.382074422044582, -3.0910593143212197, -4.570436993200014, -4.7708687040087785, -4.5667021751078005, -3.7261543493800944, -3.6542445339926264},
    {-3.0513945908704265, -3.5166151283279437, -3.2815814433188835, -4.038515506859145, -3.2737666946825668, -2.498807922266676, -4.12343830104174, -3.6971104467366755, -4.5167768968412245, -4.367097042628216, -3.774143472878977, -2.7236734148882453},
    {-3.817202165483735, -1.8611200119531754, -3.3683050947136413, -3.27036348448088, -1.2961947834466305, -3.34220224748356, -4.112232493319377, -3.066282853761262, -1.6230557403354111, -2.9528967310400502, -2.4330044941682787, -3.7142041641471026},
    {-4.017957739174033, -3.0223657642621524, -3.3435939241632897, -3.031503616584254, -3.639417130598044, -2.6643363198674543, -0.9141102285720116, -1.8437462636478286, -3.0079956024989336, -2.227673505339924, -2.481023685476362, -3.9453629864490005},
    {-2.9822538675841095, -2.9848476457324633, -3.199710790075882, -2.7911224269659995, -2.4859411078007434, -2.6486081257875242, -3.6033598206361828, -3.2627002781178667, -2.3705532990554317, -4.24007899455703, -2.9624150321419638, -2.7366060969184933},
    {-4.166169317387079, -4.497629859555468, -5.288839209230558, -5.072903852305153, -4.2351800589160336, -4.621631166212403, -1.8269776619488933, -3.215184882777355, -2.762429701459899, -3.796640588978351, -3.756139243941987, -3.030036396364624},
    {-2.965238997745197, -5.26401610635886, -3.788610950868505, -3.172114302782395, -4.218093159819148, -3.7411662588584806, -2.578082352616022, -3.6923263670867073, -4.835250026155433, -4.099709908233629, -4.13225065052479, -4.129196341810592},
    {-2.5754135939057945, -3.4208570551397606, -4.323199401123245, -2.675498615383356, -3.5762465399452923, -3.514188558113153, -3.9674284509218585, -2.961288877747781, -3.452977840581145, -4.520908534820911, -3.6451119229138635, -2.9375877457026514},
    {-4.224906866515189, -3.4015614566753163, -3.2023135290168168, -2.1088627418140944, -3.5079598892785944, -2.982860174104192, -3.6722645815403654, -2.0313157793229144, -4.414301366568439, -3.2227733915323507, -2.836718911443865, -3.173673987211831},
    {-4.449616325552704, -2.802994635650465, -3.223791865634555, -3.6903018811558024, -3.0571076460522533, -3.914226348511671, -4.911691077940934, -3.654102470233121, -4.150832874061668, -2.185161343786934, -3.4720808487112107, -4.2167674403994155},
    {-0.6924736434045663, -1.1730436599737726, -2.762282311960592, -2.2903900317728434, -2.9700984721840173, -3.831754549810066, -2.8861024110239284, -2.748801956896782, -1.742643562261776, -4.512060521931676, -1.1445564945140476, -3.696461757534762},
    {-2.8820243563820025, -3.8438080953705263, -2.258710805682088, -3.7808407874293266, -3.5623511153202565, -2.8489462583490743, -3.2634256405887236, -2.718137297180726, -2.810961715672027, -3.5163470714431178, -3.3783702750962896, -3.240818576066611},
    {-3.983563384098651, -2.48581800546149, -3.7356371610828076, -4.699216250379515, -3.645199608504694, -4.320983341260131, -4.156324790833452, -3.3819623156868928, -3.3329719120071406, -2.211432059678134, -3.8574061929495134, -3.787112945289355},
    {-2.7185291462271595, -3.707833781556487, -2.544553072605442, -2.233933782751439, -3.137850556912644, -3.0454299898821584, -4.944700541985468, -5.42798010111767, -4.153726780458709, -3.3811312418952393, -4.219799186620751, -3.510860661904586},
    {-4.478290550277194, -2.373959384816305, -2.8276010474580535, -4.178923345134342, -2.334491164519177, -3.0877944953613916, -3.2595671826265598, -4.121018874636008, -2.809579991925673, -2.0829878656077625, -3.8675359322837144, -4.4124139619502944}
};

static const float b2[12] = {-4.6526215809998215, -4.0341950048582635, -4.058039109936946, -4.6876111550955715, -4.19735466772862, -4.087978675856763, -4.525535597955589, -4.0331525878055485, -4.363775539171719, -4.2701703317432225, -4.272223657799903, -4.211039280892526};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
