#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.3571792949023224, -1.0845870432721196, 3.0517956317063684, 3.56494889660044, 3.697995921984625, 3.6318423259499513, -0.16765007731733017, -1.3587315398236628, -1.1680369102999442, -1.6652961897116267, -1.5071314333236452, 0.35793040357311123, -0.5070839071262804, -1.0565729933119954, -1.040512030244813, -1.1346474021401238, -0.5926253472884788, -0.7847668427009338, -1.7183117878975207, -1.0010791395066303, -0.7599669117238153, -0.9840835206128108, 3.5345772280695695, 1.3480547703139947, 4.083757193457877, -0.7346668764034814, -0.9997652563156317, -0.3344148510470654, -0.8831696308172367, -1.8101275803352967, 3.8608330487831886, -1.4668735399018513},
    {-1.4534164323041956, -1.8441106578698299, 2.1861287969741943, 2.1230878833334486, 2.805177699686537, 3.0322195882596183, -2.6158546111714114, -2.19704640665244, -1.4075007817324272, -3.1431112968396238, -2.64750338310981, -1.7435576874336716, -1.5951258428689636, -1.8829134320247318, -2.2151769085954585, -1.8827494231903843, -1.5592801704474035, -1.6955355966125416, -3.522297102300959, -1.1676057429268447, -1.6647950697133316, -1.4350238601221823, 3.039571609131491, -0.035444538546445484, 2.4603478759137607, -0.7554249715678458, -1.6238554990550675, -1.2813077173280725, -2.959001347001809, -2.8414597934752313, 2.8084259328355583, -2.3914210238318727},
    {-1.6801363543373455, -1.9867750776455448, 3.2218109968817004, 3.275284855372284, 4.1903173786919, 3.9152308121952655, -2.2796215829238706, -2.1364988300195495, -2.0840056446495345, -2.81963833017448, -2.8540139137669174, -1.999529000205809, -1.8317923947128525, -2.3107198515300693, -2.1460643148008596, -2.1709589309986996, -1.9098006665555642, -2.189064736835648, -2.6441792206060186, -1.7099266697036797, -1.6995001535199132, -1.7809699085451252, 4.0760519038612415, -0.10068071834435577, 3.757941405777749, -1.6377486430390151, -1.6772303499210226, -1.5921621841894968, -2.5184541727276075, -2.723461938576238, 3.954874578979624, -2.5453937104002997},
    {-2.466464937764742, -2.7628898022407204, 2.9616252105256025, 2.564818400096203, 4.144951547561332, 3.7930907694413944, -2.886773711032954, -2.6876459738093033, -2.844822906970745, -3.557344627625414, -3.4289943151820546, -2.9525227259724423, -2.6293258984579118, -2.907590681849224, -2.819957600002103, -2.8812272515203365, -2.7539731630408673, -2.853395231314555, -3.2359035984413542, -2.4790067965479192, -2.7819216231274457, -2.473315209013492, 3.273560641065755, -1.1564931421332991, 3.3663453508851164, -2.5522335702661385, -2.9716438405285563, -2.428374132612232, -3.023820335521471, -3.506513945337589, 3.5982281031917798, -3.2043647134023683},
    {-3.3006410709874707, -3.3479524990118543, 2.9455046744871294, 2.4567424330653145, 3.285083669818305, 2.973131253816868, -3.336295479642237, -3.1097499094119083, -3.2010198769245566, -3.7869703465634506, -3.626682438514561, -3.199139384203623, -2.9397583582533566, -3.0327197432430633, -3.233020983800048, -3.2449223084589107, -3.354717582733643, -3.4589815891961107, -3.2213438613769143, -2.9477993060904786, -3.0183157797282822, -2.7996576360282615, 2.919007666641543, -1.7609201880673984, 3.039854503141894, -3.0510894075224853, -3.1306654581982025, -3.071809455095841, -3.276423570192313, -3.680927709679062, 3.268907000111674, -3.7328165512689737},
    {-3.1860834047735263, -3.056419787882563, 2.645812152092695, 2.165245213811222, 2.5487935228085123, 2.56227865413216, -3.2163967244325944, -3.433800834269501, -3.598569243634629, -3.6314435752064815, -3.5678392503847585, -3.4943805792695937, -3.186348358663855, -3.3281708543310686, -3.714835099318066, -3.636686532376166, -3.273761331924984, -3.6757031466909034, -2.9810215155244566, -3.1561348398409184, -3.112369202557936, -3.1432314901075906, 2.1452489473759173, -2.3448993603561235, 2.6182538286148405, -2.840021925284339, -3.4515550814077613, -2.8741254369450417, -3.180725976915866, -3.419320063641686, 2.8655570557842522, -3.5985980308223655},
    {-3.280633211624331, -3.052308918392971, 2.5747270072403006, 2.312251328694892, 1.82140687551126, 1.603843741775571, -3.4015150084062653, -3.1678114364233356, -3.2933229306422507, -3.713781754085986, -3.620708617977231, -3.199690627420933, -3.341356653821032, -3.3696833898210503, -3.571323464664111, -3.2321304975267675, -3.1251347320303027, -3.3628051772948995, -3.432340590156994, -3.25874622117848, -2.932583787057758, -3.0812426096549497, 1.5622533318130503, -2.589975471914346, 2.1581073971322025, -2.7816093235578023, -3.2947404091613133, -3.1557634872419342, -3.3959018780283436, -3.604252195340065, 2.5135462917196265, -3.4163764174238307},
    {-3.3829749660341295, -3.4521606913189222, 2.6144864479099263, 1.7154638996579683, 1.8065094586159327, 1.8341322501395667, -3.5508602536456797, -3.391646766888397, -3.5311904848669586, -3.6369536083534237, -3.732899718805076, -3.559720138959556, -3.206186724440016, -3.4644454629006813, -3.70992769054069, -3.4181395711825693, -3.5367667999786505, -3.423790625863043, -3.44011856141296, -3.1493281017522072, -3.0968858570308337, -3.161148466880653, 1.5799257653490413, -2.585346226839278, 2.0851913474091948, -3.029594110353386, -3.1902104465425336, -3.0690365318886887, -3.7529635695143764, -3.5336829343491467, 2.1533587555765896, -3.9027247154747555},
    {-3.316358165952039, -3.303909212012298, 2.497429788822692, 1.3036622833480946, 2.2735279680435894, 1.9251538010393294, -3.1545227780927303, -3.181874668571073, -3.3981125876260228, -3.6788768145311748, -3.6564485457408322, -3.2958329402666338, -3.295932765256767, -3.365906461522041, -3.428414577345824, -3.360741543080625, -3.5898412364003023, -3.267876037478472, -3.5881877463438436, -3.151190105302664, -2.887676751012763, -3.2082398795547724, 2.0264965135421784, -2.6448024378495836, 2.3799155585070935, -2.772497751002762, -3.254238165503709, -3.2085197742818456, -3.2562884884592025, -3.704243854819811, 2.6410054273977406, -3.742049719956475},
    {-3.0645858379007316, -2.8584289085907084, 2.48597306885661, 1.6919415364775587, 3.1555059204883027, 2.7284748139480266, -3.442294748258748, -2.733937543496773, -2.927065791753148, -3.873040830742468, -3.7025063326357386, -2.9100485265913827, -2.926455043443559, -3.3683010881304547, -3.2119501111543407, -2.9350810618038223, -3.3038924247703876, -3.3449343344405604, -3.555678982665062, -2.687907147991203, -2.3692789415881714, -2.8510519185938175, 2.7299898549358486, -2.283073942103661, 2.6448912590338316, -2.6064771841982695, -3.151236246342131, -2.872696033197986, -3.737898953484349, -3.545309892416292, 2.7852768329692243, -3.2461577522403213},
    {-2.7233732134400648, -2.91018133154138, 1.639322691172199, 0.7978682657948858, 2.139699239968192, 2.459083095809784, -3.871374936451687, -2.8566485296544815, -2.705185458919161, -3.431893906778506, -3.3638947119643077, -3.0901137106989327, -2.816590366123555, -2.9951819258183963, -3.1386522612750487, -2.893978680081365, -2.7200660635848837, -3.1430264171588314, -3.9701133329476663, -2.5469317641529297, -2.5275513193581967, -2.3965727660128766, 2.648535942351843, -2.198242165230682, 1.5388291205157811, -2.598400307021682, -2.781181669148225, -2.4770907689643424, -3.779689415450499, -3.197962812809468, 2.283730064888205, -2.9884220012421245},
    {-2.957815466803292, -2.954386723078028, 1.4575296895714345, 0.5680422735935726, 1.2892550639687204, 1.566510291969891, -3.6231752151615573, -2.7875907266872026, -3.2406752815292132, -3.514142560637322, -3.228285701642566, -3.379215505450592, -2.844505649497414, -2.752069400825575, -3.0123400080007228, -2.9483855478310725, -2.6743643346268264, -2.869220823477911, -3.548333232833661, -2.5671688098756476, -2.640379757173468, -2.80437848966202, 1.5586558085045543, -2.6879444571371747, 0.9473355530687599, -2.5741720798703462, -2.548993203754623, -2.717481461789117, -3.512238269816704, -3.105312419241508, 1.0732864172817922, -3.036627475500554},
    {-2.897196294622997, -2.9042876461761082, 1.4854795691868923, 0.5289038959143704, 1.5362279975777782, 2.2297078566574027, -3.1976975387262567, -2.561271658459607, -2.774748724109586, -3.5767125169991814, -3.0485048841233167, -3.331356240401566, -3.1262576816295655, -3.170133884431545, -2.998916636744131, -2.811598341377559, -2.734867658817742, -2.7902812701127746, -3.433876628470542, -2.8003514537705367, -2.483909003652298, -2.526209226386886, 1.8816204207396656, -2.69575845074461, 1.2921188425105525, -2.43648254107912, -2.8344573674061557, -2.578469845492889, -3.649154060303792, -2.8192651529984802, 1.3913948117329753, -3.177869316067577},
    {-2.99608527166037, -2.8726660296922897, 1.2127734927756568, 0.4133786650969586, 1.792880326739804, 1.857313890295252, -3.5834758860215743, -2.69188424489992, -2.8608381797581814, -3.3740805629507222, -3.2905164028693394, -3.2223301625472804, -3.0080560836228694, -2.8198178463739474, -2.9698389066033197, -2.926917895367391, -2.920212726902154, -2.76252410409995, -3.4972690858578104, -2.6250038884131586, -2.4514501723031334, -2.576717681917251, 2.065429254223218, -2.6749924791298434, 1.127773486406076, -2.4667169584449615, -3.0234613204258207, -2.821039281428072, -3.676343714774874, -3.1049977740666277, 1.2570759494130153, -3.029094117732672},
    {-2.955576125748442, -2.391151594230691, 2.1764555543904, 1.2080492175689586, 2.544091933743175, 2.722242877123163, -3.3338274945475552, -2.5258861135008055, -2.7171079868624375, -3.369513657411689, -3.1391135558938066, -2.765321612164755, -2.8748282618248138, -3.0994950053070625, -2.848083635511082, -2.725131660804533, -2.868141534966761, -2.6101987972029765, -3.6633478769165153, -2.5377507453055403, -2.497054072382321, -2.714340020306441, 2.773604502364018, -2.121986871225476, 2.3030939364341068, -2.1449343349167784, -2.6820948313651085, -2.506113769874131, -3.3979011353001547, -3.211562209255465, 2.1534342216444786, -3.1037793729036336},
    {-3.049019187642672, -2.776382102984103, 2.644756041477377, 1.7976392927461688, 2.96732232366658, 2.763641905992125, -3.4264002129283124, -3.0520288069746204, -2.946925740182802, -3.646405506359289, -3.598258474918761, -3.3199665562858183, -3.0614619879523763, -2.9322948842188485, -2.942755161827018, -2.8445378625140716, -3.2843998300453467, -3.064900236057127, -3.863454603270888, -2.570572273979828, -2.710049329213029, -3.025932913007692, 3.184944268188784, -1.867038171536241, 2.7910794046633174, -2.529877786044962, -2.9402445907881094, -3.0487108662187463, -3.407461123119755, -3.7502982861121055, 2.867617419704856, -3.3972725081759636},
    {-2.974205589278058, -2.633155673063114, 3.373057557962048, 2.3721750057870397, 3.6734806533872053, 3.569679461447337, -2.8778436972898853, -2.7876836710168065, -2.7659227770409283, -3.3765541871400675, -3.176842147902552, -2.8136072032199526, -2.4692152659726934, -2.6695060846569074, -2.6223922915119475, -2.4511805239113444, -2.931338766238357, -2.6783191788889535, -2.872668148435986, -2.258540574872123, -2.4681291862602586, -2.8106327482116766, 3.6677134544901557, -1.602761578546036, 3.379677955336659, -2.2655376900288795, -2.634177738060291, -2.55183493163492, -3.121205548769965, -3.3246403008004797, 3.740328149093495, -3.07767616183845},
    {-2.203620551015072, -2.134144985616901, 3.096038917501455, 2.965898373568232, 3.991200173283248, 4.039397361526452, -2.15759899482262, -1.8962593198222333, -2.2368131304739403, -2.680888966496441, -2.204388906819677, -2.2584523125080374, -2.0022229569138315, -2.2927212280599827, -2.2808158440184285, -2.3085378465642092, -2.330572223040132, -2.115086313730412, -2.5637204880914473, -1.890803526158219, -1.7437928782094536, -2.1626486613024483, 3.9610906317837347, -0.8668960251839899, 3.821578834860941, -1.9838708985645488, -2.097356685189268, -1.9262963865270566, -2.005725258910565, -2.8161800971554385, 3.9041922007145136, -2.5253026225722643},
    {-2.487412744590087, -2.2175569216309396, 3.225788104871452, 2.76291697852866, 3.9640615931654426, 3.6383369110127437, -2.387370059689321, -2.4145465751807422, -2.6418543894633744, -2.8471870082132944, -2.959374097755656, -2.348465457669277, -2.441878259331928, -2.2559751091069855, -2.4349516307903962, -2.1906194446401286, -2.406244173258765, -2.2860331883639677, -2.544733464249191, -2.1350978123587416, -1.8999487966052764, -2.269782296236907, 3.389190511820547, -1.1438122128042705, 3.6467174591696927, -1.8042086173525131, -2.467650898609718, -2.1190314826033254, -2.4927576458528886, -2.8607759655444163, 3.582310710912308, -2.888014350714727},
    {-2.7547695728462815, -2.749395903663876, 2.9896544576211226, 1.979295969249821, 3.578436265366505, 3.4406001185003645, -3.240330248504565, -2.9942123242245677, -2.750776707757291, -3.1968159262929974, -3.190166275772856, -2.9016577901082106, -2.962488922309659, -2.926995449911984, -2.9347566049766636, -3.041187928785392, -2.8608947322420377, -3.1338882159092103, -3.2697086716364576, -2.699880621978922, -2.30323628199528, -2.5471339264185064, 3.665245653078419, -1.6466254377549536, 3.422508284482471, -2.2845602006918746, -2.8312186287091308, -2.3811792735489337, -3.3441953291214483, -2.94610278380782, 3.3156782769974145, -3.2605831755368437},
    {-2.5703916558168087, -2.4280039193813505, 2.7513373407005464, 1.7109530671829678, 3.337678058589628, 3.682836337950275, -3.2288662008529903, -2.212188618945965, -2.6207010086198546, -3.247098578095079, -3.241222782816776, -2.973238924166857, -2.7565688060991356, -2.6942339842381617, -2.8168957268868864, -2.9641047420103086, -2.9019229884363127, -2.6765189130214653, -3.28566095117366, -2.3183514177035733, -2.3044230726321553, -2.2283467549037743, 3.437157762310491, -1.9059199617273948, 3.227821345070472, -2.0941495518136533, -2.674658706202512, -2.005767019051428, -3.4831040462013254, -3.2729225365562784, 3.3775529246402747, -2.885819314905843},
    {-1.9328028284654686, -2.21356595852517, 3.3793940523053863, 2.850212276540718, 4.053883695597766, 4.06821678126306, -2.5824381985811553, -2.116314616780187, -2.141741912686877, -2.7042311990118413, -2.796545308979862, -2.2369760932896905, -2.0008394651725703, -2.177039858258218, -2.2104025412322184, -2.3434522525084907, -2.4177502130789192, -2.1323931538041943, -3.0474373367031653, -1.6087178727080194, -1.9092865621157162, -1.6625688467799502, 4.142246353589652, -0.9503542741035985, 3.935398943621652, -1.588636694977513, -1.9383090759042931, -2.0320207616584423, -2.559482651998163, -2.861837469741452, 4.085156638981954, -2.4437314567546076},
    {-1.4381660822812334, -1.786654263465066, 3.6073428357620054, 3.248061166673014, 4.360700922533663, 4.284720011134616, -1.764768637000498, -1.5964999121069985, -1.673869532219988, -2.1337743234056425, -2.0032312959585616, -1.359195751929915, -1.083582658943584, -1.4686421071034965, -1.7375115807025152, -1.8199499938505521, -1.805270259524803, -1.6909669573391295, -2.810762457841209, -1.3041455549826901, -1.4019095242924544, -1.3717507439207173, 4.164943342073014, 0.22146504882291526, 3.9943214060071965, -0.8706691761450664, -1.7627199268303082, -1.2318358439575388, -2.0740521862087316, -2.3729112597985993, 4.149806542114797, -1.916505217888183},
    {-1.7797347092876117, -1.8980015772849486, 3.1578336390745747, 2.7330046885697135, 3.9277402981330067, 4.0454631795718425, -2.586961169878238, -2.1476093267895164, -2.2737708988115983, -2.6642174108034964, -2.8910524771137878, -2.418425189313403, -2.0633748563058414, -2.1635517894221334, -2.065502903097728, -2.0162001647171053, -2.365970798761724, -2.016142741846183, -2.916814773942413, -1.9075662240918303, -1.8040785540066373, -1.6568733257219783, 3.8559227341935554, -0.7822537730790781, 3.6152839889538684, -1.7806528172541232, -2.2699266306759527, -1.8586226251506832, -2.901550953982275, -2.7940194535341227, 3.7726019403809525, -2.6576387052857156},
    {-2.59792831681705, -2.0195989966148877, 2.7035468269630973, 2.0034386743705475, 3.488611371489182, 3.856794950650755, -3.2854501695599123, -2.433641493060163, -2.3384036931047048, -3.269853683747409, -2.9743411926644727, -2.6097327768981624, -2.1100620604728584, -2.7207847031729053, -2.8560597540436317, -2.4760211147803286, -2.684629926017327, -2.6603229208122285, -3.116471662819124, -2.1085682658840517, -1.923234863317745, -1.8862026316224454, 3.707231690656796, -1.3268458967821806, 2.6075247882796617, -1.8475529605711989, -2.7532886000712082, -2.1096697265605404, -3.1650877637319113, -3.1428135933462733, 3.405956012368854, -2.863563144885789},
    {-2.283666510546118, -2.1721690641659657, 2.844320649156192, 2.1401810703935085, 3.4029074051190085, 3.6290181803700405, -2.8662371659868984, -2.1801713081349137, -2.2147966387280587, -3.173125958314093, -2.628755921090716, -2.5948175038852965, -2.25005604861641, -2.4187732531335833, -2.4685409542239376, -2.409956486458282, -2.475915150322693, -2.570949085091324, -2.9906380238228483, -1.6115997502814023, -2.003235508941212, -1.7584293087726717, 3.7797425878360924, -1.425254619157049, 3.0027743236966202, -1.602301866033446, -2.593258539269672, -1.9510838940384643, -2.68260723318634, -2.5538014195562737, 3.553629178273666, -2.596833329121546},
    {-2.127834385133772, -2.1706390073983144, 3.215414357586626, 2.7202941064810044, 3.801930059771736, 4.237260175828608, -2.8523674397539915, -2.3281541062799764, -2.053448826488631, -3.061639114492996, -2.883135820881888, -2.418034510766565, -2.177520794167794, -2.1741891905294812, -2.281623367394113, -2.368298431074454, -2.4694341724483757, -2.2853432682662147, -2.8795959178467223, -1.929619341026189, -1.9190428878232124, -2.0169578607916963, 4.003415149475743, -0.931203661281274, 3.350561880475591, -1.6063627969907848, -2.248085329087319, -1.5973486589800645, -2.8683970508577747, -3.020091656525547, 3.648991805920729, -2.579596246316899},
    {-2.319708252912929, -2.0977906452518917, 3.1520760661641067, 2.866530437568982, 3.883281249643216, 4.012818996123189, -3.0806402164784923, -2.2740590904540965, -2.3642567431765595, -3.2127661602373534, -2.7015072229825843, -2.561162172017221, -2.158991173776359, -2.4887142439557897, -2.61328787987306, -2.5925437467053407, -2.5151711760296958, -2.3989001186128944, -3.295437166474665, -1.8342750678635338, -1.989099387471734, -1.9238000462326654, 3.833278743134267, -0.8817895647464554, 3.5010359312470762, -1.8875790150382774, -2.160522903880825, -1.8268219582328502, -2.9494186098763904, -2.8635546573869397, 3.7880119762891646, -2.8875933841438433},
    {-1.8837142244328362, -2.286504858124884, 2.858169666291683, 2.503584449252775, 3.885508445344447, 3.9568347167482933, -3.0228232182787735, -2.234362132568985, -2.224354682941539, -3.0292610675758787, -2.8599506760669415, -2.5056243942016705, -2.2362547493128138, -2.4255187107147482, -2.4789228104836756, -2.521208542567657, -2.4830457675013973, -2.5804892388163014, -3.1624424204161756, -1.7904743846359183, -1.868512816532216, -1.8308718711096499, 3.85511929040835, -1.1389571489747146, 3.0854613489520593, -1.6318051490039105, -2.3256001903668158, -1.6882044360819588, -2.817964425361615, -2.7702324772534808, 3.63737472826126, -2.6944623369385337},
    {-1.8360884816023666, -1.9588761579355203, 2.780841840593677, 2.054723207381863, 3.7115936014489836, 3.8180054493383744, -2.8746994557322103, -2.197913324505155, -1.8935764468918763, -3.2072283026620916, -2.635236881490158, -2.561572840637839, -1.9328385360093283, -2.161840037544037, -2.373763144198204, -2.382825280359113, -2.6123797431485314, -2.194393418943247, -3.2335207497156286, -1.834316506234717, -1.7783675172419486, -1.947975677755616, 3.770677532696826, -1.212963401123146, 2.848583659080061, -1.5899958919937112, -2.2879650903112627, -1.6682934382786017, -3.186584944827198, -2.789288849138539, 3.5324946845981504, -2.729448458403468},
    {-1.587324803063576, -0.649311665368744, -0.27786902624883264, -0.009043048315547909, -2.037834725885202, -2.3532412754062206, -1.6929519835153575, -0.788874369630215, -0.5289506942162021, -0.5652992534886685, -0.20520039231747894, -1.5996880964954994, -1.5127103012616037, -0.7046149138139169, -1.473373893465471, -1.3321289409567076, -0.1379959265556178, -0.6730838724701665, -0.11861879949743048, -0.5568665806142716, -0.11033800005263848, -0.19631334516347526, -1.6841416410417447, -1.8612602899199515, -1.170017792415413, -1.0485906632151247, -1.1317964377245828, -0.38592244698858963, -1.286779171383336, -0.07052620355845307, -1.129649159161307, -0.5490019449082003},
    {-0.49328955617884046, -1.2729899951255526, 1.5724083767633514, 1.749934765022218, 2.3172548902869115, 2.2479081042848312, -0.6259230918184692, -1.195901355760052, -0.8870163475019613, -2.0444127344448866, -1.3462167775947536, -0.14877367022232107, -0.5224413711906823, -0.9838137339182075, -1.016686629880012, -0.8953036071657938, -0.4292489813213208, -0.9391628997872544, -2.2430705375360107, -1.1183117522531636, -0.7845286556476095, -1.1331177155961236, 1.992610621920599, 0.6638909358500031, 2.3822230847886154, -1.028200318733827, -0.9028703363264037, 0.00733226777694321, -1.2900183721018186, -1.8846526407877093, 2.253162671470412, -1.3971326584054529},
    {-1.725264833151137, -0.8146753473599803, 0.2286031146823506, 0.32908154390811545, -1.2288068451927523, -1.1644165468494354, -1.1735458360851698, -1.150344646554675, -1.627147261075457, -0.3423424132159672, -0.45535934592148997, -1.5764957748843282, -1.52937663538383, -1.5221460550257653, -1.5467000946941665, -1.1905331896607745, 0.49264431051237473, -1.2381052613275039, 0.8685503221535995, -1.794536715031737, -0.9689991678742863, -1.2710344549729058, -1.1024273623302792, -2.203099683985401, -0.2478221262762527, -1.95121216118408, -1.457305091355453, -0.6319100602186655, 0.014972822510967813, 0.12582685556609924, -0.36792920453759526, -1.4386691346850489},
    {-1.452737869764903, -0.9312633009027834, -0.6374692605783823, -0.7795683622478717, -1.6320442835685567, -1.50411917727449, -1.4716092423531502, -1.0877040747633475, -1.2443874035929496, -0.764351847526529, -0.2410923507247197, -1.387047710901999, -1.1588226908516557, -1.2552168757361744, -1.1737216328053046, -1.0752478407884665, 0.10490926568199786, -1.2507644708046461, -1.0918447824885615, -1.4780691289900003, -1.4394345031528757, -1.021888486354567, -1.659738635621696, -2.2975121876222886, -1.1809758441307567, -1.8337833926071494, -1.4766095767914316, -0.6391519893588123, -0.900427039066797, -0.4875573097385621, -1.3639323267148207, -0.7948288107677753},
    {-2.3306818033787478, -2.002254853922579, 0.3669235095327512, 0.5794411950821756, 0.34648680548163563, 0.7344064657290196, -2.493959635642206, -2.027785099585408, -2.381890685713853, -2.1009259710083423, -2.0096516968120053, -2.4904625394908484, -2.354947044436023, -2.5866678945682513, -2.4865575121004637, -1.7085651030206064, -0.9140745039469811, -2.095386619918385, -2.4320850218492795, -2.0998192276429624, -1.9384470054567087, -1.706040801334763, 0.24811693153705655, -2.1583223883743266, 0.6178802587179397, -2.1848023353388566, -2.318074673318601, -1.5198355563409331, -1.6287287571358835, -1.9798936329956107, 0.6907111501750556, -2.3595354150946855},
    {-1.9353141290000706, -1.7041033843849047, 0.9284480616446579, 1.1529485102262043, 0.1581365866420207, -0.0026644985250681443, -1.4584094444879505, -2.062531308792808, -2.386275167633372, -1.70279417229986, -1.8092567109487996, -2.3086692872827177, -2.206816155548235, -2.411761385337642, -2.3466883975007677, -1.6679306563742626, -0.21730750995233547, -2.129940429635624, -1.5040699902951045, -2.2167532718682788, -1.724765699883301, -1.738171775527553, -0.07290937350109318, -1.7376563977877657, 0.480458652868413, -2.356426146640076, -2.1791638275768186, -0.7495502645351182, -1.4846097089255073, -1.3224803259314806, 0.3130249917731001, -2.1533872706542967},
    {-2.3299354757997177, -1.9532185577920758, 0.5849720055005515, 1.1710167402095744, -0.10716040485415752, -0.024703903685994764, -2.108496391376276, -2.2184389449683932, -2.4314636152070683, -2.220193861001626, -1.9548542048135473, -2.0470417711441122, -2.4155785482538015, -2.527148638673692, -2.4828563145954368, -1.9903596975860176, -0.9046528625723479, -2.2910279353179326, -1.9279348901566242, -2.3026187117547567, -1.801683205871728, -1.9724147671275634, -0.27247083818759704, -1.9003678226259157, 0.37831345735097155, -2.4431341165255263, -2.35761426674281, -1.3031376963992096, -2.3416186501481397, -1.7805134860568717, 0.15446438720301225, -1.860761899825795},
    {-1.6546143252159968, -1.5955061117624452, 0.41388023328287576, 0.11137924180557446, 0.033940014307998, -0.08413561231913974, -1.892394059341645, -1.8252022587500805, -1.7402510439641776, -1.6472665664851025, -1.1891095819807218, -1.9047201225170047, -1.5970376318071595, -1.8111091140793683, -1.6957094316625105, -1.3173996023570902, -0.454238821564431, -1.4373408252179911, -1.732613191514448, -1.729152800018659, -1.2644071150904155, -1.310062178679941, 0.17058144960567023, -1.6086834466519369, 0.32254245123356023, -1.6807573147443282, -1.3731414345733677, -0.39528034309920634, -1.7720206418925424, -1.1029513692873483, 0.3348633999766954, -1.350169115474709},
    {-2.5343336325535657, -2.380704614483394, 0.7556784304225195, 0.5521821852776306, 0.01728321852458941, -0.0668714105142272, -2.262926413796902, -2.369032339189364, -2.2235247585297664, -2.398062885252539, -1.6508715171413146, -2.3890212997567626, -2.5978723216871775, -2.6748485102397384, -2.5509008055649383, -1.836435059268464, -0.92502069832532, -2.211532884815768, -1.7108943210605012, -2.5086711954328442, -1.9112349493228846, -2.048676356878215, -0.10759556077146123, -1.5908730173518066, 0.5766632278624753, -2.3945184098780965, -2.2994581570385786, -1.495261173699861, -1.9630254535291736, -1.5283956354711081, 0.7125107186236361, -2.3387642869841354},
    {-2.998618151118851, -2.4069344114813043, 1.0967527662316006, 0.7762804047845271, 0.20690554277242354, 0.13256513545664397, -2.569939445685561, -2.7487709120896238, -2.509564123853843, -2.6093095120318868, -2.236613298070967, -2.519241447679937, -2.958443052321103, -2.91294307098837, -2.769472797639498, -2.5460286551849967, -1.2544694301548944, -2.548790113563159, -2.114412719817941, -2.4382800546655172, -1.9728190734255788, -2.435124748086445, -0.3377938780395017, -2.4294772865192242, 0.6432614214762834, -2.5216582829433367, -2.854224964229087, -1.7928495133752156, -2.704832073137636, -2.3340215059355987, 0.32723284037071365, -2.520161008590596},
    {-2.240805879947786, -1.7527541791234582, 0.15958024134136323, 0.6904634656736511, -0.9198620606087539, -0.6177795127807513, -2.23479101455341, -2.0499035303028967, -1.9949052653739703, -2.1295679188252743, -1.5089854614788667, -2.0306982100628725, -2.141318949287527, -2.211393569161931, -2.211735631771563, -2.113115948677694, -0.4082736880636796, -1.9323693914287534, -1.9810717601038732, -2.134985721918589, -1.4358128018893754, -1.8974899862333072, -1.4156571601017254, -2.649790522046918, -0.4330329944218003, -2.271986782221032, -2.4804926114840704, -1.447732626495234, -2.2056661868423006, -1.2306182555965508, -0.37739582866709165, -1.9177991575031572},
    {-2.4090916434140137, -2.3179718211766454, 0.4114927676384757, 0.5692409961578758, -0.888075146651933, -0.7535349336818424, -2.520445092977873, -2.6182881913354077, -2.388166095104059, -2.3593686969834016, -1.8273803809589675, -2.5404602449621083, -2.6434206979696184, -2.4920773727044625, -2.495987713743461, -2.279830775959452, -1.3686016700553365, -2.4749720583744876, -1.947091351982623, -2.608461808824561, -1.8841147099574973, -2.3149649719739807, -1.4239037634915364, -3.006713829490254, -0.2374060277670143, -2.7530005369695667, -2.541459535791063, -1.3067614142448516, -2.3621726710817246, -1.8530521186539248, -0.1287104671982118, -2.741704534619315},
    {-2.4286123030848867, -2.3160381785208903, 0.36048800733419645, 0.6606406519192958, -0.7250636923463023, -0.8145854788422674, -2.8304831150638163, -2.380139051737219, -2.5808556941548306, -2.5197024190067054, -2.0131240315109946, -2.7964249147562863, -2.781794678046759, -2.7340770411884368, -2.6212569044718097, -2.677712709229256, -0.612668612096215, -2.379112226431407, -2.6861029764014495, -2.4080085697012774, -2.2634752940968195, -2.167706189892852, -1.3015231504529718, -2.7898232353780004, -0.1083516093711555, -2.496774832002878, -2.7515934777674804, -1.6629001722151942, -3.030616379321141, -1.8050085289530557, 0.024950927284911037, -3.024089021299057},
    {-3.140813963879262, -2.5895774086221888, 0.09839057699489831, 0.29732698920833806, -0.9385425935959024, -1.0523916037727623, -2.7992971672638434, -2.8495856433156987, -2.6025137185345697, -2.6851811050409644, -2.32612651154097, -2.8861179292138885, -2.887092145619905, -2.9261913856511863, -3.2356926089539897, -2.7921661371422815, -1.4581886648161293, -2.7855904582532056, -2.32689932855431, -2.758018579787567, -2.2120442096185666, -2.574314868307432, -1.4264322573966257, -3.056839251045103, -0.3638766167160911, -2.917715112562401, -2.9519791949535708, -2.012149063106052, -2.497427042117085, -2.2089423272820925, -0.20655211363443118, -2.83104709295617},
    {-2.8087625641617615, -2.4886555938797423, 1.0480845597688546, 1.2261870685956018, -0.15854623072868743, -0.31441100237013486, -2.365936492953216, -2.7295778577648346, -2.7473122412445945, -2.542968203241382, -2.527806812734069, -3.2036539305935112, -2.8216812231797155, -3.0089211451500937, -2.9067528729455216, -2.6818659153865694, -1.3048819632192483, -2.7509865078671347, -1.8959919533041045, -2.7150446279029876, -2.191493604495049, -2.6609179032838055, -0.5237989771191497, -2.7499089166026267, 0.7157111589674203, -2.691061955899373, -2.4612430626447073, -2.097830390713878, -2.2437497870957466, -2.208331456648011, 0.6718486028813874, -2.7451290444748078},
    {-2.790273447231868, -2.695207729792688, 0.5725380226976139, 0.32577102297806104, -1.1085020712373208, -1.0002812234024951, -2.3529048518952895, -2.896724604570607, -2.7576276142606866, -2.420901354085619, -2.0630830945708443, -2.461728030802443, -2.9677383527260153, -3.0102858249157456, -2.940136054515636, -2.897775600437388, -1.261575420131396, -2.825791131185227, -1.6194661645224426, -2.812817379582272, -2.4635909603772252, -2.6295251642255866, -1.410088096268234, -2.689151345967734, 0.3978651065120887, -2.7356848606002355, -2.6042310345269017, -1.857810257291674, -1.9279557491380344, -2.034730192406603, 0.2280608308788427, -2.8831571774522207},
    {-2.582857893273756, -2.0341912076764537, 0.4743683105202948, 0.2991075334408847, -0.44445762510070264, -0.3250803937963271, -1.7131961304276802, -2.3223289437738694, -2.426743981516459, -1.554081857146205, -1.6796344463530526, -1.6976642069706067, -1.7779549226651754, -2.2567223235778946, -2.0498036737127983, -2.107726352144674, -0.9862263924990154, -2.2790004828802948, -1.2776695997110237, -2.893575110300947, -1.9229351127918972, -1.9408847967477738, -1.1997187122519541, -2.3420171559491583, 0.3554664811716237, -2.587363960317262, -2.0542146726144836, -1.2890695292699228, -1.4115287030462085, -1.700728169771127, 0.5533625636388873, -2.6004343280519664},
    {-2.0669535597610293, -1.7802125142994354, 1.091238276732285, 0.7350709062679519, 0.5038964046139844, 0.5784630807867411, -1.4623330641537289, -2.0399400150847855, -2.0103287626875526, -1.4743430462783857, -1.5148551750013157, -1.396356855689539, -1.4867970795509333, -2.1035976883152183, -1.5595612888756218, -2.006858837606057, -1.0367341634356166, -1.9351254326477274, -0.9295992332967788, -2.161548696029771, -1.5838276230358694, -1.834149819276425, 0.1407325253316915, -1.6943170111632535, 1.1943719284043908, -2.2980798885830733, -1.981775759212157, -0.8653312174065091, -0.888791678959622, -1.3835904504705054, 1.165104733913732, -1.9236819616440217},
    {-2.4026880794412673, -2.1792747490253546, 0.01787311718762133, 0.23919329342624499, -1.0992527459282457, -0.9695259678717083, -1.2438795900244553, -2.426110735183791, -2.5201539023605912, -1.4961445272441638, -1.486336979788729, -1.9047165918524702, -2.4490496743053205, -2.217692849847033, -2.0210989674800244, -2.037470354412781, -1.0688372212586628, -2.4387118555755496, -0.6768679266376935, -2.439512887817657, -2.031873578286988, -2.370143693551188, -1.3977442264459914, -2.615852727084233, 0.24565299681108044, -2.605068577299617, -2.354521979769668, -1.824490193306525, -0.9787122162408879, -1.1124727219662836, 0.025635214196157174, -2.0672722050530306},
    {-3.021551067432743, -2.534216207965695, 0.38181898703180484, 0.5370793807593426, -1.5364613508333504, -1.3982635775367172, -2.3648142909765637, -2.7578761107825684, -2.963195668971528, -2.4508482424435547, -1.8615973608681986, -2.793927101075401, -2.9387533080044927, -3.14567233865247, -2.9307156466123767, -2.7068080936941996, -0.8458316570306345, -2.792716793411684, -1.572950689226413, -2.907881462005869, -1.9374179853024924, -2.405175894412458, -1.5466688182493684, -3.174060114116696, 0.382075808134396, -2.7264881215601475, -3.155716328099426, -1.7930767296934662, -1.79050536463014, -1.6954671445629865, -0.023678420117283498, -3.1975140037681853},
    {-3.0241243418033195, -2.709633309246318, 0.21461005893430574, 0.2298740266245273, -1.5425932742069557, -1.0332154550920658, -2.7116848295532257, -2.893156029367559, -3.0687388660186516, -2.6616930712255527, -2.065204322370724, -3.0278013250807887, -3.042546627453157, -3.235763686389326, -3.3237737608607563, -3.027404752779218, -1.3448911452906622, -3.194067774248406, -2.1704364476786604, -3.1865994410502094, -2.647735593753168, -2.550738098044031, -1.579254664393232, -3.2384329853532052, -0.39336477916110446, -2.9978204140519864, -3.149595161841083, -1.9496096849664026, -2.6241578942575825, -2.0655495136788176, -0.25625622749572835, -3.106054748020767},
    {-2.860234102267395, -2.6808038051179985, 1.8344277316037665, 2.4120926932580367, 1.3122663227175875, 1.2950018536654289, -1.5694132240482936, -2.9755787455129594, -2.7408886329792157, -2.5680083229991286, -2.15472873480327, -1.7627951498027803, -2.297503634030223, -2.6470117909296182, -2.654287384892835, -2.743605097820483, -1.3424329038336114, -2.8240159585099387, -1.4615392262325397, -2.9947858772888583, -2.648812633720461, -2.5514504555050364, 0.6784591164793621, -2.0240456779331617, 2.3597171762836977, -2.8302725480582, -2.498276232812968, -1.9793985638641525, -1.7998788148065927, -2.395379834140423, 2.240636758421572, -2.840144003555783},
    {-2.2719733661661516, -1.9034807321017377, 2.274434230694072, 2.560678089762099, 0.7974386107850617, 0.55901685048722, -0.3173305883228918, -2.356602022558047, -2.351842555595393, -1.137631588150645, -1.2622133073892396, -0.9193655315056435, -1.8524211269829283, -1.7989096508033835, -1.9190166660857377, -2.026270148723007, -0.7236786022272216, -2.264836911178735, 0.8784515155303687, -2.8163780377598737, -2.1830956167498967, -2.0872414456802777, -0.11412355057199428, -1.9563813912370434, 2.6423905510503976, -2.4431865038137897, -2.2104582781988413, -1.5106211089054815, 0.07894138608972863, -1.0612826832299769, 2.560203046752848, -2.1613209918502916},
    {-2.8816777127492026, -2.2889186083400292, 1.4090671291237078, 1.3808799478437341, -1.183700783574454, -1.2685222978913264, -1.6603743172229377, -2.956855166574304, -2.6572003263192743, -1.966447076870911, -1.9158418427281778, -2.2079266498882206, -2.8955844870867735, -2.9482648808021477, -2.8577895737907264, -2.6229924556570237, -0.8826045386137243, -2.6563435182882453, 0.3607256972844002, -2.8086593854179482, -2.3896376020091674, -2.553233694887299, -1.5598448606233586, -2.875912121751578, 1.568001555616965, -2.943464198283135, -2.5452151884141894, -1.8759161790879066, -1.0992018620273847, -1.6078664382779777, 0.7650917999782321, -2.355972334180031},
    {-2.9901240476280453, -2.5875960959003756, 0.48904852067498344, 0.805433145518443, -1.0643411410833468, -0.8642228378068316, -2.344808246490523, -2.9065053188581627, -2.917546254898413, -2.8113468546778635, -2.3004937436435577, -2.7685694422278266, -2.886488520000418, -3.048849941065177, -3.0188673255360583, -2.61116008327883, -1.2448680083715218, -2.7112055560218153, -1.6699068876764225, -2.9635265539397873, -1.8388378873772517, -2.3709554681802976, -1.5746516721476274, -3.0765835881701986, 1.0020291587451735, -2.5159481201980887, -2.7624108297805376, -1.7614348021911084, -2.110156412451277, -1.7788673707153078, 0.4371038445837787, -2.374667545801755},
    {-2.7660947754512444, -2.270082332906018, 0.8497319716578893, 1.1645668645975298, -1.4274916493606487, -1.3546977879298294, -1.2432538055172884, -2.398510767070087, -2.703000690524, -1.4975817298230283, -1.299013824529885, -1.8110550750379903, -2.4994744407314977, -2.2949779273849757, -1.9494273549738905, -2.430711668087233, -0.9633989273528923, -2.391893724012034, 0.40257263389048453, -2.5496388273059076, -1.6712867406836642, -2.080986056388241, -2.2441231519657645, -2.445450689729091, 0.834491835227138, -2.5095179725854457, -2.57203968030237, -1.6700430155635366, -0.21025622588145196, -0.8652915465632899, 0.54112499645565, -2.0380015457359826},
    {-3.5070788152719836, -2.583103397121239, 1.3160940075128353, 1.72927704437344, -0.6558962501062924, -0.5712743299978812, -2.2235057816431385, -2.9276483986103004, -2.9751267606246254, -2.273377365563421, -2.1670601806469114, -2.482452057865379, -3.0636881700810483, -3.2009732867279963, -2.8820178272635415, -3.064790990701726, -1.4153197315564368, -2.917775611764443, -0.7510827923726349, -2.7666567482792104, -2.1121132343485223, -2.3825972842177006, -1.1895342291830955, -2.766610561465486, 1.5514213426564738, -2.7667836088507975, -2.9456114069354955, -1.8506405067258307, -1.4489923281591939, -1.8831175439689152, 1.2336645495549756, -2.879640104512151},
    {-3.214323345213788, -2.797676567693509, 1.240692911941513, 1.4273177510623751, -0.5212613246364833, -0.8702117630103751, -2.4517668907687407, -2.857504056410941, -3.000280685813134, -2.3475838281491717, -2.3573314758056023, -2.584384243441277, -3.052467905828958, -3.1497932699200306, -2.868650345568559, -3.170781206201305, -1.258401746815169, -2.7199684684660683, -0.8300452427268082, -2.9732582187143284, -2.3501179076631318, -2.4454461236797838, -1.2750934065859998, -3.1678898083168785, 1.3227326056128383, -3.0942823636321517, -3.1529672987394997, -2.0016404906979277, -1.4942241272124803, -1.9609831299221567, 1.006059121182407, -2.7795493147320753},
    {-2.960078969917421, -2.4111791202483537, 1.25454829393971, 1.583062525662926, -0.26477821070557184, -0.49461771665756504, -2.1541430761983285, -2.671898513269464, -3.0302173666138486, -1.849243608915654, -1.705415270966175, -2.751459065923862, -2.97943035567625, -2.7699487228783255, -3.049878966365957, -2.7060788115359884, -1.6244233134665975, -2.6464253555260293, -0.04558583761700021, -2.7546238482570193, -2.2213656100235024, -2.777769123530444, -1.263208448149774, -2.775529677228888, 1.6191944063131873, -2.767295405162154, -2.6320171679073696, -1.7011223156372748, -0.9537622813477474, -1.5353708888028232, 1.0686298675977561, -2.611561989065277},
    {-2.982937375138135, -2.6190927332999805, 1.4287025782440297, 1.64504267559375, -0.4911892669782992, -0.9322274625997908, -2.26606525076899, -2.9479812028952104, -2.760902443589616, -2.297311887208508, -1.927362457253196, -2.3548034005000207, -3.030657273265327, -2.9637876356238357, -3.02881583820055, -3.2043104548010715, -1.458771464431712, -2.6266544190080157, -0.6948290765923922, -2.830158653709213, -2.306277112873385, -2.8357860020442853, -1.365381311187455, -2.9797580062832214, 1.07343893023682, -2.768603590465938, -2.7118940841497015, -1.8521176473974796, -1.3261977224991215, -1.9769264350230558, 1.116156475056169, -2.7659588930408},
    {-1.1390756793092454, -0.8653353511022732, 1.0365309397875906, -2.0263269361363583, -0.036648080028444954, -0.4292509546322632, 0.5498822490691629, -1.3655713074059417, -1.3030217017601455, -0.37388927506206837, -0.8603140838854625, 0.3770950650279557, -0.7345583706500798, 0.124702942808887, 0.055249552070867965, -0.6653554021508352, -1.7605497594432686, -1.2926679561323458, 0.026960816559812084, -1.2500316347162388, -1.9348118480948593, -1.408046518413513, -0.010858237171535353, 0.6945522576403589, 1.1379386443114026, -0.7775828788075049, -0.7288858800299436, -2.1785554823028805, 0.5484479409087595, -1.0558273389517148, 0.5229143832944095, -0.41131171137270406},
    {-1.01152016904576, -1.0061201535992588, 1.5541095437352683, -1.6052836505344694, 0.5831712972649717, 0.1590465863327851, 0.992904853525667, -1.1364676148490422, -1.0926980626013754, -0.7416249073971064, -0.7122304660640624, 0.8506250012081771, -0.500243414299567, 0.4679896227294353, -0.0075442744208110485, -0.9755592241718973, -1.4647211495983368, -1.2271040677097362, 0.4074691310327884, -1.7249839170564105, -1.673002143408494, -1.3047705992889178, 0.5553447267547935, 1.4452617261581295, 1.6036580383393517, -1.1016880094209738, -0.8955495723616403, -1.8276837372706454, 0.8287777808547507, -0.6742537313400183, 0.9133506861231927, -0.022562704632436485},
    {-1.390560547308928, -1.5724119053627428, 1.5994613506582678, -1.398811997942746, 0.45927088169849, 0.14078639317633648, 1.2725831838689843, -1.3623238711014778, -1.410895022395119, -0.4721736562512408, -1.1181918980385261, 1.0137605564598438, -0.9469754648253788, 0.07861148497690289, 0.06453776919420895, -1.32129886104217, -2.148887123864439, -1.4832711425469618, 0.3556503716769355, -1.9146886248569075, -1.883158495679296, -2.061503985764157, -0.34817069541013784, 1.969165754351633, 1.3325008575785011, -1.5126063240738792, -1.0428575519747871, -2.4991152210865497, 1.3028584535023857, -0.8892079392121399, 0.5993284336276679, -0.2838368812267704},
    {-0.9121824401884009, -1.5905345393840586, 1.6391785694068945, -1.516878545229523, 0.8291929844981298, 0.06790940888713513, 1.0028618195461259, -1.652193095654293, -1.2989079535420764, 0.01720795065962064, -1.1458047475655495, 1.2250778278232106, -0.7139840239290913, -0.023231322584298848, 0.08617153230643923, -0.6456881626015597, -1.9228185599368566, -1.4904406336910014, 1.051623686813027, -1.6709654347274763, -1.8603350033035333, -2.134367907603536, 0.27276816121973707, 1.635352962166892, 1.2122744433835535, -1.5110371000585843, -0.5000841933201613, -2.2096695930850654, 1.4679218038717032, -0.9256526932409382, 0.6855049227411103, -0.23364452764873256},
    {-1.02054210131573, -1.5964600411278853, 1.0262080602411656, -1.5342792724051086, 0.918253175782735, 0.1137977957633227, 0.4659056886244286, -1.4644916440648967, -1.356553898330082, -0.6048999778147651, -1.6301247881683687, 0.9455751998011942, -0.5494697463969103, 0.07698810270109673, -0.3816316922600946, -0.8399498246813275, -1.9567154821621675, -1.6457438167867149, 0.07637643393564231, -1.877876451601183, -1.8746932125930469, -1.9527749175968612, 0.3086730727963799, 1.695771197812614, 0.7816390324390877, -1.6564926799530422, -0.9697484215948179, -2.2169258919976644, 0.7910577522262686, -1.4273998458787525, 0.503716246397188, 0.0060994827501484996},
    {-1.5725924744907176, -1.708934939754546, 1.213458358322759, -1.4956903771547851, 0.416994226526163, -0.23625690418580117, 0.8223592149784629, -1.3080474686269659, -1.5201364790417726, -0.33811715227562866, -1.7995828838313834, 1.2202227121207685, -0.9952271486956268, -0.06580026799974568, 0.06904432144337992, -1.22604878625952, -2.2066119216748246, -1.8053858337305315, 0.6546289019721439, -1.946532239863008, -2.261020595288544, -1.9243190640765635, 0.21972422464602356, 1.5746124100615129, 0.952683862899364, -1.705414705662823, -1.2394116941743474, -2.365231757158788, 1.214332805137519, -1.267974257713963, 0.5304905344682058, -0.09717333488046632},
    {-1.6510569919815108, -1.9859481075152494, 1.6806746114596862, -1.4521427979159214, 0.4666655461223452, -0.21353691963376822, 0.7386282971036121, -1.4105017717032202, -1.7212816454544795, -0.11253955730490282, -1.6433463446865006, 1.312242416023826, -0.9277125837243486, 0.08661841190071827, 0.15334556255846474, -1.3261823885757578, -2.278051589266925, -2.2202910805533382, 0.8800786330925939, -2.0673011284108465, -2.273551739103366, -2.0786073052228424, 0.2823632060758792, 1.5236859064922028, 1.2373672615477962, -1.7499852488943555, -1.6754440294776523, -2.5901136448842235, 1.3139076712808464, -1.276797956092696, 1.0351515758245415, -0.47457612135217425},
    {-1.160385675755902, -1.6299752703445447, 1.6633020206702396, -1.829390215119549, 0.6122058571125606, -0.033032737158126164, 1.190119878493813, -1.1963230259704714, -1.8443590414549116, 0.09554102711039686, -1.3535081161222016, 1.267572516549788, -0.8907544667060683, 0.42756191670958005, 0.3217602293481788, -1.3231630733148447, -2.2887418656636864, -1.7224252325928113, 1.0948677862593459, -1.6950559371859988, -2.034531606799361, -1.841359665313424, 0.8236153679325167, 1.7633508045981972, 1.3881102682193749, -1.728619985546901, -1.1428121905233903, -2.407421105572264, 1.67791636849353, -1.1129518191081755, 1.0717262323271854, -0.31894905847644267},
    {-1.3640326389884545, -2.054698953519393, 1.7537656919788362, -1.9470181740417507, 0.4837615159927341, -6.801260588782902e-05, 1.6867000404078938, -1.8172941981488797, -1.9293013341300986, -0.23074895651628105, -1.5537632775155872, 1.194146606112044, -1.296562146969585, 0.09975030603175848, -0.1269072175405154, -1.2539038420288888, -2.2862142899769187, -1.6021952160689998, 1.3195854054691722, -1.8869358232941682, -2.3227349952097214, -2.045306789886244, 0.06395237758332754, 1.7024087520189553, 1.2427769005839924, -1.6417192351090233, -1.4032785275721786, -2.439094425548258, 1.8654210074218465, -1.1722813137843533, 0.8593970199370753, -0.5505213535368931},
    {-1.4190876943780921, -1.6410753653775443, 1.8804801086850045, -1.7019842743518379, 1.1398290547764778, 0.24612211175808604, 1.8057199762139164, -1.827455566779713, -1.8620466043754382, -0.2294947082766086, -1.7524925256611195, 0.9845539290702137, -0.9214615046724559, -0.17874256994094376, -0.4350640516824054, -1.3203509970565646, -2.2258581121099406, -1.7298741267995483, 1.1583651015999061, -1.7878041241819032, -2.3004592747971273, -2.069553378234856, 0.19755953513341132, 1.7090607222304912, 1.9228294201318592, -1.8905233441060796, -1.3312523426372995, -2.104724113927997, 1.8594925700918585, -1.4391304437084755, 0.8829583397197253, -0.2774477010576037},
    {-0.9846379871698028, -1.814963355828058, 1.9961154997517294, -1.6687474176135901, 1.050214352752457, 0.23628058897510176, 1.574782996454474, -1.5855749700235011, -1.3409703173054837, -0.1040747846881412, -1.5183411750620663, 1.2259587612673084, -1.0307513624636009, 0.0005262532808694457, 0.1220810595715773, -0.8836389351685333, -2.3864450010159346, -1.5691296874910525, 1.1542933095407744, -1.7943663297634116, -2.138733932678899, -1.9903054503024808, 0.3249120299196831, 1.9657204880226045, 1.9467611479166669, -1.362132668128758, -0.7764708822401026, -2.2534117274388064, 1.7461914413862916, -1.149337763037803, 1.5193066436536689, 0.17122307047589505},
    {-1.2268076848767067, -1.9172855197667664, 1.8313896756707704, -1.6563230761924386, 1.194736367584368, 0.11902056155179441, 1.6030308285599413, -1.3937505493741482, -1.6465575173886886, 0.3624125408454822, -1.3797505640060748, 1.4545975157656397, -1.1183002423099981, 0.103558601555081, 0.08187112877893399, -1.095063432801489, -2.347220894397042, -1.8078480919088147, 0.8473641612433838, -2.4244734862472885, -2.2600221335129245, -2.3362660613393738, 0.7953286038904644, 1.810372081788788, 1.7594021674087754, -1.7754547423898501, -1.0287444631713116, -2.6825099243502595, 1.904580240119969, -1.0767376053236475, 1.6699067401038552, -0.012407934561508752},
    {-1.695277178673767, -1.8261922560798405, 1.7018817113730074, -1.6065028497736462, 0.6831138536087311, 0.050854122183424603, 1.3889534623828108, -1.642333334241347, -1.5142357304167986, -0.4582201025372522, -1.8648483653938797, 1.2436398269734021, -1.21716368096171, -0.3259035428061484, 0.10095124926647088, -1.2747658620639013, -2.0914567117206473, -1.8485294709897835, 0.6253201590917191, -2.194546059145904, -2.1161179809303294, -2.2946132956822303, 0.00885102790961975, 1.6176350941903783, 1.8952752213998116, -1.6037293907488432, -1.320836081728862, -2.393197239830842, 1.9240549324934109, -1.348865591171879, 1.0046147103173484, -0.36189716034370467},
    {-1.3746315867848768, -1.358554691815505, 1.952631142924727, -1.4630246472990223, 0.6501284598976982, 0.09381276165168384, 1.4542573326965347, -1.7243748560438865, -1.493810073419206, -0.0802934373678779, -1.0884784751396646, 1.2845213254708276, -0.8205489629292407, 0.08426578616911794, 0.3533292469725449, -1.1464037319205165, -2.2787351595682694, -1.6588524630747288, 1.335662565267635, -2.049695847186517, -2.107988663192474, -1.9492620516783188, 0.21678597850447248, 1.6397793720286153, 1.9258137607562362, -1.3696582908371724, -0.6774533613584668, -2.3599533489327347, 1.8346079207131365, -1.0652682409261665, 1.180818563499912, 0.3928642028093025},
    {-1.332506856850349, -1.492907749197834, 1.3761385171377643, -1.6519538386056938, 0.3796083189335253, -0.03699161360462326, 1.5329554334973954, -1.1605138051785293, -1.3961184583018227, 0.2647698605168122, -1.134438718373554, 1.4553271373614702, -1.2743390113102926, -0.1357867511799399, 0.44102545884710326, -0.8290767703131967, -2.287051903768837, -1.3212507211394084, 1.5305833466361514, -1.9432078876007535, -2.397791705231914, -2.020423293743662, -0.07924963693886831, 1.6139996051406642, 1.4619519257627955, -1.3069135454721101, -0.7537070317261103, -2.596050986308828, 1.873522766470695, -0.8221168413443832, 1.2343909174957608, 0.03024401290538631},
    {-1.3836220687752039, -2.1508753779269694, 2.1295736694632676, -1.944421982172528, 0.7357546335190607, 0.20048623147016528, 1.5473481162697076, -1.435066916563331, -1.9659018083853221, 0.38584190319249156, -1.3326099631070356, 1.7481176642144944, -1.489422911186433, -0.29577327176466967, 0.36065747968673634, -1.175349872177926, -2.4382039229842873, -1.393628419021484, 1.1411417876794692, -2.1855545202324547, -2.255240256428784, -2.4478539792439507, 0.16283534984898357, 1.681934269536438, 1.8384675205805814, -1.490374449991164, -1.3451645506544827, -2.403492610552629, 1.7593607252897356, -1.3402078105452975, 1.5372184025926765, -0.024583073460027447},
    {-1.748260680910874, -2.3347368072806147, 2.1351869096153733, -1.3816282155475177, 1.5517934569285292, 0.7974180712295904, 1.7957683367722437, -1.8364412949904627, -1.9157481739016835, 0.166083122499593, -1.2351317857543738, 1.7210633032641038, -1.512971464977956, -0.23690784045319932, 0.5454095770940713, -1.4492364379162372, -2.2384655053254368, -1.780857725337397, 0.7951862022736612, -2.575819923845978, -2.3611722095838505, -2.3270603544788675, 0.723530513235514, 1.8844847317718805, 2.2785304476848713, -1.7085726743856604, -1.3732351817711084, -2.2975912606537787, 1.6981141944461566, -1.456176553979014, 1.82989637179842, -0.34532647502254976},
    {-1.3331297180746113, -1.8560759347408704, 1.9235130345716593, -1.3689209749596816, 0.7040530977828938, 0.23070649091966164, 1.6845072780626655, -1.9342724052753866, -1.9359131407539305, 0.1645060530104113, -0.7450468419687019, 1.965437396255104, -1.4612329428694422, -0.14326941699633625, 0.3190475257991652, -1.282662510535805, -2.3996713612238914, -1.5333426795056304, 0.8241656015591349, -2.747725116625717, -2.188105744426991, -2.089970735087459, -0.18577506124242266, 2.117330793516778, 2.2997971915930417, -1.930461775670073, -1.5009382835706147, -2.464716953107153, 1.7501199345292282, -0.9313318392310349, 1.7987487954999015, -0.36655861447433846},
    {-1.4777179146919028, -1.9815568820663267, 1.9309584543849345, -1.5201516779922974, 0.47803477918456916, -0.17768018174741304, 1.646707812266196, -1.5298509822834034, -1.5531026073714473, -0.011415248737810161, -1.162511372303992, 1.472253371214409, -1.1238180627164378, 0.30290821232848275, 0.3534588969076484, -1.0775564312735149, -2.147834581503002, -1.3257371032111798, 1.2874804916553693, -2.4250040788116918, -2.121040988600312, -1.9516881837549218, 0.0425279208861335, 2.123559740537635, 1.9445504481978537, -1.7399919453029047, -1.1503115398611161, -2.3366440741132815, 2.1550969428899363, -0.7065016746023447, 1.64480957338377, -0.18825887479734488},
    {-1.3736837067156127, -1.5979482787210733, 2.2844061663602466, -1.4670600808963283, 0.9167303708078061, 0.04234083831690982, 1.5926235829620519, -1.3424684062548793, -1.2490630614778666, 0.5828544922956812, -0.9913978797460163, 1.9104976568733802, -0.8457557034259121, 0.5010828731917509, 0.5503214008994209, -1.02238317563887, -2.005907279950995, -1.410518673832353, 1.5157187863058952, -2.035488380096374, -2.0561853202887823, -1.9256233779117353, 0.243790976510643, 2.4750311519765122, 2.109129339643612, -1.4730188888883757, -1.2148510078483397, -2.224545030851205, 2.118223400145738, -1.0412954857464363, 1.347744364234944, 0.09128492986291105},
    {-1.3188340077613903, -1.8825208126591548, 1.9240676932839584, -1.6547927800189444, 1.011651656084647, 0.13700669637473686, 1.6962844276758537, -1.7299256955822524, -1.8563126652245652, 0.035956525085080474, -1.4292297217189855, 1.6859920006343447, -1.5047701324867533, -0.014973399315149275, 0.21012605661497202, -1.593338287722711, -2.159342702471603, -1.6750817520030947, 1.0911691585822065, -2.12807175574262, -2.4051648396319028, -2.4306709404492377, 0.7172098437911288, 1.988715068844293, 2.003284722460593, -1.4366399404251158, -1.7174999785546898, -2.3813998323972587, 2.016111389535511, -0.9802633968207227, 1.754248896856164, -0.5062828073862913},
    {-1.298464261253594, -1.8642355815638993, 2.2900222710242644, -1.4492336390254337, 1.5018169315904997, 0.49663566762514655, 2.1266793962763044, -1.8478432916406586, -1.8718741570622257, 0.49234632959262914, -1.402413247610623, 1.6291721214668506, -1.6646428374505706, 0.01704683505690672, 0.8036721173761748, -1.3139352415929497, -1.9462991762810635, -1.6643520536211152, 1.5768339180033621, -2.0547326284653384, -2.436119005977503, -2.5486059568823456, 1.10525082764628, 2.4801335030489535, 2.6367291309432708, -1.7001277752490378, -1.2270377557083498, -2.7412154986303947, 2.1660778582021236, -0.9777893199267664, 1.8833201230489525, -0.2615316699929121},
    {-1.2688851714365532, -2.1691851489784066, 2.2308460082897343, -1.5262793940861317, 1.2044997915625149, 0.15009136095607753, 1.86091091780396, -1.6121637550628327, -1.9256478082432447, 0.7380043912965303, -1.2279616836534428, 2.155014030135878, -1.199059328483458, 0.41633258887986224, 0.7870485266687622, -1.0754556691141275, -2.397421783756691, -1.3479257111275866, 1.429902415363246, -2.318887542597119, -2.702140028667032, -2.400061904907784, 0.19414146075055755, 2.286609678829189, 2.5090741711372577, -1.3095786989304705, -0.8873090431072874, -2.6969275984113024, 2.3661310565335154, -0.7365265370753252, 2.1433415868443206, 0.15708089467774866},
    {-1.7349509773027345, -2.2901258308402053, 2.110119271692227, -1.9612854574888927, 0.7072477066518612, 0.18930368120659932, 2.3276998761253145, -1.99056476792645, -2.20699519167242, 0.4378505912670448, -1.439697377921926, 2.2807804555171796, -1.6279320357391975, 0.3161293126168505, 0.7700470309808883, -1.3293620873677805, -2.7398881194304474, -1.5210563126605432, 1.3706813913721305, -2.4512555923821715, -2.5499800233389065, -2.641365935266678, 0.07545588995163918, 2.3679864826495884, 2.3467338786343324, -1.8799978381832974, -1.2656736907930575, -3.0168573876909233, 2.1094737042279132, -1.1328312068584834, 1.6745527373258207, 0.014831990663694668},
    {-1.447008758530987, -1.9267999671166545, 2.3662017496232943, -1.6814506992256435, 1.0267296645111623, 0.5863902015486486, 2.2038251210308086, -2.0287614989241174, -1.7077576261706011, -0.030742173608561636, -1.2683739133910963, 2.139488641588858, -1.7162003657004867, 0.4549003783639581, 0.9761053863170648, -1.1077493931152544, -2.548886544143387, -1.9976660346518724, 1.1676494959505357, -2.325702763353741, -2.614069416143416, -2.3410545026893246, 0.2764262216591533, 2.620148931507346, 2.6257359243646077, -1.8739076043699607, -0.9473804710217614, -2.63634275415928, 2.239557303045658, -1.0449949642494585, 2.0110576025362863, -0.22291941807465543},
    {-1.4141266303451685, -1.8886390024408026, 2.2018971704849144, -1.5455150614795903, 1.0362680027621625, 0.21778445768669336, 1.9032640403757108, -1.8568324595456311, -1.727561503562669, 0.24666786759651463, -1.319500855391354, 2.1987414951226185, -1.355793710743164, 0.4844053539362222, 0.7017924627939439, -1.3397763162191914, -2.2059896998309365, -1.3724794271271987, 1.6080771145036916, -2.7065481906352202, -2.6001143368020965, -2.5776595021273203, 0.37410106276968225, 2.5338642707383805, 2.4453065763407658, -2.0157728656205482, -1.0053187394248548, -2.7737671371239263, 2.2926402491004305, -1.0269170021563068, 2.12852330381139, -0.337491211777055},
    {-1.3055599657049073, -2.10183411873768, 2.3876453892346237, -1.5906592715997443, 0.8465944388364048, 0.22175075220563, 2.088752152384733, -1.603336309092686, -2.011347039112208, 0.3988246784151793, -1.533082090716866, 2.0691407665808215, -1.3479111896335998, 0.2872566955859368, 0.5779687754442019, -1.5239436659040817, -2.524300817168241, -1.5578261382450465, 1.530252582071427, -2.322264596798582, -2.8107381135592004, -2.4922473603785047, 0.41873194246560413, 2.1568668084878158, 2.3887495359813777, -1.9347728468403302, -0.9377157258625158, -2.7595234916471987, 2.581304673119256, -1.0591482704867008, 2.19397756019715, -0.3980978891987448},
    {-1.6976349690612123, -1.9752472616044505, 2.3727613565772185, -1.4149819570721405, 1.0325416635990354, 0.4230503388908289, 1.8700532030392518, -1.8685597270868897, -2.0174122125383245, 0.13123608977947218, -1.4587073644620032, 1.6337513647348345, -1.5271030993002035, -0.011771870383898, 0.25592678599309676, -1.4862992916914732, -2.5097816030046802, -1.8196460955535567, 1.5822158636814325, -2.3604779240378146, -2.4331292965857845, -2.478119193000216, 0.34692081212582615, 2.2467323958160432, 2.4120340319395126, -2.2811217366325542, -1.4500877686021836, -2.8547042819762614, 2.210237667640901, -1.1903344553707798, 1.9086634291574966, -0.5989956617226827},
    {-1.8242346693694556, -2.311669184219457, 2.6325151156265156, -1.323952904402125, 0.7836093216619885, 0.26054679539293973, 2.1949084651566904, -1.9493768997026548, -2.339581382844488, 0.19648441286268978, -1.3087996372921213, 1.7194056236468493, -1.6350418785951726, -0.10029034085680329, 0.3778514558066416, -1.5903533784616388, -2.504750213614945, -1.778227998482383, 1.5613348055629732, -2.5262525599197767, -2.596268537149488, -2.6405808141802787, 0.04275488944378826, 2.093768305254923, 2.2486635750385187, -2.2183272525750652, -1.3872213964802902, -2.713974259586291, 2.4187555645748477, -1.1269129777812508, 2.058702449681274, -0.5123353329937065},
    {-1.9107311020390003, -2.2233936308885847, 2.392989179735009, -1.1632264075044154, 1.478568605781243, 0.6982325217450339, 1.8834766440688155, -2.149622404531811, -2.247455027991453, 0.2692409962235587, -1.5621939444686872, 2.1086709649010533, -1.5308347081193903, 0.03006236656478832, 0.34745631187334863, -1.4188027967038739, -2.50956132511283, -1.7725797044318976, 1.1432791704485852, -2.6586053375872734, -2.974217638752983, -2.89782388393745, 0.5785367628788678, 2.493359534877064, 2.4860897822412267, -2.2539987704906697, -1.2490149255963257, -2.6000500171924688, 1.9447626113923888, -1.3123551134865163, 2.239632467510819, -0.27408720609614246},
    {-1.133890002704016, -0.27240562293876275, -0.40049948855073664, -0.1385011053214985, -2.7850069554537047, -2.8518139486242617, -1.2438032491424442, -0.18597950957875237, -0.35622200704440726, -0.014838251184569325, 0.6396374795632015, -1.3773625482061773, -1.0880204480923605, -0.5311189433338185, -1.3024364459546158, -0.8637624938708458, 0.08932347214888654, -0.20722377041521217, 1.3879127652091696, -0.641920995452805, -0.34952410157410924, 0.2745977776178884, -2.333195642208291, -2.0047374260650073, -2.1194124221813815, -1.2627938403627534, -0.8613276153041308, -0.4637578870668519, -0.6534657788657646, 0.6470272566557371, -1.9006304321528134, -0.3029407205600405},
    {0.4479535480452767, 0.36589118353993505, 1.1134855213831718, 1.224204546049368, 1.3807538295909947, 1.2050541060152908, 1.3657506622177966, 0.4752878412644399, 0.33524485825218237, 1.231205045035975, 0.5404623198866009, 1.0360882516620564, 0.6504663664641906, 0.8733471055891174, 0.4595638251952882, 1.0924325191796411, 0.6842941654061275, 0.6672045303697143, 1.2438165762535187, 0.1871013510371158, 0.053320905877778005, 0.13127188726218236, 0.9481160177319463, 0.9022857121355292, 1.5401473946742386, -0.01103142366671058, 0.5151031788069687, 0.1900595204367002, 1.8158918677639384, 0.8486851204817454, 1.2740850572976776, 1.0239389372490058},
    {-1.851745750292734, -0.6690572372724647, 0.2586623498834494, 0.6774187668006402, -1.4728775050412803, -1.9780402032265898, -1.7159623336025878, -0.8999616727525228, -1.3555656995357148, -0.9011438248653131, -0.3534615883753597, -2.286369320498609, -1.5043349277884388, -2.2842029128005854, -2.1905657055732326, -1.377777121565896, 0.7658704962276126, -1.0422742248371335, 0.506135778380864, -1.2778400288743104, -0.6320492654153439, -0.901818434857181, -1.8673019088726215, -2.4736534082182757, -0.43980616070874334, -1.9569413801341224, -1.70468374336826, -0.45793165243876094, -0.7522158969138601, -0.279929816634415, -0.6657442796824934, -1.3897433606363299},
    {-1.2977765175363796, -0.7179490121443826, -0.388477112875582, -0.20096458321391408, -1.8155709097040182, -1.9081844545655797, -1.378271458061903, -0.811181014374762, -1.1272967409396424, -0.3776326698077799, 0.0191645551977969, -1.5033645030832563, -0.6680281294201581, -1.3182406837295597, -1.0415902956023555, -1.2293466014196102, 0.3133646453451015, -0.5916322222346472, -0.11811923797263485, -1.047013299079301, -1.0523050367244118, -0.6129874016391118, -1.9046928799664866, -1.8499761122116443, -0.7011014389023712, -1.301341603997877, -1.4740770232497846, -0.344047382061237, -0.2614575221268597, -0.07683160419395314, -1.046504797620344, -0.6026450469191865},
    {-2.2903649812407982, -1.6372495797244055, 0.7628264238975371, 0.8881303516051203, -0.057499824482799715, 0.05625516092857158, -1.533032215912612, -2.115433212158241, -2.2331424224873926, -1.520714911972096, -1.8012135492953383, -1.747332487182192, -1.9349652733143798, -2.2638163690066055, -2.2199436268657484, -1.8610403530410362, -0.7467140942458457, -1.821790921978749, -1.4195924949234593, -1.8418256993130273, -1.8556136571408102, -1.646531068722681, -0.40387811766688736, -1.991927393483057, 1.1067167653559022, -2.242188300104374, -1.9597121965185464, -1.3066263530618396, -0.7450458587172581, -1.4698092796123752, 0.9218573312308883, -1.8487984823138481},
    {-1.9397662826308177, -0.8795130691754653, 0.805052123638651, 0.9621193421050821, 0.25189087848537617, 0.2180883107454933, -0.805899288345259, -1.5083870046361254, -1.4731624142510837, -0.9836945443194035, -1.211160093699488, -1.09229049336481, -1.5126960344959124, -1.615946327812164, -2.0262469647791193, -1.2238087217693592, 0.029846214659007556, -1.519716386459531, -0.7089195282045292, -1.3968052764209036, -0.8628146996456223, -0.7764823943459558, 0.09688091303322238, -1.149504839387414, 0.7737478453822199, -1.599425223787973, -1.230437928378886, -0.5041346390006425, -0.33606382099989723, -0.6708791969809001, 0.9700208971991339, -1.175452045434748},
    {-2.025228531697405, -1.5997313073854924, 0.49658571489188674, 0.7060641872825605, -0.5731786464928469, -0.5785116689752212, -1.5305799318240063, -1.7950290676493361, -1.6423780677572914, -1.4398430099145803, -1.0457566931727529, -1.6144604186755196, -1.9688793975811443, -1.9167832210107336, -1.7862889435937468, -1.1702231200549473, -0.43910662922856747, -1.695718767223293, -1.3477651199918006, -1.9436762586689915, -1.1349940795595943, -1.2703805234274288, -0.8487919141438882, -1.381020549755153, 0.007820599101475895, -1.9098997151995565, -1.7070439974605924, -0.5171263581189818, -1.4802937594690517, -0.7060057492102996, 0.016836447723378372, -1.3110683226934812},
    {-1.08361833167155, -1.0640604458481442, 0.188599221685299, 0.44147603916973227, -0.3243904973671074, -0.07555917346640263, -0.9977735017431861, -1.2561150908216732, -1.1218239273223136, -0.9475908744461826, -0.5587029026275641, -1.3879661643289212, -0.8278476457008952, -1.326940736634842, -1.3373044024824476, -0.6615833423885533, -0.13063788212090627, -0.8408781379466549, -0.7006275730901809, -1.0204506546904113, -0.6202757674983572, -0.8767360588150718, -0.2908477903169064, -1.180480006589668, 0.043777981767615895, -1.1845146998949005, -1.1152171172667167, 0.0482559447445206, -0.6327254154078767, -0.704670851602737, 0.16719168805194345, -0.8691269659392205},
    {-1.9268341046961128, -1.5042478309991552, 0.9617678472149618, 0.28169855292795504, -0.4377592638606222, -0.34038513087450123, -1.772502636241292, -1.3845904272470029, -1.870149764894378, -1.3949396073414144, -1.0873353436764612, -1.3616431992459108, -1.8202141866109443, -1.8206027889629572, -1.756454459991113, -1.5344542247431823, -0.7160596240024004, -1.6059031748457666, -0.9474905800860876, -1.801069531058885, -1.689514969965127, -1.620031296481326, -0.48882850812012935, -1.1883234750511205, 0.4921878699979465, -2.0140624549837045, -1.6184911454248199, -0.968832453173561, -1.0887250354803135, -1.1718473670696472, 0.7016462507158159, -1.6481729754395187},
    {-2.228185971752701, -1.6580383323368846, 1.1345103161022019, 1.066157299451639, -0.27691323149273234, 0.12848412263228234, -1.902656045002808, -1.7017968583345238, -1.8721219789031243, -2.1596456338534926, -1.5951720435145709, -1.8697755883908656, -2.0201045073949366, -2.0457257353936225, -2.29930392555795, -2.03324199044502, -0.6250135265794823, -2.0764502618330933, -1.14201568224149, -1.9925198231842753, -1.4351269829636937, -1.6908898733769882, -0.897123537428736, -1.6970363758986062, 1.084166756798052, -1.9872834861565571, -2.2571404443097354, -1.473124880717076, -1.636126214912719, -1.170440835314658, 0.46481026587129864, -1.9237446627133092},
    {-1.592758907758362, -1.0788605822616582, 0.42552301447921415, 0.4453773238823345, -0.7948690813485987, -0.7482661783189647, -1.283599830514305, -0.9039648718854872, -1.1891878536763372, -1.378753540495394, -0.711184273549814, -1.1979248898042985, -1.5354832944955585, -1.96858733674319, -1.7385058777993543, -1.3704856117246274, -0.026964983666514616, -1.6053981928243448, -0.6651989661515272, -1.4061212874562778, -0.5313578706759353, -0.7576058312773521, -1.6873830409419255, -2.06177184501641, -0.3911258860471701, -1.5453492657016077, -1.82632835164015, -0.6020044478825145, -1.3592557238599923, -0.5695678280356278, -0.41233826910836974, -1.3621003129726728},
    {-2.012450958518218, -1.4318703733107125, 0.5744518773152728, 0.9331289165032137, -1.276611498411046, -0.9978228096265095, -1.9365873398195768, -2.0963660562305684, -1.8019397561433153, -1.2324618839875694, -0.875011301081613, -1.6993568488727238, -2.2628072973782793, -2.00456592443004, -1.8438989640584018, -2.013921541739011, -0.48217313924281846, -1.6011686617168244, -1.3966512252219672, -1.8717805831676253, -1.1118806194336037, -1.598892141502998, -1.0389860161447948, -2.048534008445593, -0.1683801336249425, -2.0894715231743604, -2.1057415939250665, -0.3460415106927099, -1.5809335389374635, -1.0086481000743392, -0.08717398700743485, -1.8676904048576026},
    {-1.9213022209700592, -1.7488672526298443, 0.6520696477302854, 0.6243748150955432, -1.1554650164480031, -1.2130239787523538, -2.0956522801323274, -2.1293661630144927, -1.7831967050096282, -1.730711526004247, -1.225160868837979, -1.9847856951067382, -2.1238469687856463, -1.95970167640391, -2.3141272475491523, -1.9029758194930684, 0.039437398562944724, -1.7464740157362577, -1.2433797772422093, -1.8289998317765197, -1.0991943555309975, -1.2334767072153139, -1.2770072559091568, -2.1929721020158515, -0.19534651976507844, -2.050116831182526, -2.199389388080091, -1.1007834270347185, -1.934085428210833, -1.0858185207648043, 0.1508784480525187, -2.1511033343069696},
    {-2.424567174126172, -1.6895855299069797, 0.4920816210273857, 0.9779503509197199, -1.296290392440374, -1.3091289105692279, -1.4924444312721115, -2.160817645785073, -2.1034074533249654, -1.3864882656566866, -1.3045831202908336, -2.0614468714118375, -2.279717972654293, -2.1507799162730477, -2.015717018779389, -2.1755545743685905, -0.4656290532034471, -1.8752372178072647, -0.7319918866344687, -1.8710313942476902, -1.7418657805744586, -1.586179415444148, -1.3602805529197646, -2.125970458320451, -0.29317110161429466, -2.2968691803657886, -2.524709673094448, -1.1128129150150474, -1.1358775488591484, -1.1682839576100026, 0.1260314263091155, -2.340927707394793},
    {-2.1245229455852717, -1.5337044036764416, 1.0848005165371901, 1.4674635702360952, -0.5262982647761036, -0.8672294743597492, -1.681864332836008, -1.6952005964417538, -1.9369922095560999, -1.1488315575256884, -1.0888772617389428, -1.8430767518684816, -1.9779046610467137, -2.3765834824340564, -2.148189767324687, -2.140466312365138, -0.36209013958736486, -1.985866661481976, 0.11793906863764676, -1.9902599355675532, -1.5402335237275027, -1.9852876205490821, -0.9056192076521908, -2.223873652702598, 0.7796672806106358, -2.2942825354908063, -2.031666850146907, -1.219704475665582, -1.330842328095715, -1.1039574039214668, 0.6129758817645397, -1.8780360814754546},
    {-2.3996400018839195, -1.8358067827211082, 0.6944365678078847, 0.6731083778493518, -1.0731708176334342, -1.2713043644057151, -1.2245924867272944, -2.0836781209462445, -2.198656684256374, -1.2918512621248712, -1.132128923040232, -1.4963081911068221, -2.1842340595528453, -2.177228436349192, -1.8378204565707474, -2.315039156304196, -0.628708242691137, -2.1700137057372806, 0.014060483771694363, -2.178579043176907, -1.8334501520026754, -1.8764823455014499, -1.647393848755873, -2.23832475721195, 0.4091637064345413, -2.3275450886736513, -2.0008590175071146, -1.24283995783309, -0.9955306534276834, -1.075009438482285, -0.04520910776553373, -2.08183664073232},
    {-1.6666062008192375, -1.4561774313020976, 0.5443049547486462, 0.6791514606404985, -1.17677016724733, -1.2704641874477731, -1.122901408747402, -1.8642055754452052, -1.7982061173931214, -0.754163823252191, -0.6894074588872955, -0.8652467829065905, -1.4431758207477836, -1.7249239664553033, -1.7143516916062689, -1.6862998917464436, -0.47650556028900554, -1.7273693597129804, 0.1866106810425915, -1.894068150081625, -1.1059929219917142, -1.3925979878295751, -1.785283694808741, -2.07690465546594, 0.16025360202127542, -1.959303105280111, -1.5118349174483845, -0.6665556280230521, -0.8191236268493695, -0.6725397108502325, -0.08476465837337563, -1.9250718394771629},
    {-2.5250212020801936, -1.3621621849779444, 0.8206145495822639, 1.2303058550121204, -0.766795279005548, -1.0084772856968336, -0.9853558167762545, -1.9887189821682594, -2.1455815862759753, -0.7201110303601099, -0.5078632489693058, -1.178603869988858, -1.743359774649774, -1.724482569483656, -1.9627386387677055, -1.8377100383127685, 0.07583578115492515, -1.7870809038392497, 0.8557228663933535, -2.1298300203163563, -1.4801031256961885, -1.7037161707590853, -1.4978527294685935, -1.7589140943684136, 0.6831958388525832, -2.2437387408766267, -1.7861909588099867, -0.9371365559087373, 0.03950674382472966, -0.576571761190239, 0.4134827474871051, -1.8790313928130256},
    {-1.9488281017461782, -1.1737434164371994, 0.6879986189414677, 1.0233253565046758, -1.5809454108261756, -1.5874045148176472, -0.4697221778036551, -1.6130859450609252, -1.673143047335771, -0.3279729837667285, -0.30685834087249664, -1.448076143627867, -1.788597751131094, -1.6122712638571066, -1.4743472516838427, -1.7336773224900948, -0.06566727479977318, -1.3537556600692566, 1.2700846781841224, -1.8472589159572685, -1.0384470468860436, -1.8281488062306592, -1.9426585654337925, -2.015193273543073, 0.3960453958649032, -2.4645110148459586, -1.5644481978151665, -1.0432747869056949, -0.037413423390352904, -0.242173711655581, 0.32471233135561656, -1.3179189610198876},
    {-2.1657173247200263, -1.5913237945376175, 0.539027716991826, 0.8920810943891226, -1.901496149480676, -1.8824442098958563, -1.3694602501186277, -2.2742151846120224, -2.244058702418621, -1.1279892679798897, -0.6131443014202104, -1.7784479367698054, -2.296126321414622, -1.9655440009250025, -2.067027991732873, -1.9758820690135963, -0.03919784056544005, -2.1114790385319053, -0.3645146636826655, -2.408507471509928, -1.4822294459011827, -1.6027193057602316, -1.9010558789642356, -2.42524883537202, 0.1379287216469229, -2.3508555602055683, -2.529901348657815, -1.1596712299720042, -0.4663473482827159, -0.5296054674509423, -0.5835088506790548, -1.9473940991278882},
    {-2.6003127021573627, -2.2678288838605365, 0.6287264460724984, 1.1275791318644175, -1.9696340364785898, -2.1794543185303077, -1.5610955249089116, -2.5444083272913356, -2.4908720788623624, -1.5286934693635914, -0.7235695383932779, -1.9178914613259492, -2.4658845249267842, -2.2905130524144224, -2.6375984926259175, -2.4685156946839193, -0.4021500982412734, -2.2786078843636286, 0.05617865546018782, -2.596874745095042, -1.7063045233758238, -1.8456901385689863, -2.313852748655522, -2.7514255977116373, -0.23323346627080213, -2.6819395788483935, -2.6869794878798547, -1.4755040395632562, -0.8881663494400155, -0.7508072739171202, -0.5514957447828804, -2.425429694334118},
    {-2.643524777810625, -2.1316013148562596, 1.6920663213364133, 2.3296884570875407, -1.1880489635048288, -2.0531692120428082, -0.15420623078468584, -2.3704369593778725, -2.536829818049397, -0.6753188149576416, -1.1823584375283274, -1.565377066568116, -2.3432976889364094, -2.5450387190033577, -2.0974925144468157, -2.314292947534063, -0.15471780440352378, -2.523630817662073, 1.7008649621996383, -2.985877275985345, -2.12687516079776, -2.4365851055560728, -2.193200058452925, -2.3565965614667856, 1.4623252492283005, -2.6921577597770865, -2.63210506391246, -1.8000651365518978, 0.279164190621152, -1.0160209924490922, 1.1102932406445292, -1.992418216420278},
    {-1.9082917059990177, -1.2527186131906922, 1.8453856913480664, 2.357962072495594, -1.5767442122844875, -2.1741606128425537, 0.7145846218706269, -1.6623620595754836, -1.4254352029925044, 0.48683595083968717, 0.10905736941245286, -0.6593145196079381, -1.6876286697664877, -1.6142894256950586, -1.4722446361320614, -1.3767555339888355, 0.149121728479602, -1.4214518070299245, 2.556837606917044, -2.239320715366941, -1.2896832537454055, -1.7446522707057515, -2.574163327325488, -1.8502150650455556, 1.406058979684851, -2.138014727674273, -1.578524500366182, -1.1173352926658928, 1.2122391023497106, 0.4633580302708383, 0.6200054111896192, -1.1223346488706614},
    {-2.3697147169150754, -1.7799749521939479, 1.2238460480520672, 1.6221506892849442, -1.7964160396547808, -2.5582867220330066, -0.46060522419167643, -2.098676926589693, -2.2824675580996665, -0.22781664298198973, -0.554818372655785, -1.3390576712919833, -1.931303223121424, -2.3528027962553857, -2.302350543914739, -1.9965735566535097, 0.1419659883030005, -1.7065622136587493, 1.9090380172909378, -2.5511952232970234, -1.6990444257659547, -1.9023719522171418, -2.669506360990052, -2.556645017231841, 0.7736312092455191, -2.4774981539279413, -2.360220316136382, -1.2114965077428037, 0.29953399667569985, -0.047292142286834045, 0.14889718776081345, -1.6921664182421494},
    {-2.642919320727834, -2.3533443734232478, 0.8900250751593631, 1.1509710546438106, -2.0917574876023513, -1.6883381985562596, -1.043996990931152, -2.1977883009775083, -2.8061644054571224, -1.241886505911901, -1.3067789841372615, -2.0112947089739928, -2.6053189361813183, -2.3915707408050224, -2.7072669161283804, -2.3819368806482877, -0.2414287608398783, -2.336386155151971, 0.7143076902394339, -2.878458361251148, -2.133519366031058, -2.35889980913307, -2.204810743377767, -2.6626643829567294, 0.5163502951255591, -2.9533033062639014, -2.5852034778849284, -1.5444460326205598, -0.6715287056818512, -0.7191505451333161, 0.13261396155341973, -2.1742769617532227},
    {-2.570760549388169, -2.0525920924763557, 0.9829418067366199, 1.7435297977548871, -2.6068166080511435, -2.9246251190845607, -0.28116645998875367, -2.1504041103061557, -2.4091275790895432, -0.34371072722804574, -0.28197928800428484, -1.0950768278944507, -2.1027254694779756, -1.7658616064035964, -2.0248156584799806, -2.1212390956074683, -0.1113648881403115, -1.6531129104153919, 2.153248338567099, -2.59077615108778, -1.817172970544781, -2.057809583714973, -3.258569356732653, -2.3210519936887954, 0.517401390667036, -2.5195430249192894, -2.2371557239607722, -1.687530430224019, 0.7221754081688564, 0.07034500600452387, 0.022060136921576212, -1.4643556486216056},
    {-3.0335233643248776, -2.0710047085254057, 1.3354760545503777, 1.8079287293452604, -2.453516681274622, -2.8801014361495123, -1.022775566618115, -2.477985037189757, -2.4130294117630586, -0.9011608055358206, -0.5533826389373159, -1.783088925752062, -2.5254878284283557, -2.601718680872429, -2.4491725098338524, -2.8283870394499098, -0.4768672012234427, -2.427648004811942, 1.5017239127289104, -2.5335648261704775, -1.532730313577648, -2.156758449942439, -2.8590295986560044, -2.623722330255613, 0.9918288076471936, -2.7414476869529683, -2.336131205091406, -1.8128013277721275, -0.22503310796974577, -0.41323133653143895, -0.015315352140160938, -2.1927194935392715},
    {-3.170305144965743, -2.3618909200698073, 1.1993451224898206, 1.7435562785837326, -2.217762819422477, -2.655346930631933, -1.310541540895504, -2.4220968114625037, -2.546082643752603, -0.8087365014646997, -0.6494334961778558, -2.102833362979483, -2.67079882215015, -2.660083787025418, -3.0445387284301972, -2.7084044015194073, -0.6122634733618334, -2.514502806747256, 1.5166467787222626, -2.948861980616047, -1.866715184758509, -2.0715883730186464, -3.123170663088988, -2.858370058624506, 0.5995879276003481, -3.0424725880828345, -3.077594147241643, -1.5925844879007436, -0.24656390446869103, -0.7135311128914681, 0.21230226006479547, -2.123344070641869},
    {-2.6992465396756002, -2.1506140674497187, 1.3898240499047552, 1.5682752853311646, -2.166712299666901, -2.6868973085954395, -0.6998882305691497, -2.37159309715458, -2.3451884344196388, -0.32491612438075995, -0.45143223478689104, -1.7971212086175756, -2.710667948043629, -2.168411388303073, -2.3562699295738154, -2.4241674368651025, -0.689692269728308, -2.176748082350233, 1.933248540124685, -2.888066447174788, -2.144469561165793, -2.379517759136693, -2.981492852791701, -2.4642625027210396, 0.9222913589519518, -2.7588984893659965, -2.4169802138320096, -1.4927051996187393, 0.4246118278836851, -0.38109310856587114, 0.449785542418846, -1.8749463845805292},
    {-2.7757498501905995, -2.100316337856382, 1.1577278515280949, 2.1622378119294945, -2.16994384311553, -2.8439255151481047, -0.7646598007512038, -2.338126143974236, -2.2884467827006207, -0.47256681465707295, -0.6664209627203366, -1.563529684842865, -2.5077855609613895, -2.3424230856342816, -2.6670151466846974, -2.630012652003579, -0.23837288327106926, -2.3193042316725667, 1.7842132279366696, -2.6695451439868103, -1.9086769066998976, -2.251517934643548, -3.3133040457811997, -2.626901565481415, 0.14824864540494462, -2.515127507484542, -2.5154026828345057, -1.8967491120196, 0.037384882603400824, -0.2575660425852331, -0.10938789181722691, -2.078001813788937}
};

static const float b1[32] = {4.425932842426494, 4.2077310972170086, 4.416784789890041, 4.802462287749387, 4.814675951928241, 4.763371598158965, 4.477006185490149, 4.361583073892368, 4.4506717793262816, 4.363688387188627, 4.333384321827533, 4.506190468227184, 4.453144512941624, 4.380915202946713, 4.429078057849479, 4.394664065891791, 4.3949936508470815, 4.31238433135256, 4.516247494535172, 4.447759445684766, 4.280513393699014, 4.308281034493924, 4.827872547131395, 4.631011949888907, 4.81859786369939, 4.351760361672213, 4.344046931562376, 4.394554216265914, 4.569100827710921, 3.913392148310382, 4.922960265198818, 4.371413882843637};

static const float w2[32][16] = {
    {3.4203458862719556, 3.5225285101755053, 3.0662513583742443, 3.8014380798382605, 3.7638124765222285, 3.6366967111962643, 3.308092838629822, 4.074632182592551, 3.9001139867758483, 2.885216634193515, 3.2674358953746263, 3.7269099395434098, 3.2091820274739433, 2.1009269442845584, 3.54160741736659, 3.6667353866975496},
    {3.687964717111744, 3.5514075432763934, 3.820219190580771, 3.999890155579794, 3.6050340762407327, 3.385379222431431, 3.649662574102173, 3.665008701576334, 3.4970870911974123, 3.2856808575726806, 3.7969576502690257, 3.7429286301458715, 3.6984351850914368, 1.8852835643888193, 3.7973283888632623, 3.5692790940757635},
    {3.7345869237077913, 3.976522412345558, 3.5385680914034476, 4.0298927927589725, 4.05814949453542, 3.434778433449876, 3.4728436536136105, 3.676810802651846, 4.015146003078763, 3.887393292981102, 3.0158416246181945, 3.4160313107764915, 4.317368338282767, 2.2703998008770854, 3.5155876192222566, 3.895347119011222},
    {3.4481753380184696, 3.337860694126128, 3.7756175446166735, 3.6652495993089866, 4.109969656098086, 3.7274344021735284, 3.996821800689088, 3.4814405576838707, 3.5052640249060274, 3.4853194716469704, 3.842926498805379, 4.2655366514715745, 3.9089147599058833, 1.8481837396175882, 3.9375511096703195, 4.0863095226636545},
    {4.341221988757141, 4.027678819576218, 3.9889283324966702, 4.094410183329308, 4.460066586503696, 4.181235254246465, 4.56446791070813, 4.56543356384296, 4.567599621668904, 3.893910269310003, 3.736818005773388, 4.079729740302635, 4.05856746446565, 2.616417136376359, 4.019824226176828, 4.126664728367688},
    {4.358504559283533, 4.115748017727504, 4.3085029076877825, 4.286367524664971, 4.3565555941410485, 4.25750032094685, 4.2849046323585736, 4.076729822565384, 4.375866820819017, 4.257289929624726, 3.9534981640357656, 3.685194201922433, 4.5524725512637065, 2.616973919605736, 3.9790706753086433, 3.7979250978891446},
    {3.4416219692019063, 3.5680576049899826, 3.5493971805867504, 3.755943054003917, 3.893995736158454, 3.766596751401766, 3.4420547931341168, 3.4730473264274293, 3.5358401263105654, 3.2554020680316995, 3.1598568666553244, 4.162813612551959, 3.744978275609523, 2.5004277296145205, 4.063861735716101, 3.851491764379729},
    {4.2539658036515, 3.477365741316144, 3.858485995505762, 3.261016123960996, 3.3351744419326947, 3.517395564815447, 3.758697908049851, 3.6444092705951707, 3.4617531827957038, 3.21277700194276, 2.926525574808821, 3.5174820410309913, 3.8303940675816053, 2.1096015559910515, 3.661676112036641, 4.117805976568307},
    {3.6598553610132485, 3.572867388657393, 3.4658085910582965, 3.697754541487135, 3.1908803869027462, 3.5573916861562815, 3.4382898432162006, 3.7619210741123794, 3.4957755841812777, 3.059678237310802, 3.74463939991343, 3.6320144708241378, 3.5790690889339634, 1.986315959395004, 4.121256113334267, 3.048130550195384},
    {3.170522295907906, 3.5084257414412283, 3.868295466213489, 3.46502632322827, 3.6332240395847153, 3.3447561200374465, 3.6772531469942, 3.534262068622966, 4.004683700016822, 2.7816688045217304, 3.3895277859808557, 3.971804561316696, 3.447844868189329, 1.7819194013481066, 3.3857970121517145, 3.6163968515102147},
    {3.618974921111444, 3.490011824455516, 3.7177368976092056, 3.259246487585713, 3.647838189878464, 3.752212752883419, 3.6912412656013975, 3.465529868089373, 3.864842983087971, 3.2228709391424686, 3.4698230943149984, 3.370310149315407, 4.190122276891107, 2.4047612245859296, 3.8059723653017405, 3.7096259420190973},
    {3.720432808390928, 3.9364215340693836, 3.498682318696656, 3.77455258234273, 3.502189041253711, 3.7286536966503965, 3.7268452815884467, 3.6926931616522856, 4.106309432006987, 3.4013855681060337, 3.6331106227914085, 3.6500519962443594, 3.84017638423709, 2.317068620162177, 4.123357803711168, 4.101906109796222},
    {3.371243393293449, 3.855340821535114, 3.8075570776222043, 3.534784976561842, 3.449947211298997, 3.716649520099709, 3.801528365638991, 3.6036171865950313, 3.907662260981421, 3.16723287719, 3.4476487725105276, 3.746698706603769, 3.4151916258682076, 1.9722461160971334, 3.6883629011424306, 4.197657888003963},
    {3.861593761911018, 3.626213929805906, 3.83417266794577, 3.7105926046558246, 3.605655414117972, 3.488359663795589, 4.06685021170348, 3.6918775744586596, 3.9921642101509685, 3.6963860007108984, 3.454011249653997, 3.419524442680369, 3.172371745949211, 1.621595913161361, 4.16878168366198, 3.6420313838316947},
    {3.3492145745256563, 3.2879423245306283, 3.4301826220824205, 3.667071504325773, 3.925919022218591, 3.441369030575004, 3.870412669971726, 3.731314132899486, 3.679869358212076, 3.295487904572593, 3.3676666714805257, 3.6876735063838257, 3.6343122754424995, 1.8578598802232473, 3.668320653976772, 3.3494236799417583},
    {3.719811185759496, 3.764908883125317, 3.57464308955216, 3.385893456757435, 3.663100494506323, 3.4042366023710064, 3.6575672238875905, 3.9638182823308807, 3.222362290631895, 3.5202296942212405, 3.218799678370687, 3.5997656863781216, 3.350509017322971, 2.166523220843686, 3.297582586769157, 3.433268626091811},
    {3.773660356247754, 3.695245155868649, 3.569921179257264, 3.3530571785053978, 3.6153936120639445, 3.7422216111292843, 3.6959736445942957, 3.6230448168898994, 3.943224358396929, 3.1348086698919095, 3.622077076100574, 3.471460038150451, 3.896554610337437, 2.1561234478747164, 3.603701464689501, 3.867082450101477},
    {3.602128677347043, 3.713636213493719, 3.328555334230487, 3.4470416169623426, 3.3997675605078244, 3.386880319812041, 3.8018667745681465, 3.677544793399342, 3.538175601644545, 3.0526745970215554, 3.530506961775454, 3.7162673609697627, 3.6315449882675743, 2.3492789433524512, 3.8644496626732154, 3.1553724670222882},
    {3.8607620767179007, 4.026217215386976, 3.8334333177764193, 3.897571899357263, 4.199167406946188, 3.8912325608943874, 4.12074600025316, 4.125864326269117, 4.053388755212358, 3.1613854515152706, 3.6596516136796997, 4.106433785811001, 3.997272118470872, 2.611603633947872, 4.028980606701499, 3.7377755683323657},
    {3.7337544798401416, 3.6959225687688115, 3.305810109030825, 3.822454740894304, 3.8325763883295463, 3.6652483459152334, 3.517784687821999, 3.7026448876530416, 3.6315349390150207, 3.4042239746902645, 3.3286300921986807, 3.9527085181146453, 3.4910336998084976, 2.3173283582762245, 3.4399775592280943, 3.62903477879307},
    {3.716767510718644, 3.434772400535371, 3.9313486491385627, 4.121628829329784, 3.4635315826553477, 3.548068978371454, 3.1933188384888913, 3.9267461248057653, 3.8195388297309507, 3.485749771759887, 3.5211768151523284, 4.095528899430851, 3.9619397518671056, 2.3788284556529233, 3.838493477873347, 3.7042129883175474},
    {3.787966413412559, 3.81762055527453, 3.81404088664978, 3.6923557197871584, 3.866880024559612, 3.5532762861694076, 4.2903867602314305, 3.515395649893, 3.764385005353535, 3.239968789255118, 3.645092156615981, 3.4165656353350298, 3.8686723255918083, 2.528655214187712, 4.042106740091645, 3.9288748486067053},
    {4.7144166181904765, 4.109218169371935, 4.572246463770693, 4.360483676530584, 4.137943395999155, 4.340462742205965, 4.17063810478695, 4.409864836826941, 4.155016297160378, 4.218638143302954, 3.6663168400011417, 3.857332228459047, 4.447467019076963, 2.309038196342037, 4.143434272186478, 4.21591990729712},
    {3.6573854074434826, 4.21025262990825, 4.154909920782363, 4.453377949874905, 3.606616585226841, 4.192030458861354, 4.129776321371162, 3.707844535664675, 4.563793266158839, 3.4668817861904975, 3.998888414312904, 3.737540271063913, 3.975577037036602, 2.5174193719648934, 4.174567421148534, 4.018047287190767},
    {4.043093756054172, 3.850720512235275, 4.55280618940363, 3.874394463033582, 4.213781872753535, 3.961297608792417, 3.8316653038593675, 4.0434133629620765, 4.052844634519019, 3.5191766619084843, 4.276570726359423, 4.228930165683729, 4.191323209666384, 2.18581148513894, 4.011385361919263, 3.7061171232016417},
    {3.904869327385936, 3.700194194284322, 3.7499463440142184, 4.039150866636835, 3.6813550035896307, 3.4800044532119916, 4.253686914322218, 4.075696607378389, 3.4278457491395184, 3.271793179226271, 3.515242469375822, 4.0512456382653115, 3.7283074524911637, 2.3639765688907577, 3.81904045017259, 3.5179895371181216},
    {3.4675350911971594, 3.5110356878369546, 3.2683057006469127, 4.0434506946441715, 3.1576433799767067, 3.886009094638852, 4.12543021407774, 3.5695293143052345, 3.935177539340678, 3.202519066204927, 3.30612288328308, 3.9173769149242417, 3.7660612877392317, 2.236045261685342, 3.7311403598101602, 3.571989838741236},
    {3.4795009931154284, 3.936163670521558, 3.640545449888418, 3.775865150992378, 3.7805823568534636, 4.205734365878999, 4.027250574131499, 3.9566738420996654, 3.9353374854073015, 2.864488743351174, 2.9327354706616604, 3.2740451337929404, 3.657612683936139, 2.0866175469107304, 3.588419092453639, 3.4228996763891275},
    {4.1484458378552365, 3.8455011789809115, 3.412030434503408, 3.50921949050489, 3.7707865786759953, 3.7543299741179488, 3.9630219996345812, 3.770961515388563, 4.060686809453417, 2.900400750242494, 3.8422574324718606, 3.7560281356332417, 3.897179081938394, 1.969088490591018, 3.77781071818297, 3.5932220467636244},
    {3.6358174841339097, 3.3647405172841283, 3.5798393485546307, 3.756028331527117, 3.925620631923555, 3.5237020670711905, 2.969494066645649, 3.9318228956783807, 3.834015159643403, 3.175146839010304, 3.242046897210869, 3.348302120348154, 3.5289233678625735, 2.550839158839425, 3.621127774491772, 3.6840817606316407},
    {4.130963769763863, 3.950555265992312, 3.894893152400718, 4.115078359304286, 3.918828109038178, 4.2922188869337345, 4.402688487302245, 3.665227617386266, 4.243469559353537, 3.486029679894207, 3.6757618788481867, 4.111585225180752, 4.104358569462862, 1.8874107139983254, 4.3221003300310965, 3.8784562579452286},
    {3.5002101547025917, 3.240740791877968, 3.2871172145555523, 3.8095178817597604, 3.904286428004755, 3.5654510317343937, 3.3650138718334, 3.8528560119964617, 3.7339460284407173, 3.155981925513936, 3.4706590869839964, 3.675580968211597, 3.2230026985690916, 2.208660489760132, 3.664440220073457, 3.399776416132496}
};

static const float b2[16] = {3.7708013622520054, 3.696275011371967, 3.4878004782137357, 3.8457995730032923, 3.5991056220242714, 3.369915240252388, 3.7286427330694005, 3.590922028359016, 3.8673127950374044, 3.741129133715433, 3.7905665651997085, 3.710687119984376, 3.656625503911384, 3.003564060956076, 3.8253055385681294, 3.8173903911853113};

static const float w3[16][12] = {
    {-2.9620966423752426, -2.332991191292476, -2.7407831473522952, -3.1325615592248637, -3.0633112185011844, -3.1971842562850727, -2.682088210887143, -3.02925874367599, -3.596417317815534, -2.726869988012715, -2.711848274617775, -2.523330635851127},
    {-2.3672841284471082, -3.3693822797602873, -3.0776735294581954, -2.9673297805740773, -2.667368968666537, -1.7959513089539187, -2.9453628488363424, -3.101333412895983, -3.424832301877097, -2.872144370148199, -3.38206383937677, -3.3214499374562236},
    {-2.0142554324901405, -2.752252978911987, -3.2674706245918888, -2.4950975653361045, -3.245594013300779, -3.2493107500321883, -2.526456371920777, -2.666564816739297, -2.420488170475478, -3.6172555597779237, -2.704242395881553, -3.706465574490841},
    {-3.4901864439150376, -3.189248666434696, -2.5403305718308675, -3.0969834498712907, -3.004497472349257, -2.62804099728154, -3.0645852874623425, -2.609299222173793, -2.690562295679774, -2.962931605712282, -2.852585536449178, -3.3428817538471516},
    {-2.548780168303776, -2.6163374372416657, -2.8458042589537733, -2.591872932675679, -2.8925156433129167, -3.5793903747773212, -3.2995880254417327, -2.7128575205885155, -2.704144485574415, -2.6897831854071046, -2.345478095781653, -3.021820712843799},
    {-2.791258876800608, -2.55819913693927, -3.3323520048983304, -3.1992830066659286, -3.2860675432060997, -3.251393644228425, -2.555012488580856, -2.929068670302574, -2.955694570531542, -2.9328656552278396, -3.738838143427828, -2.6481987265417475},
    {-2.6901151277851763, -3.063846292287025, -2.9767449736051272, -2.6413436106399146, -3.1578743459704675, -3.0284176148643485, -3.0170388104950288, -2.588336016730101, -2.734674174467673, -2.630360861960079, -3.0530276449252836, -2.8498481108967506},
    {-2.3727191256236457, -2.935378883791092, -2.295364036352661, -2.8181445658798583, -2.9186478541939236, -3.590817847745059, -2.9743824448951006, -2.8214277579479528, -2.8551794742057095, -2.737281877757329, -2.4873294183875134, -3.1282795945679025},
    {-3.163997940490282, -3.1879706404028756, -2.861845056861909, -3.2387860202428174, -2.8550052837719178, -2.985951680709905, -2.7080777723412957, -3.077665435067988, -2.9996315229366237, -2.6148884617726713, -2.4498170650240945, -2.9624832137140924},
    {-2.556618259588728, -2.737649370193261, -3.224446994866878, -2.493470929954655, -2.072159207563657, -2.8154705211018443, -2.6269420609339913, -2.152633386337773, -3.26468267179726, -2.815678971281181, -3.1610988500435457, -2.1979048285773826},
    {-3.0177179804954357, -2.2341043629231643, -2.521258669690091, -2.645855505100461, -2.336269772771641, -2.982909038080517, -3.016851043733389, -3.3581272089979244, -2.141884535685807, -2.6618308622422964, -2.758577782903719, -2.513254772755475},
    {-2.7839423520602127, -3.2723597984305273, -3.0238055728227766, -2.814987296046368, -3.162330887143005, -2.3736489830781307, -2.3634169011739017, -3.066052165405351, -2.7471590863315996, -3.2410140154363245, -3.0097477797543695, -2.879083366187788},
    {-3.396930760309837, -2.6432360522557827, -2.85365072630308, -3.085472725821383, -1.9225106625596047, -2.857518173744585, -2.7413361882356946, -2.7606196129274356, -2.9899985079438802, -3.166531431466725, -3.159686781680145, -2.8355153219805405},
    {-2.293567982708554, -1.8864943038755577, -2.161011766767339, -1.7933799913677615, -2.055089603364998, -1.4219198557736785, -1.956600253717359, -1.4918687750287944, -1.918523891620043, -1.3535569889233272, -1.2679136609043293, -1.3563626347185653},
    {-2.834196227078427, -3.1895206310579036, -2.203426396475221, -2.825386152744737, -2.990138980469867, -2.459897288547447, -3.0812094264071046, -3.4164253373850246, -3.0602782452503554, -2.6318075121846327, -2.612832666101809, -3.010374844692874},
    {-3.647908251372716, -2.5900824758538943, -3.0264728576909845, -2.862168070885116, -3.2182282932459656, -2.3452389427179847, -3.280566884675526, -2.9605719694433925, -2.336623727069051, -2.936488806129634, -2.899030259081643, -2.1988159167485493}
};

static const float b3[12] = {-1.1005765417638105, -1.4535956076793095, -1.3500124480481905, -1.8021492388830955, -1.6233487431199052, -1.1250004239165707, -1.2347351553197896, -1.0766419693324725, -1.0345896833404746, -1.2568451975296644, -1.3627231506015796, -1.862975185429875};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
