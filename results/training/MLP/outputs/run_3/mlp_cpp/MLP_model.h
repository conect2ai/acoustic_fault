#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.642392020294346, -2.8741001794370455, -4.600279525110856, 0.7809509491745324, 0.999789994489913, -0.48297770275293167, 0.0400829019640531, -1.425500680531444, -2.653266785525569, -2.6360264250574157, -0.13272199136416366, -4.78929268447065, -1.0731401882041363, -0.7262354766674664, -5.261142993927395, 0.7460301256161762},
    {2.1996045482124886, -0.7758228703446275, 1.2868453139424592, -0.3617099593710295, 0.2073221433933123, 0.2307665541085752, -1.0871108750659524, 0.9610361708678999, 2.6037139432051237, 1.144449579904038, 0.5519500212953159, 4.799380600482973, 3.5032272148091037, -1.0639734653748532, 0.33639736138039394, 0.6206685079150009},
    {-1.5634226750663687, 1.6053259262017516, 1.5295859615314056, 0.7503972880475951, -0.9345536886268643, 4.449844149500592, -1.3573114905716652, 5.656515091637147, 5.340036888261187, -1.593962542960199, 1.6332844859388909, 2.224270948586125, 1.3235538018503832, 1.257033598298879, 2.9555749519849166, 0.2668444304966767},
    {-3.4696664419599537, 3.658141616327344, 1.5488642819291676, 3.1388060294787232, 0.8890687493028033, 3.236980859755427, 2.5352700959819474, 4.738833175759797, 0.11551081407208903, 0.7540610482579249, 2.2959982650793194, 2.6889831155806334, 2.0019019393604656, -0.05436150333937405, 3.1829920157833445, -0.2686272224984485},
    {0.7055573192448701, 2.7165670801634194, 2.0470224982229492, 1.9943141203773644, -0.9942141498048839, 2.827846704346529, 0.7880354556921789, 3.877532010083022, 1.125691915053902, 0.8457139868872517, 3.06599781676211, 0.08591369344141725, 1.8227966360554515, 1.5153159468173931, 6.152666856272172, -1.2317239887310492},
    {1.3275652077157398, 3.81086584384019, 2.3090437890649413, 5.3040572288424634, -0.8653463918084017, 3.591640554244482, 4.339817929115259, 3.4701102680459, 5.377461439794365, 0.6667016887781991, 3.7393825761294592, 3.5705446834366845, 4.327371629390569, 1.6372776984878838, 5.421044603831089, 1.3210373799625348},
    {1.4933857221402334, 2.8050698515893076, 3.131969300425724, 0.2765076065627054, 0.4525079159342922, 2.2548232624949116, 3.3435407127822314, 3.545125723743857, 3.8107242017426106, -0.4707722261966403, 2.281720042629055, 5.481554154232956, 1.914865637718188, 2.1556489505885046, 5.404718848071167, 0.42740303273680474},
    {0.1534569843001279, 2.453340494569558, 3.2060240140167147, 1.5276392630832105, 1.7967041388492284, 1.5596093794179835, 0.32725479078429326, 1.6807257967205664, 1.1140250551168966, -0.927212690626528, 2.1167765315140534, 0.4850318049930638, 1.9419740286633886, 0.9420953996288095, 2.9482883793270305, 2.3233826511190347},
    {-0.6459372051570668, 0.7592075231966311, 2.1235162294396677, -1.0534446988627397, -0.7637978813555545, 0.8726049606032346, -0.8622053087497851, 1.8240673680275035, 2.892433434042878, 0.5711917382051808, 0.8883477415359515, 3.034459773225168, -0.12788009558700655, 0.043824156158026734, 1.1100853629340626, 2.6127019955257187},
    {0.925401183071886, -0.17889255898758977, -1.8129106847298717, -1.0383890552425041, -0.1959547314174682, -1.2683680714255396, 0.5834631990851982, -2.2543456922049963, -0.4141052886747056, 1.54542824256353, -3.108457745833194, 2.4797081055079406, 0.14085321448546437, -0.9872055108856135, -2.716968849650449, 3.1577128719629988},
    {2.1425265568266902, 0.7493752811450564, -3.8676182907307015, -0.8044274038892127, -0.1270150182537032, -1.2744077692495202, 0.39380629211032053, -2.079349226038782, -3.0135242772789903, -1.0828301181449502, -2.4431668672830282, 2.5125402946370285, -1.0333320997377156, 0.5482966474755036, -2.334110410743596, -1.2870517856969494},
    {-0.4077825125590411, 1.8179023780198786, -0.6638749963941891, -2.5579785274975664, -0.08073881384164903, -0.6454404923586653, -2.686433959043076, 0.586568217248763, -1.6676046905188966, 1.9515900077855661, 1.6631980103048365, 1.6422157920726879, -1.0594853179158619, 0.4382772538747474, -3.163990835732242, -0.29352929894004215},
    {0.7834234936910347, -2.10567865893427, 1.9122988171472817, -0.3904790769495261, -2.6022206326509996, -1.6127401259468328, -0.5840413512945068, 0.9445809995948534, -0.4265529629206328, -2.249562584532076, 0.1134205439771867, -0.13667148986736624, -0.6913086342007854, -0.22301165858314648, -0.8990588493953976, 2.4143325504495428},
    {2.296149862405373, 2.5421992142057106, 0.09671250849059697, 1.3291391322749886, 2.6491199839729287, -1.6955550033633546, 2.557137893660026, -0.9422075415940367, 1.7558628944830021, 3.1486941071979313, -0.7404421562343693, 3.944828657634381, 0.5364919392228272, 1.6195929719786064, 1.671499377137309, 3.287781023355635},
    {-3.319401571470911, -0.7471267246727605, 0.6737785682122149, 1.2520863297030258, 3.475899634910792, -1.7465040944141332, 4.039181246527612, -0.3049721323667585, -0.9951044797745155, -0.4181571915139613, 3.6358194019154193, 0.28470080015804394, -0.6794262832924667, 2.383957806724857, 4.049120728276144, -1.456878434230908},
    {-1.0202843124932384, -1.48652812797784, 1.427147750954078, 1.4866309504690096, 2.239173798406268, -2.3972509194815315, 2.7155593706935144, 0.2500671256490406, 1.4441882423553671, -0.8111787357887638, 0.6970691214822852, 1.4891647329334239, 1.0872830688388493, 3.6681930142480073, 1.723482859389477, 1.9497648285796791},
    {-0.4695208534926635, 3.9317935714380523, 2.833853055415518, 1.179404933852537, 2.2325262918030386, -1.549595443397901, 5.332672250755153, -2.6546286331889584, -1.5014268290073964, 2.664294140793697, 2.464164913022587, 4.532419461171165, 0.4073972622997912, 0.8623828936865836, 3.537843775664879, -1.0783252729824946},
    {0.8374460341294079, 0.9622244946510103, 0.2116777058160931, 2.861005137102142, 1.878737290927608, 0.019534828591647586, 2.4887237999318366, -0.07544640211659832, 0.13435173907951997, 3.2939906467529565, 1.1753376748339253, 3.5718256477924224, 1.6290801881589994, 1.404625195777562, 2.1681865026858937, 0.11784649706404964},
    {-1.5991480025300766, -0.1772677083989511, -0.2987739995684458, 0.862079881328325, 3.341759070699422, -0.7981769345209334, 1.073259803052482, 1.5274784617687607, 0.3224290850383877, -0.5297746293983345, 3.3077090755518896, 1.3486438434394799, -1.604248825267455, 0.5593589739619595, 1.2647224347200783, -1.6691804061343163},
    {-0.39101253523018664, 0.4319311526472386, -1.6903961537382646, -1.1349369039930723, 1.2277666371379112, -1.5191822128007972, 4.3729791776891, -1.187211443802718, -2.1217348935058116, 1.7004601430314081, -0.4181627155380564, 1.6339659053590319, -2.0426034169088503, -1.5123425542232432, 0.49207129227139296, -0.1818537418356225},
    {-0.9105982007688311, -1.5119220096297352, -2.2254759044470056, 0.7802165439939396, 0.5710535784608696, -0.19659115657211165, -0.435593572845461, -0.893295464204691, -3.169865567039173, 0.08214813880731975, 0.023656252728160788, 1.5510453968412088, -2.45242859291635, -1.2218141343509112, -0.9751382239051697, -3.1646793033714884},
    {0.6728733528389993, 0.15378475362594235, -0.8454076837962627, -0.5277617750104432, 1.8912435793654248, -2.1377942876054528, 0.782462923871651, -2.247308296151596, -2.5751152277728284, 1.3068563433435652, -2.5920119490652014, 0.32337002713748525, -2.0213306800401267, -0.3490439451007981, 0.3150540414312451, -0.45538590030415077},
    {-0.38425397815769313, -0.08876108270927045, -1.846097631074379, -2.081674518715808, 1.3195620880398895, -0.6408134667746752, -1.492704826038203, -0.75582640827203, -3.636352806950032, 1.465925311304726, -3.6040985017124596, 1.3450589211770319, -2.577787028107356, -3.296356860967732, -2.3177135306822945, -1.923201585134266},
    {1.1698747325801073, 1.2472899182157002, -1.4800042918821008, -1.1089131209917673, 2.1119894767942404, -0.4117222088881977, -0.10323706579632239, -1.8545499657582645, -2.4032779685267216, 3.861626382137627, -4.137875659120672, 0.99823838751298, -1.1497455028894907, -2.2075863249348813, -2.5290360768760576, -1.6131801220796995},
    {3.7166449503686283, -0.33592922408580267, -0.6462480019647161, -2.3775602941429517, 0.9282570456625284, -0.4964093807493572, 0.3516235154718481, 1.0484221702252108, -1.0282489689072196, 2.902925228052349, -4.34537978659953, 1.6712160774650107, 0.5449170340341825, -2.236033235685254, -2.692520179008506, -1.5685491035531236},
    {0.4277894315547835, 0.16472275958115484, -2.5548963677724035, -1.9834052431815803, -0.3709349459858991, 0.8904658539625652, -3.5392729203859963, 1.5384408600024886, -2.2995449289944223, 0.7731597691568898, -4.762743219755108, -0.15705552203491904, -0.3703695252541184, -3.8507373865162586, -6.193481726121545, -1.7802076224794372},
    {-0.20056312447761226, -0.6417264971873486, -2.6321060356661032, -4.236561024339345, 0.3307203828445444, -1.3208668305167015, -2.2040226524087068, -3.6012622945861437, -7.068076517698841, 0.5641705381248217, -3.3825152795060656, -0.931115332342864, -4.85300820571805, -3.1508696494233086, -5.529930212730746, -4.675731247607456},
    {1.624205393935433, -1.2383452296500903, 1.042239661374514, -2.599230512707629, -1.8295078803145812, -0.4836473608309901, -2.6610497769444272, 1.4302364850701526, 0.6928549734474524, 0.7452960784173644, -1.8072510136503146, -0.5133299925123099, -0.6882540229346749, -4.7247915113797765, -4.225710673729149, -1.689783235068453},
    {1.4773223733067136, 1.31354407277029, -2.007245540093766, -0.12360330770493337, 0.0409149046678298, 2.1214241750126464, 0.42231201391995826, -1.3431182630846745, -1.8971625212650487, 5.302449472768963, -4.126123044527741, 2.8804348507194004, -1.9980072273638765, -2.141177368637501, -1.2326540997981699, -2.6969539848600688},
    {-1.6236349780312105, 0.5429211103341486, -2.76809872027014, -2.351418329521155, 2.081990926143641, -3.1355208679936863, 1.4983542561262189, 0.4165177750479653, -2.33378487636893, 2.720457755589793, -0.8829422763295963, 0.1694095457236194, -2.3247717138966455, -2.716139325888938, 3.020933861977213, -3.180853388908115},
    {0.30896738052122025, -0.17352431716608716, -3.2509949693678095, -0.38312723836254264, -0.17236345640487177, -3.095763847993963, -1.0728265468187521, -4.0000044441400755, -2.4040102131320866, -0.33869806265176655, -1.06665292631937, -2.2810357779065007, -2.5932100934139646, 1.5521862851105803, -5.810944930613114, -0.016487384228524422},
    {-0.20122749888260003, 0.8102199216221182, -4.316998042274507, 1.0023915676004647, 0.8429888869403716, -4.844329539739984, -0.015243410905127954, -1.7341145910021638, -1.1732168168800423, -1.7484766194176566, -0.05346841966082695, 0.41274566292382103, -3.1031700655308505, 1.239158164103478, -2.8539884621998484, -0.6802682614939967},
    {-0.08318175337941186, 0.1380321236343769, 0.22657082218305, 1.7213987199124343, 0.6205831940548825, 2.633282485018796, 0.31294191105642993, -0.937707522430245, 0.15322266891638545, -0.6232853938831246, -1.6321315337943254, -0.33912149819415793, -0.807433324633097, -0.49051822139520584, 0.419176161983426, 2.4833629076672867},
    {-0.6255532230940578, 1.753182742114575, 1.2459489514016109, 2.368767315203592, -0.5583081094858129, -1.4162190288628058, -1.9603148393294592, -1.8856164812769884, -0.11047829331252856, 0.3585023838971657, 0.1319491891172911, -0.6443272006088276, 0.9793295492964618, 3.025435494145393, -3.0760278693851695, 0.6966231701004595},
    {-0.2198276238119724, 1.3858951186299384, -0.31887220495436375, 1.9040066942850182, -0.7601890746958825, 0.5556847755577823, 1.4037501304387179, 0.3012314884830231, 1.26579970131081, -0.12762866851923665, 1.9828186580998828, -1.3671893583400012, -2.3320177416072365, -0.279977644300353, -2.348990797049703, -0.8464676092318273},
    {0.4280931499649135, 1.7990249913898475, -0.9608405775043556, -0.08237828615714785, 2.103384913365282, 0.7619629227346756, -0.2425113641015106, 1.239398501039765, -1.942259688469755, 1.9698819305350417, -0.24580536732847788, -0.7360198676600058, -2.064833629290549, 1.8304454796413692, -2.9318064072168157, 0.03898774736990715},
    {0.01109168997238037, -0.33034778085710376, 0.2204722403712557, 1.192168853576038, 2.705627660140546, -1.1118975199693308, -1.9502737253940767, 1.3931701440794482, -1.6935262543119287, -2.179031490361442, -1.160833450145657, -0.8085695180376712, -3.6590782628782716, -1.3392529461496332, -2.9083198676447837, 0.8231528028026144},
    {1.5292157301087648, 0.2945680153804438, 2.5670633606807587, 2.5270225379909985, 1.0651361431432655, 0.8214807008643639, -1.7130872621857938, 0.1388985417947719, -4.926634127774497, 1.8471239161929158, -0.8348544716755019, 1.227710562220907, -2.351879561868843, 2.167840657134634, 0.625785050853054, -1.545898411884335},
    {-1.166149780577842, -0.1289388677634232, 1.063403201604473, 0.07812569617138958, -0.005426394914958704, 2.049535427751217, -3.1899320496568064, -0.33695900364186876, 0.3639417149317691, -2.5003040518552964, -1.3373310669259983, -0.35412558041995384, -1.831609044928872, -1.4443920923723377, -1.5868149063406884, -2.07051152484569},
    {0.9976052658401731, 2.2572124573741656, 1.2644857191585155, 2.062922121602445, 0.583829915813137, -0.5577348132386678, -0.4858071797585622, -0.29377081889042267, -0.37764248881381585, -0.07764060728367783, 1.2878317078289943, -0.025094726670435025, -0.5018199997585802, 1.8439054737619358, -1.2490480285998096, 0.46967264934857667},
    {0.7924891488198194, -0.7314600503705846, -2.4091894515959824, 0.36048933561189234, -0.4373382042371582, -2.1214559418562318, -1.229577308463715, -2.0888462424359235, -2.6542397204361365, 0.11528404547078892, 0.4579515687677478, -1.81284727112524, -0.2564070624240293, 2.4397288834082276, -1.2459837802476332, -0.032568725544463016},
    {-1.2357447172174585, -0.08650074867106892, 0.9483491610107924, -2.870637680547274, 1.1870713474094978, -1.0446723062324887, 1.189752374191013, -1.093666576109485, 2.412847527332132, 1.5086531341676366, -1.8653957631908982, -0.7550907486014797, 0.37106328134188477, 1.2414529548800886, -0.6920062096983567, -0.14752144033125297},
    {-0.008286073589195215, -0.7882992836200656, 1.7471215890845364, -2.87764988515224, 3.69533766688796, 1.18553526260411, 0.10357024522926085, -0.8423001121804149, -0.857266008735702, 2.6509675977741844, -2.4569707236715503, 2.9604448380529265, -0.546530318022581, -1.8419965008527412, 1.070321643324378, -0.7680391486269826},
    {-0.5494641914605967, -3.1728422733521437, -1.4497899945369535, -0.7611965480279348, -1.603160156918532, 0.10105496475603756, -0.7602399066849518, -2.5793712213871363, -0.8483147110693517, -3.486579052175656, -0.4474639976020745, -1.14863081944142, -0.599683401519243, -1.021638525922746, -0.3646846790321247, -2.04247597609692},
    {-3.3422023948499824, 1.813325263111075, -0.3209585325490186, -1.8985580103025839, -1.4869147630401638, -0.16251598039755027, 0.9915458388656464, -0.22110640628719952, 1.2422729986684757, -0.8161001513714619, -1.108928107137032, -0.7463836804739571, -0.0381203094460855, 0.06432411699215392, -0.15394201824331047, -0.3221114051883752},
    {0.7668223237901592, -1.5271950231919698, 0.9114534019250148, -0.22767372087291077, -0.022326624539192156, 1.78243478341079, -0.6082419503662921, -1.345122202706209, 2.0148624200525447, 2.070955209223787, 1.0034661658860744, 0.8559598422458895, 1.0929505692089092, 0.10544447674051037, 0.12944393626863057, -0.8836507196369846},
    {1.3268297228451182, 2.785879646406238, 0.9993206265875673, 4.113245445045843, 0.7596309073396376, -0.7323743353573815, -2.008174032705768, -0.10351519931532913, 0.13289872224429863, -0.7439259790075646, 1.032773063705653, -2.5116269503999273, -0.3376398189295851, 1.304464817793257, 2.837303236912247, 0.9074980770300688},
    {0.8817690549009897, 1.7212716636568584, 1.115380690057769, 1.6644662586987133, 2.355806953018506, -1.364331143564066, 0.4287847515550987, 2.2247218176390184, 1.7400086556691772, 1.7005558115023642, -0.38942337880839545, 2.155020421732952, 0.5055189478951685, -0.9099024126690396, -1.904799598353709, 0.733322017901569},
    {-0.5797166757817857, 0.4429570998372508, 0.5240190975018177, 1.1754087879894861, 0.7002791088521968, 0.9824527619285847, 0.20726686024661561, 0.2238890678317917, -0.5744463405154658, 2.5097773559626115, -0.32807100487733004, 1.4306875364449052, -2.6904078967414558, 1.1903724365031958, -1.0047169650890309, -0.3491640964591275},
    {1.2930188736414645, 2.832068682061472, 1.4589431449476553, 0.708621763749954, 0.8744551477438336, 2.489686604625215, -0.7778992174397696, 0.04917561911410912, 1.837825347014619, 1.0843366904633613, 1.5019133560473978, -0.8346650754677438, 0.9792387016011515, 2.6354832412917863, -0.12287914664945908, 0.3230626600819214},
    {0.853710921385861, -0.5417935673706004, 2.7214364368850035, -0.9828040151471186, 0.740381953641471, 1.7436774537060697, -0.33294930474035, 1.9743940544904082, 1.5391363021770907, 1.3402487163243084, 1.4462915704429635, 0.9760248748168286, 0.6585759690019827, 0.38593890326327357, 1.7086020139387321, -1.090581520929723},
    {1.0876464591432404, -1.4701975901440736, -0.4399961923365907, 1.802777923997401, -3.643048741018259, -0.24146235010857212, 1.0810989815159635, 1.922996020672335, 0.34817758141345007, 0.7057162183096932, 2.6268894338179667, 0.45004238121638596, 1.4257739594681031, -0.025001482802517593, -1.6825011461131196, -1.074365300113925},
    {2.070797343340572, 0.7563801449141057, 0.3100204758314106, 0.45268505210521043, 0.42557043587955834, -1.6494283883788443, -1.4581274687955201, 0.04282252634914884, 3.601043872134349, 0.24333248559715842, -0.9446254069222317, 2.8876853786933143, 1.7935375898630623, 0.40934437678329827, -0.8872978719394597, -1.8113774633182356},
    {0.6654370610933661, 1.4932671938758328, 0.7296466753652718, -0.45573148810525055, 1.209979909600148, 3.5565759324314454, -0.5183320764979821, 0.6151902421714639, 1.941124962194169, 2.0505755089992506, -2.194076925599946, 0.49253478950191587, 0.8994758632421727, 0.9495456705875621, -1.496595119447302, 0.5803122085826766},
    {2.3038526776083, 2.3600663437037075, 1.4029868657552607, 2.52941259825673, 3.0867008471216755, -1.9175400606955466, 0.19399283940470918, 0.8571571058164873, 1.3131532139876954, 1.0137702754492393, 2.5154592041944834, 1.5922909015342697, -2.5238441324773935, 2.5022064460986377, 1.160851997494282, 1.7715576467799008},
    {1.6146793091251295, 1.4243788906438868, 0.9311409880682949, 0.3791144875493117, -0.5067573337673212, 1.4598347200505644, 2.7313767781849347, 2.03197534622658, 1.4327669602395974, -0.6682588494728491, 2.6728165612511035, -0.1470094165199346, -1.018616240835688, -0.8517559023865773, 2.3732372568432254, -0.23567051880654175},
    {-3.190913008147833, 2.3270183998412493, 0.5251354401195316, 0.901508887513101, 1.2731633560213813, -0.007886595364527347, -0.8283829246523952, 0.4574417980056282, 0.13134291131487486, -0.9413688616774913, -0.43402123490434236, -1.4474358324764394, 1.613052768954411, 0.9548891577749857, 0.9666482224398417, -0.4068224526069028},
    {3.2681434441829476, -1.4537379516591076, -2.8824187222654056, 2.168072615281401, -1.4245134723260313, -1.6578201356197921, -0.3768241300493392, -0.39937454414961543, -4.545095268719615, -1.2843841539909433, -1.513939032712117, -0.041365924312613545, 0.19750902385289112, 0.5971140793566165, -0.4289916327796796, -1.6604766386303498},
    {-2.837239814319819, 2.061194695043749, 0.5282363261605679, -0.389524892563586, 1.6770904427340096, 2.357558688567008, 2.2264231555269305, -0.6666551792248984, 2.0551684672287562, 2.777459160377083, -0.447702295299322, -0.0072695577307413314, 2.857946089957263, 1.3213983101814604, 0.5713071661051962, 1.9797776003305245},
    {-0.4018774967676117, 3.0097220470244106, 2.3175224527521125, -0.41229725249695043, 1.6536090333199904, 0.2616618918480205, 0.20672320655558069, 2.140430094224739, 1.5794035913846118, -1.8242639200155306, -0.24519274954203496, 1.3956693216412044, -1.338426609509524, -1.0211975172032897, -0.44078786507804096, -0.5078898774675873},
    {3.0838358049391577, -0.6412266482034356, 0.737472696901195, 2.2680529132053757, -0.7280471395285887, -0.2784912537488553, -0.45858161693883287, -2.2830479203339498, -1.0064068990362052, -0.08620808923465484, 0.5676706673341133, 1.2282292981450003, -1.7564408673252436, 1.1049648759311765, 0.25963416003501266, -1.9584374677856184},
    {0.9152129627316378, 0.9409235112348746, 2.3103164218882806, -0.042242273783680576, -1.156949701025286, 0.7328837373456628, 1.929609380021606, 0.7442159498734294, 2.598403520408157, -2.149716484951455, -0.4426841322413242, -0.5279339364201661, 2.839477528597889, -2.0035799108670926, -0.5162875862913021, -0.8551827110379557},
    {-2.694066568700042, -2.17492260927375, 2.043124293173041, -0.45476614911526914, -1.27933485162526, 0.8280396745639576, 2.3465196249726494, -1.0042697405475185, 1.9002247885670487, 4.064394901282154, 3.280921212987517, -0.012814187642180615, -0.7282541751825082, 1.7540871114425123, 1.0189118636606416, 0.35279156826048375},
    {-1.1562896098938635, 0.33303240896280795, -1.5072335853949308, -0.4481779950816929, -0.11105542348353166, 1.6068089647090804, 0.3467960503255279, 0.5349739693217637, 1.1792845432591568, -0.5512282730448661, -1.8667993059510148, -0.2725501805254931, 0.5631908458573996, -1.846975371781786, 1.1677117699817077, -0.47543338516291844},
    {-1.0707030013688716, 1.7342083266377484, 0.7027601253374023, -1.5724857739570977, -1.3164407670943639, 1.2166396563430844, 1.0620107596161972, 0.8619512286104227, 0.21265018943842912, -0.5341712305865753, -1.7841353399893147, -0.8657907558549254, 2.939808586162055, -2.701144607089188, -0.8566563325997401, 0.20883958092969304},
    {0.41442942900206037, -0.8969990671171045, -2.5175211519644156, 0.013596224159691311, -0.7423028759695967, -0.21812425398008553, -1.655048852483398, 0.9971360805767675, -0.3811124463455566, 1.9089120451501074, -0.5520616243050316, -0.7011570485976072, -1.0719530954249286, 1.6973563981924524, 0.5766944103711922, -3.2939150497655896},
    {2.62363446758955, -0.5731158251687615, -1.3383500564881217, -0.4199247369185862, 2.899496433603805, 0.30842496244021983, -0.36361217113918287, -0.33231026285584897, -1.7262768204890715, 0.38140637851964804, -1.9652114018715614, -1.4056310385857615, -0.7340706605166557, -1.2548013319818254, -0.7159770721749549, 0.18933461238297797},
    {-0.28833060057151927, 1.9078130308702546, 1.137634759997035, 1.5790636522420347, 0.22921319945993537, 0.33029530685129277, -0.17538558048338687, 0.7587283106751465, 0.4334235127929709, -0.6645125385790559, -1.5583147092534289, -0.39444769259866375, 0.809092543817829, 0.9562021086548745, 0.696813935494991, 1.4202611781824},
    {-1.482974807016541, 1.8550917055489373, -0.8201082922612298, 0.023217531619762366, -1.945743326469464, 0.7540205273434317, -0.17370277965093078, 0.18154560202308181, -0.2070310404968953, -0.4057919204494906, 0.17298432373325814, -0.5189741526389131, 3.1451109172862637, -0.16549012523882525, -0.6942748021044868, -1.2455954754837173},
    {-1.735502926420659, -0.7399373585008917, -0.6724696034848355, 0.34325164461670504, -1.3485051728233606, -2.2629378369739066, -2.4927254070776477, 0.8725066437473817, -1.169916472094613, -1.2110314601419807, -0.7355814765847086, -2.5586437806369413, -1.4061680416401403, 0.6586582874630695, -1.5568642005319764, 1.3849650493000751},
    {-1.0962898205142726, -0.08979584323782532, 0.6256785415086765, -0.29088810407579696, 0.39041289724046796, -1.2493524671227398, -0.6447507893761749, -1.1496076728269657, 2.3986482417605495, -0.2601328951658639, 0.314204525607968, -0.04168162377033896, 0.22245837230753343, 0.5277369147493052, 1.7620664406870836, 2.1998725810447475},
    {2.014592462963131, 0.9692698142121556, 0.48017048423458764, 3.2456651452246765, -0.5658094721449871, 2.1796479970416365, 2.2806721280615654, -1.6460062468205439, -1.8235084206405021, 1.2954835340040638, -0.14268919852403095, -1.0230024471676, -1.6757467691803885, -0.054269077832236536, 1.7441343473966306, 0.14274468046881522},
    {-0.2668751470777637, 1.1465458459579156, -0.3558471354501457, -0.42551104132009626, -2.001144925366518, -0.9176574148248757, 0.45177714198257357, 0.4990690279865119, 2.58804307538754, -0.2989785194045107, -1.1489344366761784, -1.300231328023465, -2.213063603356356, -1.0904323129436289, -1.0163160283721928, 2.1615089164145327},
    {-1.1734694692635397, 0.25503988141817646, -1.247694957147156, 2.193425657077559, -0.2668224173712801, -1.6425708982135763, 1.1755365425986066, -1.712390519713527, 1.0727116331032212, -1.1731816928447694, 0.8068005236476431, 0.2923056912143947, -1.0645150329079445, 0.2813073925364653, -1.0465248099705013, -0.42149355570020475},
    {-0.21462020946226365, -0.8227852926223727, 1.3844322572221213, -1.664087825193705, 2.8163587890507666, -1.2340337457558286, -0.36148757459855785, -0.8064128294909796, 0.5200584071498798, 0.5393673056300445, -0.8768391307012856, 1.4501018755365704, 1.969272001855363, -0.8324240141509961, 0.37904054228110273, 1.1303751424089892},
    {0.10250828407890784, 1.3076550840401862, 0.9352862261488304, -0.5137915270755316, -0.614880534189858, -2.571866237426368, -0.5560036393897113, 1.2789578895926852, 1.3518585168484203, -0.972610585314733, 1.4169367955403154, -0.12783817246814905, -0.6907307460602872, -2.9129514733848625, 0.3729571860824181, 1.0296430763196807},
    {0.2884712908524057, -0.550436912558285, -0.8673253290580045, -2.995430066118687, -0.5181833316684233, 0.8635507684134177, 0.6223619558422628, -0.6113492702012756, 0.26122830078654236, 0.5468016988196898, -1.945740531261539, 0.7373232064377652, 0.12289102949072753, -2.1535007874976184, 0.1030433752236453, -1.5986379614136768},
    {-0.864653506580141, -0.8466741235126453, 2.1787371267713582, -0.8768825726205393, -1.752196401625086, 1.0098311534015239, 1.1173561531540572, 1.2014529632332607, 2.828437092121337, -0.4669123066792578, -0.6672504183694922, 1.1667507102784072, 1.4934516700279494, 0.5802370399064168, -0.7996284261887563, 0.4872829092680759},
    {-0.2880460849544204, 0.8764037515092613, -1.090362247631456, 0.8982656402049372, 1.2745449841782097, -0.33973398004490535, 2.809106955674375, -1.185906520503481, -1.28290871105607, 0.1600822837494041, 2.237246115211781, -0.5886785780804614, -0.6957028844353307, 2.016156453407644, -2.168743945034798, 0.00040001422218523453},
    {0.1040390936469259, -0.3211721072833323, -1.0854216059151713, -0.6492841191009262, 3.780476625768571, -1.191204132518015, 0.4239001108641994, 0.7562397011555438, -1.523425056654806, -0.1340062996664694, 1.5832076352553588, -0.8276289173682866, 0.23857891956803112, 2.394444342418746, 2.5302824374701607, -0.7039573148138646},
    {-1.2083972571320705, 0.9928854719436769, 1.2169297366543526, 0.7845698477771633, -1.6788441112917967, 2.4865523037945207, 0.5632385834713126, -0.3055486950561384, -2.688422178183709, 1.3307219008140203, -0.7251036755659739, -0.8743787439642945, -0.42240861891780557, -0.3197776599157643, -0.5933551296200764, -2.1369667006051305},
    {-0.06377369042964981, -0.5843529506059112, 1.7571677797352336, -2.5809665625406564, 0.16336988336361646, 0.50703855898882, 0.3301513451369915, -1.6356671247210277, -2.694376227546203, -1.405423802442861, -0.540881934350955, 1.5712709383194614, -0.3034749422980043, -1.0053180394122827, 0.28527175914037317, -2.75206065905134},
    {1.0280185777388136, -2.339811354359159, 0.9298421141135271, -0.5321116722675706, 1.7185810581164862, -0.39570281581637645, -1.096718628208974, 0.2978314850003478, -2.739401695435302, 0.6434154093856171, 0.18004911004688656, -1.636206211611054, -1.0452853462419112, 1.3474142985209527, 0.5361797398670336, -1.8191509916698045},
    {-2.4294318319581656, 0.8732302641997491, 0.21429651625098778, -0.7915158212011154, -0.327000094585304, 0.49444738946492856, 1.7182690095388586, -2.7961453116280026, -0.41223706989133674, -0.38380405160522374, -0.22649661994162182, 0.11653592849861193, 0.5064843978905168, 1.0874864378917095, 2.9615724621282196, 0.7183026887507964},
    {-1.0055836197649277, -0.3824183463692078, -0.3502287221767937, -1.3024333203285878, -0.3925293299113996, -2.706560806014176, -0.7396708097021556, -1.1885680663588838, 0.1578559695553438, -1.8317279795944466, -1.4962366837948176, -1.3217994536511957, -1.1205332741628986, -3.1462014722351292, -2.612734664216293, 0.16173802461792264},
    {1.450479143648295, -0.3194275706340484, -1.498288607428505, -0.24258947756058238, 0.07450940677757062, -0.1591152108940812, -0.3752074315656809, 2.1571957226004623, -0.6296189629003024, 0.4588206946110233, 1.9219836328969326, 0.4898638314131312, -5.395597660409947, -1.4878993502718918, -0.04044108415041929, 1.013338774154607},
    {0.6813119627399341, 2.021818313063445, -0.6876037158889441, 0.020409965338065172, 1.3651778053533228, 2.006770265335745, -0.14168693474715074, 0.7457104890430554, -0.1199669344741121, 0.0036984005709501384, -1.3683377469517477, -0.4843584419947303, 0.493971536776932, 1.4353639711709814, 1.0700217511188497, 1.2090343466601643},
    {-0.9495952802407096, 0.415247151815433, 0.0069652740628402725, 0.2450469852435775, 1.0237077441115805, 0.04178864644924195, 0.14135844520446675, 1.186307733235333, 1.911593116524793, 0.6204127482733395, -3.141732270831605, 0.6338435349844639, 2.2452433214087906, 0.21598363920262853, 1.0169749343250787, 2.13467520611676},
    {1.3009045838480606, -2.8364975826020524, 0.046909947795599836, 1.499009158965488, -0.5277555821316813, -2.0751418197408773, -0.7314554478819635, 0.3675380062157777, 0.2913167856230765, -2.1272158560749452, -0.28982922686034795, 0.18863524251663943, -0.11943002722591671, 1.5776474976708041, 0.1977993963615288, 0.6601641980901954},
    {0.6899846888021055, -1.4042636644930657, 1.8878450167747947, -0.014929055601050898, 0.9729625680001944, 0.16904239737751006, 0.9676093378724782, -0.7817830846363973, -0.6873567092272909, -1.325818137558465, -0.7323458877647178, 1.3022892427820418, 0.748748112511582, -0.2968670384015914, 2.1770279191541184, -1.5659143558793622},
    {0.37051479261732356, -0.3136548450060957, -4.291268082942539, 2.040597450534465, 0.7430473300739153, -3.610252831385382, 1.669479411840989, -3.7374994552528094, -0.8038237249254896, -1.5244033173291718, -2.554062121445094, -1.256436436863116, -1.4350155197519308, 1.2412782288239836, -3.9450049278167145, -0.7136833271276184},
    {0.517046370702094, 2.4734627855551894, -3.734361098500503, -0.6755719133242843, 2.8405485521078186, -5.411806179002572, 1.260166939401948, -4.975915391592967, -0.750420939496669, 0.5423393500017056, -1.0007262327695494, 0.37600170105963054, -2.342325354375676, -0.19701262221476393, -4.041888269999823, -1.3652082715102412},
    {2.1295017943686285, 0.23863645332606095, -0.29129417189666273, 1.0760204219435618, 0.8895500726584181, 0.9373781117471686, 0.7534231507713826, -0.7403582764835565, -3.180938355057733, -1.1434373060546905, -0.6076654343652259, -1.429155802868953, 0.015070645601963244, -0.828505045220851, -0.988671755796791, 1.5006268970906251},
    {-0.2328607233057677, 2.0262962710435284, -1.9483860846197063, 1.1684862081002243, 0.30881643615314225, -0.25440521144019596, -0.5126449238110397, -0.5401468192012933, 0.23343877915572506, -0.6070779925226841, -0.8330755472544922, -1.0648640042917896, 1.1790055212028696, 0.6645517922325184, -1.2372482530957702, 3.8877968824358984},
    {-0.08526377259721583, 3.3948072940140244, 0.20621565019690485, 0.7703336133400868, 1.405247641162622, -2.479229343388506, 0.3686911361236727, 0.03502307535345966, 1.3370798462149291, -0.464650301855525, -0.2873123838643737, 0.8995690438817076, -1.8817591020566165, 1.8230787014942689, -2.393654888816735, 1.299768069454064},
    {-1.9073576340272849, 1.0446190269927054, -2.605348650139658, 0.7065748230805123, 0.24557715983575806, -2.3642811269510684, 0.9308539413199892, -0.4820631603023501, -0.767289000808241, 0.7187792134185789, 0.1027579491022916, -0.4811475422011325, -0.5156384681233775, 1.60499282517399, 1.270230588763734, 1.0809328137941852},
    {-1.2194236566695977, 2.482238503370581, 0.7555595063941388, 1.0379774556146615, -0.09917913691258, 0.39454392807848837, 0.4731343042187241, 3.478583408725974, 0.5041682382206858, -0.11055768174815789, -0.9685313171818178, -2.0832732179275206, -1.5935760407468897, -1.8134464605456169, 0.35647577772647776, -0.1770052271929337},
    {0.36931065103925254, 1.5046556854627364, 1.147800868111563, 2.6204519619180955, 2.7903970867490933, -0.15593629170020898, 0.24252079395956452, -1.4544967708861036, -2.868777444738828, 0.2187283076476555, -1.2870062626702083, 0.3394869849028026, -1.2281474320550871, 3.1555204650773234, 0.9650061164212631, -0.49165624159835913},
    {1.3567263802848093, 0.3004178006753866, 2.3927433764688093, 2.531657766640104, 0.2974327487888597, 1.062624369466824, 0.4009511935272398, 0.23103122566883222, -0.30619027035294055, -0.6664282894757352, -0.9300971676745223, 0.8608546229431975, -1.2839097974906741, -1.2521793190805928, -1.2619467981390007, 0.34396054197467685},
    {0.6700465338998133, 2.6585741983807885, -0.12830537051710103, 0.7546306648353212, 0.309565131850828, 1.0041145082511644, 0.3184889002309064, -1.2518821215913312, -1.0185715894655678, -0.6866627145985652, -0.5972302012630176, 1.24469529809219, -0.2982071069908258, 1.3947891992682464, 0.12150264353190135, -0.8888947904266314},
    {1.1319008673344995, -0.2505396389968457, -3.2123531760889126, 0.19330033333387653, 2.174806112726559, -0.8665707294654235, -0.11830591448838565, -1.257978875555723, -2.039218572872268, 0.1147510523363487, 0.6719960161076804, -1.2664393295727254, -0.4559589659356869, 0.6380861594997153, -1.1512948205588083, 1.1728922925195293},
    {-0.34302574478262626, 2.335228777657421, 2.2664628906989974, -1.946807006933841, 1.9407976497901105, 0.37826801133604365, -0.06660441204005897, 0.43108455989111166, 1.9326338921576902, 1.3983733725185663, 0.3615030517844705, -0.23231467947956064, -1.1113548316564068, -0.25796926747138094, 2.8338629999335367, -0.6841939325318677},
    {0.8695225837369638, -2.112658636116482, 0.2136549567490223, -0.0009693671408838084, 1.6233402601461913, 3.165494508223196, 1.5157345064519039, -0.06947431300162292, 0.25911068322994046, 2.526645818262111, -2.0023452304406213, 1.7314887373010788, 0.8504834452352008, 1.5170187953859184, 0.6426299931102033, 0.3443224201616093},
    {-1.1279071553451376, -1.4334023029274576, 0.462030089400891, -2.5092464125493543, -0.1534770827094681, -3.127617592877002, -0.06614551805495295, -1.6558227109433337, 4.221589725889047, -2.099312268113723, -1.323208567564195, 0.7650230175313422, -0.7809824093723178, -2.539494317169237, -0.2665687513937998, 0.14424693509648887},
    {-2.126601768839542, 1.6528190561781944, 0.7469790767621522, -1.5042591446550013, -0.9097367053777863, -1.6768534474361374, -1.5967198938751128, -0.29793650430895635, -0.9216042958828173, 1.9426471813055892, -0.6080395257369772, -0.8512879850990057, 2.3440811785045135, 0.2770209072627669, -0.18405271118344516, -1.1205066286399574},
    {0.6201396286791035, -0.36389585215711256, -0.3331307869791854, -1.8296886389461497, -0.1511040370034, -1.5520579355740558, -0.7846428276771197, -2.3518747292783653, -0.9649652216885093, -1.5742461014582834, -1.3197680548603241, 1.8410497206864873, 2.1527310186814432, -1.5864173754438455, 0.2350876323948615, 1.567266789933066},
    {0.42731515737343845, 1.3435913046760048, 2.5033712842858518, 3.143030708589963, 0.8984502930938258, -0.11744310980034187, -1.4511496391570675, -1.022350319140027, -1.9678994893570885, -1.4196004666633057, 1.4605625246819502, 0.48105865582487356, -3.25027533617706, 2.2032877927709613, -0.1325095539954754, 1.0101775563191435},
    {-1.9442113482683079, 2.8696071316215517, -1.295316303467634, -1.1960228013405882, 0.48728887769887874, -1.7850567156291701, 0.849245007531111, -0.5208383256084542, 2.2197166420769343, 0.8411549974687078, -2.3545186847404906, -1.0935915037952444, -0.5733643410252364, 0.024285110514276852, -1.1840195300833964, 2.098633992711102},
    {0.06268936338255478, 0.46432403789153714, 1.012291506066888, -0.6732358543888217, -1.48967624117838, 0.4541753832523105, -0.4032362879878246, -2.021532855381986, -3.5733087277645046, 1.6314289633090235, -1.789971235761279, 1.0869291476796956, -1.876872273075011, -0.4913634802922572, 1.687994545745724, -0.4820287985707619},
    {0.16663649429911384, -0.6207415453305085, -0.7753075717804669, 1.3868007093495953, -0.9347833588360073, 1.149436274296416, -0.8328010783433494, 1.3718030060152395, 0.3320137460810727, 0.6159387700633412, 1.3451187397661741, -0.21871868876764558, -1.385884814622612, -0.19765191582701083, -2.366672658477848, 0.5746653306122316},
    {0.23281607714762917, -1.9090188669822483, 2.3306920387873657, 0.08017472557067315, 0.4698977571892284, 3.7735277605652104, 1.5210271761005536, 1.2475277854431177, 0.4366245569620708, 3.0726140857949362, 1.6312375795828615, 2.015115666102631, -0.4596521743717966, -0.32541395493548664, 0.7786847212973391, -1.2232072029114245},
    {0.02816225521370651, 0.26188102696165166, 1.6668571322231194, -0.6489104200103856, -2.7693604786858264, 1.3830357720510815, 0.6948027149925683, -2.4509323776885497, 0.8410262621326648, 1.8037499339587202, -0.6797444994792695, -0.3163953313123604, -1.6517973783191144, 0.26299676090164525, 0.1769711900683713, 0.5636391733770473},
    {1.0588276046516674, 1.083814906855847, -1.0664039494474955, 1.4055505095822507, 3.0555903796381814, -1.7670705516369136, -0.3591781671186441, 0.39655119389599963, -1.171189660443182, -0.12492065566454576, -2.655752721683963, -0.732581736725985, 0.40660619088912114, -1.0557672389010337, -0.037112328794825636, 1.3082738223516588},
    {0.5168598287586526, 2.62720503643688, -2.1012776583604444, 0.09171578066371316, 0.6885220286615412, 2.8720917584025565, -1.3978161580053556, 1.8348878480227622, 1.5288377601153724, 2.922924338557, -1.8620922589510223, 0.3288687123270691, 1.8304217488808887, 1.5962829871266788, -0.6775713387309489, -0.6266699569306884},
    {0.49538777897713004, -0.20907825961190724, 3.5723903169716364, 0.22394328864566793, 0.9176332317280393, 1.3290983790759545, 1.8609041522579193, 0.2163299185508366, -1.278525730149995, 1.3572870432018906, 2.1051770544547144, 0.22598161265801886, -1.5668508846915101, 1.6695847312688818, -0.18895308881667572, 1.0540764513879648},
    {0.511489287996594, 3.7461623061960765, -0.6891733941481517, 1.5909720035890278, -0.4019171087174613, 0.3655902459903067, 2.378286873682509, 0.5097749963162113, 1.47973920660378, -0.2106651782681933, 0.7857588123549895, 1.4084584713592518, 1.6173418641232347, -1.1719206047032964, -0.04328313862775679, -0.12534531685089445},
    {0.8026886494811394, 2.001317947690445, 0.13800315145000897, 1.2766908489510864, 4.494407191052314, 0.29775976922580294, -0.27287455409886735, 0.22575637781289973, 0.5087911149797532, -0.6607592832601078, -0.649933449051051, -0.13313084860826066, -1.8014558587294485, 0.4256068804189728, 1.5331012516121143, 0.3412656805948283},
    {0.565364701608633, 1.4680160587293867, -2.7121250564246493, 0.22999571841607655, 0.7100978460163057, 0.0901645730273536, -1.5811217596456724, -1.703080401222481, -2.969498490178845, 0.6779467776690848, -1.6495168724464933, 1.2580866470348464, 0.06786994411001672, 0.8354914477378876, -0.6320805770645039, 1.0888327760904297},
    {0.9321557653291237, -1.3985378323752486, -0.12069874695860265, -0.3984273567565894, -0.025049678254526597, 3.660527303219447, -1.2175951461941845, 0.29067286200035597, -1.6437725157594234, 1.9668635299975832, 0.4612773705288247, -0.8357060008999798, 2.044745977817276, 0.12034738536554734, 2.8298644720197794, 0.4868708026361074},
    {0.3605202508977015, 3.1166316630535587, 1.410884353643122, 0.95666545097446, 0.8762658418919278, 0.5110380095852446, -0.7297070555637745, -0.100611890224233, -1.162773503674764, -0.47202521662665636, -0.3277652857675564, 0.36894231083056556, 3.170754882718386, -1.5628484672265326, -0.5964793881419397, 0.34738745466171955}
};

static const float b1[16] = {5.416224499555944, 6.30269311011764, 6.234903066191411, 6.232442942757231, 6.890799961884851, 7.012927856859368, 6.084279049153941, 6.419921890576949, 7.669624054897687, 6.659167460750038, 7.5676513963275385, 6.655650022615561, 7.274152086925969, 5.448941466919616, 7.7942414795013555, 4.790362475841029};

static const float w2[16][12] = {
    {-2.8065172660884743, -3.4143423159178017, -3.7398463417319157, -1.3009079156119476, -2.3985492834124797, -3.761654927623416, -2.9458604252759013, -3.437881817194114, -3.7992877139866916, -2.7573879072879204, -1.09443247742353, -3.918848423313831},
    {-3.9891317641396475, -3.7614440877905424, -2.4017256597012833, -3.3313680730454966, -3.315325709622027, -2.710720666383644, -3.7207638184801706, -4.763707924737605, -3.0696204884931224, -3.855503881213128, -2.413757480454765, -4.6561152448166165},
    {-3.629120785722095, -1.941959628679429, -3.2917058845106646, -2.876707067405903, -2.9695670668587297, -3.523206950482496, -3.785124546985659, -3.2595780694250696, -3.285460333251026, -4.102339189609503, -3.5312754238409134, -4.215735041884932},
    {-2.3272326037842856, -3.3312644639834894, -2.7126475967983916, -5.681043878195589, -3.29151270305807, -3.641067496329838, -3.3017950385832586, -3.8694646504968238, -3.2522247565906826, -3.28943374349127, -4.25489365938578, -1.2298237772679101},
    {-4.328928832447987, -3.4498106059546396, -3.475934830179276, -4.901576030697803, -3.1904030861067123, -3.406017070368514, -2.5048902556830934, -1.9874752817335908, -1.9808413256096904, -3.955755865257987, -3.8577733606105284, -3.1919183027168745},
    {-3.232636549971781, -4.325451536303305, -3.3530346961469317, -3.8086598970989054, -4.149855089949222, -3.0324322831807793, -2.6911648392293803, -3.3964102115749006, -5.083722812091532, -3.97215063737272, -3.4535802386021555, -3.357435687570709},
    {-2.3757723074803025, -1.4529410797053504, -4.271291466100761, -3.426544665538099, -4.214455050092765, -4.646831706806871, -3.281922775712103, -3.4654212235405057, -4.109571433634131, -2.450001975680869, -3.1664517391062814, -4.924418953838348},
    {-4.11832869467178, -3.5240195981836275, -4.17405383662155, -2.872180981247137, -3.5024689345301616, -4.086220453411895, -3.2107937465340934, -3.913818269424145, -3.5522861615811054, -1.8171092554449273, -4.937552981721815, -3.784038737874989},
    {-3.735199832143518, -3.6502137876442236, -3.9895374848750813, -4.4162206630402885, -4.1456403925658645, -3.9062496703154648, -3.6278073122416052, -3.7553352967693283, -4.939206535188311, -4.308818040008222, -3.2912368995772723, -3.8659458858073448},
    {-4.143656745692665, -3.3495562992258274, -2.2879251448855293, -3.228154770165419, -3.1713860563884735, -4.486537106585327, -4.622654458948061, -3.2491091064348745, -3.259357306493109, -4.073969176507148, -2.9302291264566054, -2.9367794618773977},
    {-4.878732288591284, -5.228871171656946, -4.004320649343962, -4.135821533357795, -3.5851423378578926, -3.1882654524449925, -4.1960796715697075, -2.9813469643959407, -3.2134896537260915, -4.394230722246346, -3.9526310905680537, -2.6407755529265167},
    {-2.629875445195045, -5.318291726508501, -4.401678910477746, -4.620408045871379, -4.36228617361835, -2.0703984017828083, -3.995359901946736, -5.205408293802612, -3.020167713946018, -3.8967276824641948, -5.770723078875474, -2.5720730198973936},
    {-4.898264257453423, -4.37118514694832, -5.483976922816803, -4.522050152779061, -3.8447265214366966, -5.5932393386071055, -4.9184566371344305, -4.213569332029033, -2.448732615775512, -4.631739581213074, -4.350902161029422, -2.9731054036207913},
    {-3.5278765222028854, -1.6185046509143588, -3.7875573758564354, -2.698350099457121, -3.5467828651829074, -2.6451218369286917, -2.673183114134133, -2.550754848899987, -3.6987718171921786, -2.259140625014491, -2.3682834626434395, -4.394145451019729},
    {-4.204565304513419, -4.996241931225461, -3.3610901904219537, -3.8808791451337536, -3.6973267668976404, -3.951973330133413, -3.9505127684882595, -4.852845052881127, -5.36566046779174, -3.972172219678669, -4.033977858487007, -5.909098740550545},
    {-1.8973253361287366, -3.498310454380557, -3.058862848648348, -1.440851973062586, -2.7473209728059538, -2.285226221302098, -3.196389375832826, -2.217936470473671, -4.677922005808208, -2.725693932264274, -3.5683310779070894, -2.9126578471759137}
};

static const float b2[12] = {-4.732303930074147, -4.222864193761474, -4.526714912633013, -4.612187170418537, -4.582341974102377, -4.74569744954757, -4.404476694147925, -3.350138503596634, -4.4834390956920265, -4.216956730997304, -3.8910543708687997, -4.801380244235924};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
