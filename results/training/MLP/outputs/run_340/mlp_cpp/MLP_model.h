#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.3703784660837554, -0.026255685537842972, -0.25118171326162625, -0.06873343775604636, 0.6311806352240877, 0.2918055120497823, 0.4335367822234884, -0.4196715553555925, -0.05151420496381538, -0.004673279012779864, -0.4198511994181479, 0.24919498700221437, -0.21134663233458395, -0.19820501797070225, -0.009347716404128811, 0.08362918661032348, 0.2172308180633267, -0.47160370508293903, -0.17458164402846144, 0.29179423254191184, 0.4389981237417333, -0.4189268485552829, 0.09870208883592539, -0.23165998018577041, 0.7335618878335245, 0.22815695741244285, 0.4238182728309068, 0.4332420112199433, -0.25763204122805505, -0.396540159339299, 0.5815513080828031, 0.8242605562328829, -0.08961772096638893, 0.5761819504066228, 0.336266512811412, 0.5638661975896766, -0.1839477366054666, -0.35532190548821274, 0.45477806885297595, -0.13033788865382948, 0.5506860126728857, -0.17820058824700816, -0.07353139027524698, 0.10976328970317495, -0.09943751880520298, -0.22129883925517596, 0.3386380933304271, 0.8831000557216259, 0.5328780567845492, -0.14233432835515003, 0.7165831110807984, -0.5842123167273168, 0.3224576095069778, -0.41674740126565024, 0.08269242551173894, 0.020847226855298887, 0.4044815999244081, -0.1853558847691417, 0.38247232525828456, 0.08533342116777762, 0.2756294144998555, 0.2063302779797261, -0.35689611677353916, 0.5731156232828818},
    {-0.45283616703514706, -0.11114987719308878, -0.4709389969490923, 0.16098392926436372, 0.5113854280006552, -0.10653290928284564, 0.4759099783100302, -0.5362021590869208, -0.1808904546465244, -0.03997493269601377, -0.47239665867182395, 0.08829743519192942, -0.30084842905346726, -0.26089799310611633, -0.3920750425819331, -0.5855186298403988, 0.14193595694361, -0.2450049052996111, -0.479712804044626, 0.3449991889430537, 0.6457881148226368, 0.15079593575398303, 0.08914583052484802, -0.5302443426044093, 0.7133539340626577, 0.16463551432320123, 0.7859070670534879, 0.7138932269120194, -0.3323960102228778, -0.3598812838218166, 0.7736800419938407, 0.8218617441921167, -0.28296413580961566, 0.392993635866613, 0.38305434801974536, 0.5787465645692859, -0.016853596051861392, -0.2258153830091925, -0.45212279209807255, 0.11733105725431991, -0.17098822130507427, -0.33351784703974885, 0.3588835738963581, -0.6647373006696766, -0.5568372918807464, -0.2957862150521185, 0.2489256952734935, 0.402183426410642, 0.2064969003938713, -0.1570388195744346, 0.6397424119624018, -0.4772480169248045, 0.48083825200899705, -0.2680122675638853, 0.023130131452293617, -0.4825561471845388, 0.46103544886852793, -0.5552253254087197, 0.7320499392613169, 0.25808626727229733, 0.6042133435332424, 0.43020343665974836, -0.6485713500506499, 0.38147883394243615},
    {-0.27434542916739113, -0.6418810207846178, -0.38364027747818075, -0.49165152832440195, 0.9920211227831003, -0.26594727954390174, 0.6673408393788139, -0.6164496754604043, -0.4612939100053696, 0.052188511913383785, -0.6154279786700565, 0.3076175420500179, -0.19161084118156316, -0.2795096549563963, -0.3587208138367639, -0.2720694810245492, -0.3207163758294166, -0.14814995407129417, -0.47274616636377226, 0.4327768367150659, 0.9336860092518409, -0.25870125667447974, -0.27843745570386735, -0.33534161026566195, 0.7450152747227662, 0.1826291568114274, 0.7613127152382436, 0.6043163628650343, -0.6506211626079876, -0.532530656264259, 0.6070066285122159, 0.8165551466268741, -0.4127985050466557, 0.566461355369495, 0.3263561355909311, 0.7329250980438164, -0.32403986319526523, -0.3741423500575618, -0.08291231238609206, -0.19662797999886567, 0.18234085933086994, -0.6337314647907168, -0.04680278941808588, -0.3791112821376172, -0.6911682894053964, -0.40914397743160996, 0.6068916908246846, 1.0051168413147715, 0.8899057836818848, -0.533308483726228, 0.7153793441053559, -0.5923570908803723, 0.6012564873273519, -0.5605382551570433, -0.44436591226089706, -0.4319722086405246, 0.082512491676628, -0.6110144641555999, 0.8188068881707768, 0.5931674761351273, 0.8473486529375126, 0.2519830575365294, -0.19182315666315813, 0.5380851684058537},
    {-0.4785370963828464, -0.41527301850296156, -0.5568197527602856, -0.25116636155703065, 0.7544587699309233, -0.3076118048417094, 0.6447251359289642, -0.535783912510837, -0.46565833378249044, -0.2592495145440206, -0.6418789052668418, 0.18062802654293655, -0.4170945822014885, -0.3716593747704169, -0.6606402327714475, -0.43993619516952437, -0.4505322651220583, -0.42024232504489584, -0.5727647678346356, 0.1934893176640735, 0.7380819262075294, -0.242759278290787, -0.33197245621380056, -0.650806705606167, 0.7889844591694435, 0.2342830146070292, 0.6962491362612544, 0.6237853795758168, -0.5206764808389927, -0.6302270442131798, 0.7554933254594768, 0.9057337537796274, -0.18382495877753616, 0.520402257829749, 0.2863027422824528, 0.6996664023982039, -0.3254911584938349, -0.3313546676086022, -0.20326523722646772, -0.11006300854365694, -0.02793747652788202, -0.7355629738734496, 0.1505747258033832, -0.5331160141632653, -0.5321456922470829, -0.5181601627282504, 0.3942842655154232, 0.8414199731727846, 0.7219456845854895, -0.31726828873756163, 0.792595033688041, -0.7204664568260772, 0.5210327535253555, -0.4386407856277525, -0.2908469282898499, -0.5420302457633451, 0.3490819883530777, -0.611849086804919, 0.5432002239781745, 0.21255417836203794, 0.6744773766459298, 0.39508337696881063, -0.5575002150080662, 0.4312997758941866},
    {-0.5831737454397967, -0.8098152361884725, -0.5474704322224467, -0.5513341237757244, 0.6927543686895594, -0.11296996449357492, 0.4472084361085651, -0.7519179456766066, -0.7210475483947003, -0.2647542519665265, -0.6468911138730052, 0.32153422896581635, -0.6681837378625072, -0.5127493231955094, -0.778767858944177, -0.25550763094761897, -0.48548671735151616, -0.23482856288050086, -0.6475987115767213, -0.12155023693380546, 0.5396721925378608, -0.42352029816079984, -0.7262351252181247, -0.6180760128259072, 0.5267898372572077, -0.12473298898821487, 0.5846150718193623, 0.757685829754101, -0.8085231832790463, -0.7324697819733809, 0.4651638588523935, 0.6243965307814479, -0.6258839747891333, 0.46533516017326365, 0.43253968743313925, 0.2738547809935044, -0.4948927144974075, -0.3956079989146754, -0.21495541708378835, -0.16285778129853834, 0.27384646821149095, -0.5749843446371379, 0.12206141079647073, -0.46988206780381475, -0.8711298576262839, -0.5653032402156766, 0.5017783875402914, 0.5890984920199068, 0.43218913780017404, -0.6003905720890365, 0.7763498276735714, -0.7287192184839639, 0.5324729669168503, -0.7150628318053638, -0.6828282008978024, -0.46812641761258933, 0.08158650335424543, -0.8999370292525122, 0.3165361936323382, 0.2109347945735575, 0.3163631429950788, 0.1858226817759809, -0.3987565740355468, 0.26764312617646707},
    {-0.41043084832724436, -0.9229178484523051, -0.7798941532963714, -0.5840427095477954, 0.8109585581758385, -0.13704847927080646, 0.3992189752842809, -0.7795625114097727, -0.48044376905454406, -0.35745095891759604, -0.9244317007974687, 0.5523439694363804, -0.5323894857637941, -0.7646910545845402, -0.6604005379922903, -0.28380415573532164, -0.45952355555304136, -0.19951746362105327, -0.6436127446233242, -0.10136542293749713, 0.45210341070208604, -0.3669976739171442, -0.5886979850885152, -0.7444909979097406, 0.4575085140425287, -0.22277339811065594, 0.34718727832652796, 0.41288259633835994, -0.90046281126151, -0.7748680107978407, 0.6567119060454194, 0.4701231403768535, -0.41839237866706697, 0.41948980175646583, 0.22823469079070463, 0.20764647457460766, -0.44104716068826444, -0.41858377015860265, -0.1873237072348286, -0.3921650578011327, 0.24863067162528898, -0.875526348634189, -0.1399820006753176, -0.48380057400117404, -0.589098575768108, -0.3761642777432918, 0.4277013770288534, 0.6188049015880712, 0.49453586188517923, -0.460049744681522, 0.5504434008043918, -0.6552153979048753, 0.215682895446182, -0.6593267382025376, -0.5150279203532707, -0.5567069841341887, -0.20714811874322456, -0.7860203464147307, 0.19248512667608936, 0.21307813213721088, 0.2708934534696935, -0.07721265139093353, -0.44621044535059, 0.36031158391747997},
    {-0.7359336954985397, -0.854500800465994, -0.8109685898942788, -0.6766424467720404, 0.7720931901047043, -0.43651302986623425, 0.23378012586501795, -0.6996690448729764, -0.48350341340879305, -0.5510304725407639, -0.8587237651745083, 0.21751861965047262, -0.3984805112925175, -0.4311196399895894, -0.7592941262292746, -0.2996729833003281, -0.45249314456553763, -0.25848213695238204, -0.6359676047573326, -0.31729234167070547, 0.44441393014361247, -0.6141262901403741, -0.4915341620688698, -0.5677476617379447, 0.4555994761479016, -0.3351796713569675, 0.4303830401063832, 0.3310173036620583, -0.5987319915454755, -0.6498615462093545, 0.5512459796099213, 0.4279907560659039, -0.614345107458795, 0.2446968117073946, 0.34367621242112056, 0.11279822395638961, -0.6399444736974955, -0.3878033917220521, -0.22283217855905044, -0.22593726015755397, -0.09878315818068825, -0.8762073012805692, 0.01845113912167179, -0.4699324201949844, -0.7803833990294646, -0.47289529478728437, 0.3136557866247778, 0.31460973115385743, 0.23182784949120555, -0.4332060996374169, 0.2824695780289733, -0.7156376056080292, 0.07013416159193328, -0.4506990380867986, -0.5023741395866518, -0.7439744591576128, -0.027761669593648945, -0.6377974603421941, 0.21945560181444648, 0.15191522851248843, 0.42010399993003783, -0.22446432405913888, -0.4468500631691997, 0.26025086762344884},
    {-0.6668566303749744, -0.8296673087703155, -0.6969214684474586, -0.7100970402466121, 0.46772571488923464, -0.4792963538439842, 0.4378812116340583, -0.5701333872840868, -0.47211542014742414, -0.5981296161766777, -0.7116227090703511, 0.5250663541196869, -0.5069345381231463, -0.6665179738245006, -0.602813033503726, -0.464732227201007, -0.6017321819425708, -0.4930255102325361, -0.476731013989803, 0.016013570036341428, 0.2388122753152239, -0.349789710978797, -0.4386203839835046, -0.8044445044954671, 0.5350837509781549, -0.13189518767923983, 0.37360073739589267, 0.33320339658376097, -0.8896700216421995, -0.5776830611851028, 0.5373357344465824, 0.3126147213472585, -0.559671942871557, 0.3580444381177183, 0.04195080475103008, 0.31937243841983914, -0.529134666522625, -0.4662217339822248, -0.1526653826701318, -0.40348190993198474, 0.07477872959819615, -0.8336209779000698, -0.09743761078237263, -0.5504727905045721, -0.6443821562188271, -0.5907749829683295, 0.16128289944517712, 0.5833808756787542, 0.07191583237498256, -0.7025205722671657, 0.4525261361023415, -0.8934851376283792, 0.3140852945396266, -0.6008848895411397, -0.6887018604887848, -0.5261065840078955, -0.08602433484890773, -0.8166701069682196, 0.22339322282392216, 0.025340914518651794, 0.10385746555299653, 0.04260225281480022, -0.7940260185549605, 0.0906894123390373},
    {-0.6253655074598702, -0.8421017290365198, -0.7511104282668204, -0.2737920760860145, 0.49412147267162637, -0.6419089991231745, 0.36690840920577683, -0.561649462473503, -0.6851255367947858, -0.5850104429320147, -0.6624252421538671, 0.35626724097097784, -0.580098221243902, -0.7517480864731984, -0.8120318318072322, -0.6727721310175652, -0.32550183995563203, -0.45285733353138613, -0.470158540250919, -0.16136837422405953, 0.6636018299182871, -0.2782903327587874, -0.653655894310022, -0.5700654527596899, 0.4606723212395805, 0.02135086639768249, 0.5267956545636721, 0.7082681097011512, -0.9064917721107769, -0.6718925496325683, 0.4419475043346417, 0.6616332808066314, -0.4380383441098909, 0.42632279281011504, 0.323363699636297, 0.34342962809305744, -0.3990322129363067, -0.5502342514196712, -0.3529115638867875, -0.3659327587867224, 0.09545832055123447, -0.8787347037401845, 0.12227487266443411, -0.5375368826293809, -0.9176637207378223, -0.48102552220239225, 0.24555040608868, 0.3965622804880684, 0.37292302677033534, -0.7607353219901452, 0.5738008898859361, -0.7885510639767995, 0.20341411454050276, -0.5613838731671541, -0.6950521570833306, -0.7538236681678646, -0.14733477778297188, -0.7094693859569737, 0.18932842499161567, 0.14490891467589628, 0.25551798725447195, 0.16654289303308756, -0.8570281193553154, 0.09588250351622198},
    {-0.5914373872428982, -0.699608366537608, -0.5806105706444586, -0.45905635821194996, 0.6601419574586062, -0.3880730818020281, 0.29809096974437743, -0.7656730907755728, -0.645839062802869, -0.21529297208309006, -0.5364345197581099, 0.05267083782155245, -0.6609345331175379, -0.5760346054943604, -0.7956035701389436, -0.7798211420360984, -0.44914778696957697, -0.24303905093367412, -0.5357677179388939, -0.04319283487662549, 0.33908948596456423, -0.5203550071660155, -0.4664746589633927, -0.743708622922646, 0.5977631436933354, -0.018496756819408926, 0.5062164684825519, 0.732828410131169, -0.9043873961520131, -0.6341934064724709, 0.526631225844907, 0.6499759535298814, -0.635112855921401, 0.628597733253469, 0.2584547075835519, 0.36921263950676164, -0.44199203687990757, -0.4614365184152698, -0.3265046234746658, -0.08774663974992664, -0.1807695713195353, -0.780158817582325, -0.10925991937821428, -0.6853238589559579, -0.8780271008289557, -0.6815084930477964, 0.2444993320766233, 0.3807869742273832, 0.2752471896461893, -0.7095997383019599, 0.6936802366376047, -0.6907608066320703, 0.33122692140449345, -0.5314001490298507, -0.5599463782261196, -0.5381779139984475, 0.10451307313903814, -0.529645314459285, 0.3148973280884037, 0.20885926547301398, 0.4394203066608768, 0.019183061520380407, -0.6547941152929877, 0.36493946502927277},
    {-0.7966389097743957, -0.5629009943517035, -0.6755404986952191, -0.28572468645831756, 0.07601991084009996, -0.7859303033460213, 0.31325931192867396, -0.5633499665682361, -0.35634908857215203, -0.4385488452403128, -0.8291252636590828, -0.29336490452462266, -0.4661404365208823, -0.4713106647422176, -0.6949888516358053, -0.6418778651310539, -0.3938497902279098, -0.5651557197960916, -0.8078054559924304, -0.13522904354677476, 0.19285896356412988, -0.21223331743554524, -0.48731379279918036, -0.6874234391375925, 0.23573813396811857, -0.12106630631122667, 0.5841986680319445, 0.49303995118895483, -0.6931003600863406, -0.48568560247222414, 0.5318703871083604, 0.5754448123329752, -0.5804225548781486, 0.48496234408073136, 0.11759554029123684, 0.4463748027429424, -0.5461545202978758, -0.3185832448682214, -0.5177301981360417, -0.4704817737027697, -0.4778115588975083, -0.5920619278473139, 0.05719220102495072, -0.7819036328320292, -0.6035550125441121, -0.8096078597498414, -0.06816745653248482, 0.07248953210215664, -0.1604159801227372, -0.43776845170444706, 0.5669863251090588, -0.7957207194900131, 0.35190587072095925, -0.7024146691745176, -0.7540458153304688, -0.7341548522420839, 0.014692727058453873, -0.527192170467362, 0.20517607734972446, 0.10350110231826815, 0.3575230888663295, -0.06467887060286809, -0.879624263110258, -0.10256009834552937},
    {-0.8663703418806146, -0.6328459721490657, -0.4809186150860421, -0.26416568456303324, 0.016398038215260476, -0.8596627633915982, 0.28031919830011515, -0.5995745621955761, -0.6279143304288999, -0.6589030980477666, -0.7130197557364476, -0.26814386279193914, -0.6275295375893603, -0.6241832808124367, -0.7319033431064144, -0.7552137417032686, -0.4878657255617122, -0.489876573273879, -0.7300567777327606, -0.3500652892226059, 0.12158245812985807, -0.32465116883047135, -0.6866438643247241, -0.5940819646886828, 0.06746410576289713, -0.04688841559055293, 0.3343611270482834, 0.5694079200726795, -0.6938259435916703, -0.6565774417189727, 0.4759752057269282, 0.5015639321606777, -0.40272108923718136, 0.39875958667398925, 0.0013255300671148158, 0.2535623551672238, -0.6760739946513428, -0.6210923871943832, -0.7521472757023521, -0.2319854822134248, -0.3080400003570822, -0.467671326277214, -0.03275674906335348, -0.6058364058726506, -0.746835981440798, -0.5611757711056862, 0.09279534526415298, -0.24982461648884943, 0.15049745965496863, -0.5121810128267965, 0.2318007155731839, -0.7875581673074024, 0.006721083647379277, -0.5437647491786007, -0.4943688263268776, -0.5954573659412767, -0.23784786113862685, -0.5058498545494419, 0.2644905269552445, -0.010677854344447159, 0.43008689903142566, -0.24738448983875286, -0.6319400501120208, -0.03593368834043056},
    {-0.6860342123859742, -0.6095772225586321, -0.6424189436163606, -0.27816306543820263, -0.10371406924060052, -0.6093600889159886, 0.22385903235122367, -0.5294809570850411, -0.4132202138078832, -0.5069196511628616, -0.7913286927538353, -0.18396225778476505, -0.5120341364178543, -0.6020433393017307, -0.5471626896887076, -0.47757835781163677, -0.5690767871429394, -0.37488457609680875, -0.5595684932356231, -0.12929904692846764, 0.1784951054039326, -0.2858864251992992, -0.36382735515628717, -0.4428978380052423, 0.16241166065410742, 0.10057542506184251, 0.5456581169199181, 0.6472129251339347, -0.7276811976757254, -0.64515069805026, 0.29193924552550027, 0.31680823063602404, -0.5412591060953774, 0.3216351963898608, -0.08846189081922567, 0.120894555335876, -0.42581631454756774, -0.37692915577709263, -0.7286733443278347, -0.5173702587399307, -0.5939970543208826, -0.6072643927336431, -0.1430080654336693, -0.5834811699630132, -0.7362761683328466, -0.6412414515176607, 0.10831907435522638, -0.02399447155183404, 0.18304446311955572, -0.47222334889890005, 0.42444818553288083, -0.8518784788179469, 0.29058410781148086, -0.6686864338563309, -0.7687792277704627, -0.7009316266330535, -0.15657747458968233, -0.5105616504038214, 0.2583466637265169, 0.1578927467179242, 0.52845992826094, -0.12364055015901428, -0.843735047611928, 0.012795012408099424},
    {-0.7061287757775798, -0.7677682467926407, -0.5630449040061763, -0.6311486146231924, 0.1617776281377441, -0.7468030695719049, 0.19454965526103962, -0.8032642052179775, -0.6686396930656392, -0.3586826166338794, -0.5991816185702067, -0.19591932436808682, -0.6556948027003713, -0.533464224040027, -0.814884791454263, -0.530122147434902, -0.45431800522635046, -0.25250753626427075, -0.5604215928097345, -0.006188323717093993, 0.18500725111077468, -0.30400463468731553, -0.5823285278717556, -0.6247381510682412, 0.16618484242607728, -0.11169343520670434, 0.6117732565291739, 0.42296235646193636, -0.7746684961934298, -0.8015973647139372, 0.5460091135030043, 0.5460703566903017, -0.3672071745044313, 0.18853161390029322, 0.1603040346093518, 0.13769877994214022, -0.5665309539645064, -0.5114017485238952, -0.451905153251666, -0.3041398835264893, -0.5311346329572757, -0.7937742217042106, -0.028187757797994633, -0.8517326065101889, -0.6222207563764729, -0.5426094177406388, 0.13028431109726785, 0.09352528958652237, -0.03376730230987298, -0.6655982346448992, 0.389650128431695, -0.7107134832202435, 0.33017035440725384, -0.46918301964098996, -0.7243811881926917, -0.5472377235475641, -0.17341677870253608, -0.5680970915973643, 0.2788953590756644, 0.1169973569657056, 0.44638266659754017, -0.08542644847353836, -0.515972320802292, -0.17727494678074235},
    {-0.8221504004052277, -0.6771312543554394, -0.5450709095843667, -0.40864802261201094, 0.39538613333563266, -0.6057962378088273, 0.29973313940216373, -0.7634486342327446, -0.4055695215711293, -0.2154435998649323, -0.49303005324199217, -0.01771942383747619, -0.5193491880090183, -0.5302901856628518, -0.7608373947338806, -0.43853470458151683, -0.4760224610864395, -0.3421828782719268, -0.6530092645551364, 0.05202615877571672, 0.3452353063088792, -0.33724258697874476, -0.3506287179784145, -0.4453443735387558, 0.4013584125865179, 0.04601382882463763, 0.7527508876516217, 0.7611976640426578, -0.7610949087792097, -0.4485754624532201, 0.5476752972680646, 0.5726680523531216, -0.25267148593470923, 0.4676471457554849, 0.10827006614663735, 0.18603133979716321, -0.4511720725088814, -0.39584146605149284, -0.44071586556722747, -0.07043579743428376, -0.21181792959172976, -0.8017281359149931, 0.027809831459999174, -0.6804952977360947, -0.5924482663616931, -0.41045283639461966, 0.18169465825071865, 0.13442595390415904, 0.40755453050552, -0.7832907679985452, 0.41084764068203, -0.5394383446146148, 0.25481461138243766, -0.6023013954844341, -0.7420075811971184, -0.7044974669625919, 0.10801159511980485, -0.8225073025987321, 0.24509307120787857, 0.08234341262807031, 0.6466529186748441, -0.05484468654229626, -0.7778347358994115, 0.05062721195132958},
    {-0.5005682594780413, -0.6727014241089109, -0.5493783372522152, -0.26501602444845784, 0.7384039666740209, -0.4631100951675796, 0.3494893771443193, -0.6125438175009522, -0.5860548724287321, -0.39309599239601417, -0.5537302324335587, 0.41826876792325524, -0.339505795467109, -0.363753441702965, -0.5501363193221492, -0.6809836616170799, -0.36356866316710507, -0.11006871092425938, -0.6064234486156381, 0.10867069169126525, 0.7642531298673091, -0.15574707920234324, -0.5004354604495066, -0.669987504328859, 0.37669856253691913, 0.21090052175186358, 0.5136179575569737, 0.5035717189562866, -0.8398064416790064, -0.5376969040344295, 0.684862638511525, 0.7654935583553734, -0.4941713591441294, 0.6350509308644824, 0.341945940300597, 0.2997867853337276, -0.5742702872900644, -0.33526553723738284, -0.47839561616436543, 0.010461120327647462, -0.2752022581335051, -0.6193588718837548, 0.04331101069548624, -0.5490154082275028, -0.7177813307798684, -0.7066234301753745, 0.1501386712878611, 0.48551206831787325, 0.35726970416846077, -0.7316637933528942, 0.7624227834730729, -0.7731908663919226, 0.310750004891548, -0.4107502554891775, -0.417481116144633, -0.6251166526552198, 0.24396953115232, -0.808018263628106, 0.6440321550810553, 0.09563639722809267, 0.7064386408303123, 0.21282184753153502, -0.5515501848532066, 0.10564877310371418},
    {-0.45847137374810454, -0.6865898201124402, -0.4174084347179183, -0.3887137822855808, 0.6327504861715861, -0.22928741703757233, 0.5432146248904479, -0.7545086906549652, -0.28235487943380766, -0.193066349017777, -0.5654463463962627, 0.5450208629661711, -0.45808855335784393, -0.48489308254730823, -0.7049721101075189, -0.5412386403065368, -0.4978645413825701, -0.04465295158279716, -0.4066562152653617, 0.2244625620549193, 0.7918334771982968, -0.34565013380186865, -0.35831284418714415, -0.39791469803566054, 0.8078949606449481, 0.34738349304542254, 0.7074890304685953, 0.7870482726748538, -0.6396224974843727, -0.417503002914673, 0.8017265737832415, 0.6280926924737764, -0.3575050596807973, 0.753343583832886, 0.678841172764532, 0.6109998648848134, -0.46679629459222793, -0.20448103332891776, -0.4132233528709847, -0.23959385214854073, -0.38164527775202284, -0.5748264001160674, 0.07018040689491267, -0.5090252639414239, -0.7864586950545839, -0.4388934882304978, 0.3560407347361474, 0.5743590443307538, 0.5038923996458441, -0.4341071496193924, 0.7347305576058154, -0.7681716429148011, 0.40813906746110806, -0.5192876244510286, -0.5575168888333284, -0.3130575379347436, 0.26032153234205885, -0.8222399926271423, 0.5412127559863027, 0.21511778365201117, 0.827713217457468, 0.40895531206955754, -0.6970796343999905, 0.28805965390184907},
    {-0.5326084488491922, -0.6495924027760946, -0.6045162095080744, -0.4300711886943099, 0.9093217315959975, -0.46149153663765213, 0.6882304966654138, -0.538115068753378, -0.38837908979908625, -0.19621859937785655, -0.7975248858846881, 0.5611727108282589, -0.2226039261869259, -0.4133572525873309, -0.6627084918562857, -0.4634490761156242, -0.27656439339053873, -0.09095601620029581, -0.2542804645690939, 0.10580601165812169, 0.7807680259730962, -0.3049295806612263, -0.49721150777167006, -0.6360317678185022, 0.7842646972041808, 0.07370551338975262, 0.9068254334990744, 0.8231952556979019, -0.5005662666517666, -0.3875211232484987, 0.6886329396435743, 0.9201447073010511, -0.16233315044840313, 0.5018276038747943, 0.6462010324627715, 0.6018361504424649, -0.47190672592826954, -0.42439798549954033, -0.2463619975036095, -0.18259252094116477, -0.08649558177537953, -0.611334816026256, 0.10514652794503443, -0.5322388391308887, -0.49865367405440736, -0.48709960520014445, 0.3676573439143362, 0.9159757670822378, 0.9121492722924494, -0.6433649786667257, 0.7942549805624911, -0.7143107355999063, 0.678287801932204, -0.6456188670629587, -0.3802745925185205, -0.3295343677017878, 0.3433497950991312, -0.726464261609246, 0.5672913992695338, 0.3259439398596629, 0.8325943326166233, 0.1242848742585118, -0.6181395715170513, 0.3227998915366306},
    {-0.3199059724224337, -0.5443052952766235, -0.5006995223925647, -0.46118101993866223, 0.7789894101178962, -0.47865974711913395, 0.46802184564855553, -0.6779142931501698, -0.33121608957913223, -0.04811508093070005, -0.8373819429938907, 0.5573544918571999, -0.49445955796404334, -0.47926161508199905, -0.44869494937701204, -0.5076038770512351, -0.3006634370158914, -0.47112128011546195, -0.4968309856285903, -0.09847312788931527, 0.7794556318705039, -0.2823026200493415, -0.6499878142358357, -0.29632952162094406, 0.7028587112170779, 0.033312358542837574, 0.806931495798034, 0.7327511078315836, -0.6229841423648, -0.739808173693656, 0.8152339186669898, 0.7766348405635223, -0.20656684335542327, 0.6228693551103082, 0.5310261262243667, 0.5680727263953745, -0.6210314817517387, -0.6308308494338357, -0.2365053241262983, -0.3902739492261197, -0.163788177722062, -0.7532255269600535, -0.18812500518613134, -0.6562234408160814, -0.5268349026250165, -0.4779321413008624, 0.29973959480593326, 0.9017187024754341, 0.8906839558639433, -0.6802689648983073, 0.8510628707571745, -0.6244537021699208, 0.6368794673030983, -0.6144111019935189, -0.7358183416611301, -0.35328069631865133, 0.006011329396952268, -0.656704819026777, 0.6994293449938969, 0.32732736373921156, 0.6291944680276126, 0.24247073532451438, -0.4871077935919548, 0.3970222461671208},
    {-0.6947115294880782, -0.6030521856166771, -0.6458368641348305, -0.34369358314171844, 0.6491453970654708, -0.668117910627912, 0.6008428068980731, -0.722137268474689, -0.6051800497297324, -0.09058904173058772, -0.6810968177274571, 0.39705672449700924, -0.44126442637962326, -0.6018224050672789, -0.4764986374086288, -0.4864065104505281, -0.3959524062800016, -0.13071952528608408, -0.36174277866218874, 0.10275541723954533, 0.5485450656192017, -0.4896103733342517, -0.43349887710751406, -0.6042657508695776, 0.5684737172663772, -0.10017041590824723, 0.7535293015086618, 0.5963635701466342, -0.7365344218363684, -0.5302523755348058, 0.5623301174668808, 0.8451242533712349, -0.26832453681642293, 0.4987009907179099, 0.17981249421246626, 0.5520283195226694, -0.3943937080766343, -0.6077579104749787, -0.5699734502582948, -0.26924971386877317, -0.08063133910116244, -0.6442844961477059, -0.055550657748835996, -0.709613802737344, -0.784987852593941, -0.5148047887434505, 0.48341697983011805, 0.5045219468213077, 0.6158222737820661, -0.7575487785410487, 0.5829862376103158, -0.9131512872096192, 0.6788344231132135, -0.5741310635620692, -0.6585137725060358, -0.38708522044184, 0.05805573843335301, -0.6440870242476944, 0.3917034565464996, 0.15446380011057356, 0.6190509555252203, 0.1853539091760014, -0.6620852670591548, 0.18422482411455904},
    {-0.7239264692129331, -0.59280814196812, -0.6882368302848242, -0.45790661532945137, 0.5165552955632597, -0.663115138570798, 0.5584868638951345, -0.6723870781689374, -0.5050200776135904, -0.15675297893534584, -0.5803788908505669, 0.21302056208045664, -0.6146963813746624, -0.49916476337820664, -0.4245816577204921, -0.6498787175798547, -0.4865528124600384, -0.22689523294862346, -0.3199920342762134, 0.1318944531330384, 0.7738287515125298, -0.07793087129389123, -0.49343710408368163, -0.43820484756585, 0.45809952579354474, 0.11048994446677717, 0.6554679355472408, 0.8419496548279468, -0.7845556023936485, -0.6653272172259985, 0.7897651421330383, 0.9078963776170392, -0.224940903915484, 0.5182182845831174, 0.36580897921866606, 0.5684138121549134, -0.40713172730255237, -0.23549188270634808, -0.755992908862447, -0.10044504363864003, -0.39086454807492194, -0.46745438929508937, 0.16805830939134406, -0.5639076965876517, -0.7368405768023993, -0.6387914608041491, 0.3049658655317417, 0.46744729366043625, 0.7619055235625649, -0.6142005109083896, 0.5487278325816111, -0.8751513412261069, 0.378765358013682, -0.5736146045467198, -0.6931185691787506, -0.41954282944410254, 0.02498602339063978, -0.8163638216042997, 0.7485025815470119, 0.40114993701205254, 0.7608696789970748, 0.3910229571200136, -0.583153129188159, 0.4215928361205423},
    {-0.6796622743707882, -0.43258601707447086, -0.6281364752251434, -0.20480584199559865, 0.7753199525417026, -0.33400514965260214, 0.7286763521171955, -0.4035198038595002, -0.2254887766898594, 0.14355468966433285, -0.47618993357325873, 0.2902280499810112, -0.2677306767170625, -0.4850466978705782, -0.6580241365875793, -0.38601595497958974, -0.11552143219173729, -0.19756160506182155, -0.5669255391000615, 0.4349955599749681, 0.5709106545610204, -0.23515496033905697, -0.1749432568215793, -0.5874552605194748, 0.8444461549211343, 0.4012943072134296, 0.9741370413296428, 0.6842276640807959, -0.7177956308989811, -0.43441291179707825, 0.9071582482205498, 0.902572035116911, -0.19813983947316735, 0.7934463960034148, 0.6345906499890371, 0.7225407688943518, -0.5346914893412534, -0.1709472136474785, -0.3038194544823899, 0.028732306390029817, -0.18945705369987378, -0.5619880753859083, -0.0167829678440294, -0.7245452816073379, -0.48435592846142034, -0.5006798412620059, 0.4500838547793315, 0.9064683682109667, 0.8959099109343132, -0.5215599241838721, 0.8549897263779854, -0.5580335105691947, 0.7501748192606971, -0.5022801872021867, -0.45503004181865725, -0.2638795422237919, 0.2631361968850068, -0.7474801613338689, 0.8462725463704905, 0.48170582181133825, 0.8093844239357576, 0.3820859020597328, -0.6234902148770335, 0.34321013006271106},
    {-0.3834835193101808, -0.4555684229158425, -0.3064409814552732, -0.38193454181900105, 0.9786864543846407, -0.08475660099551047, 0.5496366522965982, -0.5415408864980313, -0.3870070617208405, 0.032725432362685394, -0.4818096390368091, 0.3186650754764166, -0.13577957645357175, -0.539682375393178, -0.38972536317171314, -0.30837978354248324, -0.1373923053174943, -0.4592558122747001, -0.540329867460267, 0.425057177189222, 0.9094330139078151, -0.3030283673963742, -0.11917619766586697, -0.5131365317035205, 0.6779967444101024, 0.19812908127287093, 0.9976188773017669, 0.8649533619381821, -0.5676651039278324, -0.5588873821363775, 0.6752845911490737, 0.9133003696318076, -0.2213023317399311, 0.87343035324136, 0.5982141849535774, 0.5805826518726732, -0.2859542676088623, -0.48378370458409087, -0.3230520873319826, 0.10195721633280472, 0.1419328660887263, -0.5600160763851173, 0.32650561134756917, -0.6417581295679378, -0.4455420148611502, -0.4861745248609178, 0.6423087169965714, 0.9252477052848648, 0.9026695214455859, -0.4850469832071201, 0.9499461922696452, -0.733935268661193, 0.8067176726844224, -0.4767140971202679, -0.4212579111900416, -0.3802498086707185, 0.26940660655159415, -0.5686405111485401, 0.8639967836125899, 0.4908965140094589, 0.5706788129774097, 0.34290672891090535, -0.5560158008243323, 0.5544647154319804},
    {-0.6790028798911484, -0.46529453255139863, -0.3115502436509824, -0.3547626810659071, 0.9027201554693306, -0.506685582061616, 0.445241278451049, -0.644030565664341, -0.5435201431453363, 0.053003266653694994, -0.5492068936117968, 0.4210067981707256, -0.24515239643517134, -0.6172075683138124, -0.6654293199703721, -0.7234999807131889, -0.1535812206526529, -0.23390642450158483, -0.6180787455425399, 0.3810999800202103, 0.6066643730018559, -0.34172176823140776, -0.3059606403253754, -0.31296034284802215, 0.7772774179674521, 0.3050714545786616, 0.850521657690703, 0.8109775372514579, -0.7121612961088043, -0.6485407680719766, 0.8673065829118278, 0.663099114796884, -0.14554616402593817, 0.8626673952005326, 0.7335316027307175, 0.4231249965781668, -0.30469716821784454, -0.3227176631681206, -0.4289396934864728, 0.11306776351343802, -0.2583703559549884, -0.37527157924118143, 0.2345980635061808, -0.7019502700806004, -0.7107363489476809, -0.59277540082988, 0.4641549433964958, 0.7597234519229573, 0.7012164742912921, -0.5094653293637219, 0.8778095529631808, -0.8383686925363196, 0.7767937766248861, -0.6353464381249981, -0.37885005448526293, -0.47729904833025133, 0.2823860024333198, -0.5200854060895901, 0.8281039058028316, 0.5442494133954258, 0.7036503097073138, 0.19556261226857544, -0.7144993053507898, 0.5056303030437698},
    {-0.5043027337380015, -0.668562186912453, -0.382699396493797, -0.432782239654972, 0.6876892805210194, -0.42577895485668715, 0.6733197065365375, -0.6421851097743642, -0.20489258184475245, 0.1061967452806553, -0.8135404919740981, 0.10192518235782323, -0.5073261333040956, -0.5516961172592401, -0.6420947914770098, -0.7441709237527689, -0.2792548476089269, -0.36972114374246257, -0.43550186066186397, 0.07915919869082533, 0.5999770636210748, -0.2578449634216876, -0.5548666321862786, -0.5371165491070753, 0.5283690056965158, 0.2356629047361272, 0.7603513243675949, 0.5530032514488882, -0.7776350311301754, -0.41623389721011383, 0.5941283434340053, 0.8124248059769348, 0.010797564474322525, 0.8146678577650411, 0.6455294912742557, 0.6727650600625563, -0.1864347193692111, -0.4589258549461939, -0.7209527234381584, -0.11364069135881692, -0.5775694006772324, -0.5871151436380339, -0.0004366788274073622, -0.8316778147626528, -0.6480659973248417, -0.6380203535938145, 0.47882271931398146, 0.7206378885148733, 0.5541397306892604, -0.471779037651734, 0.5997634137430343, -0.5439331531304866, 0.7325640932523071, -0.31879788833302264, -0.6394250072953767, -0.39828398950739136, 0.20996404034164579, -0.5875982210403479, 0.8384023832792955, 0.4532308150851398, 0.8003085903066213, 0.1979686332041902, -0.5913006346324864, 0.4793192986331091},
    {-0.49645419791383805, -0.4078910507791638, -0.5728701314616819, -0.24415195171134962, 0.7580771891269402, -0.5760309766338237, 0.5277665111935596, -0.5583788555269724, -0.3559924050793341, -0.05319069994543598, -0.5112823690913206, 0.17338286062953068, -0.39798205138431386, -0.6264093942845133, -0.5618675587499273, -0.4602972283707579, -0.3504310736129698, -0.3891635383463838, -0.5223333919772474, 0.3019726344824608, 0.5583360092278653, -0.2730943484050632, -0.4728230754521753, -0.5690950234277407, 0.8408919833759725, 0.18141820637206602, 0.6267013216006531, 0.7129800159736593, -0.5255868861387248, -0.5432722792039417, 0.7661340251640686, 0.7249072664929351, -0.1246193813717998, 0.7141823398618578, 0.5524382191395653, 0.5439673345938771, -0.42838369455088743, -0.568715092789305, -0.5897313437185449, -0.22938838902587344, -0.47531814100794156, -0.7074823746369434, -0.14399180561457942, -0.6399063950524314, -0.7976987817540923, -0.44145808511760287, 0.40909877918496335, 0.583392621514073, 0.7691520435599746, -0.45323914852037395, 0.6735549001675752, -0.8276435046447812, 0.33844147811423825, -0.3780784258586211, -0.42191827655106307, -0.38933994779987136, -0.05543142231133361, -0.46254180586597304, 0.6998079114820814, 0.37609244361635435, 0.6221582238121661, 0.017471819955628486, -0.5081317518505568, 0.26711451833932937},
    {-0.6949882927974239, -0.4426177914256381, -0.5832102814074652, -0.48174492252688983, 0.6998633967114005, -0.2214645136978539, 0.5644922633712918, -0.7873826391093272, -0.3497821631304002, -0.03537308291080198, -0.7314680876998124, 0.17672920609813192, -0.3483522217362874, -0.4159621195794458, -0.508266118214395, -0.4258491263816217, -0.3053258135926493, -0.340855337373611, -0.47035576196707013, 0.36400659704842886, 0.6578303229678414, -0.20827676857467747, -0.5528608830358946, -0.4128001332449827, 0.6950668237652687, 0.12413342797897944, 0.8477014105872271, 0.6363738260153394, -0.599613767079979, -0.39960899384030446, 0.7798450662631782, 0.7232374421398687, -0.23199398203975077, 0.7975809185447673, 0.5835598787640197, 0.5581900644276003, -0.3598002858336277, -0.5094690069581492, -0.5245371029716298, -0.09451313734899007, -0.22570278906424027, -0.6890978869506414, -0.03227535663240045, -0.8258118822387046, -0.6428918914847795, -0.6378399663673245, 0.27133093701871686, 0.8215929831989344, 0.6245162712824227, -0.5710134725359547, 0.7642991494527083, -0.699588761968854, 0.41091140326597375, -0.3254625753206177, -0.4831532809654675, -0.47555657913972144, 0.12237077392808451, -0.7817930540639239, 0.559189469277588, 0.30465363874336376, 0.8501574939389254, 0.4502817684572258, -0.4897083643804252, 0.36539946710265614},
    {-0.44330715832268075, -0.6107153047779832, -0.5527770196895806, -0.47712462752806556, 0.9214472997936731, -0.28205806511005804, 0.6900293090660631, -0.6733329761733273, -0.38555022718282167, -0.030527814648444673, -0.6527096242761034, 0.3338410137896441, -0.5324200840408261, -0.6362305526193722, -0.43818445090746044, -0.7388250342984474, -0.37010198780017667, -0.3438463800227392, -0.5580935753890327, 0.40624529873882037, 0.7946963597064483, -0.26558122285096375, -0.24919461947480986, -0.39617289699977604, 0.6388332729135198, 0.31501479952630235, 0.6625583931740131, 0.7961201671533216, -0.7291864606140089, -0.6556709663286541, 0.720471509080254, 0.966790199291442, -0.33811369129963587, 0.6769901149791165, 0.6912585864794414, 0.7153176515946882, -0.521633021466917, -0.5443552755143488, -0.6319250504112457, -0.2768272831290418, -0.13114567447680506, -0.6373981539507891, -0.00838441664472374, -0.6249718510486385, -0.7559323045786118, -0.3067098602684849, 0.43976787014791113, 0.5760559093597473, 0.7557809234993248, -0.35201798004964524, 0.9325997934781352, -0.7270292199494316, 0.7495687949828955, -0.31389888907760255, -0.43781837305866406, -0.3147766805746608, 0.031883300305493065, -0.7201828491708867, 0.6382638692833109, 0.3113225508916258, 0.6920890606478736, 0.38842763022350835, -0.588628531856824, 0.5391454637364459},
    {-0.49941652908053286, -0.460106256356709, -0.5149604138780959, -0.39890609482198525, 0.504150043155603, -0.4119408513470212, 0.6111910500919804, -0.6771190424058168, -0.2219172481345689, -0.23176548873722166, -0.7573876992325972, 0.16904600652945637, -0.37045248185281, -0.39305520793873344, -0.38297026889009833, -0.566551926808392, -0.3149293555196852, -0.0804874802164704, -0.6100737418965464, 0.39144333236014595, 0.6808185297770087, -0.11891522479444366, -0.29746519049906583, -0.4731725249523451, 0.7746221915074113, 0.05746016407778664, 0.7772767649945697, 0.6021427260966377, -0.7848164293182722, -0.5300095274987715, 0.7190686124491421, 0.8782182907563577, -0.3371055685175881, 0.5383502827702678, 0.5739211328507082, 0.6168197294280624, -0.5665450439902118, -0.32586193381259554, -0.5683047835700462, -0.025099650255294852, -0.5627535369308094, -0.3852564268746207, 0.09894428861855908, -0.7312767244089474, -0.483086987711415, -0.5626690262552019, 0.3769728283958655, 0.5537458673679398, 0.7484519892401401, -0.41983822230852463, 0.8135375381208724, -0.8022882391058132, 0.7282993027052621, -0.42715346104849916, -0.32573761238889626, -0.6272211898304999, 0.29527883406686783, -0.5237539192772132, 0.8046901850000017, 0.3918198891702027, 0.7304101270313966, 0.277458102788503, -0.6152797384928463, 0.4427380532071771},
    {-0.6199697471044693, -0.36572009449210047, -0.5390755331145707, -0.12435780248697852, 0.5254308053246618, -0.3915431168029451, 0.4530119322100728, -0.4611517625256309, -0.42491857331055405, -0.15238332017884504, -0.6530394307403553, 0.3404178017034953, -0.27650204049509053, -0.41587959237996325, -0.5489842413526769, -0.49248041566245226, -0.2660857342517725, -0.10074229101914776, -0.3893970810404891, 0.29880038707373535, 0.853276812915416, -0.09261650639602753, -0.3873362586930481, -0.2755491002219468, 0.6558336556226803, 0.38204993951417043, 0.945759517476629, 0.5877371856049833, -0.5178856780570086, -0.5091091330940646, 0.7921050303215861, 0.7377122030953783, 0.03343894630454199, 0.7764590996645566, 0.35357506554532947, 0.6796061048626583, -0.13846061891867062, -0.10704739101731651, -0.5526094394806351, 0.06097019503704624, -0.6213613893767171, -0.6285740993087566, 0.30063389640646165, -0.7954637888083808, -0.7404869331365904, -0.585568481996022, 0.3931928466426647, 0.4937961965242883, 0.6517439418348552, -0.3079038958222116, 0.8567940263234619, -0.6066340968304036, 0.5179472101056315, -0.33815441956450937, -0.3639645414409502, -0.5476079575747723, 0.06281374609186291, -0.6529161603584203, 0.8660333332170382, 0.32317978588463336, 0.7098291061290554, 0.37315920562551114, -0.6662301166664902, 0.397519825829317},
    {-0.41486573081723344, -0.3575218315382266, -0.6356470609069083, -0.4292859666448992, -0.6488377429473198, -0.6687269330430917, -0.4660045348320589, -0.6020718039518195, -0.542824675661886, -0.38840438117603737, -0.29700779003990513, -0.13731624864877523, -0.12006748943010673, -0.3078519777802353, -0.5552753067094875, 0.14498261622021652, -0.25505614513551855, -0.1747901168722998, -0.12199648742334215, -0.6095456439851757, -0.5427974956560763, -0.4785647524651993, -0.6560331716618945, 0.14652387427186053, -0.5228047383736689, -0.3788885756993754, -0.6895085799628536, 0.024780433745952037, -0.03452970040748347, -0.2308810178340464, -0.7245017076482573, -0.316074422341806, -0.6346071534014597, -0.39419720962284344, -0.22184308978377668, -0.5397714394167843, -0.4416892694087808, -0.6782998337800827, -0.2168814212145928, -0.5405600546868157, -0.1772980294491322, -0.5232960700595215, -0.7015770461696538, -0.3779004857533409, -0.2866800365486971, -0.44250997227684546, -0.7211867877845352, -0.4586949443474304, -0.11183721256752056, -0.4181681066257553, -0.43689564611569304, -0.18784117341711068, -0.3180097195625652, -0.07169945970030955, -0.5577748930279989, -0.5077435723942072, -0.7410432974720687, -0.35906674077369893, -0.5503657092623448, -0.46762995057845147, -0.5647302096030027, -0.664661186114082, -0.05863315765902375, -0.38295386434755885},
    {-0.42040359284197043, -0.14117727060642662, -0.614276350123603, -0.3731015437174506, 0.18115476635902752, -0.1734978674260068, 0.2767715282857294, -0.3293020243895403, -0.3561500895379654, -0.15944648221009192, -0.3499982546052809, 0.23745069649594785, -0.20507679463708262, 0.046413976041354485, -0.21387059670446926, -0.4387216219268882, 0.06503220684008687, -0.48294741800567875, -0.5907974574731083, -0.2877259094598202, 0.08393805504699309, -0.41438016077449874, -0.3395175043632168, -0.2848342676396346, 0.40098187968453586, -0.12987587380486068, 0.15566893184833006, 0.15049705549524467, -0.44803432552999073, -0.40748680894340206, 0.3945668318498478, 0.4696940111322099, -0.5255408806225901, 0.26861433785334426, 0.0554405771486152, 0.22006546219815235, -0.1419999058218964, -0.44765084451455506, -0.15751210568040871, -0.042927173563903936, 0.01262663255467093, -0.42848443918190526, -0.040718031944610315, -0.557394993002979, -0.567160510429189, -0.024228889712883592, -0.1378182222402472, 0.3072098659617997, 0.1435257864570929, -0.3113947131897805, 0.24227306829019743, -0.5300551699915794, 0.040832019593122264, -0.4978881786270421, 0.07439928762674354, -0.16025848099055348, -0.09732964522946215, -0.39467140396611594, -0.07239252524756562, 0.014976552525637246, 0.20614763402232064, -0.08290794055541928, -0.2129128596176989, 0.013330742758702805},
    {-0.27759099277775967, -0.49799988287317354, -0.45139849609063154, -0.6773317022265909, -0.03534396492834741, -0.25846198574225016, -0.45842400351366286, -0.3160122575051597, -0.4250307074702514, -0.6968384912529867, -0.329147042470159, 0.1700082893923896, -0.44332001013871775, -0.6953495079043094, -0.5928106486076942, 0.22058180339617955, -0.4414710667637498, -0.27548657733132237, -0.591791176958783, -0.7855992157396229, -0.5297998749159735, -0.7072610700553522, -0.5501133013429463, -0.3165490274817225, -0.6779541486594868, -0.5899448315718885, -0.6141082419283049, -0.17352816855553577, -0.32741918410735943, -0.745638989535712, -0.3134712576199469, -0.5385314582122527, -0.43741203593836586, -0.6227965935391441, -0.1818640418106075, -0.3748823985309191, -0.4812378727891006, -0.35960838339694295, 0.23135382023443163, -0.5126678030220343, 0.3762330636454996, -0.3436525797049095, -0.5608181388419954, -0.14774236927179224, -0.5488126312805293, -0.09025057677385977, -0.33748127546439355, 0.0020605359362248026, -0.12849906144269133, -0.35165965622820894, -0.5960883039952432, -0.44760638304006706, -0.6481412024986476, -0.39971797160186456, -0.7387299096171516, -0.654960935667468, -0.7047350688189389, -0.42732142086715047, -0.5298531675345161, -0.5318260238576645, -0.5666480669021188, -0.6112558627141902, -0.31823999800472536, -0.3685538810082249},
    {-0.5950055768981437, -0.43113230414559667, -0.48219088779894387, -0.4398549931121786, -0.3682631942070329, -0.6551921539285244, -0.6408718693190765, -0.2129273573649696, -0.43880059581501235, -0.5561510408410918, 0.06621969543460299, -0.23849163897674716, -0.44633809796924323, -0.489702476605133, -0.4113693679577705, 0.07786400684816182, -0.4017788395018515, -0.5825430732955277, -0.2749505789477818, -0.6473579304120674, -0.48160371488552717, -0.3528993103487543, -0.501209045024775, -0.369834200656924, -0.7585065424576968, -0.45627129671838246, -0.6234786632986775, -0.16136670882859977, -0.4037215994457782, -0.5317757384409735, -0.25691818342901773, -0.3668504244032456, -0.6396225509899451, -0.38563579811598114, -0.05315714204732887, -0.37532313364456577, -0.19011488588374464, -0.4117909172417274, 0.1056332599085604, -0.41096355037196, 0.15580726272532996, -0.4884206487038933, -0.6408560092075498, -0.1902055033858596, 0.016153396732104253, -0.40645614347363457, -0.44614036172151783, -0.48885605683360067, -0.12442182759062156, -0.30416768930616755, -0.17018276093278706, -0.3541638290759758, -0.5984925600251194, -0.5535539619174182, -0.4911242594693916, -0.5884617105443622, -0.40140742483984054, -0.38469307477456166, -0.33305243945191226, -0.6002754142979837, -0.3931730904853093, -0.3126650512522558, -0.4563982583771343, -0.40203362550618515},
    {-0.2879856801323716, -0.6630304302318292, -0.647206841888414, -0.4947970820991482, -0.19045392752285573, -0.6115453919522895, -0.485129713989239, -0.6724274496952897, -0.6477706845849677, -0.29913101928470975, -0.4011649890756238, 0.1395056835050748, -0.446770432038733, -0.6167510424187839, -0.35484206328697426, -0.06881749900824591, -0.5565442098156824, -0.495781401999637, -0.5500652674281026, -0.24633355107778201, -0.35157795384794055, -0.6725025664295332, -0.38136819099398755, -0.5606235661716626, -0.41548129517942056, -0.5560562241964738, -0.011501011198658904, 0.1919484125186622, -0.4478229626717383, -0.5624609784727136, -0.021854888646474505, -0.06655547842610764, -0.5187634674592968, -0.4686629666826198, -0.45259613946257926, -0.13179591010743033, -0.5043121357443527, -0.6207838581336088, 0.025471268827204848, -0.6846047443846718, 0.10608329423042218, -0.7307325536035668, -0.6009588355791818, -0.5268806713023699, -0.4100468181362798, -0.3209262936909143, -0.5709608288846446, -0.11099637213175435, 0.10061402440564544, -0.5672852258035739, -0.09478768082193409, -0.7180027261448778, -0.10849953890405964, -0.5847968556012398, -0.6835519175994383, -0.49871296958558947, -0.3183353529027444, -0.7111314509759681, -0.23639973035242082, -0.47447128752138656, -0.02194166314698511, -0.3616507751705559, -0.42999639707952575, -0.2910754410505095},
    {-0.32028153649172486, -0.6679421868807867, -0.29912495005072287, -0.5843541209595486, -0.000332921199119881, -0.4848148539666204, -0.46685004762646637, -0.59504392048791, -0.47302739951073314, -0.4966498037243424, -0.3338210539991698, 0.39181539803813087, -0.2639960938307733, -0.6418109306642775, -0.47487732625768714, -0.12445282469183333, -0.4959352541952063, -0.4652560703606408, -0.4203956530876933, -0.39218955265305333, -0.15775047944167978, -0.577920358523446, -0.6109403290698621, -0.38304860216452274, -0.3694911524868976, -0.5880247487106204, -0.44589642233778837, 0.1973008248106673, -0.46164587169665927, -0.5551268740089784, -0.013424014603343292, -0.33355404366007674, -0.7385671670634654, -0.1371814791022764, -0.1690763233994855, -0.3113583193988332, -0.5908092914197467, -0.6528675020409676, -0.01907003585929437, -0.3576326204547041, 0.2827915988830929, -0.42640192448208974, -0.5083670040806776, -0.18555629916095576, -0.37241724266880866, -0.2104504172502337, -0.44565565639162985, -0.04207073404006677, -0.21184386757468668, -0.4083565583038311, -0.053537950957090796, -0.5221425194489105, -0.15158704259535039, -0.44086422489748067, -0.23162632618611387, -0.5132480323082138, -0.26244596155707095, -0.6070453448293821, -0.23234448209716907, -0.23042825956977103, -0.3700586177837437, -0.6289503606681502, -0.45186000939736, -0.0787126088336471},
    {-0.3795379645215903, -0.4899728446392849, -0.41821153530656846, -0.5740241211321286, -0.11054036349197614, -0.26473755891883805, -0.328147879464847, -0.4347851133235048, -0.6474743191651384, -0.33532997216356136, -0.4973259606763616, 0.005634541824841633, -0.49770539942933273, -0.5026171329847747, -0.7165253277436322, -0.28391479179335893, -0.3414850202761472, -0.6876860818718288, -0.7779239204934365, -0.7564404250542269, -0.23530515628710974, -0.7249463331223269, -0.6335094734901046, -0.3442102325363747, -0.474611059968477, -0.5691888072561243, -0.48653527587596834, 0.1637601868878504, -0.5327400412293745, -0.769130000241569, 0.005931056384709339, -0.04071987841849249, -0.8804374186257286, -0.3184353197571609, -0.4195655956821916, -0.22489299901862855, -0.6758964212542045, -0.49534872956983905, 0.1283660549626066, -0.33382202831196406, 0.17716672753434268, -0.661764355366803, -0.7183913908278051, -0.33948723469741354, -0.33312473182768937, -0.2001582111082242, -0.24725880483299295, -0.1696021442619137, -0.28862028356531083, -0.49395653334070444, -0.2877126384685745, -0.423219005463634, -0.22049673237603182, -0.6533378057086696, -0.5999300908021313, -0.7586937026862253, -0.6294965759377049, -0.48974620263064617, -0.6093187965752197, -0.3035679172177447, -0.5544707987210045, -0.7152031217274658, -0.6399018008708549, -0.04511351280996871},
    {-0.6253911014218467, -0.6794711637822518, -0.598477264055979, -0.5764462209169782, 0.04043710872431991, -0.4887875627688064, -0.3064411152131483, -0.5585925047145393, -0.6937153710111013, -0.4321291002173231, -0.10598733554557217, 0.2575643807141713, -0.48965861154798057, -0.7237198524043009, -0.3397105092746361, -0.0688564743843031, -0.5910986379238046, -0.45193049284457193, -0.7664299118612634, -0.6037546956538291, -0.05373525104115825, -0.5560647681537032, -0.6357301845858477, -0.47943221349350573, -0.1648752735891111, -0.44817735361670336, -0.12133078895308272, 0.11658715808516265, -0.527175231564014, -0.5582871465646161, 0.02711291172011574, -0.17817880130096217, -0.5505604187903352, -0.5597197865830337, -0.6072748373402338, -0.40626779460558404, -0.6941197434030313, -0.5838318206549706, -0.04039458948262216, -0.4484244463694735, 0.2420377656117646, -0.7136136644430193, -0.48334093065707084, -0.4932077078614178, -0.2912171296220266, -0.27535861296173836, -0.45364738729848725, -0.10326114428214458, -0.34572652513993846, -0.7854467924905822, -0.004260910589076177, -0.3734472024980306, -0.30784872345048636, -0.7165166549020549, -0.7217686392908865, -0.29943695637655643, -0.6642645638538384, -0.7029654906438755, -0.3060273786648116, -0.5773395315858285, -0.21049026442050292, -0.35397171085838164, -0.4725468234500436, -0.280668332821691},
    {-0.37920518356410626, -0.37364521937416817, -0.7282096472067022, -0.495761691957918, 0.04722557243308075, -0.5129019656187641, -0.31202441449695734, -0.7081249057583636, -0.32036724424950974, -0.6090315229453633, -0.39722211184811207, 0.41377125751592214, -0.6886309409734828, -0.6352270777776542, -0.522073391338155, 0.02989633221016071, -0.3174353274336716, -0.5101969412186661, -0.7172231173902953, -0.7049357700707475, -0.10924122907943833, -0.7475347907046169, -0.42454685829353134, -0.4577514994209447, -0.12238343672421186, -0.6824658629625747, -0.18292247267939896, -0.02300213338320469, -0.5517174182577221, -0.502346823545144, -0.03648412325131056, 0.02761352907741137, -0.7978280315441659, -0.2116665460953843, -0.4924656503923373, -0.4681326023439619, -0.6901976821934188, -0.3197284214638114, 0.24616995594385824, -0.49189023347200483, 0.48171336982795504, -0.8000396719242369, -0.3405902503760646, -0.29697922441549146, -0.4296593029914805, -0.1358568326858817, -0.4912223375745336, 0.17581651492333894, -0.3650436518038333, -0.40962760575036783, 0.053831494434823345, -0.48867523142540525, -0.4631991629328634, -0.5482083785942227, -0.635537889758722, -0.6555694786526324, -0.43216442075897493, -0.45359116156841106, -0.4268686599819634, -0.551585948614341, -0.3813421461660244, -0.5261618110237837, -0.32287156034904096, -0.25499296296401547},
    {-0.5376705188070268, -0.7498084517879532, -0.7784417248183632, -0.4345119348015994, 0.22180874558080382, -0.5563238644226269, -0.4468551115946398, -0.6543541638604234, -0.38154949289564993, -0.5518426238128503, -0.6953056978297604, 0.3558017645791855, -0.699719331254762, -0.7417458013571125, -0.729082062323723, -0.2896279056184809, -0.5703477049928541, -0.39678319811550244, -0.4453008575508404, -0.5231999973865962, -0.21370051704666163, -0.7005044972894712, -0.4385246147018349, -0.5740092737796086, -0.08295167041060003, -0.37645634343007234, -0.39414501631753657, 0.27299050673858105, -0.6657781939289065, -0.5603958046176354, -0.11125162163256316, 0.095716020996055, -0.7336148307802507, -0.4714389626496391, -0.3984077211140816, -0.4707584090190124, -0.5425377809113673, -0.6576100178425205, 0.06690368839666666, -0.5921540940819168, 0.4557639876150951, -0.6048079219620716, -0.6672520297396601, -0.3701520466474543, -0.45633137733789225, -0.3008934532785242, -0.41343087548763735, 0.0017751425252088451, -0.0674641058811729, -0.765110302656972, 0.1644368645487444, -0.3875333635415024, -0.12572980909410086, -0.45599888001595595, -0.4596312942079366, -0.4602394250719663, -0.38647629279029755, -0.4696179762780646, -0.4238476928447982, -0.3168945441631306, -0.38851852828526257, -0.5098700367322916, -0.5797419478970912, -0.31158115216650645},
    {-0.5635265933715841, -0.6027174173770591, -0.7324292827104731, -0.6378000843352243, -0.12808143524224752, -0.3663268786644227, -0.6042178877432651, -0.37255530921187696, -0.6203137800351143, -0.39119072420839884, -0.5888166361615149, -0.05881557621002844, -0.35738518609659564, -0.6409720244008237, -0.7117643965311601, -0.1700917916725559, -0.4283545928709721, -0.6915545379447023, -0.49046015466718007, -0.7043574273753527, -0.5417933830910461, -0.44910552860133396, -0.6423583606627, -0.2391841050000206, -0.36538319037661815, -0.7002492406263455, -0.4661841455990222, -0.028428191615027385, -0.4947208017937651, -0.5203426358817642, -0.2745414926897269, -0.4648620982182234, -0.8266822246180626, -0.3303093171125247, -0.2718450090714679, -0.2953816644097805, -0.693878344559778, -0.41428995277018954, 0.2563406511242393, -0.41803294498677535, 0.11391649270036465, -0.3463659903105652, -0.6289719012507627, -0.638483747224081, -0.6111088299817999, -0.2920073621910151, -0.37336677108170496, -0.46290734170589376, -0.25353887279836307, -0.5501651792185348, -0.40092873141733437, -0.47275242539071327, -0.5173245953303091, -0.592737363824103, -0.5633089337829822, -0.6841766074375336, -0.691181350611854, -0.5990885184477535, -0.5984428270482266, -0.5585094752548291, -0.5522208886524126, -0.7722046000070727, -0.6301168991351127, -0.5943475892735134},
    {-0.43764646106684074, -0.5183570388307468, -0.6298336986102765, -0.594847729487255, -0.35853007602373516, -0.7091689165507946, -0.5217574327794708, -0.6200463230974326, -0.6987333899230828, -0.3641660639413485, -0.5131735380453959, 0.32380229324067794, -0.3668195457176199, -0.4948916012283362, -0.5456819388017741, -0.2980945821865078, -0.3368233529399432, -0.45012040493950417, -0.5439759465637879, -0.6920169060691476, -0.3608587948503971, -0.3950771443564671, -0.5654684850864229, -0.30594189202293065, -0.003199245621941937, -0.5430314851124343, -0.2053011210883155, 0.07287497155909256, -0.5427906896664153, -0.4129848819695833, -0.1737306925130929, -0.16846851876522648, -0.7012322497692339, -0.48053168689122383, -0.08770645784428087, -0.3173688990451497, -0.5983063834430925, -0.5027239914228049, 0.21154425915011044, -0.5093054363513326, 0.3176282670338818, -0.5521091565621752, -0.4062312785970922, -0.4531826836686468, -0.39043166659268874, -0.2976453511405328, -0.5423059851924584, -0.26822898604110057, -0.2178242866237432, -0.34490262669464244, -0.10031845264618497, -0.5493109662247495, -0.34592426790544567, -0.5974053296208657, -0.47552774167935513, -0.4510279297828713, -0.35285507460677684, -0.3477372307751611, -0.30298271997263576, -0.43668884848778167, -0.35707955977517125, -0.684258986559014, -0.7261127587095535, -0.3094184133746534},
    {-0.6428583918383544, -0.7305733183637907, -0.7683025098512146, -0.6302669426514962, -0.2371837627190839, -0.7096613076793349, -0.37955448754893045, -0.7392700035222378, -0.4521205803584209, -0.3523370265507448, -0.27959478070104954, 0.3208290099897773, -0.423614768414487, -0.6573948378567886, -0.464939050416351, -0.11344161959159435, -0.6916171030921229, -0.340438339526198, -0.5392148792509317, -0.45377713207119746, -0.45155504959759185, -0.5692579257861009, -0.7169325789431935, -0.3922745236223698, -0.2027887162220559, -0.43957486075994234, -0.2772460911902064, 0.18757312097433268, -0.5957494454228675, -0.4318670411771896, 0.007110637914165941, -0.023429567443125174, -0.7520119310506167, -0.32571470500149896, -0.5748785245637927, -0.1729606092098086, -0.37089459548947384, -0.4171786032354703, 0.13638455687365544, -0.7433285592301572, 0.2280618688307747, -0.5777125657305265, -0.4473406778824688, -0.5548311359366765, -0.67590420459953, -0.4618460881109527, -0.48310573166504367, -0.051545771593997564, -0.10961326755923258, -0.6196630576880684, -0.2333012329771385, -0.7171276498862182, -0.5031541314978917, -0.6545339010251797, -0.417019656317543, -0.59704858614863, -0.3216278313399167, -0.5863770488880048, -0.6366307287450128, -0.31960362697674954, -0.5124716792361516, -0.4152977915839994, -0.5224145273216827, -0.39926690748727206},
    {-0.8230127674308848, -0.6575030821380037, -0.7134304931421142, -0.6953628817919385, -0.04541679897802803, -0.6284836788070022, -0.6021292107874634, -0.4664700285872116, -0.8068739771716213, -0.6005905280253547, -0.3833800131557292, 0.41769188082377084, -0.4288806463654959, -0.7139896588276889, -0.5495047479385251, -0.34430443880921374, -0.6430857727071729, -0.46233128871143836, -0.5846631430006793, -0.7546413784195247, -0.521366607600197, -0.8006536369557883, -0.7328786315578176, -0.6418634312693461, -0.1717762881795541, -0.6982698711836345, -0.42787973269418494, -0.10592038656170465, -0.6581647015766979, -0.6587158530761904, -0.14004470394651647, -0.38775678080988935, -0.48731267841522735, -0.4611034711252904, -0.4177775710262086, -0.3825493353851763, -0.6068209972356591, -0.505936280129754, 0.13261873014841352, -0.5170338808021865, 0.3693343633335257, -0.7123368786256647, -0.7542760998356346, -0.6135988914559106, -0.5114822536574598, -0.4329404124538615, -0.5425621525941101, 0.08768368555838583, -0.49849057691339377, -0.45681336565429737, -0.2870038597086961, -0.5573649712989921, -0.2569573183169138, -0.6049499617086219, -0.5559898278453772, -0.7051850792479832, -0.4571446252701952, -0.5167820472219408, -0.46891945587970374, -0.4486383237187137, -0.24179926122253612, -0.6427983360491372, -0.5407927141241778, -0.3419821560658902},
    {-0.6631897611261129, -0.6397480247043624, -0.47958209950131836, -0.5822346198911834, 0.31933248986322693, -0.5894345747096394, -0.6574190511853748, -0.5480847092215737, -0.49891226722779475, -0.759715203546015, -0.5926911501266691, 0.46747637654331464, -0.5683942890885834, -0.581164472724922, -0.6994809791944309, 0.14099909659475937, -0.32670006421438375, -0.6903516908462315, -0.6289925979852783, -0.7964175499118151, -0.2907424988924869, -0.5092660799843229, -0.620247436170085, -0.7374697230457239, -0.35618528073568345, -0.5014829546131987, -0.3372623012339898, 0.0630972248863381, -0.49022526125574967, -0.8296750697085612, -0.15926776524919506, -0.274057260180836, -0.7480211175920499, -0.5340041148100025, -0.47523375406288254, -0.3454311813157803, -0.5220174762003986, -0.5088280871302139, 0.07501858314850719, -0.8387836034867868, 0.40119314228475306, -0.5374328987294555, -0.6620986794600703, -0.36663629264906517, -0.65585781348926, -0.48950331346008513, -0.3177714775351966, 0.27316313550126475, -0.4013352062358566, -0.6238303005712302, -0.1434263382640288, -0.6595252282537497, -0.696012474027382, -0.6470956302151712, -0.5043721408003651, -0.41038921173697446, -0.4133777505001527, -0.5891240730385586, -0.7434211328454986, -0.3816685174229255, -0.5286976143697124, -0.8203274454032591, -0.4118267099617938, -0.4938369119422494},
    {-0.6098336852738252, -0.5430733252026986, -0.601822814344271, -0.5484912006590225, -0.10070723418560855, -0.40895102053537086, -0.6826540528007565, -0.5945007860716648, -0.723882162092541, -0.6326017218216575, -0.5173566525743336, 0.117450574112203, -0.6008230759510781, -0.7795209423238703, -0.7760635976922478, -0.14410349029354788, -0.616311568807627, -0.4745172075727695, -0.4784508201759549, -0.7663357251208311, -0.38999033713761116, -0.7380882219783169, -0.46821860939088283, -0.5528292430323328, -0.2675116390401439, -0.6071489091962542, -0.5563126418929939, 0.010306890698882057, -0.5468493558197443, -0.529201772967972, -0.14349655530559738, -0.17929642241764218, -0.7932119824996449, -0.5315355536332951, -0.19580425327669798, -0.43594973339029264, -0.7120981235248609, -0.43747636845916454, 0.26473272323918356, -0.8202097405321321, 0.5282891339926394, -0.4978472315241827, -0.7146769760526216, -0.3628813499036504, -0.704111368470509, -0.639864993993604, -0.4120189406669379, 0.10445076808120032, -0.22630169184146898, -0.7205256913259488, -0.23977111071222135, -0.72148975014212, -0.5897463134056103, -0.5128244550342314, -0.5873270814704663, -0.7532424016579534, -0.6432077552526243, -0.7809033461590122, -0.4532185418724903, -0.7614200230132468, -0.584845047241136, -0.7305763714413921, -0.5957599824756308, -0.32048091092285286},
    {-0.5994793394034894, -0.5411363158085416, -0.4213054554238393, -0.5690005598641207, 0.3108972445383511, -0.538002639853043, -0.5419471499421185, -0.5177168788685513, -0.47143022892070235, -0.37945224897494434, -0.15562661803660402, 0.43441475483170083, -0.5113126690123726, -0.6321273968653626, -0.4919240900926214, -0.22668236849418072, -0.36244250932180827, -0.7742706412411019, -0.6294129799285698, -0.6915644361938658, -0.37486076379979827, -0.7482851576486433, -0.5218880678748183, -0.4834068787856772, -0.32050639556167765, -0.6400625726447684, -0.28150412692737353, -0.1986733160268558, -0.6388529748946614, -0.5947663853805305, -0.06354597804080343, -0.1480532145668581, -0.5775421046925148, -0.43761518701447494, -0.07372991426002655, -0.29411852617013107, -0.7003758649971408, -0.32818971966659266, 0.3740884503371734, -0.7390924406934459, 0.18752263775786615, -0.6717265170145066, -0.6450191991571103, -0.1823526951611518, -0.5786753137449685, -0.21882616779218067, -0.1983599569085775, -0.12516715756261834, -0.25365516646398567, -0.6011805280942364, -0.27875635376987523, -0.47470868950470085, -0.4718126750677504, -0.5987270653823695, -0.651367093471981, -0.5850360504737788, -0.4711608125711409, -0.6498265220570774, -0.30853977977249986, -0.6544495192500499, -0.44022986485714816, -0.7760450562261956, -0.41981264098728904, -0.39290511506091047},
    {-0.5795384607889388, -0.5524622966064079, -0.3703157062401165, -0.3883034843907865, 0.5232863467687596, -0.4083541261932467, -0.46040450824153684, -0.2536688508705296, -0.3366416486325652, -0.18738129799021078, -0.3351093962407902, 0.3879486423845268, -0.5578658234879074, -0.4420502108683935, -0.48907738298773856, -0.166582929125512, -0.42515219119474534, -0.6527698879987495, -0.34511214764562387, -0.33464230654595706, -0.19664885117528838, -0.5892413437850015, -0.1744355598867237, -0.5733311840968419, -0.19171917992929285, -0.3496477471460469, 0.0033282610906297115, 0.20156599091996577, -0.3523116231406403, -0.43591028603151377, -0.12651226004834928, -0.07996527458564556, -0.6593485092008379, -0.24422830956457928, 0.10337866853426347, -0.49315224057734636, -0.6544144405877288, -0.38576141748854875, 0.3567138708891261, -0.6479478759464958, 0.3115474783457725, -0.5929356353342736, -0.5815952065188276, -0.18385301644941013, -0.46471339524251903, -0.090888145134395, -0.399433491331902, 0.40905381115790274, 0.02366195498955978, -0.5536072714614717, 0.0050116435106399345, -0.4956755892147093, -0.4078847098987237, -0.683393608810415, -0.4634885332709879, -0.3165745186503602, -0.196315963529, -0.6264940758062594, -0.16205765410401288, -0.5642222911347381, -0.3156540091943265, -0.30382695711960606, -0.2599557854332865, -0.27688695617970116},
    {-0.6905751010744815, -0.7602314743404378, -0.516266166096431, -0.6217980123650465, -0.07644429370954267, -0.2585868806957622, -0.65694654588689, -0.3208283223396382, -0.6539679594434242, -0.4510699731760293, -0.4165180907494804, 0.1232326110939852, -0.5209523572964934, -0.4891558941976344, -0.483357244309228, 0.09020910025522302, -0.4652619775756525, -0.719505198112546, -0.6822497263639986, -0.7935769637868478, -0.5898478177553584, -0.5279502325619982, -0.5565069127390803, -0.6559180635631534, -0.4389653970808667, -0.7313961079553208, -0.4549019192631763, -0.19213508598993584, -0.3396158987977745, -0.4615016701645204, -0.5641604399022273, -0.3252121553752382, -0.7039258106404185, -0.5043692365654772, -0.18227063641604987, -0.6871140234894234, -0.7536963210185325, -0.654666239352931, 0.3857084903012898, -0.5885763244982798, 0.20270512613749456, -0.8510671813139324, -0.6543999716317644, -0.3267072084062921, -0.42269186211853743, -0.23858327597880633, -0.4054472637631835, 0.14368390424836275, -0.11098545194074781, -0.761841824594812, -0.27892595251018226, -0.5521328513452729, -0.7335737612180424, -0.5154516128506635, -0.7762761217768547, -0.7226582456449693, -0.4101330925347435, -0.3785609465358132, -0.47946841568875126, -0.6341233549720303, -0.4534380196568129, -0.7172606402235789, -0.2959455536222853, -0.461523490533955},
    {-0.6327177177005078, -0.623802567526937, -0.6040391704358868, -0.678519547709186, 0.03984404628570955, -0.6417150761325912, -0.8116599214515053, -0.6315617450182641, -0.7247281237388281, -0.43304407917528426, -0.3603440938259087, 0.4465074220499736, -0.551634266579595, -0.675484722504226, -0.7532294728719581, -0.059641914763878784, -0.6223727698099343, -0.6599390630220244, -0.531993515995256, -0.8472250754490807, -0.3140944028147703, -0.7678171337947327, -0.4730381118158883, -0.5875845037885574, -0.2503156669287484, -0.7991503503451263, -0.6006874890563404, -0.24005827583025044, -0.6746603627960485, -0.8479192439775198, -0.30465559057094893, -0.5306331221249961, -0.8703905490565262, -0.6979906220657236, -0.24430988069515602, -0.5928317000726808, -0.6359665890037769, -0.6356684776674196, 0.32043585395230106, -0.8095058951071289, 0.25327636626463834, -0.7934593964079679, -0.5342351256026954, -0.34629613133001663, -0.6356989891117325, -0.6057493032638126, -0.6318980176392068, -0.12415825990910175, -0.1565817170357239, -0.7269436756418743, -0.2403166198711132, -0.44530056442161325, -0.4405769916811624, -0.5033124741751265, -0.4802442792466867, -0.5594422261031661, -0.5127367743549043, -0.7630630382586753, -0.4356390325046813, -0.5479645335797954, -0.5110537868344137, -0.8110650607888485, -0.45156404303618014, -0.5433126072235084},
    {-0.6412276237751591, -0.533368355848238, -0.7340745097512568, -0.5523604882220186, 0.0713338654717811, -0.773047727265309, -0.5248357914216306, -0.5412321556052686, -0.524836842307541, -0.6890278841161426, -0.574043053289588, 0.34285763946876685, -0.47124808220172854, -0.7302291233870063, -0.7853471401461586, -0.21280542740935787, -0.47717799108702763, -0.4128202616743236, -0.8442039981115571, -0.6680258046798723, -0.5536955970660511, -0.8080843573744234, -0.7863679340242863, -0.6636966659219935, -0.4486573432566297, -0.7028351929006847, -0.3037104225765969, 0.03970483801629706, -0.5764082381916916, -0.5445021283481581, -0.155366408867901, -0.17100066433134148, -0.500509944105968, -0.5293030740221806, -0.2623656637013197, -0.5508482447164431, -0.7986146357158901, -0.7988408140316097, -0.14941651234245254, -0.691512355956489, -0.008435075749758802, -0.5425525102433618, -0.6098147231582085, -0.6691851932322438, -0.7622826704277231, -0.4479835247246381, -0.48543172553970737, -0.02543164871443765, 0.03581508187514527, -0.6423105748726214, -0.24427854929131002, -0.638185612578209, -0.5465815759228242, -0.5735033463971289, -0.5344345406732914, -0.8557530424598239, -0.764187307776623, -0.7716691403111717, -0.35312746693353314, -0.5407252946892593, -0.48931225038822257, -0.6336713980421054, -0.5223491923653619, -0.43600395208532505},
    {-0.3844399333162992, -0.34109548716637494, -0.6073247391608662, -0.4026566224570631, 0.7892677203382656, 0.01835461292436496, -0.07798771625510932, -0.5180621208441647, -0.5111597098535791, -0.48774411601999385, -0.5788658763588067, 0.3978612976958257, -0.31873598215845955, -0.6919789244323654, -0.6310262989386948, 0.023339993291628315, -0.24796635035581288, -0.5615185225387233, -0.3844460927707924, -0.4953855462272959, 0.03652692145908743, -0.5564508391398704, -0.5959954784400636, -0.3463298443114833, 0.24171076945566183, -0.6009109422882113, 0.08187489818068229, 0.43378534673365726, -0.46394661970845497, -0.7458084116628431, 0.22572968295072568, 0.30680949665210694, -0.7268185636953497, -0.4128327698464223, 0.3060082695035202, -0.13209344781406918, -0.3843586989229181, -0.576058408017242, 0.39955876058757667, -0.6044125453595286, 0.5367178950109861, -0.556947894257196, -0.485606362379514, -0.2828488430880746, -0.6374159147330933, -0.32207580618533005, -0.15314467468861787, 0.459834657645467, 0.25287430025167906, -0.3967995140494687, 0.13244435316440234, -0.7950849990377858, -0.08597032258121591, -0.36376028109679664, -0.38859821771760245, -0.5994276248488295, -0.4184568015114958, -0.5842212427133132, -0.37114200956650856, -0.3642831224604516, -0.37341412633916987, -0.7365331474097562, -0.37011988295835335, 0.05075172925671683},
    {-0.30337050623203027, -0.5755367615096899, -0.6850031594481572, -0.6150183293582978, 0.6828803187855457, 0.0846601728158214, -0.28881763028503793, -0.3612906476517, -0.49718151423201423, -0.6202487130447554, -0.31577862960549674, 0.3871755060200367, -0.5636965066331434, -0.6763232976603016, -0.7113934045837683, 0.36504868864914647, -0.24677524781650628, -0.5587223768622426, -0.36797028565479767, -0.4067258802220474, -0.03239597120207429, -0.8217789431090612, -0.4484571588808057, -0.555051133709433, 0.012326008318080625, -0.8166306021681644, -0.4723158487908793, -0.1861640564940772, -0.43445257716233243, -0.6048470230246908, -0.2766956887809017, -0.3907281327662772, -0.5336626040238956, -0.6452551998202039, 0.20474023661969437, -0.6581815703946536, -0.453723761213118, -0.4264532765093727, 0.8291792527771286, -0.8743082624059875, 0.5787917240187792, -0.7584199415413094, -0.5211111415895919, 0.07584155219280071, -0.5317044827145504, -0.3602494534869945, -0.5478239545746931, 0.6563851155105, 0.1983702608768653, -0.4136711238008356, -0.3607229653820522, -0.3816542218292961, -0.4301530683008396, -0.564006271208815, -0.3344155227376836, -0.3403344808358436, -0.4404319588864785, -0.2495852719679093, -0.35340463629594643, -0.38668548679459913, -0.5972629873943169, -0.6133472330112123, -0.18630025820714968, -0.021419299419100542},
    {-0.3585777812447787, -0.7072401951397602, -0.4953922143234135, -0.7759579904880016, 0.4805135222957292, -0.18192617213155224, -0.5079547710939162, -0.528351916239152, -0.6835836686392605, -0.6734529369546352, -0.42236158155945913, 0.5731163292356066, -0.5341167910891582, -0.5880682991000521, -0.8034641798315428, 0.3495144473474905, -0.6155337446164104, -0.537467574519485, -0.6770331540457966, -0.7501321999085296, -0.6033460106891082, -0.7226779279763815, -0.7768855556341769, -0.6285529363930251, -0.171724429653047, -0.8296946845607508, -0.4318480218174225, -0.044611778132029094, -0.42227067654986755, -0.5558277086219626, -0.3084747128184489, -0.2711885348127018, -0.5334208923069231, -0.5098342427912954, -0.181384896248537, -0.6237632782049872, -0.5496531712279565, -0.6136907990729045, 0.4788691816525272, -0.5679605347411871, 0.4141350834854473, -0.722337300499715, -0.6608315250643824, -0.12052710947907402, -0.4406918365368994, -0.30967655333545124, -0.5919970052720035, 0.23957988882925385, 0.11372799463702002, -0.48594931675412517, -0.24459492170733277, -0.6259240633471552, -0.5269254784686853, -0.6454863432236042, -0.7094942216156147, -0.7050857015102271, -0.7892939088405291, -0.3822689225134096, -0.519861052702654, -0.7155830616668618, -0.6213185084434392, -0.7479121625279013, -0.33537274282884216, -0.39722030150303445},
    {-0.631677945361127, -0.6119298222419369, -0.6778602219672545, -0.54625230084007, 0.06724424112417561, -0.6700966989079926, -0.39258046389459933, -0.7713532667649377, -0.5676011934058223, -0.3856316542202059, -0.5170706017389145, 0.1038778408914557, -0.5827943759160823, -0.8198848313182527, -0.5395663369719674, -0.004891429449958131, -0.6419305212672928, -0.5144358972421131, -0.7823601057753953, -0.7713538988964763, -0.5960208190060758, -0.8182209384803474, -0.49018865347560997, -0.46966820597059417, -0.36127417150943747, -0.8147719786197222, -0.6035477777388308, 0.009970778987121252, -0.5306626066387445, -0.499157146263429, -0.4527778044852209, -0.3986006077120024, -0.7265664948284004, -0.5556547872129184, -0.15850543829581856, -0.5313633688526133, -0.5903745590151318, -0.8587568906388279, 0.125287206756729, -0.5403636521579419, 0.5122073277147697, -0.7584226504448583, -0.7917725547224739, -0.6417349627068654, -0.6310781447554602, -0.44434678875618583, -0.624577758931287, -0.01883907986486707, -0.10320713373652717, -0.6464885314108966, -0.1871122246822338, -0.4834670461724997, -0.6384633016115853, -0.503119583609831, -0.8300216132902639, -0.46647991624380536, -0.5296353478117021, -0.7222606211307276, -0.6155177944345348, -0.6141876183351646, -0.4308250427458004, -0.7543990018623336, -0.5428984562347953, -0.3684056461762466},
    {-0.34406334114770365, -0.44821346934159695, -0.7138448421765982, -0.4236731686662858, 0.21119842026076743, -0.4785176805345404, -0.6204478288782361, -0.3208698184191249, -0.5104696664480677, -0.6487154891889747, -0.33999721586788373, 0.4389452192238743, -0.37348962330662294, -0.6263659148500195, -0.5429580277170275, 0.32499469010548954, -0.46595140997998247, -0.6866366935175373, -0.5310171053228069, -0.8875691259425148, -0.5224253943795469, -0.580040733620429, -0.5804389798790925, -0.22597429359362398, -0.22609439528137315, -0.9311043162393123, -0.5121683123377536, 0.01674173213632203, -0.3072639702286346, -0.7969550736176976, -0.35168440159646064, -0.5621352748016991, -0.5469816667767061, -0.7487856560316769, 0.004815987856604229, -0.7587228305721202, -0.6132356695746288, -0.4924170064896468, 0.4616133141733574, -0.9213277803730973, 0.48426586484367895, -0.7173339500168243, -0.5966889240950706, -0.2141948178873745, -0.640399773163641, -0.16089489802551699, -0.4595518129121817, 0.0714727546305769, -0.23938260177236592, -0.5840553342289885, -0.37386037032614355, -0.5913904252307669, -0.8062267044209452, -0.30598537278187565, -0.6448485441154829, -0.554344732220062, -0.6701648582966603, -0.4973996375945157, -0.705419265108484, -0.8268711026623221, -0.6629651715519354, -0.5871390461554872, -0.3393423632270791, -0.17825351187478125},
    {-0.6193460603512139, -0.7677724930436116, -0.774188081421581, -0.7350325877028543, 0.30672720894779687, -0.14782569752385152, -0.652908447748481, -0.6006148305444006, -0.55821936074056, -0.5718455661975912, -0.7083529158645073, 0.6254266246235708, -0.6988216689697582, -0.7326660962505824, -0.7627452972428246, 0.11152708080153054, -0.2895666444770223, -0.5149264758914496, -0.5390371067227251, -0.6641944526834659, -0.473469564094937, -0.7151770723159938, -0.5258991075462958, -0.47759315404547453, -0.04889666313003707, -0.8786593880100746, -0.5183415404521334, 0.10258732931401963, -0.3038023642047465, -0.7491805427724328, -0.1164431170161331, -0.5039494792586409, -0.5172932138071857, -0.7944400880359787, -0.026364007143788185, -0.4899475082402112, -0.72634019507723, -0.718506995221358, 0.6272239532753402, -0.821956622319412, 0.46595601204671805, -0.6717874920345518, -0.7352592857568144, -0.19710841035744647, -0.6752469925263995, -0.13458376039265738, -0.40826168557977843, 0.2893047503462681, -0.08430295879511829, -0.3907275546507359, -0.4028691019126446, -0.5510325093395181, -0.4320514944251941, -0.63818142488107, -0.569445091549008, -0.359261301188541, -0.7261756294903231, -0.5922732928000324, -0.4542872842128268, -0.6838634450794624, -0.6967302331137893, -0.8261150769381759, -0.1578176763014735, -0.24567482718653066},
    {-0.731817801219238, -0.5214528274910867, -0.5495056718837855, -0.5519226779518667, 0.3247315810205189, -0.409601595515134, -0.4187721919393318, -0.606860140394475, -0.5416098045461188, -0.613706405716434, -0.663180942698674, 0.14115268866983027, -0.7715168177939052, -0.6064792657245164, -0.8758012743490756, 0.05305339123570903, -0.4494841080561426, -0.6869377500857888, -0.4890142472780145, -0.8517491114696901, -0.5974568447642543, -0.7047856555036857, -0.7105496913733789, -0.3487409381964745, -0.21699706726227727, -0.7760011901727558, -0.36075157137979996, 0.0828502007421607, -0.4399339885293624, -0.7284871647584844, -0.3852435418241894, -0.565141929722625, -0.652658965309873, -0.6976915605479482, -0.09966425211145101, -0.5957160641363795, -0.8046044088193371, -0.7373582218797918, 0.5084510595924481, -0.873187882649035, 0.42167802145861194, -0.7842801734462179, -0.8440162239234746, -0.212778998017811, -0.7993152660316856, -0.28331973142899264, -0.704213216083551, 0.21744011172369784, 0.1220724762017755, -0.4446868147816372, -0.1299513672855152, -0.5607906183689952, -0.45723268983428383, -0.7162804477350293, -0.5252042228228022, -0.46153245429751355, -0.6927598278372462, -0.6684091529572839, -0.5482086483563413, -0.6423714740307284, -0.5552362270614584, -0.7117565593394117, -0.4615037773324274, -0.16413072546019855},
    {-0.6520447154017951, -0.694071316402948, -0.7105887238042825, -0.624350213451319, 0.4691742428220384, -0.25385032461720375, -0.7482787465294282, -0.4182854593055709, -0.588521930806474, -0.41094939313512874, -0.7356296006684837, 0.24975229382863176, -0.7882825435725412, -0.7541070629269186, -0.7737875049874485, 0.1646103648359332, -0.2816507132781333, -0.7894090768428449, -0.42550700616593723, -0.5769584789793202, -0.3757234346122211, -0.5528193564821218, -0.5331263454033867, -0.37129209441088, -0.3264052678513575, -0.8348212693355334, -0.6820483043714173, -0.07137164212158084, -0.5042901921045407, -0.7025915221539971, -0.2222135782310453, -0.4645620155824608, -0.8773328644672459, -0.7942631730335719, -0.2827300953553829, -0.5756922538249641, -0.5631425990095285, -0.6235604220181784, 0.3477670394113049, -0.9103411949068398, 0.7083146044630432, -0.8292619114438704, -0.9038832599428053, -0.3884986855449233, -0.49014230473132464, -0.2510767914313409, -0.4429382143107138, 0.12758476263005264, -0.08212672404742702, -0.7479104993004686, -0.4551658092627384, -0.4735662927751481, -0.7277359404934788, -0.4386204944614361, -0.6463548819596017, -0.5618704207840604, -0.7112709547177611, -0.7635223283683741, -0.5888500983389524, -0.6155785451007512, -0.5402494368422657, -0.7073168752098099, -0.20950736093788977, -0.2606689886985935},
    {-0.39286581963576456, -0.37385360598114015, -0.5294218028998099, -0.6865498503719726, 0.37273201206007117, -0.33956961063867813, -0.5419244376880576, -0.39374060156687013, -0.458550942596218, -0.5774577608688678, -0.6758866601940489, 0.34515018313435203, -0.45828288034384473, -0.7861381392826199, -0.8016545047021264, 0.1784735328847013, -0.18845403425188667, -0.5245790750842072, -0.5716066628767683, -0.7631712250336258, -0.40530652950488544, -0.5500826166159135, -0.4968295581462103, -0.49716366153004, 0.05319137008320967, -0.8866854182253096, -0.5946578544886311, -0.037671347287122084, -0.3285088613275041, -0.566621828943171, -0.06334125378646471, -0.5431903262220762, -0.7622672662312754, -0.7326777620599164, 0.12642148125932792, -0.4724459649558736, -0.5089930439554374, -0.6616245062073455, 0.58941802063022, -0.8620261054076054, 0.5660097648315672, -0.673506586780507, -0.657658653049315, -0.2742454893370452, -0.6143561277973734, -0.262126988817419, -0.6406616913056358, 0.474258953550279, 0.09668916692215941, -0.5385806345582694, -0.2637347833760323, -0.5679151519764803, -0.29644825766735516, -0.2985627089504805, -0.5127812426700233, -0.4329447547233155, -0.6880404350512159, -0.6208644197366507, -0.7032847491432099, -0.5904011628335721, -0.5573834944410297, -0.7136422336398967, -0.3772274859856437, -0.10315223101094188},
    {-0.4321446723546026, 0.23701168500749034, -0.45526295158986085, 0.42216239880494355, 0.11875043493507174, 0.19940168721657228, 0.2371857247071776, 0.10699863671077121, -0.14320762446929558, -0.37903907122505676, 0.06606316849810911, -0.28234596013548013, 0.2071113829836474, 0.04131360922543831, -0.09342377868110596, 0.32518022771731536, 0.24033234939324513, -0.3566311178309569, -0.5835382405232877, 0.5721903832923964, 0.3332494722062213, 0.3602516921025514, 0.046429872815586914, -0.6065438676326097, -0.2507470997681572, 0.3234012544263821, -0.159123225967392, 0.0356619809027829, 0.4487575317041062, -0.015780678259773893, 0.630235830156875, -0.2283349550689065, -0.3180301498688481, -0.22693178293374994, 0.6147535103038344, -0.40043652658488316, 0.09434866114133117, 0.09917750856809908, -0.019580244339954547, 0.05667224613650055, -0.0927133227530258, -0.1727616030811677, 0.315300274603513, -0.25437303892482716, -0.10591599501726011, -0.20202830495780216, -0.37359125376698693, 0.4895439982970427, -0.6688990056584652, 0.2934587608972609, 0.5227108449318831, 0.11544542509054662, -0.16777391768907746, -0.503109123263265, -0.10218264562569743, -0.5737191181572668, 0.6669852425381427, 0.4301797077090147, -0.4203253721518965, -0.2597359316120067, -0.05756887771530677, 0.4349607616807549, -0.32512313760525663, -0.333687792431549},
    {-0.5011998656151786, -0.06636341437872367, -0.37484271051277285, 0.452479080146365, 0.43711119627285994, 0.3594287935885111, 0.42136583749540274, 0.31071650870828843, -0.15919190543734255, -0.27628995459688027, 0.08037182399850507, -0.3983470366320591, 0.1562909485151445, 0.2630361777375557, -0.1314967980569024, -0.024068014457498486, 0.5585335541533625, -0.27733749734449054, -0.209418864409367, 0.6028922088268638, 0.33777794643540787, 0.05479937980546337, 0.07543364793311652, -0.589834217971401, 0.13102453035122721, 0.3195435393431653, 0.027594888240692894, 0.08137056219789013, 0.2321237962555262, -0.053444535514281855, 0.3668438416200304, 0.04538233540408189, -0.4182690777692861, -0.258981827142364, 0.6786273869043354, -0.3731188148859702, 0.15033993825412484, -0.052910157890414394, -0.15059446958579112, 0.31649097887284267, 0.1949040401423697, -0.0027402404683516323, 0.1925480378403884, -0.06619739497970376, 0.055829270479305845, -0.4163213409851074, -0.2397794352166409, 0.6275361367115174, -0.5288571359282013, 0.513989899420136, 0.32744821983791583, -0.18450525285599992, -0.38864552206666886, -0.2607373748965034, 0.08799544091244178, -0.37354098655064777, 0.454870723101391, 0.3023396990657479, -0.09988890949562929, -0.44167351518232195, -0.014236699509845057, 0.5098533778833689, -0.12452333251662946, -0.5364653522402371},
    {-0.47389052690721756, 0.20218085361419327, -0.4134859522323923, 0.31838166089192094, 0.0747782675463956, 0.45496052634484685, 0.2114585833920296, 0.3282142528984642, -0.23911879203190523, -0.23603853105233266, 0.006852821787398458, -0.2672716940966956, 0.4667151330226713, -0.17416416765521328, -0.057103179942005644, 0.3249524270310291, 0.590933413335645, -0.47741956157404575, -0.36977581168195156, 0.5699955606692716, 0.02106048948439409, 0.4349048606885155, 0.37658268601489653, -0.586503963262474, -0.3904131590681508, 0.007683780021135815, 0.12960055918065347, 0.22272149032056454, 0.5333243342074829, -0.3906004235222814, 0.45089678356352897, -0.045192484816323396, -0.11442717949656762, -0.21085713298725348, 0.5782437324100392, -0.41574994770808404, 0.42397495947127645, 0.23709226250110324, 0.16044697031510502, 0.4657231823792743, 0.09020539039139872, -0.002884104432215435, 0.5626324109532793, -0.08172253284938619, 0.1373535728075968, -0.24218008496552315, -0.5433699746094344, 0.6207444300223053, -0.3937042645868508, 0.5118154594489739, 0.23957288986106398, 0.09676055340630317, -0.5815904448103804, -0.42273397187432965, 0.1740609581256147, -0.5187937056039404, 0.6666005383597605, 0.44909780559555057, -0.03678517096093221, -0.6264124335016636, 0.056525593169215585, 0.41114315660392564, -0.5010307966740335, -0.8073483251271927},
    {-0.6057588052322824, 0.46327155429833045, 0.10784627192529109, 0.6315399678688606, 0.1055239991814664, 0.28350822475910176, 0.5695310765058114, 0.21246742935502896, -0.5626031345944726, -0.17444589156650914, -0.2090167267552089, -0.422679694225914, 0.5417777074942673, -0.04773773832216946, 0.1407103201353454, 0.29885514736817514, 0.6752403361079702, -0.6163748626920138, -0.26608139341317105, 0.5432378955678147, 0.3849790041473466, 0.4063966134150677, 0.3577745870545064, -0.2171075270654306, -0.318713587512601, 0.024171767691832758, 0.4830926809717382, 0.43838257049578977, 0.22117153974734027, -0.21902906443711406, 0.6231994228119847, -0.14273795332650313, -0.027388009118628695, -0.14742475255891996, 0.6321048800714578, -0.280378327076871, 0.48569932092007506, 0.07580421944788991, 0.19628356836764696, 0.578656949174735, 0.2373439634580433, -0.1733178146673578, 0.34178497764888693, -0.32119777946637357, 0.34299536353663906, -0.14070304465165534, -0.20861232946745292, 0.41695790293949303, -0.057185502460647485, 0.49749501102978066, 0.37170230465582166, 0.038095832297433393, -0.40141732971699645, -0.14734156872078386, 0.5393930166474366, -0.49301043842527376, 0.6972871034176783, 0.4078954746200947, 0.026086576927290012, -0.5973616930592458, 0.2788398505660008, 0.446591559673152, -0.2873667028420634, -0.412020611298271},
    {-0.4565736323452718, 0.35167021751653343, 0.062024789023425744, 0.516599179198231, 0.3530313264304115, 0.32453849021576175, 0.685842074638075, -0.0448294085249215, -0.5233845500910312, -0.25392395080337754, -0.15485381289329908, -0.43228311730241736, 0.5230222890215079, 0.06269413756177075, -0.1638814260701364, 0.21098787177558137, 0.7661284118833575, -0.6625834283391181, -0.302751781264901, 0.4817080545659411, 0.20771908352399754, 0.3089279004214522, 0.4177462039757104, -0.35794513223604507, -0.2741565483721746, 0.09030475021185097, 0.5058161396751499, 0.2755222386184106, 0.33510025972220264, -0.29429130929899844, 0.7017972534804273, -0.04731333573181027, -0.0319628992801091, 0.12473819033847165, 0.36619348313329275, -0.049918073037008306, 0.5970215038136434, 0.0005184431676635748, -0.12392303171953852, 0.6198687687671437, 0.36237870542678746, -0.30062542431514344, 0.5192961683366515, -0.1223664837104415, 0.013026163629441121, -0.4327262274490559, -0.012406339704133454, 0.34288347465276914, -0.18721696726776213, 0.31462507444589194, 0.2296025373490766, 0.07889024929044648, -0.01031517562274391, -0.42520579580936696, 0.5372186447984396, -0.4107786485292941, 0.6345435511842568, 0.3032919173604067, 0.3579358481336838, -0.5380792256449473, 0.345809373782133, 0.5774369255419456, -0.15283600757525292, -0.479690015098027},
    {-0.5419893954921903, 0.07536739420753176, 0.14411250264099892, 0.5892526602210939, 0.4600980918022845, 0.18225614324777747, 0.47295009219170825, -0.19490820481162824, -0.565912871844951, -0.2230131225339607, 0.0067517656343503585, -0.36717623722192105, 0.3084343004508783, 0.3219526023146286, -0.10687512376382306, 0.27849623557301095, 0.5956791843863485, -0.6128798860710116, -0.5141814331291505, 0.5827402740814116, 0.14521572740085495, 0.2951347059618789, 0.5646958478375064, -0.40734432426133543, 0.02188476397703659, -0.0945497475328974, 0.4794269138648145, 0.3863773507337248, 0.1423767083119662, -0.3788929353827926, 0.4819883720629442, 0.003573779860096487, -0.3660648733111782, -0.24322266574640167, 0.5257428039797017, -0.187276553826439, 0.5809745518709906, -0.017820065968121433, 0.11274541857955422, 0.6446827277023512, 0.09591503641715905, -0.21697316654100998, 0.2903099962431863, -0.2968691792193006, 0.31001351164177404, -0.48312905824642544, 0.1173718928125036, 0.6080166596730406, -0.14301899093219989, 0.1273570565139105, 0.4163694356459471, -0.09416679839336045, 0.0778938522271792, -0.30820143261863403, 0.28919627479224375, -0.5285481513960737, 0.626258468786369, 0.4086522373713078, -0.0035342739529497028, -0.5448054162167731, 0.16977775055842698, 0.4724265607464539, -0.5503179373077473, -0.6269484428837095},
    {-0.6036299165246438, 0.005421697056016294, -0.011211040308744038, 0.6768804242923152, 0.21887431810377334, 0.5325853376223519, 0.447024761316837, -0.3436079055267005, -0.617966632714726, -0.5727853957338127, -0.20181124865700137, -0.383669518328854, 0.6776421733773672, 0.10209444393125952, 0.025093575502502234, 0.32516022033512165, 0.6355752648243314, -0.337085314606072, -0.5513859727831157, 0.23560555738529868, 0.4197599380148579, 0.4931756316137473, 0.581042589023042, -0.5028167453037623, -0.14091587141670933, 0.1905742517179424, 0.40860029432805756, 0.41639488915268563, 0.33650390463701024, -0.3999100670062777, 0.5242036141719775, -0.2305467422901714, -0.3342679058405258, -0.44016509208019244, 0.6643752286687699, -0.4568720744875275, 0.3907007679286609, 0.10849004901839236, 0.18582888166808392, 0.4989939664057155, 0.1738043885463971, -0.18822396730405003, 0.6439728605632621, -0.15800931296895682, 0.40065413008515277, -0.5005277127302588, -0.2963804737103027, 0.37958469444547915, -0.14747220431191935, 0.3622738216361807, 0.19267619347446016, 0.026516555412044073, -0.1641643335328897, -0.5200159926829114, 0.5489601747159101, -0.6650075436732596, 0.5580549305315208, 0.10512109170460138, 0.010778455977838141, -0.26473326267620134, 0.30807268591141956, 0.5247051493569521, -0.45999157182283457, -0.43544155946613916},
    {-0.6187124084643119, 0.02545694849414336, -0.4039438927094033, 0.6371438027266348, 0.21497023651910632, 0.6817713941420057, 0.7114912965246616, -0.08179934656168637, -0.40069722643978495, -0.6118183088145328, -0.2424472028042234, -0.44727589867713297, 0.7725129963189041, 0.34189932867076794, 0.11564406457887387, 0.20436089247844672, 0.5855118897190368, -0.24526847891734055, -0.35690818012857434, 0.4172667403092023, 0.47179252555788065, 0.4259899461306031, 0.5107007314767537, -0.3814538480277267, -0.43092710311365867, 0.26125838727323086, 0.49534393121941706, 0.5580055123367194, 0.3662523355749085, 0.02711165869663352, 0.49004121547458723, -0.25113899773120724, -0.14490280735819505, -0.21939179078779517, 0.4652460237080512, -0.5130023860057148, 0.5274031087554636, 0.5049732152531253, 0.13280414472913368, 0.5525072059116101, 0.21122300169577068, 0.010506576064804813, 0.6288688311567496, -0.5026970453434723, 0.4412929767427419, -0.37885828283512085, -0.5188374676029911, 0.32368786881700523, -0.6814122839328026, 0.2967578072315519, 0.6275001995378736, 0.26287833955593554, -0.25546654142237835, -0.15092433508101044, 0.18715132135841128, -0.31404292572337056, 0.7386774383129234, 0.18175635994183176, -0.0026744496579261118, -0.42879426540906457, 0.03795195445389523, 0.5393583954973656, -0.5170982744604573, -0.41767437895173},
    {-0.6693542470615527, 0.17045288019607455, -0.4454751720662692, 0.6068190562768914, 0.04209106216411853, 0.44260832077949946, 0.631232281866318, 0.03900087010429394, -0.3653681947929892, -0.6120715832010076, -0.19152929947274946, -0.19679560944292834, 0.7387352400827844, -0.04468768474323654, -0.041735354458247886, 0.10418287186659794, 0.40127591279260666, -0.5023681823428768, -0.6263488966024835, 0.3898975780785275, 0.331626651569893, 0.17454071296202156, 0.5547831121628161, -0.5284416132921583, -0.2200884573306133, 0.04906944702346963, 0.19382356587776678, 0.365936232205304, 0.5320659274233844, -0.02583851070455405, 0.5953575888742288, -0.001786307368153392, -0.38733208573996025, -0.2504466511504078, 0.7451418595780278, -0.5773314804569099, 0.5000468702270894, 0.6616843977925463, 0.06300355100991625, 0.5433327341022546, 0.248503662678727, -0.12593007222685074, 0.6261814455164919, -0.24768104030150326, 0.02764105518871849, -0.51923070390604, -0.6665440832698588, 0.4917556901401483, -0.5368530761166453, 0.37383128093651186, 0.43129979551475495, 0.29478752913541295, -0.4411500486596409, -0.2296898094445157, 0.271159741415723, -0.3596724405919292, 0.7485823759073614, 0.3930143320381687, 0.21432262781844164, -0.45222442582732514, 0.09522836022752107, 0.4928616367059598, -0.38467236560474694, -0.4775444262119361},
    {-0.5761377183929988, 0.07033434347245938, -0.14586369475737332, 0.33085289595019957, 0.03520124312417102, 0.4965410408621239, 0.5756579311388978, -0.236707200920615, -0.3618058095246152, -0.5608528650351217, -0.11977515722573773, -0.22693218949786406, 0.6077731905211856, 0.1486791661036839, 0.20192825523930016, 0.25707175328953075, 0.3439263911560845, -0.6231239240569056, -0.40866538611201564, 0.3188970172828687, 0.22457030773096018, 0.11259487046346511, 0.21634321908424958, -0.37241913497173756, -0.3871973170703903, 0.32219239493631063, 0.06411127628444625, 0.21549098348453413, 0.562551837400443, -0.08151552836739447, 0.5589700565375146, -0.15677020397736993, -0.5494755716093594, -0.08188371913045055, 0.8245856488999608, -0.5517579032817428, 0.275738594151934, 0.4821846001780256, 0.12583977191237627, 0.610756808448627, 0.34154144912956835, -0.038499667322550515, 0.2558236306580088, -0.38813115735053344, 0.05557246059251805, -0.6445333993584146, -0.4038046097787229, 0.3294218625438073, -0.7202889315594101, 0.19268724987794114, 0.6179588392028615, 0.03321477074794017, -0.4474379433423974, -0.42957485310656035, 0.11393993629590458, -0.6277896917911474, 0.7564402257577706, 0.4730376311777647, 0.04576174518785154, -0.36804076296008065, 0.3845209095859078, 0.5663642721604243, -0.6650395020734302, -0.7763496112993885},
    {-0.5871376186972335, 0.08051236308203048, -0.35709441486033316, 0.215535381217537, 0.05480490958464347, 0.3633065566126268, 0.5228858693514753, 0.12813255527937817, -0.5504375189758889, -0.45947778789653126, 0.0227713162542723, -0.20970534425742118, 0.5410422316022097, -0.05273979120545726, -0.09329198077631572, 0.18076455230817845, 0.29751586075383146, -0.35551199855850374, -0.4450099649656857, 0.49181783817470975, -0.06742063135758439, 0.22541434984033024, 0.31150821231037107, -0.6315272745753993, -0.17024756686336562, 0.11950433380930378, 0.3495603918960666, 0.21883994608457927, 0.5564596298286921, -0.46852121851606393, 0.6599907226212681, -0.34364137695296676, -0.41925908857266636, 0.008583654609403812, 0.6158483137513051, -0.5797023121144856, 0.2827014738556674, 0.3630451564457858, -0.22908210426526612, 0.4938757533054562, 0.2714397173371212, -0.18797714866624093, 0.16830110476922314, -0.5096237612268104, 0.13994379828330827, -0.45942958197797157, -0.34105635518874833, 0.48010671653832115, -0.6364764665438489, 0.39459732310014345, 0.6134734308184399, 0.19599031376391474, -0.518965455467238, -0.14876800732710674, 0.26665667988776215, -0.6782058428303332, 0.4990749251335307, 0.295261246691848, -0.16691253158455016, -0.4708203460885252, 0.10662497886541782, 0.5807197812741423, -0.585498072069065, -0.7801159989821437},
    {-0.6219030734992882, 0.26719370394553166, -0.18157368597555118, 0.3484769616128405, 0.11853201604993602, 0.4033822570180476, 0.4495535667255865, 0.19950667232048824, -0.4842198611801078, -0.3487530448691502, 0.07834332485348114, -0.34962188813645007, 0.47391672261724926, 0.1418538161722157, -0.04547380522925028, 0.12280264714498883, 0.6985016362559915, -0.581772303483648, -0.7409346772818758, 0.4221192043998284, 0.37930656574133387, 0.37940942006513245, 0.5668289162779547, -0.7308509655811924, -0.4819572669696342, 0.3894515631399103, 0.5173365137524727, 0.21715038518599974, 0.5442131794321144, -0.4415471196531633, 0.37497603846957217, 0.08802923889098303, -0.5683071520590007, -0.23427167458346307, 0.7791859066258952, -0.4779383507427227, 0.4047382013107222, 0.4855154356542379, -0.07056932523315033, 0.2942695393512417, 0.3674660544136066, -0.16024347713283416, 0.5710902580838235, -0.5063508993673144, -0.05202100770943674, -0.38331922300076193, -0.20437517005318587, 0.455018471768837, -0.4897062672250026, 0.656845859249535, 0.2737725065886327, 0.06403356950003751, -0.41601719838889967, -0.5005555291209126, 0.29516299923658457, -0.3668573562893903, 0.6742250718411283, 0.24436094019108917, 0.0696314592556804, -0.4076213815122085, 0.18979774172003916, 0.5610971314791402, -0.4462236915151116, -0.7616035353758569},
    {-0.47826027234206653, -0.03774929980714692, -0.23223608665650441, 0.40579764148263514, 0.07110073298255715, 0.2056141794131635, 0.687068976061102, -0.10370523981478098, -0.4990922812599516, -0.5782008235888122, -0.10591417083764305, -0.6002558415338896, 0.48619028027290156, -0.2105720880455532, 0.022689043537500484, 0.16501206575047717, 0.7414638969284557, -0.5127471266628021, -0.6999334024935296, 0.4867631731344906, 0.4244511066461025, 0.5958136275995429, 0.3305715088052332, -0.48786438752455463, -0.21143103873789432, 0.22325535823609596, 0.2779172706706942, 0.40034882161571617, 0.23169692031069758, -0.3339117579726551, 0.5514499259389578, 0.07007390053532504, -0.2989188693270417, -0.3919529862848726, 0.4954141672114561, -0.4434495813495558, 0.4257610899033238, 0.5649539799955146, 0.03568158726543287, 0.20789818401144278, -0.10915529587259556, -0.18538697237726698, 0.5962667460894397, -0.6235781186733728, 0.27424597715092164, -0.4790787342722558, -0.5215448992162998, 0.14625879595645427, -0.7298627035949473, 0.5272879808383056, 0.25073260009988096, 0.011796282167395915, -0.5173814721257505, -0.3836165422088892, 0.4387111356491598, -0.42207486928916066, 0.6458732739821247, 0.5143453361257052, -0.20177872699192614, -0.4994006028815598, 0.20495480633910018, 0.5605617464639897, -0.40938634323313977, -0.6165295743820702},
    {-0.49921868871181396, -0.009675550544464236, -0.5052095188658479, 0.6771197017592296, 0.16233378586922698, 0.10116279161404738, 0.5738683838280022, 0.05388630949133605, -0.27800241911131945, -0.2993068614158636, -0.11492778190886781, -0.6634561771363818, 0.5624756186325713, -0.286508753217873, 0.26771991923250066, 0.08757892173951039, 0.7562883179150485, -0.6449429913879968, -0.4158548934296062, 0.3782806132349446, 0.341704080323648, 0.4019920328799363, 0.5119644649244893, -0.616421968412207, -0.48690359423286417, 0.1502562769857731, 0.5181330151133079, 0.5524605403867786, 0.5609212791313974, -0.12016482471820086, 0.6738107596511422, -0.24344822152053278, -0.4520374474009728, -0.1740177037669674, 0.667789326813672, -0.5320096668331228, 0.5461200050716115, 0.40964106642585923, -0.19849045915858426, 0.4844207742385, -0.07608356126156397, -0.26115378240703674, 0.5994436255679125, -0.29814768010554216, 0.013656452308612121, -0.6837303121905379, -0.4197819721200845, 0.3186631607164906, -0.5839124386442293, 0.25617799035068906, 0.22100436744948365, 0.2139981214747762, -0.27514815006682664, -0.3723074145294415, 0.18331502432561608, -0.4086362385218369, 0.5363897287297241, 0.29865071296567214, -0.17766183656839543, -0.44911868878392913, -0.01654741173956218, 0.44455785183656904, -0.24155501953859929, -0.49656791757285107},
    {-0.6663596454902412, 0.1711017840781531, -0.542044803660076, 0.5936773618360198, 0.3115474371765447, 0.30223805987843394, 0.6975056443060312, -0.15844511322354907, -0.2410593830181429, -0.6545671430241424, -0.19041502630269141, -0.41594917215168703, 0.4080008108198664, -0.2025242475691053, 0.03406887089761839, 0.28914301959878186, 0.7135553468261462, -0.7661085293119555, -0.33599908862296046, 0.30732279645693794, 0.24451525585109649, 0.5461508730053856, 0.26753092616724944, -0.5150780927289969, -0.5990261790385255, -0.25206652326713663, 0.2487620652693277, 0.34900761890530413, 0.531116854000024, -0.03367325921543648, 0.590007865812764, -0.15495243530614852, -0.3205195612665137, 0.019011673351682298, 0.6277194624348559, -0.6170170731219313, 0.3661790456921289, 0.06123108213527135, -0.05771128738580878, 0.29931259478020683, 0.0709435348900006, 0.1171550806713024, 0.48823434016806605, -0.10649703134019343, -0.011710971301177356, -0.624347111518255, -0.5186248175126442, 0.41091019832258274, -0.655926107004756, 0.5442930963567877, 0.5480675791514285, -0.06190245784857825, -0.5086579730271946, -0.4503382104456831, 0.27647463043470955, -0.5646981467588205, 0.5797977444978024, 0.3405070710834917, -0.45161675803143736, -0.7123301751282424, 0.11860791101577073, 0.36217863674888023, -0.2126739008102398, -0.5536916644451823},
    {-0.35374760461085575, 0.21739671770481678, -0.3621276056535628, 0.6250677460648479, 0.4534680388525124, 0.5969353875497521, 0.5546693908552929, 0.04584186606747439, -0.5050203306564109, -0.5604145891701013, -0.28901513541095813, -0.2669279614207366, 0.554722004231809, -0.17577687115175303, 0.15908528208459002, 0.2907559234967712, 0.7164576041837892, -0.7373802886695767, -0.7032516722768005, 0.7306492149093465, -0.048621886445452414, 0.5459996262488535, 0.43966007876988333, -0.5401063488454374, -0.6354896253506154, -0.09195375129189373, 0.40300837616745144, 0.1569638049502655, 0.17926953820483585, -0.42551611132571904, 0.3865942973697575, -0.08430546865692175, -0.20276676469422728, -0.08984921599881246, 0.5943599494630221, -0.4943528910510852, 0.343674310386466, 0.37790549445644184, -0.009977434960210474, 0.39951007383541615, -0.0030668780218217986, 0.1242163027571274, 0.5776913065933682, -0.30259055464947326, 0.05542458315003859, -0.5599919867875369, -0.3233479191394037, 0.5398953879258298, -0.7698424663640869, 0.6577297501353412, 0.5312779806406941, 0.09825756516735457, -0.6108106837111366, -0.39152959410961424, 0.5539603281556662, -0.5881690730354269, 0.4023951131186171, 0.2744987669527696, -0.11169664847624484, -0.6160816811823845, 0.2357723154522149, 0.5351828840001891, -0.5628116729647243, -0.8495875058530447},
    {-0.6277373146688316, -0.0353368936039079, -0.4486772575015077, 0.6420087354804358, 0.25812474140828734, 0.6085980618849661, 0.4229193381473201, 0.053206762739582636, -0.29568340574382507, -0.41376233864275214, 0.133958728703673, -0.5870403778500296, 0.685074510350348, 0.1832220528726267, -0.030522547731198668, 0.15964743780911422, 0.4783192093936662, -0.7268750462137058, -0.4626429217104199, 0.7772482481829366, 0.06250863050270385, 0.21135523946494583, 0.3058552153307067, -0.5877147401070306, -0.33863777396345407, 0.3738843101318366, 0.38077779846918514, 0.2501660382248065, 0.2606163926799373, -0.414581829299665, 0.7740313998156766, -0.19527429506469585, -0.5756663035682738, 0.15711293872804366, 0.8355135438165454, -0.3375050447028939, 0.4113966959045988, 0.44257194114544157, -0.01612342462739848, 0.39379919344197334, 0.09616814525228783, 0.28493428373032836, 0.36429916850902316, -0.2800328711953881, 0.13076949437924218, -0.758676382063175, -0.4611285151531679, 0.7207975862678817, -0.45465007394143786, 0.526422836261778, 0.6287119537796139, -0.19259857644102957, -0.5473086076140189, -0.5479075967935966, 0.46531980498103953, -0.5535075389782845, 0.7169760561610515, 0.3545653549241276, 0.06777670403580689, -0.48890069195783425, 0.03201316648671402, 0.6966563488220751, -0.376655207109492, -0.6522976087257791},
    {-0.5037137580649362, 0.15300358904352093, -0.29069693771638133, 0.5852699592542329, 0.23124572975596727, 0.37846879862988236, 0.5439632967158803, 0.0342616931642421, -0.364115237211952, -0.5718223001332098, 0.05737420874609351, -0.479219651262693, 0.7421986596737858, 0.07146256921959306, 0.003890569246323007, 0.4539562286022061, 0.811176541024379, -0.4148864358444271, -0.7308652583643626, 0.3824430707877938, 0.3777033402462343, 0.27044583250528337, 0.205302439441365, -0.6288488572531797, -0.30929193078537687, 0.25436992139428716, 0.3386872982430747, 0.4822006511047928, 0.3348960065582848, -0.3416138984959054, 0.529327023762799, -0.2366228879445258, -0.33558486853905634, -0.04719539190287545, 0.6113939877180959, -0.30408534379774865, 0.608324806036419, 0.6654964791950218, -0.020592915403815255, 0.5703763824577553, 0.3509133624621055, 0.35341232333267775, 0.5243177989497304, -0.24513258637000257, 0.25905452413831465, -0.6131225903742084, -0.3066104931950313, 0.5908820685126837, -0.5477105031846601, 0.6511856502266813, 0.6110976119475555, 0.027219139912004846, -0.3502988320544847, -0.4999668608406217, 0.40570323542341824, -0.6621026848044862, 0.8567446746020043, 0.38268953263260785, -0.041222672836014364, -0.5796845331649998, 0.17901260684998102, 0.3582539903992394, -0.7036271519411647, -0.6961999738931529},
    {-0.7276673147095706, 0.35039654147409666, -0.48489910914311884, 0.6073667479937155, 0.35901776097948507, 0.2455570055722517, 0.4504745604302559, -0.1487221182197404, -0.3985140220775899, -0.3393319223238391, -0.08706768101022107, -0.3746415630014109, 0.7085813843049659, 0.16954396135017735, 0.07816417101701689, 0.26932800753112685, 0.5281783611463955, -0.5839672643392491, -0.6275082665219505, 0.645325740308028, 0.08257642132486953, 0.4083658138140506, 0.5547308901173954, -0.34260645506783227, -0.2996897841304413, 0.1797939338434744, 0.44871388388626976, 0.13216543994119434, 0.5963587341331295, -0.4059408927193177, 0.32917369223086806, -0.40521639125954356, -0.6162430841671422, -0.021045176781739124, 0.5995265495072771, -0.26250608855229346, 0.44232665077377564, 0.41981853612402953, 0.03489124966616322, 0.3036519544113716, 0.30601728652352983, 0.23408270515262974, 0.5668560088555483, -0.1925870290557846, 0.2614294364376632, -0.5537484890692937, -0.5228765906580112, 0.5540175568684195, -0.5349596507416113, 0.2817622865435919, 0.6477574377236336, 0.06930937648543674, -0.3301431015435997, -0.5702239816618553, 0.3627217995926614, -0.6520205843521224, 0.6462636033252768, 0.22307967869270787, -0.2591402073786439, -0.7634651552855656, 0.2665853931829975, 0.5502791402260818, -0.2822475027983074, -0.7668427502331199},
    {-0.5682641504421093, 0.40127217536137766, -0.13963080363596073, 0.7535847400756424, 0.5151312712560802, 0.24862479613831684, 0.6983137681738809, 0.10903381920583197, -0.3235474326382306, -0.31129616835153046, 0.07419869761280104, -0.49263169961868164, 0.7336878447774907, 0.4318601604619934, 0.1961669420592687, 0.3835438603371024, 0.6434990742507891, -0.7412836592415157, -0.7119113964346063, 0.7446400602915766, 0.30949877954988264, 0.5078865788327677, 0.5673115727632836, -0.39288552993302145, -0.33065458773753537, 0.17964572086702355, 0.19047501486421664, 0.2638801656249278, 0.6864370958281844, -0.30386498422928143, 0.7014927314348334, -0.09815024368793725, -0.5710421425413384, 0.13380239070896954, 0.8451046600344553, -0.5528857589006235, 0.1962123040791512, 0.2732577804774176, -0.028753120160441056, 0.6497227172986714, 0.21450963950125096, 0.2486337656212899, 0.495487419158798, -0.10231910258995618, 0.4322399575944686, -0.5408903378777858, -0.5697765024146252, 0.3680571635205072, -0.7245852724203046, 0.4571965878161604, 0.3709096786927792, 0.07130695166729646, -0.5712979196497691, -0.2257822851043514, 0.36634052509251724, -0.6718604498554339, 0.7572194251559315, 0.5648848003540472, -0.05375540329219014, -0.5359115805897996, 0.23489213377164395, 0.6600041238397002, -0.1880641018993652, -0.6414123556800884},
    {-0.4270858954315117, 0.4620856278274951, -0.35212718678996907, 0.4314768877367153, 0.02966435064948116, 0.46098046342060095, 0.585729149522137, -0.08029763369704587, -0.5067810779413686, -0.6381736064733429, 0.008747670974526353, -0.5316691846015402, 0.8544477653997427, 0.39296951001886454, 0.44502613332171126, 0.26292071872259654, 0.6693440940573232, -0.5747498544774751, -0.6869936513888395, 0.48839048858503054, 0.13794904585941747, 0.3292619918469812, 0.5204781323223695, -0.7040384505551217, -0.6575080836380662, 0.3543847666539734, 0.16200556660335855, 0.22647408444542566, 0.5695978690926057, -0.34145432499862033, 0.5944998304993333, -0.2369155571919262, -0.5098648201894612, 0.21132457064201132, 0.6295001460687291, -0.1576559035695342, 0.3211829580713397, 0.5936766728097919, -0.10972439869512617, 0.41590384041973927, 0.27300048234302327, 0.01788907377820676, 0.4955033679600069, -0.0310436956364738, 0.3142958882650398, -0.5930023643579483, -0.6874978946838934, 0.3316587386609915, -0.43655997628797144, 0.7486264350232711, 0.5189910335807291, -0.0025680709247428686, -0.3518849157006411, -0.44987317015245115, 0.5819230687762411, -0.49370546867021453, 0.5365559691599174, 0.37687079625806286, -0.2910571637570106, -0.5916492270980704, 0.4056539662713307, 0.7121537789091728, -0.25720149076625887, -0.7630866339911108},
    {-0.6443752029019127, 0.22801140727571628, -0.5003386593564243, 0.7550927073994005, 0.3795771383008802, 0.6111709128977428, 0.7979285959473373, -0.19540181114771285, -0.24800599367045065, -0.5125082377598527, -0.03291204822487307, -0.6322770571885056, 0.6071141588997997, 0.16064430937955845, 0.41117542178070526, 0.21979433347879027, 0.7863211260642087, -0.6057414715908844, -0.7564918187337143, 0.6201954975786094, 0.004644771743089838, 0.5865555408314623, 0.2722535530670806, -0.6636713827488608, -0.42060806818201985, 0.4077409830042876, 0.2575409473216466, 0.19078460729834618, 0.39329239532928373, -0.29259031026303006, 0.5271597694886536, -0.18868584616264686, -0.40950265275371056, 0.13629721447666426, 0.6866599054487408, -0.22010530169613565, 0.4488240783923764, 0.5696528508605861, 0.007836187635490044, 0.45012316001148556, 0.10064998473608157, 0.1792269058924829, 0.639149858180379, -0.05348514210994013, 0.2767360793096613, -0.41848562455163146, -0.6108038509817629, 0.3426682883508134, -0.7355497781297285, 0.6748127107897688, 0.7037457176853533, -0.12211658170043306, -0.44029266939953865, -0.44495274993138345, 0.6548864000256698, -0.6736215861542989, 0.6688481798016879, 0.48184530365881456, -0.17202506521154176, -0.5369012249607837, 0.12510928440351285, 0.5405216101984837, -0.47840226338552544, -0.7256262702078428},
    {-0.3644488111415742, 0.1986706411052423, -0.09202817710366401, 0.5793450360304627, 0.254344999063444, 0.600495599067448, 0.782991770575316, 0.07731356040446952, -0.5247448133581415, -0.6696762856794489, 0.07230267219606752, -0.3932629698226428, 0.5423486611659756, 0.3345124922674142, 0.3771303054477035, 0.3118037801238182, 0.8150982229365877, -0.3660450071249498, -0.6107885547130143, 0.6163870247921033, 0.1372183911877602, 0.5048830573311662, 0.41252086900236373, -0.6317336932182239, -0.5153654657794824, 0.16295904299082234, 0.44091356617165894, 0.26852260787827187, 0.6342318052633209, -0.13956643931468363, 0.3394766694861271, -0.4962939788003371, -0.23978537264266603, -0.009948571446401747, 0.5122310849850067, -0.5207676382543623, 0.24968365835040884, 0.6440801725736238, 0.21578607197776123, 0.4239036850701517, -0.056601635729886995, -0.024118372513100984, 0.5576654264690676, -0.25547296616544374, 0.31938300957651933, -0.4868253855118349, -0.8443715671643504, 0.4673719035697565, -0.7870737472846644, 0.5812221463977736, 0.4408381331393268, 0.10087038286290821, -0.661981801857685, -0.4705756421796668, 0.32078635965128366, -0.7003472004199421, 0.7310580385919576, 0.44848398144095547, -0.2997636127175376, -0.6170239718278574, -0.009787194055540654, 0.30364081666786247, -0.23394799302179428, -0.5633351370945318},
    {-0.48735665099646175, 0.43653370390551105, -0.3927473212426505, 0.716884997526739, 0.37382760528872194, 0.4797840082083057, 0.4829578127572304, -0.08555996067372666, -0.5094812835329866, -0.4984541115298613, -0.008298567398168056, -0.32356335356027766, 0.47857940883762723, 0.3421839093902907, 0.26811211814913993, 0.21199602712078078, 0.6480882308117059, -0.6551764604614067, -0.6207630903848098, 0.4215649253829895, -0.03646494574414322, 0.322038630151979, 0.44635357710120155, -0.5067658380996454, -0.6514143636726101, 0.3960402538496363, 0.11778618914262919, 0.3907134265389312, 0.6391467538502783, -0.4558195949982599, 0.6427080776320196, -0.32094161546478067, -0.4009728924740533, -0.24859004528367187, 0.8935862860422059, -0.4846092671093809, 0.34462680777468824, 0.3304945396672675, -0.1549037876484947, 0.36934398960097087, -0.023545984033302166, 0.07277899424143615, 0.34456997389580296, -0.16757634247407427, 0.42820929222443566, -0.7538255305397885, -0.5519912801196091, 0.44023804024361696, -0.658638242024192, 0.6063858910737814, 0.6788147896164972, 0.04867621031697126, -0.7067518224789636, -0.6382308613434687, 0.49368191014587187, -0.7435609790483219, 0.8792275296211611, 0.47713032179485393, -0.4106764558845185, -0.7691147441970595, -0.011621895146599547, 0.5223289839653167, -0.5386919701565036, -0.8367533037799442},
    {-0.6120515491415889, 0.06530091133777664, -0.5526691874577707, 0.5866384162852253, 0.22208375576852626, 0.5605184008980163, 0.7387579989819371, -0.08569312181440895, -0.6002676664541271, -0.7001602165686152, 0.2183281453462519, -0.67617072691972, 0.7232580904347257, 0.10446271444728963, 0.052785262808748325, 0.27482433537817286, 0.6466279923925146, -0.7638852326833915, -0.7190581286676476, 0.7002763597535996, 0.09354246012650645, 0.6134458233637847, 0.5004936352988422, -0.40693029216907384, -0.6434788699741857, 0.10273035293106099, 0.22961856493996943, 0.471647880940496, 0.24208471362999956, -0.27132697337725187, 0.42256788253976096, -0.2899059065280169, -0.6253658925242143, 0.035738836837446136, 0.7971887847694498, -0.5383619541293096, 0.5601436054905377, 0.17850952180018206, -0.0072869946943644745, 0.49304246986128264, 0.25979397312291425, -0.057066453086524534, 0.6008977235326896, -0.1740339564810615, 0.23272577390835045, -0.7297943658119705, -0.7400111272290657, 0.5681694248194535, -0.7354058778825241, 0.7383277434518077, 0.583765394988453, -0.123961824676439, -0.3139164077779445, -0.29931405235787206, 0.6456516380957796, -0.7406864860259565, 0.8582782989004889, 0.41282857412116136, -0.18031219753609856, -0.781272008621599, 0.10423536872349741, 0.5598717792412556, -0.5521222430599501, -0.5109323736274476},
    {-0.4580109629268375, 0.10694585581273543, -0.2337509569243081, 0.7430771551556584, 0.36822669694839427, 0.6766497867957237, 0.6838781215668585, -0.06609609555999311, -0.5177745645965116, -0.7795826482318972, -0.01924407513000196, -0.6586688364845172, 0.7454803244905107, -0.039035092939124875, 0.20464672201636247, 0.3974255684019269, 0.8189220324883894, -0.6190224514407414, -0.6031022635266289, 0.5782363447487753, 0.1836438057392484, 0.5720161796725924, 0.3292351327655301, -0.577172132345261, -0.46770127587986343, -0.021420615396216248, 0.25390223575812976, 0.4633072924674732, 0.3679703857144521, -0.4907922975358773, 0.6156195047108081, -0.29790181137938043, -0.36289369031662067, -0.1308713730829791, 0.6554270020493075, -0.5916271481764361, 0.5087763797612513, 0.17840151290786388, -0.19925677352417218, 0.6072093288644437, -0.01925307313085555, 0.11670621194711066, 0.4110993719165292, -0.32439006833801615, 0.029355436061118727, -0.7295339402533809, -0.7078006930908288, 0.5725280006971435, -0.5836706251555762, 0.6928743970737039, 0.453126682298111, 0.12214207207015154, -0.7444871766824803, -0.3663009729807882, 0.6834794955430975, -0.7606646449098737, 0.5346120487296386, 0.565081640755606, -0.40012505941261484, -0.7143526798722624, 0.3408258424242539, 0.32190519130375067, -0.4624217402295339, -0.7599782515078964},
    {-0.5698766226910266, 0.4185080754640477, -0.23749513606287062, 0.6410688442627315, 0.24943355070512868, 0.5861541651031461, 0.5895363487018046, -0.05292751028879814, -0.2760828339248149, -0.6635466413611424, 0.004185897906163925, -0.44643665808343547, 0.7233758261587658, 0.0976310949686126, 0.17580453425972317, 0.36828605419691807, 0.8649917229825034, -0.41833297822055937, -0.6838736639696789, 0.4563466691999326, 0.3817545803969215, 0.4905384572041557, 0.631209302858601, -0.7468734405199553, -0.7811387916996062, 0.18349628784755678, 0.3626666013810433, 0.27059917252782795, 0.5759751574569555, -0.2690477259899884, 0.6409306127338447, -0.07582517350320873, -0.3942919809108866, 0.1204065863734681, 0.5973716845504528, -0.5408306068420411, 0.40478412774198635, 0.34299151340771433, -0.11593563334766441, 0.736443772924045, 0.16745192962676883, 0.18003781507220162, 0.7013528407056918, -0.41341814767478063, 0.052360794588346755, -0.4297575713561323, -0.5819454516177974, 0.6149823531941663, -0.7672331477620401, 0.5611608117857435, 0.4128212495881435, 0.15070174632246505, -0.5819284231611551, -0.5642807948543369, 0.6156254482414573, -0.8268650737277188, 0.6326919981035476, 0.5319821688029754, -0.17634809626211398, -0.49166925501508363, 0.31170238471015305, 0.35924142609927906, -0.5629461034207641, -0.8377547410591544},
    {-0.6518824908228017, 0.2093622267316656, -0.5780220902045884, 0.6785543482386367, 0.0811419112799976, 0.4644099457842992, 0.5951211686693219, 0.12301244240956151, -0.5226534988265737, -0.7828209129411826, -0.13992316185927198, -0.4790327123286814, 0.7838814609401258, -0.00524483849845704, 0.19581229714848208, 0.41225664460072275, 0.7576277781285059, -0.5606904196800688, -0.6732411275538625, 0.5352650436072798, 0.018729145053068316, 0.4425071913339979, 0.20653841282727642, -0.7929866850991267, -0.46491511583290196, 0.2802256282861713, 0.31699520842192824, 0.46067889041484067, 0.37411417013089937, -0.33454305770229387, 0.6641107572828252, -0.21056694352953226, -0.5780268544062027, -0.21294082162940475, 0.800120094520998, -0.29528814431057643, 0.2612779125719808, 0.3902397868541956, 0.06395919320434915, 0.44233288797479486, 0.37152476832693265, -0.15448885748604332, 0.5616307593971827, -0.3389775882744449, -0.03432322218725033, -0.7334307197085266, -0.8142693720291986, 0.653255320677187, -0.6245489451259427, 0.40267111136214784, 0.4898153106175812, 0.06885391815684747, -0.7236894669807695, -0.36152413295636665, 0.2553912702899892, -0.7690246000545334, 0.6848306447640409, 0.32327846630178747, -0.510207443577514, -0.6370439737612551, 0.01863330192278952, 0.6532671754129595, -0.7049057054962409, -0.7384406634077764},
    {-0.6797331301264982, 0.4035829297126079, -0.5331433567641058, 0.6581088603114621, 0.2927620935628108, 0.39730241510990577, 0.7645621200830823, -0.0479990834191485, -0.3655328944605361, -0.6071091717333846, -0.1391583182201942, -0.36101623507034775, 0.771244272069453, -0.07692491119757923, -0.0303480318271836, 0.43175555723087694, 0.748862957405029, -0.6492211929821787, -0.839997679123807, 0.7115032104576962, 0.1317709776460942, 0.3753710234233338, 0.5349115639145965, -0.6588345624219217, -0.7498196326778207, -0.016406608245252797, 0.5088670886492087, 0.2892273528303662, 0.2702161749014847, -0.5208728853542705, 0.7767506590016418, -0.3338992307972382, -0.5727894149939653, -0.006044154099219216, 0.8326344725787609, -0.34109437441577306, 0.5956839334317745, 0.24320624705405255, 0.1926254341492089, 0.5903827811173891, 0.4078766062058576, -0.11072169397396753, 0.48866118510342843, -0.37191631843733464, 0.26217603210601603, -0.5273148175851005, -0.781379784079309, 0.5211569472018633, -0.5762129790802343, 0.5312756214770031, 0.5437962257929723, -0.03409985671256519, -0.5156868348141942, -0.6315935985776082, 0.44300158947726986, -0.6634503738700446, 0.7594235264682359, 0.4235356423440781, -0.33907597159437936, -0.8729560503927337, 0.15319126350806556, 0.5879735388430369, -0.5318002105338141, -0.5562225104836893},
    {-0.48316183664768747, 0.3940259764820001, -0.22682990465818342, 0.4816759274068084, 0.2795616681918608, 0.6653822031096359, 0.44688398451070244, 0.05030531583605351, -0.20439437200898825, -0.7242951206234582, -0.1830665300854663, -0.36660014636992644, 0.676722508976216, -0.1116921422327695, 0.17556684549467985, 0.45558013088631166, 0.6678939750858145, -0.49971011803771315, -0.6436028318243059, 0.5741777540764149, 0.01193312827333988, 0.26046710090727754, 0.43511320690766436, -0.7153161601465281, -0.7058416757169684, 0.39382373964815937, 0.3877159119885837, 0.3449667686076484, 0.21887407706672116, -0.2314679187766162, 0.6511762096669936, -0.20630872597930175, -0.40302675723309245, 0.03561867476759849, 0.7988915876753155, -0.5802857582082463, 0.6070420674260606, 0.26416501755805827, 0.22445529285659632, 0.5296751272151978, 0.2770792376721941, 0.0018541934443796605, 0.6931932398220639, -0.25261424032305085, 0.2158750000708377, -0.44550296652550203, -0.7834066880666922, 0.5067608776766108, -0.6243780880530085, 0.5426166201948319, 0.3731128991425584, -0.10124236333588328, -0.4110261647983313, -0.4730843553148536, 0.6186561030435097, -0.6390828989912242, 0.5688095703182706, 0.5418759922990138, -0.23391326790460845, -0.6619774712754226, 0.2753904682382026, 0.3962501792939836, -0.5972624649774813, -0.6599034079093974},
    {-0.25350445845676717, -0.5767987135065139, -0.26091634680015696, -0.42705424344848525, -0.5575129208211483, -0.5807164375058234, -0.41584119453931223, -0.5666900730349739, -0.41020223602162253, -0.438266566504366, -0.13609181571859583, -0.29266565460051197, -0.19027058122073137, -0.35908476597185834, -0.5995648093699616, 0.4335069843806254, -0.2872425098518596, 0.008324584476158785, -0.15182610779559647, -0.7479042239797591, -0.8139196503640881, -0.6745602465760451, -0.5939756472663252, -0.00623505736103431, -0.501634153779239, -0.487339668786679, -0.7702373700549067, -0.3570453419055518, 0.03464567132943257, -0.4373550624815765, -0.5796410531426116, -0.727602175668814, -0.313537706588407, -0.48475317143319024, -0.10079448887503901, -0.5332979838710515, -0.3899309278136613, -0.6737896716989628, 0.2306388853087208, -0.3871842453464436, -0.14899237863145423, -0.14782872023532975, -0.5206833374106035, -0.3142271176288767, -0.2332507619297718, -0.24495285958632457, -0.4919980947529218, -0.561740810845758, -0.2729771953998576, -0.5002338770166331, -0.703025200928557, 0.2373039100888544, -0.6196882949936654, 0.16889138725080438, -0.2720648449006131, -0.17890308425926582, -0.7300256455568639, 0.006835896707770241, -0.6420496938169626, -0.6951927434005407, -0.6633007501335577, -0.625178687635694, -0.16283802697381314, -0.5993320873902948},
    {-0.03326428270764217, -0.4376519942911112, -0.38776890114803975, -0.4768510872928006, -0.1918823902695692, -0.07639726111203288, -0.36802961540691587, -0.06141113512834945, -0.20742329338728857, -0.18251122213648482, 0.22976091037379465, -0.0654667566663157, -0.03983021046364163, 0.10013435679459726, -0.23623068550086346, 0.06695826672702991, -0.08116250401824425, -0.47389367319798176, -0.08976596907539022, -0.5518891946075914, -0.05122449348791497, -0.5419473085807491, -0.3795744388263841, -0.4309245873836536, -0.004249059771385792, -0.6179794176528484, -0.3487726321219285, -0.33265330933270737, -0.3606494667607576, -0.4567873515576691, -0.14061706616039032, -0.018145448800250583, -0.5503884507578245, 0.02778623165833111, -0.1972941590585534, -0.21867041910590082, -0.39730999378355786, -0.15486990399961767, 0.4144840390969948, -0.577296966381634, 0.3801869056239029, -0.3409310164847787, -0.2318120902229294, 0.15142854001265274, 0.01359894675195582, 0.051129432009738254, -0.43514168212756144, 0.1063529803775911, -0.22407919901516793, -0.5122081696219142, -0.233611294290952, -0.0689871226816811, -0.3661213199660547, -0.1310967463359425, -0.03566656581196417, -0.021386582437606844, -0.41292323775186, -0.2906423647196537, -0.19140701025989842, -0.4447141755952161, -0.3256158396505752, -0.37087891215679325, 0.24895636469465468, -0.2758845518155086},
    {-0.43116107691623506, -0.44707119899382414, -0.4031245298040005, -0.6783330767068377, -0.006046465416276226, -0.4895267554153498, -0.3253122071732475, -0.29363868419343897, -0.44199153025599625, -0.43053811710549217, -0.2569066136446333, 0.0002606655569148482, -0.3269940441638837, -0.5757016302478077, -0.5823058577990851, 0.31973598014925164, -0.32193884166034525, -0.46296729153144983, -0.16604363162351102, -0.4932167834245272, -0.5452618306937925, -0.7417986207165999, -0.5268271315697889, -0.34137786395259834, -0.5784712796803041, -0.3611875858903625, -0.5038835077099023, -0.36383477943385417, -0.4529915276123766, -0.5086627964993459, -0.41390849203658986, -0.2324793049515493, -0.47636215323923203, -0.3325131252408809, -0.4001193258441407, -0.2932647390303171, -0.46317584219430774, -0.40835445494478173, 0.5033649990049254, -0.7304395562618902, 0.2561308943464525, -0.44318534888456196, -0.6672776841806957, 0.027734363071350108, -0.5246842959603408, -0.3531798095943611, -0.2362902310934587, -0.1843457626114435, 0.02686345950436753, -0.30813853665402274, -0.5786762208043427, -0.3273467514520882, -0.560431709146443, -0.336353237554338, -0.5949755322191882, -0.5456187455096836, -0.787784277142784, -0.6280921621620783, -0.3310937384865567, -0.6530297489554129, -0.5253707273806132, -0.7970619278676416, -0.06798655779522175, -0.5043872059644194},
    {-0.11179029721319886, -0.26383549473687073, -0.4568216383469684, -0.39128521506914227, -0.2398406378395649, -0.20453811161808602, -0.36177023413431286, -0.3830242476794226, -0.47237531427449414, -0.20150083256740028, 0.013774595089724936, -0.01580419810729233, -0.43363820312003976, -0.412212502386311, -0.28423539624776223, 0.27677046832798213, -0.4907498527603499, -0.4026970046670704, -0.17557357144701347, -0.35338463279213095, -0.5580394455383159, -0.5467789959305859, -0.287956926824069, 0.038610621070554255, -0.5472646866462086, -0.21136746693722677, -0.6780471119861184, -0.22785243050692766, -0.0420998786297263, -0.39610396585527274, -0.20046088074696175, -0.5334637765275064, -0.35840476401088556, -0.39058372653682905, -0.07207631807593738, -0.3412028727509202, -0.2387534810763851, -0.36816403637478956, 0.425471306745711, -0.22952243923805096, 0.5486759281561056, -0.10840636752388669, -0.5659684002236329, -0.03253718576013439, 0.025675327991801684, -0.03578437962363888, -0.4816531181210658, -0.04996853974058025, -0.1495188751262584, -0.4136450769055102, -0.1430895737393175, -0.2857870760750509, -0.6093519796773943, -0.444280842402659, -0.24625482060078507, -0.08635625502943511, -0.40528131832026887, -0.3651861662479027, -0.17589992196086215, -0.6645700509132761, -0.5407212501111307, -0.40348161654378306, -0.09428244176173976, -0.11746449524766822},
    {-0.19129577044289314, -0.3546834563879045, -0.575489447557452, -0.4634435089723501, 0.42982816986393213, -0.2904263928658698, -0.24550535312694424, -0.28524825302781, -0.6250978297307062, -0.09018102895415676, -0.4006195880777206, 0.3229766041372837, -0.4666626199686849, -0.29904791701164657, -0.3875133017859544, 0.34015023407025974, -0.37662609039502287, -0.5788579370969414, -0.4207569999844027, -0.16371817830299767, -0.13470370940380152, -0.3738826397101907, -0.44995526090299875, -0.1639631688601309, -0.29578159775592827, -0.5161764897828004, -0.32792779800280786, 0.09379059006451144, -0.5570457239615973, -0.3613101788396123, 0.1296368673744467, -0.12288413920251867, -0.4014192030762952, -0.42635986648522906, -0.11419603605899734, -0.3894997384289641, -0.37903768685345934, -0.6264420951435636, 0.374859413372603, -0.40823983744821407, 0.5445508707654092, -0.32648069880582636, -0.16961448616126956, -0.32546410596840497, -0.6010884680789056, -0.14099127495447514, -0.3788752122821224, 0.3668413538049074, 0.29800586036357724, -0.17735388902819066, 0.04663723263577369, -0.3986864668954724, -0.0403188622623003, -0.3421534369718539, -0.34158774475413695, -0.19841794330768547, -0.2151856272219685, -0.3000664532795971, -0.21180384712625563, -0.1922557743960105, -0.02940227491659829, -0.4467426127959186, -0.3144640207167355, 0.07484745107432118},
    {-0.05642973309511288, -0.4330884414449978, -0.15859657154939136, -0.5141613659817263, -0.05952970764485022, -0.28043909735450645, -0.1197350039726893, -0.3669656454880755, -0.51613084687641, -0.10952726365295908, -0.32483723152260857, 0.05176293942125956, -0.2461482468853292, -0.4216085103649562, -0.3921737213263723, 0.18309477553864198, -0.021743818561132836, -0.22967333275662646, -0.5076957336630137, -0.3551924825539475, -0.3114392661588395, -0.2104016455990848, -0.5864623894761668, -0.3634461079424527, -0.3895679174082906, -0.6314580051953826, -0.28798962453170873, 0.19013003005723128, -0.252971149849868, -0.2157602543214031, -0.14077747248071085, -0.025297653120096596, -0.6290887855689736, -0.031967120813479605, -0.3112398711000634, 0.022218569415631915, -0.44449394734731335, -0.2583209117041484, 0.2141431484775065, -0.4964163641947848, 0.2567258093956655, -0.42991500436294683, -0.27286267314546314, -0.12903296908967862, -0.36335084698059983, -0.15540720127791285, -0.3573125900640629, 0.17243010369094713, 0.11233710126904105, -0.10079972527271963, -0.07890119544618958, -0.12301911945362846, -0.33991720144403603, -0.610664389431361, -0.1633242228959886, -0.2838293453917337, -0.5201457503282026, -0.45652206332753337, -0.30458526799455155, -0.4955679735433789, -0.3403792781383538, -0.606263919761459, -0.1063131814867569, 0.15672790740222015},
    {-0.3406231477644424, -0.541641485805809, -0.23327902595671943, -0.4404758750975864, 0.11994467341250649, -0.4953680433769361, -0.282892107602316, -0.6153327595284571, -0.3608579136560658, -0.29615347711750833, -0.14117696114177453, -0.1465428226739341, -0.3317897145305908, -0.6117310562899576, -0.6684719545552932, -0.0982628195335238, -0.1175805962770462, -0.5039446617376295, -0.5182401458970077, -0.7237518706789624, -0.5317045551386125, -0.6054054877776159, -0.3933389751304235, -0.1308219062920568, -0.12317478243137508, -0.4086854117434946, -0.22704706768703556, -0.17123924031129656, -0.4227935553224192, -0.5658112911762487, -0.03517548627677149, -0.35416086191524465, -0.5785121552362229, -0.5904614674131048, -0.5042052909320299, -0.3963492845445244, -0.5404369071182499, -0.6962152452743716, 0.12109894737007305, -0.3216268895916176, 0.19975228835579567, -0.35840937397214356, -0.5019453451521242, -0.13046689992852453, -0.18471584559529802, -0.1203886902608387, -0.13873516752187584, -0.270123674269127, -0.23536909942633988, -0.440654117257648, -0.2648382380161794, -0.3354402620744642, -0.3665337800023043, -0.5433513815315645, -0.5340124397645605, -0.4228762072014579, -0.6705601345866486, -0.403850754123716, -0.34251410964511975, -0.2977032096613953, -0.3842365511647018, -0.3270697785688634, -0.5556519911838542, -0.0844193157187583},
    {-0.2101320571148295, -0.3397726788018922, -0.3242334205489167, -0.18580833425707644, 0.02302855991190818, -0.5671940040535636, -0.12084610823660943, -0.5196540202700008, -0.26473426587874405, -0.49454816657136236, 0.0825439910539733, 0.14696183094406395, -0.3754730721522594, -0.23814154959894435, -0.30267160184009567, -0.08830015293444304, -0.5299307955831264, -0.5382473694606489, -0.5758976761264006, -0.5796273343091682, -0.18534720883901323, -0.42430542381273384, -0.12258832539238677, -0.347148825327139, -0.09601533874736244, -0.2861736685412807, -0.22680261940412091, 0.26641203655086876, -0.09252797926533328, -0.12848622069662585, 0.08818500270543464, -0.06802182854883547, -0.4874568597503649, -0.3840608181640351, -0.3701468868896094, -0.5030712345455293, -0.5243913198888864, -0.3065324989658061, 0.07362202101863013, -0.1866564586944346, 0.3880309641868608, -0.5016027290941769, -0.30456050942168716, -0.2699787571597048, -0.05961218132076327, -0.06603887688756328, -0.48116546024008633, -0.12370356736551387, -0.2552255850677441, -0.5874124907359317, -0.17913273445229289, -0.017796514441674224, -0.029342623029805795, -0.5880659040906838, -0.22106666565333125, -0.15044507185745676, -0.4439125693837486, -0.5214188207882338, -0.09321564627117036, -0.4079207310081727, -0.3738039537016076, -0.19111933220661645, -0.43824949772583194, -0.09360378134695352},
    {-0.41476666254721084, -0.23906435727829842, -0.633477594291363, -0.4248210698474437, -0.046315251854848485, -0.4938843427996094, -0.042774349857554114, -0.2572597542176091, -0.26129732857104243, -0.4170649379056566, -0.05269305327357165, 0.2918486567517292, -0.6102541227957905, -0.40800827019982727, -0.4869277785880407, -0.11718204647722934, -0.4092282003206916, -0.530360327597413, -0.1907798098467323, -0.2534847270476707, 0.016089410190598504, -0.3439369175335039, -0.5214065414893211, -0.41566788862409276, -0.29833253216189554, -0.4939441243961788, -0.04312673424151063, 0.2208893623739648, -0.5880085337186466, -0.26910486156765123, -0.26737093264052336, -0.2537336077683439, -0.6947370514514404, -0.1887211268536652, -0.3402513252979383, -0.16695855246090488, -0.5626085356511408, -0.44963574407354046, 0.1078879156408669, -0.4029726379854832, 0.5185610617926821, -0.6359474411286588, -0.5603813571019789, 0.007455474086567408, -0.3651560815166664, 0.016088433047580442, -0.47416470692580037, 0.2598050408540875, -0.08327781072980689, -0.20865480935015204, -0.13973263588105755, -0.2600591827816837, -0.09194525343967347, -0.6019642611451667, -0.49401297624394336, -0.278065040671786, -0.3898403015330702, -0.12156869949908368, -0.3916797814049984, -0.15152453931009113, -0.1716676431821297, -0.1452718147908061, -0.3967474913528089, 0.032831649561705235},
    {-0.48575365523306463, -0.5962520183444197, -0.42887311936292916, -0.4871256360426367, 0.2491573617100118, -0.38300104994911754, -0.32978260775175977, -0.3501727642880391, -0.3313544156834569, -0.5777716358333121, -0.22469124911884317, 0.36987822699881207, -0.7343357728962716, -0.4121796105155916, -0.3999124452950361, -0.02411461116996526, -0.3397591088535205, -0.22615998326182582, -0.30602549573865, -0.3372798664797118, -0.03444016336757564, -0.6732109941888403, -0.662251538228609, -0.5406042280742986, 0.023439715227129423, -0.24155982143159505, -0.2849239985704399, 0.0979752627652557, -0.5801104071424754, -0.5840479310073707, -0.11813448383165212, -0.07312428817487779, -0.5831635012905174, -0.35208437127648934, -0.09817026444606383, -0.21558956342113503, -0.5465950020775827, -0.34659029401720476, 0.38665556843342863, -0.5122563216504677, 0.4641972513135092, -0.3704109297789389, -0.3892855084423562, -0.3198377465962043, -0.4102170276777573, -0.038869903368937586, -0.1808201930464939, 0.21986462364471507, -0.12223607652578129, -0.3808829941131389, -0.060303522795576804, -0.2363333029480741, -0.2674553020520581, -0.30377772111155565, -0.46243691480210664, -0.32201050317090907, -0.21204175703797293, -0.23051466072413618, -0.4375477996672063, -0.18689016489850255, -0.21628130256302025, -0.5275751184538036, -0.5755652656726924, -0.19149132837064667},
    {-0.5212067312242183, -0.35192614122894084, -0.6222813069176495, -0.38488504884159147, -0.1372458289772397, -0.29682353127872646, -0.4544817078082962, -0.4076606380457803, -0.5008738021904439, -0.5676092965196515, -0.3634703358603419, 0.00043366707047563606, -0.19213405462729446, -0.5071133894852524, -0.2361416196478079, 0.12532075678507604, -0.19315129942556483, -0.5717076813215907, -0.3215994432268361, -0.5611679020687252, -0.5169488359133279, -0.5222201265187019, -0.4854606625459187, -0.06699666564766973, -0.11730428765150161, -0.4886466043916116, -0.18531491962015062, -0.14067972974517615, -0.3277523133094268, -0.1953243178153374, -0.0189575314960262, -0.2817107582815937, -0.7490161310255657, -0.4515686365827368, -0.2511376839737395, -0.5033735924015709, -0.5118780444497205, -0.5301853925814977, 0.20759023591302844, -0.4005533019808086, 0.4185894314158692, -0.521634381247307, -0.4487708127704139, -0.2498997565239423, -0.30327009950512057, 0.1018472021048785, -0.4555315098813957, -0.02262031205152242, -0.08045930749454341, -0.2489123363919512, -0.2861132053843278, -0.06455866464896942, -0.35909972223061104, -0.183871447028816, -0.32350737125870105, -0.2549372551269657, -0.4277478602785037, -0.08384669677220416, -0.5590045610928062, -0.48858185684769073, -0.3781191046559665, -0.7076116399130594, -0.09751710217197994, -0.28919906329967154},
    {-0.5152436210355453, -0.5853412282768363, -0.450844377623078, -0.5443266364684028, -0.27846362644800887, -0.45844080992298925, -0.2153982798573063, -0.473307783945503, -0.6484733421284106, -0.4758996549108697, -0.12860329535699483, 0.19156541822143897, -0.5291061185666486, -0.574854175893873, -0.3843086637995111, -0.08586644362599617, -0.1049407914020169, -0.3176687675607997, -0.32365404957909216, -0.5378958935640883, -0.5203637476922265, -0.45367531115906135, -0.5400617265736307, -0.09225696242973802, 0.08895111520641792, -0.6285727214430099, -0.15127821710001005, -0.1475370471366001, -0.19505768461669373, -0.4462606742106251, -0.1527273615701055, -0.35392993784386595, -0.693549850660348, -0.3017576426460995, 0.048508235209848906, -0.2373676266231634, -0.5808831210473819, -0.46193251397401847, 0.4251345353217875, -0.5692142835609273, 0.18047031073589734, -0.6713057825505081, -0.44919744949210727, -0.5152074429952991, -0.3590391953548798, -0.47167365577197795, -0.2103807194984654, -0.19794685570086093, 0.0607198828014369, -0.3978137228645524, -0.15524532538294208, -0.2341676277083893, -0.4381697270675444, -0.30941520641515663, -0.2615966898508176, -0.3376985898267973, -0.6191507626799709, -0.3796127005771433, -0.5324072764688629, -0.3383974203585911, -0.40434980551486394, -0.5626306132182232, -0.32653634955817484, -0.3636276901874642},
    {-0.5606737386297446, -0.586609030943736, -0.6344699098602552, -0.5410299011284332, -0.1346093241962817, -0.7123865013824144, -0.32786936316455245, -0.7473697085679348, -0.663358956244746, -0.453185630373713, -0.12606592948225157, 0.10887317832461442, -0.3255672193520747, -0.3580678472654907, -0.703764141355197, -0.18153765962452967, -0.3901950906791401, -0.303568562425092, -0.38183203697561213, -0.3372980818252443, -0.5031921848247085, -0.4689466012522694, -0.4057703176637353, -0.1232238462642058, -0.06867966037781022, -0.4265470108684191, -0.3188620293368241, -0.03151984183661772, -0.3946742811756798, -0.31743702034189647, -0.07198859258394832, -0.02788941988729712, -0.6635824028865895, -0.4046321220739594, -0.2905009574907107, -0.4889237196482433, -0.4089209018277215, -0.3991575571778759, 0.3734572032716672, -0.3419116176612571, 0.44799464998511146, -0.5576166187845563, -0.44233316435521847, -0.45944450415420385, -0.5950179066014032, -0.28984318011623067, -0.4253579960562998, 0.0927612349794275, -0.22053062811531277, -0.34468668245882267, -0.07565786409798662, -0.2848670625871286, -0.15580318574273597, -0.46285749835335976, -0.7046962130698992, -0.4208723295430179, -0.3320924939406003, -0.22912120467993038, -0.47348064649617505, -0.48495589900556274, -0.29658354898287587, -0.6793264459578089, -0.3468699638493712, -0.04348444448173944},
    {-0.6437012412657713, -0.5479840586837458, -0.6708959741435818, -0.4456450931499908, 0.04221757472888576, -0.2241811517508671, -0.5494533003101946, -0.4390507360115564, -0.6931634778990976, -0.5374419294732934, -0.08097460252994493, 0.3582598963175278, -0.24707252362871332, -0.48158831957178844, -0.39545264162749416, -0.027844528544854804, -0.29452682683352743, -0.37344493771675136, -0.2980824704578881, -0.7290329389840454, -0.30031961425904674, -0.5662335791607943, -0.6352420716873723, -0.15510097098748502, -0.11404011922066627, -0.5691777721829524, -0.45891170990037417, 0.1262166158446752, -0.22380315493098565, -0.624516513646546, -0.26406272166169226, -0.18418941470714228, -0.3921145352210208, -0.46274980854482217, -0.260023697003782, -0.4187983259156681, -0.5654897522470592, -0.3654840135916839, 0.32424193429638687, -0.6731885406544701, 0.5147268760175476, -0.45050267423066526, -0.5877980889258376, -0.33482586076460785, -0.49395392817213274, -0.3602055918236683, -0.2830674848103775, -0.1397348497961935, -0.2005680849139162, -0.2658008720749163, -0.2841830061291392, -0.49945388589931555, -0.3503098296991381, -0.6185047934163764, -0.522190812676546, -0.3113200866245485, -0.5441708918821101, -0.2707397852802964, -0.6989738216987595, -0.28551295421291856, -0.2196883822545066, -0.39479670306011405, -0.2938054272701319, 0.001744074098004627},
    {-0.3271550824419163, -0.5962378533152891, -0.33074334279352424, -0.5328242152737565, 0.3489788376382409, -0.2355151804398416, -0.3366092586087977, -0.36059692679628796, -0.6836760445750639, -0.3839309054811783, -0.3121720616863648, 0.28644251031852946, -0.6785681914823026, -0.5649669518554662, -0.7748899582316268, 0.37230095623878484, -0.2980869834309222, -0.22162419722093293, -0.22099145659642436, -0.4627627039689108, -0.13510718232604696, -0.68976569263481, -0.4104872150085556, -0.29054163555665435, -0.165917193457205, -0.4421928283774702, -0.5418788191124981, -0.04231989299245048, -0.22032433915570668, -0.531459574505805, -0.20883624247543423, -0.35602478610561655, -0.6547552812046245, -0.35087888322259164, -0.24374441391678808, -0.3184378473348608, -0.7449369174577668, -0.7768559046343196, 0.5189906987750283, -0.6637615151729206, 0.4950304569074945, -0.6267760873915836, -0.4554832428982076, -0.09156982652246588, -0.44670839332149403, -0.3613789486844239, -0.24157091793046462, 0.3905179089116278, -0.11170164271666078, -0.4357314552519101, -0.1481181753863427, -0.26698143305513133, -0.548999170646986, -0.27534792347792086, -0.647416610877537, -0.26932022516203824, -0.3674323549942898, -0.31754925319677685, -0.7404556008293588, -0.28761699976597815, -0.44969274513287966, -0.5872453210425044, -0.13077529393383316, -0.04982620588550812},
    {-0.4555448504521808, -0.45983543561755175, -0.6427652659539358, -0.4360946091979058, -0.09023418845308272, -0.4240332514386309, -0.38478571774633225, -0.3137748173789393, -0.31031681632013863, -0.4632108261714662, -0.5050631993379301, 0.5349903115810858, -0.6589768416625128, -0.43603296646556927, -0.5763733053186476, 0.34524562435298844, -0.2276742258721011, -0.38696875347362447, -0.35519471359768034, -0.6546763898800461, -0.48694510269442837, -0.4362687565690192, -0.6403334765839943, -0.16329448800323026, -0.49974318380139754, -0.5038035663646987, -0.3281484302617842, -0.3149837593905525, -0.17875691136579036, -0.4371270522870374, -0.1327128325655532, -0.5047028805994371, -0.5604465314319831, -0.6740288208496906, 0.011355128829968563, -0.4643205887536214, -0.5149826298735429, -0.31836189322147523, 0.3082463824767545, -0.45810965310124746, 0.4794124527291405, -0.25560358351706536, -0.7345013627597264, 0.0983909922836671, -0.48425614693475877, -0.29634385930541296, -0.527386308210271, 0.27182294090115267, -0.303807776264685, -0.4160463754386607, -0.4657102396789439, -0.20487484129297748, -0.2876476535693936, -0.48105265400900865, -0.29855659455142664, -0.36607409783771677, -0.2929967637986918, -0.408463386305865, -0.4181298137959775, -0.539993118363432, -0.693333779417073, -0.6755733072555226, -0.4535375952275462, -0.27265511998370745},
    {-0.12633865663185326, -0.2626086011024931, -0.30408310215514783, -0.31357549561541215, -0.09398570912254778, -0.4874381968755178, -0.6014589053076015, -0.04682295057253249, -0.4827840343451673, -0.4488534078221324, 0.15257874054546217, 0.5212928219626518, -0.3421526566276114, -0.4677669126898562, -0.29182631416516885, 0.19906137130983012, -0.3856352666650573, -0.29244180183941215, -0.38317574885282313, -0.5188815278426582, -0.18906737103252272, -0.4682612722262296, -0.25971987387122486, -0.39283121168518004, -0.354911409620744, -0.5642275174772842, -0.316544384801883, -0.24571752473513914, -0.48008120483598454, -0.28354502841087786, 0.022134115671886, -0.3706866678216962, -0.6846394451098771, -0.45349466967743246, -0.16315622729723567, -0.49713017790590086, -0.6024047161389718, -0.24007466861310164, 0.4471789875875062, -0.37361436597931047, 0.6421921581007424, -0.4448220054268069, -0.7305701290868563, 0.2553896733852411, -0.36509762779382277, -0.27816729736899204, -0.34019282392376143, -0.10428302900160631, -0.31155821601401373, -0.21879166323680202, -0.0905109620405776, -0.05132847538297342, -0.6489905159553413, -0.20919244163271872, -0.3381225578957642, -0.5348356560615882, -0.2691695115962178, -0.440583197392105, -0.5856517330394244, -0.6826292021701688, -0.4513116361144431, -0.6342622486511189, -0.3674426507989794, -0.4576972582454567},
    {-0.16933931946176495, -0.5646863452476506, -0.1826830064274752, -0.5415760190216611, 0.24812770312817245, 0.07951762507404253, -0.34292933465858294, -0.2071835948849406, -0.5030955548665927, -0.407548390474817, -0.2623018507712767, 0.5124605590819148, -0.5147332700658187, -0.6440542598926868, -0.4637611070171693, 0.45735115508518287, -0.21583050963801242, -0.2829809324783099, -0.3275905135670914, -0.3117734711717199, -0.4342330621486215, -0.5358258896124345, -0.23000675756646727, -0.42615308009594666, -0.4542437326122625, -0.5081646186801064, -0.5516712079038335, -0.09372198621765097, -0.39078351778932885, -0.29440364193554025, -0.0907822570921705, -0.15126965992112565, -0.4766804255473262, -0.568883898035404, 0.26418336548731974, -0.5703684940934666, -0.573616280589165, -0.6332478115100195, 0.5804485690118146, -0.7270511858442226, 0.5742353227169044, -0.5032192758593387, -0.3510746471361729, 0.13495585231164192, -0.16392263785433903, 0.04172162951916435, -0.1912143910173097, 0.4026021585709816, 0.28616170940963753, -0.30240495755202623, -0.3299332292980967, -0.3362884454761619, -0.49473702009996257, -0.5163356354689744, -0.6124254054671067, -0.462298464836046, -0.43075398203962934, -0.19866168883569105, -0.26390797314325987, -0.6183989827022858, -0.3347913171508467, -0.6911921465607723, -0.1351672330033885, -0.07831651038635667},
    {-0.33678525254698516, -0.525432092169851, -0.4501068017893528, -0.26944454865719186, 0.04360356522056556, 0.08365641285409396, -0.4719216806243408, -0.13391827117936755, -0.41443992704143207, -0.5315587060912755, 0.0009062661414725914, 0.2948440363292759, -0.532582463629614, -0.34306750004817604, -0.47024864787806536, 0.4887860831612101, -0.2764075260776727, -0.5230648442378876, -0.5500233342901647, -0.46733414496505493, -0.45966680655601183, -0.5336466583443717, -0.28678620852773384, -0.3351335103704401, -0.446031497583449, -0.7842778001883718, -0.6553229083483102, -0.3420728532143029, -0.24327747851241363, -0.5101409774286834, -0.41720437156108003, -0.5803009512004386, -0.6947719275700923, -0.3940591708773475, 0.12153123095375798, -0.7786466881597243, -0.5648046836858875, -0.4028872086840643, 0.6229737950372053, -0.700843900291723, 0.41801850261407064, -0.603507329741251, -0.6330945529964302, 0.19542369327296077, -0.4393074884952129, -0.07604576655744141, -0.48654049163909774, 0.30876196953723306, -0.12091915649438989, -0.41674124880827074, -0.18834026344374244, -0.10900070087555687, -0.731287355708018, -0.31753162161211845, -0.5113869824512428, -0.3480668639703815, -0.3043016276081326, -0.3192814354783402, -0.6354478719740255, -0.5313574002819982, -0.43302209565471944, -0.4973082042973405, -0.17484997681688955, -0.4212982746146145},
    {-0.3806486528279062, -0.34404666126870115, -0.6683583105210903, -0.370308921782334, 0.16011985876810722, -0.06990542367042742, -0.7007453104404158, -0.4832317945084233, -0.40171802250070626, -0.6381992252606112, -0.1285622412597376, 0.5195544507913601, -0.2827476791127139, -0.7378156978949828, -0.654956129926518, 0.3793518572985519, -0.3602287267300756, -0.3969690883427112, -0.6055507241229148, -0.5500997182305979, -0.421223961650668, -0.6388482210609535, -0.6498380989215199, -0.2650434338916554, -0.18368417480211602, -0.6615862787575688, -0.6058847778073262, -0.06502731706644474, -0.2425534987897087, -0.6898696739372386, -0.21623044309042624, -0.49734921666947746, -0.557099055212938, -0.7256992211021728, -0.32124305853361473, -0.5965119285719258, -0.6214500596856324, -0.39103219593917027, 0.305814317021271, -0.7024280098215762, 0.5123727621296816, -0.4311094956696289, -0.5190361831570371, -0.12588644329578103, -0.3300123622234975, -0.14107402348092238, -0.36970857886636055, 0.17324636952778644, -0.18830208225948783, -0.547794334036863, -0.20237227400160912, -0.44042865120954744, -0.6205324911145138, -0.2681696735920399, -0.3594584359888565, -0.6038016835070533, -0.39735362906949373, -0.24710779122788373, -0.5236237013307208, -0.6787447995086031, -0.6147267631998669, -0.6371203508727096, -0.40000776498466767, -0.24347750454303563},
    {-0.46868119872071284, -0.49773958109491223, -0.45408099801556, -0.7066978665658737, 0.4612112031294209, -0.37053122256463195, -0.5349977704943393, -0.3000208209284382, -0.5453409507913133, -0.6884622214051169, -0.22585540111046867, 0.4937741394057334, -0.6374006768723819, -0.4201908335215241, -0.4682631246219134, 0.2428783795728738, -0.4250710874781713, -0.7018915609664944, -0.42186194550300793, -0.7869104877045935, -0.481655473613204, -0.6159975443255183, -0.7299158101125718, -0.22522223504205457, -0.34651456990729546, -0.6600613186502757, -0.6907182275520414, -0.29939242806091626, -0.4875695436572158, -0.7706304378858985, -0.42745482718519984, -0.284398935266291, -0.7271017608938588, -0.3799837496693361, 0.00695529863099615, -0.3992491850769378, -0.6813847965518065, -0.7232911041378214, 0.34663691822077786, -0.7959443784267738, 0.4531197326644784, -0.529345601015675, -0.686849738749963, 0.08828908449445542, -0.6378842472747849, -0.4286649714588474, -0.41023547802276156, 0.13354338590394238, -0.12037606997647571, -0.4068367403752904, -0.4711436620506552, -0.5174673534307955, -0.38714256895865173, -0.41977076988891904, -0.628871901307113, -0.6422372240929827, -0.7044391660177639, -0.3226782391166984, -0.7570961162337797, -0.5226141452652313, -0.7376127923276607, -0.5630558540878726, -0.12985076530790898, -0.5540084613085838},
    {-0.15141573876274106, -0.565629819096137, -0.3450061311968543, -0.46199606075244204, 0.6740855728327613, 0.11257452737971431, -0.620291720323518, -0.28818682072142904, -0.597109911098146, -0.5153901079661405, -0.19613230412999208, 0.6190335521743078, -0.47597003156871603, -0.5453993313607003, -0.8025512511982533, 0.37754040593256655, -0.35613966272231107, -0.33072989075174986, -0.087750049067353, -0.6504452468477956, -0.1871102889228509, -0.5918741788882886, -0.6408235462329833, -0.47498666810789003, -0.27373002019087667, -0.8450216103042735, -0.649892228734926, -0.10393302853182594, -0.4670535478282023, -0.7347309453890534, -0.14123467788113653, -0.3131792355200211, -0.7346337254816883, -0.6795387078998886, -0.0393889762473035, -0.5769823883772194, -0.6054176322937999, -0.5143785545758844, 0.6180617116773051, -0.639410116545709, 0.8138819197346089, -0.7104851668296108, -0.8173804930632875, 0.5002881573533567, -0.3582921388479595, 0.027602604726242628, -0.35792193077724427, 0.3285686420050307, 0.33517709885136054, -0.4282548020326824, -0.5675254450975603, -0.4218475302287432, -0.5918935851001559, -0.2704748559971837, -0.4852759784149148, -0.2614638235108697, -0.40684566028391883, -0.44057563908158615, -0.4899296814875406, -0.6314911032645903, -0.591136675278533, -0.7528481727173566, -0.03885531598064904, -0.32546600438398865},
    {0.05586312070074677, -0.27211682899200534, -0.5420179738474394, -0.3260130514822157, 0.6327241507918325, 0.222283439712412, -0.45320274541920497, -0.3471469817741802, -0.584373407832067, -0.5172332311906701, -0.3153516701873976, 0.5806029936803021, -0.2311100722211852, -0.43616967007634366, -0.7636977053892201, 0.7503031082650118, -0.21019309701675537, -0.363740044545849, -0.033067744386534925, -0.5146355718724456, -0.41402728689196433, -0.7631659768318738, -0.4805437757100439, -0.282080497396251, -0.07318219359216005, -0.7349082393122452, -0.6059617136586387, -0.20691168691180362, -0.14264345959811936, -0.4931972320645258, -0.5579242360483431, -0.6464575877241863, -0.5430755632148133, -0.5091035366830516, 0.2660670988237974, -0.5270906231357964, -0.5866594939615428, -0.46871275232496357, 0.619116280885924, -0.8367523204671788, 0.61280221199655, -0.31089543777833883, -0.7635436596744062, 0.27222882296337575, -0.23631005008906267, -0.08420260801849958, -0.495007915903548, 0.40449174016019224, 0.09835539159405449, -0.45627770193162015, -0.44998401238728436, -0.16044850176467307, -0.5789881479760156, -0.09033901675491861, -0.580261154519346, -0.22834782551927968, -0.6200532923200526, -0.13680742938669826, -0.560101049537336, -0.4789056170432279, -0.9012823104789259, -0.8028065269115008, 0.09648718394276619, -0.19970907778866528},
    {-0.18545228581181475, -0.5629757978364062, -0.6415719419521634, -0.43908942253639316, 0.4346594933598634, -0.18050297591387834, -0.5362141193672525, -0.4729279642261975, -0.39167474602680324, -0.48816204857265566, -0.23722393162216016, 0.66406632083345, -0.5921903681579204, -0.7417552658654323, -0.6563529885286847, 0.6995254968270069, -0.5274124320810863, -0.29657810238677274, -0.4542903354408984, -0.7313504062874964, -0.6615542253853625, -0.6986299196776885, -0.6382929418506771, -0.1576843293642508, -0.34836106979691933, -0.7324217370094686, -0.567990033915913, -0.3479166925667089, -0.3078618396735513, -0.6954350192163434, -0.2670945937769299, -0.532366995206462, -0.443546565037265, -0.47389536194216775, 0.10112791946290822, -0.7036079141309587, -0.7383540841966572, -0.5140945117449924, 0.5555268756617577, -0.6902415139034745, 0.6354970810660464, -0.5511808740445039, -0.6943011422982719, 0.13707730182240718, -0.4524520199140538, -0.3171079019543939, -0.5394700272848575, 0.29645752275030546, -0.15259198432777854, -0.4854866881981255, -0.4123561019471596, -0.10950048079047975, -0.5055169617352087, -0.5028854987889345, -0.6674462274765443, -0.1998331674259788, -0.6328488931569253, -0.21940840588579602, -0.7088137127683393, -0.6987271429575055, -0.7873599197174111, -0.6796783214266058, -0.148477560770321, -0.14515404135224327},
    {-0.16443004029346223, -0.737960363132541, -0.6801316692775891, -0.3979941433077515, 0.3594747283015937, -0.3826370663984478, -0.637524380239488, -0.2903830125060217, -0.770314581840111, -0.4448765112207507, -0.17448130397853912, 0.22660369699065805, -0.32799264731413275, -0.5428720262110908, -0.5470855665787058, 0.5238098866584409, -0.364526375568022, -0.3509966361517037, -0.5414341719735432, -0.63858723706887, -0.42119752695457313, -0.7924351905195537, -0.691877021043531, -0.2574079817611239, -0.1317763309285303, -0.8686910014179956, -0.4972499698393426, -0.3689565150168791, -0.2744707268596339, -0.6212172612605291, -0.46290210590309855, -0.7007285440057699, -0.7045341765222607, -0.6488995234033894, -0.19823913965827283, -0.42744406341291824, -0.6412507580113371, -0.5580925047897592, 0.7178876108462465, -0.6713262892793022, 0.7227363586888882, -0.5391837889018424, -0.7679684960423402, -0.007397345494818592, -0.7167092153810876, -0.187029928054998, -0.6213129100790229, -0.02205374780376539, -0.27848755277568543, -0.6764054197073653, -0.5779903643568286, -0.45665176007453817, -0.7073498331069139, -0.28937833981327354, -0.6790363892062193, -0.6002766404071848, -0.6540885520268389, -0.5401807015271689, -0.45385397697315816, -0.7396737372045142, -0.7275579072898967, -0.8481927926580589, -0.1766337450559042, -0.24926997475105184},
    {-0.3869983861139843, -0.5718611518399774, -0.6028811067915766, -0.4104683325664203, 0.36810314057754884, -0.3062227126451587, -0.5710906736447354, -0.2565924270888999, -0.6318732434683637, -0.5592207005726337, -0.45967434456248124, 0.604172078286455, -0.29517353488387327, -0.49354202758539, -0.49836610652158453, 0.5065531210102153, -0.32938658758800765, -0.622307728363773, -0.3938755821715756, -0.4957203603128391, -0.5246016747259556, -0.4667767804964756, -0.40256670644565934, -0.4048796416819096, -0.20301773045079735, -0.5844667639444894, -0.82611644509234, -0.1248027629648818, -0.2570155122218642, -0.4580013551203307, -0.247281318426771, -0.8159562885647491, -0.7370891322379381, -0.571538752804281, 0.13591528026198285, -0.8464418513590402, -0.4777611335270995, -0.5283848652202783, 0.8425901092742529, -0.8706715386802449, 0.7926625762005278, -0.49864265135091174, -0.8315175664404302, 0.3939750297160037, -0.5215580146764263, 0.07582417974837435, -0.6561257918685032, 0.38097833620705746, -0.1291419626766715, -0.3904727429233658, -0.6281072714562931, -0.3849045931181759, -0.7138771558522099, -0.19591260948715453, -0.38892162118384044, -0.26039193320977805, -0.553604669309851, -0.13961264738953758, -0.6924396531031694, -0.4732620766104255, -0.7555797265196511, -0.7392290921890899, -0.07312699704587472, -0.12532272231442818},
    {-0.12418978560915177, -0.5994599036311038, -0.4799120300184034, -0.5051942656482682, 0.3526713219669601, -0.1782645503624279, -0.6060128426642323, -0.28454130286127793, -0.49472360035667773, -0.4073310308029122, -0.20922695087302534, 0.6419275457777053, -0.5327625947075323, -0.8352925271978209, -0.75123250227583, 0.5520565732499366, -0.17077090876674791, -0.48323658926753965, -0.38963821369476853, -0.743218556327317, -0.5912270172490045, -0.5607757763503245, -0.48819204239860414, -0.15217916566624437, -0.17618745847247078, -0.900033605652752, -0.5530795588984714, -0.4213019044449123, -0.22270851911786962, -0.5929725030503085, -0.3271148905352296, -0.654617455869077, -0.8131026927285193, -0.6250785145280436, -0.006999368469565762, -0.5309111048035733, -0.6526248001116002, -0.7038345292598319, 0.6237381310653809, -0.8847216063270545, 0.6952614545005745, -0.5989901017664064, -0.6551275413896597, 0.3428683465121699, -0.6105654050142258, -0.20054803049535866, -0.5313922991425666, 0.17578788866004255, -0.14416973204956562, -0.47711645028810107, -0.5236966564610018, -0.2026575575409554, -0.57759407221022, -0.3654141723177576, -0.5708676794530567, -0.423335149934804, -0.6529396805385559, -0.31513297288854664, -0.6997219240199899, -0.6323054962720425, -0.7336961579232112, -0.5790512665036315, -0.027081674963903415, -0.17470352293261215},
    {-0.2735203084158485, -0.5407024311850163, -0.6681368497199457, -0.6198867703287743, 0.36565998707489117, -0.1328221526808887, -0.5944575665428921, -0.3370618387997078, -0.8205376250451155, -0.3949423748477193, -0.4488671343856834, 0.4051976500810237, -0.4160931874538818, -0.8599385301940371, -0.7498190027456851, 0.5119427293843023, -0.22009617004174575, -0.5196571358459201, -0.5333884863839217, -0.6226950577808059, -0.6967658108136819, -0.7250393030460954, -0.7592683169237292, -0.12979590759983872, -0.16798582037081872, -0.8616983224717415, -0.5327780386736735, -0.17484353778413578, -0.18297548941123487, -0.7028818893278519, -0.4768072399175339, -0.5869110504008183, -0.5953333702883287, -0.6756995443023875, -0.09265209129657245, -0.5209955811090317, -0.7097057655920155, -0.6720731792248045, 0.6866149459535119, -0.8024029990171253, 0.8290253111947317, -0.7811581201447003, -0.6744192498686556, 0.19406490323649023, -0.4605296977280815, -0.2044242499562705, -0.46336177982767823, 0.3368224492248612, -0.0015193086951875458, -0.31464470879704853, -0.6983521070019927, -0.4246574021167801, -0.4720456793048475, -0.5121991875305071, -0.3770846206767821, -0.5598933147142314, -0.7847826272074401, -0.4105095724695463, -0.8138275614809571, -0.6931716552596043, -0.698053456613596, -0.5697172889077814, -0.017536809509613897, -0.17778812739808175},
    {-0.2773923284694631, -0.41937432147829634, -0.3852355418779508, -0.7317256399691067, 0.16600540093209626, -0.04326987647110556, -0.7218866760193648, -0.5389658308268126, -0.6570601815676451, -0.5976580682764295, -0.5655644039187916, 0.589854386745923, -0.36772141908892375, -0.6797939222861576, -0.5176887987540382, 0.4369970057647569, -0.3848819953304251, -0.5801408713417885, -0.25232596815634806, -0.8196759328202293, -0.43348667732553076, -0.7740356871164091, -0.5094778423613349, -0.21798241357615047, -0.3409216569626225, -0.9079493162970155, -0.6065623609800532, -0.1955450241280094, -0.4742342179092207, -0.6923689530499127, -0.6967633240770786, -0.8074818662040363, -0.6897643867137208, -0.6642213180801605, -0.06404177144109821, -0.6185383843233083, -0.6293969920837917, -0.6480043702193425, 0.8681486873203066, -0.6002067868878472, 0.8651275643908257, -0.664244058219634, -0.7630632225654511, 0.33275483620112906, -0.4941164894092399, -0.189094382390964, -0.6479545389202153, 0.14742643831302846, -0.1451882436770796, -0.6342734565418945, -0.39319059650413035, -0.3652943499989293, -0.4827425674797212, -0.2453741004546697, -0.3681964069352846, -0.2973789217261076, -0.8521546640792914, -0.2643910865902749, -0.7445775138969335, -0.5826357357902495, -0.6795147070883522, -0.8451747264315554, -0.28015733128482256, -0.2963592677543705},
    {-0.026808148027235024, -0.4535460959357931, -0.3976237457850168, -0.33781251817949287, 0.24020744195507285, 0.1252439265506592, -0.6190926381753948, -0.4279016237554896, -0.41955139363292826, -0.6416678837481506, -0.2181154418654466, 0.5867221326902771, -0.48126959541935693, -0.6904876836427555, -0.5649955796175813, 0.6106786185748263, -0.1092493938874546, -0.5731818921838194, -0.059612081218205555, -0.6647358588626274, -0.31833754284017274, -0.7906012706661336, -0.6463485481366207, -0.3460515515603867, -0.37193723095592046, -0.6049341135107925, -0.8250762325423525, -0.35984681080403125, -0.06615284045120028, -0.4547998566407557, -0.6844869794834707, -0.8266232107480326, -0.4782535952606809, -0.7203907158300366, 0.0665532395526775, -0.5966728593807558, -0.6232120239408837, -0.7544062140843656, 0.6550185283941297, -0.8486279016259168, 0.6053572640071165, -0.34377397750987737, -0.798014114921409, 0.10705113599903983, -0.4817828850845724, -0.16292205768190685, -0.4209663439105861, 0.4479555941402822, 0.07601839729351084, -0.25123403808784633, -0.6307702751422799, -0.2148191193995445, -0.6271780141966842, -0.18596512324155218, -0.49882069330271356, -0.5339455789602847, -0.5423839396007333, -0.27632425825139256, -0.6544087102840532, -0.8145939646161475, -0.7205056943021667, -0.8237529349678182, -0.1431794636710103, -0.4412314949823113}
};

static const float b1[64] = {0.9029420153771417, 0.8881478746297716, 0.8658195264106582, 0.8524924449179307, 0.8783279870316624, 0.9299765401357292, 0.9471171887546127, 0.8316632914302432, 0.7926732149287807, 0.8861238286526557, 0.7970086954160164, 0.7692706631079629, 0.8778280561591302, 0.8285242211638395, 0.8711525929228561, 0.6446307479392851, 0.8699717390285292, 0.866217543561025, 0.8957614735477354, 0.8991800020657379, 0.8381370577794796, 0.8530366918703322, 0.7806368723056779, 0.8724301552377233, 0.9388191952157433, 0.8669988238169217, 0.952472706288922, 0.7737092393731214, 0.8987618510938166, 0.8193953441162402, 0.9409135717260084, 0.8812884414579596, 0.8845881515624975, 0.865561205585951, 0.9674335607956351, 0.8584926821937606, 0.8048413639124783, 0.8703261878168062, 0.7241200123784842, 0.8854008703530076, 0.7823061466132486, 0.8797794204250284, 0.8959456485990461, 0.8695434879858022, 0.8203221885755445, 0.7885255246460396, 0.9345467326942253, 0.895065124354411, 0.9717803241311913, 0.8852056621776646, 0.9171625028245851, 0.8620028268756139, 0.9227073316456755, 0.7981776708409297, 0.8545851097865105, 0.8522867442481372, 0.9046351795315433, 0.8880624820825813, 0.8978583638431786, 0.9328491664179264, 0.8222381647390278, 0.915603581245721, 0.8501649578385608, 0.8833802605522489};

static const float w2[64][32] = {
    {0.39657734370967873, 0.41483013911633276, 0.5799941169858199, 0.7463925065816387, -0.018388184805712988, -0.1507011921821539, 0.8420585793420856, 0.875041147500278, 0.4815241510252794, 0.6503303268983507, 0.5925347565764004, 0.9593271353001143, 0.599496370452692, 0.840865951632661, 0.7529221725002654, 0.8280911301029714, 0.7970032748905846, 0.7881197580004025, 0.4860210036195966, 0.8872496869092205, 0.6721668387416185, 0.4606281232453775, 0.5658256375687064, 0.7046163388552901, 0.6459869952354466, 0.6326179035562026, 0.8319898291146628, 0.9439270429025741, 0.5706016190955008, 0.507012697814352, 0.41927213564565957, 0.09123207894676708},
    {0.5970711107472442, 0.3101457115213294, 0.5123648785301582, 0.7454908086592331, 0.1541376129493229, -0.11708628634525228, 0.6444621243111901, 0.8885445826838431, 0.7423642661299373, 0.6550485287612829, 0.8133327311446229, 0.8578553485068368, 0.41359556734759495, 0.9143605506044667, 0.7436165510587731, 0.5360746023438964, 0.5496779061867862, 0.9657599845839825, 0.39332627188328945, 0.5598663401773898, 0.8023248181544772, 0.5415074975082576, 0.5601721709213523, 0.7964688202893176, 0.4962605646298095, 0.5894601685034683, 0.3669880471279305, 0.7974563553188695, 0.4519614060458883, 0.3125792417736837, 0.8684644594914086, -0.2424334881971791},
    {0.6381607813796918, 0.3964788048362113, 0.7722472580101127, 0.5080105201663653, 0.1762266679713768, -0.2220258303702595, 0.48050441005684125, 0.8583895329064782, 0.6422348057389191, 0.712861259240877, 0.521816434542127, 0.4941303297968013, 0.5911611331785618, 0.8984471883564292, 0.7611555188652628, 0.5594936483513927, 0.7806943832543094, 0.7351841508609016, 0.6801276006563984, 0.89412275169223, 0.5980069393109595, 0.7448244571728553, 0.5680314716757392, 0.4320506863044398, 0.35802652890245085, 0.865534295904528, 0.3786683416636084, 0.8677598569216373, 0.31432617206590224, 0.6607292748206985, 0.46554209198698165, -0.28102227512074257},
    {0.7585227536369947, 0.5844609724529032, 0.577386787807349, 0.9879851048044153, -0.08545106576499828, -0.16069393819822342, 0.7075967859525965, 0.910808423405796, 0.9051111379702109, 0.757450879130374, 0.5884087589145318, 0.9189340041006238, 0.5377343907729035, 0.9278480753292284, 0.41251708307219453, 0.5910265676251325, 0.7999870805988528, 0.9391600183871748, 0.6252235539410109, 0.6789947361753528, 0.9058582562431777, 0.7029292441364786, 0.6035523146523369, 0.6074896692652478, 0.5910482626817887, 0.813360105210011, 0.6324804757234508, 0.6409588600408632, 0.6294547255352894, 0.40337342946214916, 0.9037909979407319, 0.05129749295907393},
    {0.947205902930295, 0.6938878468853498, 0.8975876242041938, 0.792619888766006, -0.23252766947072964, -0.039975800178399225, 0.6559362331763022, 0.6414699873316112, 0.6792508731754099, 0.8488409525574382, 0.9955033539292031, 0.6533928956899988, 1.019320273431473, 0.8592625613909867, 0.6196312557801379, 0.5603887728515669, 1.123405137852212, 0.8371142524648985, 0.8342833846871265, 0.8505813160536241, 0.6248124620500263, 0.6476295090682189, 0.6160070815877443, 0.5501176982987855, 0.8865921576771658, 0.7620887828876065, 0.9254120141813499, 1.0108721790829642, 0.617922108869441, 0.35392818014110083, 0.8083710899359904, 0.12591967359899137},
    {0.3975100086092382, 0.6856048032616034, 0.6675519691354451, 0.5987637837625942, 0.21265737797355336, -0.019820468887377915, 0.683238445922368, 0.6870587464543783, 0.9967191708868955, 1.0514399649354, 0.8485500666242776, 0.7439722925257279, 0.6207825795130046, 0.9986210288728159, 0.493195473304032, 0.5888700013982552, 0.6914298950660808, 0.6763658987684857, 0.6362792539773732, 0.6491703146351344, 0.5590997598264746, 0.5435919086280283, 0.5249949501910068, 0.7639474275893574, 0.8749944989975349, 0.6463856200102275, 0.8930707767711479, 1.0016826122191196, 0.6156445015310581, 0.634339067928741, 0.8580160345782103, -0.17279865975731168},
    {0.5424397661270266, 0.7002597749724501, 0.5091343888834542, 0.9374541771835235, 0.18731799464576096, -0.11743788629974006, 0.5903394872809744, 0.6258829723639694, 1.0480947446514222, 1.0886780175683965, 1.034590283046181, 0.6966877872674103, 0.618542225615061, 1.0510370131571716, 0.634372939568644, 0.7307476926099301, 1.009066905876413, 0.8894443897736733, 0.8024156413404948, 0.9779929157011599, 0.8692593054556653, 0.8777484388639246, 0.8568415179114602, 0.6050061587589662, 0.5744850897853033, 1.0686645839477857, 0.8746496506970947, 0.8267559337765796, 0.6557770442363795, 0.5707189911872306, 0.8143242508721471, -0.07048721218533359},
    {0.4437331152345236, 0.6268233285182147, 0.6189743483290612, 0.5072657517803844, -0.02595669656762329, 0.05332943043601106, 0.8963203631302006, 0.8525123531992966, 0.48370325385867063, 0.80807090135412, 0.9084168717602936, 0.6130321439215713, 0.64909943082306, 0.5629781371618583, 0.3840970168589599, 0.5867640547006524, 0.7417071457212016, 0.6510226198600862, 0.5900444762699625, 0.8961497044482807, 0.7969729642291158, 0.520849920777456, 0.35389081005380696, 0.6825095511395225, 0.7786380770475166, 0.6219206703858086, 0.5930177915825269, 0.9486233122044438, 0.6573325444078273, 0.3488403274752596, 0.5722275844105409, -0.03151979764631441},
    {0.4100391672967703, 0.6273522723038598, 0.4578258291462058, 0.5290340251058834, -0.12400313767630833, 0.1791874391460759, 0.5905627331168207, 0.5407103968867117, 0.7585880477010174, 0.5443407040051279, 0.8561599932561691, 0.9985293217258903, 0.4229675145795984, 0.7592786728861882, 0.3531888937594809, 0.8522246362087958, 0.7278730891619426, 0.7211196516658481, 0.4127165407301963, 0.5701882425591426, 0.8801364250127023, 0.7606621441052063, 0.3821689462306403, 0.708512308617388, 0.7328211245528881, 0.7471869214724295, 0.7145716099332027, 0.6444840960516959, 0.4456830481390966, 0.6795571829570582, 0.7279035986064499, -0.2670589552186325},
    {0.7565146228412551, 0.5310380251524234, 0.8041077452476657, 0.6554754495039924, 0.2001346310679629, -0.1510517676980027, 0.8779453777869493, 0.7591448701977902, 0.6048952862019367, 1.03684187108328, 0.9065558846873811, 0.9780989983253997, 0.9255532065018516, 0.8007190878062161, 0.4100569977691976, 0.8311556243539382, 0.7763510905220532, 0.7482999238190029, 0.9231602568379971, 0.7131956557458601, 0.5966685050312519, 0.5999389932218664, 0.5441832384788862, 0.8013982115565953, 0.8720798692619701, 0.831756694159139, 0.8868948953893934, 0.8697319134803784, 0.4968563545624133, 0.5179296250133103, 0.4610494691160366, 0.022210765734610956},
    {0.26875044155199096, 0.6387186817889056, 0.7417514602401203, 0.858714924826828, 0.20011176470251976, 0.06444890059421865, 0.8589903690907053, 0.769840638817031, 0.6428816860074801, 0.47685169157960744, 0.6083304838085478, 0.906825921919407, 0.8465122937051418, 0.5814854238652742, 0.42349503459864485, 0.7768419530349622, 0.9005742473832181, 0.7898593383282762, 0.5179254582647781, 0.8313085403834215, 0.7493427740109765, 0.50846463340152, 0.4291894114178512, 0.560532804767953, 0.5036904287228179, 0.6937440451555572, 0.562789472098578, 0.6935135367178025, 0.6214128330576071, 0.5635150235709577, 0.5110540790326812, -0.08940261230900125},
    {0.7618800775214619, 0.7265885901062835, 0.5644447208507265, 0.719096293984405, -0.251783815405746, 0.03473604927765147, 1.043664021083642, 0.6894466172398148, 0.6887436213933175, 0.6908196783047287, 0.6599047539920146, 0.7813290870545827, 0.9823343107297449, 0.7769223072162796, 0.7394972032110629, 0.7624870562077173, 0.8118115448650317, 1.0992374763017903, 0.961080722152971, 1.0748724540563743, 0.6480570328303963, 0.6292097118171901, 0.6175322837434668, 0.6572443986424977, 0.882170780856626, 0.7543213509301626, 0.6839712662483051, 0.8578945571205919, 0.42547202177510324, 0.6040510032448667, 0.9596517365822915, -0.2612001328344121},
    {0.6659148279999979, 0.5170547353638351, 0.48822789890264073, 0.6077248086481732, 0.1661129948404102, 0.19309423187713864, 0.5906529928209708, 0.7813251653433494, 0.6829253410200686, 0.9690774355195308, 0.877576777159696, 0.8885521456455078, 0.5135014660082409, 0.9692336833610512, 0.641120360593593, 0.8300306617274068, 1.0196431255630822, 0.6472385986861517, 0.7054833022162234, 0.5380055173656476, 0.782438592422251, 0.6532659301975431, 0.5413532733602164, 0.8032133101771939, 0.7494331199528764, 0.9103862777320304, 0.9220572291391691, 0.9651880930842822, 0.5139172149220634, 0.48935408976487665, 0.9192464160407116, -0.2537853471036355},
    {0.4250891266586968, 0.49237758240335583, 0.5474844530961123, 0.7463379901377846, 0.09566229106572613, 0.08622348404377211, 0.8544454452343778, 0.7568076141939999, 0.8563054689583398, 0.5210845043461914, 0.8476440308227349, 0.9579551575217081, 0.5503965597509556, 0.7890941143349732, 0.5323017723330311, 0.7876067971998538, 0.7807313579094856, 0.8437527473586272, 0.4501455054837861, 0.7351060368453335, 0.6409516732749359, 0.7393136230793752, 0.6192902700671394, 0.8014484052128127, 0.4233987307322433, 0.5861063622064159, 0.7713258905439759, 0.976049398911684, 0.5409161790432169, 0.23912525114240799, 0.8432399262400084, 0.09303161014370442},
    {0.5953248791551151, 0.3386805835143329, 0.6282722626780608, 0.5361248929897645, 0.01020352050383965, -0.07306885258895206, 0.7886029620892342, 0.4222114390836946, 0.5976059408770523, 0.8031955740788688, 0.9438298271572482, 0.9207265269687971, 0.7563442116741058, 0.6881605549397583, 0.4400447912874842, 0.8086194139860792, 0.7208684475345529, 0.5590428885015525, 0.7172748245010983, 0.8902327493911255, 0.8241602195240376, 0.47283729880883574, 0.3831427258820666, 0.8587696251112593, 0.7441425728983767, 0.85386980966831, 0.45279197003463156, 0.8609445141168156, 0.6339545479790168, 0.21820301998856037, 0.5144231744776292, 0.1508991417809315},
    {0.8413988256113305, 0.6585556203700648, 0.5914936679166467, 0.7211880135813741, -0.06423809285847823, 0.07377247765883743, 0.6078425403056917, 0.8210104616739459, 0.8505746855925229, 0.7744002813531995, 0.7463056112620189, 0.9049505014503016, 0.6912540564993598, 0.6744868230867853, 0.9766403945258622, 0.8950465813357839, 0.7684801010651972, 0.761575408479005, 0.6161381563583953, 0.7067329539953372, 0.8447762683607722, 0.7643496450303771, 0.5893562915725415, 0.9602084048133638, 1.0238288939677294, 0.7326729062223202, 0.8729630367903007, 0.7140268386883379, 0.5680081072418125, 0.8167823965459746, 0.8096185393369288, -0.01059957236376791},
    {0.38674896936690467, 0.3803583277837032, 0.7124972300410715, 0.8294925490651134, -0.22216136493086364, -0.08123134555038516, 0.6347857499917229, 0.697834547455139, 0.964485082162608, 0.7912929391774782, 0.7570476506273534, 0.8303729504031613, 0.4912548247152913, 0.6465490479026743, 0.8431924977225982, 0.47755627490814695, 0.840040822731633, 0.927483240095169, 0.7458705563805526, 0.6096955367512513, 0.675446153691551, 0.699395353605701, 0.5023301707204896, 0.8832116317578774, 0.879713245060822, 0.6747406739623942, 0.8522425094275827, 0.6378142872287327, 0.6478610946547295, 0.3704321233781283, 0.5527088048785926, 0.12004108542274926},
    {0.5576004609134881, 0.7190322605243679, 0.5423437638794775, 0.7427198431438132, -0.14484911376727955, -0.19566266815536792, 0.7342427398186451, 0.8254244721246156, 0.8001605688694102, 0.736420506955652, 0.524200227071681, 0.822786560034098, 0.6772303141338758, 0.6509600916984721, 0.5946261376472431, 0.7937818548215713, 0.811716856056914, 0.8785699545324591, 0.7911617904435703, 0.7544322882637968, 0.6356633929410102, 0.8938413868926237, 0.4661852453014458, 0.6258994849065792, 0.9469818132539609, 0.8904586667015233, 0.5969420412468998, 0.8231824188912403, 0.7464933397628286, 0.4303323980511344, 0.45650595055914306, -0.031956176996029824},
    {0.35473530874430376, 0.5960089791863509, 0.585136848941708, 0.6368086561894637, -0.2558493666927967, -0.14249113974749703, 0.4450996600800394, 0.5802788862580913, 0.8615941303803532, 0.8213603634544082, 0.7180452896076052, 0.5175664141171035, 0.8162239700621594, 0.9007949181677275, 0.5792836500982731, 0.5794114252080748, 0.9285705192232031, 0.6017815580094085, 0.6704665160108522, 0.7827119965975765, 0.5892539921187099, 0.8691690194872977, 0.6639615575705272, 0.5457009300928386, 0.6897063631492623, 0.9081775011829312, 0.821093933999129, 0.7944230212799769, 0.795693422812634, 0.4472522984951025, 0.48534483078232793, -0.07963151489458907},
    {0.6355453550651736, 0.45578079407547295, 0.6663568587795565, 0.8386410923169549, 0.0009547647626168698, -0.03555157837797733, 0.4889426327391065, 0.6151619010237485, 0.7137552253961184, 0.8275260741052521, 0.7452573695098196, 0.6572603825911756, 0.8898056917713292, 0.7887954550202066, 0.4767217938428053, 0.7656803655671931, 1.0407799973945384, 0.9170771999951546, 0.7041217013049544, 0.9979671376551874, 0.7372946098486598, 0.8227785337134501, 0.3956222619399229, 0.7649889119597341, 0.4268432225878503, 0.9570233581577854, 0.5723032001826659, 0.8839403651102542, 0.3053588392588113, 0.5472055674893674, 0.565147183253487, -0.15982576998710296},
    {0.770337638019809, 0.37756533090546107, 0.75382895776476, 0.7343303219120279, 0.15304646774904224, 0.0473918250922154, 0.583184554761472, 0.6486416698497067, 0.7030134333156827, 1.0845636409951063, 0.8373493115632706, 0.9116264251716621, 0.645949530588586, 0.7106077036707996, 0.587154551477385, 0.6721918316489189, 0.6973831205947371, 0.939420124625389, 0.7124767904537305, 0.6969722557159256, 0.552550282450366, 1.0763182201123707, 0.5756280977438255, 0.8085054123458333, 0.7593890282889975, 0.8801971562678005, 0.889305531319402, 0.9544761736663863, 0.4288459827821036, 0.6590972690836753, 0.8543376394908654, 0.20180102238732153},
    {0.42524002684837586, 0.278639581492207, 0.7098167720015137, 0.7783815703879571, -0.12455561604802227, -0.039958960391374435, 0.6593802613742664, 0.7871522852224341, 0.5987489282604672, 0.6687854590814969, 0.5416441122301396, 0.9066826944028709, 0.861560028274812, 0.7822757695484384, 0.4130656684468436, 0.7183020390090957, 0.6538025323770932, 0.9369417222270752, 0.6922749935017428, 1.015842553354586, 0.6463281877897078, 0.4884130878875813, 0.5651451358127324, 0.7845395739804547, 0.8319044193052958, 0.9711912132644931, 0.6495446131984479, 0.683026683374162, 0.7413914595351744, 0.21472593117762345, 0.8817751908230754, -0.170672402871358},
    {0.37805468495601396, 0.5435074603559863, 0.78169554457671, 0.6548579075643617, -0.19518205543825146, -0.15007546996755095, 0.4985689527985723, 0.7336636810638127, 0.8808926078471542, 0.5530714610074265, 0.800598469935247, 0.5654704130056807, 0.48846442153082925, 0.9936074649731464, 0.8032739623181988, 0.4681430467459513, 0.8120056410143957, 0.87768489597085, 0.5018045187931167, 0.5630060073445154, 0.9234106646842982, 0.6535733450699285, 0.7418722546298961, 0.8973267650842206, 0.5840750203773365, 0.555876382558479, 0.7801671520029678, 0.6641869246967869, 0.7670248585945176, 0.21219008413425877, 0.6467255011259201, 0.18973209770526905},
    {0.4069651430980198, 0.5121485704533811, 0.6621614999410657, 0.8405134189800718, 0.04178268253670191, -0.07975989503093212, 0.6345245370296404, 0.7412874168885079, 0.655600803172324, 0.6199036290407419, 0.7139148090011985, 0.9609472861675902, 0.620682212999016, 0.8117691662197549, 0.6069242090246558, 0.6944908393176507, 0.6645451035979189, 0.6771535836517418, 0.49390127311650056, 0.7458499065066179, 0.9359800708925587, 0.90635893033931, 0.8420919284127998, 0.6152330996374045, 0.9217022378591353, 0.6274697233614727, 0.8724105328531572, 0.5425918988575726, 0.6198803758215763, 0.2576751658918667, 0.8007600353599316, 0.07084715075312835},
    {0.5677027523923723, 0.5248498862144163, 0.5844378848287525, 0.8850778024790151, 0.0022231434654485433, 0.02993324266549369, 0.9823571624011819, 0.7675648258201764, 0.7483167092166173, 1.1157458882625413, 0.8109384783234145, 1.0751586072781252, 1.0450228912510044, 0.9867195521504941, 0.5428756699432352, 0.9895149166572489, 0.6398793208399567, 0.9178296633413762, 0.6218989420782867, 0.9439730544709148, 1.0346840011026712, 0.7581126067310813, 0.6894467558999274, 0.5591537430907875, 0.5630435267628832, 0.8333376520574075, 0.8568337568276208, 0.7858634879276806, 0.4165921469048303, 0.2402341878012993, 1.0232169230967707, -0.13458497678369238},
    {0.5100234901977877, 0.592331720060145, 0.7432276383861768, 0.7947484495634729, -0.08153056291284433, -0.21721646392188002, 0.6625600981210327, 0.9575811007060249, 0.9360557340918074, 0.9628971925201696, 0.8174677572204178, 0.7972419409545463, 0.8189160726318896, 0.8891556792874342, 0.4817668497633414, 0.8729346543335655, 0.7824054560360693, 1.034531450201195, 0.7040591265321297, 1.032303504527722, 0.9981665368140965, 1.0155139332286893, 0.41406109640545585, 0.46673047870428935, 0.7551406599255895, 0.802624595607038, 0.7174038830494486, 0.8051052163759919, 0.6356816123418125, 0.30694895281251194, 0.8975699823315404, -0.154578479370057},
    {0.9044901785153044, 0.4954305858882413, 0.629772995690012, 1.0435770506243989, -0.07828506152924743, -0.23272894687751838, 0.8483338054802297, 0.9399213890505506, 0.9335170858916724, 0.6775887076348501, 0.9524652973170616, 0.6702052000869496, 0.7795392666317711, 0.6453057836438508, 0.7042402926576508, 0.7449224180350321, 0.6439955979422566, 0.9821256244823201, 0.529735298331336, 0.7223129231362108, 0.5262385069607546, 0.6040037627835385, 0.5812864499320348, 0.9244170449261983, 0.7224482765224671, 0.9608628679266337, 0.6686774157221652, 0.7657525463716638, 0.48886842444168294, 0.5201103568675672, 0.976402762306653, -0.17788889891001963},
    {0.9348073881300379, 0.6028064268519929, 0.7628736503860623, 0.7454814121361458, -0.06891935727672664, -0.1036502860444048, 0.5448221225263132, 0.6731544244632325, 0.7466696928807227, 0.7156032124429242, 0.7255915479158735, 0.9898100368204977, 0.9633163279204997, 0.6800116254459958, 0.5512016758018642, 0.5214132364860389, 0.6837224184063672, 0.8821003159132746, 0.7255162204926564, 0.7001494768923974, 0.70306390357137, 0.9628149575907781, 0.7733922638750663, 0.9605527060351448, 0.758972385689483, 0.8799436196783021, 0.9039357463326355, 0.6233110130025827, 0.7093502060523773, 0.38747323253675836, 0.7956490963458737, 0.06824887622679801},
    {0.26328323610412485, 0.8135334344130019, 0.7238905964588072, 0.9662014299144694, -0.28800541148105824, 0.18558250281393715, 0.5046992493317147, 0.6725791162676223, 0.8372882017084314, 0.9700362115657574, 0.5321251276201978, 0.6190906916756932, 0.6750257670716837, 0.9530963070784861, 0.45201515926112656, 0.7184197011461375, 0.8680126036274048, 0.9046372421941844, 0.7303619824002123, 0.8546847417289952, 0.8474476128643817, 0.44449394516506424, 0.8207730070604482, 0.4156125395225173, 0.8595775802810398, 0.8621507288844285, 0.4636185304971764, 0.55158168545203, 0.35907889090712203, 0.37749709643938634, 0.5313736346405316, 0.1355282752540788},
    {0.7273163145993031, 0.3114926714682349, 0.654821306817976, 0.8359749578458999, -0.10140874442925851, 0.14460695124665598, 0.7800837608775546, 0.4810930939725286, 0.5312561293367918, 0.8328574483047877, 0.8122172594472603, 0.5156782541533171, 0.7140726163926413, 0.6885762061780486, 0.43988126636280844, 0.7982179180130881, 0.6805948805546157, 0.6477444104379216, 0.7631005183188283, 0.8125293775965934, 0.6891081340531543, 0.6781364132618765, 0.7340552499587265, 0.7995334856268511, 0.5948619163306635, 0.5610691754686982, 0.49088811673228844, 0.801973982591735, 0.5005269629107609, 0.6104275251268918, 0.5642463080878687, -0.06854555977524635},
    {0.6168881408983089, 0.5474609996123646, 0.9531154967476155, 1.0159048550176333, 0.08096729516622272, -0.07122051323871162, 0.6821283573102156, 0.5835991653043865, 0.9955254775111978, 0.9724577155712516, 0.946680191579992, 0.6390732859570555, 0.5836244877100869, 0.6088231399473715, 0.8316433732079892, 0.8092450649543196, 0.9785528615311705, 0.7502832291211373, 0.817304524681189, 0.8566197341063128, 0.5751820755067548, 0.8380283571590673, 0.7860904959587939, 0.7469191454869195, 0.9081756620133221, 0.8835080482808525, 0.7558038098037806, 0.7039831158934385, 0.43986289041320575, 0.4182523020666291, 0.743488038661426, 0.019972126246400802},
    {0.9186164621773476, 0.35510678411331914, 0.6831720904469751, 1.041044352269118, -0.23505783631488517, -0.08258880420495004, 0.785494142466847, 0.5928373992006365, 0.6520682088091764, 0.7988025568653132, 0.8030403474373413, 1.0080848478668345, 0.9893878362676171, 0.6488601810893252, 0.7925068336975726, 0.6996607884973886, 0.9420735903098185, 0.7984798175013099, 0.9970854170799586, 0.7417575981287199, 0.5917332387954887, 0.7414502150982822, 0.8128016023674094, 0.8419768019143702, 0.5756654235012726, 0.9537257163265622, 0.7757678202681021, 0.8669465557750659, 0.7101263042234612, 0.48486017962833045, 0.7008343139910622, 0.13838208063605906},
    {0.4149805639744684, 0.5373328172540541, 0.8310392626927362, 0.959017358908233, 0.10769968284754705, -0.2618627063668445, 0.7109368195491086, 0.9351806785183503, 0.9634260619165179, 0.5506409318126565, 0.7961445916094908, 0.5583189401896784, 0.5354631084690046, 0.7411062911913306, 0.48728380805897825, 0.7655681521784942, 0.5816007729694225, 0.7641012460555259, 0.6259135060349232, 0.924237082752984, 0.6074464841366773, 0.8945467288529065, 0.5877428125515197, 0.5938236872308742, 0.6046685226235956, 0.962978804310737, 0.7060039897928213, 0.6489327345355745, 0.4911056349542789, 0.3292328617028356, 0.7528711060277273, -0.056686345191474655},
    {0.6999876763106258, 0.3021717597939452, 0.6713064751380842, 0.6836613395042985, -0.05544611762511703, 0.12031669268573338, 0.9900251287854056, 0.8224969316400582, 0.6902213698848116, 0.6506355055496312, 0.967928477505662, 0.868141737760989, 0.5880936652967363, 1.0599831624180898, 0.8211699613327843, 0.5879270830922829, 0.805953390353071, 0.659721068017967, 0.7238437597214699, 0.9616408091979023, 0.8680653284705185, 0.923320721797921, 0.4415417890246569, 0.8839455789209798, 0.9231145055686687, 0.664494057958951, 0.5378039354174698, 0.916976323540013, 0.5847884915916397, 0.23910966898195063, 0.6512136591237202, -0.09875539783176676},
    {0.8867295150460159, 0.7201961648281044, 0.9331410852180766, 1.0666818037411188, -0.004404540913950019, 0.03466553174543898, 0.7927029001513866, 0.572985388318004, 0.8100433133627442, 1.0275094835456473, 1.0082349059388218, 0.645177696048954, 0.5640377368728144, 1.055109955192789, 0.5827082362858399, 0.5452658882335051, 1.0839001571586058, 0.9488334859838442, 0.8409114657868075, 0.7652664134238295, 0.7953133889037759, 0.7494744018670032, 0.8926371425238653, 0.8293302932401797, 0.8810435657963848, 0.9735210344659206, 0.8352904891098717, 0.6470412586061328, 0.4267372448675834, 0.4387985115298811, 0.8272988109861826, -0.05173467457294842},
    {0.9355882242709187, 0.7272936132939678, 0.9033519630164573, 1.0887775439797052, -0.2749977986007679, 0.16928322099061868, 0.85182034964935, 1.0269888975974346, 0.8073530191425664, 0.6167560864722387, 0.8772214196874095, 0.7333577412337121, 1.0232735823839405, 0.7465014910656602, 0.7792076475794282, 0.5358848903768341, 0.6684568859006402, 0.7268070327627709, 0.8041340022153979, 0.9913484716834431, 0.8444381244465863, 0.9419094073272591, 0.794610428911307, 0.9493754987484306, 0.5050440151912264, 1.0418394853162292, 0.7636574513981863, 0.8867131181458845, 0.3756095517147009, 0.40092157938677764, 0.8558884735672909, -0.019969249598408654},
    {0.5706827903253876, 0.5341525954732808, 0.6472358687777625, 0.6358312583174178, 0.1424621123499929, 0.1810525837977963, 0.6460702018989355, 0.7480050259755092, 0.6660956677711606, 0.9314495617701861, 0.5987426536566817, 0.939344773864798, 0.6886899255419262, 0.5547951923641619, 0.5328448586173304, 0.7909800645926972, 0.8140849463353026, 0.8319272753568123, 0.6306314407945622, 0.8267919614471876, 0.9336268372038472, 0.5867251537276182, 0.39998156133169427, 0.5552857782538683, 0.5529187626094565, 0.7729388480960532, 0.6667093448663254, 0.5687938386325615, 0.3223100303343103, 0.23128060806526807, 0.49627424480728893, 0.023786934120416377},
    {0.3195011760357418, 0.5142899285334002, 0.7663790425327669, 0.6472231933652928, -0.02500688367709091, -0.01730864366181833, 0.8210416820628927, 0.678335106724858, 0.7847821482911095, 0.7281562737004899, 0.9905511346403425, 0.7917935958402037, 0.4563101360369545, 0.5563169534326939, 0.5646697055293992, 0.5486108352448085, 0.7112184731360803, 0.7993909869751503, 0.6142125586848098, 0.9830396472511866, 0.6011233212195445, 0.8054622409531373, 0.6020639791592175, 0.9150981114264733, 0.4492164993359664, 0.8418398398357123, 0.7132955293091149, 0.6355257373114122, 0.3669824293692699, 0.23272411311585314, 0.8651773551942957, -0.05682751873592591},
    {0.9763271584054107, 0.7009752374628763, 0.9855299839228027, 0.8384965821643706, -0.10523209952858747, -0.12084639382585854, 0.7291945714266423, 0.9447489417598193, 0.748945944413113, 0.8259356415092, 0.897191040562229, 0.878894551330158, 1.0675528306788962, 0.8093071705455909, 0.725579858102504, 0.5770207153220439, 0.783042629330117, 0.8531271031857964, 1.0247678201728825, 0.79587387081912, 0.8241999468192053, 0.7679240304762835, 0.9907343946807196, 0.7790125705484087, 0.697622604160306, 0.6874129507533451, 0.6450197382716945, 0.7362244282477353, 0.5448546162927992, 0.540669665739147, 0.7213417161917844, 0.0019568019362845943},
    {0.4407226463687171, 0.6400879988947985, 0.7745948651876926, 0.9007017395806336, -0.1824565816413523, -0.1095948105208509, 0.8352918991950005, 0.6098761747586143, 0.619996683135472, 0.8430740917088523, 0.7564361354063809, 0.6129154419996989, 0.46528443410543674, 0.7613871264113048, 0.5292340286478457, 0.5399508062979668, 0.751453332324071, 1.0287556243208582, 0.7572969123630885, 0.7404128459148868, 0.5415189865263793, 0.6391453143243405, 0.6197909682334591, 0.7955030983862058, 0.38129247550703704, 0.9531115473328391, 0.5693638668924561, 0.5743988659438497, 0.28282925757192295, 0.6164317800721499, 0.7663312546615437, 0.08936740270269625},
    {0.8958248024486642, 0.44746499740443674, 0.741941801137203, 0.7119571970673118, 0.18149025270816005, -0.08921201428172444, 0.7858932313307347, 0.5699196721693321, 0.8399754910944042, 0.8415143815112736, 0.8175457473887427, 1.0385234895101725, 0.697447417262546, 0.7369109130229863, 0.9167251184971004, 0.9035642149542372, 0.8877484342927939, 0.6607533582008651, 0.6353924534461989, 0.6942374572383414, 0.9128198981049719, 0.7896595738507193, 0.8380896841737856, 0.5388457876878104, 0.5291262045023372, 0.7758883178086468, 0.5429086690432475, 0.6453719801767585, 0.6299359055353132, 0.5698206304575824, 0.5975327070859211, -0.11807377325417652},
    {0.7257931207449453, 0.22654301206501753, 0.5492497798178834, 0.9844357089906335, -0.2622090090305704, 0.036837138694541756, 0.7544268103619042, 0.6396148193077532, 0.6670256513666599, 0.7996346778190616, 0.8566725736467041, 0.5223723821779668, 0.7483022655501829, 0.9547166408490196, 0.5206637304624545, 0.6613703182369651, 0.48217683900248576, 0.6940426528773684, 0.4556598753644589, 0.8562886234608922, 0.6740380965403036, 0.48423304597300126, 0.4277303206980697, 0.43854924466693723, 0.7905835386718258, 0.7826235389306658, 0.41527264121673974, 0.6334495696554637, 0.46423269619618096, 0.2505487209183932, 0.5353096074653666, 0.10934277242426},
    {0.4700718609751126, 0.4063503726222616, 0.9368784855858724, 0.9509403461675853, 0.009757023640503572, 0.1448203054683819, 0.49182600600373594, 0.7979232613414015, 0.93414967866382, 0.7173714135944634, 0.8572414755834826, 0.6504883759257678, 0.9191713467018037, 0.61305996979457, 0.35508220323164624, 0.7731163298792026, 0.8244553829207764, 1.0494327645362471, 0.9123505104879366, 0.9853959500184423, 0.6043108905421739, 0.5638736063069684, 0.4749960575543993, 0.9505239544974068, 0.5805768395069419, 0.9657159163147222, 0.46182649556676814, 0.673932628629358, 0.31786426480420554, 0.5714002403645353, 0.9147743299639962, -0.17520867279641444},
    {0.7920462012115584, 0.3070986330155419, 0.6342226461027619, 0.5811619834191614, -0.2624718104878693, -0.049934696513037856, 0.9193658860784967, 0.8036974211852786, 0.6090869785249826, 0.7853816806053083, 0.8111356707476992, 0.5303396364413676, 0.9071877932994659, 0.8480866035640063, 0.8429565016783495, 0.9245999647156501, 0.567378250765402, 0.8023744044794788, 0.8854863950384178, 1.019400663920329, 0.6650169539545849, 0.5980598883018663, 0.769081171509004, 0.6842122006093556, 0.758970577796653, 0.5393508248290316, 0.5065689733093882, 1.0126232064833804, 0.41283232809535775, 0.7001161648417923, 0.4660603526517523, 0.11217181852276019},
    {0.5639129598370461, 0.7414398264371512, 0.873351585155413, 0.49959328731801395, -0.12621586796451095, 0.19977158044019136, 0.48585804878980854, 0.456591289910789, 0.7008583252293158, 0.9714562496773516, 0.6667426596301077, 0.5247267576118806, 0.40870628337036535, 0.5232928623017565, 0.39084214539226786, 0.6999684998440368, 0.5643910051001388, 0.8538518055336318, 0.4152558065556011, 0.968027728333361, 0.9120853151961564, 0.46275727313339393, 0.5910546990220887, 0.7442635998364998, 0.5976090651647272, 0.9135184323417093, 0.5721069517883448, 0.4757270647553704, 0.6237963983824635, 0.38834046268796446, 0.5994095182388962, -0.13503165815178422},
    {0.3401011189283369, 0.370751333295117, 0.5185592382654062, 0.8819184453141381, 0.11564676168514924, -0.212876867692989, 0.7116144455865882, 0.5265916238126891, 0.9128516786527124, 0.5905057215494989, 0.6369341377358815, 0.5029201596365916, 0.9149589563210717, 1.0181918753346804, 0.6667912919562087, 0.8621983617259982, 0.8685088178966682, 0.5690557916036088, 0.7839968134099466, 0.6436851794216724, 0.9196903290409372, 0.7474158862269548, 0.4376383496720471, 0.5233760954909042, 0.728717506400885, 0.6483005984432694, 0.5275928072845831, 0.6251084187808482, 0.6225486913932013, 0.3289500349385058, 0.8860289994345459, 0.15152551606327072},
    {0.6468093373430932, 0.6726418862778264, 0.5785047272903211, 1.0294354286647436, -0.0021367550592120317, -0.07530252678125976, 1.0174748346455433, 0.921928577706384, 0.866688221078353, 1.0139187947322215, 1.0618988082192695, 1.0016011968374625, 0.9203694706586345, 0.7727392710357806, 0.7111887975538329, 0.702396764806622, 0.7618063895627755, 0.9238308419649159, 0.5593411077066515, 0.7595719013465522, 0.7643228512985338, 0.6840458404081418, 0.8419100940351549, 1.001976369010856, 0.5513214986724844, 0.8486536927704109, 0.5765169024232965, 0.8932978884098369, 0.4107809689511678, 0.3410628365692901, 1.0195845277550877, -0.1262605052523999},
    {0.828697143272481, 0.40903879596136955, 0.8706793492352399, 0.7609132723906151, -0.04893598647281426, -0.1196140870435988, 0.7182017004400004, 0.5641153321189267, 0.8116928833322936, 0.9049602510392546, 0.7999982757827648, 0.6627896738018259, 0.9705261677719312, 0.9220051971153361, 1.0093104238458313, 0.9553256313796656, 0.9263112067180513, 0.9477744665094207, 0.8524013881217588, 0.872397236059475, 0.6652847807131614, 0.7249992238057416, 0.6421896011107098, 0.7563907815654302, 0.8935808336550265, 0.7236978741770553, 0.816662791479629, 1.0653583475704258, 0.6016571179696576, 0.5476900183756269, 0.6675083806662162, -0.20555816998398868},
    {0.8789802688221343, 0.46016259857040553, 0.5784883933983396, 1.0718098128059175, -0.2763327232788662, -0.01217885684872292, 0.6096107336582143, 0.9113116435099793, 0.6329303148540151, 0.7628175964294508, 0.8854367183502594, 0.9936038022725181, 0.8196367618063927, 0.8723633547949298, 0.8412280444917758, 0.849913215403133, 0.641573740566579, 0.9272040648809389, 0.7007919662146248, 0.7017549761898462, 0.6257312943193736, 0.7560804093847544, 0.7184090368883491, 0.6547168074547332, 0.8462420320536702, 0.8314298821191842, 0.7392761561367746, 1.1100293687908602, 0.7650965849188407, 0.48200580530619896, 0.9845056074764963, -0.00032624233452710006},
    {0.6322393148170606, 0.5089854372443622, 0.4668446941198543, 0.5936072049497692, 0.1742543117436855, 0.059820798014816996, 0.756996936464903, 0.5804670419936951, 0.731823317381341, 0.8534135402375637, 0.6598598532633999, 0.5319548736027595, 0.5355065179189377, 0.9569681805891272, 0.34478202337063113, 0.9123923533615537, 0.5300645936250169, 0.5443621537234151, 0.41822016998016837, 0.9531992101285621, 0.7096712484386594, 0.5195408523969665, 0.6004164931403416, 0.4924681195478124, 0.7245922712622751, 0.8180554628025843, 0.8426067599102636, 0.9346812224341615, 0.36286575159357876, 0.5586244570939235, 0.44558612356433674, -0.08592964987911189},
    {0.5272008893557365, 0.4100025250181052, 0.514495843809661, 1.1032029172180347, -0.12470157013983046, -0.2335727431405708, 0.6666634821938863, 0.6050045260383622, 0.8444993168313203, 1.0818951129859078, 1.0749010450210095, 0.8851347882169271, 0.6463429942297583, 0.9224980761168262, 0.7060235743449619, 0.8827106552319554, 0.6989986526663468, 0.7450303677553252, 0.8820719102940134, 0.8844681995351036, 0.5399655985405748, 0.6866461310572586, 0.7396816545618222, 0.5303905872720813, 0.5889708976022865, 0.8963444381864075, 0.5515654390741085, 0.7718342222471373, 0.3103989493107894, 0.3859240765201347, 0.5314348770643181, -0.11184101604652175},
    {0.5796816757018153, 0.6841109277895997, 0.519064216058899, 0.8160817631665116, 0.020974208859231864, -0.2123292669986432, 0.43675245072820695, 0.6201961001803467, 0.5278459425080292, 0.7132172121229625, 0.6935555233297177, 0.561383762437394, 0.6065720800950125, 0.8486767365414677, 0.6488509141529404, 0.6274159923800271, 0.7278717084781565, 0.7500431881414987, 0.448647725596433, 0.9397065095815746, 0.8561302163018147, 0.8869893940843351, 0.7633465885211599, 0.7129896068736414, 0.7425377984439899, 0.6482802097079483, 0.6467881835285875, 0.5796803477430491, 0.7363499679480189, 0.6622322857407816, 0.4605267240961717, -0.2777746668458906},
    {0.8554578897018636, 0.5492253941661474, 0.8731155153662583, 1.0435723469177896, 0.034836588395613, -0.1970133354047367, 0.6404094012337816, 0.6866789007034637, 0.9411074630420031, 1.1142076989319536, 1.0371541783945066, 0.9729595610483126, 1.0015712640013463, 0.806175803840168, 0.5371163697488455, 0.6378008055629508, 0.877250318155827, 1.0134211497426766, 0.633640565378479, 0.6183202215318251, 0.8168325515569983, 0.5947367717656904, 0.6596388321298992, 0.782312351203827, 0.5286964225940052, 0.6882676136451947, 0.5075871429686214, 1.025812524759873, 0.7433549745450221, 0.5944253114047232, 0.8185659704635989, -0.03270232142859051},
    {0.7781673599193452, 0.5749374510069232, 0.8619162029720702, 0.9484972595659953, -0.05276561441711888, 0.03909268936471934, 0.8476015121719742, 0.9110191265135119, 0.8755181295307106, 0.5625505713093196, 0.49090372546595756, 0.5574211464991875, 0.7720141613288977, 0.6972653830881415, 0.5451969457215396, 0.6459800819346403, 0.8100885612685917, 1.0027034590099628, 0.5803726868299773, 0.7646917565659966, 0.8091703282889516, 0.8939017978146917, 0.6361577207202882, 0.8759446693801953, 0.6122462512070573, 0.6632337294033432, 0.5498255159925263, 0.6804872492219467, 0.7218630192922756, 0.36043782143484626, 0.41813490947684484, -0.12764533942631018},
    {0.3166507037417461, 0.582983033004365, 0.8894661958807941, 0.7752052640056298, -0.24431619056577167, -0.2533844270268153, 0.48035014193597264, 0.49819701677835593, 0.5235268240267359, 0.697102781092211, 0.8585386181955387, 0.7420180256388391, 0.40050977872788907, 0.8917145558552323, 0.7716239902339586, 0.8030320709777157, 0.8803560733174662, 0.9171540364826446, 0.40706251010089, 0.8276146963198097, 0.7409889414609584, 0.9713626126079211, 0.6440572212764846, 0.6230258456337827, 0.7215330261577384, 1.006953458652299, 0.4785128630681569, 1.0138492290659897, 0.5758381966282942, 0.3392225114345088, 0.7362904729331956, 0.16839092987567605},
    {0.3649176478627059, 0.7203556602533122, 0.5638628994160328, 0.8483421846709007, -0.16131118972181785, 0.12344322320540728, 0.5218660635352885, 0.5278007536127299, 0.5386735744027243, 0.662270069422023, 0.9339696355574605, 0.7244653207734305, 0.5992261870156402, 0.8445142822706361, 0.7216080324053744, 0.4458318693424553, 0.5591642007573213, 0.6127238105329764, 0.6121508885109576, 0.6706809807083032, 0.7111134018174291, 0.8334307099664351, 0.42545454260866883, 0.6982532875296221, 0.8178460822684144, 0.742397336762291, 0.7338624669998798, 0.7367718507758831, 0.5179892403130086, 0.703309531450945, 0.5221280152620531, -0.17760726158295395},
    {0.565716767002743, 0.6486893851940477, 0.6949608532868061, 1.0253556254775977, -0.08602764145791747, -0.11002582303044407, 0.9227031939062221, 0.5560418888728772, 0.7022771718029045, 0.8446002228724167, 0.9926258308660341, 0.9726596864713907, 0.8749808738512902, 0.6995726092642061, 0.7658155296782445, 0.4702430766908764, 0.5973005278665381, 1.0179325807890183, 0.8897565138981149, 1.0197462310956837, 0.7765220436222164, 0.6353851111026249, 0.6548150212265196, 0.545509377042348, 0.8973508345852035, 0.8260232605750392, 0.6440393338509586, 0.6282085462932199, 0.6677803419310185, 0.6480650333061883, 0.872451932035671, 0.022297163036555035},
    {0.5452571641173433, 0.7872152923770045, 0.4432845622690131, 0.7597817821816982, -0.22775099672621194, -0.24826666119904986, 0.49761669935663044, 0.6026475906150099, 0.9001096250067482, 0.9986143914207535, 0.7293011355016669, 0.653826671707776, 0.7848549095213333, 0.9805542344352607, 0.7150908493441257, 0.8602931315826003, 0.8621093855009281, 0.7439320650346996, 0.8080055560192506, 0.7012275732245613, 0.7717011284426617, 0.5414312672962397, 0.7347433122907819, 0.8859879894396603, 0.7300946340310014, 0.5728383372192657, 0.45066145738067226, 0.8211676911932891, 0.7144480991158454, 0.21761603148993236, 0.6410713589729933, -0.020856223783399738},
    {0.8304317228792331, 0.7361187136819481, 0.9432146010699334, 1.0413485264971867, -0.05921603492924473, -0.20041979747166477, 0.5603124477364477, 0.7017482117811803, 1.0037102258251305, 1.033564680431542, 0.6863010231118031, 0.8829564098130124, 0.9234522668085825, 1.0647363890741188, 0.8154613664538332, 0.791830245920539, 0.8391473556507757, 0.7015800022678145, 0.8035450567870333, 0.9454414586402456, 0.7819371139298892, 0.9449403934344264, 0.8010123164841719, 0.715437500466417, 0.7055094994184535, 0.9326729199596262, 0.8893292822301805, 0.7877876026295864, 0.5057861394971346, 0.16522715902879412, 0.5510199856164836, -0.22617947150437112},
    {0.6729891116452366, 0.37542646695029713, 0.5888099031171976, 1.020966156888333, 0.08284212790290307, 0.09879648189566911, 0.8659729997688225, 0.6086960990336175, 0.846299092893797, 0.9190875158480054, 0.9675772272485236, 1.0308189276183777, 0.8886563103628835, 0.8394623583107774, 0.8094373518010507, 0.5594769017608219, 0.7826555481155939, 0.748243334848125, 0.7186996559256936, 0.6342740070214051, 0.7797102877526895, 0.9582189197804531, 0.7074103374124615, 0.6599424974713539, 0.4828910968763502, 1.0001970968305436, 0.7304753649827813, 0.8579165318003493, 0.5599936945707509, 0.2472253153090268, 0.564124243746754, 0.14780762679354698},
    {0.6352302962920758, 0.36570995408248613, 0.615849992095891, 0.9895775452196611, 0.03425479998188798, -0.24474160863560035, 0.5262710808596013, 0.6145588758395886, 0.9939704325434432, 0.8761218176115952, 0.6026227852769653, 0.6192313794749972, 0.601231616204813, 0.6801260593101697, 0.8527919784281811, 0.9444121261554241, 0.845122344006963, 0.7737901553742379, 0.6437665034357899, 0.7555378956370992, 0.6394854970113957, 0.7456274124285807, 0.46871344899624007, 0.7318461627954289, 0.7469145562268583, 0.8880963490163601, 0.6594264091465447, 0.6856724548725932, 0.7896538241907569, 0.370416253180057, 0.6051786947512887, -0.13189368317393596},
    {0.7691892229433402, 0.583893955674028, 0.7821769529213181, 0.853677594353139, -0.09016224776421917, -0.0006090956287711919, 0.4940792752435263, 0.8242857598163679, 0.9018366408981783, 0.9272504995561268, 0.862299486462963, 0.9160175915710089, 0.8400337310168221, 0.9755317931665595, 0.5330330728398261, 0.5758525656383164, 0.725167002818671, 0.6980100799463187, 0.7669960123276223, 0.917087795178076, 0.595798033227028, 0.6378837164299511, 0.7077007108428942, 0.6654337432894253, 0.5330951401586634, 1.0024545392492348, 0.8675264208528877, 0.5890413427949598, 0.29542334594626685, 0.4977160888266082, 0.6622992074341658, 0.14345809839108156},
    {0.7895975447706458, 0.3742292490964836, 0.8137108178699284, 0.5724911188920796, -0.19433076785382733, -0.28634869155387505, 0.7971841156991665, 0.8346854535057415, 0.7584308280831387, 0.724392492447549, 0.6150056133845505, 0.7991530389775455, 0.6128646528720433, 0.9541999365662952, 0.71986683443085, 0.5993875070435974, 0.9341675766795277, 0.8070852904243567, 0.48923311634015615, 0.5915809161240386, 0.6559811308570853, 0.471365295472074, 0.8253001089974374, 0.8410974655227567, 0.8684835388983887, 0.621515565027148, 0.5823901527430753, 0.9205778849900258, 0.5216957730025413, 0.5518510298039419, 0.4358200200822351, -0.22401599635155683},
    {0.48661946106657694, 0.5672765512848488, 0.7786181280643608, 0.812604458507694, -0.10332906725145859, -0.000818000825584398, 0.6635222346914547, 0.7309865720431818, 0.9831704524132019, 0.9078625520529846, 0.9651740009640961, 1.0899652447778707, 0.8216520240328276, 0.799294270615582, 0.9415061185185551, 0.8208539692798588, 1.000040887014631, 0.7158811079079627, 0.8445038347503597, 0.8605154585452679, 0.792664123321477, 0.8084740217670289, 0.5259537400237053, 0.6834155149076675, 0.5181213428517397, 0.6722154306263357, 0.9001896150920847, 0.8027788735098494, 0.6625301383884398, 0.6482462297550786, 0.9974840051336717, -0.02095281658710369}
};

static const float b2[32] = {0.6593597264902912, 0.6047320321322666, 0.7418627450729859, 0.7920139837779133, -0.04556460727570819, -0.07279547532340105, 0.7582632792577779, 0.7288739045109257, 0.7605394204355868, 0.788818491663936, 0.775731501283447, 0.803241774530547, 0.7054326387890355, 0.8031879963382962, 0.6700134791696465, 0.7056658579383264, 0.8035021214991598, 0.7897655226694517, 0.7012499380445788, 0.7800023773185903, 0.7353840774011382, 0.7773819236282669, 0.691981272053023, 0.6919063546406751, 0.6984922903554114, 0.7668489395618145, 0.7032352331718421, 0.792333654699223, 0.6126068520523622, 0.5939957276683598, 0.7245622350097024, -0.059846843030783844};

static const float w3[32][16] = {
    {0.21960313259533637, 1.1005662992807748, 0.6722286121806801, -0.0939300826742274, 1.0538212634634954, 1.067228848417922, 0.44040133915290713, -0.08370731801411918, 0.5060555654596548, -0.03560220695663495, 0.554329131951052, 0.2857378863680948, 0.9577475251989201, 0.8904183219188103, 0.8722882847949979, 0.21810674059864146},
    {0.2018631639458375, 0.5733456635994829, 0.49584029822097847, 0.059303198724489005, 0.5910399504810129, 0.7889162836050777, 0.7971602560758818, 0.06964250124816852, 0.5867111184973225, 0.11548696880786595, 0.6314968245584297, 0.0034400623579546904, 1.0170472815743015, 0.9662904953681183, 0.5794450292768022, 0.03501678045655923},
    {0.04172038247266352, 0.4882644216775186, 0.8746301708681085, 0.29282131562507535, 1.0244680233165058, 0.5529605667784206, 0.5317654930901253, 0.09809691511140363, 0.45911009540397507, 0.27742395165299677, 1.0944065856105676, -0.3296115896702143, 0.7516637445802643, 1.0387898254860002, 0.5391519454245983, 0.1792753513325512},
    {-0.3077254239455974, 0.8145916088067858, 1.042444424449049, -0.30113502779771617, 0.8201713379849991, 0.8700158876878703, 0.9089648776240759, -0.3354355044266178, 0.9745178763351297, -0.12424656443699227, 0.47363098621883615, -0.17974681709083476, 1.0571217534194017, 0.8809904972663654, 0.9362843810952436, -0.0872584020992335},
    {0.2644588558789326, -0.2699001056569916, -0.12204841520997013, -0.05083112617743278, -0.2950424041790712, -0.14826863766636378, 0.01030306281405992, 0.15989675086896601, -0.1534618567218149, 0.038066211159573086, -0.26333107196884664, 0.3021098537000661, -0.3395675664929408, -0.2668722353181806, -0.11631986109249315, -0.059354965572227913},
    {0.3074732986775019, 0.10120184133691808, -0.2537973697063081, -0.1007140301559701, 0.32608873939925265, -0.029816887693048855, -0.126599305611525, -0.3024427270129678, -0.015687289825245008, -0.19023778110739897, -0.2221602908012071, 0.27727973572273884, 0.17929696936854736, -0.07845678780411543, -0.21787613282880203, 0.22817357296999452},
    {0.18342333900534005, 0.7642545673976221, 1.159768361029824, -0.08505339385847446, 0.49614072084825367, 0.6144596808334885, 0.3545162100443077, 0.08278517715419204, 0.7852224287552345, 0.005725802760126577, 0.5914247151661595, -0.17534131290312374, 0.9940214516982597, 0.6844255015959487, 0.9486163561674085, -0.22586675209935997},
    {-0.257687932953942, 0.5390935393853853, 0.46688863176035145, -0.1173096477624984, 0.6909583543835784, 0.8978216607906953, 0.9407873156883524, 0.22193379768892937, 1.0478049146599644, 0.061783839196355876, 1.1115376258098648, 0.1296705752823099, 0.863487480452334, 0.758223966612792, 0.7496916156087889, -0.258610953304947},
    {0.29116074289994043, 0.9279782990533345, 0.6661434421674188, -0.002003344595679628, 1.2146030127314742, 1.1270903129225573, 0.5222642557498269, -0.05164791219067473, 0.9519187062194088, -0.3483279705322203, 0.7905536763918394, 0.22427805128397227, 0.8026084413788738, 1.167382019709436, 0.8842561735602542, -0.14141497170200476},
    {-0.0033288084132318723, 0.5320504144968532, 0.9467998071513944, -0.07221000515658181, 0.9129426690281266, 0.8696792404430216, 0.8206133895752297, -0.17201600618936286, 0.8355211923036945, 0.10871262148816696, 0.5629675749530801, -0.03955708868908333, 0.5932619353408588, 1.1532013237550167, 0.6704166568592644, -0.24286504341935247},
    {-0.2489690824305248, 1.0391559207856162, 0.894332837742617, 0.19066896910234876, 0.6972579038592253, 0.9762605547068841, 0.35878793778472357, 0.018195031691779717, 1.1538532817482055, -0.16848376072125776, 0.9287586225980078, -0.22039894428359708, 0.530471090289597, 0.689667159842502, 0.7316001264408607, -0.20117259198413498},
    {-0.15942260381036058, 0.7849188185173241, 0.9299782343792649, -0.14954903377578105, 0.5897813503322803, 0.9002289784751945, 0.9732501655878696, -0.2183689024843912, 0.9307054568628845, -0.1106742878538894, 0.680598779743382, 0.1536759722486821, 1.0784290738120108, 1.0362713523413698, 0.7719002804985091, -0.27425993867584353},
    {0.2051983186291715, 1.096139953610256, 0.9089278287692423, -0.3607826195984204, 0.8256729221994729, 0.8496438217531264, 1.0063654318553685, -0.08014957531447586, 0.5700973708309458, 0.14378754700075233, 0.8809174602088738, 0.139481392986509, 0.7927784100605724, 0.7210189688493909, 1.084181718445449, -0.045475189323719786},
    {-0.25008035704907633, 1.0064767691466912, 1.0213092875774603, -0.2706669466271535, 0.7855995582291161, 0.8780480792140417, 0.8559970347489222, -0.06802801760409158, 0.576648341500882, 0.1203238967768023, 1.0584579601425061, 0.07940864490776342, 0.8617912705215227, 0.7403720644823806, 0.6395785613704047, -0.3017788287789023},
    {-0.0158265540824318, 1.13585805672818, 0.6057540190926698, -0.08592708741985111, 0.8967022636295913, 0.6941110962569719, 0.37444594490461697, 0.0324935453186123, 0.6372054373464537, -0.15403259025117785, 0.6799910671619029, -0.23906216552760176, 0.6192749847340074, 0.9575772904391159, 1.018183657464564, -0.10380178198186904},
    {0.10972504948419742, 0.5128956140533997, 0.61508794673727, 0.3244623841774236, 0.863499088119556, 0.6413754266411719, 0.647868657485753, -0.25868778846182033, 1.1158093761537344, 0.02439159108978348, 0.6599127405376498, -0.11577713268716368, 0.7800221745338812, 0.6398474429065166, 0.5391085106823714, -0.12045485860748628},
    {-0.08766281519549761, 0.9185464218418741, 0.7881843658447688, -0.1596293407523139, 1.0728518767882882, 0.9000011258933509, 0.6065790008748084, -0.11578993843830757, 0.575498292459779, -0.23719330471382366, 0.9534121910955851, -0.12202444945008539, 0.6754655123519552, 1.1136704287950285, 0.8034103627394558, 0.2748066355522487},
    {0.14103410539369157, 0.4804802499570654, 1.0408431946008925, 0.07943652331083537, 0.6396928319150618, 1.0080178156058714, 1.017484733758702, 0.12711556001423785, 0.9176606094336425, -0.30187521614078655, 0.619664811103727, -0.299056449378124, 0.8439955129674077, 1.1106864964663048, 0.5667391601623695, 0.09325206143202325},
    {-0.24768973762837865, 1.0344934960566028, 0.663711380656421, -0.15637876984655097, 0.6055797898707903, 0.8727521419920908, 0.573433814172796, -0.06334065674336481, 0.6545613668042622, -0.30814795044068216, 1.167652039854297, -0.3219865849311282, 0.6141493203873771, 0.537428256799927, 0.9636955190450875, 0.2180641465672177},
    {-0.1367215076003672, 0.42287329146080316, 0.9562938012080114, 0.05268731211865728, 1.090506890589877, 0.83408408726927, 0.3223194914994376, -0.1995183319941037, 1.1227584070497125, -0.2688531858992026, 0.7371256694232452, 0.13780799541657754, 1.009819103278627, 0.5948931456872074, 0.7228066717209947, 0.31083084896399843},
    {0.19640580724760798, 0.9995458641692858, 0.6519972341208524, -0.3066572174969016, 0.964732636276088, 1.1668918258717098, 0.7865358520827586, -0.25514526600482335, 0.7056098413398263, -0.21482182300267696, 1.1528269311520427, 0.1414257362291183, 0.9211511375234585, 0.626355250179493, 0.5769755658911289, 0.2642340509203655},
    {-0.12940863139368575, 1.0361066792569353, 1.0511390989928215, 0.34127702825816825, 1.1455302325336698, 0.9392728589648282, 1.1018013033045737, -0.29353686731911005, 0.6453700442888087, -0.20018239549970535, 0.7831587921226393, -0.11961939253192748, 0.5751959815725456, 0.8434686773490897, 1.0483113905310122, 0.27772614803502216},
    {-0.07653012094533505, 0.9462972812416441, 0.5313971951694583, -0.294630992587006, 0.6998778812373648, 0.7597333076123262, 1.114587980499453, 0.26416393779698427, 0.5769342169753543, 0.10262143536175161, 0.5331942812232804, -0.2964256770991822, 0.7295503884856575, 1.0909632696807148, 0.9145128617889143, -0.14411542632991553},
    {0.26777193625524864, 0.49492372054111383, 0.8626277385735516, 0.302477600528554, 1.0195918220975284, 0.5884157481237374, 0.6472726074313006, 0.06175696641897856, 0.623381198059169, -0.2370855875477944, 1.0883675189009878, -0.3142138524006881, 0.703544526403413, 0.5961904174490041, 0.7719696441344562, 0.026886456186510307},
    {-0.08909156536822363, 0.8112610013143252, 1.039307808522304, -0.08342894631904325, 0.9355677908808632, 0.5895245039718677, 0.7966254527802006, -0.25678921586269504, 0.5251504738295577, -0.15476946262120952, 0.6351977045698676, -0.25567540281272544, 0.9231187638011127, 0.6726716487645436, 0.7348844390545934, -0.12670831137494165},
    {-0.2025536426120484, 0.6524868354582223, 1.1109292935202293, -0.20036515127198026, 1.1074169450018445, 0.7574506513129516, 0.7333879121099847, 0.07039721115655666, 0.8401076856564215, -0.1796345166067135, 1.130693139882795, -0.01941566981299116, 1.0203497783592013, 0.5839935584616132, 0.758878444108455, -0.3447454205091185},
    {0.296786340454811, 0.708814669012699, 1.0356309607710905, -0.2639291974341811, 0.7630297443552061, 0.671280052809392, 0.8089519649558007, -0.05284207446542946, 0.5760160361966224, 0.023942654817401224, 0.549608098910148, -0.21466159601265497, 0.771984301899107, 1.1135347330727972, 0.9128902258261616, 0.03224483870719817},
    {-0.19884101952892883, 0.7717450019847102, 1.1787073327240878, 0.1769459220675896, 0.5290060208169328, 0.7627372943012508, 0.8623399807867346, -0.34227831638158995, 0.9203362132958557, 0.28886199681067576, 0.6438658638756488, 0.026195620967413492, 0.49285760647322135, 1.1291252185160787, 0.7095862051681275, 0.11876327526946638},
    {0.31875630921582204, 0.6097316288088355, 0.5025390759254066, 0.29375774711575225, 1.1060174242472416, 0.5885784218612324, 0.47615065641713683, -0.010361959145982202, 0.4365697085539469, -0.07838439847419447, 0.7366750388153133, 0.26234638785646724, 0.8483920019594385, 0.7988187064033857, 0.5692295845080813, 0.021149198456331984},
    {0.13458538699365288, 0.8527422500569928, 0.8331238567455366, -0.10131036730919867, 0.5536343351682537, 0.4491088652764482, 0.8228685676224016, -0.06760193514239565, 0.3890558085649219, -0.24747655707452587, 0.5980228881814467, -0.07229354276004303, 0.880034690470944, 0.7125632172470344, 0.8308172710516886, -0.08938529361526534},
    {-0.1836739095515092, 0.7490589135971706, 0.6849324088439827, -0.3559946655894186, 1.0690489130411711, 0.8215538518205427, 0.5056070090915155, -0.22391336783842317, 1.0383677400136238, 0.2229844646203883, 0.521997899951101, 0.20255716344778013, 0.9472003956961149, 0.9283252714818127, 0.4679523575652993, -0.21145431296092188},
    {-0.28978955758317987, -0.2799690012939893, -0.11190753774700729, -0.23322886306264115, -0.16418589913605847, -0.21901618968049077, -0.12055208049727491, -0.2098392480121711, 0.2279644071204642, -0.016239735634411424, -0.03432840336665112, 0.00725273075881618, -0.1196890315053005, -0.24308757035603107, 0.046690756541094315, -0.07767868626372637}
};

static const float b3[16] = {-0.03092304669520859, 0.6307499995911311, 0.5147649271891661, -0.028106865886005458, 0.5955632119988226, 0.5745108980425186, 0.5114183735948624, 0.009375905244199175, 0.5568758978633894, -0.01263113118445191, 0.48636912668586546, -0.02768968677288159, 0.5782950625820543, 0.6369356505963587, 0.5722901643253595, -0.030111850872147614};

static const float w4[16][12] = {
    {0.42572696501126106, 0.20657562071977104, 0.37227332589018236, -0.043338571142023975, -0.24253749971562036, -0.15809293794725368, -0.20303320722587084, 0.27055185056375597, -0.2596153181920618, -0.19590480674197902, 0.35376306551241166, 0.2993824172681117},
    {-0.9704765830562945, -0.4161186916038259, -0.66837416065584, -0.9253347164447924, -0.4624946751291827, -0.5693093292786937, -0.8697561755696686, -0.8729645635409752, -0.6386941381861281, -0.24842890855527314, -0.6670843507404459, -0.6492552498574696},
    {-0.9367745835240167, -0.986314481454677, -0.8814679596969891, -0.39668253517728147, -0.6835722190610325, -0.8571469589144719, -0.8197743851455556, -0.8561865849071354, -0.20630885352090272, -0.8717549516024453, -0.7568380985491434, -0.8669535901299756},
    {0.2896749007904246, 0.21150305912143663, 0.01367901590385724, 0.06770150916321795, -0.23909084795511623, 0.23756989075772245, -0.43082769524290504, -0.015889944151737036, 0.39691585721500783, -0.21935001534423762, -0.09326655588878009, -0.0027972149898827263},
    {-0.4819439641659805, -0.9094862039427345, -0.6134962157549941, -0.805346962855781, -0.3695792014209385, -1.0239102043774553, -0.818982040760287, -0.14739986443773928, -0.4766815523151492, -1.0249340097989827, -0.5794078220688349, -1.0193792490456863},
    {-0.4611350839350007, -0.33474571738970227, -1.1095399411951086, -0.8681595549391853, -0.9942485078123385, -1.0492477144403791, -0.22546885857257631, -0.7487879699825074, -0.7769768657906367, -0.11604848772264699, -0.8812986692790078, -0.862282332838399},
    {-0.7788052481411357, -0.8903486903105028, -0.46040254705914624, -0.7818372469464872, -0.9088297759487901, -0.270801302855313, -0.1414652735260344, -0.9641643532655034, -0.5395896969445599, -0.7783667891692438, -0.2722344984520643, -0.218524679998317},
    {-0.45535856832906957, -0.35555276139776076, -0.12140939059025062, -0.331657295807184, -0.37645236674723725, -0.22099684711050263, 0.13515169794316456, -0.4360264112655527, -0.28541885432146286, -0.3104653500700006, 0.028936898425505467, 0.08363516039861588},
    {-0.8575274416289921, -0.6027459164551304, -0.822468857596244, -0.4874801210045208, -0.6803590027057979, -0.6013513050179781, -0.9497118096731084, -0.18433236069675366, -0.728344542556973, -0.6956834876559249, -1.1085239332147676, -0.5403454613948115},
    {-0.4455417294142958, 0.010911530342447195, 0.21829673491787627, -0.4194721731682098, -0.025090750892316577, -0.09433577967468715, 0.41889888871355097, -0.2480575854080758, 0.4429895291209466, -0.043538249362713166, 0.3801441559028552, -0.34461773947429003},
    {-0.563155559280189, -0.8393306189740808, -0.30440760021816765, -0.9468358329179549, -0.31118185855526453, -0.37220550008974385, -0.780085658729874, -0.4165664902382108, -0.9246197235694785, -0.9269736598657063, -0.8439414335318046, -0.6451331485718351},
    {0.2875078947892866, 0.03631550951647828, 0.07925189430757758, 0.3109132173751429, -0.3066586805262473, 0.30670395506410647, -0.07190303710581318, -0.32411773300627383, 0.33878452881564164, 0.34639669087983826, 0.20492765288612735, 0.3500167291359467},
    {-0.45200188883672854, -0.513943169123761, -0.6062454270093687, -0.6234143128070566, -0.7502152063476601, -0.5208787094770888, -0.6501699626549643, -0.6695340447065576, -1.060586256848723, -0.4638391271005007, -0.3197810457669143, -1.0607875921188092},
    {-1.0759827702084974, -0.6665855292934844, -0.8102690864996638, -0.5401637938706757, -0.9031222824808638, -0.949209358551662, -0.7557055165943047, -0.9807015320804243, -0.6079810865721982, -0.7235537056809797, -0.47822132259619493, -0.339050023909954},
    {-0.18108414972355702, -0.5892333252479751, -0.4461192115121971, -0.4067560480660163, -0.6927251399913907, -0.39912321715987964, -0.6523677531689597, -0.9136739507644518, -0.8284114316684764, -0.8929788012480316, -0.8507092357318848, -0.45166533538451525},
    {-0.30025067075939493, 0.17443990464133644, 0.36932593819546994, 0.36956936096695353, -0.15240704367984104, 0.24427716939533164, 0.23142630157392297, 0.3574944759870021, 0.37948640819851875, 0.39642948165271896, -0.41129324829453723, -0.2478717491119724}
};

static const float b4[12] = {-0.26183086718315635, -0.30670019102657886, -0.3316170849458957, -0.19651980533063046, -0.1675659372688283, -0.2931857358671995, -0.15960679319377438, -0.13632147029117625, -0.18218935369363443, -0.12983097623830334, -0.29610275161983685, -0.24576888748778286};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
