#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.711019049631563, 4.580036108940604, 3.0016988508717786, 1.274834754659399, -1.4623747224030947, 0.05940011650161787, 1.084633864590235, 0.7445259125368866, -0.5356729972544826, 1.0142747624640347, -0.6776044017959784, 4.743243808791527, 2.605059381147845, 0.8365179215653143, 1.6224456938272256, 2.495549687129821, 2.1040915168464287, 0.9914511254095283, 4.695953616061866, 2.0649267959072524, 0.1939987853503288, 0.8062361060971419, 4.211582662594776, -0.25275301708809145, -0.039978122617607886, -0.6046816140538579, -0.7571311742124518, 1.088133814724906, 4.339971702828759, 0.5560441030688963, 1.2143035750002553, 1.210729550745434},
    {-0.13291161498142995, 1.3999704928738512, 0.6719178386793454, -1.9667043462346643, -3.1050387957464376, 0.4146222750369239, -3.40825197662314, -0.6794474729792873, -2.3919303040783233, -2.9773105457167697, 0.21935962953500365, -0.3414792508313829, -0.2738359520037471, -0.5060199897579026, -2.6796664635432017, -0.3025399447786578, -1.3095814346024748, 0.2494993408680512, 2.4077831036997415, -3.1300940263575217, -4.295489570301404, -2.9094647669791622, -0.20292216305804528, -4.050716087013554, -0.2651090998893597, -0.36797632380187617, 0.9035595102604463, -4.769062944806825, 0.39530945021247, -0.81874470209927, 0.9136625085954218, -1.9525583495270291},
    {0.628507159917694, 4.640894962776369, 2.1278967328676575, -2.1158317378236493, -4.325857879810883, -0.6104070206782735, -2.194417694948958, 0.34786625347755373, -3.5574458390947044, -2.719471320321278, 0.2235663491467395, 4.038649212522123, -2.022458374957888, -1.2099378992908125, -1.7182736677827941, 2.0353650845160263, -1.5151575011794565, -1.6543927170246202, 4.574289954253142, -2.057040639214013, -2.1521500567078933, 0.46993460835390466, 2.254065103624757, -4.205797105356764, -0.527829179458808, -0.47451666769911616, 0.4460698617967114, -2.4332809113819054, 2.0765001259398876, -0.8962998214839218, 1.712204623985753, -3.5560112803169397},
    {-0.032972313009424874, 4.666468125653279, 2.2112366181316534, -2.709248181599596, -5.04418559332668, 0.1054584136468949, -2.8966306642221573, 0.4678343283369346, -3.448821101719339, -3.35572445955281, -0.8369575846376697, 3.2810898399138573, -2.567783919346859, -0.14445730878539456, -2.9457562841466007, 3.2770797280940447, -3.304685258726529, -2.8720588739470196, 3.9272273761829783, -3.4752786088262964, -3.8404420707893663, 0.551250906052913, 1.5239759884096904, -4.294497880487712, -1.8655928306735952, -0.33236518705935836, 0.8729569447667248, -4.072722545731898, 2.400105021879506, 0.7657021523918668, 0.034582054133353704, -4.719551973308248},
    {-0.3047056009423481, 3.525378498459219, 1.4885258380701025, -4.42552330710187, -5.1673669182907345, -2.2634083038435726, -2.409758441163402, 0.9182125857623, -4.682675646204046, -5.033605214284986, -2.9659159234395944, 1.8227228377075853, -4.505010258146861, -2.45044300915286, -5.218482888160691, 2.472000946831356, -2.156295688271376, -4.011829697937736, 3.1070099626322203, -1.568214659072391, -4.044207741442251, -1.0778989670258954, 1.9712513799641345, -4.27404559681456, -1.422434554519155, -2.4448227227762716, -0.8470823766227529, -3.5320911006519498, 2.664957007939556, -1.0173869657668608, -0.5886838681426555, -4.5464181252991365},
    {-1.1739412546573316, 2.8546449903797124, 1.5789699346586874, -4.136830219926031, -4.655875311298838, -3.592582237644489, -1.8961895118177787, -0.6345989819846859, -5.142820049116287, -4.159424296584107, -1.8208153790211377, 1.517713882891091, -5.464246767004838, -3.9051577682014034, -4.999377367240386, 1.4924929913637972, -2.593381099377985, -5.248626887408047, 2.963231115713071, -3.228881878895112, -2.5776653072083695, 0.09221272886684871, 1.420809488767408, -4.884951066870199, -3.6827565092569308, -2.140708498621411, -2.099749003139145, -3.7789708015572114, 0.8868202598923883, -2.8048074928057005, -1.8356017355614844, -5.993769368980889},
    {-1.4705838026617561, 0.5607643539763038, 0.25119215024325975, -5.039476430496205, -5.457202105625679, -3.298922175048059, -3.231136898945125, -0.4934553721021384, -5.518500516736442, -4.617468950261378, -1.725802126479236, 0.16779819995614692, -5.467474344501249, -3.496694945578433, -4.705912056344025, 1.613631612305477, -2.957354450988136, -4.730576723994946, 2.655327949178404, -4.103816364872124, -4.76552882987925, -2.40309401196827, -0.6210474917051936, -5.0959304946362485, -2.640655752603511, -1.9549935081096654, -2.3576394063857835, -3.575762305388504, 1.4515307532989083, -3.597637580471871, -2.711042853080284, -6.067310826514358},
    {-0.6315663305490622, 1.5511509802554617, 1.310172260129068, -4.243442065501178, -5.544430661197663, -1.6201092500354541, -3.4007950186634206, -1.6371802340002135, -4.661556459071972, -5.055978315663751, -3.1712197851743906, 0.31727643558828483, -3.6880524125169414, -2.6081315730969057, -5.156298158514489, 0.7455592122998967, -2.594520265099369, -4.920590865490103, 1.8527399186002897, -3.7787907145638595, -5.202799281320575, -1.144517602754071, -0.16895615195850894, -5.709974398990839, -3.3024175970634233, -1.8503570564471947, -1.4921017886035923, -5.20982027250521, 0.904216459257362, -2.6012567085860416, -1.5290101090679815, -4.365641871211202},
    {-1.1652075005239968, 2.7883193168308207, 2.852847298760028, -3.5998464390122384, -4.999194010691651, -1.6097232076068475, -4.241602002962711, -0.6569469471651308, -3.405967024891655, -4.587564041067905, -2.6119002047901785, 1.4648104434163447, -4.122301666399462, -2.5611440967710126, -5.6590148764906205, 2.6499128608187537, -2.410881183814002, -3.4253431314886984, 2.03634083022867, -3.2233114719861002, -5.440084152693437, -2.157226563924036, 0.4662109074781839, -5.712612815099855, -2.3547629270638226, -1.1485197803450935, -0.5647969375136246, -4.747763152340885, 1.041052560382521, -1.198838884182876, -0.5326206867768539, -5.502637326416901},
    {-0.6934992198968248, 2.243610004223291, 2.187225766994499, -4.840740192107779, -5.48825410650494, -2.3268579609151683, -4.3859743541815295, -2.890092008446175, -3.3258053192983486, -3.8694408249188705, -0.4552905762957987, 0.23480103059521512, -4.181355808757082, -2.5232722671407695, -4.65936642791427, 1.3847638912530948, -4.453936681033907, -2.8342795573418744, 1.6984657053675358, -3.9814513816986175, -5.3735895690212905, -2.3561585932132068, 0.8930683980183742, -5.322012394406132, -2.0664898717295945, -1.1916709542994761, 0.016399264138223204, -5.4800494845271555, 1.7485830070125559, -1.5453747892660927, -0.47603013378567216, -4.345396730989852},
    {0.12644351983183247, 1.4508723505156147, 1.0657826844075242, -3.5911011249417895, -4.718155934109877, -1.697745949740176, -3.8711471693246953, -3.148604296505875, -3.439890372008462, -4.623933976803765, -1.7781414581955777, -1.7015803608432316, -4.429007778131778, -1.0443679228364617, -3.1326736658618275, -1.3931130990996008, -4.0970925014684765, -3.6572655404285004, -0.2457801884537205, -6.035393421342633, -6.033788348069397, -3.5930630030572597, 0.37250036557875926, -5.317252694533864, -1.4643345786475752, -1.5053084987159593, 0.2624302111674005, -5.53072042557366, -0.15811611336981815, -0.911088717186111, 0.31841526227026234, -5.537911082842836},
    {0.4072218534793609, -0.010122175291834479, 1.1137386767704378, -5.1313814226369665, -4.062114476962345, -1.0776127346343753, -4.249989025302111, -3.2174674374386902, -3.9977235595855234, -3.450287281376783, -1.2002496322984144, -0.6205473854882483, -3.2235436895471077, -1.659190172926245, -3.094735367163439, 1.3985492648637528, -3.9185968691070547, -3.1619136772223095, 1.0030961121341044, -5.187760397209857, -6.0509174335585465, -2.946498404677272, 0.20657247432290207, -4.240782484341018, -1.2963906261101354, -1.2604798696994082, -1.0210707578058984, -6.127280042475297, -0.2853269428159899, -0.7088230843287306, -0.09839215402471893, -5.353534952169005},
    {-0.3705380788156882, 2.122019549877811, 1.303931347967504, -4.594441347758907, -4.97778996420886, -1.7323127161769567, -4.757960321044208, -1.8605174997181035, -2.6710747582958296, -5.0516564582755, -0.20765625052749995, -0.8385552247069491, -3.2282341904322163, -1.0868364955296888, -3.689446329176631, 1.266168824097015, -4.154774971740214, -4.123943930759092, 1.691575470302093, -4.768241031853816, -5.124951038030351, -2.339171472279969, -0.15269163336743827, -4.213505968599492, -1.1251109468201683, -1.0448874032619109, 0.1620546396230744, -4.356414001858025, -0.33607230432781954, -1.3997642387995075, -1.3447640921801627, -3.4778797267756234},
    {-1.1594231517172222, 1.1694126468484651, 0.16058900176978413, -5.263057778477694, -5.593558922438981, -0.7643117778469298, -5.43827876199363, -2.7648039168590657, -3.8438362381355544, -5.3999378316920446, -0.6288380292616149, -0.12757196228440984, -3.9882708256864516, -1.580293320260421, -4.662699326608909, -0.21364884006180665, -3.7353451315527963, -3.9560132180384624, 0.7003444826056027, -6.088503965613269, -4.463288324310792, -3.032506889398137, -0.2577671298898163, -5.0750840660633445, -0.911475554847174, -0.8000422024617019, -0.9844311424381027, -6.285651718025761, 0.3775516543415991, -0.2529109300241607, -0.6990359011676239, -5.450003931515862},
    {-0.6892607897407635, 1.4089151715231587, 1.4973989840068604, -4.004774261285767, -3.938111620979215, -1.4436369385967762, -4.3523624165618, -1.674465198743068, -3.450459841005144, -4.28150597070312, -0.8332496734962788, 0.7745671058099313, -2.956112874904703, -2.290661736578505, -4.582338189269917, 1.2598125710990284, -4.7307933627783125, -2.537435306381803, 1.002303091756616, -3.9232906105300303, -4.299707039336407, -1.3831811347189047, 0.22567025260270585, -4.474530376724949, -0.703301559925893, -2.134597999583482, 0.15089313047722924, -4.997689718486146, 0.8208730639305607, -0.7066973234396945, -1.0081032477296228, -4.237702645125194},
    {-1.0466868805071563, 3.56128833659646, 2.8354167917644175, -4.709463341380484, -5.035797225134167, -0.6339031958852622, -3.9695778213504838, -1.257674718107616, -3.898648427234305, -4.437419046973548, -0.9199038846138718, 1.8092776040994447, -3.0116496669640367, -2.845333556256972, -5.2191014241876745, 2.4316647696715554, -3.4661945099072047, -4.566547994098198, 2.0851245756107324, -4.8136091229983204, -4.714174754584813, -1.614533151765886, 0.3340676910614259, -4.524381615272067, -2.8092462381376366, -2.1852164265510403, -1.5186104955488087, -4.866826113696692, 0.6281511471906684, -0.5677870302904442, 0.15376887543065526, -4.516639781043551},
    {0.9066733518370275, 4.554713594468191, 3.842320618943437, -3.2096374446347053, -3.980355063275925, -0.4160363071111713, -4.281094217401836, -0.07503633844554729, -2.6240234046932343, -4.7289145336206335, -0.4006026512902454, 1.6140840096521767, -2.384529382795672, -2.1778968572869624, -4.412662130319616, 1.9532593446194617, -3.132988373858751, -3.7420208179207433, 2.605213915187507, -3.804108270669249, -4.351159586353739, -2.07855614614512, 1.9805190442743144, -5.31508651255582, -1.730929474063615, -1.543485113174846, -1.1787439462850886, -4.207276452884287, 3.2897478662948187, 0.38768088137483026, -0.6538835856499534, -5.610441051080059},
    {0.5560887716025942, 5.605384271249256, 3.506986147736073, -3.1204585465894064, -4.63555369096962, -1.2815752121004076, -3.5498248285023775, 1.2576488672733088, -3.425578954787562, -3.145736002097719, -0.48956924440037386, 2.4112510418904023, -2.1646724317338846, 0.07295123887625013, -2.4520295677635118, 3.945078016727616, -2.607785466086495, -2.7827352278744204, 4.436855977695232, -2.599357641286823, -3.3133957693155813, 0.04242944983963433, 1.6278565346134553, -4.162323028879222, -1.0016521783655563, -0.9195490162614605, 0.4389150116558546, -2.5375536843962103, 2.1831093539763833, 0.720776420588583, 0.8844593341729208, -3.810030867996939},
    {-0.9739676935154568, 4.59590663501537, 3.1724916197596045, -2.2062810788852967, -4.311799553360238, -1.8158253470365828, -3.436303635047141, 0.8723895347362275, -2.7373128139992815, -2.593765846714941, -1.3324112182523602, 3.7182226547597628, -2.717250129067183, -0.5542666932665988, -4.171097993063587, 3.558721458281459, -2.6532285062053194, -3.7564983282867552, 4.18692850951801, -2.1848365415563626, -3.059517941468768, 0.10973012788774243, 2.1845635867154076, -4.450619841939722, -2.2129893786435435, -0.319237764740675, -1.0276007209305862, -2.560594527887181, 3.761899834427531, -0.23028776595480097, -0.45455725646758566, -3.958164259897357},
    {0.12762160638611555, 4.288079423085299, 2.1975562698619284, -3.7762204872654364, -5.124353156149745, -1.264904369234638, -2.4794980879615194, -0.04806177890003393, -4.198552782221625, -4.418162227992939, -0.19320071713731568, 2.330341028469495, -3.7701651512279497, -2.3427110033534886, -3.8360906955323397, 2.0902142686462972, -2.094269988453959, -2.9559555876544223, 3.8438536995465373, -3.315365538060154, -3.7977326606331916, -0.6018771865948104, 0.6851272204383018, -5.265009420557544, -1.172712772824205, -0.753766066186541, -0.23464013541588494, -4.754045263934939, 1.1378069143485718, -1.4612327820534476, -0.23579196512445166, -4.353212721276749},
    {0.7329874028545968, 3.793304450222698, 2.9897599350633763, -3.6213996599125786, -4.129346970698236, 0.32650391261375117, -2.862648730715507, -0.5419969461542871, -3.053871856198507, -4.561434893110578, -0.6266270079078073, 1.8542273427582432, -3.2630153849815997, -1.6291189841211833, -3.2484314054105594, 3.000930395993571, -2.9655376040611228, -2.483727553693227, 2.5925228546230867, -5.4710339724007575, -4.960197955911698, -0.14188224173466038, 0.7934674656593839, -3.8138889752593674, -0.4414220822270933, -0.2531963289547866, 0.1620066700469107, -3.6366567151413562, 1.6940621914944831, -0.49641868257335725, -0.0025549002501542364, -4.238414822024042},
    {2.267525991846386, 6.358372087452687, 3.632857493318121, -2.3052424708958363, -4.707552577880487, 0.21658046180151394, -3.517781277845703, 0.06559208880915025, -1.9766857575598893, -3.0087217301989697, -0.2772330498201319, 2.7211260268282054, -1.8419405808282872, 0.4251660939255479, -3.3424223597406857, 3.530071672279138, -2.9609744347748452, -2.022043289094348, 3.825513229853603, -4.04201959566574, -4.024338164473293, -0.5969619903667518, 3.02016052191879, -4.207537525545857, 0.17237724766738258, 0.6979352605584724, 0.275157841459039, -3.1541521391863836, 3.9047773714269742, 1.6201235311138054, 1.743619840391891, -3.2887186059695273},
    {0.5659587127355302, 6.218360193583412, 3.0622473447176666, -1.977912415400573, -2.158385109830848, 1.6622700145269182, -1.7458183831765395, 1.6714140687685122, -0.9018953853739663, -1.9836382568201005, 1.505672416006264, 4.710940069619708, 0.4432049783999629, 0.5670255981469906, -2.213710975273015, 4.157361768760773, -1.2824617216993748, -0.19482779660765065, 3.421652691315156, -2.2886003577540985, -3.6130146188316945, 0.5177428077784552, 2.969318305724472, -3.5683627048083726, 0.27331851242791644, 1.5849136198987992, 0.6475346503152704, -2.689356855124705, 3.4236374080066168, 1.3584932427597263, 2.1463347772316217, -1.7039452616515534},
    {1.59906710951944, 5.583772550292713, 4.341257019280774, -2.6395999231369025, -4.168434178642332, 1.1486305959779484, -3.2086756511285466, 0.4423201582609708, -3.078353525655351, -2.2109708577697664, 1.0889924926666235, 3.394335056633684, -1.4963726243163427, 0.13801052912233353, -2.0459019761114408, 2.066587456040401, -2.3047408462325016, -0.8676582030269755, 3.4796496307654112, -4.411831471415326, -3.8577485262013367, -1.270179359324221, 1.6213323631959626, -4.431592209455205, 1.0571587484424112, -0.1178089076344597, 1.1698483820132273, -3.5752639428726787, 2.385755653172052, 1.095237441342353, 1.3002372893947192, -2.4515930160776414},
    {1.2167774616457308, 4.79499213167976, 3.4112522207525573, -1.958827664668562, -4.684682250986644, 0.01805606939223379, -3.163022521158016, -1.3339333715904045, -3.9990294676763067, -2.685075760155347, 1.2183990308952104, 0.6146264853723761, -1.417315197655733, -0.4552276960590108, -2.56557616029878, 2.7233064041027335, -2.40869424799494, -2.5151700409812983, 3.7799129929104858, -3.6644867166957167, -5.1101580172939185, -1.4502505087253879, 1.6071127648899661, -4.371827488335144, -0.10175660113775714, 0.3591941894450847, 0.8046296873497004, -3.3750036304761935, 1.2509731584022934, 1.4067525703122485, 0.21512404050256853, -3.3615301043867736},
    {-0.11804957385241625, 5.025484491701985, 3.6232663528719606, -3.2513485571369745, -4.523917981891304, -0.26609009041701265, -3.8288763164065123, -0.6515740540285698, -3.5518947339993736, -2.425352802905647, 0.3207035811015016, 1.832401157798831, -1.8376863745853333, 0.19989190101770016, -3.7297156464688896, 3.3356122666449672, -1.5454387297069017, -2.8372752353601944, 3.7171960544467018, -4.562894990517596, -3.9879127476868543, -1.4353980031972082, 2.699995563028652, -2.9371353952938835, 0.016448938015519474, 0.28829941872190373, -0.08716606071708533, -3.5397970273675416, 2.9657608502386235, -0.43894897344439404, 0.467838450901686, -2.920735339224727},
    {0.9618828967445934, 5.356541718873193, 2.9987282880300468, -2.8785713662143917, -4.892836048768273, 0.04154423741874223, -3.0578458967339466, 0.5981780192202956, -3.7219023926416335, -2.9939085765130566, -0.179437085495335, 1.816078883487622, -2.424769667697122, -0.3080831115124396, -3.8789051260610656, 2.494524723097965, -1.7690016062876022, -2.1406769778202026, 3.6279677857515944, -4.39584115962191, -3.142609958756032, -0.5396756518831728, 2.7403621795214974, -3.382787083905943, 0.58608690202378, -0.4612250409021087, -0.7063393334193776, -3.3928556757882866, 1.8067017067744018, -0.09416981054049806, 1.0198703899051291, -4.707924617812012},
    {0.3246303119661633, 4.8571069942332485, 2.7623740693598, -2.547810510584541, -4.641257224894612, 0.32643575942225994, -3.9283045139800232, -0.9892844755037289, -3.819046517686663, -3.059164430382915, 0.9900320047489418, 3.0223968159029297, -3.3239187077233567, -1.1278042478033552, -2.780538298236169, 1.8483439757076936, -3.417682714837282, -2.9672244870100335, 3.0615892002273593, -5.074496865385935, -4.474138807479257, -1.8673615306030513, 1.9010930941418658, -4.120028844952588, -0.23425151664397273, 0.397190927054944, -0.4797181054492661, -4.090744414081902, 1.608441214786326, -0.7412772245660908, 0.597712016690804, -4.607007261520995},
    {1.1119595505021451, 3.085554624512608, 2.287304184323575, -2.8408978434051027, -4.067822882467332, -0.1274168958244561, -3.498264797418395, -1.638119675108639, -3.7222191927329584, -3.363311875485396, -0.7708151548232481, 2.567073035829151, -2.0660018344336972, -0.4635323326471004, -2.547301002678802, 1.7674194349930572, -3.140712605658563, -2.692607623276255, 3.2130202036633135, -3.76266841854353, -5.477866119191812, -1.025314743959214, 1.077394029566215, -4.844824744619494, -1.196369121666106, -0.106633617014915, -0.10917979119271097, -4.362765553772254, 0.896691265238045, 0.807760802007537, 1.5406035263043407, -4.529277565699789},
    {1.7354784002190984, 4.943322054021448, 3.231898693564674, -2.306448140636967, -5.161500892136038, 1.227509642214472, -3.9708995273027803, 0.48131390627240644, -1.8028543723144659, -2.518509026723905, 1.4947014279979705, 2.368442850050912, -2.1501885013650712, 0.4447442418978968, -3.4057516322811963, 2.8025633260686007, -1.972855598483418, -1.0117602026683195, 3.7569896363211743, -4.574105919627644, -5.007615145536803, -1.123522399148131, 1.698649002693928, -4.261382509814965, -0.6919589534553179, 0.9922432076969631, 0.8901607986663728, -5.129952822344835, 2.8678107036177716, 0.2355270361459281, 1.563727893083658, -4.185682621506094},
    {-0.6991033649668726, -1.5480156381611478, -2.8272102072838594, -1.071473239022709, -2.2819223497538097, -1.704952761037891, -2.514426070134138, -2.8537330556399882, -1.5340552153692004, -2.8977275013495714, -2.313953361603717, 0.31346881368317736, -1.2063481093484092, -0.9114195954621437, -2.5168831757243213, 0.6257720725763226, -1.5290917891592715, -2.390123274151574, -1.117577616827809, -1.806684845694423, -0.34818337962811463, -1.4979761338392505, -0.45273872516646896, -1.8740422421061678, -2.9860489487415594, 0.1968616403533921, -0.6153607214261603, -2.204706845121136, -1.4339206122203774, -3.2050208078345137, -1.493397789201129, -1.074865727868174},
    {-1.5895660708584856, 0.6346606412506836, -0.606807854623271, -0.22466830829068657, -2.8756626116597364, -1.3332312725400617, -2.5654228943501196, -2.8111533823493975, -2.465794410926289, -0.13280473232814796, -2.3999599169691996, -0.2935654520461087, -1.3691689248224461, -0.46127592008204876, -2.7108260560249002, -0.5023988754383537, -1.2015496329979563, -1.9203696647270603, 1.1238591283244679, -2.4666096136400073, -3.2631248528203027, -1.811324885616904, -0.06101451826476085, -1.396406937677188, -1.1018970755513624, -2.1426892253472443, -0.7148540304280083, -2.715799461386571, -1.3076088040882283, -2.110485441389594, 0.1076844792082055, -1.7757120619005022},
    {-3.6291101754215074, -0.8355503948495312, 0.04932638850947708, -1.1034881023659684, -0.884452817547495, -2.0592429796870992, -1.2417930906777992, -0.45508643410800026, -2.755525983898815, -1.4438191399126126, -3.6756395271753703, 0.4207889100759596, -2.0535705798952284, -3.1674491047492306, -1.5401839523545944, 0.3799627457809737, -1.540774098817381, -2.331728364136535, -0.18639952827236106, 0.2411716116626785, -0.32914101333699897, 0.49666703615846536, 0.6811066863991644, -0.7866315238997795, -3.823184626622057, -2.0233819447295094, -1.8435639714405025, 0.28318641040318865, 0.6636292753676585, -3.3456978534539967, -2.3427834113706782, -1.2591245079238342},
    {-2.0043940013405157, -0.7374714324956875, -0.0847393735949896, -1.1070835622920068, 0.6163917340377161, -2.1411102984168022, -1.4352115064839683, -2.369500473885719, -0.2817790722433835, -1.3868171771246005, -1.9297370696003286, -0.8890866086427291, -0.7548473673796571, -2.7606303486254906, -0.07358728375319944, -1.0404386761285775, -0.07302803655142463, -1.3254846485245788, -1.0689249476159493, -0.12710365826051312, -0.03365338184916359, -2.0887686519405952, -0.684028840813365, -1.093299795626131, -1.346457962267086, -3.1329031446655953, -1.9689631793437428, -1.738090014867792, -2.027156060543911, -0.7308015372754979, -2.832993034886456, 0.9444722601867052},
    {-1.4325341350388052, 0.038798556761953346, -0.8383491950480425, -2.915974263835671, -1.326965491517818, -1.4761333216446255, -1.3377868614743922, -2.9874189835199507, -1.7996430647193806, -2.2246759039199646, -2.530225735663118, -0.11557908953393554, -3.4682735487051737, -1.7252968050444812, -3.161331262406343, 0.21905787604874097, -0.8080217218629305, -2.0720627989484477, -0.26287454757513223, -0.948177220410315, -2.4768564554739854, -0.05336153595200206, 0.41415803051623923, -2.8435611695886354, -1.8736411075614618, -2.559434980987777, -2.5864109330758276, -1.0114239646636303, -0.4461562268041494, -1.741760124456407, -2.0454418022085683, -1.612552327037898},
    {-2.030360014589889, -1.7863492908569156, -0.8032067218106713, -2.7807630647997637, -0.9768768978695919, -2.616618818265279, -1.7269939969938688, -1.7692372364963438, -1.260266418574623, -1.3090402159082726, -2.477858023328209, 0.0230816713063004, -1.7402611272834072, -2.6460304479804515, -3.0841605623623414, -0.7051113350815323, -2.0177055201075063, -2.5753712938303797, -0.5284114029758423, -1.5835052231166498, -0.9263773985452738, -0.756210807388485, 0.7203785397731904, -2.6896590743091284, -3.367675406974578, -1.1121324437424869, -1.8158180538959712, -1.923876240911171, 0.9853871492748476, -2.6875053800408115, -1.7518616056315697, -1.4888370237418227},
    {-2.2233534059008506, -1.640238902192135, -1.5935940180164372, -1.522345796889283, -1.370763375001015, -3.6388187469105406, -1.350592579490663, -4.096732433374836, -1.9450314418059471, -1.7559038791407506, -2.9955868743990264, -0.1783841185961017, -2.885028043338521, -1.9433880331615005, -3.1691032686110767, 0.18086671776770596, -1.7287750446475743, -2.7123526557295454, 0.17087783547118687, -2.4697660155618166, -2.321938308365256, -2.1441463782329357, -0.3181195083307471, -3.428924067426568, -1.906634680846689, -1.4604230654190535, -1.2681994746313314, -1.5607977257923196, -0.49182794146915026, -2.1906809738364683, -2.2537990875787854, -1.7153891304687452},
    {-2.0832001647976712, -1.8556476380701203, -1.1030463362115555, -2.661547634620076, -0.7541625518480098, -3.105361880206269, -1.919553237795285, -3.434265359982375, -2.2041648575908908, -1.6523665101581462, -3.007546566984103, 0.9848485702295363, -1.9324183290116617, -2.7157968706254763, -2.6584909948207853, 0.4043094491739423, -1.5374205440509536, -1.9392882427131308, -0.5868801483603231, -2.3354879278540137, -1.4830239518494126, -0.4179605214828899, -0.011242860237020456, -1.560777350315398, -2.828814807459038, -2.3197265781551666, -2.273584476507532, -2.3077361701837162, -1.560543736096541, -1.7954509084946637, -1.1670223604816525, -0.7579878113951724},
    {-3.3598679232279296, -0.7659248459172586, 0.1091852290804729, -1.4860504822245793, -2.045910092737658, -3.8595098612254044, -0.9589580953261336, -3.2513665101903526, -2.4158526731097387, -1.741490847169272, -3.340934530393315, 0.26507285992843915, -1.8422696404585746, -2.9874104597716626, -2.970832868361719, 0.7575007299571361, -1.9473051358116453, -3.482747037622312, -1.14965890919457, -1.9834635160646699, -2.1054809655990847, -1.8469210922671149, -0.9257334459726281, -3.027897679599356, -2.8313163285592995, -3.7045544725741597, -3.4643862806881627, -1.5163006453625925, -0.45101947919271484, -2.936636467239579, -2.458341909927053, -1.5724098280842984},
    {-3.7584393687956763, -1.3904172084577062, -0.02566217864071808, -2.764845060732206, -3.527640460431017, -2.2037260874303994, -1.3814545391556206, -3.1025841375533796, -2.7084631005372204, -3.458317365521026, -2.9164911408091543, 0.539217755588082, -3.261577356350451, -3.974842548931493, -4.01973207789785, 2.095613105157313, -1.5523302027425359, -3.971056765796271, -0.5049268750454562, -1.5441803822116271, -1.6526018435044247, -1.3836865536154683, 0.3238824055909758, -2.9968031037112803, -2.674408279708028, -2.244562903448752, -2.930837561166097, -1.3871675489581456, 0.843979305630017, -3.1684047084755558, -3.251561015636612, -2.2258062623545287},
    {-2.89949255501002, -1.5323005327128703, -2.224104033875121, -2.975930957213914, -2.7088877144040233, -1.2516972552003058, -1.8117452720644993, -2.7014823664035696, -3.0327099190081612, -2.296797040717914, -2.6220159661926328, -0.07613193413586931, -1.683608288586222, -1.2527992314691079, -2.7525406689679977, -0.15995219056290452, -1.244058759523917, -2.220651980274066, -0.5883342300293496, -0.9526383671358979, -2.2947788349141245, -1.4022851847948499, -0.607360695722024, -2.3450948237244664, -1.3787951703184227, -3.4291332777781314, -1.1319601262864922, -2.4619090544591744, -1.9718948817276507, -1.3898545224264856, -2.565834330864568, -1.8903500603737706},
    {-2.962837853525899, -1.6908946179589317, -0.550885888562748, -2.439991235167515, -2.3505878929732953, -2.771650650185486, -0.38276337162696683, -2.854954531567801, -3.446249491132298, -2.2711388551929015, -2.6043439066452123, 0.1944645241090502, -1.594618753210158, -3.606206722830124, -3.4121327140039743, -0.005843076065161724, -0.3708953660283024, -1.8324813771545345, -0.2956179291365124, -1.5331472856136719, -1.6447998987937804, -1.5660854552091832, -0.6881831183030013, -1.9659202849595208, -2.8299066200268057, -2.2186579928767736, -1.634067008472794, -2.0799407854838505, -0.94435053718117, -2.2259427086510004, -1.90858011680611, -0.9429317539285382},
    {-2.9791770075963915, -0.18611015487057048, -0.46838573155549634, -1.2440378074559124, -1.9208853800151995, -1.6779759095779276, -1.0679848197372672, -3.441685892465449, -2.628466264931813, -3.2785599355671726, -1.9493264830981893, 0.4844753042564171, -2.898056179312185, -3.2797784471248153, -3.467419406458258, -0.2475393196097669, -2.91755822353784, -3.661402353829691, -0.46736945543700076, -2.334177814030665, -1.3307332967347147, -1.465091058188313, 0.15482518005910448, -2.7575472835249246, -3.594903793245291, -3.600899657351311, -1.5905662281392237, -3.202382592608711, 0.38608493129589255, -3.8714742459496043, -2.7591894161099595, -1.2233558628391494},
    {-4.068242085804105, -1.9278437633237457, -1.1171813089979257, -1.6536651108783385, -2.5894936419039034, -3.479284750553976, -1.4132816801680825, -2.9559231541996125, -2.076838652113577, -3.9410132272031766, -3.3365154518763083, 1.0017683066700758, -3.093819114782289, -4.628089411018002, -3.3414733974041857, 1.1038391282999858, -1.7411462104813387, -3.45669710255327, 0.0014573089262462943, -0.2963904223790015, -0.8643141570939831, -1.5851587962826574, 0.06679022734598151, -3.558875499750002, -2.4013402045360794, -3.5576462480330284, -2.6552053150784225, -3.282984462397655, -1.5449609164332043, -2.8425667779656845, -2.843152565412914, -2.616472596464415},
    {-2.723740298412787, 0.4890033716717731, -2.132599684616049, -2.7911944579579337, -2.1527347020840164, -3.671395356264465, -0.27329879059464746, -1.349200221635238, -2.1766160297943222, -2.8455781233588877, -3.436978622321377, 0.5482033516664286, -3.745319792521298, -4.362150490905547, -4.153112416597628, -0.15454788440403536, -2.0284364741622714, -4.441863353827967, 0.4634498662506219, -1.1453059505835275, -0.4333781835174486, 0.21896340395217634, -0.18711677978644004, -3.677160826312347, -4.068186021977721, -4.182058039114038, -3.1401611289842477, -0.8704848546658237, -0.13183791449928883, -3.4139769198724195, -3.9632525204603963, -2.805121095572627},
    {-2.7640541319025886, -0.5093689868520901, -1.1420381694758217, -1.5860658223415534, -1.1353410180831685, -3.8626087215256057, -1.5796101342978912, -1.732277733270352, -2.2443826860759786, -2.6763929404822497, -4.0114494124537, 1.3473197615738277, -1.766693597705666, -3.2214808609837258, -3.470158273630857, 0.1011617262016383, -2.171115145295914, -3.2662875773458433, 0.3253510510351156, -1.3596649790113498, -1.5851234739711575, -0.7950931438246747, -0.261823316445224, -3.034424837560793, -2.9147005660533827, -2.2392053145192357, -3.6927477924064043, -0.6658345172088204, -0.7159013288106925, -3.621399635206411, -2.601660863691538, -2.62046097414351},
    {-4.274317289102161, -0.24042835340294047, 0.10128616957278157, -1.7692834322510513, -0.31739322022327077, -2.681207666707187, -0.4697010321514013, -1.7912200954944688, -1.9461452071134442, -1.7691723530371117, -1.9838807787164339, 0.5390672336635912, -2.9855283922644316, -4.044645891673955, -1.337556759293544, 1.858045881178255, -0.8138547856035179, -2.001823284503823, 0.6011090148667452, 0.8481351617401416, 0.02631079707509766, -1.423131757947462, 0.342724294010587, -1.890672641969814, -3.8389354130216122, -4.167372727863131, -4.28214445945271, -0.08403252386934928, 0.6918616348486014, -2.368427909835793, -2.997164638409676, -1.4976074396992467},
    {-2.8498270834626056, -0.11109416316023185, 0.09047724425931525, -1.872872678951813, -1.3711609915908505, -2.943196678086888, -0.052743236405696524, -1.1458779683575688, -2.449219728945163, -1.631072282750168, -2.1433974335860397, 2.4047368550089554, -1.6132335974324346, -2.8152321913520466, -1.722401696401733, 1.782372382957423, -0.054548942655553004, -3.0023420175586493, -0.3447814309725405, 0.9393106287780023, 0.32816899915209025, -1.0108525026791022, 0.31225123655134707, -1.347264090680692, -2.897753596449126, -2.093529490345009, -1.9020558198649624, 0.04828297970003139, 1.0131351979918264, -3.0183572794444924, -1.057451917319904, -2.128822305562449},
    {-3.720545951620344, 0.009888103530146542, -0.7154249471074555, -1.0792353368631333, -1.7238961602033258, -2.44504566224423, -1.9181778522613178, -1.6827559974707755, -1.7477611789914667, -3.591287791196938, -3.3378624871127323, 0.09642276110831646, -2.9313538901370637, -4.070928375387715, -3.5270458643565297, 1.4126075985756292, -2.273287403518501, -4.010464645097781, -0.2967704092411991, -0.8407783899252811, -0.018379422899239498, -0.12091813974521082, -0.5179229310237418, -1.943921761963821, -4.558297802032886, -4.309176203054256, -3.9411301970706427, 0.20130980021573885, 0.7109276248853049, -4.327795252422484, -2.545318244087737, -1.0127761002013307},
    {-4.02428941267063, -1.466584681056813, -2.441700955848278, -1.4877650249892858, -2.7633272415830645, -3.6316445960273396, -0.2467168173554572, -3.282196834507869, -4.296851310153818, -3.1453262782887093, -4.386021311288398, 0.4924219242352995, -2.737627041942804, -3.798133844718593, -4.929385530448582, -0.45946070491186164, -1.411880121665835, -2.780911686161811, -1.1525230304401866, -0.6477088702795127, -1.905015060010214, -1.467830006776591, 0.004482440203114151, -2.895937740033109, -4.4792929073019785, -4.16081711088946, -4.4627883677097975, -2.9180622705074124, -1.5818245685922883, -2.908574854570842, -3.05443782274597, -3.548210093544312},
    {-3.586067637158571, -0.5914835396747004, -1.3708249880631944, -3.428707966811725, -2.491008736944198, -3.0992217869841285, -1.2189822697630575, -2.6571940730478003, -4.479695835280161, -4.014787380642349, -2.7374102219502308, 0.4383359652531838, -4.477948755325766, -2.714604054724063, -4.521625934646679, -0.254982324643962, -2.5142203289629284, -4.49313547063082, 0.661239913425142, -1.6747772616490748, -2.1008081819505087, -0.9625953539040826, 0.1935603370298258, -2.035399644265949, -3.9077709598940316, -3.6705119107606556, -2.367548449915313, -2.0176628136601296, 0.43896696553799963, -3.987334309529263, -3.64297918131452, -3.8503698173388394},
    {-2.256627818125191, 2.5401831079553356, 0.36142140558839947, -1.8972780396677975, -2.1168452748972664, -3.256873889759625, 0.2666924459132811, 0.7399052169887564, -3.4082470346381393, -1.0089342344198138, -4.1885099340157455, 2.735290327049527, -1.6588468292379006, -2.7557990049085013, -2.1575336499332742, 3.3112716962223248, -0.6970062087611287, -3.935603871300131, 1.5243287327105126, 1.3438214081581592, -1.0249935603262665, 1.2665064134065696, 1.5959461612532186, -1.3349688624985447, -2.433734441175789, -3.756495975511937, -2.9146498670046856, -0.5981690813979561, 1.352605874915287, -3.431652115441793, -3.019930100404241, -2.367603450155199},
    {-4.123975283833133, 2.6305295139590674, 1.0265348968743133, -0.45837630861208895, -0.35347790070335455, -4.40922865994388, 1.6436196991611904, 1.4338076528882726, -1.0870211957614553, -0.43852021533101393, -4.505707916263015, 2.9508983328116543, -1.3083913695728435, -4.063941056476525, -0.7014871306141519, 1.9603052327974195, 1.3152772490116253, -2.763164214316211, 1.0710114822145573, 2.4803519162994085, 2.0412038044752436, -0.19796788706041832, 1.3853875586050048, -1.0978839541670253, -3.7446752572523585, -4.377383154210101, -5.207675777186909, 2.781901166185393, 2.8845213488040624, -3.7977005350710487, -4.691800035896736, -0.8736199582839742},
    {-5.838441482179268, -0.986976117332103, -0.941726474778328, -1.5567146576166142, -0.8171989794942237, -4.263208499419623, 0.540652269871449, -1.203302909378201, -3.966282615891037, -1.8592065722183644, -4.983131333670805, 1.3197055178074337, -3.3847086906246657, -4.4546661969504555, -2.304884325920343, 2.0012041308325434, -1.5783759521796015, -4.528004543632905, 1.0042349593356823, 1.8842514779343829, -0.1153504390837806, -0.925318800755146, -0.004483661918532979, -0.6607090800416765, -5.031327322843593, -3.243743600160524, -4.257751158654651, 0.23174045083751887, 1.6829245574273646, -5.575276794597007, -4.112014150276474, -2.652563888927952},
    {-4.9896059532895976, 0.09797132547527736, -1.3633035760342005, -2.623286189845093, -1.4392416904691667, -3.4268528922684314, -2.544054451312918, -3.4291784850134226, -4.159256632384087, -2.3843833773510252, -4.613505105227641, 1.2923659448149056, -2.5620489786035914, -4.063968609290844, -4.580930500712034, 0.5007292336685386, -2.4530950560871707, -2.8780974312308523, 0.0018319454039417472, -0.5332349363356692, -1.3752819113450154, -1.713816316575187, -0.22569094527766895, -3.7979633008984535, -4.355165216552159, -3.3425899385674818, -5.244727431833918, -2.3703871883198753, -1.0783351934113043, -5.2164419291089485, -5.051498918044943, -3.9954622537424047},
    {-4.946673013884602, 0.24265029199152355, -1.9253429365656873, -2.0787534929135743, -1.7308840285219642, -4.854011063655215, -0.19173927172185723, 0.23703519424532593, -2.587249935992584, -2.7698291226817537, -4.946243377253256, 2.086367807990383, -1.312400553279228, -2.7623148965040287, -3.1079183181838577, 1.9465924509181345, -0.596738406109495, -2.1918784325150837, 1.0132828698853955, 0.5931413620196354, -0.2089997174298244, -0.7236044676900248, 0.1671700176106955, -1.0401295546466707, -4.088856572959845, -4.889435151291893, -5.678048985198872, 1.5001622122021319, -0.09309967916250823, -5.227241286951292, -4.243006795471632, -0.29000431387576775},
    {-4.117789110366954, 0.17622655892849795, -2.246040881189137, -1.0690009629574464, -1.2020013109893222, -3.8067662021400746, -1.1863283137401057, -1.223305954295086, -3.9045674911899413, -3.7856463432042293, -4.581084316604012, 1.4090119134278223, -2.847030869638384, -4.441594779249633, -4.494823996976777, 0.5781497707968637, -1.6181312689054725, -4.699072588433125, 0.9709668116181192, 0.3528079287450139, 0.3402272844136817, -1.082818669753672, 1.2702040172067204, -1.2814102342842173, -4.016003552781931, -4.7239161764926445, -3.863321495661528, -0.3043804369152842, 1.460430520483601, -5.335743735473936, -4.389398578794315, -2.8016602267908013},
    {-4.510371396131361, -0.5470160393725437, -0.8801057319449024, -1.866302659422973, -1.9678942634188437, -5.310059790201372, -2.028961066137672, -2.728168549540866, -4.861300348638028, -4.195924687751335, -3.8302642391346344, 2.0425316794027326, -2.013409176116858, -3.238880749899298, -4.398095576850051, 1.8857504838250212, -0.7156498293925765, -4.71466146170846, 0.7290650870761674, 0.11138578568193899, -1.9437425413083635, -0.4377812670667154, -0.6540549240283955, -2.329907229923589, -5.350495540885122, -4.339989629162726, -3.6519797687650595, -0.19499851800304094, 0.6910479227414579, -5.341557488047649, -3.2770121504327747, -2.8646392933148275},
    {-5.40295679133458, -0.6757902310922015, -1.9749078751527995, -1.2676396021222922, -1.7653130295132848, -5.22846054704742, -1.5971354128254338, -0.034510894342103735, -3.3835885749958967, -1.756475062291927, -4.867082435188318, 2.549181406022325, -3.392896314055858, -4.76002326989916, -3.97585502651637, 1.3947886051076759, -0.42249487926870904, -3.686016609552388, -0.270271853135314, 1.3270144082525264, 0.16248700879095376, 0.27060071548609826, 0.5216328198220068, -2.035856459276916, -4.686004719015379, -5.222498186646897, -4.572334970707691, 1.3886540637153515, 0.5397853933379849, -4.228919748151907, -4.6578888616322525, -2.528949190515389},
    {-5.739526018767006, 1.4306445883016932, -0.9320313146291571, -1.8721474493760368, -1.1352317421542155, -4.444464053335299, -0.7316933429211813, -0.37433264339365013, -3.943678721561814, -1.8504608549206714, -3.242303953436522, 1.9668677454410775, -1.1944446342461037, -4.6264092838059305, -2.17594486837019, 2.145173422716573, 0.9142904877994292, -4.220984661131145, 2.0236266032315418, 2.319847897074084, 0.2131269915787174, -0.6793617743592035, 1.5560357085921013, -1.681819241209747, -3.4560085121791433, -4.5411752599441355, -3.795266465848469, 0.04674138371698492, 2.4572500621838667, -3.7245734012831617, -3.848021883261262, -1.2575292145006616},
    {0.03426810960189524, 0.2066170292261532, 0.3769360275946474, 2.2114183662872398, -0.7363269950854486, -0.5456514521870841, -1.7310532473651814, -1.6399193186444312, 0.4813549644988324, 0.008504612895592813, 0.06709434574821538, 1.4868327819867844, 0.010587633605553103, 0.308007653800857, 0.8950021793779139, -0.4918669481037256, 1.3893519081962784, -0.33168845538302344, -1.7818206459455623, -1.2313155277097685, -0.19392179693608183, -2.3883502621457695, 1.327547181500269, 0.28100902659616, -1.4955651130299112, -0.7777859055489561, -0.42221592855338325, 0.17458997140777308, 2.182324872789909, -0.45202376128188815, 1.3820772912167265, -1.1273109051718126},
    {0.5278928849082152, 1.39771226278879, 2.7918491627610105, 2.786364889948498, -0.17742971420654474, 0.6938328693528717, -1.6003303520347887, -0.29067193870390073, 1.2844537872252113, 0.37186901778876824, 0.8054036234472685, 0.754476852861328, 0.9934199441893191, 0.8784464129292217, 0.10645897640112582, 0.11019679154484407, 2.1504978771915075, -0.25914821887547207, -0.6896535380450376, -0.13888411798561964, 0.3733032994003424, -0.7555932689994286, 2.9632416879120203, 0.6265160576813098, 0.7730733417295125, 1.5962454388615992, 1.1768383986864495, -0.15140688178687528, 3.080791457468735, 0.41276725690706856, 1.8874650555664736, 1.0453045121164226},
    {0.9154899662061229, 0.6746183453453297, 2.248643301134327, 2.2288735047431594, 1.0161337425321812, 1.5112882640719447, -2.6661789566183227, -1.0350502792861656, 0.34853005519465813, -1.0168251868851264, 0.4522515409054968, 1.6803509472013254, 0.5718729396069726, 1.6381494079822474, 0.0891445128044288, -1.349320460998155, 3.2706767324356356, 0.2941778562108472, -1.146452313417604, 0.34492487039180997, 0.5122599417832938, -3.438977149383236, 3.134556383606797, -0.9278435072775377, -1.6266434817490416, 1.042006831311034, 0.3642200083775254, 0.4358155382524846, 2.6624167056910495, -0.22348570827428618, 0.4722344467978927, 0.3841382065815477},
    {1.1725913123445977, 0.9003588375936553, 2.4480794465954845, 2.209268047256396, 1.102575802921979, 1.811930331811414, -3.2850182365582703, -2.5509516359412734, 1.5007731745181363, -1.1086474542423834, 0.9770788037679121, 2.499760959789228, 2.7428369103436543, 1.929876904211038, 1.1051017047748497, -1.2854835513361342, 1.5736542127702113, 1.1707954634278361, -0.5384477583852071, -0.586021367201325, -0.9427632047713718, -2.6305793370969477, 3.754931736853386, 0.7071595654303933, -1.0175126283366536, 1.2064608847152944, 0.6756862857113153, -1.0254593281332984, 2.7387142360391032, -0.7128005244134967, 1.5855641252657924, -0.056711501643328},
    {1.5041907844354774, -0.25743617734485047, 3.011207292819369, 2.549144988178998, 1.5130246199382682, 1.441849401039942, -3.0810995402622505, -0.8929872670718619, 0.7177954057706714, -1.0849151125849692, 0.7258395683473124, 3.047936139320285, 2.335089306016647, 2.3486592098981305, 0.4213544877370531, -0.9022239343066232, 1.0672300035684588, 0.7318470695942484, -0.18589521555667102, -1.4081734465559514, -0.9216508948545671, -3.2801990564720356, 2.344476609731886, -1.0465106724586417, 0.28414938895801584, 0.41649752402772783, 0.4252193645496784, -0.721018474054598, 3.33280443212577, 1.262797265795389, 2.4410880283896272, 0.9744988037705985},
    {0.5188244195751888, 0.47847913892506866, 1.5970213279644114, 1.5264882546030167, 1.3271159542050637, 2.573227379487733, -3.137914713874362, -2.1343936919336817, 1.7098161826347666, -1.8904508584036903, -0.7765804441904414, 2.3545735808239088, 2.8184318453854504, 2.513878708043986, 1.5908205193428058, 0.8917081038197983, 1.1797622197629736, 0.05371154463814837, -1.887543084911384, -0.5484278200917476, 0.36162750006812283, -2.089642242892627, 4.065579568445658, -0.7300944698746699, 0.1324187398785352, 1.61160276689137, -0.33229515659659864, -1.3320454536499906, 1.3302785544492866, -0.3801325612067923, 2.4878066964324193, -0.658115792803559},
    {0.02751551759642769, 0.16210513795410905, 2.134167533045393, 1.8089760961523764, 0.6219948989436915, 2.290957744519562, -3.4918099380900447, -1.9573531439989822, -0.005130389795495022, -2.906908383213294, 0.047557682775165956, 0.6096080004390328, 0.3151274823523475, 1.8914711940873028, -0.21609267854962969, -1.3719454635850794, 2.3704121478590796, -0.3314780898939838, -2.6773563361301096, -1.2154538486637056, -2.012591599753088, -2.4557500902214304, 3.6427085575657214, 0.3067355731647701, -1.6139242745912425, -0.06867522891149735, 0.7751089255249461, -0.3815186748389864, 2.2173609386072624, -0.12007474014205785, 2.0553125416915896, -0.8920417465898488},
    {1.3041782430862647, -0.8085108491354227, 1.1134721221733197, 2.5172550597769714, 1.0368033831002772, 2.489225502960791, -2.3971757237965714, -2.6956100289971183, 1.7540119651173118, -1.524538578456532, -0.031744345256908196, 1.6942517347946382, 0.7730379145135756, 2.7480534044896103, 0.06621468565722798, -1.6992359794297371, 2.579046622347146, 1.1334986561780067, -2.6000698778880484, -1.2177745974618612, -1.885191216154752, -1.5600214501998992, 3.402565490137728, 0.7045849064162526, 0.5232125887800766, 2.03464613784144, 0.7490690807298602, -1.3187173537753905, 1.893420367126633, -0.07029518820210076, 2.470038383925113, 0.7609844544587878},
    {1.2120847182543057, -0.3064729375875436, 2.0636317023895017, 3.644849973389533, 2.744900669167629, 1.00378435578521, -3.2883838117850814, -3.032487943725848, 1.3899894082732385, -1.502746950112343, 0.28296134954133123, 1.4171076015460333, 3.095662291386236, 1.6174700526129828, 0.18509015723085862, -1.7939499623337651, 2.7739927572386818, -0.19385636554023064, -2.1828633702628224, -0.807549724338443, -0.5738982525428781, -1.7350361079800434, 3.1365892105111177, -0.37383772556411393, 0.48396248952410803, 2.2340865608562015, 1.113954648437712, -1.2306085712107813, 2.469102278075774, 0.21232232517852898, 2.0033062237114727, 0.8640885436680722},
    {1.2418643734793497, 0.1731799115642733, 3.3574474492034, 1.6632089796669822, 2.097192696195464, 0.11805671351566999, -3.0630057029069455, -3.3013895322434834, 1.2051588237369675, -2.2611676605032134, -1.308034957763567, 2.7803289334877954, 3.439308836583492, 2.3118928845346365, 1.331754056909476, -0.3742521745721417, 1.9732725806778817, 0.05940212494868161, -0.744139237665212, 0.47339996415005275, 0.5694580506084673, -3.5192151989887703, 2.677941492308885, -0.39793807195170505, 0.7608079035910628, 1.1302783728748427, -0.3650132403758187, 0.028522189681408742, 2.5831349470347167, 0.6340593252390939, 1.935981207451274, -0.004337105791482971},
    {0.32624935497857716, -1.2937144308448503, 3.1146710341780337, 2.4452901116473917, 2.4551057400528364, 0.9011628688647545, -2.8259615741696558, -2.278343154869515, 1.8084042805326053, -1.9495853134891412, -0.8086493394999137, 0.7513332699124825, 1.7515540733699364, 1.5718499399281087, 1.6514173386675062, -0.009333903558852313, 2.3388940554054973, -0.6159634575251111, -1.7616422443679303, -0.4451184989245678, -1.2733176915897757, -3.027479200813764, 3.4008686897466243, -0.5266165033719183, -0.5915138345288651, 0.11224886061688436, -0.5344981168729043, -1.5237778856849575, 1.7111785920615392, -0.022598507655353685, 2.4233200960952104, -0.8388348369703577},
    {-0.21367612606247122, 0.14559585341704326, 1.3251890054852473, 1.7471715099445118, 2.7614704468699083, 1.5300250466669696, -3.6143833486305446, -3.2133287250316194, 2.7517852477503237, -1.4658737832245117, 0.7891890462935237, 1.9290278684309397, 2.746722262661616, 1.345247775972382, 1.5436978371293897, 0.24921010142444758, 2.2251945534770634, 0.042650391513978925, -2.4045579485745736, -0.9992330921885154, -1.1206602218850237, -2.834784121036772, 3.3231058420012958, -0.37537112334239714, -0.15433746917881605, 1.8579392857825228, 1.656362326027022, -0.05859988019270402, 2.635229349646925, -0.4585121772826753, 0.8222335537269018, 0.12640474110781788},
    {-0.05614454919450019, -1.516785565367091, 2.5672489771511326, 3.2701927977736744, 1.7294646994408747, 0.6778847885751874, -3.8016825911585745, -3.13905580687642, 2.558840102699379, -1.4365858984189885, -0.6469205348458534, 1.0993589537623163, 1.8105984400147697, 2.4704269324442065, 1.530389112661573, 0.5982634376426157, 3.0724408900257516, -0.5311498367405013, -1.6724654344184633, -1.1538692669536157, -0.2774716688107778, -4.378811819167242, 2.327532259181721, -1.8505895903835727, -0.9369521664425479, 0.10379766762599557, 1.3757181028788983, -0.06194637760997375, 3.776800343529825, 1.3870457654413824, 0.4563717822992437, 0.24398673779148225},
    {-0.1516264635709138, -1.2984052028489992, 1.2526270404131017, 2.7748930436562684, 0.7035236001562568, 1.8697058515313059, -3.3462203395071235, -1.3591253096360592, 2.7523396866867973, -1.5220746682193949, 0.7306496747718926, 2.666945152095696, 1.330206317131882, 2.3361687281571073, 1.4282493278598065, 0.47109422918000304, 2.530745731113375, 1.2638682681162434, -2.71919627107438, -0.7634597490755134, -1.3800920896986193, -3.70698898021499, 3.9162860945004576, -1.011566386011352, -0.4545434555662369, 0.5705677578766178, -0.07514460116529036, -1.5341492090755575, 3.183686348129025, 1.0945403780642766, 1.441583498620506, 0.3818943603278881},
    {-0.1295532080150075, -1.3214712455690356, 0.45816811616332287, 2.6607852277949022, 2.1551717832841963, 0.6160972097416606, -2.5802460854038634, -1.632342728655694, 0.5619731684903747, -0.6788094588736008, -1.0703954800144322, 0.6911920661051457, 1.548041994948152, 0.6553414642511008, 0.4550593048255235, -1.286787746716015, 1.7076098301842038, -0.09667214663372946, -1.7963951647714864, 0.6072035938039496, -1.4703019718476968, -2.4983088212957933, 3.2884319252754115, -0.48425085478677293, 0.47053151323486053, 1.515554960882829, -0.4964352420444373, -1.5354132106880298, 1.7127056705159929, -0.2943638562087715, 0.06366998781187894, 0.13506024099412137},
    {-0.8763445990519205, 0.04520911827077757, 0.9898066056338571, 2.7149016511117927, 2.1241880424179898, 1.930118445658466, -3.0482237897516584, -1.510188238043506, 1.0316694077419857, -1.196848046944765, -1.0268770379956282, 0.7797783246879021, 1.4626587437160328, 1.1331593554710895, 1.6275377879684159, -0.16566319209053085, 3.7352835269066773, 0.49873166622398046, -1.1780928854546058, -0.6136314768729058, -1.1169277019094237, -2.8093093339931396, 3.0664502244752256, -0.7358702702164668, -0.48394347611556854, 0.8449649128572163, -0.5422419183852186, -0.6777413096078412, 2.7111176384817672, -0.3917047865485945, 1.2225922630815058, -1.5185641061120176},
    {-1.1490234347850217, 0.26738934085060906, 1.9599209137313585, 3.578353533338675, 1.5532230282995978, 1.784692451235598, -3.159201485852876, -0.6836792223963434, 1.917688159753127, -1.919385486608098, -0.06711109602889401, 2.5282115481415417, 2.025079592937332, 0.6441566523839878, -0.05596006334564593, 0.6311039543442666, 3.1817586429846823, 1.6683632311850956, -2.6626199660040677, 0.998486453702549, 0.5951056222022824, -3.4232539220113525, 2.289895507527782, -1.7199316119158916, -0.9601026402278872, -0.5434531449049317, 0.36477321253748707, -1.071813017797425, 3.2421239314877464, 0.40226169497421765, 0.9340462727879997, -0.9836655821315393},
    {-1.1507441712479156, -0.24535548690333922, 1.6613565577929617, 3.213557251536663, 2.091728295566888, 1.8043276073012395, -2.4879119052685867, -1.5397166651147114, 2.5496235609403186, -2.8081120556349872, -1.5770051089739237, 0.6753789163512239, 2.1370974446606823, 0.6604238333799399, 1.3794527619950017, 0.5531859205068744, 3.1419694018188853, 1.799806118027484, -1.0256302231762822, -0.2967776678397318, 0.6568262862525901, -4.139054993077164, 3.53620056088766, -1.5889838276218338, -0.3555709044464679, 1.4550733587439735, 0.006147353677158335, -1.3447865415527651, 3.5825533282106132, 0.4263120064103071, 0.6490430214640484, -0.9551454362825837},
    {0.5045462067663341, -0.8252981066328791, 1.2921995744617183, 3.5934720726956697, 2.180075754177634, -0.06256966882844425, -1.8844683639724658, -1.1313086817904627, 2.2749905875997762, -2.8840914666835724, 0.4337024829087683, 0.2753004626491466, 1.5722225763450561, 0.5691948841159066, -0.2167880318429912, 0.541402909833804, 2.8527506292157514, 0.9132583996682829, -2.432310043515958, -0.4820845648120084, 0.24331772021508727, -4.301033032891279, 3.9951352797992206, -1.9481686628543007, -0.685023033632728, -0.3872364108256353, 0.8175371026266368, -1.2120174087756146, 1.930871180922485, -0.23855850691053704, 0.40248909438404024, 0.11671684673628352},
    {0.3474390023348586, -1.4656552020444464, 1.4050454412964413, 2.4964675710081745, 1.1069905252812509, 2.363324373304978, -2.010412050666103, -2.080044437195711, 2.6897808172592024, -2.1496627358859297, 0.028001027582306433, 1.5811155525447613, 2.829178232630166, 1.60629918559168, 2.066909141108724, -0.053003636260913194, 2.4315751769037464, 1.434437657164053, -2.347693804603723, 0.405760319191708, -1.022174272843933, -3.881292935662673, 2.9053330265160233, -0.5567492747658024, -0.871598623245984, 0.15356549926605634, -0.14333346909192443, 0.1860903406986253, 1.8682186537722985, -0.5332146432681215, 2.541897545973825, 0.9851720268515403},
    {0.25541806231565145, -0.07292250889297382, 1.3150660998586883, 3.6868405085410925, 1.4067725739322112, 0.7733909701460459, -2.598681965225306, -3.195458530776213, 2.6284710270380454, -1.838101661820082, -0.8487741231296904, 0.4007878211130131, 2.8767403552314614, 2.684107731962628, 1.2279803186783305, -2.2343746245688543, 3.51880558812081, 1.3538082397518219, -3.367586081239275, -1.0390919489303971, -1.5723917810508636, -2.912841869140492, 3.6452378759100754, -1.1133920842803373, -1.4161467613831888, -0.07553277945262848, 0.6593293908576838, -0.28018487471667575, 3.575463183176512, 0.052831201670118406, 1.336651002099844, -0.6312013507723472},
    {1.2165266236516685, -0.5519630192058689, 2.95976722103557, 3.8821854421792135, 0.958374672403105, 1.599725419374756, -3.8361105847858883, -1.0505376265134396, 2.2416684572248036, -1.2367942555311493, -1.4901162839508806, 1.643814673414137, 2.977557467256272, 1.644006648818392, 0.256647414114899, -2.2758396005691375, 2.5006694310561253, -0.039710206611244914, -3.2172514088329853, 0.4563404913054825, 0.4291418347905435, -3.844137635666006, 3.9643951000348108, 0.29414744195071474, 0.2313868689663207, 0.15264689292923228, 0.18308897057103016, 0.3534238069333403, 2.236163493273277, 0.013058653781896282, 1.7140647390339736, 0.17048737304567438},
    {0.3022120536784365, -0.3953255189163304, 3.2415204117204373, 3.7788023475574146, 1.6588364144346093, 0.8680485648375161, -2.466250408982195, -2.388544302525597, 2.2860862604710905, -2.142115270595368, -1.9154718175970782, 0.09748340334526098, 2.69660894042492, 2.786416288482801, 2.083858918950932, -0.9529882452506284, 3.019905447577143, 0.44715763451710755, -3.326208768894059, 0.5924672875926136, -0.9465157372638049, -4.334593782598541, 3.4926969266479904, -0.6456694555507141, -1.7214105146421768, 0.30199217091160135, 0.7239520209893938, -1.2821217771107025, 3.4184763088248777, -0.5550879916153942, 1.6013589421009478, -0.03304108223101567},
    {1.0670105621996218, -1.0368966087544993, 1.3556127194978018, 3.935716969269042, 0.4784938354220001, 0.5240808972830672, -3.146209186220926, -2.3349897253395415, 2.8765585731625194, -2.6336192704809545, -1.0073150641240547, 0.5144044753527439, 2.0998190244952966, 2.4266869350901255, 0.9288592173555172, -1.6322043917206814, 4.000918781100789, 1.2757467736494854, -2.9175325499608844, -1.3559504857866425, -0.20123868911168924, -3.496724109304839, 2.79060896890583, 0.16338428890380266, -0.7187755440223099, -0.07899765945908446, 0.008227706931568764, -0.9786778599327113, 3.2979607502947035, -0.021658180359199856, 1.1423844821386688, 0.4130345749972219},
    {0.11460438382653135, -1.089711502093592, 2.95062490264606, 3.766661560693447, 2.0683598816458355, 2.5269851764169293, -3.5945923179922774, -2.7381952678302395, 3.12472537060103, -0.8385086721864013, 0.6509559517685167, 0.767536068349722, 3.216497759872358, 1.687444324592893, 1.355395564351192, -1.3203442753413017, 3.67462307780839, 0.13443955843288086, -1.5610413455107617, -0.618158540344084, -0.9829230331318805, -4.216420535728183, 4.322764887793983, -0.7205782482498808, 0.6282280345638681, -0.6265132322631185, -0.5275217464620735, -1.93627999846474, 3.7929336861710095, 1.2936966777489687, 1.3448434672065364, 0.731407164294605},
    {0.18605402739033475, 0.39915121195967074, 2.355902664422865, 2.3329744959163645, 0.633055358871453, 0.5998319198183207, -3.7815888643600544, -1.833249512478413, 1.350889590941048, -1.5437833791368876, -1.7431164395149221, 0.7827935458914023, 2.4185053777766834, 2.279987229777755, 0.3846229056546343, -1.5496822399589272, 2.434781326451684, 1.1591840342286286, -1.8776147607154245, -0.830634115551447, 0.04760287456898208, -4.788414908318339, 4.610686299679583, -0.2485128511835433, -1.7248099960935506, -0.4331878106606555, -0.6376593251134479, -0.4984608811640661, 2.734142137714496, 0.5032727943432913, 0.9327732523631245, 0.8754056906954012},
    {-0.2860247737812897, -0.13207118280018765, 3.090732644015429, 4.378139125336713, 1.1014939031967892, 2.231180779944591, -3.2994238215374305, -1.7477633634574217, 1.4416238655863904, -2.812070920104523, -0.7354099849212925, 2.139686087549757, 3.0642213448463744, 1.351840189109277, 2.220821554953574, -0.3813754979916844, 4.523469331758538, 0.9713876677557365, -3.6757497409720923, 0.4549712732304234, -0.6628596018472807, -3.7859879555944467, 2.689327893769451, 0.10261747723060936, -1.4945504579807394, 1.612403311777182, 1.313669962077202, 0.3519039741415241, 3.4035764892085174, -0.26083325265883356, 1.3942756632963855, -0.5559867126103455},
    {-1.0523940204897044, -0.8247786049287, 2.477567498751984, 2.571703544574745, 1.7220603365607354, 1.3361248860706705, -3.5087599745862783, -2.9827058278878114, 2.5931365352801468, -2.816866310467377, -1.7189412275134754, 1.1647404938573975, 3.1709953953551886, 1.51649124747759, 1.1578477393983826, -0.37180798425842104, 3.596445081400339, 0.8541979370453207, -3.536913050362138, -0.6970872798595572, -0.6070209024544561, -2.997232737326712, 4.660436171491146, 0.5291313520376275, -0.4863219694485716, 0.3641971497054902, -0.6370562575727888, -0.8931781800461993, 3.68621268634507, 0.854931306768556, 0.3616239231316247, -0.722651385013228},
    {-0.4852655300842788, 0.0971174865170904, 3.382213972117582, 3.5986379451943877, 0.7334001269181931, 0.8122891200710484, -3.357837168992416, -2.0340263882982197, 1.5199090783643554, -1.1595130797290494, -0.6822259942056653, 1.8296408017284052, 3.457892616070601, 2.4920134221658894, 1.9666631160341657, -1.734719748241064, 3.6376175749883823, 0.7463550325247346, -2.6331308067046737, -0.6424001085179749, -0.014314927793588918, -3.707037011478717, 4.363710053792178, -0.7817472326453163, -1.191079922880899, 0.19554465438376972, -0.24867492446511938, -1.5783971591755692, 2.2694898481534755, 0.16353527175650856, 1.4841374824165503, -0.8041707434722205},
    {-0.9821879177476738, -0.922467139069007, 2.686525009917144, 3.994248464371828, 1.8971575846926132, 2.049929873595862, -3.0011974628695155, -3.016767296411339, 1.3987823438626936, -1.2674304530204668, -1.0579161875264544, 1.3454667740210398, 2.1919127566378314, 2.57087783099801, 0.8362059403122949, -1.3867863410542842, 2.504442764164394, -0.12289442914909746, -2.9366148499642386, -1.2423068869273495, -0.9257259371618924, -2.7909434174479357, 2.412740208288388, -0.7817499597038967, 0.36066246672116953, 0.05109150726841178, 0.40623820667745464, -1.250167015590151, 3.3675296244196713, 0.29511841317001886, 0.9932292537491251, 0.9247495084162932},
    {-2.8900205951447715, -1.6014185816870983, -1.3965061777480867, -1.6393340637178404, -0.15144175953324737, -2.401847952601632, -0.9628475503791479, -1.466208592982451, -1.1463296634996687, -0.21658929810354788, -1.885227356895049, -0.24016054108275886, -2.08509303536238, -0.6664442247509241, -1.1514239091967378, -0.5383178914796117, -0.8638227093953357, -1.8878308265945425, -2.2492692362363846, 0.629062805770817, 0.29194020076091437, -0.6257815029065037, -0.04553648534189931, 0.024990737750994148, -1.1265059581631496, -1.2983488039893525, -1.6803772031539148, 1.0597940177025351, -0.6359996702869147, -3.2522742531511852, -1.787131822530781, -0.2671118669603871},
    {-1.0328059220085006, -0.8718738817792532, -1.614092558058633, -0.22466334875743924, 1.0660164362358553, -2.2254265493453085, -0.09135372025621062, -0.1067171999452753, 0.20198108814857965, 0.8715765779413244, -1.9212260461637185, 0.8307340469908704, -2.139914637322424, -0.1304852078401828, -1.488562233197191, 0.05592772553811445, -0.13387737780899656, 0.11639575299260413, -0.44904578893973174, 1.1511338466022563, 0.4334376855601242, -1.3183150995765085, 0.7625396903262458, 0.5722174136797402, -0.2835702587849144, -1.0663969531620654, -0.5105232621936528, -0.5136840765304909, 0.3423734629661257, -1.9485507465725316, -1.682828734405753, 1.0284822444888435},
    {-2.3951548893289365, -1.8858484405124585, 0.00487339789341761, -2.0427977704960782, -0.5179506552938218, -1.669045020909144, -0.534614749944929, 0.027668460229487792, -2.9000132864431993, -1.3453486803920958, -3.9361552475438297, -0.20467437283183185, -2.6299780551560166, -2.0365600470808003, -2.4035427732723824, 0.7245069006307202, -2.0491194053279584, -2.5431862829813947, -0.8926569995692085, -0.25434621074880465, -0.2594944760656658, -0.64294159603505, -1.680000657576249, -2.176496346692099, -2.894748544862944, -1.2093158021230404, -1.7487060454145795, 0.44595228435900836, -0.7208916290549765, -3.425792069390027, -3.6935146782832637, -1.3728672101793975},
    {-3.2511471423342004, -2.196298709594592, -0.12177747675850675, -1.4613568254074587, 0.8594530870507044, -1.7534507827649006, -0.6226731819634364, -2.080806954012034, -0.6191802287694557, -2.034933821037155, -2.970794021832089, 0.8282397409773389, -1.8871195468287065, -1.3320219734955212, -1.0374007760931856, 0.10745887699679077, -1.2324134104067175, -0.6284303785952648, -0.056417766733026536, 1.0009831228961035, 0.4996045057615597, -1.3943382797067487, -0.9575625270373517, -0.8493132001735791, -1.9692437054848033, -1.3893358403011216, -2.0185782647097383, -1.5585339411422752, -2.1340039302448788, -1.9648172896414022, -1.741357308085206, -0.8147236577181651},
    {-2.6709930267186124, -0.3639700594173886, 0.7821330543126633, -0.9775874821276227, -0.19325797300993688, -2.840588671977765, -1.0173321773602142, -1.76738742862375, -2.584248237009541, -0.7798095866323514, -1.3982215158462437, 1.226766108032621, -2.4437117449009946, -3.2532931945813672, -1.0111703303133366, 0.028314564058139605, -0.07762095334495721, -2.7607113896906745, -0.25242846855600337, -0.46720384673500015, -0.28339662889337947, 0.6342055811278602, 0.1758957924754616, -1.3515973061690914, -2.738762367528774, -1.102277418096832, -1.3220426432075256, -0.7377815419258023, 0.38072698925380305, -2.0630601767997487, -1.3325952851838272, -0.9205362774028896},
    {-0.9304809345694184, 0.19037557222823645, -0.8672895352434437, -1.783198245471054, 0.040593298101320584, -1.0976582326781534, -0.2022191601335176, -2.0439685827518437, -1.3026762086252544, -1.1346605635840141, -1.1015876393431923, 0.5908195330762086, -1.728599187690979, -1.1691873766562877, -2.1683358929188743, -1.1759780209464827, -1.6271976825725891, -1.8496885579610678, -1.1555881917748914, -0.18325354815130565, -1.7690704532844026, -0.7437936451531312, -0.3356529254186625, -1.5575430181216112, -2.852951464386168, -1.3578975158516158, -1.486510122604086, -1.0890201999973346, 0.5830284838968445, -2.2711091143231217, -0.8495128252321511, -0.6719142566124414},
    {-2.976676667199313, -1.808686689554308, -0.5076032586465221, -2.6689261517777534, -0.1003862396963685, -1.8719907834665943, -1.9370501464926588, -3.578983383797625, -2.1013994873469346, -0.7800884764263164, -1.5926752628669827, 0.24440259088794197, -0.8440411127601068, -2.774482707270445, -0.6640528351637293, 0.45539900339881473, -0.6541269355880402, -1.251075815499364, 0.2494602754384084, -1.266706561576366, -2.6039240687087326, -0.9266920279031806, -0.19924824592857565, -2.1467382952960503, -3.3585886590342744, -0.843265125459265, -1.1994276074153445, -2.6450495502077636, 0.30831448242926146, -3.1447953926027834, -2.342625716265401, -0.21625190533435532},
    {-1.1048258383406218, -0.863790672517909, -0.009297541561972425, -1.8576007536357737, -0.25247748978444706, -2.2454056739985018, -1.8381362014736586, -2.6375102548612253, -0.6585202284199818, -1.2897061572466615, -1.8454040306961468, 0.9369933493970005, -1.2015880426662089, -1.3160734287207028, -0.03220981154205427, 0.9218713410077309, -1.1455838927593516, -1.771641602084126, 0.17805639671433876, 0.5960228625562889, -0.39290509371736193, -1.340719921246158, -1.3615582290528632, -1.001692643545119, -2.1553171585759268, -2.3620273629916317, -1.9059054089422387, -2.1932080741492057, -1.3341452446045619, -0.8994917010892263, -2.040888479204745, 0.34183433612787034},
    {-1.5373493923922645, -2.1364933139934585, 0.7061695750126803, -2.3471714065315696, -0.45763194545089625, -3.170523134017819, -0.646078377333743, -3.51863764687197, -1.3044219266360315, -0.5009262904636266, -2.6945506571033566, 1.3479577244412797, -0.46242925954664216, -3.2279822092268486, -1.9671389076320887, 0.9951781558694692, -1.322085615486508, -1.7285033736420732, -0.6343459360609395, 0.4767664372714144, -2.274542867145, -0.09246476859654805, -1.7006058176011973, -2.0286159133976436, -2.8276309591015045, -1.3638371019931568, -2.890376144962366, -1.494470472784979, 0.28756379017504374, -2.2986624846133923, -2.798194856145526, -0.8049142423415255},
    {-2.2723812032670225, -0.4343085216937147, 0.7385946099618798, -2.2851947369725956, -2.6088319305549854, -1.8334286812975846, 0.5648986716428107, -1.9779408076507548, -3.211365512874189, -2.7130282812789597, -2.1324153803654586, 1.9587922630664993, -0.8308745807380762, -2.5494414727186174, -1.3611032277487964, 2.3575240898498317, -0.8787503109874693, -1.5431347958490869, 0.4516437608887616, 0.8610630455883953, 0.1597498492658302, -0.013366850668871269, -1.1281034241848984, -1.484003296168761, -2.86751684336785, -3.041858006794401, -2.1352703569991265, -1.6272472792731196, -0.3746022700752594, -2.0031723705875657, -1.7818895610332433, -0.6298596397413261},
    {-1.4332741137097786, -1.5603529412914199, -1.9747087426331038, -0.47085445860493025, -1.0557887227177547, -0.40011163194834193, -1.1522619149561395, -2.4928920421040397, -1.523579023355845, -1.4663814657538545, -2.822919721494555, -0.07531319726257175, -2.068639492595243, -0.30339781918974856, -2.689547342887599, -0.6740764073372186, 0.181660488326984, -1.8968086963054613, -0.6798954805031043, -0.8057264487822982, 0.493478171279967, -0.8976510229779661, -1.8924481031355844, -0.4920573951123035, -2.730254580083781, -2.1062089996681457, -2.33867969162578, -1.509415164025134, -1.119331061271367, -1.299026018766512, -2.5420591325093627, -0.5305999940955644},
    {-3.225645831074651, -0.5018431683333076, 0.047136153543147576, -0.4990026395775279, -0.8638827701981273, -0.8382575956174895, 0.5141592772658389, -2.4201018395995435, -2.7555087560867584, -1.4593185025510966, -2.0600058159777053, 0.21040666260004712, -2.073824548509581, -1.106272142819439, -1.8873463892664977, 1.6899118982132602, -0.21044586767061857, -2.6217733464195487, 0.2004017008037801, -0.20280342340535784, -0.4953848322480235, -0.41514516303935367, -0.7891700926817601, -0.29083348817527604, -2.7181797343868794, -2.1214446653216137, -2.0244157321521277, -0.845508262601436, 0.016434306662970903, -2.663240833890516, -1.1497127768399389, -0.6851052791666238},
    {-3.2491891485568463, -1.3207659012609465, 0.1824620121222071, -0.5102682533440004, -1.1609447100249262, -1.3384846471592622, -0.4374967877114039, -1.8386630329538824, -2.522479761814971, -1.9600840793374699, -1.5782846574766822, 0.1469219887171887, -0.46332061576696953, -1.9952906310312897, -1.517703056425573, 0.5549457551444089, -1.4499115727365162, -2.3802177227073815, -1.4157468305592742, -0.8430125297631139, -0.23672439244941013, -0.28796330473301446, 1.2431155843371176, -0.9513004913858225, -3.097229637648474, -2.975369893878684, -2.1348125749188163, -1.1095275950884385, -1.0652710489844517, -2.6696692189913023, -1.8186815286964528, 0.2304859835611398},
    {-2.9449859301596457, -1.3582875716765686, -1.5078501742970196, -0.1644010621802188, -0.21905593540640145, -3.128850332614622, 0.8201787531267359, -1.1984322613855394, -1.2350519713117338, -1.5199945419338252, -2.9183660629104025, 2.316664937237348, -0.6547293907696206, -3.5202707156466726, -1.5772301877737434, 1.1879211932391758, -1.5772354353821103, -1.9054301307403114, -0.3605666300221977, 1.2631648905647401, -0.4187130979312375, -0.86187626329599, 1.3701526308517709, -1.959556976016403, -2.340621600861841, -2.9460258468609704, -2.545214141040108, -0.07792783409138482, -0.13557949153627294, -2.9920177573845774, -2.645383427472102, -0.5463648570703258},
    {-2.3144757444199886, -0.6672546518300444, -0.9777732234867776, -0.1628069918981426, -1.057311531598832, -2.559771020502988, -0.5181792630687662, 0.8215923408734522, -0.6594659099098706, -1.6643924101641174, -2.52614698813679, 0.7820963880428767, -1.2402320240680773, -3.3056563537906873, -2.728822962356294, 1.372641698251976, -0.45834548307154876, -3.41139964418623, 1.2924125440576633, 0.7738125940272172, 1.7873437748243408, -0.26180273053500064, 0.19525343479883797, -1.6159299154924327, -3.5064557953062057, -2.8368605480037052, -3.6748901635915834, 0.24067544961126325, 0.2582014773003189, -2.861648903525364, -3.418253207077319, -0.4172634040485482},
    {-3.76011228117493, -0.23732505261222311, -0.7865635469373417, -1.6055527040280608, -0.5189908666069597, -2.91314731450907, -1.0995110197063402, 0.7963651141541143, -2.410377655585908, -2.377615263555212, -3.932451534950286, 1.5622027346129748, -0.6736586779927716, -2.9279425165979056, -2.480890246907425, 2.5937110380270134, -0.2645813566582703, -1.5201638894090266, 1.2385882829479027, -0.24071767626475654, 0.31069101825708106, -0.22545803936325637, 0.48642577198121645, -0.7949150340353035, -3.5662212820421355, -2.3424773592165953, -3.4015701510816396, 1.1761075386244881, 0.11739677896136771, -3.2867623068668945, -3.1381088864783355, -0.5897955715650519},
    {-3.693874223816652, -0.20982861206787004, -0.8198310744597951, -0.5890838132457314, 0.9076614673027544, -2.7342486472045993, 0.9208417844437172, -0.5798473656589819, -0.8521355949633714, 0.5296213329131673, -2.119692326064336, 0.22526432750350883, -1.391475783975522, -2.9882831397099476, -0.7254192829709529, 1.2963381988947398, -0.37148314762953893, -2.038609068384696, 0.11000626912066333, 1.9601436673404946, 1.8652174769218524, 1.1579629928641528, 1.0022663274240766, -1.2025458945472898, -3.1899200751846952, -3.886168389663065, -3.9514836608304322, 0.48553983670285245, -0.48096196040837824, -1.8865920724161485, -3.17221428348532, -0.08167403041024149},
    {-4.29349772356973, 1.114078367159526, 0.1674211085579698, -0.48840100794543345, -0.7169095165912124, -3.015393290539821, -0.12336592908709536, -0.0015355924298782256, -1.0164024005639762, -1.9028914334131835, -3.332207444038188, 1.4558593360870205, -1.6798682731695564, -1.5312356105389053, -0.44047656379111294, 1.067946720924549, 0.43309847737142465, -1.943076500143757, 0.7050357267507973, 2.1955194205312973, 0.19445567057521668, 1.3050519193589654, 0.46420749625392205, 0.7252896281080743, -4.174840599423367, -3.2874977996054624, -3.9184082780747382, 2.1250735131212832, 0.07808782363568888, -3.0942184279042886, -1.8189166810182336, -0.847299755797298},
    {-3.224425101378292, -0.7920978337547236, -0.1026473595071845, -1.4509536389125204, -1.6080427163548938, -2.1254319870633336, 0.9407761097658881, -0.3102255139762223, -2.0737302861093063, -1.3798377327247116, -2.9937679063872857, 1.3021533561316934, -1.7989542864163308, -2.094023361904996, -1.5043389390837019, 1.4588516219328216, -0.7431410909068673, -1.4780307727809336, -1.1980504352917127, 0.704043470486171, 0.11338722920271214, 0.24450800799395517, 0.9996456619983884, 0.006607362318805105, -3.64174641611479, -3.536499652395946, -2.4963910128296485, 1.6476807799949802, -0.56068208169015, -3.7879457142521398, -2.711060599703097, -0.8096164943044469},
    {-2.5731286583172652, -1.3873675739025149, -1.6444563641055299, -0.25555280895164917, -1.818450327588593, -2.301186193605674, 0.7212726906913435, -2.196399565955992, -3.023980275272964, -0.8176967615294818, -2.3929152445650916, 0.25528842850874817, -2.563781766759904, -3.786353848409502, -2.753068657861106, 0.5551144711943079, -0.06841585292870006, -3.1639275272508622, -1.1113062535731293, 1.0807870323987043, -0.13081893570910316, 0.44746024848945953, 0.6232763041775576, 0.381557661021948, -3.415733439907754, -3.7768451547634907, -3.007438338714813, -0.39106426388116006, 0.14160598734644567, -3.6594961669729296, -3.3514071656929985, -2.306989447803438},
    {-4.591602015686425, 0.13538610741702406, -2.015572051174093, -1.4094054084132763, 0.023691463698562305, -4.190075669410566, 0.04108005963201544, 0.13365316300592525, -2.5178709925473104, -1.2172015827822638, -3.795897674858846, 0.5168478604433946, -1.946196153959856, -2.5144854744628287, -2.988207139311152, 2.0663795345330955, 0.7636324739579763, -1.940152383540217, 0.8709733954706411, 2.8485637601170035, 1.2989231715617473, -0.1726759422452088, -0.2719169198817781, -0.23310793910292232, -3.3630285736485854, -4.52526996955445, -3.8553149711743524, 0.11216235475939526, 0.7185585852716062, -3.0887138644951118, -4.478759308584132, -0.47947478872654226},
    {-5.451174083591103, 1.6988220428931131, -0.352000518118925, 0.2947062246369802, -1.1422926066106047, -4.4189142512401345, 1.8742797823353834, 2.469447779165133, -2.581847749055455, 0.18162116694248748, -5.629184672288512, 3.2126974359347455, -0.1485835133455484, -2.686977616097476, -0.9594237509864751, 3.620213030475138, 2.125451244709709, -3.4508512639734996, 1.069315101763116, 3.4457434456733798, 2.3137685028129047, 2.2832819940428055, 2.896773002144529, 0.7180733583152138, -4.93844100686603, -3.5527900224245705, -5.641676711173132, 2.835549593499057, 1.0752083407360125, -5.07731108682066, -5.4941501619770285, -0.38112670091750245},
    {-5.6804789857435605, 1.121360853317477, 0.957623156790224, 0.39544554027569967, 1.1834547956562207, -4.164794688936601, 3.0155108139723485, 2.2908821532875345, -2.07522373075998, -0.2737946440836152, -5.420305138025707, 3.933632988460129, 0.13386371192887606, -2.7320328464087327, -0.41239481132623707, 3.2345315386605473, 1.2446250706292354, -2.697653676611313, 0.7245593231330751, 3.284829829220102, 3.8391225482030116, 2.246594803897705, 1.8207274546677747, 2.303307671574825, -4.503637748669883, -3.6666036260466366, -4.7100542502938545, 4.660824402510995, 2.381334103229421, -4.750876067087538, -5.329147364339525, 1.2315321288208196},
    {-4.443364546367888, -0.10967701865462796, -1.4739406390423169, -0.5744770991972017, -0.19962171591690242, -4.53938578720388, 0.7664464605713778, 1.3927307012035222, -2.9418260582034446, -0.1008396109644663, -3.6035711908615515, 3.3005371359325615, -2.2624931016458105, -3.216123897555452, -1.3254971472395498, 3.3438226023635633, 1.1527149746876135, -3.432589454921806, 0.09467861574833607, 2.960486297903878, 2.849947536801979, 1.8986142139562145, 1.4706161340066473, 0.46179647420780784, -4.488611136571732, -3.4894844369943114, -6.0293568778574205, 3.877767259088563, 0.9546229981004427, -4.1426355411465625, -5.126349683370769, -1.378475149708171},
    {-5.310533440658916, -0.01506665234603458, -1.8560406146995172, -1.1016729370901206, -0.2575757706010636, -3.256948258095999, -0.31876612324921205, -0.7423972994102335, -3.0219196238812764, -1.1835420054025083, -4.218036907902222, 2.592501056255985, -1.4619363127519565, -2.790183955327381, -2.802910842113975, 2.4634695517622784, -0.8986465843624125, -3.1610662581309135, -0.5598822498869199, 2.1842733392590152, 0.4910800858960258, 0.8368070185522595, -0.3896366771682984, -1.5135315231585404, -3.8001875047039744, -3.496680511905677, -4.287743046937569, 1.9775537984574094, 0.22728532032466078, -4.118802253506083, -3.472038100431583, -1.8463193068426267},
    {-4.257129093224877, 1.1434305128461073, -2.039877401558737, -0.07399936541718527, 0.8156281063905918, -3.7277566020186876, 2.1117301307767917, 1.5825290311363807, -1.6825980685635955, -2.0384147891721507, -4.980944291483492, 3.4020349814191477, -0.6326662880404678, -4.3563189243752385, -1.9636001567149117, 3.5266289554371117, 0.8266500507317387, -3.2495782558583794, 0.7889799004879614, 2.845809506959104, 2.0807386922320656, 0.8353858693966617, 2.094064040843031, 0.0679704829177233, -4.052405703215052, -4.740544573844202, -6.023402673087824, 3.393106982473027, 1.581802595657739, -5.378073585203706, -4.962528548854442, -0.48922572455417174},
    {-6.031617978288663, 0.8298760401711066, -1.9165225537599668, -1.7709361278298723, -0.07549908190594616, -4.982853908864602, 1.7929400893096619, 0.6594194166019547, -2.20702872118571, -2.3852992910208335, -4.367530466132977, 3.2152656832001236, -2.878030626655921, -4.772016813547214, -2.3308053649448643, 2.0168823790061996, 0.7229256017108029, -3.1369224380417213, 0.4331781082104236, 2.384497105317735, 2.795936300413663, -0.24365976815595947, 0.49618221995744277, 0.5852605561048613, -4.820725617511659, -4.251393274557337, -5.489705463963327, 2.7586512645923094, 2.2862806644750746, -5.875577053334324, -5.768017631913707, -0.822924692521763},
    {-5.529642486372832, 0.5595439837188987, -0.9311212261915343, -1.260749130606971, -1.5911039778579503, -4.905432243698641, 0.2743325117814852, 1.324806071183999, -3.5240362873980753, -2.2051418391752935, -4.820124738240331, 3.815008034114001, -1.354303305679256, -3.211532499980325, -3.241590555090719, 2.9695396022303586, -0.46961983490203696, -3.8272896781503754, 0.1531587285091066, 2.2736808613679136, 0.8248815968419316, 0.8242960285408428, 0.4746434645284779, -0.7640010787085946, -4.799158212725296, -5.1957639944283285, -6.234341029579276, 2.6503906435183793, 1.5374626830303648, -4.656118726778944, -4.63876150657124, -1.347843414565873},
    {-6.459102431431172, 0.21899557948880202, -1.785335818507525, -1.1528030169966865, 0.1395501609497246, -4.818968290072268, 2.0525897788354084, 1.5656949302310363, -1.7778078327965878, -2.4619401034379025, -4.778532049704948, 3.786765093668834, -0.934442811612063, -4.734539485571676, -0.7941823851180972, 3.9469893683009802, 0.6530387116591276, -3.8803301063848146, 0.8160256395299734, 3.543454420030322, 3.1186198258484334, 1.6388493319591695, 1.1288158456817372, 1.1158002640756857, -5.016930816487047, -4.816531544977969, -6.382702918031165, 3.0268797043701388, 1.3139728336048435, -6.0732529206916235, -4.904626006013905, 0.3036800410073567},
    {-5.777833618176827, 0.9226757814134351, -0.2972503963778169, -0.3928205543324478, -0.5201306524663236, -3.271542249131952, 1.5450964003185041, 1.6755840309704313, -2.6813963554725655, -1.5543969824472228, -3.9740477630655118, 3.9870832573581207, -1.493777978039416, -3.49084433971391, -1.254675957006461, 4.0511064899159805, 1.5707007387196004, -3.851799971155704, 1.4793580733486542, 4.288449849218877, 2.5473149156701864, 0.5186217803727996, 1.1287133250329098, 0.512078208365768, -4.691383814744011, -4.740543323963559, -6.231599034946405, 2.460611679243175, 0.7745400328832845, -4.684294522038639, -5.534553828862231, -0.8263616430615411}
};

static const float b1[32] = {7.1897655370907, 7.348779887037931, 6.831344464819504, 6.767804185780809, 6.537377159493063, 6.9669218375568995, 6.966488005609338, 7.0938174117518, 6.793360525249877, 6.722783759347974, 7.119761620319371, 6.737184224487259, 6.67815319880969, 7.166278797049188, 6.910125447429363, 7.09750250714824, 6.478093803477308, 7.066602113571168, 6.473362565040319, 6.4990488855492625, 6.70192548168959, 6.339648613778338, 7.093494844536563, 6.862540149864384, 7.18529697691794, 7.212294485915829, 6.990792689428137, 6.932897128473631, 6.424870502528016, 6.9103610482473306, 6.889501462556187, 6.406736802396511};

static const float w2[32][16] = {
    {5.697315133839058, 5.663166102351348, 6.180588477789986, 5.415476190338075, -0.6830285387724594, 4.086530707208083, 3.3004751058174615, 4.168574652727171, 4.904680900211678, 4.913993451370054, 6.13850111607564, 5.824813230344298, 6.7326813016250755, 6.109073219980679, 6.006033758523327, 6.637881174839704},
    {4.737451009776439, 4.440361436788917, 5.754181536952705, 3.7339898458621583, -0.5016439800383308, 4.3200345097840005, 2.7856639300501174, 4.06616309756241, 3.887356657777225, 4.57684602987188, 5.016807715538593, 6.260665910949734, 6.2836952119831695, 6.0813152376833335, 6.554163248017512, 6.044688664740782},
    {6.010446920790848, 4.735212039478725, 5.3148998228724755, 4.172716104745391, 0.04685435053232689, 5.504451302208073, 3.7481833996714897, 2.5732162959922795, 5.108667236874912, 5.1597285309290495, 6.066547543626741, 4.926793384161257, 5.431924631656888, 5.356708581606678, 6.10895132406473, 4.99497830408242},
    {4.783076840513354, 4.954285659071571, 5.103985482526079, 5.8282072891118935, -0.8104135154797857, 4.527132469273251, 4.1600368531798875, 4.268850881225751, 4.75561291322509, 5.471847778583043, 6.044185763006336, 6.018726951415123, 5.633107594210211, 5.028239872866551, 4.844753662569288, 6.102626450315727},
    {4.911959884351626, 5.816653681603222, 5.761658928514668, 5.147989340351235, 0.1984854451576487, 3.8620764490267345, 3.205778957841433, 4.105684994847576, 4.703211634822413, 4.002335332015505, 5.216457011056503, 4.561898037041257, 5.2352280121764885, 5.169440359693719, 6.301730147494808, 5.788868240116304},
    {6.045126664406829, 6.406072214924969, 5.180402842788001, 4.79915501617158, 0.7347039621612899, 4.394968493383672, 3.110991422420154, 3.9521560594290572, 5.315740829448117, 4.452113211153072, 5.376771247557003, 6.363449092471111, 6.645392475544554, 5.86808840571458, 6.5386314650170165, 6.831723214362243},
    {5.009573809105992, 5.391330196625137, 5.685234803899308, 4.553436109641209, -0.5642729424103358, 4.743952625993305, 3.6219370040240433, 3.2074577020297554, 4.473238575379124, 5.1709520484831994, 5.472242889544985, 5.9845489876603395, 5.931733724871901, 6.141833106427945, 6.555320869487312, 4.4504593344917724},
    {6.093991742456874, 5.444244187016983, 6.841970954402423, 5.810123710591795, 0.296030688166071, 5.7567621009983885, 3.6571158732436966, 3.25704488130314, 5.709489971170333, 5.3666260157331385, 6.937918970138092, 6.747993881652533, 5.679064033608755, 5.3251927125035445, 6.013520452173024, 6.5896515930667485},
    {5.519605687349729, 4.734635957848666, 5.031154041352522, 5.953775217079356, 0.6864324653663767, 3.783889589448591, 3.522201724499755, 3.295342749655124, 4.000554051914145, 3.8526794793553782, 6.052211154887111, 6.355317538808562, 5.7846998423850895, 5.114493922943711, 6.107106814582596, 5.504473337573665},
    {5.4149147080923195, 4.856255947684434, 5.975784920268168, 4.250186831644428, 0.5793996930133748, 3.491720695533884, 2.904501862891965, 4.290724266545139, 4.7571444940435486, 4.252255868132948, 6.129451937199283, 5.974871338598644, 5.881981016975288, 5.588746359258808, 5.42006351940236, 6.1528335005759445},
    {5.474964576613883, 5.556494072397387, 5.802394184695036, 6.221452538454716, -0.6470630673273904, 4.568840366749657, 3.7170753266181733, 4.284655141506763, 5.174539500700471, 4.449249731522499, 6.759856846346101, 6.51170937766363, 6.111183860710999, 5.977728929906, 5.889502913334722, 6.662592895344817},
    {4.493676252214735, 4.112955304862646, 5.282203892628316, 4.2449522903008665, -0.8516556761538976, 3.0870797947586146, 2.150769433233712, 4.0588131150841145, 4.899000757861723, 4.776667268593435, 4.450736849534846, 4.698568788415865, 4.372199244506114, 4.925817826606445, 5.2005410055623, 5.298980101728851},
    {5.6322157582017525, 5.4989058887266715, 5.633250388110618, 5.544730902316718, 0.6347296312282257, 5.771818721809731, 2.950293496320902, 3.2917070762713427, 4.39458912072256, 3.854226317045274, 5.431796045142719, 5.998803122894851, 5.402640104072433, 6.55459561909023, 5.376411880355669, 5.647376739228664},
    {5.737518275597953, 5.240630815028887, 6.319026200309424, 4.71476779593218, -0.5639247612527291, 4.992129748342456, 2.887466542500366, 4.517788380384104, 4.947642402203935, 5.712057357350064, 6.353709408738831, 6.466006755251842, 6.426723972620799, 5.608094352016422, 5.6673174803923425, 5.393386471548646},
    {6.17711155183955, 5.702311465829229, 4.514698061929701, 4.763375381363159, -0.7951063257288242, 4.584311379107065, 3.7829343154036184, 3.934953883830358, 3.954593399421159, 5.056535071030372, 5.144780352592476, 5.687730488762204, 6.015028205215321, 5.113581407240718, 6.493537050986504, 5.95064553062445},
    {5.265373102110879, 4.7831273055294705, 4.476557748822406, 4.073284213706793, 0.42527612270585546, 3.9774091145182395, 3.051607230625005, 2.072787034892109, 3.212114429650919, 3.987987853931939, 4.245295706682811, 5.505916989875638, 4.994523418248835, 3.806306507726993, 5.321229891987163, 4.319118009919269},
    {4.9722118163485165, 4.909305808186838, 6.004769387490723, 4.7032109715702255, 0.7139833792405151, 4.353157574790535, 2.6732942560093527, 3.2540190414918198, 5.151418277411472, 5.0963129003400995, 6.260888266253598, 5.905595855809853, 5.379664558406603, 5.366380067359146, 5.330338893536205, 4.993006137779595},
    {4.672254400105337, 4.808022978809747, 6.296470105704176, 4.835924027763299, -0.9680751451634233, 4.707178519273494, 2.6565223017717923, 3.7733505943967676, 4.42003995790415, 3.547390013786382, 5.311024948479554, 4.6221067072304285, 6.1593937575150655, 5.453987741348498, 4.743172145016569, 6.2786817138115305},
    {4.526032507459929, 5.244619111861338, 4.612012905272999, 4.495943472863966, 0.4987785813994418, 3.1296274625698453, 2.7673516102917426, 3.8430508545819815, 4.6633611544233755, 4.909929672364592, 4.40107650223548, 5.07515087528848, 5.8168401137824715, 5.7067349629415025, 4.726602430804398, 4.845484625113293},
    {5.701086356920503, 6.150082292679915, 5.716351750910348, 5.669745078623823, -0.8449713749061835, 5.108884180276758, 2.691284034682334, 4.2636490284636865, 5.300288357851085, 4.614019135732318, 5.01746596303053, 6.017561129513443, 6.271480475083682, 6.050229576660815, 5.262479618483073, 4.824946458600351},
    {6.143505559706521, 5.570103984038911, 5.941011771592337, 5.181986501844395, 0.38898277493933153, 4.282131806444127, 4.313985811874303, 3.6651186074006628, 5.13849983766667, 4.908244817037215, 4.756676820001653, 4.85765126829983, 5.417604163521006, 5.7440999639559935, 6.348262154009988, 6.441882861984971},
    {5.23743384788353, 6.273324548011775, 6.339411544416768, 5.389038811240172, -0.7798327668830977, 3.8011864348018793, 3.634560673702439, 3.771887435258311, 5.337444016822349, 5.202751641453365, 5.370783376190109, 4.993371583959522, 4.946651230415385, 4.780542965108437, 5.029621264151716, 5.726064241161119},
    {4.900237136031845, 5.678083630170673, 6.434756637356374, 5.45830931115183, -0.8768255081838099, 5.267626089874526, 2.9406907802726185, 3.1210606788490436, 3.9873690197756058, 5.755948416557209, 5.777115765504555, 5.079410848106837, 6.541127260800426, 4.74634778343129, 6.6723279484820015, 4.686385400116641},
    {5.577996107635906, 5.194993144938646, 5.8233331535413155, 5.777059608792337, 0.1437154704505898, 4.1193594923380905, 2.601643229759457, 3.5262857193497887, 3.7353565072599855, 3.966032793042896, 4.457006272422389, 5.701115733768855, 4.669397848655202, 4.734672486188759, 6.403933913171466, 5.153917417075501},
    {5.63659249694941, 5.219744668760617, 6.2511627301995345, 5.140510288499833, -0.4624280489511908, 5.728284366251848, 3.477006191878082, 3.736858108458773, 4.519771137862848, 4.416422944382935, 5.72280553276304, 5.508459730735154, 6.077633568452269, 5.512753724389256, 6.125065910847082, 4.95084759064952},
    {6.812521689585457, 5.71923786079682, 6.217508719065191, 4.562642215007051, -0.48716128661823993, 4.7155926907340255, 3.565947133289677, 4.458464008813743, 4.231889851149498, 5.473139030510371, 5.427437425821584, 6.637583182435964, 5.131960898491049, 5.368145503650152, 6.7692381529683425, 5.734190657083133},
    {5.230266555283043, 5.661151243231161, 6.4389568251407825, 5.720801551993808, 0.6987809594659539, 6.026674656735094, 4.323546862238497, 3.1609623464994874, 5.290616652084757, 4.570222449852308, 5.729481328896398, 5.5075970839018735, 6.876981503440079, 6.249263483670796, 6.810375694105506, 6.065033543675737},
    {6.38684382451318, 5.113022155664346, 5.3572374546762, 6.086769469322191, 0.39616522529381826, 5.682157802164722, 4.04686159553957, 3.8022877588138355, 5.3543579194281765, 5.606803439859929, 6.295660268935773, 5.828533716172316, 6.410608957465334, 5.229470947762298, 6.711249952406605, 5.56174069017292},
    {5.51367814336079, 5.326722121849755, 5.4394119913281305, 4.730241756624291, 0.2592302883416104, 4.68960956971208, 3.2641552198525043, 2.726140992033718, 4.363846550950508, 5.927139239547476, 4.9881329723797565, 5.028205276443838, 5.377633319988546, 5.66359365366679, 5.493533026917271, 5.1280602301722755},
    {6.415750343162423, 6.151507256165429, 6.69891300041361, 6.102925500263674, -0.4408363015584748, 5.656364839920477, 3.6785773874196392, 3.852939008368753, 5.6548245924200895, 5.633656719077876, 5.603074243673117, 6.873874460217376, 6.417057736370365, 5.044728864016313, 5.4771899824053225, 5.845841790490164},
    {5.550730925801238, 5.761786585680882, 7.025396137028849, 5.940188819928744, 0.3499376870828101, 4.888334200624822, 3.9016620067694245, 4.29846243586686, 4.23655529746653, 5.6309088980316595, 5.474467098461708, 6.15475869217958, 5.303291785820328, 6.7507459125811655, 6.636903266720028, 5.481683083026993},
    {5.1158892133529035, 5.942952425530645, 5.557886010836896, 4.986256341674849, -0.5012488440437983, 5.2809798852231244, 2.8804653217080824, 4.016205727825186, 4.769839145440828, 5.242712662897011, 5.603979972588096, 6.318185176145035, 4.547051604627268, 5.0693258762492865, 5.18365244684715, 5.159034316073894}
};

static const float b2[16] = {6.322529474581761, 6.035040370514355, 6.1918492619615275, 5.9255221159371425, -0.21304854232828807, 5.732627771946591, 4.677937862614656, 4.624665962625964, 5.648406665681515, 5.7578304526591735, 6.09835801121497, 6.266110150434662, 6.176663317749438, 6.286283435833104, 6.306839134437992, 6.174140735505332};

static const float w3[16][12] = {
    {-2.9873086638799595, -3.630974412786845, -3.5290208280218436, -3.5790953390228504, -3.3681836388296884, -4.019126166882945, -4.463610414974432, -3.2108285486706833, -3.8935968565548564, -3.046098875650711, -2.91648636306299, -4.620129781649205},
    {-3.0101237436436614, -2.9957720885080383, -2.988885006939309, -4.076396955208726, -2.665622342836299, -3.731343898210842, -4.2202582644752695, -3.5758782752277605, -3.140050376109132, -4.182945918550704, -4.352497768586409, -3.685518510981534},
    {-3.115048568282063, -3.7237047425743643, -3.372495975636143, -3.4895536364617716, -4.557076696115053, -4.395443077843425, -3.36204731868786, -3.6052495094879062, -4.05320025610123, -3.631562132053389, -3.487724031526409, -4.174641311228536},
    {-3.089394878905435, -3.3917521189547832, -3.55315808852728, -3.0790016397770668, -3.353424324197847, -4.2657202307625814, -3.3416076496066043, -4.477455553810368, -3.0594867501366325, -3.1732661274535974, -3.367222855802288, -3.6739843088434276},
    {0.22534938695876372, -0.9396353612696007, -0.681986488650497, 0.570703157914714, 0.08067149976248247, 0.3154610096478275, 0.7295970660394957, -0.35104399081498167, -0.43192642685388744, -0.7988588659527359, 0.29922603495206085, 0.7649433007977774},
    {-3.48043204185803, -3.7147155715554856, -3.0357202996571004, -2.9180804089712655, -3.6878846909428558, -2.8259220160029783, -2.7217744706532576, -3.6106215875197387, -3.748053545323773, -3.1610039707728177, -2.869498438760025, -3.507581360489289},
    {-2.2083758184527547, -3.914753093780866, -2.32654965845154, -3.6005626451571704, -3.4805111927528847, -1.8388509057698037, -2.316966291820131, -1.9742299070560796, -3.38331149475304, -2.1140404606327228, -1.634487398579371, -3.740946617425163},
    {-3.156056406710902, -3.466059359952286, -2.5064099804397086, -2.3574182259760463, -2.164431132503413, -2.7354431238667063, -2.7049444049245355, -3.9005761029277153, -2.190253542734189, -2.4718014478313117, -2.5596006499468067, -2.226895897316278},
    {-4.62098612705111, -3.027067779693241, -3.1296846368472724, -2.7112376134602925, -4.19134160573037, -3.4265367704634957, -3.0998305929897465, -4.111574162225339, -4.172337092860157, -2.915867369096146, -3.400064060036651, -2.8816924937740644},
    {-3.0881016977003157, -2.896665635950845, -4.747677217727396, -4.506032947939963, -2.8741651799985255, -4.046352451083516, -3.122233997232901, -2.8328734481647295, -3.254577724550895, -4.248785278072761, -3.504306862830491, -2.8460626144442864},
    {-4.264461814842323, -2.879766323334615, -2.9680407120878507, -3.0749232959842576, -4.413039986499744, -3.1990882325090784, -4.8544267745763365, -4.037113869374344, -4.1343822651622215, -4.2733531659197315, -4.904191919764839, -4.45110957962892},
    {-4.438360012440704, -3.7554875614834073, -3.821676014495197, -4.866593061773679, -4.129144690029757, -3.2538143485661104, -3.0834687225395427, -4.385746218947952, -4.198339722986837, -3.9068413841458023, -3.6681379873409097, -4.345432595770313},
    {-3.7291830023361783, -3.8982950453214893, -4.005333180442109, -4.269176192100187, -2.7000695889942006, -3.1078409744607374, -4.607653884504826, -3.245819881225458, -4.148364629421431, -2.8405472333418595, -4.589282934266724, -3.291684701954483},
    {-3.920057730105041, -4.071773062137206, -4.331670288645756, -3.406745035763748, -4.269493542638435, -4.262833960258063, -3.4661035972911614, -3.398693632843719, -2.632722691113213, -4.2616636350441315, -4.512704360472837, -2.899759362658674},
    {-4.600082892217276, -4.4840697191748236, -4.1791844892543875, -3.8582650272823726, -4.1371910580423465, -3.079883254951519, -4.305515591594564, -4.23216204501101, -3.3789133047849926, -4.347159646670544, -3.5828949050140086, -3.262344457953105},
    {-3.4407891577243137, -3.921435398603234, -4.4946529401411, -3.4782525474676143, -3.3288605878298414, -4.733503249443377, -3.119264798323358, -2.796577345531082, -3.9505860747596198, -4.253786835579241, -3.3151502695179054, -3.7300346955247226}
};

static const float b3[12] = {-2.688480002305177, -2.86233709066632, -2.375886912057175, -2.650536249695189, -3.109495109883658, -1.9491623594793352, -2.443786119281452, -3.0852552712174184, -2.8374996665553045, -2.8671505750702435, -2.3689022950140206, -2.249203918685059};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
