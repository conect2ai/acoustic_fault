#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.47910389165311384, -2.09116589100434, -4.332627397248441, -2.4504116250083023, 0.19341827700045072, -0.5485470641993667, -2.018013361183373, -3.326115642050263, -1.2809691642868752, -4.2173381107835795, -5.651704958744535, -2.1307738471052065, 3.5912005429020404, -0.40240537724930486, 0.4174404934824124, -3.614163507893348},
    {0.08439043862821023, 1.1156270774607444, 1.523824349276852, -0.6420673259220852, 0.010040139028150367, -0.4963909340970822, -0.26588510936958965, -3.4896145739539914, 0.021324170123589815, 1.771687665234158, 3.0703110112408676, 1.7221997029590457, -2.285444462277686, -0.5660028967773633, -1.2947463325290933, 1.324426966403511},
    {-3.377348236612286, 0.2056609692518358, 2.9105889492606614, 1.6270663281266065, -2.8142306890850763, 0.010691284478312604, -1.8228600030337068, 3.5374582645802617, 1.00888654303368, 0.7455914667848568, 3.117005878683321, 0.9213251763768654, -0.7629625049741752, 0.7952435805223248, 1.3178277534978267, -0.0172137730245774},
    {-0.2492562983287698, 1.0643676015647667, 3.1479427830325144, -0.7654320515411019, -1.4986229710811214, -1.4435061820796924, -0.6834757161927134, 3.667787485923734, 1.453917050436137, -0.442363811103044, -0.02062085753343433, 3.5753168705454836, 2.052262997667327, 2.896510250062278, 0.9546207849234, 2.6376603346267653},
    {-0.21544521542741574, 0.5233454685647756, 5.051234755553313, 0.37429042937496404, 0.9823600664170876, -1.1445426517407493, 0.20028363398967827, 3.8674846127039797, 2.426599684472395, 4.278590086734965, 0.5825191939524668, 0.8168215281736403, 0.3141598518505825, -0.864600971779297, 1.6468198930210771, 4.278854958940081},
    {1.4711751636202226, 1.5468305550383268, 3.8388624189711065, 3.561337838399941, 2.284589428329565, 2.0074876172792067, 4.200997723632525, 6.939827355071292, 1.6105084891997314, 4.695907763626641, 4.790131063520721, 3.666959675711437, 1.7671389123899057, -1.2813620003098514, 4.843805723463671, 4.8445237549268905},
    {0.7474577609216009, 1.9092007527182309, 4.528427360091535, 2.453443860586422, 2.3613242399781234, 0.18517693914939648, 0.7309230832766956, 4.303663670159839, 0.4092594192918121, 4.333664333144361, 3.7295738574443082, 7.196229162160107, 0.9209665430355456, 2.0475935899314255, 2.426349592335131, 3.647538230176853},
    {-0.6226812726810206, 1.6433988539058895, 2.406713568675628, -1.1506143774491917, -1.4236799886092508, 0.9408139262522036, 2.718504970804478, 1.3982174094293478, -0.4449606097384846, 3.59381862352309, 1.1668109498815438, 0.9422105790108549, -1.7962679303872446, -1.8240734375616476, -1.031222860168591, 2.9878926101854235},
    {0.1831194248769352, 2.6631397842724183, -0.3217298707715896, 1.045192956400342, -3.5225672378869946, 1.0640547487710914, -0.03806944021924053, 0.7803288932014438, 0.6416880197276672, 1.746324825510372, 3.3953717646821127, 3.035118666264693, -2.1588645473605355, 0.13992416317497106, -1.3861243889133745, 1.6524188848035435},
    {1.7212535906067135, 1.4573919999334704, 2.214700235420942, -0.9389329711303299, 1.8642252142334936, -0.07682172064031695, -1.003575430111596, -3.3879056616982, -3.1477049005526636, 1.6706631713086217, 2.372930867869223, -1.1037199534844384, -1.6604345547733932, -0.1544889283801193, -2.56891836495954, -0.19749615320109687},
    {1.8105248316300189, 3.3929148049399975, 1.1209812394894163, -0.8353411065923066, 2.2107008281057765, 1.6608700472790188, 0.879628713329966, 1.2246874021829084, -1.588134255981593, -0.009496052351379035, 2.6660363312329642, 3.910633354213106, -0.38307496373335703, 1.8574003738800893, 0.07116200400609025, 0.8158591818639057},
    {-0.4802727494832344, 0.9907028019677974, 2.1890892677906097, -2.2686956924145085, -0.4520731776381904, -1.4516977250856133, -1.4630378391134455, -2.2916441444316242, 0.0219523840749051, -0.5744997643051512, 0.5112800517695512, -0.10084285775046659, 0.06974338455185067, -2.5110889325356243, 1.02337749977533, 1.392890209543566},
    {2.003796711574165, 0.7530343434651197, -1.762986379250739, 2.5824675647219624, -0.7400756849907693, 1.9279876508817857, 1.354945709696683, -3.0463482113713165, -4.422353623551613, 1.2653866336033874, 0.9677350893373823, 0.5374963601259134, -1.8013448370080067, -1.3902672547650423, -1.7142666134635935, -4.348343616946269},
    {1.0846682144281707, 1.576035647979211, 2.9838077027117675, 3.0746442125124416, -2.1490412516884008, 1.2599368693947117, 0.6813476786571968, 0.9195892519994805, 1.788751609627959, 0.40171599321847745, -0.7408440730478401, 2.826548236338569, 2.808273580159602, -2.432816963331676, 1.4018088278843182, 1.403404191651818},
    {1.2835406272627718, 0.761330165057326, -1.1975621922366957, 1.8450641911533099, 0.705292328825788, -2.5059285978961308, 1.4961731319884215, 1.138825890658035, 2.5850890184880804, -1.3685223652973761, -1.5166497692860594, 1.1406523491757643, 1.9350333124313106, -0.3266733910958352, 0.015803320006080604, -0.1836820130520221},
    {0.49882738151918854, 0.06577392247976871, -0.2648495938856998, 0.2939718119777734, 0.023433295745531216, -0.10807457448855887, 1.2738072448579048, 1.5434836458856112, -0.49377214567477884, -1.125574139497862, 2.2408894112618003, 0.9499067878120141, 0.9430808810280922, -0.026517321313955726, -0.5782937661396461, -2.8206968256893594},
    {1.269472225223701, 1.0726128966462882, 3.1985490306518467, 3.4149631489619847, 2.8302693365495086, -1.7685525579898147, 0.6338737842810153, 2.5626276846298386, -0.030439677894074316, 0.4131427754961549, 2.958062214084245, 4.742084389680438, -0.4679114338966579, 1.4598305365161115, 1.5997408723458477, -0.08777622519604973},
    {1.5189796480297777, 0.502895999188302, 2.0584026410376377, 0.8627660321912165, 1.895144897463067, 0.17965800567004747, -1.0460056684060777, 2.744094133341853, 2.637029844377285, -0.11148669906147127, 0.14069750183243615, 3.112191430762662, 0.6190100088460317, 0.21164044691575737, 0.4744153039124695, -1.3027395982635983},
    {1.788265823506485, 1.668441758583955, -1.907201901510635, -1.0236502162593681, 0.883430709066819, 0.252410480647506, 0.3158726178162508, -0.08589866056068904, 2.894721037366813, 0.4099484053729948, 0.5895337431232007, 1.5025742339503947, -0.5829810855680287, -0.17610154102465614, -0.7817816518410909, 1.2675699913906402},
    {0.03840565806292877, 2.6560847691094756, 2.092764510705215, 3.314757994472776, -0.9614502545435383, 2.431564568942751, -1.498160931870259, 0.2157925110330686, -1.7405338660267708, -0.8075028045384924, -0.5652040521315955, 1.2452769769706826, -0.42682553946807306, 0.9839891984574983, -0.9246530471322081, -1.263986968551336},
    {-1.2898868713903626, 0.284964755193541, -1.0910529665266213, 1.6258905009694333, -1.36007393247045, 0.5026014953615774, -1.9512194007577635, -2.7383627202224443, 2.779968553199087, -2.8024977757439355, -2.6888987725676103, 1.6936155258635242, -0.12421352031295986, 1.4929939532062901, 1.7804591643955463, -0.3676063588797374},
    {0.08231805921917934, 1.114775493923683, -0.4453828021276735, -1.997166400468062, 0.6734577833701254, -1.2231074968745914, 0.1995715302230577, 1.4797239566462796, -0.8068699049544886, -1.1843931603342406, -1.3455890765843428, 0.3392323090236653, 0.304569721991356, -0.4485395038893401, 0.19392866771165349, 1.258959444130086},
    {-3.890529663297472, -1.989374215379187, -1.4654972717872832, -0.6441846851286844, -0.8260525379564128, -1.001903643852358, -3.190763062943226, -0.41280234158529183, -0.3787479114165308, 0.12540240347364018, -3.3487354211181772, -1.2025200506268456, -0.874044872245135, 0.5070273374894705, 2.518665293413501, -2.1067658138282193},
    {-1.0738627888365933, -0.24624599469617078, -3.2587111129219, -3.097840829413197, -0.7699328046231794, -2.482517391935101, -3.6006058038054496, -1.3050423037776409, -2.8336338501549516, 2.005498987566099, -4.705566532541039, -3.7068864958850956, -1.7657237559839845, -1.9270152629509798, 2.5574086464634744, 0.9671059553350125},
    {-1.2906871701859557, 1.2288837929187375, -1.05824788744239, -2.4335184555856357, 0.4558862470706318, -0.14512360891333356, -4.355518071068796, 0.537003105816711, 1.2977165332453162, -1.0770303898498332, -1.8000394366446728, 2.3875342142431006, 1.8328569715402485, -0.9794065360363332, 1.0374288405985082, -0.26686473619427015},
    {-1.2851966847453855, -2.104234865494386, -1.1609678305967062, -2.838277256921734, -1.7697678991227188, -1.2765128799230794, -2.8572681621218856, 1.5126879658175139, 0.33051794882760294, -1.6539982538807831, -3.5297208118117607, 0.23157747337432705, 0.1813955345259174, 0.542569337608362, 2.853297336117617, 0.6685695225049739},
    {-1.8383401823589802, -2.079952073551046, -3.7928469805825733, -2.3468107432873246, -0.09583846794160494, -3.218294435995277, -1.336241736439659, -2.118844133456987, -0.48725846024318625, -2.625515267558356, -4.305828256319252, 1.6267781931049254, 2.134781084049889, 2.5039947868323695, -0.7536950806301324, -2.604750263046577},
    {-2.1932399980593957, -0.4255961607263669, -1.961629558625545, 0.14648692963245144, 0.721665185409944, 1.8539586496155873, -1.5774244209600738, -0.2941237736297051, -2.3058650281905817, -0.7876425602178398, -3.731171473097273, -0.27310984911719177, -0.37960282783904753, 2.7163693508043467, 0.5923333009285011, -2.6406045537903107},
    {1.0160932139062406, -0.9628697752008034, 1.2507118048836, -3.0835723725931516, 1.6449139609586212, -1.7085504184378721, -1.622232532251679, 1.9106507166124058, 1.8142043066873612, -3.120193265602131, -3.3633234585246536, 0.7803864478990256, 1.3020271193150939, 1.8918910020680522, 2.0269324901464123, -1.721328638142403},
    {0.2515436085383397, 0.8755009593360247, -0.6868424062279431, -1.1952783160475895, -2.1579015766479133, -0.6480690503444094, 0.38972717770445936, 1.6115789534177094, 0.2264241888073664, -1.3256907241860745, -0.27143143902819833, 1.0501244129761307, -0.9290122827388919, 0.2753157130837047, -0.4708606541121719, -2.7727779265039176},
    {-0.007573763056812068, 1.0667923295579302, -5.4761629789311055, -1.7536113789660255, 1.9884227285047076, -0.17674758123180517, -2.3804452574297765, -4.787436964109961, -0.2647131368861161, -3.38533686897119, -4.294138742015038, -0.48736915951270393, 0.8758474936115376, 1.3254548414933132, 2.9991931998659402, -4.391323036138924},
    {0.021244135510486147, 1.8999832343429943, -2.924297072409928, 1.0606784417550315, -0.24204828415462945, 0.35713073702666126, -0.6342775466561542, -1.899348085155967, 0.3102057684235674, -1.7367815924703032, -2.7221881834198163, -0.539515154921822, 2.6177640164103875, 1.952078839660227, 2.489809966043018, -2.4100605971873854},
    {-2.9247899201813623, -2.2788959822238746, 1.3506158369918164, 1.0685254161195716, 1.010297314306856, 1.654068281335513, -4.165665830884124, -3.748816169553301, -0.794944322764854, -0.9807337153527418, -0.1574715693639698, -2.712251583188916, -1.598926925435631, 1.0318868843435038, -0.0029659050748754964, -1.9915995387164775},
    {-0.9967893951976123, -1.586241796056678, -0.4552273152715782, 0.6952887728376149, 0.006720270664224332, -0.8977672534603507, -2.115372449655424, -4.3361607713742485, -0.3865850834883668, -2.200677730967384, -2.0757787207236698, -2.467179198087425, -0.6873558971494651, 2.1390292786868996, 0.8281499995978304, -3.686861433607484},
    {0.35915311000460287, -1.4904750875504098, -0.7649526643556336, -1.164271119945435, 3.324349369421549, 1.5506134481275915, -0.12750445465590637, 1.3992872396709022, 1.9535066992295405, -0.12060543250857503, -1.073863259267126, 0.951481684124358, -0.16494338217805157, 1.2704295091958784, 0.45656806099170866, 0.6376586047022043},
    {0.46196136378184904, -2.4453340644186605, -1.5076183493211104, -0.4357597650898787, 2.1774754991732745, -0.563286110022172, -0.44515211370705104, -2.879937665562339, 1.456925298325619, -0.5398370846920622, -1.304044700565443, -0.698142171197399, 0.9704964443922148, -0.5566726457521342, 0.04451963135554865, -0.9615826703627047},
    {-3.2840204435207183, -3.2941258202292785, 1.2850538278966672, 0.07321824087744086, -2.562788381430481, 2.7788896593939834, -2.241622673428316, -2.114325899137734, -0.2806757704413208, -0.6390728676968134, 1.5793495242685824, 2.5764283838939748, -1.3890698469024352, 1.434380201745276, 0.0118353333550753, -3.781302898795728},
    {0.3743958091679104, 0.7356308866129347, 0.9261875058363531, 0.21607440105756948, 0.020131572219658053, 0.99510940965082, 0.3610711222830069, 1.0828662645540135, 0.5221345241450241, -0.6519508257917092, -1.295682318190133, 0.13873965114783182, -0.2943882177042937, 1.7749066902079562, 0.03213069537530576, 0.029937312933064463},
    {-0.7085516184246604, -0.6714767305691729, -1.0389380163131916, -0.3627189263547199, -0.9950229122126611, 1.2367093354033476, -1.3685419710533502, -0.6496601755895041, -0.31595801093967146, -0.38851042446830825, -3.321172390951908, 2.834291600055321, 1.0173131832388755, 1.059241644309173, 2.914171714635306, -2.059715114257285},
    {0.9066214849930339, -0.1481718765863455, 0.9355471842044482, 2.8653922520516004, 1.889322719588425, 0.5553766801199602, -1.1114192237872536, -0.26531814708886037, 0.8627417874819606, 1.2792719739939136, -0.5422242429748546, 1.073981173744771, 0.6583635473316651, 1.5704086636474601, 0.6103296793422129, -1.1624895672100237},
    {-0.3352959766002832, -1.15209290570288, -0.10672969859461866, 0.08869994126481391, -1.0320595138981101, 0.3630987798563963, -1.3089033322054402, -1.1634942649708966, 0.10517059470878724, -0.6672123443549328, 1.5510129291515, 1.3297597431229866, 0.9214191163413432, -0.26655666004300377, 0.5862362978340006, 0.48823586428198923},
    {-0.928839731358952, 0.8430911205260754, -1.9138472773402038, 0.5244593058421342, -2.0635244392769896, -0.8047174426217677, -1.4730204858378546, -0.2519995350520054, -0.6315432562937199, -0.5529533663939894, 0.9155807584173158, -0.22471855120524584, -0.3860113398352501, -0.4974404888793226, 0.06523890058785632, -1.5889312740282546},
    {1.4954933237395875, 0.4989151799103673, -0.8390004981152116, 0.6061549861971173, -1.7291123098171162, -2.6902228720880634, 0.3418998930008134, 0.42533139418105936, 0.8221037351731257, -2.6504140106964944, -1.4636002629146663, 0.12059317696048599, 1.1936476327950412, -0.3902150925565051, -1.2124196974983426, -2.1837463778589896},
    {-0.969375640181252, 0.6436488419565638, -1.9959904713463843, 0.0074832776255079276, -0.7304899581437074, 0.29754923472741573, -2.0048015425472965, -0.690366568777861, 0.6971510247627881, 0.21909107124177243, -2.668836901130295, 0.778546912388068, -0.21903847968248968, -1.6833732119594285, -1.3351020513401657, 0.22667389639729338},
    {0.9526570891149316, 0.7133529955365425, 1.7735772024630874, 0.6783918433436507, -1.718591792940999, 0.41366251815419836, 0.6493654386414545, 1.499804273595895, 0.7680241884029864, 1.7853728396729793, 0.45105042309583077, 0.10856911236033225, -0.7812281380001784, 2.2799730553005078, 0.3697368582239545, 2.4084632876178036},
    {-0.1633936657975857, 0.027224970233915194, 0.5824244421196898, -1.527526734336513, -1.435152645387558, 1.0209966212489239, -1.732359770038793, -0.8155379878309341, -0.8118695409898311, -1.610270950214237, -0.9358782720683105, -1.1676192718651668, 2.0126373554715427, -2.029230014265274, 0.5195017788496835, -1.550178676330403},
    {1.5437963474498961, -0.9559130787850914, 2.0430301322008155, -2.1948472404407124, 0.481869070947109, -2.439703151344584, 2.275725077364867, 0.9580821478432092, -1.4074400900247415, -1.2300945160906798, 1.6244769086463653, 0.3256821273909849, 0.6363486161690756, -2.9909585864067, -1.3611016066996444, 1.4230436452291126},
    {-3.2379950568279963, -0.8984836055699368, -0.02247560248198033, -1.6050736517420252, -1.9273631028182159, -0.4503411901357267, -1.778241615654304, -0.6994432186065236, -1.4766529322624822, -3.3736144904772045, -0.8367747492294103, -1.4461243296132442, -2.765781432683976, -2.696790511294254, -2.8561805022793045, -3.1363975885114797},
    {0.3037288186207919, 0.648094266708542, 0.6074220842556157, -0.7075956092288841, -0.5560490231238718, 2.08335247905199, 1.39320385344232, 2.293712586474304, -0.3393731844650744, -0.5706326793724806, 2.3259567614719336, 1.4510029418099426, -1.325532757921932, 0.07173861897568981, 0.5719467384252395, 0.5246811341443247},
    {1.2336198315824984, -0.836330055448191, 0.17909504880921492, 2.6931899991865653, 0.44503388130373006, 1.0325882341739756, -2.32967106672637, -1.712256328897779, 0.8875416294529739, 1.6279540109801243, -0.2803965803948174, -0.5226229469569372, 2.2989754044312543, -2.63915229085255, 0.6915846708505413, -0.13990692113738332},
    {-1.748187787538887, 1.3729827614781613, 1.5128589050809387, 1.0592695100492124, -1.9364655092008194, 4.800189763999014, -0.40257076544905235, 1.477969253595067, 1.9325658130218237, -0.6244345518689515, 2.3002460449416637, 3.251437933835975, -0.31520830100323816, -1.2158931902565402, -1.1809563162792007, -0.6154773970181333},
    {0.6433386088124281, 0.8379330779819777, 1.6202524195820405, -1.0950079153299626, -0.08814860401268627, 0.22034635823880627, 1.4606036074616304, 0.9281977384396338, 0.17692375630405158, 2.0419935446449182, 3.2264165730470835, -2.109067189469856, 1.2575178806093175, -1.3344373928338407, 1.277465070193571, 0.7360759269129062},
    {0.6542549429843662, 0.4323068911796262, 0.40607839694015824, 0.8569438167651771, -1.1949949624775666, 0.44812078963578283, 0.10117318062077456, 2.210818043189933, 0.17039217939181675, -1.0664710577071161, 0.6916467187095375, 1.8038582345763876, -0.6782196645172679, 1.8455551035349653, -0.9248076631408548, -2.0699685371872576},
    {1.532857951600653, 0.3609994822137774, 3.7118195498341713, 1.1029092404812313, -3.9984322348136048, -2.3688812987361625, -0.3524742100793102, 1.5093341335267116, 0.6750036466054233, -0.5892424814786326, 0.3041449713507815, 0.19014797820995166, 1.0988151058362423, -1.7258815853829315, 0.06793643250963467, 1.0423442630891213},
    {1.4039857159420956, 1.1349650373726894, -0.25594390630303687, -1.804669490371638, -1.197523966647549, -1.1015919302700987, 2.451215695873869, 0.9489402416913288, -0.9847314929907683, -0.9787774140173275, 1.5751213414702714, -1.0227989076193724, -0.5259187860794551, -0.39244434352259894, -2.183366741969828, 0.5533156871814232},
    {0.48521394112784993, 1.0463737983419097, 0.3245093001771615, 0.8095065661453452, 1.4555906093178377, -3.043190817766954, 1.299430432658884, 1.405527191495175, 0.6261176606424522, 1.5215190936715222, 1.0760155921455048, -0.07897745257385273, -1.7709305833929805, 0.47929100452795226, -0.6083832698974568, 2.48455558043411},
    {-1.0778717739157033, 1.5826013824898495, -0.21230487538060117, -1.25379690725421, -1.2785000549216503, -1.9077139147410023, 0.7290767152048699, 1.1154106939213584, 0.5925831248207789, -2.475634475714405, 0.5025859194309983, -1.2888208291993983, -0.4864107220388808, -0.8455657123324561, 0.815695095541681, 2.14246915857985},
    {0.052686217798770155, -0.7331808637611189, 2.3949535926999603, 2.694782136772776, 2.647181878240899, -1.7865272022574068, -0.3320401779702809, 0.9705092203167717, -2.1057703066169875, 1.7891166725272154, 1.6385768638194127, 0.7127098622322472, -0.042884757746482066, 1.8406771994410305, -1.4178783469325347, -0.5948578930534185},
    {-1.0353535698941083, 1.4623724135395042, 1.4158389009727261, 0.42438568912287844, -2.9498208022047545, -1.7674921694312935, -0.699036036022549, 0.9149320806371057, 2.4935562635290545, 0.08857666766440303, 0.15036546928283243, -1.1607668527238229, -2.83823775141623, 3.760480712475406, 1.6632581184612094, 0.7983741503475597},
    {-1.0536263745633399, -0.33205646043500836, -0.07795532693353074, -2.5836145498566245, -3.079060254715426, -2.0963578966187857, 3.3372337220693233, 0.027927322054960325, 0.3617174934683787, -0.7975367891776752, -0.2601906362682053, -1.8597727163875468, 0.22180838731403513, -0.7878844304280722, 1.0916925533993247, 0.19786084630848877},
    {-1.606614114091895, 1.7858517422242386, 0.89788634794372, 0.6280261707158766, -1.379430871879682, 0.20532529492161722, 1.4331279909826595, 0.6180130431351205, -1.1291179586338878, 2.0899608953342277, 3.3710510223906116, 2.754095302541936, -0.22262751471719253, 1.0463018520122775, 0.5346825221286994, 0.39243031873562767},
    {0.8555821807611401, 0.4261841172624202, -0.6560949642134242, -1.3534073366892911, 2.3565303021203827, -0.33411486729865086, -1.8913031537643035, -0.046488718351216, -0.3604814551975436, -0.5708498962710135, 0.38862141343969736, 0.834214022754297, 1.2497606242460972, 0.768571373444356, -0.574729810622887, -1.4818075723054898},
    {0.9378938340266911, -0.24141734278839352, 1.414030115870452, 1.293573089286993, 0.4364318819504912, -0.019513991383632797, -1.6006092724653853, -0.7615968891328607, 0.1471499407470596, -0.4899866040470212, 0.32429910686687724, -0.9719757967050789, 0.7855766481814666, -0.11633670289771703, -0.05677181827346285, -0.8490050029157952},
    {1.0119845088924377, -2.2977884813136824, -1.3981172736469258, 1.9039226446344362, -2.471269474117642, 0.7380852803891146, -0.6492368949920734, 0.7088592566860078, 2.4455672030180553, 0.5360993590519887, -0.5452241324143066, -0.4103892244515135, -0.7963218413492628, -0.317435953753645, -1.6542009979176815, 0.7972665400526812},
    {0.1253015618744418, 1.5685175413716372, 0.5012159433276996, -1.495495705107178, -1.974173574319939, -0.9563037266445868, -0.42886593936407275, -0.5074281466301912, 0.6404552624353791, 1.0402338468794299, 1.154033363956262, 0.48872230460975324, -1.1359276722266773, -1.2237534995418544, 0.25300491955007137, 0.4613496484074364},
    {-0.37525009662477254, 0.7120905303591207, 0.6495688709989424, 0.35586048292271766, 0.34457386558217307, 2.076454702554383, -1.569663786885693, -1.9927694414108346, 0.9265079831853309, 2.717010690444267, -0.4272336648453195, -0.9264299819835163, -1.032202175982747, 1.2515485751683546, -0.4369435997964863, -0.7646435737590607},
    {0.4559346463586275, 1.435064525180261, -1.51444419215793, 0.2446636291498955, -1.611980716617719, -0.16115173422745052, -0.6340097804542749, 0.068396195201725, 0.8137680715019167, 2.1886924079800365, 2.0046246715767566, 1.3670928884804137, -0.9938588956202713, 0.7905503203774418, 0.48554523007533007, -2.3957205484313695},
    {-0.10280835002783065, -1.5912240249469565, -1.8199202801330632, -0.5760695552777801, -2.0531182001715207, -3.0382336213062655, 1.1979891004804506, 0.8615855449345264, 0.22267056299734417, -0.20855877130903105, 0.03612765328476698, -0.8171770916642699, -1.5121018151702619, 1.4673896502839532, -1.8377958690767833, -0.4744395805464139},
    {-0.06308600862224317, 1.3298881456017413, 0.3030673935223866, 0.3076935700420059, 1.4743715582953574, 0.9183135860018654, 2.029466693624115, 2.6064273938209443, -0.6266513380888011, -1.7594088293307368, -1.5794631852428838, -2.5024780256263894, -0.4653290539387457, -1.156406824574236, -1.0286464201909282, 4.530733321383759},
    {-1.212613955706717, -0.8655875435478587, 1.4623920075839594, 3.167109289278202, 1.8789661837969187, 0.38665834063827303, -0.9754205709113151, 0.8499713658120976, -1.7280820785503228, 1.9856445128224165, -0.864863772945161, -1.110413988580715, 0.12469305608179904, -0.8928908148461111, 1.7980412949708369, 3.9312912337856276},
    {0.7074815582424726, -0.047258197483111164, 0.5229948579489504, -0.6615928282736238, 2.9554853898264986, -1.0994154206547546, -1.6199924046147012, 1.2626133160601458, -0.46706190882894416, -0.5470095026696602, 0.06357103686308828, -0.25471732552587817, 0.8892709265565498, 0.1541093754373067, 0.7070415902907375, 0.6167252048946315},
    {-1.4683483932670451, -2.5972385598433907, 0.7517580380749393, 0.3545607898553725, 0.6792839291947547, 1.1821078715678242, -0.8382167648409614, 0.9159999835710291, -1.8298719090822742, 1.4861104147924828, 0.8434429544444128, -1.482597744062912, -0.28480786852729884, 0.817686395167591, 1.0166868853865185, 0.9284043403739201},
    {-1.044226174027967, 0.47918280130540297, 0.18566888216159727, 0.7456453933667805, 2.039665370918514, 2.8771146267534746, 1.252122468060802, 0.13381773125597834, -1.3686780506337102, -1.8884098016922204, 0.5869640933146022, -0.6311975795233917, -0.2778698347264903, 0.888290011324297, -0.658202464478484, 0.3772524596483022},
    {-0.19665903822257177, 0.7805278870720638, 0.5897536919925347, 2.639176227839379, -1.2602642292622315, 1.16589715457039, 1.1622447299379588, -1.0173338310868119, 0.8771223823314871, -0.7410701832570931, -0.5876966372383408, 0.4122231674032238, -0.15118529928970192, 0.21149603195556194, -0.18460315823747936, 0.18931206060308653},
    {-0.9553437447960543, -0.18183240160152234, -0.5490609072609662, -0.5559619808972373, -3.179917348003725, 0.571388649921715, 1.826195868760131, 0.5967819114164112, 1.005978472511965, -0.9664994922795846, -0.027282622436250143, 0.9650428914696009, -1.248359006875042, -2.7625173403602905, -2.206625589933746, -1.6114296608795922},
    {0.8384764229541463, 2.1838084573298446, -3.712492145124393, 0.9830221711065349, -0.8445224703095995, 2.447765082425358, 0.008139621280218497, -1.9607919204561317, 0.8211167532398894, -0.6076643557548459, -2.689274505471352, 1.9233972595599367, -2.246138285453967, -0.12281970938586902, 0.0851730329242981, -1.2648777786390337},
    {-1.1961832725379464, -1.2885283500189308, -0.6218369596543742, 0.35879861599856566, -0.5013654424016154, 1.0216676162409488, 0.07132878610786748, 1.5036679446504577, 0.11211390752622206, 1.9132589770729922, -0.39614390677401046, -1.273136068606357, -1.4731411822063385, 0.009068069761796986, -0.5706747307897321, 1.339936498031741},
    {1.389866514052191, -0.2696448279374964, -0.06611764997375122, 1.436630115699903, 0.4159373999717357, 2.2898257248638343, -1.1994872874268563, 0.4812147506646626, 2.1006811238821794, -3.294067899877838, -2.6401481583679893, -0.9519302627530514, -1.102766722799198, -0.7343637273472065, -0.278838029039132, -0.20508178691975895},
    {1.8515700266752233, -1.4067451498922205, 2.8000617553960634, 0.8223588722817007, 1.647260074008797, 2.5004854192534793, -0.994002793067569, 0.8973210000370758, -1.1475897418055545, 0.9536571198887028, -0.053482242794917555, 0.7459218324750893, 0.1955169498391503, -0.5244851141996456, -1.3881578568861765, -0.189103590328386},
    {1.0460920677774932, 3.058183487615786, -1.7249038173504485, 0.9122828429589811, -1.039451345631284, -0.6173081460175744, -0.608472738389746, 0.6303095766219561, -0.25834449507733415, 0.9726166200112761, 1.0356845750978574, 0.49397851066792164, 0.7033654777683065, -0.48060663868257114, 0.6374501017221732, -0.7651323752934814},
    {-0.9772620684512564, -1.789567234107112, -0.6361985742721742, -3.3174889614746066, -0.05859899795939066, 2.834587677902935, 1.2972500336279018, -0.9274690160888088, -1.2671191004062994, -0.5831866639761139, 0.20889384466626318, -0.4077259375508939, 1.4365241897929275, -0.5747915975995057, -1.0268840853336099, -1.8379351074354984},
    {0.289223094047879, 1.2587229967401743, -1.7212801513837244, -2.6681837857759976, 0.5309241257887687, -0.9774932666718057, -0.046170294520165085, -0.8093664499128008, -1.736982663794399, 0.4044298734233704, 1.0657155051940896, -0.22011079140648207, 1.5572730320943649, -3.028514072478523, 1.2184075492884427, 0.42938071586717486},
    {0.32514220783102404, -0.8385238451736666, -1.902333653709615, -0.06359755298028277, -0.4984326782812439, 0.032637205792159306, -0.16968084672235476, 2.5286981471511134, 2.9359525715642065, 2.1674130821299453, 1.9155166362862732, 2.64671002554055, 1.279456167371325, 0.8725006302006912, 2.1313136512454487, -0.13013354543890832},
    {-1.478440520662536, -1.881861889975194, 1.7037097099791534, 2.084402885472014, 0.03730527677597928, 0.21890781053434444, 0.7654890682820839, -1.5347248109357263, -0.15960130740063158, -0.8871266968567569, -1.2205893097085905, 0.21227088135349453, -0.5626926235850138, -1.157839730394822, -0.17864087103331366, 1.4820119954697073},
    {-0.892249226940773, -0.21225914981032207, 0.3422524909239147, 0.5765926854575564, 0.07962264981417674, 1.8456312486534947, -0.7272260060305292, 0.5394093075534098, -0.5211238331189424, 1.8361480813236897, -0.23031244345660173, 0.05286280011732715, 1.4525175684251657, 0.07251118310420564, 2.1624711103356766, 1.4801794975906408},
    {-0.6573419919592884, 1.3709108223917121, -2.2645998035481774, -3.6940722374069606, 2.8869018480404085, -1.047970362697492, -1.3979453286965235, 1.0885323026702622, -0.48170643512751343, -2.2282092536544478, 0.05651277366702375, 0.8394472028965393, 0.9741050273407477, 1.0349427542401726, -0.3981667618621511, -3.8069869294804675},
    {0.4023454996172241, -0.36610789778873093, 0.9203564988761256, -0.030635028824255478, -2.9733673052019536, -0.9564031769984489, 1.0081938255298302, -0.07278397262608742, -0.6738583819005676, -0.047272600748594386, -0.7376878062691697, 0.6552956595251658, -0.6974903990405334, -0.09302034686740716, 0.35581941894918034, 0.6414664230030743},
    {0.5210158872196722, 2.3853764349071938, -0.8988733489380824, -0.05580100791376871, -0.3079235208977703, -0.6598088206354269, -0.024221354999340434, -1.6879120775353225, -0.38293250513599386, -0.6707603846189342, -0.9791863298217497, 0.5960078798712602, 0.9945541381023105, -1.0650921453102298, -1.4527692095488478, -0.9559764077051993},
    {0.7031061132584937, -3.0904785024397428, 0.9755427793600927, 0.9119022526117203, 0.25685811930891755, -3.507662442319312, -2.431750667174637, 0.1437302778517639, -0.07793371109197562, 0.022401381550000373, -0.8272867690090092, -1.079589417110356, 0.5356830508769845, -0.026296268091894108, -0.6192474969569736, -1.56514838034062},
    {-1.330129160365623, -2.4445950516076436, 0.9977923199575273, -1.978842984660026, -1.21081504964651, 0.9287696841349711, 1.3774427889934153, -1.687360910827555, -0.9434930109646321, -1.3043895820610725, -1.0117477910658614, 1.3575697596965517, 1.1953353794685158, -2.4077228286186734, -0.2314793473827279, -1.536807978305409},
    {1.6480887536994344, 2.6937015535717355, -2.0169327263167918, 0.3422796714663802, 1.455433687149181, 0.5144845625151017, -0.965249476762762, -2.6755928167097713, 1.985801822076285, -1.650783837895739, -2.7750771352622285, 0.8381645104522347, 0.29327898016901616, 3.40056106143247, 2.4987644079799196, -0.23178633994666004},
    {-1.0372097124656032, 2.467941027635618, -2.0036291555715766, 1.6508862922485708, -1.1712042307032065, 0.03281497143617572, 0.580392362234961, -2.524529384623954, -0.4422581172968049, -1.7647826596514524, -1.3814865529708427, -0.7163871602842872, 0.9109989450099154, 3.983835533456477, 0.2603442200065501, -0.3102179017156353},
    {-2.9837703705071545, -0.6196764784107658, 0.33328171468696066, -0.07818069796641669, 2.433694649587344, -0.03298957346544989, -0.7619420699814882, -2.765109634463373, -0.6050852988561372, -2.3077672351334972, -1.2384079328741655, -2.576302515691427, -1.177152953768582, 1.190490926693425, 0.6108921852927791, -0.6640267888627241},
    {0.031126002673631945, 0.1143709796023353, -1.0271467751299037, 1.499375986639283, 2.2536805190826703, 0.4136285923406274, -1.4236253593991994, -1.6762003772500127, 0.33850221087592675, -1.048761559624966, 0.11979168279839864, -1.3220433330195749, 1.2887156639514132, 1.6478253388857282, -0.4053567977854129, -2.055535449210143},
    {0.28474004260200103, 0.16445311952885128, 1.6611892824522054, -0.30002261333211616, 1.9432960956122263, 2.035670550432324, 0.9484506309273064, 0.5096215795525721, 0.44533472496995025, 0.5579604375763257, 1.5809720062718755, 1.625610141028724, 0.6293570408630547, 1.3467753565408205, 1.4285359207247375, 0.47394186246150544},
    {0.4452822000596397, -0.4095394734320763, -1.8706690557899843, -0.22158935903134505, 0.5407211488292817, -0.21432053266167153, 1.201174110622214, -0.8913644689690884, -0.6317140068223102, 1.0306468315618462, -3.4529038416299276, -1.1085426770423334, 0.36085086970845687, 0.46271668357923035, 1.3351499946920182, 1.1461632195366103},
    {-0.02902259451060799, -2.416907292493704, 2.426190280886236, 3.0615818550110894, -3.6560371857039584, 1.7379617772716551, -0.8082716046187484, -1.4556923954485914, 2.0092443163982145, -0.3269198285930169, -3.0389277719486127, 1.8089757884139122, -0.5756905471236905, 1.0917734693713137, 0.9730445514484013, -2.5750748294185706},
    {1.0948857857039196, 1.6009671823676581, 2.5272885324473964, 3.8101733478942896, 0.4741823161986254, 1.022993990404294, -0.4078948359017981, 0.44320846939165426, -1.2778224730383785, -0.4801073291165441, -0.06011895624955041, -0.49557293572011474, 0.016140169915766694, 2.061238773925986, 0.30721275573628576, -3.2576930980248617},
    {-0.4060118067283267, -0.901714337489819, -4.042379597134619, 0.7663953115987856, -0.1166775067627835, 0.4544488674114945, -1.5221923918061555, -0.11541798724950185, 2.3231598155654787, -1.4396468465456929, -1.3944235228570532, -0.26584314653104735, -0.3015852028259495, 0.21506386840934266, 0.4649850116403045, -0.3077378370539744},
    {-0.20654641519175412, -0.7872362945203323, -0.49084346898497816, 2.906407435597179, -0.8785642922049004, 1.278879526184783, -1.2057736035691875, -0.5973775403020404, 0.17302172204628066, 1.7043439464299772, 0.7083638619666877, 1.7852308683781106, -0.689072219325285, 1.7394672496922092, -1.658977620883423, -2.2326507461693432},
    {-0.8854521968510967, -0.9066818663980853, -0.7532820895797998, -2.589700841075648, -0.018337813824684107, -0.16426010219514012, 1.0412869489028274, -0.28570186674073306, 1.963228126706978, -1.4720726008315848, 0.3478804739585758, 2.1142064512175374, -1.0155040748788837, 0.8170129409738472, 1.1402899146270238, 2.2835412597296934},
    {1.3294178756248292, -0.2168009824594698, 0.6188946909933726, -0.14881105709395004, -0.7666193144313336, 0.020130133029837727, 1.6077313272704363, -0.801013899194613, 0.49528241244295523, -0.762424545572369, -1.7979697333494762, 0.8250071832332156, -0.5982573822305528, 1.3076916994249859, 0.1356825077943005, -0.47428557743421385},
    {0.4505907899024619, -0.44533009572842186, 0.3587331358814808, -2.269817601652769, 0.9138404583878891, 0.8238278229084615, -0.4253224958012587, 0.41229457301017763, 0.3983912822410953, -1.9189444345208109, 1.12310705875395, 0.43817433463265526, 2.072441856791357, -0.6219836695814361, 0.3463488804544886, -3.498287833739853},
    {1.1702333530516043, -0.97480083478317, -2.3539408214309594, 0.07957070305257864, -1.4031175807291059, 1.9086042456262042, 0.9840582371482393, -2.735242752338441, 1.7919219484903819, -1.1208400976611865, -0.5547111531232658, 1.077267387178962, 0.462187618990563, -0.8418225419065947, -1.06159540849033, -0.8191298116007196},
    {1.1813900284213315, 0.914683774280685, -0.17163260852233003, 2.399052467452186, -2.0727150945540562, -0.391199570535869, 1.541139600828011, 1.7813064549667947, -0.027987042705002525, 0.2622294127963718, -0.30193350564582633, 1.3652460415782204, -0.859624366497995, -0.982397826053226, -0.16092687248425297, 1.3898821043555034},
    {0.27290193491788256, 0.9802369418863222, -1.6164695548639099, -2.137382712300934, -1.8392887706178276, -0.6816653889500623, -0.8859555060961917, -2.085275243255767, -0.5419780010607059, 0.023939650829177293, 0.14762070033151892, 2.001382898132396, 3.261214412702131, -3.2729937295492713, 0.16117502497716293, -2.6001336532165706},
    {0.1979977289503424, 0.973039039088933, 1.0454512266273397, -0.12351689102981481, 1.0279868411402535, -1.2697742842456752, 0.5877940776707827, 0.06690417798527495, 0.20890336577570834, 0.5879909974267289, 0.9413298086113707, 1.3485335206081281, 2.0899055750145843, -1.5368088967297495, 0.1655371143301112, 2.807480111413381},
    {2.6919739624231305, -0.24866546117927327, 1.9789121596992294, -1.3900983225053078, -0.8694104830575056, -1.7395208798454056, -1.9554565203443939, -0.2756479587542632, -0.2371917571231033, -1.1951418435016807, -0.3764429302815752, -2.0689701263732987, -1.2890728299783922, -0.0676397090817384, -1.0683242343602943, -1.7642847961582995},
    {-1.0403025958734073, 0.27871581214990176, 0.1640904028079736, -0.10977346681060826, -1.6690125700113705, 1.129561775942986, -0.4072720622138455, -1.958898519717033, -0.4227859750782352, 0.00449713223492654, 0.3178158674816098, -0.16556452836312655, -1.104909507686158, -0.0875274684715828, -0.04692642842894672, -2.0267903827021394},
    {0.6681052265649638, -0.9825949687787388, 2.992579053887077, -0.45359328038537183, -0.143205057536203, -0.07159970959758369, 0.7908892011083627, -0.1321579103280932, 0.9025955946361711, 1.5592186835051856, -0.695177274747729, -1.037099233595232, 1.641119081326757, 0.14367823412425007, 2.205538229573819, 2.536510780219967},
    {-1.372139796553157, -0.414869517049301, 2.1372457823829865, -0.6105841622878009, 0.8633254492936262, 4.052989304523287, -0.2484869509469546, 0.22969360560451693, 0.5268887564956847, -1.069722972357906, 0.3425405386144971, -0.7614911985881891, -0.14528805339029932, 0.6014721847870034, 1.3759244411349731, 4.341041094994573},
    {0.29556017710855675, 3.5688454690726807, 2.9081840386096838, -1.1700951094889693, 2.677573998456605, -0.26639387976643153, -0.8672788789706619, 1.2097116266306698, -1.560268323914011, -0.4147793097777786, 4.067068030460318, 0.6749947352443324, 0.10625296753110444, 0.0642687451198809, -0.10411791935662128, 3.3589763827661887},
    {0.029608397610121916, 0.14128892301011642, 1.054055083954323, 1.7035645848141059, 0.6215428080975938, 0.365256254573495, -0.2362024688917806, -2.135731662184186, 0.15993918278286937, -1.1226022512568308, -2.4924838153971827, -1.1713643812884522, -0.15323757818203892, 0.11748383227146021, -0.6911575332144385, -2.0741840453210245},
    {1.3821266765723237, -0.6828404452126445, 1.5375083589132241, -0.3393126848784737, -2.5021851330997595, -2.1690919609464507, 0.935634554000218, 1.4113557202251341, 0.1037505726618585, 0.947039810865968, 0.07955677563860342, -0.717182982240312, -0.5938750412872027, -1.8484161885919832, -0.3321424615736141, -0.26063986615917506},
    {-1.6214629885589025, -0.7608036400349113, 1.7952927177161506, -1.9911694975269014, 0.009913679951431066, -2.063214964300345, 1.4485343563948254, 0.016265736571477663, -2.5673103459376057, -1.9029191538601462, -0.8173141264243199, -0.3263198516782142, 0.2037721406675111, -2.9398889763206317, -0.9559435961927927, 0.7205390425376996},
    {-2.1426649172276955, -2.0382659988161813, 0.6067620462616253, -0.8436911350885462, 0.3983343425855202, -0.7526562030665241, 0.9897639115125485, -0.008549290970754991, -0.36320133725857223, 1.7494305688682694, 2.1934951878194076, -0.9965271419266799, -1.5795051388040302, -0.2587236044433878, -2.001536585781932, 2.3526666514027457},
    {-0.7738596767511502, 1.439789427741578, 0.5346669078831282, -0.9527410240755869, -1.0994163143068474, -1.099748888252968, 0.4053192027798538, -0.8862281108841, -2.4312503064032844, -0.7936172775089554, -0.3689586270678369, -3.178131993949012, -0.030228657911576647, 0.13898367634271855, -0.8677813936193652, -1.6568879025473549},
    {-1.7707000283742576, -1.8471364856821522, 1.9873271336830614, 0.8674734894874048, 2.6440929929540262, 0.4226304092240227, 2.00359523930443, -1.3855123199458312, -1.3356569581756041, 0.9647505890345183, 0.45754471179991635, -1.4415971362583018, 0.19394456538974805, 2.8529918954650095, -0.2415134973663505, -0.2024985942739952},
    {-0.42803243491650594, 1.5861736208168022, -1.86539847110135, 0.16337621606883546, -0.2955321583468424, -1.3043762094500848, -0.6185217723240808, 1.129724062641281, -0.7035455797650771, -0.6531849735917467, -0.15130082794004895, -0.0803000508091939, -1.68875775337175, 0.10068805782371605, 1.0712379223442499, 0.27209985827356553},
    {-0.2526992691316029, -0.730426044711799, -0.1441515955640392, -0.9987905771102857, -3.0570287184792866, -3.260287597376443, 1.7858072769432456, 1.9390799149886975, -0.503304160917088, 1.790326259055202, 0.9931320996164182, 0.5717600471309131, -2.213410380022303, -0.4151600419935907, -3.121646941738109, -2.2562363524631524}
};

static const float b1[16] = {4.601091404007704, 6.305548974263422, 7.106262553524089, 5.1345705436714795, 6.289230909236595, 6.331627200116835, 4.039096013566551, 6.690777986437567, 5.162066584485724, 5.804115820535913, 6.906841620402479, 6.386053187055995, 5.4896018955066, 5.637246592757343, 5.599718475093736, 7.4234861796177345};

static const float w2[16][12] = {
    {-1.1801475788618025, -3.0679760826827107, -4.752808450602496, -1.9493194262629883, -3.8365551687724837, -2.741360618264261, -4.38330139690612, -1.8746288765332815, -2.219822153965804, -5.398832351632844, -2.248067337617781, -3.0361255370282154},
    {-3.8057084413000526, -2.025989768428619, -3.395148322728728, -3.143024587671615, -2.7264457151438215, -4.190845308316825, -2.9535294038117685, -4.584387690575323, -2.8362248946369637, -3.930779523748071, -3.619180774374147, -3.1672850998295767},
    {-3.2421591785977326, -2.57504130106412, -3.133516096911655, -3.807441493841298, -3.6277549006667074, -4.325520525967327, -3.217934477982619, -4.057255868105478, -3.276091480286792, -3.8558133879411938, -3.7726197014849063, -2.384460670303442},
    {-2.8083174275077534, -2.780158690756531, -2.3697641068750204, -3.787501027055228, -2.701616860594536, -2.2230444314448072, -3.6453975936392893, -2.870433350656133, -3.2113280325512243, -1.1607324848681282, -3.3280004590011774, -3.893673502477619},
    {-2.7034072024248617, -2.0302548210574383, -2.969644101394945, -3.3959469244106057, -2.6069520037767604, -3.098148588001714, -3.2614383337689232, -3.3531713992150833, -4.795172199381019, -2.627125657895515, -2.887887043160947, -3.2029680810485917},
    {-3.5628082630738787, -4.922172579933193, -3.938069089818627, -2.085330573896312, -2.6787346363986306, -4.46942465638962, -3.2637276736474767, -3.134301922606442, -3.61577630313715, -4.19205460754711, -3.229884291695009, -3.1737540680832166},
    {-2.4693860489491777, -2.6012921562911493, -3.0735685657489493, -3.506966857121919, -2.0094261205747, -3.6886757518324376, -3.901663907664184, -1.4716114327445284, -4.104445274547846, -4.005470154066988, -3.233994363337252, -4.062346841477484},
    {-4.019904677284464, -4.383885444666086, -2.417288501266775, -3.323853754231348, -2.996412866124003, -2.957211715879424, -2.5938524205756024, -5.07796328276568, -3.934245852371071, -2.518194041933628, -3.56918131730847, -4.268260445166569},
    {-4.46201110580942, -2.688620055770142, -2.344478449141638, -3.6936167184101736, -2.4347434342254273, -3.3862371005432212, -3.0811960524727073, -2.1431685968649883, -4.610803301304471, -4.1866071311127175, -4.128219745014838, -1.840654699910909},
    {-3.7186329738280164, -3.0716119042214194, -3.613471998123966, -1.773243287954319, -2.0445895153496396, -3.4145571656454674, -2.171618857463685, -3.1405141696852574, -3.689342357174739, -3.827856808705561, -2.844628115508075, -2.986550906764586},
    {-3.3147729516951174, -4.6831408546577995, -3.252062622124365, -3.557766490934434, -3.608614662932214, -2.210301686421337, -4.170176757075802, -3.269787766906343, -4.619205479818629, -2.4600750792160766, -4.305383603434402, -2.816244436984468},
    {-2.406040784651383, -2.640414789810253, -4.6561505780368275, -4.508813966953528, -4.64696681180226, -3.938937868863632, -2.905817255861377, -4.094661921794335, -2.7383386829350425, -2.817277200605982, -2.7199610205846034, -3.979849527651937},
    {-5.0994769198506305, -3.836750442257361, -2.45939891561591, -3.2728594101474906, -3.93758016153469, -2.880991683621852, -2.8784399351415964, -1.8789249660915488, -2.031178539711012, -2.9096091852896206, -4.227525453353009, -3.6475071870072404},
    {-3.7656801825521344, -3.0875974002159747, -3.258909568698695, -2.550650612871171, -4.510026782709992, -2.0369505145392197, -2.377198373279199, -2.0507769826749005, -1.2098820405324096, -3.1987972921018133, -1.5106299416764413, -3.0824891833732124},
    {-1.2706351687002586, -3.665439971245767, -2.9037647029201765, -5.217338846125319, -2.2342978689915722, -3.4230091389836206, -4.720197613479867, -5.210905032789233, -3.9179162801418466, -3.361292397842929, -3.7974721441199084, -2.695034105842586},
    {-4.414914653536983, -4.057523569722661, -4.450770512857686, -3.673101332368076, -5.044710016645271, -3.680339273724085, -3.4441824481788914, -3.8925442064580915, -2.5694399401628636, -3.7921292922598537, -2.75715729487303, -4.149303440421089}
};

static const float b2[12] = {-4.610383409599806, -4.4455190773935, -4.434046028201142, -3.776489025372233, -4.761850196435256, -3.9843603083828585, -4.103893115590875, -3.672576863755352, -4.252587458189703, -4.105114153893607, -4.267485920361258, -3.94480378200405};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
