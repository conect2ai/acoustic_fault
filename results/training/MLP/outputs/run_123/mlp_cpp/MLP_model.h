#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.09457149197571726, -0.804634819029846, -2.4711433692301283, -3.0955048751218452, 0.39406008365099, -1.328665128623433, -0.9080499546094823, 1.347255178093525, -2.291802394241523, 1.7876095703921715, 0.23585185472634565, -0.3782199461398096, 0.04604238687417688, -2.248310215114581, -3.6206658510753185, 2.042933796979093},
    {-1.5820870700366587, -1.6219899931999597, -0.44337194111518974, 0.9327036753846281, -4.127821962333855, -1.653706693902674, -0.6830889913805618, 0.2130847743927714, -1.1870169396374737, -3.027244759767661, -3.3887278318248852, -3.4318201267360218, -3.598157723318625, -1.8600240260660779, -1.6266045269644536, -0.11962738061970143},
    {1.0064028543701116, -1.1348882154766144, -2.527596719546369, 2.247072152032466, 0.36109281822132694, -2.0327679052101106, 1.315703705637381, 1.4763792449670163, 0.23328863146848877, 0.18754811660269158, -1.4264635819346425, 1.3669830226711668, -0.5099845020194662, 1.7604095041494698, 2.062743609194859, 0.8456486854569059},
    {2.647592909676783, -0.1321254727859421, -3.876579707252614, 4.477080247361542, 2.560646373862474, 0.2725737302696378, 0.3771992766255936, 0.2738239898592619, 5.388547043856254, 4.737035446282838, 1.413754970587117, 1.8964505823703615, 3.035546257459569, 0.5347129832379495, 4.1302304135656165, 1.2158441545565875},
    {-2.6744019369861514, 1.9133321711053162, -0.6268967906916069, 1.7443358485616742, 0.6468953378742558, 0.32046048415580164, 1.322565347763085, -0.5264816462146724, 3.4485898588745156, 3.026641587596243, -0.660896508916901, 2.5037321719432653, 3.126697357269401, 3.8120713558979835, 4.128317084304261, 0.9510585514429208},
    {-0.8752329666504105, 2.68363923740048, 3.584947847842323, 1.4145552153303962, 2.5450937731296697, 4.602888149446058, 3.6680607178483395, 2.965157028512659, 4.435820119676931, 1.9180460922819056, 0.131204412107503, 3.8764078849488763, 1.4419317566384318, 2.8672286625227166, 5.982395803066586, 4.218428388358709},
    {-0.020877265197812817, 2.590006927807725, 1.3776413083276, -0.25622376209130004, 1.7127824551297266, 2.616498342128574, 3.505156463242624, 0.9151170927542656, 3.109004213943569, 1.2862951822238626, 3.8949226873283838, 4.888823641149859, 1.6095877525521256, 2.755450879098729, 2.4582156135115434, 0.43473064204540324},
    {-2.3463921265419985, -0.0651037692024, 1.2058470866021787, 3.7929566202691394, 2.0182931374221593, -1.121969978086111, 0.06807199400676199, -1.0640517508014482, -1.3357275645567357, -0.6663013636464512, -1.3019202347078236, 1.8947138512290715, 1.6619847866289104, 0.7779369551026237, 0.5999497913546813, 1.5889827792278277},
    {-3.0325304261835853, -2.7600065194192633, -3.09645626661332, -1.2374047818578398, -4.350402219972362, -1.0581320040582542, -2.7288534768482506, -1.2066580194472394, -1.7541083016960701, -0.5412304710744964, -4.779405146731209, -1.098387645803257, -3.264566891649543, -3.759111614815747, -1.666150167163118, -1.4393266844877612},
    {-1.8318642797331735, 0.19040040725875948, 1.3957609244552622, 1.071320672008567, -2.684742604835479, 1.6722092182276307, -1.6687827227180176, 0.9323528403793018, -2.9784803292066506, -5.045286509478818, -1.4398552278852201, -5.723833550457821, -2.186197594687697, -1.0485119102529454, -2.2903069734019743, -1.8619063417509116},
    {0.4837863080119163, 1.3098323446091298, -1.4488736555717432, -2.1690658253899593, -1.4707058815347576, 4.442084119310427, 0.21285260048413304, 0.2090090295403159, 0.37247255766119947, -1.2300040663479404, 0.648752258508225, -4.137090955995513, -3.8083905260990214, -1.2704584859472854, 2.318080571630302, -0.44775125364892837},
    {-1.530687387302634, -1.7832649970912489, -0.869345998640809, -0.581631799759857, -2.5283843962536827, -3.486987616534428, -4.855219464169097, -1.003949665255068, -1.912048327428607, 0.34822466883112263, -0.05839789230478865, -4.246286609144646, -2.2973232885685397, -2.241925838779828, -2.145142321834429, -2.6436999277759625},
    {-1.8749298405588424, -1.241183310545956, -1.2844014202353256, -1.6159940862555688, -2.2070463685983186, -1.617790761691004, -2.1982961627061224, -1.421620268723382, -0.4267192973200914, -3.7045069712486844, -2.6910041732810126, -2.226507193934914, -4.817438744867903, -0.8189392735909992, -1.681794669691734, -2.9041679353164125},
    {-0.9244148677544711, 1.2843935406107847, -1.0883152396141533, -0.9309161477632936, 0.7783454898261315, 5.542729567233932, -1.2784720523225455, 1.484175095591875, 3.1435116376301098, 4.735872327781039, 3.176413231364605, 2.798412623645473, 0.9734931804898678, 1.7846935892294211, 3.758840583012035, -0.998334069776871},
    {2.3092997626068135, -2.0972766875229842, 1.458562971787279, 0.568805067896162, 1.0307949271262742, 1.7950758479294113, 0.04269072642001971, -0.6895682553989838, 4.130901629365102, 2.960890575704305, 2.2178508497276037, 2.740292818338033, 2.4827608666117063, 0.519649268700002, -0.13024856863491313, -0.45367938812019154},
    {-2.0080363275211863, -2.2706250645926733, 0.22617189831416076, -2.050744275398921, -2.296743339891338, -0.818034299018991, -1.2019126197970427, -0.8179257262167617, -0.95324328654519, -2.921278308595642, -1.872070389887832, -0.18579048624671318, -0.957841412917552, -1.737465298029521, -0.8302589990452991, -4.227767116045152},
    {-0.15897924044286418, 2.302417509643128, 2.407140237909087, 0.5754505281088849, -1.0485637018139968, 0.8805171927654124, -2.189278262990981, 1.2558331361647521, 4.432777080464259, 1.666069050533346, 1.2189645860126648, 3.4208198038094304, 3.014200961008971, 1.0396764754905454, 0.42047985673078037, -2.298584567299025},
    {-0.1937184815802522, 1.8812571120820603, 2.759330782105573, -2.4210192365154892, -0.10264746991095573, 2.208453508444963, -2.6005519400874895, 1.2887031867925687, 2.9195912938534176, 1.1727552815417617, 1.5527987321874115, 1.1639878822004066, 0.22651615179708512, 2.459948139631153, 0.10053572061623532, -3.5841675526296366},
    {0.6134741655213932, 1.452592650469935, 0.9291848023355819, 1.7625170451219867, 0.36059692204221067, -0.7042330341105958, 0.7590212554812369, -0.7633725769441144, 1.8499789501915092, 2.6780574155581776, 1.6309723026757437, 2.184113626929266, 1.4428891580520944, 0.5686825782249938, 0.6661236244628048, 1.305953320563873},
    {3.8840573578546342, -0.571482981935661, -2.6396653766608407, 1.4153560690973406, 0.7970781991848221, 0.7437045161865735, -3.163352623635229, -0.548610522892236, 1.0825862455769295, 2.3060504127761905, 1.7387739582268729, -0.2895123235276004, -0.9827168042803017, -1.8987754853500538, -2.821690528063642, -2.145681774684611},
    {2.0416084030768307, -0.07942562033016679, -1.3667740081617286, 1.8549976906678525, 1.683984110966017, -1.0238025240500581, 1.6515715721991917, 2.004720575956293, 3.4880184889123074, 3.3613855728129476, 2.2293197464759165, 3.6144404315204004, 2.4293034110677643, 0.4931478961248696, 2.816960007831284, 0.5653170277357575},
    {2.3769656483725816, 1.5599613903128442, 0.9993970986358722, 1.0147901461810127, 0.9179906019249453, 3.6001642121745716, 0.5305124677204691, 0.3016805541880971, 4.245696968753936, 3.005164302875139, 5.361773987067483, 1.9285555530171206, 4.126834663831474, 3.424031104958793, 0.5126881523275997, 0.6542113251521204},
    {2.6831259273490438, 2.7053810050756835, -0.6154637847708444, 0.27073572006936825, 2.024530081405044, 0.7663153199108498, -1.4491189478636906, 2.420882515127924, 3.252570517428826, 3.253551251153083, 2.882146499990748, 2.2088120073754745, 2.6271967876205142, 0.6545811201444377, 0.6410644717281297, 0.400143013027981},
    {2.238335355658739, 5.111603846927406, 0.05986986220985429, 3.1352467385219938, 3.6866056295305785, -0.28948227268016125, 2.6755398515804263, 2.1218456292943713, 1.4750752052409042, 1.808468221315753, 2.134037145740553, 2.495354710144018, 3.9393664177825887, 3.0459648429876482, 2.6912867253775, 2.808850594875983},
    {2.1406507179790095, 2.692490498666104, -2.0694143352343604, 1.1501328608681227, 1.6087387840878837, 3.91180716611231, 1.4399492448020244, 1.2812965650004877, 1.8935343713677126, 2.561628163448458, 3.8177317810326694, -1.2364390974429216, 1.9055742660509076, -0.07402298047069542, 1.273753466851924, 1.5279055646943114},
    {3.515264937921593, 2.302333691961454, -2.988055124319081, 0.9984208672866973, 2.594020449548011, -1.4147677484212806, 1.3304164331102353, 1.2179903853169625, -0.7593189127313709, 1.0192639760964535, 2.3613519560225686, -0.2454697824969318, 1.179298554212396, -1.1039827131901248, 2.342732906401117, 2.784622952257979},
    {2.9312337136615376, 0.4705876045151249, -1.8257763707001846, -0.08070463537962932, 1.3251869272604695, -0.845815417466799, 0.8728200861340378, 0.17376772526009068, -1.3124613537459064, -0.25084108403257077, 3.8601331871744473, 0.5508231038951665, 1.6427233522184628, 1.1926106680427857, 2.150273071956803, 2.317361602689665},
    {3.0936143602512307, 3.770552575597841, 0.7859327275766594, 1.9117043449958242, 1.5683073821402624, -0.9759268189333453, -0.014214148350890724, -1.7783483958127706, 1.0670845515614686, 0.06571151052814884, 1.6705971998019733, -0.5750596132026712, 3.3992818711261314, 1.1506932536306205, 1.4490350487655814, 2.8729883633410678},
    {2.2959960818879437, 3.6993872125163545, -1.0531363747528644, 1.0774343587779667, 6.275981418992074, 3.754745528720052, -0.9490450469272484, 2.7716247763471786, 1.2806272387700441, 2.8277775740541418, 2.9914897036098784, 2.1678483691250205, 3.9694217206977327, -0.3766668202037413, 3.161705675077585, 2.6744146161131916},
    {-1.482079449027888, -0.9374973684922757, 0.3614867151072472, 2.5097467142266265, 1.1555935477279327, 2.662681526386558, -0.6672123960894266, -0.7735098129438768, 0.4333437614652756, 1.7772182279592161, 1.7274524703767629, 2.302472449556274, 2.9706780946993847, -0.6452452102061189, 2.915435797647637, -1.1513196177059402},
    {1.298418728622487, -1.7935291961845856, -2.221561516709501, -1.572571098771131, 1.8793098152095404, -0.9667202483673807, -2.594865766004117, -0.5636180911246725, -0.6707912284133437, -1.5482446273398682, 0.4553765393160311, -0.7303693562183892, 3.166158838954565, -3.428931083202589, -2.4330535180831148, 0.9855973856956707},
    {0.7456084225843455, 0.5310921393917981, -7.31301589303698, -2.5213388623610538, -0.5373008932805524, -1.522570027938385, -2.5383703121781047, -2.4220076916288025, -2.211141906776506, -1.0021516204334486, 0.11921322158264688, -0.4434461620390879, 0.9228078309502252, -6.183134877700363, -1.4768333699609668, 1.0675373944033753},
    {1.8753563668121886, -0.9092655485909679, -2.0210148721298196, -2.648801457467487, 3.08018345229489, -2.9770673220524393, -1.2715801177237929, 2.1026404051396037, 0.2856188847626897, 0.491872140770661, 1.4587464108633552, 0.5355009088150005, 1.1705641835797873, -1.31064033389218, -3.168517573467833, 0.36654346911132457},
    {-0.6740236815888694, -0.3960424204444026, -2.7011470465989964, -4.17583678388557, 0.22737397910848767, -0.13058192068461885, -1.110105394382079, -0.2942698089354528, -1.597598038443429, 2.077076840580867, -0.26825265816981797, 1.5793081174054207, -1.2821898770486218, -4.471705494187145, -0.1265271652041518, 1.2780175039085149},
    {-0.5963939304580129, -1.5597696487212063, -0.9094564862083647, -2.2644440294627994, 3.349355157805552, -0.08230304600951513, 2.1913130966807506, 0.8540191921626711, 0.8088470672350082, 0.3686616340133149, 0.8535832070958776, 1.9488835539003884, -0.6784472002407751, -1.7265814243295747, -1.2761138228717688, 0.9785210316887318},
    {0.791261369970766, -0.7575843424212448, -2.0011975162418065, -4.466946992268943, 2.8054241977571475, 0.9519491348910505, 1.1944841802824235, 0.44432238686522574, -1.0043570307556935, -0.5205271842288036, -0.1413535696194192, -0.9555657234721474, 0.14157189576023677, -2.0207258440144025, -3.3002143941600792, 2.027687782527761},
    {0.7906354450102515, -1.2054561008259925, 2.9351825265889095, -0.40694848441318554, 2.15505402431707, -0.2987789191023346, -4.066314800353341, 2.7994990455152244, -1.4572513146717094, -0.9281071089954933, 0.3442020284400128, -0.3255240311974637, -0.06947240084377612, -2.4632034143739254, 0.3372071725837753, -2.621471930004802},
    {-2.1504471524114743, 1.9494544174762596, 0.06028219839128668, 1.1623318784758012, 2.412805265168228, -0.370913872922096, 2.2797152891319845, 3.116381638368591, -0.49208597807161375, 0.6154569478810782, 1.7814226522934313, 2.288276342072914, -0.022986097636771115, 1.3147150777652115, 0.5726746522252322, 1.153431711378873},
    {-0.5533187434977554, -2.1608910857916452, -1.9910103922406774, 1.6692836310969055, -1.4107643280912154, -1.3588275338123053, -3.1851352780307973, -2.566053261491238, 2.579011024625566, 2.3112898986472667, -0.3881749523091953, 2.9780842911057075, -1.5859626256800388, -1.6531252816103577, -2.7978300039866717, -1.4180109464917166},
    {-1.6192327173417331, -2.5095700773797724, -1.6439324933388286, -0.17058787489229676, 0.5405683218195636, 0.14823523929280122, -0.5257635435085257, -1.4506946617424836, -0.9476944424741086, 0.39463454672276305, -1.9238737112913746, 3.9397987108303236, -3.20006454017536, -3.8813858112829607, -3.9880165272743024, 0.1963830911544218},
    {0.24688282567311873, 1.1291808092721416, -2.7180978367479147, 1.003897430084118, -3.9629983100788237, -0.3399550633735914, -2.1250711222823058, -0.5090940632258336, -0.6360382846204553, -1.1139667092069316, 0.42277434604407566, -0.3005700428301314, -2.5733372722567935, -2.4641133159699655, -1.889715957253478, -1.510149787636208},
    {-1.354516931077875, -0.47983124635398633, 0.22463221249955073, 1.2466024670338391, -0.0754711491322862, -0.6026814419668519, -1.408439597388849, -1.4375627786306244, 1.9275345501162848, 1.105562985268249, 1.434192214633284, 1.1801995399911676, 0.3641776600699194, -0.28337018981052803, -1.5957337489691463, 0.9784980145776416},
    {0.07177229842544319, -2.3553478134155434, 0.3351765847467054, 1.3427183899527242, -0.08167106481811034, 1.9072000019593955, 1.3108381521432353, 0.8403614012132001, 3.645754986228116, 2.0054158472668235, 0.4891039511377656, 1.2650584771193545, 1.094273778966252, -1.206159173552686, 0.5764299572464624, -0.3036943247259327},
    {1.7112934699248579, 0.23756077311197993, -0.263504753935715, 1.2568214147659689, -3.0081282334579105, 1.0311911452797173, -2.9637385032009824, -2.9107478728021134, 0.16896400816994184, 0.9593945966694062, -1.3568917499774344, -0.17638811238077406, -1.6602023173015261, -0.9744382472763385, 1.1411768227063588, -1.4497084888238738},
    {-0.7118470804988573, -0.511007864854194, -0.6460793774507224, 2.289965794754243, -0.4298003926106149, -0.8228125974601508, 1.4489783125694278, -0.6526052621362248, -0.7179254258228912, -1.30358832423183, -2.048873637603878, 0.5959614486043282, 0.09281289098690197, -0.07508896695815802, 0.4482246288238886, 1.9198469585958404},
    {1.994214226302232, 0.7742012710345629, -0.8340241152324414, 1.3833644824683686, -1.0437962733748678, -0.33644811820135884, 1.566592454022677, 1.2612061299543613, 0.17681718601566407, -0.2034941219190151, 0.06226118981815491, 1.9868642331037585, -4.4126127522481235, -0.6905063711372741, -1.9856973127244926, 1.022550795279671},
    {0.17004061236275975, 0.7469109037627016, -1.7978059265289634, -0.10965852341944801, -2.0881067157511795, 1.1246988591832572, -2.80467601143645, -2.386965422486616, -2.937005064116631, 2.2282236349000257, 3.9722964052641307, 3.2900505815061636, 0.9478305863290468, 0.8338360030255849, -1.290953362750102, -0.017826110070283927},
    {-2.021586736762069, -3.603805535485516, -0.8558667334817079, -0.10872982830222748, 2.030663022277028, -0.48850762922208735, 1.5865951991444613, 0.28972511562331965, -0.4560352609038248, 1.7933574399044647, -2.7794171054890495, -3.0852337059639807, 2.1923942344407554, -2.2995718129583125, 0.10963214091612258, 1.2991123917197558},
    {4.488622926533483, -0.6422572437179349, -1.4954408641223684, -0.27514257378896234, 0.27013316131192106, 0.9686161931740691, 1.4087439427342925, 0.6515915594950328, 0.5014544311300257, -1.0586135243597194, -2.6844179300686926, -1.610499713648045, 0.7666083304902814, 0.9259308440257273, 0.8796922823033108, 0.4090181657030431},
    {-2.2986134526933832, -1.756714116722918, 0.498633821607884, 2.1860719381745017, -2.8197199216563664, -1.9619341094597504, -2.1920570992044643, -0.20385593254467874, -1.5335149548556515, -0.9580368086199604, -3.011287052548352, 2.4115362328515455, 0.345938168117606, 1.1199588218077363, 1.6425369666769143, -0.33738847694670504},
    {-3.701976714544584, -0.4335647961017664, -2.502244282884371, -0.6765548070256462, -0.7121538623084085, -1.9471039500133256, -0.08603553532549482, 3.1429256221647255, 0.12503828579989945, -0.28639555855128035, -2.5384780752656817, -2.749330045714262, -2.373402031118326, -1.5147339213458157, -0.8999364714496313, 1.6826942733521828},
    {-0.08083941774049415, -0.8506530164888183, 0.9647064117176919, -0.1749280762533469, -0.2506189105453579, 0.7222493839331418, -1.6485234984142345, 0.6270255156307305, 0.2634692272285234, -0.2007701482039946, -0.19711652037658914, -0.8998655705193771, 0.4201639682081236, 0.2813513023105901, 2.2852401635099495, -1.8985975271175937},
    {-1.5410239934865717, -3.6088282078195646, -0.8068681314845131, -1.972990540592683, 1.6827205215874386, -1.4584492059234915, -1.7175714505652682, -0.2341039560688417, -0.8255809609795095, -2.3763466668568554, -0.967096720610315, -1.483206222310044, 0.15850743241615098, -1.4219735566365865, -0.8056361680656212, -2.088091694721373},
    {0.39902174623717573, 1.5210910418277768, 2.623874508000881, -3.031143169948122, 1.4213417200047889, 0.4549877671088006, 0.17309139491832246, 1.8391386410921773, 0.2577536722873378, -0.36621804332042546, 0.8690453105345107, -1.7662379947763818, -0.8245484266673274, -0.9347146128020439, -0.9549695062388184, -1.1676826757933823},
    {-3.8864298217681545, -0.4821636262868353, 2.6881588221424972, 2.1529386134691695, -0.9535426347249975, -0.9471333622153277, 0.31048353577124327, -2.7974849551708063, 2.131288967908704, 1.1824211524119648, -1.543584658454839, -1.5066985608146661, 3.1590589205532216, -0.15610917863352206, 2.390128562102951, 0.8731431296429114},
    {-1.7645446180112825, 1.2537755750862194, -1.0262485919812032, 1.4593224870266632, -0.11049792787519132, -1.0756292712884277, 1.8878505320671468, 1.3398086560061995, -1.5811766610704678, 0.04521386342927165, -1.028055381551872, -1.1209715192639316, -0.2004874192347486, -0.12460329981196562, -0.025472874782196182, 0.682137259854372},
    {-1.2130532792597668, 0.0802966850941348, -1.171931743126456, -0.25705868527702314, -1.2031278939556491, 0.304299977567399, -0.8817451684502174, -2.269809496280348, -0.4161660955095529, 2.911025207936848, 1.1401660306284653, 2.7944937706725765, 1.7864385698019476, -0.20524353075733756, -0.4700063192991759, -2.384949263613543},
    {2.323805281616714, -2.0267647650705434, 1.58914547447916, -0.679572282058817, -3.3980775237439493, 2.3575727806741784, -0.7233833612096231, -1.295146144396603, -0.5396594619627866, 0.6778654514497712, -0.26331285587427283, -2.112974855571503, -2.5132572677353573, -0.002843931900874251, 1.7250988813164871, -2.4488170329168115},
    {-1.7536138097761718, -0.7854258263828269, -0.19493273152721477, 1.7445120000735903, 2.8321400471823055, -0.6991636255356075, 0.6720746430198579, 1.574737333811701, 2.5573812410141876, 2.175966011753306, -1.906510213064372, 0.5049765038352243, 2.6595271677838754, -1.187538722589252, -0.9177023388167695, 1.022069803211623},
    {-3.510042038457384, -1.752108287492424, -0.8302322294967801, 0.839672727966668, 2.2292135890124545, -0.6870647442189574, 0.689017509518939, 0.16896889418073086, 1.7561587193439196, 0.7436578959664587, -1.5970639288307806, 2.1390657977176883, 0.7155529749578246, 0.9007468065381942, 0.8030389878444311, -1.327771606065854},
    {-2.8131081881830236, -0.19283110912716797, 0.7784192698084796, -1.1212316523577233, -0.21936669345684057, -0.6514595598849646, -0.7434091473958537, -0.15943876907179155, -0.4329947132949903, -2.1386127848016487, 0.6616223237967815, -0.9085797400532485, 1.0146861295470924, 0.23257478771734094, -1.0934220548280562, -0.3644232406416624},
    {-0.2681965649812918, -1.2121447303120434, 2.4899200744388135, -2.1378590727111724, -0.2166760374388793, -0.045278680819569636, -1.8402406999772827, 0.6741807716544715, 3.665385367477778, -0.3292134193383132, -0.4205180677924941, 1.6257099000947852, -0.6309426351306896, -0.7930436675231082, -0.36174434376216297, 0.21231247143026966},
    {-0.5496578334083876, 2.7929099075252335, -0.7346091412136074, 2.051981556908838, -2.1246302668213692, -0.6308614889532194, -0.43402617190172305, 1.6960058575539332, -2.4684756101746794, -0.7587866162652683, -0.6407803079119764, 2.7817360304276226, -0.14133903453057267, 1.2816741338714963, 1.0803875228153055, -1.54089492735209},
    {2.307399647784708, -1.4521334191343687, 0.24563928614981737, -0.550355082770871, -1.6753443708740268, 2.6590995367326062, 2.461792924401406, -0.8813241219509806, -2.9153209327284806, -1.7652574901066207, 1.9951329229757786, 0.05135250743550388, -0.6741112497928359, 1.0391340480536901, 0.36828819979322575, -0.09597319551472909},
    {2.639604704470505, -2.0021568227706976, 1.561898953914799, 0.8130396258317872, 0.5431524964385948, 2.7693993684448515, 0.2583155295668883, -0.9037633206475902, 2.0077099379351666, 1.3073750816227507, -0.33271959388982253, -0.5730868359659683, -1.8632215505633927, -1.5990542640089151, -3.1787781697840467, 0.6241569011739885},
    {-1.0785283504038383, -0.6922964547107491, -3.660381691439709, 0.03379102245979083, -0.38956678071807466, 0.03663729216490057, 0.8696216151704964, -1.3003951714260793, 2.0350931878439456, 1.4248899220154534, 1.0079129828273388, 1.0763671252834488, -3.2197633685030813, 0.07863820529308112, -1.0322826883648615, -2.104671637423512},
    {0.6684838767478224, 0.1297279793951977, -0.1308656438851417, -0.4447847550157761, 0.23939627194439683, -0.07878120415581569, 0.26323074409301644, 0.07814927328938434, 0.7355178929110616, 1.2299958723526963, 1.4761502568493388, 1.3032563393917016, 0.7743019257568008, 0.4638760148469213, 2.403084730593549, 0.4133818766323893},
    {0.79411016121083, -0.12943960199964377, -2.6890409148359464, -0.3605952559459836, 1.299350953571177, -0.36639578654749655, -1.5182761111998, 0.8554517809746426, 1.8611275378547965, 0.8058093973342499, -1.749532542841388, -1.0169508556274784, 0.5006012845412932, -0.027903991647569786, -0.1500765832876956, -0.6125426557975827},
    {1.5600526881882688, 1.2407825214661818, 2.39669062259855, -2.3115154924065315, 3.4689499110438065, 0.3003253567786142, -1.016185027525161, 2.672435922774846, -0.45289011876730184, -1.5904043018437009, -1.4647542903001534, -2.4074292896017098, -1.828214504504645, -0.6382581554618517, 1.778624388675961, -0.3191702572869441},
    {2.1389004876836997, 4.203553855471269, 1.2356104813257927, -2.516791765301711, 3.2990507249160874, 1.3801697575779899, 2.1040608547491, 1.4160396839150486, -1.2536157115892768, 0.15139520662092001, 1.9559932159787072, -3.3252796324796767, -0.7905402304374389, 0.43427351765631755, -1.4494616885933793, 1.0948873064365083},
    {2.241624169677209, -0.2191974495416819, 0.08765620697125864, -1.5013392225720732, 3.205826146513898, 0.6215812846316989, -0.9531944560077203, 0.45032550852710007, -0.27842993693071333, 1.7643655895913175, 1.0276343448840006, 0.6708161789251479, -0.13157248759895843, -0.5258928401758363, -2.083641982838767, -1.8315707097761573},
    {-1.2658039146782605, -1.2557652751985602, -0.4787434079618107, -0.29311231620340383, 1.0867463518328118, -2.127563996860207, -2.6701171345514045, 0.04615346209046617, -0.15578214757033318, -0.4704118470514666, -0.9902933812554193, 0.9699200045673748, -0.8722263048459227, 0.7017281742264855, 1.5614018583798293, -1.7443401783323538},
    {0.8856616892931971, -0.39342901678124026, 0.09236454223041092, -0.5950846616936585, -1.0202875370584803, 1.0068912995924146, 1.143182737135126, 0.15727105658879564, -1.1387849874710454, -0.23201376969429555, -1.896610370618542, 1.1796561258566278, 0.09152289350415126, -0.7496790811129013, 0.4964220181112063, 1.522734290020502},
    {-0.308713282924082, -2.888058886914519, 0.2643060536113306, 0.5172478270200291, 1.20163063130359, -0.4415304856337314, -1.1108879609239573, -1.972056932583336, 0.7988560835237452, -1.099223295158933, -3.000833570377421, 0.11129336154167585, -0.10299725398602433, -2.037806806432774, -0.16129284829661703, 0.2727223840545707},
    {3.0444194803377154, -0.6348018810656756, 0.39636045627468325, 1.1817377556923512, 0.3255330166006543, -0.6150994903106598, -2.1133603406571453, -1.1446109579880241, -2.011473278662288, -0.09819458584853721, 1.0602022712772319, -1.544987452708789, 3.574869056750084, -0.13785784131127066, 1.606922255182483, -0.5396053972539319},
    {-0.25178799210109454, 2.019368509350549, -0.8290891798294606, -2.1910467059033274, 0.621245502071517, -1.461375698605668, -1.3257675899655896, 0.251899068445944, -0.11813025003486138, 0.8210490867959968, 1.5050746970487225, -1.4387875581119154, 3.4288635092284943, 0.8948700709996641, 2.5293896536470415, 0.2851267856529145},
    {0.51423033397993, 1.3980436148546607, 0.7882107063154936, 2.595233424736311, -0.7993011108307813, -0.4619593933859763, 0.9398918957821916, 0.6476512317722904, -0.8203815226758847, 2.7311124859227816, 1.0988878498404802, 4.10259586097578, -0.36882403894261345, 0.553947582728087, -1.1689580249816, 1.2396092079438654},
    {-3.1209341489446425, 1.1030805286446275, 1.6987548576742637, -1.1143155823274755, -1.2044521398499448, -0.41737488060372946, -1.1589550582537105, 0.12650308229465151, -2.143638216316002, -0.4228079078534601, -1.0225784604829398, 0.9106815029873658, -0.9683809686984665, -0.4735692449616833, -1.7898848897398298, 0.26757473610840277},
    {0.3444690484682802, 1.9766272905141842, 1.5234400704593696, -1.0897180521250986, 2.5193790842602124, 0.036924814477753615, 1.0223417422289878, 0.46321481963826056, -0.5681998773156227, 0.45055986482892185, 1.8908691361276142, -2.0648002217568266, 1.4332344855144628, 0.8339604932074934, 1.1161583004249631, -0.023408541598442228},
    {3.858390955774473, -2.933669112320272, -3.614311106192742, 2.1708168902307072, -2.8705841376838617, 0.3690099799135706, 0.046556653369151504, -0.4684298434645607, 1.0268316217543814, -1.4680875379143705, -1.2060306357348414, 0.820871531394423, -0.8448249265440373, -0.03371607399205622, 0.318389071061382, -0.4361560632270106},
    {-4.367089673193653, -0.06817502177318432, 0.2084434554901024, -3.540924046260815, 0.7578158769870558, 0.28011809322595715, -1.1204572395113195, -0.2193911710362524, -1.241301109248, -2.22519102509957, -0.832836940283651, -0.3707786934203734, -1.7321635368167743, -1.9211307609883965, 0.4711479056610905, -0.28635513673499896},
    {0.6058314503696602, 1.9784934949654231, 0.5737984755545601, 0.6774255304747728, -0.21652262930216018, -0.7661167869146398, -1.4291583954459424, -1.0778197190962264, 2.167812646535492, 2.1608307578286925, 1.7435625364242464, 1.8654865670976295, -0.9379943901122132, 0.6178617490424387, 2.3346703514213165, 0.13736300954646993},
    {2.0046766781179794, 0.3505273052481644, 1.7538670062575192, 0.38901700681332757, -0.8862911102166102, -0.507198314440989, 1.178354058244634, 1.3588140781661322, 2.472416711572856, -0.15997135922221578, 2.5408658276041196, -1.6638675677307475, 0.44382484171786873, 2.1132702518975894, 1.0671634477656176, 0.5443209049434239},
    {0.5163801615010545, -2.211657662159621, -1.0098947900094386, 5.349956185200132, -1.5356803857374821, -2.527877312778354, -0.3427981957546483, 0.3528448916345898, 0.2916412787154794, -2.313733757258757, -3.2160355251192345, -0.7712974926720438, 2.5088262552989313, 0.39477025830713275, 1.0118457451600216, 1.8039909297784218},
    {0.13366049177618813, 0.06026510662761822, -0.5428543947835046, -0.4973860652056956, -0.90739413888425, -1.0326261551594722, 1.687506954867756, 0.22210098047468188, -1.4239401052778657, 0.308770751758862, -1.0637144415580697, 0.3242881983704491, -0.7358186563020324, 1.5659314262820554, -1.7317214140240365, 0.3079803203466864},
    {-2.2147132430311376, 1.4179561543112913, 0.3426654668781735, 0.5925930724815976, 0.561633833235703, -2.174771002237466, -1.6220034616531853, 1.0593953005168883, 2.6653366734443003, 0.549393140503844, -0.5676747942484772, -0.057530775998493065, -0.4240603416814467, -1.7972457204561545, 1.9338575173563062, -0.26291754490778896},
    {1.6989989176783076, 0.05825985521863952, -0.9158465661864337, 0.5542986775068174, 1.789662964349066, -0.7340408981482076, 1.6330802305170757, -2.5217782397871273, -1.0635138657958267, 0.4338027693837919, -0.4348678128828869, 2.244370823872312, -0.18407971987440155, -0.9372281400733706, 0.1923114734278589, 0.19506128370982775},
    {1.003994015008737, -0.38907853956205835, 1.4298050733669063, -1.1725820959834252, 0.5325502002037569, -0.04176151294128924, 0.9680372273440678, 1.0107295360375126, -0.5534190168504713, 0.21106994129893863, 0.6943017064046884, 3.0041306714866955, -2.050723715999823, -0.6079715276940759, 1.2931749154644812, -0.09112889572673631},
    {0.9939212530435952, 0.04967660915419886, -0.820127357385401, -0.11839691112290006, 1.082846561502332, -2.0831910318096125, 0.3477753908270941, 0.19219766209225475, -1.774119905151361, -2.474272086530005, 0.6448468388598881, -0.7625798734842525, -1.76260156722669, -3.4745228615953883, -1.834972410979159, 1.8192377262672272},
    {1.4244416494320804, -0.621144226392069, -0.3296416327443541, -1.3776582499522456, 0.11591145643482005, 0.3015032639371982, 1.0409785109991752, -0.3182937756237628, -1.2184029206701978, -0.14039531480608597, -1.441436804661134, -0.3462484745843044, 0.8306315428621516, -3.104023084104608, -1.6174856272755838, 2.946995074463504},
    {-0.22621935814293642, 1.1532070203306324, -1.8832932944494134, -0.21911419606999866, -1.174028126050884, -1.8040822670345422, -2.477494690314694, 1.39848543134065, -1.7396390844587397, 0.05526843655781129, 1.6401996742854872, -0.7248472262389584, -0.06286241989614669, -3.3288513060225053, -1.7770185415771647, 0.022052163286945817},
    {2.499483682111448, -1.2169426872873255, -6.48469751501971, -1.0219746465122097, -2.4375482151189183, -1.8963998842886165, -1.7043002125123743, -3.8418663623610514, -3.315139922425098, -0.20423611323885485, -3.5765826690215907, -0.17248651448963867, -0.2968289131910023, -4.902524613464271, -0.18352031308820363, 0.9450627463642023},
    {2.1176617380632936, -0.2371087809017058, -2.998323314273456, -0.8800770436447743, 3.7829397047073705, -0.515194909181373, -0.9010934686939404, -0.10775767471729847, -1.377732736597036, 2.2716290872902607, 0.6882828794657068, 1.3873859905584516, 3.270536588840169, -4.337956898971867, -3.452738072883538, 3.624605111727946},
    {0.5160568620358285, 1.008356680562511, -1.6716434232574968, -1.2809586252337237, 1.5104721077262853, 0.5982574282430879, 0.0458854088676127, -0.1297813504874021, 1.6897337648873496, 2.1699111050150477, 0.5006086969681869, -2.1938742852370403, 2.354366221935722, -1.9395794440805765, -1.4974485782935099, 1.7868128178199745},
    {-0.09050696474841387, -1.9665290975736394, -1.4464298454137041, -1.2715649527772805, 3.35029897431683, -1.6544141149346536, -1.5301045661465673, 1.2473359039553413, 2.5205983700432086, 0.11334164321866892, -1.818607620821514, -1.432367144813373, 1.3865044161540572, -2.481918047388151, -1.6010628794414108, -1.7134801487499736},
    {1.0935761985600585, 0.23832400157089564, 0.011609680801950942, -2.0098935744972493, -1.4831401900280718, 1.929309289219498, 1.6948432861049667, 0.10972608127791735, -1.658205357171453, -1.2927685501425772, 0.9684055959704966, -0.4255581510413023, -2.1924523520311485, -2.025041239735904, -1.8470617552233044, 1.0355050869347013},
    {1.7654773562781596, -1.3144961343096926, 0.7710501582509625, -1.5995968307191908, 3.2552855423547036, -2.529734183980219, -2.600884582006177, 0.6852913921233363, -2.826757781019971, -2.638449673182394, -0.5688142441352004, 0.37257742690501067, 2.289112626089028, -1.7712957387686088, -2.069158693111571, -0.17416935231088823},
    {1.516321003896428, -1.36600521028401, -1.4410709002382558, 2.1147122661137265, -0.031096649985539924, 1.0540087657717208, 1.3170389799474636, 1.2004463154762275, -1.0094137312195663, 0.9033760414187582, -0.23932084080013097, 0.7660802987670547, -1.3218060521707384, 1.1718182154527972, 1.1115715596543083, -0.9699102529945991},
    {1.7655916268686171, -0.04007372943030495, -1.7741335588313014, 2.0911692331597567, -2.0670842739716275, -0.3649136860320158, -4.09938560496084, -1.9838913098332036, 1.013964763921569, 1.3701323758013897, -1.9491389232833296, 0.726840672721893, -0.2392223536880936, -0.11102595729398758, -1.747631687278117, -2.597790717834637},
    {-1.199548123642934, -1.3138904364486275, -2.7815303405292084, 1.2065957321238492, -1.648254378793108, -0.943655807156044, -0.3240099200690679, 1.2755575614072512, -1.0077857658302254, 1.8757792184769801, -0.25056277822469847, 2.7324062839342456, 0.6361862784646901, 0.06816801811801719, 1.5207410519868088, -0.8760973026184603},
    {0.7472471600336825, 1.4800412380037549, -0.7656047936282068, -0.18277640957809993, -1.2756975527920296, 1.2553297874230531, -1.7311354877948368, -1.6781004117714016, 2.121392764622706, 1.807501256753784, -0.7324730107699137, 1.4372481543641251, 1.2740573096726546, -0.8410225160074071, 0.2350530198550151, -0.2898860919555431},
    {0.9720300513048662, -0.05034077383552316, 1.441788804243186, 1.716343953227477, 1.050397967361727, -0.7283453798081154, -1.591970857175745, 0.5261917863356823, 1.2751744166428374, 3.0307030504588, 1.9682345852191683, 0.568370681503757, 0.28307500527752244, 0.7004432636262337, -1.3041465798307452, 1.3446931384611307},
    {0.5815562431583424, 0.24824024079436038, -2.9667821168055455, 3.5006195713782655, 2.9361637842574995, -1.5863637312795047, 1.659911468646328, 1.4850650897587545, 2.0898234687018418, 0.4100059548310312, -0.919974693967914, 2.8400165954920484, -1.6417404855022006, -0.8328789260664929, -3.057606556891239, 1.099650989137708},
    {0.08696606702335084, -0.31722622777663495, -0.15850348353390192, 0.6208525958193032, -0.4924372855045044, -0.5918453230139815, -2.0580990066473466, -1.8024911794021221, 1.865025379236669, 0.8616600454727733, -0.367273310465501, -1.173467735250754, -3.314424130136881, -0.6931907690789239, 1.2662044428971204, -1.461326636571412},
    {1.7840240928002942, -3.695871773320892, 0.019222176723157295, 1.4908494596172173, -1.2063736045919702, -1.6423894204428093, 1.7003006174590285, -1.9582670493252767, -0.9260050359791844, -0.8104021643799595, -4.402590639039201, 1.8752984058395432, 1.816493176953946, -0.9731001331003494, 3.32894013329833, 2.375926921079048},
    {2.364681146993554, -0.15907953004604175, -3.3623874787409864, 0.43416697985033764, -1.865942998978409, 0.9396637397481981, -0.02425519082491702, -0.8333131784530394, 1.1372432159660177, -0.39840173032532605, -0.5701642382563412, 0.008500236144762108, -1.72462042557359, -2.0331868779096833, -4.636423596480476, 0.6723257840111565},
    {0.052592477488041474, 3.6918979913864156, 1.6012407860397135, -1.9924142707167904, -0.8771596916743236, -1.4952040430665567, -5.164068757721262, -1.8380037514551864, 0.14043974238721768, 3.813278083510279, 1.9145884441777004, 1.2805412000778353, -1.223923111650085, -1.7099646041527874, 0.030899350265934496, -1.753893873450369},
    {-1.0305008320238287, 1.5301547542991445, -1.213296576240072, -0.1696881878101833, 1.4874396256496325, -0.4749829600513827, 0.7833558105433501, -0.18916291662598464, 1.9473749543411532, 1.6219513103462235, -1.8901712939975914, -0.5132203136492431, 1.7974829812604631, 0.31179511303572754, -4.058746126596885, 1.022007609143465},
    {1.474217735549199, -0.034527129099489656, 0.5544724472059299, -1.5650558024795953, -2.571181903855623, 1.8085699296109452, 0.19385862669189877, 0.3222666668374361, 4.020303545699523, 0.23128802528675138, -1.708676149462533, -2.0246919673512616, 1.4847547814650526, 0.22853222234396697, 2.3454170403774524, -1.396879395696819},
    {-1.06013014104819, -2.2703593165416662, -0.030800405836125824, 0.987508143473157, -4.852347216024226, 0.8306315478523747, 0.31130385181533055, -0.938199468026302, -1.29113605059287, -2.8456863312601746, -0.6524387504406138, -1.0408095861640658, -1.3211743780427774, 0.259007082653053, 1.8453328403434228, -0.8660202823822248},
    {2.550635900043034, 0.7897742955175924, -2.7352058719788617, -1.371368829563069, -1.2270118914589867, 0.6469932492085714, 2.068664942776023, 2.1114819994282796, 0.8536407948157607, -1.9730176534948098, -1.0748723757607528, -2.8508105046160575, 0.44544606229392736, -2.2469230074979936, -0.5064509313695009, 2.433356905315298},
    {-1.8254363196398242, -1.1099585231453761, 1.4235315787291163, 0.7566495459387026, 0.19054335868752859, -0.8831568172188416, 1.4215670112655774, 0.44711910323692977, -1.3924645820590404, -1.1204392504629224, -2.5692628230326147, -1.6205370240440422, 1.575649829449668, 0.2450141200755043, 0.9562097541880377, -0.2608135364384638},
    {-0.1137239990900947, -2.5256059719261814, -0.9935427846387749, 0.12294643989551657, 0.333511162687829, -0.35198177561702504, -1.1264906116977251, 1.9504185221411348, -0.8624301068111618, -1.9673235397222804, -0.31394898864314963, -0.39290037343925616, -0.2502996105346899, 0.4325910289989243, -2.1307984757524316, -2.857716149690761},
    {-1.419632470216444, -0.683315221423969, 2.3105667453814878, 0.02942210069976995, -0.7661107345050499, 2.0094706484134495, -2.1410158258357512, 0.834180966973766, -0.41300742766445997, -0.5805600795975185, -0.6217681719102368, -4.055293544096265, -1.4604166572050612, 0.3587288385851775, 1.3374599991395106, -2.8354119856160094},
    {-4.707095817834971, -0.5153489900305479, -0.09846491486400163, 4.2909788107496745, -1.344129046206166, 1.5112471880761955, -1.748324452835978, -0.15322201285983272, 1.2983916888969753, 1.3073618978024624, -3.079284535630711, -0.952762986134916, 4.066629036774703, -0.8420969794675642, 0.548497404700896, -0.09565015710129257},
    {-0.4992607119520071, 1.7872701117197722, -2.012829704925621, 0.9906546583171263, 1.4263999429399041, -1.3954867849156631, 0.6217227997360933, 0.8820331832342785, -2.0444567584128257, -1.6773453943547907, 0.806201413030008, -2.036486385695613, -0.15379745481566573, -0.44197836512696925, 1.375459020696796, 1.9750882202928728},
    {-0.0025159416690380995, 0.7216565300281288, 0.16285776986578132, -1.2044070589961822, 0.48418343740384934, -0.7437206895856402, -2.2970949221481334, -3.534085934925043, 0.0032930700903357614, 0.548236363735813, 1.4313544431411835, 3.2795887328535027, -0.9205048466302803, -0.15234181581740397, 1.2337897192124783, 0.5163617652824736},
    {2.6975653278246052, 1.484041486504292, -1.2444479850265822, 0.27988130911836334, -1.957930025766638, 1.45205661797666, 0.5012071682972933, -2.124557828657291, -1.8779084783708244, -2.4088882724348593, -2.366442116804436, -3.3361935704432906, -1.6149697121934734, 0.3590357719361182, -1.5843714813529886, -1.2907612154450847},
    {0.32285419960084943, 1.0420634958588526, 0.9126422540358455, 1.4486412034255878, -0.5996539320916111, -0.3733443436508216, 1.940149810177366, 0.865245687154136, 1.048387582726994, 0.2382431373933489, 0.6306178180095352, 0.45384265510699356, 1.3434307355274968, -0.7603995034977376, -0.3046260109480001, 2.0687772984263777},
    {0.32263824249707396, -2.3295350897672535, -1.0339064308019477, -0.997689226281593, 3.0310783604081726, -0.22304022502479492, 1.0622716585590906, 0.6069585131652177, -0.10854393147783506, -0.9059393642207149, -0.57623994013444, 1.74847511969423, 0.10776559661923103, -0.9232646902306468, -0.03594807745019393, -2.405517110223045}
};

static const float b1[16] = {8.12985258548549, 7.02605496654746, 7.166354363851517, 7.498542074377963, 7.219708450699535, 5.589362314995371, 7.701829749914304, 5.490309502814318, 6.9946501574320585, 7.040365538708054, 7.309269301560477, 8.089316839967648, 7.332611321140714, 6.4195262153176005, 6.664585682532386, 6.521035139643814};

static const float w2[16][12] = {
    {-4.876588585281242, -4.231328554805743, -4.706686620473243, -4.343582192963459, -3.926094085995592, -4.3336287968749225, -4.493827420289434, -3.7350843275477885, -3.7729771042545237, -4.066862005639998, -3.868661258600116, -4.8976667906106135},
    {-4.393635356541949, -3.5591749315653796, -3.974101494663829, -2.769570691601309, -3.1919347562399327, -3.6595497962256838, -4.765296842149199, -5.013595278342818, -4.352409554731431, -3.9432996527477746, -2.7896867632458195, -4.674789702796963},
    {-4.087233942147656, -4.630071503445805, -3.3653587961100424, -3.88997945225456, -3.677481188722036, -3.16248856383257, -4.5847387177525105, -2.7237173672345123, -4.155435414334683, -3.8233497872263507, -4.724152346014005, -4.167339751307541},
    {-4.546543463284396, -4.75729736133073, -4.114209435890664, -2.9842247965743685, -5.200752746878811, -3.803658827234552, -4.970909694382502, -4.445549219848702, -3.5959804195347114, -4.7514392103986625, -4.141986958743385, -3.254703194267022},
    {-4.276973448985018, -3.8156503559802224, -3.092147125247712, -2.5345571214184526, -4.106944185404035, -3.96228048181097, -3.3607960018862233, -5.464654381940228, -3.811668257667263, -3.7881913924613153, -3.270496338585375, -4.101430509829065},
    {-2.718214795382344, -1.562268499067218, -3.0793654518330653, -3.8612969798517103, -3.864115856425484, -4.0781812956754795, -3.0304524883602, -5.02312939696371, -4.2230682446737395, -3.791090440547985, -2.2115730489454797, -3.3609723439652837},
    {-5.110823361739375, -5.308726087477966, -4.094050204368057, -3.797599658505299, -3.851577238288834, -3.0174551149854203, -4.659612751928229, -3.538131607027077, -3.375461404869653, -4.03141730922771, -3.7197047461844615, -5.532390692672361},
    {-3.1409786578844354, -3.0100115587988436, -4.281411609987481, -5.458247408357486, -3.639200409393647, -3.4449539321885716, -3.6244741418219184, -2.740076662643034, -3.966765889151439, -3.522064937051651, -4.034545593762332, -1.492839617175087},
    {-3.258307614287222, -3.7482128526323812, -4.777057515781334, -3.539088566373167, -3.951333053630444, -3.3758313754109173, -4.195233395485882, -4.471566170887807, -4.180824996620239, -3.909841143413599, -4.740112568648162, -5.133876697277227},
    {-5.116814745971488, -5.250165040979195, -3.1508581191043397, -4.9205779786296935, -4.460488175752191, -4.392399927145683, -2.9696686182082646, -2.9516593581122144, -3.6974595837194593, -4.77668814482489, -5.599902212524945, -2.6114967059288468},
    {-3.481512294051745, -4.584556723897994, -4.512367121303377, -4.024767487606595, -5.1329244478545, -3.9554859875745416, -4.661523889030718, -3.131673859504206, -3.1080391257917124, -3.9716686546088615, -4.672048030402715, -4.305317132509345},
    {-4.483197799760713, -3.761644137891584, -4.596517715293363, -5.864334164147893, -3.7551154235696376, -4.104498785194683, -4.760427007402156, -5.20494867296293, -4.906967870115057, -3.82185964150434, -4.925633021835093, -5.046035762624332},
    {-4.068036269773717, -3.7138863650750022, -4.727703851749574, -5.634277466152732, -3.7844462604146853, -4.00087739202807, -5.389359092816214, -4.049209176028891, -4.483789219802337, -4.124059407510241, -3.0040515599041475, -5.270884332831068},
    {-2.700624127106578, -3.592840309596975, -4.397250419356976, -3.166751178583659, -3.3459457452474397, -6.384158203940443, -2.165177741981438, -4.339432523435948, -5.352747545577762, -3.5476688984847167, -4.18169648166863, -4.019807861364257},
    {-4.83411896409922, -4.660362737429489, -4.040200507186004, -4.59921730810122, -3.9908006516537817, -3.2693127468565675, -3.924848358669259, -4.111599892452475, -3.3728378180947365, -3.7354857852252796, -4.013455581908253, -3.430141825121413},
    {-2.657497782806098, -3.230553974267839, -3.249246898064322, -3.6359175931243204, -3.982729419064594, -5.549865839641491, -2.4336690966955157, -4.0918468111884785, -4.281820511631602, -4.1786592695910745, -4.6117591242849665, -2.3740253924778876}
};

static const float b2[12] = {-4.659589088342573, -5.125719190621283, -4.930085772862792, -4.696080855941516, -5.324024176553463, -4.730173441441334, -5.036536429850214, -4.747257032741064, -4.610361854763125, -4.691851743153268, -4.6218732533532725, -4.4173939672716465};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
