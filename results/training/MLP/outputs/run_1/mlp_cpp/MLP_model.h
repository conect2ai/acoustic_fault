#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.1487216280422032, -2.1200770286684527, -2.1844573583822187, 1.240325136934655, -1.2571476136878115, -0.415564679536518, -1.7352556675734967, -1.4373590230280882, -1.803599622295315, -0.6302217086095978, -0.4431385669929131, -0.026837876492642604, -0.6308350911798632, -1.8089682219994567, -2.0238253435101288, -0.1785991364661211},
    {0.2599088669137682, 2.034135890998797, 1.7478532226556303, 0.4428704776305146, 0.3890274775600102, -0.6226398136798101, 1.6653755045768617, 0.02431883426039143, 1.8254951182744317, 0.02817927140881088, -0.23788457208791655, 1.7855050240786898, 0.7127066817796434, 1.1166186968842804, 0.505598208580085, 0.07447356019418898},
    {2.381695974859668, -0.7365078819169134, 2.0896161246722302, -0.9889265162285242, -0.8560631216187227, 0.49256961288221474, 1.5677008823610672, 1.8626009872861473, -0.4898307931500668, 1.8690503359107535, 0.8453560085801324, 1.17335414372047, 0.4538006332934591, 1.148866604092742, 1.289228228930595, -0.916719100927521},
    {-0.4295375206803778, -0.44344631987195077, -1.0927382637807381, -2.176423280583672, 0.11740164579762617, -0.6450523985906874, -1.1945602234749204, -0.8426454343670264, -1.457445027969954, -0.9961513733920987, -1.2477321429652033, -0.10071093904456872, -2.4030238624294413, -1.4042735238877706, -1.3085816187263835, -2.904688550509268},
    {1.9825496715999622, 0.4655156728593375, 1.8353863754454383, -0.8229282404029471, 2.0170436502039, 1.942844096502143, 1.834017653122477, 0.8205937967587777, -0.2846230819312312, 1.6853753992554215, 0.9818278122001743, -1.4371896900426422, -0.5422447796025756, 0.9617470320398845, 1.2179787775220374, -1.528329519151003},
    {2.7082903950111894, 1.346492747945211, 2.046014479012565, 1.530145204158586, -0.2318981287148491, 0.71568651473901, 1.3342897390385944, 1.6422450789799534, -0.07913545373392727, 1.7373775657698434, 1.8941505925908444, -1.2930865949663355, 0.19390152546041123, 1.908548134684437, 1.1091229494294104, -0.8003962813464137},
    {1.7423790567104882, 0.6978412980939197, 1.1343613829732477, 1.0099816774389747, -0.52252269840068, 0.7779481712919143, -0.13250855092263666, 1.7411211999319038, 0.9333596445536239, 1.4666497777907772, 0.7987582692592803, -0.363363453773868, -0.4436559294959174, 1.0353254602230952, 0.8676696152456832, -1.056142164854995},
    {1.4201946992979593, -0.6262346789748416, 0.7698194531227375, 0.20422161177277398, -0.5952325981279941, 1.483822742413079, 1.5381550695334647, 0.9939890097654221, 0.0927403737927909, 0.2555655874065141, 0.24121593622094123, -0.20076931474411233, 0.5470449045302462, 0.8546971932341288, 0.679427968017485, -0.3623236063067065},
    {2.2754163565374057, 1.1125820169811054, 0.14210533904505185, 0.17261047561443377, 0.4070391036126328, 1.862784420758408, 1.631582894313322, 1.812838325758243, 0.16951190209788305, 1.3387946416635497, 1.0711373529862565, 0.6893178766398179, 0.10766416377214785, 1.8351895426286176, 1.3345790096391983, -0.707103800578444},
    {-0.42906700963636585, 0.5108700529680265, -0.255157012218476, 1.7223861870283792, -1.4108151128987352, 0.45785634582839674, 0.7252679494404851, -0.004337244564238374, 1.9366502652405058, -0.4278209262309759, 1.3903224748005616, 1.3369637318416976, 1.111835540723891, 0.7016605401515115, 0.8483161068415347, 1.1022160363456464},
    {-0.2703773315591678, 0.2533626753678932, -0.4228088593755549, 0.337355380817103, -0.9556794441104506, 0.8807023570086784, 0.24600417819075207, -0.04844467499358411, -0.06098542348596717, 0.333309673601233, 0.9753351018597187, -0.6394194444711147, -0.6191170869106961, -0.07189831996238095, 1.076259096473754, -0.6642686736647089},
    {-0.7996287810354221, 0.0422575053836323, 0.1038847949190504, 0.3516379027930464, 0.5868667400394216, -0.8952396919659541, 0.7954203503921204, 0.2986493963888713, 0.6526267375096405, 1.0561175394539744, 0.8193505473583756, 1.1748758798003456, 0.43078089024555105, -0.18362744076605955, -0.45897775809686114, 0.42269226257835224},
    {1.207004681374149, 0.5941980418486451, 0.8373040008392746, 1.2798181111229898, -0.9331533108299125, 0.5596490246300952, 0.8994327457919633, 1.8745586485262542, 1.2868681373071804, 1.7257387150748078, 0.5856160959182448, 0.8975388464195501, 2.2427339892371463, 1.5934914673122345, 2.0268683834841936, 2.0207586141370584},
    {0.3694306826304808, 0.7558565873431918, -1.581726838710064, 0.6744200233534196, 0.5198485052736009, -1.4361850317515619, -0.5440139047616837, 0.30666204371541794, -0.8873212649719648, -0.750316900875247, 0.6439828199630954, 0.5628386649723287, -1.1193031864072442, -0.9090605840763111, -0.552286159877668, -1.2580910789965265},
    {-0.00912901018770906, -0.7466243610707303, -1.3132859160123016, 0.40275762209634924, 0.4167540239287105, -1.5174118761886175, -1.6049610076199783, -0.05316293890353624, -1.3608928655540116, -0.29301172353325966, -0.4030777224970681, -0.4030484436498489, -0.22668409015083807, -0.2647586839069622, -1.3456807524242114, 0.12929514926409422},
    {1.6565747841221115, 2.1796028213148584, 0.19307185713062758, 1.1736845382466474, 0.5792441655292697, -0.651535048034822, 0.1429361336433746, 1.2071339019160592, 0.6758749191349335, 0.8195649162086912, 0.0738130649011031, 0.9272152149212343, 1.7859113974751137, 0.9880704450980422, 1.078077654091716, 1.3800225047677874},
    {1.2429628840723308, 1.3556858608162163, -0.12624876187829764, 1.1346825132950533, 0.7485381630054787, -0.4642051869089245, -0.4581977617152254, -0.3138157854388442, -0.33708786386549344, -0.5147561691768673, 0.01467083560911174, -0.02789745257715516, -1.4251003208565047, 0.210486090649016, -0.32521056796096154, -1.2680785615629322},
    {1.0322501201197642, 1.236898716173978, -0.44746648299781855, 0.2607333393266093, 0.2026771476434974, -0.7131010319103135, -0.7211585269186417, -0.09759684992634615, -0.6276865810355471, -0.01232597183413551, 0.2195204814254392, -0.2731171816300175, -1.2881227783771405, 0.06877004622664733, -0.2591996164827629, -0.7391031450837706},
    {0.8095440630025752, 1.2847045052892743, 0.5076901375324637, -0.7838008845959383, 1.4230480681224276, 0.3035248140068933, 0.4172031946102216, 0.5676366308938514, -0.5072214358889603, 0.574716865921814, -1.1314129417459131, -0.3174059636534283, -0.5453118172100511, 0.4201369827999372, 0.2292115950465573, -1.0451433508097445},
    {-0.6142920249527082, -0.4253786251590224, -0.11320076544429496, 1.0205173254421251, 0.12999567227175693, 0.11367226511750203, 0.052055377743046666, -0.8758689760873004, 0.28193130274764655, -0.6394454122680718, -0.6215290420533454, 0.9442094991147951, -0.18996700802181868, -1.1995790492064844, -0.530909402872871, -0.6587645606976127},
    {-0.7400933036803425, -0.8545403168238543, -0.7419766232193697, -1.2131898129547587, -0.0289551254487988, -0.9875931238510484, -1.1566167694117482, -1.4982377761257362, -1.4217681422398885, -1.3690007234743655, -1.9522524354272919, -0.6727106279823163, -2.1820715828437045, -1.7099411740625556, -1.3377137153568306, -1.6010693769427526},
    {-1.6350792235793719, -0.21993541422372365, -1.471602332231104, 0.3953208211671486, 1.0360607246143083, -1.6489977205066808, -2.102672380246664, -1.8966919545953995, -0.032596659974120645, -1.6819848837351143, -1.2775933189879896, -0.7064189230938348, -1.5416886340614537, -2.160387457722165, -1.7571877502168525, -2.0443031281215185},
    {-0.7834889110446122, -0.4449992153915069, -0.641440569791427, -0.34140859679181146, 0.4960237906158959, -1.1332151726452908, -0.8444405652459007, -0.11998171670052454, -0.009134345322264599, -1.3521425693418596, -0.9654435345796121, 0.5141386081785095, 0.7605422999894745, -1.4651530198352631, -0.857948209747152, 0.14593269020499028},
    {-1.4820707886200892, -0.30846629564664374, 0.5756383768822347, 0.09847158062314397, 1.3041975375473907, -0.15313736797617863, 0.023786205267178537, -0.7117502295342855, 1.6970889353077314, -1.4109591094725755, -0.004233336175229424, 0.4153363093294109, 1.0419252484902544, -0.8539008860986024, -0.4690576867567797, -0.46300032580780376},
    {-0.5840626720423776, -1.226104686477637, -0.7681687985528984, 0.16109324069880523, -0.17438637870650295, -0.11988267209239271, -0.6148086017731232, -0.4588657308163444, -0.8954206342138553, -0.9450344369124408, 0.06569417225840841, 0.23694995583826509, -0.8128440417055831, -1.657642769590668, -1.1476370248512744, -0.7082791598499972},
    {-1.6300764179942242, -2.022569063185143, -0.8669697195113659, -1.0315499508187052, -0.15557253239757768, -0.3859849976773719, -1.1601854411969548, -1.4312826662281837, -0.6760769552737859, -1.9066268194688956, -0.6254485218314343, 0.92818737868528, -1.258798697404073, -1.3873141678435075, -1.7169777372943786, -0.33505020455434237},
    {-2.6027752875907537, -1.6903375790805322, -1.478103996556084, 0.6472814926737764, 0.012404457648568094, -0.34970339656294447, -2.240524802464336, -1.394269655098418, -0.2972007865441537, -1.5746979473518148, 0.46927186560050016, 0.5017857943104891, -0.24558545955465078, -1.6267796505011696, -1.0055558173362784, 0.7028586989077491},
    {0.35262262698463476, 0.5614041143628532, 1.5430347332486745, -0.5138866983636609, 1.6625071300711296, 0.8803346655283263, 0.9803207110497514, 1.3613663750213272, 0.8575443639909082, 1.0168248630775456, 0.15482915425205368, 0.18591767202723058, 0.4043661369168189, 0.7929825205136316, 0.9704464587535613, 0.006358924836491083},
    {-1.694504566838942, -0.710970592456415, -1.3208798735388354, -0.33628745604654114, 0.5660245603441658, -0.8876581785596894, -1.385787192091762, -0.5649966830030305, -0.6143240002740326, -1.837275760900289, 1.0857081303530967, -0.0838692694000871, -1.7886948978125186, -1.1851041215215394, -1.6378346393004086, -1.745116377742448},
    {0.2610543359147351, 1.4849103339301915, 0.42128504467884587, -0.5443967565510295, 1.4331156275056727, -0.10113184647246504, 0.17653663922698273, 1.3176353000816547, -0.3873074563924258, 0.7965417317089856, 0.890415059143272, -0.8949332348863887, -0.775493838673103, 0.43625603573388666, 0.011728962164696327, -0.9089562144043118},
    {-0.5528355754078583, -1.3984899209653632, -1.145855051397176, 1.1131809141214453, -1.4923125976556038, -0.5479661691961428, -1.443740705383707, -1.3225905210380742, -2.1924626285879927, -1.296089225519336, -0.3356003587572825, 0.47350913078443363, -1.2578217996855319, -1.1365924059545103, -1.4980451392336855, 0.480414396269415},
    {-0.06473901725630261, -1.4127821597389831, -0.742131407142734, 0.9005818375820892, -1.2921686983251208, 0.87430545337154, -0.3034684136007089, 0.6926303458738846, -1.1752710299748916, -0.7884220608809995, 0.3816154866496066, 1.6189160134989928, -0.28841007404280944, -0.26829987509189146, -0.6423675800984979, 0.6451606664247296},
    {0.42560022069622144, -1.4360441247326254, -0.6144029295253501, 1.3603198978918463, -1.5977627918481476, 0.6650355045734844, -0.14144545930136584, 0.5797083085314688, -1.4243665315210319, -0.15314699892960476, 1.2079275305913082, 1.6974088250346884, 0.6603284884103618, -0.346760448132455, -0.13092384781321142, 1.811230861785946},
    {0.30878823632957936, -1.6340623527241747, -0.9202721874439509, 0.9421639029944648, -1.2249853222453837, 0.15477042042352462, -0.0677312726061966, 0.4302567382101216, -1.187203055021343, -0.5565020931172703, 1.1337189390592863, 1.392062641942719, 0.6462802368233767, -0.21652339557601238, -0.10999398299745151, 1.9332118781379521},
    {0.32924438749512447, -0.6430595589478207, 0.16950004215291772, 1.08069271387906, -0.754452401823079, 0.8397876105331682, 0.3749923542669221, 0.620682871607912, -0.8721887552470833, -0.16047909748628958, 0.5538650031618387, 0.5561316773030731, -0.5503502535014001, 0.20569473207448866, 0.43781560629579264, 1.0665340155657526},
    {-0.010005026595008794, -0.71088484713047, -0.12333845301711067, 0.6795355933034078, -0.654050594129836, 0.4186510751917576, -0.2630078922957286, 0.2803042024118606, -0.020295890684019255, -0.25729032956066933, 0.4029214858959152, 0.5321880477066845, -0.33726583920116143, 0.21521158706246135, -0.5114146099077013, 1.2438238842154443},
    {0.3108694423753609, -0.10094032485836153, -0.014273784853922226, 0.5833835346600997, -1.039659734957867, 0.5364085631998863, -0.15346230461322688, 1.5537576832357887, -0.6492782572692917, -0.1271363325862419, 1.4065652234905412, 0.902037686455261, 0.4316853068780921, 0.7367398348826891, 0.2535268473937467, 1.560368361174594},
    {-0.797820818629932, -1.405937353991398, -1.6194520986284788, -0.38084466441681714, -0.1510707394668326, -0.5041306066354423, -1.1374370030670948, 0.018981568350158285, -0.8428863187083938, -0.690764332714288, -0.20831693686994981, -0.3646132820171529, -0.15892913535451075, -0.9319263189816227, -0.8546641740782461, 0.2678179436886929},
    {-0.22120237769022397, -1.1695298221039137, -1.1393532856618172, -0.46995080146011503, -0.8491553420238512, -0.09900426282940977, -0.540399640140441, 0.08395243450322282, -1.0607862003422683, -0.5968989406115961, 0.06640419375565056, -0.27544370510683325, -0.9166734793362143, -0.18786193286782948, -0.635746160615729, -0.13519669763815173},
    {-0.1380556920469374, -0.34367731743819085, -0.7700238681482581, -0.23854474459606825, -0.2945861043406729, -0.29284951471014226, -0.4753662108572538, -0.16450324411902312, 0.16171510534196365, -0.4980940439406732, 0.019891873565748633, -0.3184060131752023, 0.005790981370739842, -0.25384365878590437, -0.7680985567537686, -0.25420113843475894},
    {-0.2802646714085811, -0.39968015679242236, -0.7621753628693652, 0.7722589989750486, -0.30722422214377626, -0.21994105141860168, 0.09777860328299039, -0.1939431983140105, -0.2648918457914036, -0.33661018903292045, 0.1321683035223972, 0.923300053982296, 0.10388728203556818, -0.40429682492430297, -0.093425542432642, 1.0721611928631258},
    {0.055880323772474524, -0.09025802372945536, 0.0027856035413807304, 0.2559127018300994, -0.18552812100420338, 0.08788248886099512, -0.15596827944931074, 0.36752678435019426, 0.4894187906874527, -0.10623805889754569, 0.350116045945514, 0.07532589849446933, 0.3810726601569786, -0.006425563959623977, -0.2677900656715779, 0.49497130582382454},
    {0.2745278655728894, 0.18868468186801057, -0.6094064130511487, 0.5576361507419213, 0.40743879367549035, -0.052584418883621004, -0.15206256891609965, -0.11698234466869298, 0.024790267761126205, -0.3048792204615944, 1.1624551149998452, 0.8876366377289993, 0.24512995809810237, -0.10454964127367236, -0.14168586374120176, 0.3599580836737421},
    {-0.7325769844171627, -1.2558070103065098, -0.9939341728082596, -0.605905181382064, -0.054236441982916585, -0.3053791988229051, -0.6570263902193995, -0.09811027225639869, 0.29608374044026575, -0.9449194946805478, -1.0672333995507304, -0.9673496882029289, -0.5979892752101901, -0.7528280767897795, -0.9918420231912326, -0.6324398933772304},
    {0.1769135959090503, -0.6175573768713115, -0.007032031068221687, 0.20257567161593787, 0.23402509416474665, 0.5918007639841653, 0.17804785452309355, 0.1308430281404792, -0.2552660447594037, -0.5139863908102632, -0.5525461909035811, 0.45433792577076054, -0.35941288303984, -0.13017246029587, -0.1913937609898339, 0.738521550838791},
    {0.027573998201976344, -0.2380629009236047, -0.1396491600813504, 0.44997898445801104, 0.052362159057266766, 0.4548752039077854, 0.0028794922667147453, 1.2252467165686163, 0.4111000363722521, -0.30487852990090564, 1.1619679442306974, 0.7546199035025091, 0.6839940475699272, 0.22245622804864393, -0.21670734379000986, 0.4198557754363771},
    {-0.20078022013360433, -0.11848857294831128, -0.49823462749517683, -0.8032485549290732, 0.006890446336160009, -0.5774038007350107, -5.48052952521424e-05, -0.577189756413483, -0.9840017161275647, -0.9349013483976367, -0.8840578137528087, -0.20804743533261683, -0.30249092113787707, -0.8852742666209196, -0.7956102316326732, -0.6494573141969183},
    {-0.2449797375726585, -0.43213238997004305, 0.2499124053510788, -0.7918336762960426, -0.735860779315467, -0.16595474101426327, 0.30572966972827226, -0.3251615596414248, -1.7594536307999291, -0.2060694063656067, -0.9642140838242947, -0.5144244844447321, -0.35393660633142643, -0.48139738893255674, 0.0981372016739396, -0.48446844446491427},
    {0.30861178506413456, -0.34160825585096743, -0.7390267747377316, 0.35745222992813064, -0.327054097390347, 0.11372413448022838, 0.8144472384547214, 0.8319000982216266, -0.2407660528604116, -0.0022644183814209923, 0.8561224890365149, 0.43546711221567236, 0.5609125582348634, 0.09546479124549496, 0.15012532829725544, 0.8668459804741162},
    {0.11971724066997544, 0.0762401871116326, 0.3629500472955321, -0.3272889809508592, -0.05334992201248246, -0.06505466181423154, 0.7245715330795581, 0.28483262842800505, -0.609586791278225, 0.196459664565141, -0.2139858668706117, -0.3208663872547734, 0.4875537834977679, -0.25318646672668804, 0.06258704307542635, 0.08360420707610888},
    {0.6841328212731783, 0.31726762127627817, 0.5528294840967773, -0.014811625336352413, -0.253684027770407, -0.050385336175400794, 0.7442940002616679, 0.6012039318947768, 0.8282076891799045, 0.48254149521286116, 0.765686202168586, 0.42312126133138167, 0.8394958674931612, 0.41823564453677864, 0.2513088105072837, 0.012128155419184385},
    {0.6532078555488016, 0.608074764095138, 1.3751772516700713, 0.1163215445536925, 0.5015189626557132, 0.4056767892065071, 0.9144645147299512, 0.6790989144599212, 0.008929916918696485, 0.3739992535039695, 0.4339164426377318, 0.25098306660699715, 0.18037252470685594, 0.6910299052230281, 0.6384916050647281, -0.037452647010994655},
    {0.424834695492286, -0.18647521489028013, 0.28619598789015843, 0.8422122388455601, -0.3484280050698496, 0.6706058831863533, 0.6655259288411308, 0.36069719372077325, -0.37174484058689267, -0.04959031429201086, 0.6859584765274864, 0.736670224668227, 0.09713977582102588, 0.03474080765693851, 0.5667693144821302, 1.3316109070552327},
    {0.38312737908255323, 1.253316583298902, 0.5788982410832983, -0.8622251863203466, 0.6594782024868016, -0.013977304368460624, -0.4063788328456495, 1.3171083438467415, -0.1309458604530295, 0.015975658565367236, 0.3267243859620844, -0.23736745280619503, -1.1571139586881192, 0.7959681131221976, -0.48095065709813484, -0.7959887148786915},
    {0.07109321153657878, 0.3098460858434121, 0.11837326316461755, -0.5009458235789512, -0.04466072176552675, -0.1719657309327355, 0.14827584519781536, 0.5885908111468785, -1.1071492730141854, -0.06771714740059862, -0.0816565473529996, -0.41044608587437725, -1.2837683301823666, -0.039673998782207606, 0.07159820512661867, -0.4902612952348929},
    {0.6049873751767879, 0.5013021217871908, 0.07352481381298126, 0.3912423806269111, 0.6999837314042962, 0.355888889424893, 0.2762476697439584, 0.6157611209251137, -0.10416772712621486, -0.17275140054123825, 0.7493454499735849, 0.6449346829234026, 0.1430536516968633, -0.09253749709650955, 0.41282494232891426, 0.6071182303526842},
    {-0.2072653151302579, -0.5687588496842575, -0.6656561548420111, -0.11144575044833939, -0.6786487464198567, -0.5467530804936306, -0.6782586392761077, -0.08283658630601087, 0.16953797401647416, -0.5960390924279302, 0.19425491241313755, 0.08910410910338964, -0.6918609163306878, -0.2789312570679377, -0.4365460045257999, 0.3675611404112268},
    {-0.6172510534850164, -0.14869319316545887, -1.0387840202918475, -0.05380358162072187, -0.6958853528547784, -0.3215926493551566, -0.766270696448283, 0.5039671298147359, -0.3725897341397452, -0.2646511015274261, 0.7692750720709685, 0.3488770955708303, -0.38235488648715693, -0.21718277967919775, -0.9259888821786902, 0.4145354850692753},
    {0.49686432331136443, -0.21802218541782248, 0.6666820422585904, 0.3648937875198353, -0.13326287075811813, 0.17493895340999877, -0.2717631214617935, 0.4629730512462839, 0.523964682771089, -0.19374202294039836, 0.9125229401686699, 0.8701162733957423, 0.1333874384183822, 0.20953465060988963, -0.3638197425692037, 0.48214575800081694},
    {0.4042483650051542, 0.2781570069768686, 0.21175291477004782, 0.04594494164519161, 0.2597442363636817, 0.21426477016919002, 0.3468995416334464, 0.03728223382359908, -0.09548163750484447, 0.1564505383098012, 0.972933969506366, 7.944666640495295e-05, -0.28695530921588036, 0.2433146018332458, 0.09616972965083274, -0.289686382508836},
    {0.41312757677923106, 0.41174268972578315, 0.46196695070580607, 0.35103169987862975, 0.453525784654443, -0.16831629155850597, 0.41493430808334997, -0.21003462606380746, 0.396009983016482, 0.8766260874186123, 0.1234574895113072, 0.28778902202695616, 0.6518672182971782, 0.24645558049460295, 0.625289159441185, 0.42446503451376466},
    {0.4721757682861569, 0.8409148887643648, 0.6650492842255494, -0.3458515675027592, 0.7349422454848609, 0.5829287593746258, 0.38885514293365964, 0.7485909494510038, -1.0001583186287883, 0.3685822312299162, -0.04695813723370962, -0.31155418444511396, -0.7110425035499629, 0.8211807412646357, 0.4745664818093021, -0.6036954618681704},
    {0.08461594757160992, 0.6894075993748723, 0.16701064186454387, 0.4696916196611935, 0.42765284853884034, -0.09071491872129928, -0.1453127451873856, 0.424691839951209, 0.7038161524510139, 0.600283321205743, 0.2028327653381748, 0.2439534856523305, 0.26093429496537757, -0.020564574490827103, -0.2416256603113136, 0.6172123397426924},
    {0.021932935695680528, 0.14099192517538958, 0.11589229295898144, -0.15884229096458666, 0.4367793655757308, 0.0539809550726308, -0.1723881399649078, -0.22832902238617833, 0.8226811433569692, 0.5927633647978399, 0.324177553911874, -0.13381147632518045, 0.1626044275029755, -0.1804681035545069, 0.2183349443641234, -0.25756402138278006},
    {0.21180578266152092, -0.17564170863706588, 0.35856209131551137, -0.21991035854852514, 0.09083922139316605, -0.114103586815845, 0.2630613496255149, -0.0343917041654651, -0.24646356631700023, 0.20984638585131218, 0.145921903432849, -0.3081153242628635, -0.3600662914562082, 0.221280007060782, 0.38875870267583323, -0.11097245082661907},
    {-0.004705014639081823, 0.13038410157157904, 0.626879838868059, -0.9058490505608164, 0.7530920959059626, 0.4590029968004275, 0.2714798784327181, 0.9710749678898615, -0.7612959027122438, -0.23308502565594486, -0.4751391922182751, -0.8018395387954601, -0.9675361898202041, 0.05081320419315307, 0.020825298325135484, -1.0842174508439189},
    {0.20219660529347652, -0.21512343533943784, -0.10940385737631679, 0.4113344452237389, -0.4290480468351155, 0.36496332193432623, 0.5218775729711415, 0.8698784670159699, 0.09794009078796456, 0.3046638970669813, 0.6647974670664603, 0.22211552780113936, 0.5205520104984722, 0.5338106411030464, 0.3248485881762942, 0.6735739699306414},
    {-0.12314831111203525, -0.17879941205733413, -0.14475987994003278, -0.3528534672355464, 0.05774769036303331, -0.3300831345922669, -0.11673141178792709, -0.6033369139167591, -0.5017433253855169, -0.5546267888848372, -0.6761373142862982, -0.3876374672948549, 0.009704894449123518, -0.35961854338304405, -0.023427450180747385, -0.28084658425573356},
    {-0.4083428929973164, -0.5413908705509524, -0.16828982689497163, -0.7495937865129786, -0.25975422313921237, -0.4614301609225593, -0.6608284251936863, -1.5220797711423435, -0.293527959045295, -0.525521697324761, -1.000810202301033, -0.6802298390117097, -0.5646471915542981, -0.6245450426558252, -0.421317182511269, -0.5838693600581317},
    {-0.3637056677898604, -0.5873041456619861, -0.6151518756538962, 0.2885203076917878, -0.3147267626891704, -0.1958655991357064, -0.40663726442975706, -0.6568040135155554, 0.286871909304879, -0.19618386651658548, -0.22453185864424846, -0.03212511175800013, 0.7944972890578426, -0.5579648137207344, -0.22395988098343547, 0.2570516179668902},
    {-0.21722496806512276, -0.18632385177363447, -0.5457621858428433, -0.06926669267092281, -0.020644468287530904, 0.13398275398649148, 0.06112813149617309, -0.09712268169596129, 0.25318672400246356, 0.030618185449273444, 0.0989254159128682, -0.1088527982954813, 0.32113416740011647, -0.05100059933124887, 0.0889176797648479, -0.013073647212307101},
    {0.2657519040325121, 0.018048551188682614, 0.590384764868599, 0.28991267523280284, -0.19458555251858642, 0.23007786848498818, 0.3550147822163458, 0.38619481018990126, -0.18952704628772973, 0.4722880658512437, 0.5367922781093455, 0.6376043637968424, 0.11053292378865467, 0.18159373599387943, 0.5187531305591528, 0.6602037888843946},
    {0.1733203165162827, 0.48811313767208336, 0.4129062220675461, 0.3684023885956123, 0.5476824191773407, 0.2350254759912643, 0.21559732464071318, 0.2914191187738824, -0.7967474125809186, 0.2735201503399271, -0.45113558800144254, 0.12752936984621688, -0.44810969655778954, -0.103663082882089, 0.08144383401942494, 0.22922389976189844},
    {-0.3384208269069741, -0.1768240596269243, -0.42220880098164554, 0.27885557416844997, -0.04089307204223213, -0.22500919587983706, -0.19434879793034252, -0.535707099959364, 0.7178673109019404, -0.6105165398398991, -0.39383576467316284, -0.17150002356231, 0.10141374808558937, -0.2391843496329299, -0.40976021488797715, 0.6202820719971861},
    {-0.08771390210926339, -0.49984496830929803, -0.3399461882876341, -0.39532847452185965, -0.7267711070226636, -0.4415472352434883, -0.1174617552201764, -0.7432611337200246, -1.4654278983722737, -0.28574845048781383, -0.4906883445675588, -0.7277770349784671, -0.5827441557657648, -0.34341934173612404, 0.21277993085601585, -1.2892660547909567},
    {0.5609969184458844, 0.8588122362849941, 0.047158162868366445, 0.46994567030082657, 0.1337639688135471, 0.5272371855261635, 0.7480446048339005, 1.09333857715619, 0.49106338350899653, 0.7655760083122106, 0.8903803839334138, 0.41183211386729274, 0.24303127486423395, 0.6842688681978678, 0.4517288124219459, 0.5452946843363422},
    {-0.4011619393920892, 0.3493882732413603, 0.07229184275671727, -0.14454641430628473, 0.6424497635809296, 0.01100335940533071, 0.0539479516631485, 0.3606659831852782, 0.8192697027039574, -0.16189914560218885, -0.21500834699223556, -0.32218265230823906, -0.5356480353506755, -0.2752045481485479, -0.4143619661908682, -0.27727523964769346},
    {-0.12210611831709761, -0.058019987717227356, -0.3818263988348958, -0.7418635018712948, 0.05094138158142152, -0.08702996118620757, -0.5425089236437272, 0.12370879314163756, -0.8204767743121409, -0.4104027569602267, 0.324151592132881, -0.2657356078720362, -0.6095470104918497, -0.030503178118449943, -0.49076849546065476, -0.215308142791763},
    {0.40020242635441383, -0.02208690275894004, 0.1473944253701583, 0.32164047488123204, -0.19726140337376447, 0.2510284026784138, 0.03442842817446849, -0.5832653730292477, 0.42289739441132174, 0.05636611933112046, 0.20126070495113454, 0.7180409666943051, 0.4744058267137089, -0.03433601051009426, -0.14208899518820084, 0.7660900517916541},
    {0.028355805886407293, -0.6045729379659606, -0.4706102128531467, 0.4253091025243145, -0.5041023657234325, -0.061655487671864864, 0.07284826446691878, -0.4433087973403027, 1.1379824377859, -0.29234429708742865, 0.19994953116035927, 0.539543728124656, 0.9858708106671272, -0.40574633937096116, -0.5394459423960344, 1.7228228158535224},
    {-0.2198290173511947, -0.3120108161444717, -0.310353417187347, -0.1202675354830578, -0.0851791958606949, -0.3971743087084197, 0.13112888667553013, -0.3163699198771132, 0.4649623389371443, 0.0722546207042156, 0.03368632035961957, -0.05113392335649972, 0.1449560406642057, -0.191236119524252, -0.0466312514397841, -0.17421310518240365},
    {0.4714423094801146, -0.09895555795688142, 0.1572107507963473, 0.03177297325231396, -0.33296378793180853, 0.30234207887064984, 0.13056659321396474, 0.8306475802374791, -0.430283051135363, -0.009448912436837738, 0.8196442119993502, -0.062372954669260565, 0.23008032568725706, 0.4154362262722087, -0.0800041735012309, -0.4070386704561108},
    {0.5638774219740627, 0.329051293750243, 0.38040263389706586, 0.9639995335067839, -0.12298494715568159, 0.6804167176309428, 0.5102240460257537, 0.6188196889181566, 1.4832867125229225, 0.5199167180597264, 1.7797671217290918, 1.029422362271388, 1.3995759874211033, 0.6024299801357307, 0.5500401968079579, 0.7528814765554465},
    {-0.4034934645724764, -0.19492397714458432, 0.003010451995354631, -0.42484837817246185, -0.0642425543953168, -0.8102040023731565, -0.28389577948505845, -0.6759959157165439, -0.1825677113441679, -0.3783519498684604, -0.7001535624702522, -0.1446868034012839, -0.6229859265530421, -0.6063339377225408, -0.20653175751152683, 0.03390578679932671},
    {0.0954165353662129, -0.6212286656544082, 0.1366718800319864, 0.23600733938944954, -0.08698258586228051, -0.3296956712192447, -0.2952622442601966, -0.5961043512664324, -0.22703688827232713, -0.2735349723398841, 0.00511225869510888, 0.25309975361003456, -0.12248775672768973, -0.19491816034186274, 0.098555845678779, 0.26555365134735753},
    {-0.26724392508730355, 0.03367188229320948, 0.07690269129098093, -0.3369653006617327, 0.08336770284992082, 0.04683145374558047, 0.08893084429551189, -0.3829295747136063, -0.6958003050678503, -0.3340021631711058, -0.6216761734648879, -0.31250617529790475, -0.5487671624772725, -0.2964463200888437, -0.04238527273916227, 0.2814845853569946},
    {-0.21980585198693378, 0.18548106149771584, -0.5244332129298657, 0.14049173706842197, 0.00498458398427652, 0.03736109804950143, -0.3606178890269263, 0.15912437125011752, 0.29284243701472196, 0.006146311414236101, -0.03242324700430315, 0.5831462087359098, 0.041247944335472776, -0.2248153792802926, -0.5676088067889794, 1.0720055977834198},
    {-0.2474871521821664, -0.18175465359941492, -0.2308975948272812, -0.24005282948552475, -0.2803382848832406, -0.21528112984844727, 0.11547766024012773, -0.21944451894189035, 0.5844131842439182, -0.08063007935080208, 0.00929943354428185, -0.2944885339415694, 0.2525048173393113, -0.15937434340596726, -0.27464914419965747, -0.03718568386263336},
    {0.30546969780482697, -0.10450302226249948, -0.039857790345090266, 0.11491401896086738, 0.02999231820729932, 0.33786163700093513, 0.4631591470862917, -0.10187891847432883, -0.4354562837186516, 0.16870779946606174, -0.28243943266074567, 0.13960680969559805, 1.0323091031554408, -0.0651134270611483, 0.6439991893098297, 0.16448072131252373},
    {-0.6369150449825393, -0.38795913527545367, 0.019602162387636818, -0.5485130618818271, 0.100040832545762, -0.14723135185786376, 0.1821066500226524, -0.09224292040334948, -0.2558177020855776, -0.3767289883399043, -0.9669485429972552, -0.6649129713909723, -0.30449758826839857, -0.3340900411061267, -0.3683882412833849, -0.5260379455951045},
    {-0.7029472794474895, -1.3685760535994507, -1.295527777315127, 1.7430070987561788, -1.4933418406919206, 0.3302155219027518, -1.172960640772392, -1.1598076535038109, -1.4025157127986017, -1.5852217733165446, -0.25215602594781283, 0.7644696329229566, -1.8038282788215032, 0.667939878647058, -1.7700293606300204, 0.2460937092586758},
    {-0.6036677841644666, -1.3505131048911252, -1.1651262281136454, 1.224248213894673, -1.0965660154799937, 0.16357954482285103, -0.9597140409096397, 0.2721847152430831, -0.8835157683766013, -1.5793671416389548, -0.5763827112546391, 1.3220764761026342, -1.3537552069387648, 0.9946601819924634, -1.3502280349880187, -0.15928778650575093},
    {-0.09462439354938444, -1.0177771787239571, -1.2838321874460843, 0.8551717114816302, -1.1924913597471853, 0.4716686891572359, -0.34214461782826794, 0.4986323140610343, -1.2224749877012657, -0.8593294946565365, 0.41126097349161855, 1.1806833638964476, 0.08712680059814178, -0.28518349939688176, -0.19523322644520472, 1.4734078214227246},
    {0.263020408314662, -0.7316353182912003, -0.8227489291033379, 0.8833528368359109, -0.6694503557200971, 0.2674065215992363, 0.2663268043397509, 0.7120788817627834, -0.5924276455075871, -0.24014315284912224, 1.1195160585022301, 0.7013084436532757, 0.030665594749498367, -0.029692446465149964, 0.1001504738255643, 1.5247885987005052},
    {0.1668873383842092, -0.1084094699847532, -0.4268857755087629, 0.290589092302719, -0.26570563254323065, 0.1336597121606197, 0.05188323513878781, 0.546014282696077, -0.839224785812695, -0.27884095958677985, 0.2435367467300768, 0.6068562353098274, -0.60552910140689, 0.14081339835573814, -0.3546273362379584, 1.065415950193138},
    {0.1065746028058368, -0.5448904091579748, -0.4383869779495476, 0.8614952362477, -0.6778680513954165, -0.16077266616894698, -0.7502355980271729, 0.109475907827334, 0.28867545185146715, -0.6622172527988105, 0.5435219759407953, 0.8292494599616932, -0.09859738462343567, -0.34306664337469583, -0.9969062500012809, 1.599907705947706},
    {0.37863892870314103, 0.057236395733706084, -0.41117845779905426, 0.27111071800760606, -0.5375425856362603, -0.18144633297469473, -0.09385138719754713, 0.8535514430655505, -0.34505573617226953, 0.06881712496479155, 0.5181210490006045, 0.1555367331134807, 0.0094396373016478, 0.46158089176394523, -0.07594815497512314, 0.2614127346716536},
    {0.00844230825459217, -0.6721709251517393, -1.199529695231258, 0.2737613291657526, -0.6006664440967815, -0.30438010969717144, -0.8479749749084133, -0.062277839817558536, -1.310427725679881, -0.7498919600476253, 0.2102208623026666, 0.33659168233532866, -0.6623111385988676, -0.9115013203376728, -1.107399208119475, 0.4203570185153777},
    {0.1456746166093945, -0.4673051845772953, -0.9435230435398068, -0.3400984982924071, -0.7746039902634367, 0.030315250560382947, -0.8156071944562754, 0.7319047639882993, -1.2254144885202845, -0.8959674485639927, 0.2181397396112075, -0.11450539752249092, -0.8369674136426497, 0.5284243595430663, -0.941264336835855, -0.38549773353050193},
    {0.004075012392224154, -0.007930786313605434, -0.4221088038348864, 0.718726868205202, -0.576195628527344, 0.16319006071850914, 0.1944495125038489, 0.5921693502675237, 0.6496363949744275, 0.19803275852309374, 0.7289567022128633, 0.470564134170317, 0.8374444981423502, 0.6915561222436708, -0.012925131368530515, 0.969318186185742},
    {-0.6166943883607948, -1.2829837729039704, -1.0264805938696926, -0.07636723878942595, -1.0845033059961957, -0.12873201325585576, -0.6581495853696145, -0.9516924970397763, -0.8258756858184159, -0.9871551597994611, -0.10485283582311684, -0.11101814341536796, -0.6519605251969245, -0.8863856259036393, -0.9103147129874847, 0.2057108283377023},
    {-0.09490495194502278, -0.2635907741498142, -0.22800313062847374, -0.07671327679132975, -0.06252703730504486, 0.0931634019594016, -0.13931115701845148, 0.2883940873544434, 0.6023737951620867, -0.07494648458068212, 0.07653897759007028, -0.08234637731943834, 0.16087657333249078, 0.0715495356765506, -0.3494735183073077, 0.1837629709242258},
    {-0.10954703696824365, -0.29624131160955197, -0.9767917411958609, 1.284462581281772, -0.15477709415208754, -0.13219011672776163, -0.6110215612686353, -0.044967902962156706, 0.47737485465787943, -0.2692135779499386, 1.0795858796515683, 1.0613043044219999, 0.8528778519762814, -0.2747601253332238, -0.3478959032444831, 1.268399334134607},
    {-0.28387618930879, -0.7325755834648846, -0.4717499087840615, -0.6211440826279768, -0.18814829938886926, -0.028564277669770884, 0.06326272348256287, 0.23597603616246288, 0.16924325974824528, -0.48817857136864057, -0.6115377349984984, -0.683405502552159, -0.464372521953511, -0.4125930893756773, -0.48125384040083324, -0.2764665102409977},
    {-1.0553872499272574, -1.0779487317063257, -0.8437127548448221, -0.3529566969052413, -0.4468357804210208, -0.6271092956685416, -0.2445182059052428, -0.5502322956501525, -0.3432176606153454, -1.127086253283036, -1.3646701161169135, -0.35512792041299207, -0.9886995130293216, -0.7580759581673449, -0.9190186706432909, 0.5858101782971832},
    {-0.13253383196962326, 0.17129980166963107, 0.01446608440638321, 0.8188085860290985, -0.18263324315539084, 0.14239142906789867, -0.48689015090017973, 0.5114074884074487, 0.6927423200446126, -0.4560222064733153, 0.6714513734873139, 0.4316332997576942, 0.3489895080413146, 0.23762356146982208, -0.3376343014347163, 0.02933906120506301},
    {-0.8555300965748079, -0.81371961192988, -0.9300118936113757, 0.3406386911582798, -0.13920174936657442, -0.1453752730496066, -0.21674442677047956, -0.748021876189113, -0.06209709121687193, -0.7681695163258382, -0.20814372335760564, 0.25485492541979404, -0.215509017148956, -0.5726406479317202, -0.3478359053699499, -0.04639792298946675},
    {-0.5657259757220175, -0.14576200943555445, 0.4078728415749626, -0.3418360876069627, 0.053664199751533886, 0.031275893969946775, -0.19488668728960853, -1.0804460783208325, -1.2834163179020477, -0.509013202387042, -0.8910682801598038, -0.20652417539868193, -0.7116045576172966, -0.010371841779786834, 0.28857593619437183, -0.8593990673352778},
    {0.14659516440933645, -0.11418594910418435, -0.04601178478337976, 0.34768376684557445, -0.4168659454215284, 0.27920847182840663, -0.050424308793933635, 0.041625313037954144, 0.143090479033169, 0.11388864866915752, 0.7401131656030366, 0.590771577331013, -0.30993118030259076, 0.32494008176149597, -0.3052617928394166, 0.08149034251548673},
    {-0.257694733983023, -0.636153518441662, -0.21008785099512248, 0.61459030549522, 0.08244134368570491, 0.16676127131087412, 0.8954776502899732, -0.04959494647005703, -0.3969990875786243, -0.4745665888169314, -0.35201382042121554, -0.13692693624811678, 0.2015768971434194, 0.19569986525651872, 0.3045478137613351, 0.4610324272079167},
    {-0.2872946806761068, 0.14062562970972753, -0.12786321407628887, 0.2711729070417019, 0.1393687889564162, 0.3708142874632718, 0.309420653299406, 0.3708500202245205, 0.7537650776052767, 0.19647799317003045, 0.9380049530146244, 0.11916492293330298, 0.9051239267863771, 0.30170487485533276, 0.20003664260471193, 0.1348457403316633},
    {-0.11570373753086571, -0.22161756178417938, 0.134366118376182, -0.20319338260236758, -0.24339600823562724, 0.43592723113367177, -0.024847010351947422, 0.18777049130192988, 0.14120519489398808, -0.09483222576662297, 0.10829823919993734, -0.30670532838633263, 0.045954441301257885, 0.26460816130979076, 0.10486712509593944, -0.34938345478188826},
    {-0.4589789378200162, -1.0042152531666864, -0.33706019388430447, -0.5484376219721357, 0.009246657752464986, -0.10846855335971296, -0.16251066375025822, -0.07490670050898988, -1.1854849468273516, -0.6677409102749081, -0.5217789555199502, -0.4040535595632174, -0.24007758954995131, -0.4365229025435045, 0.06463731013744861, -0.4661310167661808},
    {0.11806946860484378, 0.3507598853811837, 0.8163280062199803, 0.14609008159992187, 0.3166967406237536, 0.5496372788297305, -0.12565317287463812, 0.8471617435207642, -0.16788539757905682, 0.02081889245081704, 0.3474895906140369, 0.09146978377185774, -0.8570324695847717, 0.39068025032277265, 0.17944755375740834, -0.3190407484810113},
    {-0.200258711986264, 0.018683526829301546, -0.45076827221293, -0.5299557729258858, 0.2304862269847459, -0.022453861706622228, -0.3714642073227, -0.1527833608040361, -0.36953555193106563, -0.48316559337382453, -0.13531360133434073, -0.2536172658205127, -0.8484608495346572, -0.18360969882191647, -0.5091907859191482, -0.26844028090844024},
    {-0.3667934093939569, -0.6973568899216375, -0.12690963448556622, 0.3202886062714502, 0.19664731077460162, -0.008204905304035674, -0.1751860481772683, 0.18584839372306652, -0.6077979553085942, -0.40710763303076175, 0.2584308107564327, 0.09642339005511683, -0.4653226273480309, -0.21300434149228967, 0.05452213976020134, 0.21449550047520832},
    {-0.42715472098389246, -0.5833828574082083, -0.7869415620155771, 0.486092316359104, -0.5686509600484979, -0.09568946126222276, -0.48381814680246665, -0.1850109709475381, 0.19236733093478625, -0.31128559540318435, 0.5798190875112437, 0.3112011892538718, -0.30212066882279426, -0.20953343658321621, -0.5799023681398829, 0.9017821866816953},
    {-0.34077430839557915, 0.07071769527120857, -0.09272252764135983, -0.09379161802476718, -0.38944914316942647, -0.05278228280617687, -0.06245364810805148, 0.523750225269647, 0.17999623130839595, 0.06475458713522053, 0.5223475470840686, 0.17673906521302649, -0.23667938508468955, -0.11557808321857917, -0.3260886595401293, 0.6525710895924514},
    {-0.19577242512364096, -0.015965732676263476, 0.7182102766827781, -0.23561085238394772, 0.5892753561720349, -0.41168966683602615, -0.690130494874813, -0.32577674519731853, 0.5203993668783877, -0.10377414962085003, -0.7229799136764979, -0.13181596817260294, -0.6145499335010676, -0.205317243055294, -0.33719110037659084, -0.35255639263212324},
    {0.7178731831776248, 0.5716804134491384, 0.523355020944174, -0.057546785868887146, 0.2324121552719078, 0.10184678190598345, 0.026376277664475575, 0.28009451866063106, 0.342524844172367, 0.08740875130529561, 0.4107442160348231, 0.36013861783001794, -0.22757748293051255, 0.6935289820969859, 0.14408040696435997, -0.3931998722518354}
};

static const float b1[16] = {3.1704597229922906, 2.953111956202905, 2.8610640717060503, 3.8984838028847326, 2.919350114066122, 3.125729980186236, 2.891190650414355, 3.125228125566136, 3.0255427229719007, 2.89656570192987, 3.6132864441247, 3.346227497333582, 3.2132130030008574, 2.85783580045942, 2.6568601155039797, 4.029291406113599};

static const float w2[16][12] = {
    {-1.3480053429823429, -1.6738786289930372, -2.0347020707720773, -2.7001490452402943, -1.3762863973040795, -1.0987488186971346, -0.7315888877711307, -2.133733922234516, -2.0700756561498164, -1.8587708996906536, -2.4644462903495614, -2.114382826362563},
    {-0.8731552657739531, -1.3769558591655369, -2.0883403364047166, -1.7380101963724417, -1.668361516599126, -1.7714311666576932, -1.722012165263468, -1.7284472029205264, -2.2893009894948615, -2.312136858300156, -1.9659622717622927, -1.850422302340905},
    {-2.0141041828817174, -1.6510184950666387, -2.2897697199752183, -1.8310700969057827, -1.2907800176454456, -2.2519182894939695, -2.0801715995467625, -1.7582696191714167, -2.716845935643725, -1.5174761655925595, -1.2473217896472406, -1.1218014055590122},
    {-1.8342412669811283, -0.343951231320264, -2.0871756493849243, -2.7335965398424182, -2.641839109387651, -1.4832504022661137, -2.40327005995628, -3.155316837560946, -2.2925633220305386, -2.165495641678958, -2.0264570251825256, -2.6694627392796693},
    {-2.258806685636731, -1.5864007222832415, -0.7627972531002462, -1.6735309158691496, -1.628101325685428, -1.5205670384256373, -1.574303268940494, -1.3969327831605984, -1.2008870248188448, -1.5390737576872058, -1.909569570400569, -2.206917791089882},
    {-2.003289229086936, -1.6018471795102371, -1.8759374099909194, -1.10221193538421, -2.325123514920246, -1.9144379706838694, -0.29203814446981086, -1.6282004478612546, -2.4608261295873755, -2.6628111240572956, -0.29405999067158234, -1.8976716032790295},
    {-1.7699330564832954, -1.219726643410352, -1.3338567867729807, -1.4968620470144625, -1.4263789917215266, -1.404631971910001, -1.6343025718034292, -2.473034302160671, -1.7921035471886702, -2.3773756128929864, -1.8085267752084353, -0.737052071572464},
    {-1.7200273545456635, -2.3582921333489817, -1.9923782742408933, -1.5371268252979933, -1.4616441156616367, -1.951460507940854, -1.7466304758813131, -1.9724981551934095, -1.3968221703818355, -1.0077515479489516, -2.6745996099179425, -1.6106569493428686},
    {-1.4068175972210601, -2.120996501188211, -2.1653286961819416, -1.4142795400090271, -1.7800466073564205, -1.5245386799099654, -1.685419260029871, -2.1211898067689456, -1.77554583137758, -2.0490579014718313, -1.3855304515486437, -1.8084532343690662},
    {-2.6245902126377274, -1.571619299220743, -1.7849960986281004, -1.484022977879259, -1.9642093060350594, -1.9356009858600738, -1.420806075499566, -1.6070889177504881, -1.81404312833647, -0.3409398244126054, -2.4804292428054096, -1.3190096275908998},
    {-2.2055114603291637, -1.7513806082615555, -1.0361035540220844, -2.1464976091235703, -1.8966811194714726, -2.4920878084149916, -2.2646937260414903, -2.487517376667025, -2.9688545936324804, -2.028590763829463, -1.6249267060745765, -1.7133082492141627},
    {-1.6539935134106412, -2.6759561048184324, -2.5905070839483613, -1.339314495848504, -2.23756801125312, -1.3624441066967452, -1.9548947284951486, -2.20079962972411, 0.00394541787587582, -2.5591456851798795, -2.18771509667519, -0.6837282754993327},
    {-2.0200390669212718, -1.9259180997992793, -2.344309603582762, -1.737704460117327, -1.313002762060907, -2.1359590983776533, -2.0577837872126943, -1.0703593819689499, -1.8990581690510537, -1.6467933054620374, -2.2677939432792105, -1.8500800964678588},
    {-1.797032630228888, -1.4942294260662814, -1.7209022128865377, -1.8618913148155138, -1.8359984989196954, -0.621139448567735, -2.999453028302032, -0.6755411730288419, -1.3834386313428773, -2.311790040124545, -1.2370648072622126, -2.4385792528225023},
    {-0.7737773512936341, -2.6670248665238434, -1.9251050956942293, -1.0568707330976193, -1.743437480552323, -1.8395281141555988, -1.4894044755914992, -1.422153255490462, -1.5724057061408174, -1.219769420048019, -1.5141196927746414, -2.022206838973299},
    {-2.1097954512346915, -2.631414209458568, -2.301542748076664, -1.8285673261546773, -1.5145852638680555, -2.440781786328279, -2.3840726125525964, -1.0509673125138987, -2.7875146247439173, -1.524509133002562, -1.7082801925399593, -2.2710227109973}
};

static const float b2[12] = {-1.4046323973334178, -1.5022347260629958, -0.6970185083029259, -2.6117282645314512, -1.670446787732676, -1.6570734852348759, -1.1778802553682939, -1.2798019452295741, -1.565268240141308, -1.0228416374594327, -0.7477026350216089, -1.4817345521925258};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
