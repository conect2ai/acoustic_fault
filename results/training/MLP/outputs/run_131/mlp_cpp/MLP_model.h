#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.6053232643845725, 0.7405218426045513, 0.8306890751604402, 0.3150037160705182, 0.21696382155813063, -0.4893703019557981, 0.19907489738380565, 1.2104516300233565, 2.5017116654244744, -0.8186812017458435, 0.03984539193693296, 1.2979061708795108, 0.9933356198526189, -1.5228350850397163, 1.5019376288461541, 0.7471398815275219},
    {-0.2830420061369412, -2.1001346226642696, 0.8078972859938097, -0.23562777183501907, -0.6295357928141156, 1.171490858021107, -0.0784385551930447, -1.3012674576170382, -0.4014524418322475, 0.09486143171812653, 0.1801678438124894, 0.2773060723347449, -1.1505799188970731, 1.3053841656087797, -0.11161418070664503, -0.25115587778120635},
    {-0.26783539987785737, 0.6376922217366322, 0.2812520745414778, -1.1891195760781579, -0.5000451803549508, 0.33761676425099946, 0.1490199433910652, -1.3675840448249408, -2.0792173743514537, 0.9657116281616998, -0.7978905342104856, 1.3955589417322973, -0.4316949504422925, -0.34910160265516743, -1.346558712062324, -0.7776012506972345},
    {-1.000328267048291, 0.9496942720060362, -0.03906952771110407, -1.2492132900180202, -0.4313153517379944, -0.6957544366961034, 0.26468811961383726, -0.34466010568541755, -1.8903240256212914, 0.09045711607785525, -0.5927342935030815, 1.167879202362557, -0.46157560551563803, -1.3752409479292411, 1.1116562490692286, 0.023900191687620788},
    {-1.3414250743538443, 0.2399181997861131, -2.016990607752754, -0.15293441572143815, -0.992900882942596, -1.0579192665925314, -0.2227338193263761, -0.5558295456970237, -2.011937709106378, 0.7076717253519121, -0.7056199686000066, -0.16378702815627041, -1.473007204626865, 0.3418081045314486, -0.5018692658934568, -0.6198746144278585},
    {0.894830301860964, 1.162697331890202, -0.46335867190589336, 0.19158566402143176, 0.8374042586514336, 0.2823933778044212, 0.5506715716747828, 1.22587415686141, -0.41689099963659, 1.5464819942727615, -1.156049185716464, 0.9671526248156119, -0.7278515951966492, 1.9689717193438654, 1.1055775314350016, 0.8856809657484663},
    {1.3572408070043365, 1.4704306217805918, -0.02627848170059866, 0.07771662985725449, 1.5139743413989426, -0.11730606885815113, 0.8049275861474425, 0.5465431463776564, -0.9827760499067788, 1.3034212323711363, -0.7470057342332972, 1.2585182927590122, -0.2898725699368619, 0.8696483759087368, 0.8389611588798837, 0.7255729573493593},
    {-0.5675272120476959, -0.28753976263826114, -0.5320920006571176, 0.24925188200801301, -0.8143211425532223, 0.37780579874901093, -0.14807216501119772, 0.018946942893167364, -0.5874478949600233, 1.0075535747772661, -0.11459676718618432, 0.45930822359847084, -0.5574296558120126, 0.09638928796056277, 0.5783849638723007, 0.10757667347312076},
    {0.04893600868087802, -0.19958177374782834, 0.151646935487953, -0.08417493798146189, 0.4850748794905275, 1.34975562987945, 1.0614767769855489, 0.1438047686887938, -0.013520274987951319, 1.3575297662829413, 1.341202858369599, 1.394559819860621, -1.266589862873013, -0.5076564887372662, 1.0303589888749813, 1.1707519161206474},
    {1.6813097557272882, -0.5141971559049956, 1.903280236839112, 2.0804569186263446, 1.77188652900264, 2.131852409600442, 0.027381244309607883, 0.7531462254123735, 1.3827039940903054, -0.19221537984292916, 0.42819359422297876, 0.7693481934459053, 0.24280301623771489, 0.9117467713721661, 1.0330770217142409, 1.7351814762758897},
    {0.21622126978498926, -0.5725613608628466, -0.7249107036800778, 0.009545879176637672, 0.17357857376796687, -0.7023071263730858, -0.8608144569706847, -1.0004908590333683, -1.287144799069987, -0.7312360333425449, -0.9650295350006378, -1.030333389575808, -0.3917239242422629, -0.05651713736933435, -0.16751105363067853, 0.29275665724294053},
    {0.1715244373632376, 0.6156383807145317, 1.1510561187989001, -0.49374515483661846, 0.5504228975175975, 1.0228451261631448, -0.14041802503603687, -0.8321914509014496, 0.18185777449346813, -1.0298272423125352, 0.33581099665338104, 1.0150432433437873, 0.25740543624779194, 0.11880399299469514, 0.9803725703550717, 0.03359978322973316},
    {1.7589624993886719, -0.3495269973008089, 0.2332715376330518, 0.15494175786125544, 1.0448167960659454, 1.2522553455376164, 0.5496793369354321, -0.963903371720464, 0.7023472090137238, 0.017497040582034006, 0.6332155969963904, -0.11214696825040293, 0.9173692999018889, 0.08045106292675279, -0.907577580103879, 0.5231947721355039},
    {0.7781574431746746, 0.33850586196328936, 1.0835593982865113, -0.8337894437428465, 1.2509654992290955, -0.13339323524203475, 0.5135550947548986, 0.9728731146384649, -0.045916574999310435, 0.017797092689406126, -0.620609265136158, -0.08270294361808019, 0.0728780978868894, 0.6382717214894877, 1.494468847947052, 1.2757412317763348},
    {0.8679223757092144, 1.8025362954549566, 0.3357462085309111, -0.5567975298129206, 1.4970058133466144, -0.4691265511822366, 1.466491379240834, 1.2795481127270252, 1.6623788737906438, 1.0647771876428818, 0.14964099405743472, 0.11321663289200014, 1.798093103413098, 0.2848439791097674, 1.7310785966724425, 0.08265329006513136},
    {1.4387803657850609, -0.4758874114878513, 0.07746363490588669, -0.9742615010683847, 1.1012534021587488, 0.1878676458106574, 1.3740198188819959, -0.0622925582283049, 1.4101882727204635, 1.1145559247607089, 0.4846894884458512, -0.2749174050815814, 0.7748118551521089, 1.1139282076113655, 0.13867542639026362, 0.5535649365429666},
    {0.4881408527510139, 0.5142568095742, 0.6160769821973219, -0.20334703717025834, 1.2030270952901418, -0.3545267505078436, 0.7177277727602867, 0.9748162044515499, 0.012289965537793728, 0.7313887374509848, -0.5821214798710601, 0.22919390458031616, -0.05449505634806572, 0.9543708187761748, 1.153930766300041, 0.8146717150581745},
    {-0.3269624074331336, -0.49609495953189964, -0.6742962976437401, -1.2213426407952546, 0.22091849466616817, -0.6047964595206023, 0.2748307142992381, -0.43377296639193114, -1.3635264354164738, -0.288716631198725, -1.3908877287931916, -0.1868753599694345, -0.8784516927979611, -0.7375302169472957, 0.1219782682959525, 0.05039228191345259},
    {-0.9621166400369022, -0.37918988971881235, -1.4878629799759184, -1.5333840101715426, -1.0003041295143302, -0.3808198257823841, -0.015194925119602467, -0.6361914396984278, -1.3820204176791644, 0.6302645274607166, -0.2677343692100823, -0.08732488552236968, -1.002940241754182, -0.4122883363451853, -0.4803276121601808, -1.1796921062800207},
    {-0.539913634030837, 0.37688320699510314, 0.560702262952274, 0.08375429890895605, -0.08343070472777758, -0.46509605917114083, 0.038786581206375126, 0.03181685692643631, -0.4651732413820887, 0.004552583233430464, -0.531709172270744, 0.3472070578386572, 0.6691350847710912, -0.07759590446883191, 1.1220861251591052, 0.5208742270790696},
    {-1.3625678349486894, 0.11453191525207537, -0.1242855615779614, -1.0062709378501775, -0.6868551174398754, -1.0778496864400868, -0.07749442587965158, 0.2038767109332985, -0.7009177709036004, 0.35683791774263, -0.06761692430929074, -0.5712726668652177, 0.42500921815037346, -0.6468388364832115, 0.5021395540412488, -0.8538208988476376},
    {0.1868985721671984, 0.16431490097022153, -0.0531530435081203, -0.3464375676805146, -0.2169819518806909, -1.1547608339329205, -0.34783632534192455, 1.097529660584012, -0.5748569656193768, -0.3066265813014398, -0.13050948282043556, -1.3267543389474297, 0.7811120109501741, 0.46107634030152844, 1.482260469636623, -0.010658498282594861},
    {-0.6019411670268189, 0.3524388062467426, 0.22793231482935766, -1.5293664559481088, -1.0267276104847, -1.3458504897537251, -0.7817696057599427, -0.47172502756536655, -0.5908962585851799, 0.48789075257685627, -0.639570099690344, -1.2626840268432005, 1.7106103414776104, -0.44614690025061043, -0.4436995863465419, -1.4664833933725383},
    {-0.5769084161374605, -0.09427256259180444, 0.15479778956755388, 0.6132829646440193, -1.0395672865766736, -0.3258171455155637, -0.9777943509736539, 1.2430875135769617, -0.5327320556488933, -0.6530167463919357, 0.6247025939897491, -0.33342081210558927, 0.7952893963588793, 1.1137789145939898, 0.33354319650614, -0.5006968101902172},
    {-0.0049487396897437315, 0.39563141225512327, 1.2885966171621834, 1.1382833661115186, 0.25242040379821, -0.2896745752260905, 0.34471632856482953, 1.6043072192589356, 0.08664717888223229, -0.4239773171709691, -0.04870581290378487, 0.34203669256117897, 0.8218846895389104, 0.4836751784559932, 0.4323866097273338, 0.49920883715528785},
    {-1.3589193094517147, -0.21416472281917293, 0.37989278565317613, 0.13851020506032932, -1.6523191845234708, -0.4547276352111401, -0.693744610708148, 0.23926482963403065, -0.993820554587297, -0.8994983130522171, -0.3383756133830248, -0.27016316594724926, 0.33414115539917477, -1.5602390458809166, -0.7151940915243078, -1.09482812015163},
    {-0.2855579169425099, -0.008487373185857903, 0.4404457255478684, 1.2277279601950277, 0.01784685865691619, -1.0385141956795692, -0.09425385202954031, 0.19887655774140786, 0.13598210906022382, -1.2521630154318009, 0.36263611070227364, -1.1989635880871201, 1.3238254394437112, -0.4159588415909677, -0.15904487315104573, 0.13475429410421802},
    {-0.3579579741188714, -0.4349311834000065, -0.8314793540399666, -0.34169117073259636, -1.9824685288424415, -0.6545297207892765, -0.1627644274562715, -0.8439397892106637, -1.3954290915794147, -0.5713836268742591, -0.34685316753256457, -1.2498179318202502, -0.2900026693440251, -0.4485893066134064, -1.4295252493230959, -1.8986758363521241},
    {-0.5819878747446384, 0.5050637881950029, 0.8657982489494468, -0.18784272889630382, 0.0524837485992531, -0.46422890270635936, -0.8833734271734669, 0.866904472536175, -0.9472191608056366, -0.5970770724359185, -0.4282397253566211, -0.772373427563942, 0.5762511155938141, 0.13453877390387267, 0.5624976898296388, -0.3351400621630208},
    {-0.630127171719483, -0.19767523003755516, -1.3182637602284257, -0.6636454809520538, -0.6535451405041794, -0.9656084091818126, 0.2631906611215302, -0.03112375727253605, -1.3545026833336473, -0.12462607305788284, -0.30314596262066595, -1.0053993545207236, -1.025050996029801, 0.19972022606608247, -0.33331821799244926, -1.4004039631484286},
    {0.2289303225407717, -1.1728532808828698, 0.6673663751624405, 0.2964576668478447, -1.4496171998936183, -0.9778634213385875, 0.3846116390673474, 0.8442100519827197, 0.6439519055539159, -0.9862323853113548, -1.3418065199038682, -0.4784997795680898, 0.012113897778433434, -1.8427429518637957, 0.16086427987828567, -0.30870833718736607},
    {0.5646711687181154, -0.7582163975705148, 1.3710437681288945, 0.5154607367365883, -0.8590757716228189, 0.6881828498910015, 0.6701000370312329, 0.721606611346059, 0.4948313513168378, -0.546195315420322, -0.49050913470711865, -0.23608025803718538, 1.0844657712823411, -1.9215262712863743, 0.9473476186683509, 0.37465757795728705},
    {0.7868008301072927, 0.017093333882885246, 1.9479420877031932, 1.281648630936953, 0.842513709643685, 0.563997384046739, 0.21884056473932814, 1.2162891813361056, 1.1747545288805565, -0.5054404118854878, 0.5876284100155891, 0.8182774233283495, 1.3833729665111119, -0.3872623111301504, 0.2630351663039382, 0.7473942652156502},
    {0.895033887562799, -0.3481323582604821, 1.402126358971613, 0.8352011871801205, 0.20219844836268194, 0.7800308609689943, 0.47153457593996295, 1.1911666655908288, 1.121804776695269, -0.17653473067413464, -0.29536358843450383, 0.6013490909937925, 1.1339680497986149, -0.1611486385913954, 0.22357992382839917, 0.3072179636709942},
    {-0.0008538837450543778, -0.734783395968946, 0.1958030600505997, 0.45120756018403246, -0.4231701108104999, -0.6259224024407127, 0.09486961801404309, -0.08100059116554302, -0.23558760571566015, 0.16897931657226276, -0.8667049449260373, 0.028792610897207232, 0.11982182302964309, -0.785790194865833, -0.38984567780079615, -0.3582247176478661},
    {0.13069597962853485, -0.233195216738278, 0.3403731956312556, 0.45234694594795105, -0.28505852949734467, -0.6007008736017215, 0.04417299752019146, -0.2030243601251301, 0.4285500304486688, -0.11792139788079171, -0.46522918435361577, -0.07276908933340537, -0.20805609099719008, -0.45786721672102043, -0.5224878592784813, -0.21685422761819523},
    {0.9709454804948533, -0.0024381911305485357, 0.9351315076602545, 0.9758849945760167, 0.4304562347668342, 0.4961814531713599, 0.7465094629802489, 0.49366721240205413, 0.6891618533885465, -0.38945907845938454, 0.22665325557702265, -0.05231967098740959, 0.3392457773580304, -0.3530519556063677, 0.13908297442828227, 0.2898557843550675},
    {-0.20707865195071617, 0.21428152658962485, -0.5654946383238292, -0.5551721127597068, -0.5158505301685273, -1.0397091814315687, 0.08986763991264413, -0.2713404852757999, -0.22527318500157043, -0.2190328636705422, 0.14948744617819013, -0.734536010260114, -0.26533055228892655, -0.35467100460238477, -0.5790331448772373, -0.8676775018179927},
    {-0.7161050540972972, -0.12098287497030097, -0.377971015773975, -0.7531713693914588, -1.211213941331759, -0.9064703855192314, -0.38719616325273215, -0.5170596617977163, -0.7337401968473346, 0.11669238288936329, -0.6378137040237288, -0.9763430565971831, -0.4351535526731654, -1.1280078176242816, -0.6179207847435442, -1.1028535779810962},
    {0.4645640559829676, 0.22768306953088532, 0.591165586943915, 0.541123013229759, 0.11210026524733481, 0.31863118159590975, -0.26689792287725794, 0.2889581216360148, 0.2118519822806382, 0.3371024267306183, -0.06597435963177718, 0.32849731019767725, 0.37184986925986024, 0.054561519121994695, 0.45613429951134216, -0.27660746366887123},
    {0.8346995442560258, 0.16738215141208135, 0.6699761915332173, 0.8665844494684387, 1.091821055913215, 0.8000072470711762, 0.41709270800813597, 0.2212350284971589, 1.2660311406296674, -0.23180331032928397, 0.3800339271545596, 0.7807359769381813, 0.5161927929897435, 0.14505597377335358, 0.547131346643775, 0.2797594822626654},
    {0.6857204625763573, 0.5709425271034378, 0.8635713099553585, 0.2669118835351645, -0.2625007075780072, 0.13700439654843405, -0.3250489244300082, 0.5865659916325211, 1.0545778788661324, 0.1735421463651629, 0.12529121797090248, -0.08169135068130254, 0.5002858935025485, -0.08878481327501132, 0.2848489081434912, 0.058999153485884165},
    {0.5738141676734079, 0.3301023223181817, 0.8656535659631049, -0.22802598589864512, 0.10274185941883926, 0.23643874020561023, -0.03444019616492081, 0.7063994129649842, 0.3006946173472185, -0.1718612116654709, 0.5780058251234352, 0.8489726041554035, 0.5106939258292135, 0.45504896418871854, 0.37344283166639464, 1.0999943619880193},
    {0.28454538737684476, -0.28883371811171427, -0.07174866170839296, 0.18899300144019898, -0.44729719143575736, -0.11537296527007916, 0.15360761932661898, -0.4247080803463555, 0.02377979943417264, -0.18245969153627792, 0.22345634276799597, -0.5121447747962931, -0.2716893074327041, -0.7667684887142876, -0.023991301904685392, -0.7343750129740914},
    {-0.12020318920020802, -0.11752588261773304, 0.4768081585447151, 0.3422562642009872, -0.5763934995079047, 0.011633806471731137, 0.23361504584353415, 0.4911588777550181, 0.18096790944672017, 0.3801897955253703, 0.029628909444915936, -0.28972449437024483, -0.179064869056261, -0.4393071569268264, 0.002968324199516287, -0.4517733100010909},
    {0.6837177368802371, 0.22576990322924928, 0.9803951097685029, 0.46111758156837684, -0.20010123917367165, 0.1324796701681559, -0.6270996584531808, -0.05663188600130098, 0.1614572475536579, -0.055836195215023136, 0.32631318585131197, 0.19710099035148468, 0.30578337477913486, -0.12997195429363362, 0.28260648523660103, 0.31910143710767036},
    {-0.5822745385828101, -0.03335752720854136, -0.0715693621050116, -0.6791779135330172, -0.09724629345828356, -0.13931975350135026, 0.26300756375697476, -0.29220429523025143, -0.24405171921862437, 0.10135538854193918, -0.04728289367763338, -0.33064423833756623, -0.2005283219562136, 0.14075766809142765, -0.19759853139621453, 0.20114001170655585},
    {-0.3782641202177875, -0.6245020629601867, -0.37933845891037693, -0.30177503677682543, -0.23590376186514472, -0.8457200607176705, -0.894811068452976, -0.570906481480669, -0.4345333535810276, -0.06311121991175275, -0.39269971564153144, -0.327304282703624, -1.1341528487780514, -0.41518621828915175, -0.5285587531712239, -0.612773424617972},
    {0.6459872986786708, 0.287814992835144, 1.0132923864193812, 0.8942775396179518, 0.18108167452588092, 0.7184456924736228, 0.4788869545853243, 0.6408084345402714, 0.6437240038156445, -0.02546941970812606, 0.5007368205723, 0.7913378268049324, 1.0673024261677329, 0.2714450429971983, 0.44701798945590415, 0.7416517448966373},
    {-0.5468714159661808, -0.29620839708238017, -0.3414379765927824, -0.966577902682956, -1.0377973674786223, -0.5356605338002016, -0.7450827110794359, -1.1646197167675356, -1.0503500677079878, 0.32432848141972254, -0.6023734796576254, -0.6279722127132279, -0.4372373423476391, -0.7651518756154526, -0.30578898562981743, -1.3411083625233144},
    {0.19809366814463694, -0.06380923313936608, 0.22397195675172654, -0.5548053733501366, -0.06202597423179806, 0.09439083175472013, -0.9033999241430551, -0.750406006385808, -0.46021786462369174, 0.2032567159012237, -0.2183382393843102, 0.24017925020373598, -0.014313917831241602, 0.06752946666745586, -0.1905534467345107, -0.4393589360432173},
    {-0.045506931523800385, -0.16747608426361066, -0.007308014933185282, -0.32979981159998484, -0.19291201433298538, -0.14235464025513134, -0.21297821852498403, -0.6736389569201767, -0.2778910134675353, 0.28654681635942925, -0.3942696517792286, -0.17866565029689735, -0.1791189967623054, -0.2520711932263671, -0.2645420965090836, -0.3994212980645574},
    {0.5019517541085505, -0.12558418313930952, 1.100034824813096, 1.0420723480937297, 0.6700952064627059, 0.32946030948194704, 0.5430293146895568, 0.5056145502250992, 0.5409574800295966, 0.20821736839229701, 0.22732279650948145, 0.6064655676256485, 0.28179686530864717, 0.1018734106605643, 0.37191756272123433, 0.44501173318516873},
    {0.07541032242920269, -0.5377868726960131, 0.45410568831246834, 0.35486717230484416, 0.27587352869203624, 0.15115685180493843, 0.7654765403746993, 0.4870359854912377, 0.1647056467826277, 0.29960359516022983, 0.06221399240168042, -0.15306585090844152, -0.0901203377996357, 0.01012214584248749, -0.08410228410373397, 0.20784621933413386},
    {-0.3291875381593529, -0.003831243884415853, -0.3996277789839085, -0.4515337474331788, -0.3579798313160341, -0.14967917264431693, -0.49542788047956077, -0.54131047583278, -0.40970444444157456, 0.5407858479921555, -0.23612510985000298, -0.27613397549179175, 0.0268525666133803, -0.3427637575214262, 0.04402098390182511, -0.7251394105218958},
    {-1.019568743281713, -0.23499127125348407, -0.8243202372452422, -0.6855535388067917, -0.7905263482296914, -0.23811519931837039, -0.37709117141242987, -0.4110822695397542, -1.1375270325406104, -0.12878215639278456, -0.4114757891069157, -0.6142694076350531, -0.818942961626251, -0.35452285978149456, -0.2842673400345955, -0.24014699661348682},
    {0.0773925288319969, -0.055443598287226704, 0.4615866434858828, -0.04687948643991475, -0.3162026035630637, -0.014355215088147388, -0.31956736141185127, -0.27620165319870904, -0.10999822535963043, -0.08167307268729888, -0.33585183690686726, -0.07434705524918253, 0.23779895712482077, -0.2779465079537029, -0.2594354734422768, -0.6868142693067586},
    {-0.1416988127505245, -0.0405908125745357, 0.2845406967743368, 0.09057954840655204, -0.36009153372482056, -0.49218664259492645, 0.24794480664475174, -0.6165504528682499, -0.5226788277074145, -0.12739852102019647, -0.47329274348058126, -0.5972868946379454, 0.202040612684921, -0.4676852900848841, -0.03718600941033774, -0.5285006870587623},
    {0.37995318509787473, -0.13103288852536352, 1.0151664774520541, 1.0226352142429653, 1.0751237484195082, 0.8077722376556258, 0.935857390883369, 0.9717190347485938, 0.7056623931761958, 0.24447738837150915, 0.41320766374615, 0.7335467073229762, 0.5175682276773076, 0.6572320169368417, 0.5980021661057222, 0.7697861495217613},
    {-0.17790958962965134, 0.4084766739695976, -0.27834150889176207, -0.41556870834928766, -0.4933225013049392, 0.19059904276040174, -0.4426606601039647, -0.2385273018893074, -0.04710348484330923, 0.30245640733571433, -0.37554292240247994, -0.14987577817022915, 0.18298592711613387, 0.02792129266351282, 0.4277845442026078, -0.22535711419273},
    {-0.43335960127713063, 0.45224244862030677, -0.662644661360187, -0.18477588263330924, 0.15352191366279125, 0.10594603467671637, -0.1617962887511057, -0.6047642031641185, -0.13228260882840454, 0.44665226916755946, -0.13986176995132593, -0.3460168041651805, -0.7462477112667497, 0.3043322522084809, 0.2125534561240569, -0.5551580993982693},
    {-0.593300246804507, -0.6587051150887336, -0.5299012361805446, -0.4400235851906914, -0.4911169283884909, -0.531982782105825, 0.006272410772046783, -0.41389412682656623, -0.3794464018672964, 0.27885996952381786, -0.8488229966275793, -1.0381184727218051, -0.7502694438293938, -0.649592816403227, -0.6135267356467516, -0.9408399532208535},
    {0.3794334774610898, -0.17184417646293884, 0.17452086508264222, -0.25545902561158507, -0.19738155971835641, -0.05697596467829461, 0.3393589581993968, -0.005925503635632747, -0.2268429002600625, -0.3398471408601954, -0.26492024199954295, -0.08324472591344109, 0.28970645052214666, 0.04440660734925992, -0.15824054714756158, 0.27516743825083634},
    {0.2775550985747632, 0.05877681753361263, -0.1426730384252866, -0.22649467688043878, 0.19108267601341533, 0.2626244278625269, 0.08097109361089969, 0.009662871822254589, 0.2072375149376622, -0.18296526765478596, 0.23690363741488452, 0.5350895694595279, -0.2466603779666495, 0.04093287238231904, -0.1942725287259926, 0.31946127519784523},
    {0.368088426713575, 0.5055271193833993, 0.3658434627778905, 0.1513308481481818, 0.6410444012281471, 0.6354472385574353, 0.42644937247748393, 0.7137855783318781, 0.4507526088822414, 0.2393627507072893, 0.3399205288674257, 0.4317744940222462, 0.9211110230419279, 0.4539453762183705, 0.4202524827223083, 0.8914835595585393},
    {-0.093464944862618, -0.4337287792632833, 0.13811708385762408, 0.3283957660648268, 0.17243919113005268, 0.2654275785908903, 0.5359929326446718, 0.5023418573836602, -0.21503282786320516, -0.22904795562439761, 0.031441486692296926, -0.0948952250093103, 0.0038723669782494935, -0.1234964660532558, -0.20331586851489444, 0.15414432939136105},
    {0.577047469632487, -0.1718529215115233, 0.4894424865461813, 0.5900417236774119, 0.7301553696708498, 0.04055566457211579, 0.5134063789745686, 0.38533194069352505, 0.33860261000079883, 0.16533118281784787, 0.5074495348930148, 0.5932047950079872, 0.07544605134896583, 0.29882900520360545, 0.029054499447610682, 0.597079949327148},
    {0.5763067935199105, -0.0565092461155959, 0.10560773281082324, 0.2878071189312612, 0.18031109182205352, 0.11355421152107961, -0.19626902430523488, 0.05465177662079089, 0.10406108751817292, -0.3623755728810984, 0.34417119759968345, 0.18887482909029743, 0.10684767283153748, 0.0744732851251749, -0.08186874422761291, 0.17395824900624174},
    {0.10993949951097064, -0.5202266117274041, -0.03786981678101321, -0.01232762141790933, -0.32844005225132306, -0.577378013739721, 0.2898015926880547, -0.0514652480204825, -0.3461281191170169, -0.14956177688417469, 0.05110691575028028, 0.3047186034129191, 0.08533734309569824, -0.2505517605258517, -0.1865132508421922, -0.27848730731908644},
    {0.2211222909856106, -0.0883728204003176, 0.17256336191447075, 0.3207329866551113, 0.09899201697216517, 0.012320647361299703, 0.16821043017428813, -0.04260598226748153, -0.04753709789346142, 0.08994860667022225, -0.05552692005949816, -0.12354512236201175, 0.3997970240093105, 0.11489896831837886, 0.21120385927892496, -0.17861617279298214},
    {0.11022401922137304, 0.007351126213606273, 0.603814712333184, 0.40132574330206616, -0.36869678586907606, 0.007350950398166747, -0.05734211174586044, 0.12156716542498364, 0.01772919346164832, 0.048566776389261844, -0.018613526819395487, -0.19856146263341598, 0.07596842121310035, -0.1582948726918911, 0.4396607914766445, -0.1790788769944616},
    {-0.4999097453430516, -0.05831557662941588, -0.076441566498214, -0.032974213125269686, -0.504986726377951, -0.17097472429887584, -0.04656046659942979, -0.5560235659602469, -0.5665797400043242, -0.2636495755470192, -0.2700340684136983, -0.30254754806107637, -0.5340571983341453, -0.42531194287168045, -0.4179507121384639, -0.4467261672740319},
    {0.05400638681871236, -0.6732256472654555, -0.5783019224830188, -0.14785782489437738, 0.0006525006123492811, -0.15275778208682805, 0.5034335934782036, -0.04007866707565127, -0.04874816647975624, -0.1404079229185552, 0.008384384957836326, 0.018072109058060955, -0.4003911229147932, -0.38750148511316984, -0.002469396109557329, -0.2057315816246705},
    {-0.14547730360133818, -0.25925513876641204, -0.49002393322206894, -0.3814506631463011, -0.6815397552650896, -0.6380596684466092, -0.28349222155665094, -0.1446835458594876, -0.45941476775086476, 0.1429843368580996, -0.577026294645893, -0.7330337156701197, -0.4582804325684866, -0.49593581234313633, -0.20854662994511552, -0.46125517989443154},
    {-0.5425019831552539, -0.12264103850973851, -0.6859800547485924, -0.645152759068221, -0.1688543810737793, 0.05921416807939812, -0.22934956079771893, -0.5833651349268254, -0.7046665071522495, -0.08186389777378932, -0.2619377159729935, -0.2896340492482653, -0.12306526090961577, -0.27084966253302034, -0.018837586649677066, -0.27118764622046143},
    {0.5200470450257545, 0.3170641789359009, 0.37165892098607356, 0.4989462280560939, 0.601401388746117, 0.6147106420643033, 0.5318385188495204, 0.3222249465050635, 0.8961309199890171, 0.01692728284717458, 0.38823626960930235, 0.2951034498379695, 0.01154878513040234, 0.5495683453381842, 0.32909061627662534, 0.8508011609431355},
    {0.14300386324644912, 0.5429609085122866, 0.36143713890508744, 0.3622442911750912, 0.5419796435231662, 0.09599712202085285, 0.13531220367293484, 0.3019100808257414, -0.07717646357728682, 0.04984017443552227, 0.07417867757269611, 0.2936969355919465, 0.004458459043824292, 0.18433526379089898, -0.100315709643959, -0.0798661551869338},
    {-0.5233702999327523, -0.41026874559343285, -0.13053519140832595, -0.4115677486868476, -0.6848387975642455, 0.11013747463353195, -0.14687673372518942, -0.08555879678617996, -0.5873992459299124, 0.20491704515499695, -0.16507588130998868, -0.8326393996727806, -0.37830877987825173, -0.7294521943791216, -0.3282874941834888, -0.39356312771485175},
    {0.3463429020693665, -0.024768660651691515, 0.6319472345203683, 0.2965032103340689, -0.32763247905692255, 0.04227034666058143, -0.06766723686449247, 0.24584259684285706, 0.3151814391111269, -0.026149061740228692, 0.16750606624779316, -0.11421156393878752, 0.5779599449768197, -0.38703834479359006, 0.25351518229583975, 0.09038122524461557},
    {0.45028162743161065, 0.26707602166314853, 0.3192563286127022, 0.17256943132641464, 0.33043871962988847, 0.10905096961569792, -0.07862219583499987, 0.27588357048861384, 0.6644457284753477, 0.29100803140184067, 0.03845509953398078, 0.5258766414422115, 0.7143668415290354, 0.04451588627130137, 0.05185425531328116, 0.4210825821491103},
    {0.5680575763561526, 0.19253204010876698, 0.6979937316817119, 0.6512024649248344, 0.6549475286150911, 0.9448966880430892, 0.7482869111902541, 0.8300147193877822, 0.3768603234156465, 0.0633289703356587, 0.7160723310181367, 0.5180299523931552, 0.5773871837594965, 0.5932306316547307, 0.226369419853409, 0.8800661414722364},
    {0.8899595150141003, 0.34826985033095886, 0.6757995750093982, 0.6981593138572991, 0.5250598879760661, 0.5544132389089866, 0.6757906838309999, 0.26323779446260254, 0.5482618330497626, 0.1039280761267544, -0.1697176781564741, 0.5385503834746647, 0.594187074335055, 0.44483277993722725, 0.3448249307933407, 0.564164020459414},
    {0.2318805687707544, -0.03374227841525242, 0.1493909766083692, -0.1661237733600605, -0.46722988651981895, -0.05371792236349001, -0.5377976632863763, -0.38088486147938466, -0.1579891196603262, -0.11863135447333505, 0.023704074064382786, -0.08336209718474373, 0.5005508479520637, -0.3171536536501618, 0.22553026150690839, -0.16175279801196923},
    {-0.09522991091921743, -0.27194693457503877, -0.37513363925534826, 0.11195654044379295, 0.043751044783273706, -0.12105160535096184, -0.2247455200091643, -0.02911777737407687, -0.08728582653866651, -0.1888407585005435, -0.20579931563635714, -0.28858078176006124, -0.731965002714405, -0.048385188879378684, -0.300938625672832, -0.15312749186982894},
    {-0.08823018282703135, -0.37279962380903225, -0.06204554097025525, -0.03889534502677477, -0.07362516549432555, -0.014789232849293192, 0.47409621560541454, 0.06941526691219643, -0.06373519507072417, -0.008400027348522587, -0.34508936452579014, -0.14371949628632097, -0.2712901655626957, -0.012389049688198123, -0.10237273925553599, -0.5994411852736924},
    {-0.507108732546232, -0.1007636675629131, -0.2281697207397688, -0.22598907998043916, -0.5281905634328861, -0.39291051148469863, -0.41658345312379097, -0.30955206156440424, -0.3345328497916861, 0.28809377814266157, -0.3542738762473025, -0.5361927053332318, 0.6403180784304485, -0.5503062490552509, -0.3806438900021321, -0.4107967789226144},
    {0.14233504709361197, 0.32465426454973706, 0.4936337272521239, 0.5523700182220111, 0.36963716582885897, 0.35098275249131844, 0.06854615759054346, 0.31604588324077143, 0.5144436761041706, -0.10008517827081362, 0.5324824750342549, -0.04516798328778205, 0.20755336622330184, 0.3868557158016268, 0.28237086119033344, 0.32928764473847916},
    {0.45396412116376916, 0.32813162554247266, 0.08424428834641115, -0.06088490291181445, -0.054882023452282866, 0.0016305759500363202, -0.20923591551808174, 0.14967674329852185, 0.09326168430781719, 0.2510684592236654, 0.1157990731023421, 0.38532529763980883, 0.08007808415246896, 0.26340375589676573, -0.016447406836703777, 0.12815822938317156},
    {-0.1716048363059293, -0.5429969345113367, -0.30642372478034907, -0.3836578499089971, -0.3904499466713686, -0.2804000746257529, -0.38258521250401784, -0.6361283370943153, -0.2976212941030507, -0.11907806046626036, 0.09337809792931893, -0.5837544620584884, -0.4970955433893848, -1.0291006741065756, -0.3362015223133379, -0.3775254417089209},
    {0.36543154426534674, 0.022280308542505713, 0.3291272622852957, 0.7468651259496744, 0.6178424652133555, -0.1683661147545753, 0.5912611891670885, 0.3589825039332138, 0.4406912562613769, -0.031158933393371332, 0.10043683778825035, 0.25864514512830505, 0.020037046542947818, 0.3795177788856081, -0.1707477354690225, 0.5578039663187557},
    {0.03804882168896421, -1.9977997259955502, 0.5922615549258714, 0.6256437880293825, -1.507003913890687, -0.26926336698133935, 0.7773738600304245, 0.20632793490896625, 0.708406782245307, -0.6529260617085433, -2.403889090589732, -0.5755635441747678, 0.5778510942334314, -0.6724801027263309, 0.8310780420563972, -0.48808358538476615},
    {0.7032736287893084, -1.5374431379216573, 1.1687376510187126, 1.0513942904206721, -0.6405517247533343, 0.9505639265104685, 1.4100344168074839, 0.566033675705818, 0.938692920067382, -0.19257120861144428, -0.809111301178819, -0.597647391449912, 1.185663059278823, -0.6522299926652558, 1.4832720744561052, 0.11169092314804292},
    {0.5598261600329806, -0.37981409818139306, 1.3770206758535244, 0.7701311426201187, 0.08517790517394283, 0.31414850597984395, 0.1780855043034226, 0.7234048739171617, 1.1883239763597113, -0.15845572821664827, -0.09075296899813441, -0.5431640464027634, 0.7766846126872271, -0.6466061249994971, 0.17344862239576836, -0.08522592159865254},
    {1.0242816186601669, -0.34671934273274024, 0.8989378441696221, 0.5333023714159842, -0.24476053101122, 0.2810754636878625, 0.11459638510856031, 0.8612557871666576, 0.8432063384988163, -0.10714504385002865, 0.11221845248995242, 0.2390838300609304, 0.5117863949252989, -0.41286357337802876, 0.29671282134217586, 0.5397739794547108},
    {0.6174801831854185, -0.49561474588803955, 0.6933508210605641, 0.604788125403862, 0.32120294740870564, 0.28224414894334204, 0.6297104325628533, 0.743427717973243, 0.5834855554790551, -0.42032191904072014, 0.09659620794308439, 0.3043567698678286, -0.09119298357571827, 0.05410463127482523, 0.13940751743286064, -0.07150132496948974},
    {0.6740437740079369, 0.28711505612629484, 0.7081006510448659, 0.8074161490442033, 0.8439212543534188, 0.23791369858725928, 0.2570520046928277, 0.6709594747080804, 0.9624211280571483, 0.07378040010658142, 0.27616608944235316, 0.286460546127969, 0.675083461909979, 0.6852074935236051, 0.4775352252388013, 0.5871302637566647},
    {0.3638254513179259, -0.4317474423794879, 0.6896596758062365, 0.51937596243252, 0.42163132906089956, 0.29959523474189365, 0.7928350480297726, 0.6052042276976113, 0.5879515670098275, 0.03928538338825861, 0.14786043302589905, -0.0840636590880696, -0.42062904008294305, -0.015386795598797152, 0.19897629412614637, 0.4901094445064695},
    {-0.020340754040717907, 0.2261344695342996, 0.6478872765861673, 0.4199492356142083, 0.7011599501369039, 0.3643274582029683, 0.5835648777785082, 0.7464645579978774, 0.7045614876811014, -0.1843898327047291, 0.5340855553065345, 0.4098129473115255, 0.5547079395908884, 0.5060954624865411, 0.3347660127863077, 0.21249582869819728},
    {-0.3248333952351629, -0.10457071799841167, 0.008868416332051966, -0.01302754526684482, -0.6284498088982187, -0.06642837824823339, -0.11521756434826616, -0.4521585191693862, -0.21807753000420607, 0.2880485455998265, -0.4242383562890844, -0.7785099211594664, -0.02675265418655163, -0.2776779196955889, 0.06920400188307392, -0.7626342301562453},
    {0.9478684425060725, 0.20885074387278946, 1.010853663314596, 0.8863865560908254, 0.8025271231250212, 0.6550071910182265, 0.4612378594143068, 1.1084728281595642, 1.2849314927290332, 0.4594728033065102, 0.44476904040184206, 0.7297908610587452, 0.8456154631489322, 0.2687836492304318, 0.787949545509273, 0.5564715992939322},
    {0.14371732394674355, -0.2572476613891151, 0.14918514456641482, 0.4010329454370731, -0.32439627634481816, -0.5389713382778453, -0.6195138815982194, -0.23839577020979863, 0.05039894550592941, 0.0452706338584054, -0.21806105990703095, -0.005096905860078229, -0.14336956630122688, -0.3994907937615101, 0.10491173712411035, -0.690145458082476},
    {0.1829171771197941, -0.08731526254179989, 0.42701906058284833, 0.25249644681188044, -0.4836692819942581, 0.019809673714855206, -0.1300774763559171, -0.2905303521558637, 0.2761060741133758, -0.11834040157471833, -0.5202287832312401, -0.6981810497706035, -0.2360648837182239, -0.6651102742286902, -0.29908279069390276, -0.5534353904615371},
    {0.9411191018061715, 0.29925046056128923, 0.9783957417433728, 1.07163702065679, 0.6208221346211984, 0.16618778147003044, 0.9652300912862029, 1.061565013324511, 0.9742243083789056, -0.4358559656632335, 0.727552262764036, 1.0676145319014778, 0.9641765009791371, 1.0008786081229195, 0.5068392258993082, 1.394348526252673},
    {0.3181373221488204, -0.6054356350409122, -0.04574820486516666, -0.35253500936910726, -0.6217577008305656, -0.20815658326506925, -0.3023933050087442, -0.07597473597106617, -0.22126709336778194, -0.2800506013029422, 0.10360770166665166, -0.7286880045144842, -0.06570236010037371, -0.8170053842134273, 0.13044588039324856, -0.6651305953929455},
    {0.16280847959578224, -0.027792952325200446, 0.5276140097995295, 0.6442300614355795, 0.547954848521514, 0.26847000950612576, 0.40656536549066297, 0.8706149937812832, 0.3594362457031125, 0.14275271253670377, 0.4315740728821474, 0.11850603805961822, 0.35986671742336135, 0.2041998665851612, 0.21955029286584785, 0.03889412056605304},
    {0.39708362058332236, 0.45513643192227093, 0.6122518321612286, 0.23866223769468037, -0.3191509577577104, -0.041075029650684346, -0.6952668167876292, -0.2770498660307537, 0.09796710305645263, 0.4765553835197476, -0.2524374067091962, -0.033652154210767504, -0.017801228312809215, 0.4195696829921625, 0.6385819204879973, 0.5065563490755283},
    {-0.3805741846717524, 0.06943818726685706, -0.08185834384733393, 0.1410790910606622, 0.30583033967795037, 0.16822579673223925, 0.46447266043117846, 0.01652176237509585, -0.11310479416001423, -0.09055235781992528, 0.0973643068537171, -0.2081391770179686, -0.09412585781454835, -0.10407415564555234, 0.314406280252614, 0.23470182110779444},
    {-0.44859829149385755, -0.6002325585915229, -0.5542672575994566, -0.14183794875540903, -0.33158855983211794, -0.3903333596740045, -0.13909871772157217, 0.10085662453696767, -0.23368109989006589, -0.6095253060626661, -0.22837821625417928, -0.35991616165873397, -0.49848764488408825, -0.2861203302254284, -0.43084577899622833, -1.0359590649651076},
    {0.8142427200970827, -0.012320880295749822, 0.9823788269851743, 0.8236701180177084, 0.6256652686527309, 0.7491893808931503, 0.8639570892132832, 1.0492666412718148, 1.1664139437449832, -0.008092371710059627, 0.08905508154495517, 0.22460165423823233, 1.0705249786361763, 0.26168565519269305, 0.6728134891214421, 0.7794974184339777},
    {-0.7601816060364637, -0.4377787943825318, -0.41365383031633, -0.7194860861815449, -1.1372346120731263, -0.3846605125670529, -0.8345693885535399, -0.8649223278395938, -0.6586263320631344, -0.2753155255732311, -1.1785126952617344, -1.2395829266715335, -0.9148197854908772, -0.7873223059305959, -0.2515079855228881, -1.2338223964667043},
    {-0.038612316839120704, -0.38082051636938896, -0.5339200441496865, 0.037827227310863965, -0.6925547741266026, -0.15531865479920243, -0.6866633708796971, -0.7760709455202699, -0.3761132948470006, -0.2580379526350585, -0.4061196791928395, 0.012851910466529386, -0.22451685541850155, -0.6946716340130006, -0.3202362659683551, -0.6912698134328554},
    {0.42846486586054217, 0.24982799369920916, 0.22528285508258505, 0.2559556190208971, -0.36608668697011654, 0.10896947432581648, -0.7379548146405126, -0.2754994249903225, 0.309232990063523, 0.17465003526646222, -0.11883649740368334, -0.2127818656399057, 0.05237277839651897, -0.20992947071065604, 0.46632342226313717, -0.42045125327590027},
    {0.6956585309882742, -0.04178677030497832, 1.0023479073572505, 0.8736839160507787, 0.37359300790083816, 0.212043533157797, 0.4450469759351727, 0.6302324086753752, 0.9864633175954326, 0.08869724250840606, 0.4795687993460746, 0.337034029842676, 0.31628568026888687, 0.07170495084684775, -0.002990262594782167, 0.4603114127597168},
    {0.7484283230301203, -0.0014193948325897678, 0.9242623213251921, 0.8602915684104334, 0.26474501286445684, 0.3099375091615032, 0.8307352812008292, 1.0649541336536361, 0.6273267193287726, -0.19996141003802992, 0.6561935781609797, 0.5055854118740681, 0.688134735391057, 0.19191078919355492, 0.4812839531322531, 1.0395815520521896},
    {-0.3477581483865109, -0.5035326174942141, -0.2731264166425794, -0.2970236179231825, -0.2881451564307772, -0.21817775767006944, -0.6386708562782928, -0.23193948706202105, -0.15472453382347573, -0.25718338631004, -0.1676108243778924, -0.5028183136549235, -0.5212005511631076, -0.49901946776827694, -0.1309470588859528, -0.6082143405903001},
    {-0.23739380406494434, -0.20594344028089823, -0.3949686418069219, -0.08237331822409284, -0.18625664119843924, -0.23402234047067982, 0.390725669478599, -0.23751549802084942, -0.5069248446260091, -0.4551921998876986, 0.02895030201787675, -0.22264328183551796, -0.4726500235894953, -0.08620603564670842, -0.27908099152917515, 0.2635990430848137},
    {0.36265267826125885, -0.10001765392766632, 0.6180615219708158, 0.6785368478332785, -0.30685267123012805, -0.10997950472766829, 0.047139030820907264, 0.269114521984043, 0.8284094765135027, -0.3922791836419925, -0.19817074395664347, 0.24973797217119967, 0.36104037465111355, 0.002375467504891228, 0.29316717676939735, -0.0074798295217764505},
    {-0.8347073146743167, -0.5376796692432118, -0.45376047856870044, -0.9797676135269464, -1.121784983826072, -0.8537794991050109, -0.37478964848793256, -0.9190258257448737, -1.1626122508004053, -0.5129536913180955, -0.6559268953539946, -0.9158992298167137, -0.6855752868507833, -0.848767521842494, -0.6446782168072243, -0.8846746844321246},
    {0.1749282634538836, -0.5769558428007227, 0.10867714229256388, 0.368516447834073, 0.6938031639580151, 0.02237218993338401, 0.5818602601886584, 0.326856244560938, 0.12959588267553634, -0.36986136781917994, 0.31066396979214245, 0.44263738176212314, 0.0578093986297928, 0.2655576364459692, 0.059085390663123925, 0.12551279233597212},
    {0.19612474914817313, 0.10665403759617262, -0.006994748851755805, -0.0035023973256222717, 0.3470407158195578, 0.6562114554011862, -0.20800828784994277, -0.012256264702118394, 0.14331799113954566, 0.12133052411529338, 0.16030728988530407, 0.34261207071943367, -0.1282626064019836, 0.5321850697221922, 0.37469751613339314, -0.09717615852716331}
};

static const float b1[16] = {2.458017519360552, 1.5711193713718006, 2.404117207826086, 2.54425658865161, 2.228646081223496, 2.539028178055926, 2.120235039048071, 2.230657543318502, 2.743518984554743, 1.419391490210762, 1.4247984606709039, 2.1207086296477113, 2.2846703465487828, 2.43363798903258, 2.438054068560008, 2.010862331039556};

static const float w2[16][12] = {
    {-0.42261219454917365, -1.3678189091859942, -1.2405166266575263, -1.0549876731322114, -1.0102462935490788, -1.1569138907918737, -1.97844224976155, -1.5185629362612592, -1.996399082833599, -0.5262424765661099, -1.6869535337721435, -2.2906959985513735},
    {-1.7293577243656961, -1.5657673322935814, -0.08324394142278484, -1.7959466911490363, -1.2899573782213212, -1.3256052794146678, -0.5152455712526669, -1.5245804021692726, -1.024568319269204, 0.01230462205458017, -1.3016488065812704, -0.8902972043889333},
    {-1.1895269849598624, -1.9280888034031196, -1.7242285387641851, -1.4066472302716444, -1.092851036956297, -1.230807767043672, -1.6350154938383448, -1.7964829966580476, -0.8565895781875698, -1.585582588229093, -1.625573477143261, -0.2800804217419067},
    {-1.9600841990640663, -1.236215988803989, -1.6520072657945764, -0.9265576176662388, -1.6113591445496633, -2.10335854653892, -1.1566085724877884, -1.4933955471339013, -1.643033159578724, -1.289890901635295, 0.2156535234676765, -1.4995781939356403},
    {-0.2075061050671512, -1.0318790404637768, -1.1311046231018542, -2.2368524894601984, -1.71959110761642, -1.5244481011302462, -1.5508201406992497, -1.3629195519253392, -1.4516833627763872, -0.44379860256001796, -1.8982506485727697, -1.583724801986714},
    {-1.5036220856937978, -1.9005807386905562, -1.4905002693064082, -0.352465728973759, -1.0429785432201557, -0.886146127505296, -2.0339260639461876, -1.123270417778501, -1.742398501567603, -2.466630214619419, -1.528343115342602, -0.6566775734265912},
    {-1.6513691449636791, -1.5629576747695566, -1.514967655132869, -1.6095434797516108, -1.2475272134696598, -0.5671047657846544, -0.957761223913618, -1.1738404522498747, -1.020818551181566, -0.4116571658329669, -2.0714997636841708, -1.5167145899470402},
    {-1.0800951277275055, -0.6721179229827495, -0.06060767754764729, -1.289132750667586, -0.917731403085377, -1.1043781014161742, -0.8202797017679164, -1.8082498624202628, -1.7806726238483968, -1.825417354385563, -1.5267350798720518, -1.757695046035979},
    {-1.8636524243984687, -1.1399411796116887, -2.000913079439547, -2.026081902522081, -1.4997495192916181, -1.16476627583552, -1.4627455292379692, -0.8379113970929353, -2.020370633727903, -1.279861118451081, -1.5714454900706816, -1.3457838237279545},
    {-0.6291623587348575, -1.051928980379975, -1.8153744921387276, -1.6764334762312374, -0.17253408625204827, -0.38520340627425026, -0.22687345770966208, -0.7744279692495523, -1.2708650185504506, -0.8761060509328036, -1.0361321110193071, -1.368784275104398},
    {-1.2906504748104402, -2.615055108833349, -0.8646831640419377, 0.08170723121293073, -1.0940185331830008, -1.7304328902852855, -0.35625037659657216, -0.059310483457122726, -1.0544199645432366, -0.9752055783379185, -1.65309018045816, -1.017019278447283},
    {-2.2487189180136355, -1.6815073104768041, -1.7554400661967278, -1.7568326139545494, -0.999602899909551, -0.8940599433942766, -0.29488581707310424, -1.3563792310038416, -1.1129822790617179, -1.2366235062096336, -1.6591087692438726, -0.10126210509561212},
    {-1.3703553534004445, -1.4182600187863212, -1.43755464081248, -1.1957774902214684, -0.7781572110564374, -1.877218649584146, -1.9015316212506315, -1.019802593510771, -0.16500229059326654, -0.9440435724872827, -1.068293202406952, -1.7881537803390202},
    {-0.7411290049005824, -0.40073862091345425, -1.399628641702289, -0.5472756643088773, -0.262865754892836, -1.095850426149993, -2.574288349336572, -1.5034472407067017, -1.2137904201888026, -1.7311917437030047, -0.7751535564178629, -1.3746840869599866},
    {-1.637169870439014, -0.19137737703663327, -0.6767594626744167, -1.0674853706572143, -2.7746326580346596, -0.7174144646473456, -1.0096306019789527, -1.3600258619377388, -0.7118131038643064, -2.485315540933109, -1.3843632766727159, -1.5650188464119072},
    {-0.9651419520294984, -1.0671549312516495, -1.6396907207536586, -1.4508889249216026, -1.7658532186601585, -1.5640161076977248, -0.8172177006961844, -1.362363209395882, -1.6046656482793316, -1.7701178913056879, -0.45512037578181425, -1.4658517476025479}
};

static const float b2[12] = {-0.8624724982700054, -1.2140846656406064, -0.5691979604982472, -0.7334451985657288, -1.007423513138184, -0.9538973255781455, -0.9027965648820058, -0.7814972925436698, -0.7776823013566947, -0.7262722076188411, 0.03870403443024037, -0.07615673662062437};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
