#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-2.3503825498805977, -2.3493529754264744, 0.576155072860195, -0.3146765243806402, 0.6625120913621135, 0.17632384037840815, 0.9096081558694826, -0.70866288947802, 1.1776507290183555, -1.0775221574803722, -1.8293808979304949, -0.017427663068423575, 0.49175793066941154, -1.1049067997057662, 0.05163081416546672, 1.1271700784836898, -1.8186482146302614, 2.4845666355744895, 0.0681511294747437, -1.6009818832512963, -0.862352728958405, 1.6541544931752825, -1.517059803999185, -0.8642530372745063, -0.16026755482563892, 1.1465132598760066, 2.099756277241031, -0.18216951000899517, 0.8612009605122196, -1.2518070203499354, 0.6466569658114386, -1.0285966487721923, -0.09041138673920093, -0.312780271273969, -0.2132126434219156, -2.9556636061914396, 1.2175644299108572, -0.4018778423668053, -0.2945756296804624, 1.740198687524765, 2.1092950072408576, 2.028785223401771, 0.4324633347914958, 1.443603885296102, 0.896592459576377, -0.5443529203624967, -0.3519406400957004, 1.0082748717841097, -0.8293756331758174, 0.5674665033981092, -0.7812763261983229, 0.273887190900864, -1.058104516317808, 0.5560628042220391, -0.7196310345499454, -0.07534887252341095, 0.9553516249414473, 0.5304009089258518, 0.9078723520690235, 1.038879912012089, 0.3758899814056073, -1.0858754005531892, -1.2230373634789111, 0.1671439574874126},
    {1.2145676666945902, -0.3748574299477309, 0.9734318555548164, 0.8941476666594788, -0.543144498481298, 0.18443806711481017, -1.3600790369345557, -1.001953686739029, -0.5538395610329633, -1.08407945331321, 0.08369675178079404, -2.1605011684910598, -0.4981701715664504, 0.2450563085425359, 0.9304211407460745, -1.958612867994658, 0.6700817022473657, -3.1321891162389375, -1.343655448079393, -0.6376422505885043, -0.6694194612323473, -1.4429403342085547, 0.49144405707581335, 0.7558228878408751, -1.6517766596300654, -0.7730764340889706, 1.0712161439641907, 0.14803513100529964, -1.3183002528013168, 0.6603687126474884, -1.61306680984837, -0.1723750933748508, -0.16226249319798156, 2.468956561907813, 0.7336742990805204, 1.7235115867884216, -0.40438879777107345, 1.6271295460942796, -0.6660050028039637, 0.3008026256820417, -0.29519834608458223, 0.6527529415474282, -0.6561878695852221, 0.5742957427997933, 0.06688295141208386, -1.2463504763683824, 1.3902710046979851, -0.45021675844548115, 2.209062288152486, -1.7526393702696377, 0.6474986301718471, 0.4993472169560261, 0.6894221269283675, 0.36843736997506726, -1.060504367256723, 0.07628368817538159, 2.280928318420085, 1.051347862446451, -0.35047045633580104, -0.08436385551829854, 1.579479568041971, -1.0494489046111735, 0.8692550979712038, -0.9522202126428584},
    {-0.4436343326897028, 1.478134941727606, -0.33375497431387857, -1.2172493258089985, -0.2536527256290553, -0.6116234890242652, 1.5475894761088107, 0.6041181741859495, -0.8133751741620333, 0.7149146264879405, 2.0815076873206877, -0.5956005021082673, 1.8037064575819153, 0.7067527428859552, -0.7201806218330116, -1.4180694202422732, 0.13579078824694302, 0.5324038018510673, -0.47287140062928806, 0.376118199130579, -0.9210756874451651, 0.5396362817876496, -0.11612018674130897, 0.019603066164508354, -1.2631314729918885, -1.164557831416962, -1.0117040780253164, 0.7319264718969566, -1.7134572101013608, 1.872316597941602, -1.6860500101319715, -0.13170326049630685, -0.9483315283636536, -0.3803605442977982, 1.5330998356841616, -0.3009324775261052, -0.5164471822368416, 1.6704400643412163, -0.7167546423602575, 0.2658591383423938, -0.44288071039332594, -2.514112421368781, -1.0609088463381189, 0.015559455518725573, -0.9021691559058724, 0.40230474090989565, -0.017080931442150907, -0.4053972455273188, -1.6886528377881518, 1.500617854711746, 1.291784921279924, 0.7718231659429002, -0.16087864724472906, -0.5846162941450292, -0.16755076455110207, 2.1055007981538716, -0.6804341400382261, 0.21734515693166648, -0.23556476570271595, -0.4717398795182354, 2.539867052822134, -1.5655388632146763, -0.8250267554389068, 0.6089701442549804},
    {0.4126978666052407, -1.8782467233157185, -0.10947904720227354, -0.8650141526689235, 1.7186549024238043, -1.2164024525919674, 0.9935236722536919, -0.287229655415119, -0.3988373751776545, 0.31692631696327417, 0.23384424770873138, -0.8777872902589595, -0.5072322301786033, -0.5478352315227367, 0.29160748031957623, 0.7302194356768255, -1.1795100458207173, 1.219423147120449, -0.5327334660935563, 1.629015606748049, 2.9709272542713947, 1.3553813080816661, -0.06060151538119, 1.032771458237428, 1.7830414037262592, -3.367146887151642, -1.5070168907796968, 1.6109012396863867, 0.18532452730374166, -1.4487223400487477, 0.6552835876337793, -0.931269785293859, -1.232265513633862, 0.3961772051973731, -0.8251958541935652, 0.11100207275397223, 1.9264654307096158, 0.7308498619076114, -1.0696224954770657, -0.49279135772415483, -1.0976423966513296, -0.05773201600636939, 0.18976978696393262, -0.05467134094342435, -0.19153181159300417, 1.72681755637292, -0.08007387694584513, 0.7180406354937872, -0.8145299364573564, -0.03583912443442734, -0.46731858056330405, -1.1500376108693429, 0.3489318097645939, -0.48646636419558736, -0.7060242702777138, 1.1634712083526428, -0.7763406673187838, 1.0478850191262508, 1.242093512835762, 1.9669397794309986, -0.6214027641861647, -0.020294337280992, -0.3009072694428474, 2.907427075627552},
    {-0.06608551637818587, 1.379601413281787, 0.5524966929494668, 1.047210219406118, -0.13072531499643486, 0.4944696635184372, -0.7271147946819696, 1.6713574359759724, -0.7998835119622633, 1.014122546944528, 1.6531509922726944, -0.6686304498559688, 0.9948856883081109, -1.2401179988669615, 0.6178171258807668, 0.2920773313902978, -1.0462197676306542, -0.5160105793727939, 1.1883436373208227, 0.748660283920504, 0.7905672205116521, -0.052246211775323466, -1.3207789094417985, -1.3009597082325945, 0.856313936550011, 0.35246373723824104, -1.8559855265977103, 0.18863646598267786, 2.09217260255125, 0.2925248823843485, 1.0899117965784324, 0.29015650800311377, 0.978450701815875, 0.547619583628968, -0.703451493348861, -0.9806532070876602, -0.07771268883904107, 0.08303350696128871, -0.019283008126492335, 1.1488423924737454, -0.5045256526591685, -1.0410902547000513, 1.1803697984511186, 0.7579398182489553, 0.23910497683668255, 0.18702515181811274, 0.4944431623209696, 0.237177681228798, -1.8441886705820216, 0.2225390707822729, -1.8192686650221117, 2.040746525900183, 0.7444609073653605, -0.3293412058366401, 0.9779893418251162, -0.7442853327285187, -1.6054752323065065, -0.2769104843622419, 1.8424261513625506, -2.194065892963282, 0.8379698091372427, -0.5819691739266127, 0.7371913362616294, -1.5932860120559322},
    {1.2197636619928098, -0.09851277071310037, 0.11055392884898596, -0.16526811389705967, -0.2639938622668499, -1.3053825186257961, -0.505255765021002, 0.9849087841677275, -1.1540652694198839, 0.9287531858139446, -0.24366960579106448, -0.4518502666602343, -0.795247915429127, -1.04050281506022, -1.6947658567775097, 1.3020635126763611, 0.2327088109818284, -3.0063961305557143, -1.0840124328857172, 0.08292291806542765, 1.223003052197578, 0.5527477659188352, -2.230844233717324, -1.6345273083026104, 1.9652382436964657, -0.28782963109463006, -0.7635407456503682, -0.02009313783279638, -1.7008667592963516, 0.6018467221122333, 0.11698016496262842, 0.7095335498558079, 0.9104605682001299, 2.2375643258923814, -1.176404053343815, 1.0968631229262948, -1.0895731998066098, 0.3242113329928085, -0.9037477154198537, -0.8773814677357882, -1.1422789784334215, 0.5537778230394792, -0.3273315078743662, -1.3042315004054337, -2.051786253422029, 1.5937306818353356, -0.28956124931847343, -1.9503723003206805, 1.18509060389047, -0.3315253937938782, -1.1057097534260911, -1.027083794111985, 1.335278195263186, 0.19926647358284533, -0.4039523089901109, -0.21319227806816066, 0.6278140983346836, 1.3519730429616306, -0.2268273948343062, 0.27232304840063604, -1.2039115459620828, -0.5390971380916797, 0.039005918060285326, -0.5454360998796046},
    {2.0355787375380197, 0.46928920714052813, -2.034090384165772, -0.4249564206383595, -2.6690196094617935, -0.8612022554089529, -1.9903093448932512, -0.4740394557465051, -1.6021706046531785, 0.19858926400954405, 1.3790370954246467, -0.04956652225814676, 0.3573388427900906, -1.116470920895745, -1.3153640271997915, -0.05719167555281031, -0.5366744953863499, -0.5881037383512295, 0.6836316926961944, 1.6382654529013343, 1.068303979859569, 0.21418455750254206, 1.4860971890423023, -0.09485644896792796, 0.042144076217481216, -0.0748513792313371, -1.239273923160356, 0.2899866748199849, -0.39159860209925496, 0.6122869550133195, 1.2304172806406024, 0.7964102515779071, -0.7779953831289196, 0.17469918609486873, 0.18810734677665783, 0.8616000404703109, -0.561634705288517, 0.804277181517631, 2.4793521266828216, -1.2743512591748343, 0.661677780884589, 1.0812124420029738, 2.3168927159030233, -1.6466144805467902, 0.8973023375157784, 3.590454666776508, 0.24348369693533187, -0.9076900166956103, 0.5768037563194341, 0.36494871062818024, -0.3163004658251707, 0.43041882341753457, -1.6014257168384374, 2.248359811018341, -0.6424915763714898, 1.75663411073943, 0.2416777661988034, 1.4571726523854864, 0.261211785192663, -1.8790464335797123, -0.04695768768245612, -0.03200047157188582, -0.14312527634277855, 0.687777884088542},
    {1.3177125073648799, -0.554736961531181, -0.09737842119434464, 0.36929566157399096, -1.1843217892143354, -1.1468053009225048, -0.5813201297925993, 1.3155951991374852, 0.9479588438607511, 1.0242670086082821, 0.6983084552799291, -1.9484244041959635, -0.5745325041295084, -0.301036049634276, 1.2582240193747622, -0.3879977134552869, -0.7585345961554892, -0.7897948749689171, -0.14497614051791452, -0.7817567986655253, -1.0828718614916533, -0.8544964184396959, -0.62969007300324, -1.9402222602276227, -0.7282460521812778, -0.36017557253954713, -1.4164092065600318, 0.9267265645988094, -2.5660215223611, 1.3762269881281277, -1.141281575896323, 0.4167762016035091, 1.00602761935868, -1.454241706571679, -0.4561893923675381, -0.23338317904478023, 0.9828004752180819, -0.5007050655284563, 0.4360811205720048, -1.0028053088271112, 0.03300414450048992, -0.3857528370431391, -0.8262542973056285, 0.19067763693034445, -1.382683045009724, 0.747093073462097, 0.38218116490615367, 0.13893995144730342, 2.214339733814174, 0.06735528403705403, 0.7063859250459325, -1.3711172416638528, 1.7172674754996433, 1.396926462844457, -1.039679525545406, 0.8666578865933938, -1.0153743429044169, -0.440744811546015, -0.1834996389662971, -2.2354135207485437, -0.5388776523881483, -2.5719505259036706, 1.5957632219622335, 1.5890811351607999},
    {-0.8515265324446776, 1.0344257651290405, 1.1793828201360337, -0.7632108022366632, -1.0780035401221926, -1.0195965520215946, -0.5208058940162195, -0.3561295244932024, 0.3360377901012705, -1.3321608594729046, -0.8833510740409479, 0.9476060716530187, 1.9953141350830192, -0.34632851784101326, 0.21688823810353505, -0.04731557004157214, 2.121241984415716, -0.7591355459229916, 0.21324660263965714, 1.1904987648502103, -1.9561855908750687, -0.23962341944835722, -2.5193013644686246, -2.0360235328093443, -1.1516807167929435, -1.0946114197437613, 0.3034404095738008, 0.39884263989350227, -0.47829865604460753, 0.8470473012510645, -1.436508083831881, 1.222936181057094, -1.4513014597659881, -1.8809868533622942, -0.6182550081482937, 2.0203535721493995, -1.134194722935167, 1.33951458005517, 0.7790271116422857, 0.5356695426398616, -0.9907816667890692, -1.2890561138081573, 0.07050515948330868, -0.7427513546587086, -0.38575044800662434, -0.06261131167012635, 1.9480701689879372, 0.4384679388637836, 1.727502119145701, -0.03256356203432894, -0.4335593134058946, -0.6964792884265021, 1.243543641079606, -1.8776924795028955, -0.6329418498734566, -0.9916131202038349, 0.8564084266015339, -0.43404376971521247, -1.116440354361717, 0.3758348743599183, -0.03359693364321179, 0.5059164260128942, -0.5317778003586681, 0.9014613775229896},
    {1.4128043945495208, -0.8229974211684664, -0.5255757223580049, 1.702779654015968, -2.1647148112080847, -1.2950857773186046, 0.008056603422919842, -0.492274208208828, 2.060553789358054, -1.3643150197817795, -0.0021915907970599547, 0.5096897948202002, 0.4013740740022748, -0.9854058609880919, -0.3515577990983212, -1.0162534985253777, -1.3598249218579552, -0.3969613476456228, -0.6416139208567405, -1.3725304149780397, -0.7807112289464174, -0.553750852811455, 1.1849140439509067, -0.1493136009847094, -0.9685876880700739, -1.0057279683123774, -0.19597379669669676, -0.16237667398440675, -1.5354178408492871, -0.08268856201235866, -0.3909905434048952, -1.8086083062513476, -0.07388667405951205, 1.520734582970432, -0.0073338876432490095, 0.2174032247799039, -0.6528281494901483, 0.4584863003475657, 1.0345696219707714, 0.3605748645523015, 1.9829348964029336, -0.20186552426088958, 0.513029584294967, 1.4025529890435078, 0.5577837293075933, -0.28309294734521856, 0.5355316472827204, -0.7425692879631236, -0.9498394636898493, -1.077723422074971, 0.029037661693220918, -1.3965406349690292, -0.5226719592022985, -1.8532912853315862, 1.7713129394103613, -1.3282548634922537, 1.2340526438839743, -0.2909186242852538, 0.7110279824522298, -1.2065811151113548, 0.14777127536331552, -1.882625923377698, -0.31536971776596695, 0.11199395060528484},
    {1.3998635800605796, -0.5909545308570331, -0.7444774765484548, 0.3065747077858476, 0.9058001180635685, -0.5532273264759727, 0.8108374560917583, -1.1298000487581374, -0.1849411660431666, 0.42710587048753185, -0.2337058434765772, 0.4208586551529013, -2.458789879852711, -1.6117574860011636, 0.8463843956068491, 0.49830065462563194, -0.7025988853470934, 0.4945930792583258, -2.8038684440070885, -1.7677005084438429, -1.3130101907729756, -1.1737006068132367, 0.11916848383571213, 0.12416534274078155, -0.4475062217088322, -0.41086640438309596, -0.23459743040943254, 0.739914239863124, -0.8630557857172764, 0.7622813314103954, 0.5802989423880381, -1.9403692269360608, 0.15229124157476256, 1.8156542656318448, -0.1626173625086503, 0.8489929053218975, -0.6240651318956435, 0.2591209263228994, -1.4390893871431705, -0.46970632347300073, 1.1410769126661415, -0.30073093566397396, 0.5166742453272053, 1.2490940910584327, -0.4363034852086581, -1.014735273439522, -0.379181043247879, -0.12593812891606845, -0.7656710544402429, -1.2963665861364126, -0.7998673227514764, 1.0070129345185757, -0.878774287123002, 2.675350618460958, -0.7963378467382979, -0.8412418690199756, -1.4449546273437446, 0.8040243792444594, -3.0279019111846615, -1.5319341719707804, -1.9352307058354064, -0.9401488600515968, -0.21195547272499124, -0.1462151721541156},
    {-1.3486652156489283, -0.3822551471804411, 0.35673713582829464, -1.599117813173723, -0.4335352060895524, -0.2109457643721811, -1.5110678970642464, -0.9501078074232372, 0.17709390296987126, 1.6050578983371764, 1.3154952275860696, 0.9859225317414007, -0.23000331237222782, 1.7122237400424787, -1.3513681684896608, 1.7588238944888674, 0.6933221618618413, 2.1322425876833377, 0.3423886396413143, -2.6844175121048828, -0.41748653430596006, 1.0188270984291363, 0.05884546940606678, -0.07723177576666317, -0.8665792820226103, -0.3715779145133229, 1.0307719252807634, 0.7696292603565363, 0.06629667628498725, 1.406646520104059, -1.4848785308147334, -1.136437889170987, -0.3245374270815392, 1.0791833243762838, -0.48155457716439576, -3.3469819356729897, 0.41011633795461583, -0.9862285286472275, -0.7402472596396663, -1.6347463655434449, 0.6394638559610859, -0.5330442091455543, -0.34040750498841793, 0.48035052561978064, -1.083623175212971, -1.1108022610726094, -0.9506364112148371, -1.771706570493608, 1.0022192344999028, -0.6345777053296894, -1.3552610437896973, 2.1127869970406596, 1.0745593719768505, -1.597286781598438, 1.0711536272031836, -0.5698915109794116, 1.099483571763043, 0.7053797887303449, -2.446703490759799, 0.13257337128820712, 0.7241121632495062, -0.8065015378074214, -0.5268723092985905, 0.8742618006552346},
    {-0.7433638523982751, -0.4991912628839123, 1.585798278003652, 2.333990381891339, -2.5215616901279203, -1.3057462418904737, -1.0191545459359461, 0.00642741476378932, 1.7501399103621365, 1.5161926700747705, 0.08833023475092677, -1.3047075926132932, -1.5431506423543635, -1.8749787839286391, -0.19004149747254787, 0.5861585103395945, -2.628350665039851, -0.7678569944873846, -0.4516282870210871, -0.01830875733811879, -1.6844728594329863, -0.22081119381710673, 1.5954266972073903, 2.8461575060328523, -0.12367378739615476, -2.7175307579476735, 0.762492807404076, -0.1864817431315871, -1.5978244022846928, 1.6283576061034042, -1.3183809323610263, -0.09931551600486499, 0.7478872238384685, 1.687585946944691, 0.6503285145914394, -0.06992490378738263, -2.610257921355327, -0.33427207119975694, -0.4042690411464899, -1.49967735954615, -0.09277436764850741, 1.1379968963260798, -0.4777199526340466, -1.983213943682721, 0.8796514639395059, -1.2429145371160495, 0.8621240812843867, -0.33394742310108444, 0.3894650524870152, 2.424166878611346, 0.09673495546173572, -0.1758995062223013, -1.155571848973777, -0.012617184015187365, 1.2487952943465597, -0.5307300772666609, -1.7795111572693052, 1.1183540028883008, 0.31098367321295967, 1.018495628350426, -1.495362286036418, 1.4164899932917512, -0.35305032740178227, 1.7163843613049137},
    {1.343375758208765, 1.3171036626313462, 1.5308749236583983, -0.9645427942481773, 1.6923050878820647, 0.28621706088169496, 2.4064378052975037, 0.3253573795572857, -1.4837936140512087, 1.5808861395910987, -0.7679329187615352, 2.120521715705179, -0.6266956145450161, -1.4926482005721196, -0.37766466837910884, 1.5502310122969503, 2.0349858388821045, 0.3233464572910182, 1.9236558760191498, -0.9686759131276033, 1.1985670658232872, 1.2396477684617486, 0.7969212531566947, 1.2453043426942807, 0.253139746934561, 1.2459096202229438, -0.673825537762362, 1.888778271325386, -0.2114302364645436, -0.20203412474086177, -0.9871560971612874, -0.48322998034232106, 0.06720114526642684, -1.171432838437564, -0.07248819269949572, -0.8339370475986546, 0.04959879993067516, 0.9270954024919184, 0.12302475433144044, -0.37961892107953343, 1.0601458141881277, 1.198740372515744, 0.2819450323033351, -1.2763604089333989, -0.23309507552383582, -0.6754398027966717, -1.102585301632127, -1.6036249245708616, -0.7779615677228704, 0.5330387373922502, -0.03640415465450089, -0.7555182390900975, -1.7085176765161714, 1.8974376377808768, -0.6798607353953628, -0.018574815584075876, 1.3815171451929054, 0.8249215327891697, 0.5522047050246691, 1.1544986911604553, 0.3954468605069373, 0.9583625218366963, 0.39886311300560345, 0.7835781275829456},
    {-0.02763951991218728, -0.6405520310738446, 2.117115380322938, -0.8689801472666474, 1.4019187644264017, 0.09039165216083953, 2.1264272183812607, 0.818653446126954, -1.5031392169657607, -0.4639402557059853, -0.6145678908475454, -0.21812062667344537, -0.21926604620597942, -0.07016353186449505, -1.8343901063926875, 0.7030038856968787, 1.9743571640051576, -1.3615678493726235, -0.39813085210804716, 1.3695214427195221, 0.0915422855357813, -0.016033565244164667, -0.8435465025052173, 1.2354947172860582, -0.16862221685607437, 0.685329508363403, 0.72184157944968, 0.8207645290697871, 0.20860177341845504, -0.4576816258850646, 0.18492228443006192, -1.3494799591142193, 1.444323096794915, -0.6403304864880063, -0.8660527241187442, 0.9574377328494168, -1.3445557841661395, -0.15317745022644438, -0.07631379170727048, -1.484698522821224, -1.0670039561887583, 0.20045684094204855, 1.4957372508963191, -1.2109079297146514, 0.4649364456982524, -0.47994469628636205, 2.2072616726304313, 0.8763140057279938, 0.29574229587171824, 0.8127888878831371, 1.1568813866926144, -1.5546937889574568, -0.9399019282001884, 1.0779094318929783, -0.6910616533379468, 1.0730853321379978, 1.7630916125455003, 0.3172734764298565, 0.6003972519916979, 0.0627987447694598, 2.0654501896365103, 0.14516529311352344, -0.18716339182042158, -0.5659977814140581},
    {2.7212883559219754, 0.01520290809263971, -0.0989147845970359, 1.237929920124754, 1.2328957435302483, 0.5419855150944083, 1.2671103086138513, 0.3142843927227564, 0.99365675889904, 0.4531721768728557, -0.5615189102248588, 0.7215657142271312, 0.2323333436604432, -1.0772396359063297, 1.1445157453837758, -0.44196160634842996, 0.447347656383357, 0.35575097505705966, 0.5232744083571236, -1.5264748904292107, -0.5636625700867888, 2.8230069078853077, -1.1723999776026641, 1.9884450316268483, -0.0328534762333564, -0.009496670198708302, 0.7330458127488085, -0.6594514810353423, -0.4164394172480943, 0.9606996557800436, 0.353673558474691, 2.548398611076903, -2.1448226807066026, 0.9999409056742342, 2.143259764634571, -0.5642526275215939, -0.8799037985399653, -0.4407892744477521, -0.24234262078236737, 0.5802041970178914, 0.7523071010850885, -1.3022767759644904, 0.5517420592781263, 1.1606019722521543, 0.11272142365477011, -0.8086907549332418, 0.7557731928730264, -0.3357320513773977, 0.1707316957772262, -0.46406971961374477, 0.1563843850552986, 0.30933342328228314, -1.280322200830467, -0.13603381394039588, -1.819543759193569, -0.737713835055292, 2.176334207632853, 0.16024797567428542, -1.5399966661920657, -0.608076289679871, -0.3389255270371396, 2.509802703415429, -0.9241833045286938, 0.5007459686435174},
    {1.466459761402559, -0.046401726432915784, 0.1113766344977893, -0.9756112856750945, 0.1841027777475008, 0.7489574704675515, 0.4854153098996218, -0.6869075312946267, -0.7378999871213971, -0.18483871703534996, 0.30042307446949196, -0.31424292482948857, 0.2247913565036157, 1.4050495452279481, -0.8937229903685641, 2.494047613898353, 1.8087064420004586, -0.4854374995785795, -0.8213216409239441, 1.580579415233014, 0.47805035334527907, -0.5386741814806144, 1.4375805523445213, 1.450374097929296, 1.0657235259429922, -1.3569213422872408, 0.6781289964128907, 3.741696306265618, -1.6179491873219893, -1.2754935065568065, 1.6956095658412251, 0.6133998238251959, 0.1443768924748604, 0.841045148695071, 2.6221192515596026, -0.9937975708909103, 1.6615370705185974, 0.18413121424010065, -0.9224496060360782, 2.2969476208765385, -0.9791204218750778, 1.2688273365035978, 0.41948201793142104, 0.46283045623819186, 0.14378341094720695, -0.03317704936040468, 0.4853902511972109, 1.3434855894233968, 1.8517807165145888, -0.10785613918078316, -1.1648926359376608, -0.41132688221226976, -0.28695568697769996, 0.793545493367058, 0.9422307518061802, 0.7016371968167077, 0.617624918432264, -0.2329817215058608, 0.7074867899639822, -3.1273518054999907, -0.0647273650504847, 0.2845420376767944, -0.10626275810420031, 1.0978453078168249},
    {-0.7115066755990256, 0.816646432469693, 0.06409912619652339, -0.19500687681679585, -0.020500328328834746, 1.0891854857520278, -0.3000600783704796, 0.3347532591686008, -0.9436594819955901, -0.7741042094094724, -1.8133539233504516, -1.30230463983835, 1.3404408934955008, -2.0922884046348864, 0.44078258150618504, 1.1182790400043088, 0.7627526334984234, 0.9031804356465782, 1.772104856162081, 4.278941749665393, 0.39381218777820787, -0.08530416937279932, -2.1201699451950544, 0.3254697219435505, -0.26999021956171754, -1.0076107021791352, -1.4854805361809125, 0.11359737306645804, -1.3064714475383639, 2.514785411001136, -0.47286936346102404, 2.054883129948461, -1.1064216472027992, 0.4450953837652029, 2.797818438836033, -1.281919906766874, 2.4942665207068586, 1.30185561373758, -1.505942009321281, 0.05450843830186673, -1.3377277272679613, -0.4911542180509436, -0.8909679104111591, -1.251994651248107, -1.1895119117504038, -2.6905617088618334, -2.843770850207792, 0.17855708318230465, 1.7545268350111858, 1.1203129176364843, 2.6300289047354277, -1.4818327000655531, 0.6535267857558382, 0.22995047917391262, 0.6219286179154664, 1.0015095145343826, 1.5334462163455964, -0.4611626589644607, -0.9102213871336619, -1.866224006818265, -1.324797107184958, -1.0584297337579192, 0.6554596007135846, 0.6881080929468223},
    {0.5114844111493605, -0.04601850183619605, -0.6611982277914668, -1.2887371786715673, 0.5940023832074246, 2.1604221004635686, -0.6436732388967346, 1.4861931814904736, -0.4880449982669652, 0.44368095009576664, -1.8379664750692688, -0.013664744069231695, 0.5404789090258186, 2.494699354276387, -2.4025991615777142, -0.5133225440796614, -0.48277113532470084, 1.2712403628976694, -0.2194312297754407, -0.35310510865627354, 0.5722751107292686, 0.9954749316554715, -1.3900177917116756, 0.9322880502467664, 0.9755984467589792, -0.4116895068369332, -0.7096806535981035, -0.5939133576291713, -0.24676213465518035, 0.22722929972069356, 0.15266943232996, 2.437031638003918, 1.4830950734928552, -1.0223514672673535, -0.6131459305673326, 0.4874714222944715, -1.6502817158379306, 1.4656086205046637, 0.10168448966551398, -2.594688237715433, -0.47693444116052586, 1.580069895203385, 1.6671385830417216, 0.7512217220148982, 1.745238839133167, -0.1852264471424027, 1.881712037301192, 0.4564635240634537, -1.7156622043660057, 1.7333217649493524, -1.1323089334241745, -0.19598151102259373, 0.47343747917588397, -0.6441113755907971, 0.7449199607806116, 1.258739001774553, -0.7120265697721129, -1.6689099882381764, 0.7102458492811681, 1.4252998259332952, 1.8133825974754691, 0.6824605259815727, -1.0889427729124317, 0.3995115163428215},
    {2.650801428093055, -0.455475707313164, -0.5272635154757892, -1.2188851697412866, 0.7617376311831281, 0.0665487957114077, 1.7788350737823029, -1.9692162357608907, 0.37567399052687606, 0.7210887326587812, 1.1152085909201863, -0.401549196429784, -1.146861337973479, -0.4819955674687628, 0.15780808402700583, 0.44802921589062356, 1.1329178475170179, 0.03148699483036704, 0.5424591448958684, 1.049417847055834, 1.4482753790844187, 0.6406722146872643, 1.536745719934609, -0.413892914075789, 1.8555173019321916, 1.005069927450114, -0.07869529337366556, 0.30150963747184373, -0.22770243741504662, -0.1804542158571672, -0.1701223738595939, 0.07775345447705, 0.14835117054579777, 1.3585082077279407, -0.45740968862628906, 0.6551832584792525, 0.5263617299257866, 1.7423917218320806, -0.35057553679796416, -1.1122880014255654, -0.6371336748255978, -0.021862040251510693, -0.23023887102566573, 0.4315153373657892, -0.5111540321258066, -0.5741339258334631, -1.1637884260268394, -0.5268495851372836, 1.9277199131765337, -0.9783078769891738, -0.6588044320898169, 0.4249751600834434, -1.722566274481855, 0.5491887552845043, -0.6027450828866067, -1.745685771279054, -1.0192847848902107, -0.14767209975610193, 0.4273271132317749, -1.4497217289477997, 2.3863421052151437, -2.5575784988324495, 0.007305142165662668, -0.179751421890285},
    {-1.0426670485385514, -1.4579149235831963, 0.5250576855257367, 0.4729364022172675, 1.3276613534519845, 1.369082990340145, 2.1596912405223403, 0.6759343503487677, 0.6780645365518359, -0.3167948639593688, 1.6849516036319594, 2.200480447481438, 0.6531433413767302, 0.05221605582861256, 0.35099209701291695, 0.5284901784181611, 0.6682542894971012, -0.250272897264776, 0.41753178960209286, 0.902827013042864, 0.19262570036864787, 0.9013226269327443, 0.49078675358215457, 0.4583350819023205, 0.2576583703674868, 0.7418617454626645, -0.0008328931093168382, 1.7739528002136205, 0.3144084542302153, -0.8677618441607597, 1.4995711836329306, 1.8687916498629116, 0.7520401860133019, -0.8419487793835536, -1.3209488574354435, -0.1852854404302223, 1.4355751403217694, -0.641136500036165, -1.988981988980435, 1.7259896198274742, 0.6573803335824879, 0.006241053669523365, -0.48623645977576924, 0.03354205757205746, -0.43308855918132483, -1.0172724098523294, 0.02196528247754268, 2.6595350806751457, -1.9305158822077255, -0.4011382141226977, 1.098277147279591, 0.5018007203749653, 0.40515415455566633, -1.554286561912736, 0.05200372273815418, 1.5047932582214543, -1.6816787191404625, 0.4427994225087214, 0.6438185169404489, -0.35007842433958314, 0.18363792516438313, -0.32077549720261495, -1.2651715152694403, -0.16612855043390473},
    {-0.8085880916798184, 0.10400831199162747, -1.4169739497193592, 0.8023270187720764, -2.0039931393355763, 0.9906322771893836, -1.1426818653760131, 1.902858130480068, -0.7842799872390211, 2.0638162606368993, 0.32400301367476564, 0.5108585699992553, -0.2971850288283836, -1.45343804855873, -0.10795548514777709, 1.9261177090729233, -0.8530623967694383, 0.8674352886051402, 1.3884436762353896, 0.7340875025805401, 1.8220964786995393, 0.003123555909756786, -1.0567261195083197, -1.8711374050172245, -1.222499937429375, -0.5634453788833548, -1.2699956531999461, 1.7176332837226058, 0.411115029507806, -0.4097648408770324, 0.9971164095891313, 0.5341100228580097, 0.005314393739966006, 4.295938605177592, 1.0157567296371055, -2.0171185559394247, 1.2498618056247623, -1.6645026962173644, 1.3539432270599718, 0.522625086572495, -0.032244944949883586, -0.5341017598427749, 0.4662002913347217, -2.365336589795789, 0.3485109549774775, -0.5940376168345312, 0.23982809982719064, -0.08364911961209617, 0.483394379956611, 1.781224993511298, 0.8103632158860766, 0.9966406820060492, -2.1480863965974533, -2.164773449512539, 0.20207289068073714, 0.8512429397277143, -0.37102561717968124, -1.4708549790637884, 0.8803674242481738, 2.703033125959285, 1.545506086652616, 0.9380709559862079, -2.0085772416680485, 0.4616834735418516},
    {-0.14926778334633037, -1.6704172994632331, 0.19080903027678625, -1.1040463434214596, 0.40854667193586547, 2.2135106227535855, 1.3999545992713163, -0.04814397351462904, 1.0192215174332282, 1.7942461386587893, 1.7713259466900015, 0.17505181727303315, 1.9987829259213623, 0.6787827115658871, -0.11955843281560581, 0.5234495623672573, 0.46427561954170415, -1.168740421172827, -0.9443250695378588, 0.6796344266445734, -0.44606855947420054, 1.9348018014615862, -0.17607587992141854, 0.03366351567073482, -1.0489272874449773, -1.702053526642683, 0.26106523294645795, 0.054604389818030355, 1.8121351568965867, -3.003052422160506, 1.6912638800181423, 1.3262158268884825, -0.12406171150072051, -1.1613936920159165, 0.02964525126881129, -0.21422180715185973, 1.563354894422046, 0.9455529453463207, 1.0671459889436063, 0.515830222869125, -1.9287571667243675, 0.010743229352239475, 1.9787705245681073, 1.7832301346025312, 0.6196200889715624, -2.0018123956113363, 1.1183139438223981, 1.6909207978205634, -0.5392168927341774, 0.3912474633372671, 1.31750850582106, 1.8112513240215218, 1.3540416841743488, 0.27081435566176215, 0.8292782850020585, 0.6838441287999206, 2.353123786705472, -0.7572424406620495, 0.5277336774228627, -0.3617341841581772, -0.8539611025159075, 1.2325516547739301, -0.5766587088021514, -0.024290578507085877},
    {-1.551606245203015, -2.0959102101956706, -0.48917129990430885, 0.1449624405285622, 0.2841793776102524, 0.4967064558616303, 0.368895180284258, -0.2747217494084041, -2.5175089211408164, -1.2825797318331869, 0.5234843640708035, 0.07537130960210474, -0.23273339445607563, 0.011226649671590632, -0.96985945938186, 1.1879429403542108, 0.08821526786025087, 1.0371220810465025, -1.430822839855801, -0.4701132926026575, 0.38480082505915636, 1.1663387618736656, 1.4004219063478736, 0.016965272447473773, -1.4962464909269144, -0.1356680399432899, -0.24150312735811746, 1.042323969416577, -1.5542240807469865, -0.9303100797539271, 2.683345394463008, -1.0914720070379502, 0.14273656730751869, 0.005739559048328958, 0.8347633378342263, -2.7986817947198768, -0.6549465942069674, 0.02132351551935554, 0.5012774524854214, -0.32292658331192026, -1.27308805979918, 0.6500969872377009, 1.2043793313543913, -1.4648376444693327, 1.9452992635003135, -0.15988440184333702, 0.5478325804452544, 1.4841295949977404, -0.15208143332255855, 0.9371271924726008, 1.069652240081377, 2.4178647701126796, 0.649149516226179, -0.9362268808675974, 0.8475551268037186, -0.5180707304317832, -0.2704260905670579, -0.6365849544150585, 0.5038968668942223, -0.16478770520468353, 0.5645517165409594, -0.3725494785928718, 1.9852814360736388, 1.9927955143762033},
    {-2.2140068688052987, -0.5257798781069483, -0.8819646802185455, -1.1247899445796747, 2.49430955171763, 0.8631396655744239, 1.5931573282626375, 1.35779218950486, -1.0932437407780249, 1.078114073830334, 1.2688097058954775, 0.8082317008456703, 1.994096713762064, -0.5679730431616891, 0.9454089734717253, 0.8168673413025359, 0.12135773200723482, 0.09557267253452137, -0.9604749551445473, -0.9330335569627092, 2.6090022378654227, 0.9526429506586791, 0.224301878184652, -0.7301173642512868, -1.087702963954126, -0.00862103825939257, -0.40480291645522903, -0.7365114290772508, 0.467435925432334, -0.4555559674055467, 0.15951449038057927, 1.4009291806524327, -1.0374047693765305, -0.3829687107421064, -0.7838135712464979, -1.8853737200564604, 2.1275546467754114, -0.8815248026669862, -1.198027803390347, 1.9865705848989001, -1.5120913020820872, 1.4339204806313746, 2.3823213719740557, -0.15159564377604184, 0.8926172780240336, -1.1750384118019996, -0.9810203884326478, -0.7353218899513342, 0.21703982621037662, 1.6320503429232875, 1.141817031842238, 0.7541952339908089, 0.8068212026571272, -2.5960951704484856, -0.17937846239458455, -0.30466947761663554, 1.746727387505413, 1.7733464522355082, 0.2074110323186316, 2.165360372905315, 0.927119943309328, 1.660676189837775, -0.5276657367712513, 0.6289936915760573},
    {-1.730099843991157, 0.7578242146729631, -0.40974355451035716, -0.1020849140469834, 2.3463607310702037, 1.3869990182679195, -0.0946435727980021, 0.45403963981484186, -1.7805966808951015, 0.4027301312384605, -0.6215297113125, -0.17798097887427083, 0.5761809527279107, 0.2989468280176285, 1.328811491951384, 2.016087553300724, 0.1307959258456586, 1.9635746669955865, -1.6435263573386583, 0.2642319170536771, -0.2434701399617825, 0.40808918077466666, 0.16988615040399327, -1.153746411825458, -0.665120865063039, -2.5126360386545885, -0.1986798354166046, 0.6873030483023259, -0.47056659338247464, -1.7229978338318002, 3.348219957343622, -0.9214586787235364, -1.1276605247593536, 0.7385684924843944, 1.5474848209648262, -0.7482721638626876, 1.0504757565293512, -0.5660073748497723, -1.128812311794364, -1.874820380771346, -0.1952478464683629, -0.7364199043338869, 0.5808839638434234, 0.42868114841290295, -0.4080832356132325, -2.2939660767674197, -1.8465814317704987, 0.5038952311249911, -1.8703553264587982, 0.004335133395698229, -0.7362098492846877, -0.3019926992818382, 0.8749563049724548, -2.736388051909722, 1.0779353132121239, 1.6159322625752008, 0.4151903252491571, -0.49335175625865196, -1.3233561891129988, 1.0275855413905721, -0.2854852278950604, 0.18041786351270694, 0.24895132739472114, -1.5853151095363751},
    {-1.6776684774494526, 0.17387564822005597, -0.30168310952494926, -2.2077794638711072, 0.8376469776636205, 0.6311461426585248, 1.236632128021627, -0.17791549412298627, -1.6463985670502854, 1.1338132488257102, 0.17843618033283515, -0.06742145378670825, -0.7685008269477642, -0.9705811039410616, 1.1146917688648255, 1.1517221667026718, 0.9381864780017642, 0.6021477494638034, 0.48860363796219464, 2.5946370350074326, 0.3787635426030842, 0.8910504064443645, -0.618652134024717, 1.6743333497352426, -0.5547752947622093, -1.5265296431697908, -0.5321337662095552, 0.02975515717402499, 0.10146285590496168, -0.17430028316401733, 0.2602061428724596, -0.5739091601733368, -0.0889196892671562, -2.4012562984906163, -1.0904011682023707, 0.6352836772476463, 0.9616199080256519, -0.014201985335867978, -2.9185411744156657, 2.0711231057145167, -0.19485508371816004, 1.063590128650723, -0.9796205247448395, -1.077078972316997, -0.12764316823750524, -1.0598672244994638, 0.5709065749980581, 1.4522499949050438, -0.16369063767870093, 0.4548192116431226, 2.9119313146834647, 1.7557207494542129, 1.8908144018587214, 0.3304067017152221, -1.987545290622406, -0.5271203437764826, 0.2080672233032571, 1.3469880677582164, 0.676657017737392, 0.6166447574628722, -1.1136744044831914, 1.3889833605042925, 0.18077428477167543, -0.43430334458833997},
    {0.01479375014634743, -0.9334876011065555, -0.43070046258514977, 1.1633823024082357, 0.9654182755488185, -1.9586772803128858, 1.622156314357846, -2.2588697352877274, -1.9317160115287868, 2.871148617770697, -0.6875765579442605, -0.7226393599497553, 0.8747055616655255, 0.05033655730742779, -0.9186870265952083, 0.09211660355296825, 0.37953599039361985, -1.0971876407071661, 1.5866532233105104, -0.5365975844748555, -0.8056971914777281, 1.2639114979017017, 0.8930864084148716, -0.1237321873903883, 0.8152727187717541, -2.5218458145365594, 0.6838072088222398, 0.16863815348280153, 1.0339665826907949, -0.0881053894043829, 2.467847357269182, 0.6532658526770265, -0.1360664302934218, 1.6621091103359162, -1.33542675317111, 0.9897147930672356, 1.0719136591801732, -0.33088824260127425, -2.2860135466489737, -0.7518411391894677, 0.3736267788111282, -0.9459083781239873, 0.580978721565279, -0.25379951780466364, -0.5829204186522017, -0.46778141207150675, -1.2414038314716493, -1.029998818508764, 1.4433744883693516, -0.7288158956375832, 2.559211619901338, -0.8373468814183629, 2.018736462368751, -0.2136748554427291, -0.6447932374922919, 1.6823860567080735, 0.7406797226073795, -0.22558350418826306, -1.0090212007561412, 0.935072956979947, 0.18308328515181707, -0.5621056766209663, 0.31601387385994045, 0.12058502384031873},
    {-0.014641157226371902, 0.90078178361446, -0.10440183189160834, 0.7991329817413921, 1.1003512366223336, 1.0104780111037208, 1.4066938438528194, 0.18865971663040032, 0.29492632563131593, 2.4427169619909352, -0.5132944831201955, 0.08433242395126223, 0.8148174365367136, 0.9973229403951734, -0.23898460678461445, 2.102602036266785, 0.2936635022285029, -0.20451736406184573, 0.16097200841154824, 1.9555086534348372, 0.4761594530671101, -0.2722090490010388, 0.3404520184103854, 0.6389266809871798, 0.5465072274932705, -1.5834947212862185, 1.083659618983264, 1.8887282567373591, -0.6977908082433757, -2.03441686620739, 0.9963789275006698, -0.4096095481018168, -0.3463243020420403, 0.6626383397906676, 1.4340246394817617, -0.6528863700983732, 0.6095950085694603, 1.5969079937780855, -0.9853997579980569, 0.1933656757216153, 0.697755539112043, 0.30989698404639276, -0.4310990933190989, 1.754781281594471, 1.4325358301147126, -0.5269900647926196, -1.9485621817827035, 0.8073089837423019, -0.8497240434051171, 0.20763063763958142, 2.353472122482309, -1.09386410234352, 0.19871742667380554, -0.12076610513017265, -0.21198066318348205, -1.4031498668399773, 0.07487989705128179, 0.6025148546007046, 1.8238590327552324, -0.1885191856719102, -1.6811682494066964, -0.45085520402090856, -0.19917697022812528, -0.5147294236935633},
    {-0.7971448416985912, 1.7950353862920825, 0.3702934556616611, -2.0141985468367465, 0.8149984414740215, -0.4634974069005102, -0.7007198262462824, 2.7814010317130147, -0.30020362856201116, 1.608938102221843, -1.0214050057411608, 1.7111397904187704, 0.9325332083598038, 0.7318645700880221, -0.42461766414850644, 1.3842545101822028, 0.022255173038679767, -0.023052993466225906, 0.44346890294058816, 0.4285037339861728, 1.5996267474633958, 0.4171388510385821, -0.484288976104186, -0.8075774628537891, 1.4707060564409753, -1.1401415279216411, -0.14683795251624077, 0.6120742332258031, -1.233172663827988, -0.6794878668050524, 3.455123203216796, 1.9084903110683147, -1.431526149094479, 1.4252967969927068, -0.9295957247225001, 1.3030319056834028, -0.40031239807356467, -0.266237071577682, -2.358323929789223, -0.3701469593280776, 0.2718995524295177, -1.3121343617291525, -0.08652396990466481, 0.6464221911054288, -2.0058404530986182, 2.6613636896923265, 0.5444340042158362, 2.1930158554992563, 0.9591240793909211, 0.3120300909415662, 1.334308960460024, -0.550262524233969, -0.4669015709245483, -0.06462044181184724, 0.5840988758620907, 1.0399997280367006, -0.018973762452058302, 0.4507252497169081, 0.48729953685752275, -0.7513348283631535, -1.426645743709168, 0.45714810085299884, 1.8456342211612873, -2.342861479771027},
    {1.0936908401813519, -1.0800353422838784, -0.9285798982890746, -1.7721677966556504, 1.3462394242920097, 1.9199721142364303, -0.3217240960934265, -2.5849134866564616, 0.2696380902419558, 0.1993329387589832, 1.4335059017930767, -1.0106709149553834, 2.897962990593281, -0.7332872451147238, 1.5989630700151183, 0.9526873624428588, -1.329602737931808, 0.9019034272857538, 1.253124479397741, -0.07219115138546996, -1.1461785031095253, 1.5484038584733064, 1.088926780789733, 0.12114459245971257, 0.5381918834142119, -0.7226483028932561, 1.0938790144888324, -0.8675914718726894, -1.028987072783067, -0.9791280606896093, 1.5215457384948545, -1.800003532231735, 0.3755551370910786, -1.1405867319620313, -1.6049072693808475, -0.8071755495061177, 0.5064308136037732, -2.0310146386376386, 1.7103959916577165, 1.4230125581858917, -3.510109277906287, -1.4513460880815974, 1.0373383714561142, -0.06194755805017715, 0.25022736991313077, -0.8863810307914146, -0.9149877320529735, 0.532542982355039, -0.4207982178900656, -1.3441561377459288, 1.0583735795947902, -2.360649522330691, -0.8711938716388643, -0.35156463848527336, 1.0424358455148415, 0.10850252620809062, 0.8465104273855507, 0.6613523894999984, -0.5841344982219675, -0.6644655386954023, -1.823160017520842, 1.9251700178729523, -1.5608498146920704, -2.619164545794729},
    {-1.507313375109982, -0.9391780651226584, 0.6498562697904224, -2.1586462046868578, 0.9189322320715425, -0.7863551509383987, 1.0008190360790483, -1.1973007551427208, -0.04818262151547281, -0.9144999484292279, 0.6184479940353647, 0.6747245992150631, 1.0084830811377867, 2.462284148401817, -0.5029082999686539, 2.3539174358068418, 1.2828651294773388, 0.9994957294110807, 1.9233609436895367, -0.029986863042035166, -2.364231337981086, -1.5270141033610354, 0.20631218196327028, 2.310307137081148, -1.5012978680691464, -3.7296905488830525, -0.3219734757381106, 2.17686703894637, 0.26370424682850274, -2.4535326628544523, -0.7926216601043437, -2.6472657738824017, 0.8883710429389681, -0.3559585361966288, -0.26707556947497846, -0.1494877343144204, 1.0231017532581848, 1.6929164134851291, 1.3681432059305711, 0.8921265038519011, -2.687355999464987, 0.4416251617491231, -0.7234228559340358, 0.5435146329580905, -2.1692700143343693, -0.28744668714262345, -1.7625102648503763, -0.1115099165737901, -0.2292264878784421, -1.129919012202799, -0.07295446180214994, -1.9830341969345426, -2.608388834202368, -1.408384558929468, 0.49097722745767997, 1.6243872749900738, 1.7190597100610348, 0.6078939969414174, -0.7404428697081306, 0.6862385854865062, -1.8166324300559644, -2.159784433852064, 1.1232285291185586, 0.4844177730593564},
    {0.004421275106251004, -2.2101726504005987, -0.3989032086743107, -1.5989846424895402, 1.588246643873449, -1.728605464162168, -0.5458831795816532, -1.0375349893373664, 0.2088390200721769, -0.15318019147767034, -0.9433234543112718, 1.6896877954882443, 0.5489104278328052, 2.5466448299252846, 0.9254521313585511, 1.1928109402623561, 0.41391727568513137, 1.6446149543004565, 1.0179474092665555, -0.51562927638193, 1.0720298384832676, -0.0833288984744036, -0.012140513262262566, -0.9495568646882729, 1.1055213890339348, 0.9768965659360372, -0.16975958473441194, -0.9713784200135324, -0.5384982016565862, 0.2513869513271237, 0.25448738600931997, -0.14697677637791645, 0.4183551697502252, 0.7796419312900694, 0.1835589733878603, -0.5543309949941909, 1.4655288040779768, 1.0343241563100651, 1.2449241866588843, 1.4236472139861798, 1.1027242562828923, -0.19479331275006503, -1.1165436514772187, -1.1399455813321935, -0.8413067293398836, 1.120825816723603, -0.03784764408390038, -1.2396024580372673, 1.3232342688486454, -0.8106083623672445, 1.6906883783354285, -0.47089288346211744, -3.1666415403977197, 0.28182088305173164, 1.7354691122672536, 2.643039053981481, -0.5416399653206924, 0.65618917076282, 0.7300902276204665, 1.0830577317859424, 0.6635762803659951, 0.9768842416743198, 1.2942699832928128, 1.1870857216178077},
    {-1.7857439543802551, -0.7563823004949333, -0.7204629193541735, -0.8790851863112924, 0.04330992580627496, 0.8502821849874516, -0.14755012639086246, 0.15211477331566273, 0.19982775377367717, 0.5653003661854702, -0.44975369812903776, -0.3362357417740533, -0.4654558753500115, 2.151659597972915, 1.3311994707703771, 1.9877896930058947, -0.23463522549137442, -1.4554626579229972, 1.4239736228785824, 0.715858663499572, -0.18512286944812475, -1.4259388716784964, 0.5220471414877798, -2.4833311570026018, 0.4782069482914003, -0.38041455425309667, -1.468318542927349, -0.761542781074732, 1.211010725947069, -0.9609265458869847, 0.021564371603003455, -2.073596646675743, 1.1569676704640595, -0.6988546941178453, 1.0703726936339755, -1.1840472145457621, -1.0831544682186862, -1.3857679470574222, 0.839965927362451, 0.6017569783661968, -0.09506794189349035, 0.5268241964223076, 0.5425813132937415, 1.7003706996352235, 1.084833024587577, -0.5801528378768773, 0.13410230970958242, -0.26164983811834625, 2.806313240339701, -2.3651753558187614, 0.37526441142674377, 0.001875313892215141, -0.4284464266912352, -0.11158249012338714, 0.3367060747123496, 0.7065231390718982, -0.02637379576882217, 0.258558913960672, 0.43129139182606163, 0.3698030861947749, 0.0019270245440983456, 0.2087463573825886, 1.2949144551453105, -1.4748816572561825},
    {0.9725961025734933, 0.5028262327799291, -0.08560660193985681, -1.2828269636449223, -0.7568426335402739, -0.3845608933822908, 0.7169844106539708, -1.285361851254526, 0.6555008109396641, 0.46821351547968276, -0.5152468466652274, -1.289338777107599, -0.5002762832994512, 0.0545469058770264, -0.14725940414198224, 0.9686121668085064, 1.509415478257458, -0.8418552889727853, 0.4251602845146685, -0.9242884914433626, -1.1909579823625591, 0.227983876858387, -1.1980854539443229, 1.163428022627024, -0.15325341389531408, -0.5125039747646867, 0.5390991526682112, -0.7671699991526064, -1.0279610873561629, -1.6987839608739488, -0.6472185915349221, 0.48444024972926436, 0.8021883742875319, -0.21974953768554698, 2.213937355004292, -0.003954867400526875, -0.8701585433328738, -1.809938046380459, -1.3722176219180753, 0.3128413615889589, -0.315046915125494, 1.0124370198030213, -0.9633485706210922, -0.8040121384561715, 0.7020614174412708, -0.9359767592779026, -0.9045867986013002, 0.8192532025979401, 1.732338700769136, 2.73753855691104, -0.8696333603070608, -2.2029824679851195, -0.3827112514630706, -0.09787117210918696, 1.6080821296904124, 0.6700214383253196, -1.3937086155404144, 1.131578530228213, 2.10823294516512, -0.9552626140395266, 0.5310107970543022, -0.524312132324203, -1.2061333847304783, 0.7982896022792594},
    {-0.7489316052414976, -0.18040145113317496, 0.4703546977798612, 0.7694165952610685, -0.12361677371007172, -0.09220671902224163, 1.5070905404903063, 0.7229522612157294, 1.3628025654208966, -0.30629424507017217, -0.7956779993826097, 0.4107259492246713, -0.3134086599998943, -0.8243315273938121, 2.2567262054591906, 0.6379177531457929, 0.8718824486189397, -0.24053565547765215, 1.5143328276036185, -0.6908505191474609, -0.6119455581619492, 1.4175461970579384, -1.517676253878346, -0.05231104551499199, -0.30200206719578626, 1.829139211265755, -0.09725294018263822, -1.3419131777480726, -0.4280811056442853, -0.028903389111780024, 0.5723935764863238, -0.2194513721889512, 1.3947410649477145, -0.1429992131814713, -0.2716274290079688, 0.1792591818789128, -2.008420720932513, -1.1682865269360778, 0.6624237749050926, -0.9846719368602865, -1.025997333009529, -1.8130510521558272, -1.0186356248033503, -0.7605645205343714, 0.2501829797367996, -0.1450861550740723, 1.7797674128403358, 1.7583459589279598, 1.6451414047568165, -1.9227938450459567, -0.9513744237701701, -1.4996129573398174, -0.2120637800654406, 0.7345762018773047, 0.4770422194224879, -1.4119583677086716, -1.9144141705988555, -1.4444315904491234, 0.452145473454877, 0.1521869552593368, -1.3391417166788693, -2.777314127216507, 0.10940174552631184, 0.3508162980852364},
    {0.07338862228966068, -0.9904677268722515, 1.6764952317359278, 0.6273436896630888, 0.5830216571791909, 0.10816157831982434, -1.7792012602832032, -1.483819834126357, 0.04327445857714424, 0.5299281676254739, 0.4143361868953685, 1.8679130657955478, 2.5269461080972326, -3.063977685890044, 0.14251491651227016, -3.239715974486339, -1.1210116649683703, -0.8342219347625783, -0.9377976867732138, -1.961007274542472, -1.6274351135266427, 0.9774385964633302, 1.16185907658637, 0.5610845538325637, 2.0271451579144926, -0.5246473789840285, 1.4382336165201461, 0.3592167042287162, 0.743405574096171, 0.9309309922522541, -1.1709621859143455, 1.7087651240014343, -0.4550509265631854, -0.7672924166368305, -0.8843729411202083, -3.983491812438252, -0.5028474654679485, 2.1425355047691306, -0.7973580978952189, 1.7841761774801799, -1.1201833192523643, 0.18795639760999, 0.8229655602206714, 1.9293444308656056, -0.46387804293141854, -0.03340094809311114, -0.8962931132191537, -0.4263007688552393, -0.1968605636362205, -0.0012372839972489363, 1.761696560486822, 0.529810194650884, -0.5651295895956427, -0.06753216645003661, 1.3917643378181859, 2.42768341573339, 2.6876329352031063, 1.5758821561758898, 0.3084128130083884, 0.9940431464428034, 1.6588885479567201, -1.4152939065983043, -1.0413763996698477, -1.1042355789934815},
    {-1.2633505060504338, 1.005851656180917, 0.412488952984126, -1.3641474888560996, 0.5854450530712194, -1.9523042043131087, -1.024989999323803, 0.024041809443878105, -1.6135020060241818, -1.1229572210231813, 0.7666013047998312, 2.682227461187237, 1.3938196155725873, 0.9466200906502416, 0.14454546901276366, -0.32260746343790614, 0.055047844892859965, -0.6161217064016438, -0.11220930419995519, 0.3572988465674821, -0.17160907415556695, 1.9290744147314973, -0.8674750273650242, -0.3573619570941778, 2.4349136939660676, 0.2978388425791439, -1.1874159661297021, -1.1496890172057086, 1.2794623910329452, -1.903844719878096, -0.2457205699996621, -0.2195049320682207, 0.3134303181403537, -2.3095503189424593, 0.7093893725417527, -0.11433769304787823, -1.446709441647094, -0.7805789894000097, -0.934529223570861, 0.7396670210941813, 0.6366102268427184, 1.36855577111638, -0.8054165337862478, 0.3644875581074913, -1.6738852467983254, 1.3892416219952453, 1.6406708358957443, 0.3374634904666413, -0.8733230841635042, 0.10184184419833435, -1.1001951035194124, -0.6312209987803606, 0.640818661943449, 0.8068882975253365, 0.7291584161277631, 0.25514321823773345, -0.33098811782943843, -0.509839332155951, 0.9791957230231753, 0.7184126009425766, -1.377057861558181, 0.7389367748801198, -0.2700774024674579, -1.676421861442212},
    {0.8607635914296239, -1.0052962533758352, 1.0409509694063956, -1.24822172896348, 1.0499240825898755, 1.0593276281661053, 2.0709456825908346, 0.3390871695935796, 1.0019014340432693, -0.4326837144496791, -0.6163549998008411, -0.6547431153202321, -1.4289048544852532, 2.0360007681151253, 2.60875610736077, 0.9886019024770202, -0.14481456216572025, 1.1258829091702987, -1.659038816226085, -0.15933094323474783, -0.4004767895605218, 0.19621176875507554, 0.028012982213543532, -0.521267472677404, -0.6536858365268998, 0.4558090524167188, -1.6993071566960607, 0.14159920521733224, 0.012145864520967515, 1.3816879286946635, 1.127300663479651, -1.1125509524559962, 0.4497918462739163, 0.647872046877345, -1.5566573626111495, 0.45486555751433966, -0.37348113928069226, -0.5757262759610324, -1.3105367440872713, 1.6576806065971414, -0.9438370625877294, 0.45412830269468246, 2.997586869456173, 0.03973107688633083, 0.6685718107392211, 0.8792156751904237, 1.3714851155825052, -0.023173149722933595, -1.6287412680707574, 0.17871522730667458, 0.13694651277313066, -0.7464261561148071, -0.8050257284414493, 0.19072828398591382, 0.5451208293137836, -1.189030465185886, -0.22414453927957448, -0.09836934759253715, 0.8743362407273452, -0.07053100058717206, 0.40712625105394423, 0.4859193785953481, 0.4163411310531562, 0.9973621220061645},
    {2.2149720413722385, -0.13787034333011475, 0.6732704878078102, 0.3723405503547794, -0.4785139141775532, -0.5892066862524324, 0.09736557997779711, -1.782180320129964, 0.7503632844716027, -0.9190745598461759, -0.11593426816369115, -1.0921765767539335, 0.19525074405592277, 1.2055697570276203, -1.4527220901273519, -2.678978840430387, -1.4489374212446506, 1.2054255404642749, -1.7100655568426808, -1.0424380304453535, 1.0186509272167812, -0.23439463335143754, 0.14212730979063098, 0.6816550674842574, 0.3002896516849395, 0.2369939136760966, -0.18304546406459954, -0.10731024384049553, -0.8010381027016811, -0.05001652563302749, 1.2416073526722013, -0.8721783662913971, -0.5501507651175013, -0.9587399848681347, 0.7056679087736881, -0.8575249184592367, -0.8575243628455136, -1.043905845413359, 1.81659056152557, 0.5729677264790167, 1.6585012773437107, -0.2838081010672009, -1.2683677451788442, -1.9561584967935484, 0.5394242763241384, -0.26748197909526605, 0.32379023607124235, -0.8063970245165657, -0.5828145607187956, 1.3422620018550384, 1.6201656572196281, 0.0026734676342376556, 0.943556786793523, 0.05833823519332698, 1.0688391287978312, -0.9247608260759871, -0.10846563532716096, -0.8985261885216863, -0.8018245263553582, 0.11945147708849818, -0.6705571632905108, 0.30342814047554606, -0.9526072957251861, 0.6065595933251833},
    {-1.4603534277970043, -1.5441100432441852, 0.9681446928387945, 1.4443960449684226, -0.3602536254525783, -0.19416962545239333, -1.1424266213849001, 2.8317241770625157, 0.569150554850253, 0.3103582932941519, 0.48073667185491115, 0.015453274856323869, 0.403767837402758, -0.9130231201076044, -0.8305079342704472, -0.40049022167630216, 0.5088492830767916, -0.3947734969192119, -1.0558642416707484, -0.9478434902468255, -1.4362174921587343, -0.7835444011145135, -1.2419251977033563, 0.6377243205913385, -0.44924549079407355, -1.0561143457790658, -1.2422929375890701, 0.6595291976855567, -1.2826110658495626, -2.259767592970554, 0.20600968802881273, -1.4103582604897063, 0.20636345395887243, 1.978499294928413, -0.18252256863669628, 0.45485806152717945, 0.4289260015154732, 0.007353314865294481, 1.175263798783359, -0.5487271120941002, 2.856401410383811, -0.1709886548023423, -0.3462166472743281, 0.21403966772930358, 1.86384483281212, 0.26327570227865527, -1.638565711146882, -0.16511204819041803, -0.0027236469072119186, -0.9430696643232769, 0.00530813276547372, -2.4495614439072275, -0.1659774392302389, 0.261049607874966, 1.160070389078905, 3.026878094414979, 0.5039187833286831, 1.152757755659404, -2.004151547409915, -2.1398012469949483, 0.4545800261086907, -0.4517031085112004, -2.3069484118377472, -1.1389983515175375},
    {-2.6627835331153427, 1.1700477540488656, -2.154024459968055, 0.6692659836641535, 0.443795175787555, 1.5983392151187938, 0.09051607475294944, 0.38233413854716725, 2.1807507683869916, 1.237463338813309, 1.152579096694672, -0.006490480876993514, 0.814760392036658, 2.3779665542152544, 1.0088038274135858, 1.7460728862977166, 1.1233504107502912, -0.2848304061945523, 0.34486680081284243, -0.41672343490318636, 0.5509122474344748, -2.187897923146875, -1.4694095103452305, 0.19136197910492825, 1.2333394736419372, 0.4940108241741934, 1.7287801505540634, 1.6400641510545722, 2.677563448267316, -0.1803543038538978, -0.8613953972809602, 1.4454007980605044, -0.4121896752799385, -0.30068726755198183, -0.6635840598848074, 1.6619914888676168, 0.3799653638677985, -0.7636535865740487, -0.30706504261421586, 1.3107207601501374, 1.3309386216818762, 1.4571497226422452, 0.461402137883674, 0.5031438875270631, 1.632687412714833, -1.1813459103635224, -1.5470580445996756, 1.3457534519728769, -1.2916110987140226, -0.3077924246587063, 0.37905722695867766, 1.6654378384880049, -2.1496712542136596, 1.307542896545805, -1.7327927309882738, 0.3728199471422614, 0.847711465657067, -0.3408372067836675, 0.22992262067543873, 0.4802115677707807, -0.4162006826775827, -0.1285742727749823, 2.043456123440727, -1.03559910693236},
    {-0.6877224866189051, -2.64152079747839, -0.4196208277391328, 0.13164814419118237, 2.6377367769894775, 3.464170168401832, -0.02905110220462535, -1.1642277088842483, -0.2078348844688563, 0.30211750987271146, 1.4600749086164957, 0.6679544683345359, -0.28196457562358357, 0.7269463546365065, 2.3415852484785016, 2.066971939408708, -0.5550504931361632, 0.5490322210812086, 0.19263437954736973, -1.0064100842515593, -0.8121082928556884, 0.33433268883464495, -1.9562719310789514, -0.9491335065553679, 2.0811283187705496, 1.091502918083752, -0.24156012828878254, 0.05471140375204609, -0.9726966460314498, -0.40878631382199826, -0.8179222770059209, 0.8810067467605547, -1.3261704355897452, -0.5516749046560743, -1.7115571178091877, 0.31737259947404245, -0.5854407255661747, -1.0703927933337396, -0.37706772711663494, 0.3001591054596179, -0.028774120535118786, -1.9846756354714927, -0.5608005744712138, -1.3635600315680716, -1.4341548580757133, 2.7645149459469933, -0.1734177827035804, -0.6234477335463495, -0.49701573638835966, -0.715689874657423, 0.8465584337189761, 0.7523023819769032, 0.5061742013696855, 0.48499866919669077, 0.20979527350810495, -2.1173804057017422, 0.30210859504367854, 0.15527299173423, -0.021927329635219504, -0.2735620157628621, -1.2275578138675127, -0.5822879512134597, 1.0289977264831878, -0.8663854644748414},
    {-1.0930056598734168, 0.5870760372753547, -0.8234947195056251, -0.9830842521585128, -0.5888370628288281, 1.417606000143503, -0.11541055363776134, -1.2541849270680738, 0.9376909244894911, 1.4383540403189654, -0.5690579218431685, 0.3498460903210232, 1.804374281885833, -0.11786306561062156, -0.023166797026358602, -1.3698523492551398, -2.419144966975658, 1.1851342201059303, 0.20357451632115917, 0.9039138579177575, 1.0844800024060066, 1.8239425205699265, 0.9396746444101427, 0.27942208805995183, -0.03358377782911003, -1.7461705784592456, -0.6238138878999354, 0.7423463622529423, 0.051421912038897497, -0.6093191073405122, -0.13760000339548784, -1.5297014556086694, 0.034468287631612166, -1.745703550696597, 0.27225132176066585, 0.19841765449197063, 1.319103786610814, 0.2878861168580354, 3.5533788195573113, -0.5894471665883011, 0.7034339561102219, -0.6317973903453562, -0.20721312842630973, -0.8576762949378663, 1.1421226786603116, -0.6748510920707863, 0.8111432369700802, 0.07759623239980218, 0.4067294061331464, -1.5427561477447052, 1.5097100692118142, -1.925963046037724, -2.130559367323089, 1.2609526490627965, -0.8871567344350079, 1.004295708824214, 0.6456729717372202, 0.27109862323623984, -0.7201653376005491, -0.5321148092288132, 1.063595463442554, -0.9128067074391815, -1.7332153053723363, -1.5082932915686609},
    {0.9975833345238078, 0.5748761676689894, -0.9973703156608016, -0.6398518542182804, 2.3482991428969098, 1.3977042932496215, -0.8817555625095271, 1.3110287142284798, -0.6426991556691102, -0.19521664878644493, -0.8010670225842406, -0.5391714696452649, 0.68227072211385, 0.49610855911135654, 0.8827972078180814, 0.32671881323675916, 0.017943468858855113, 0.6761406148947958, 0.620485503539825, -0.7061075657386414, 2.722906739538604, 0.7742544193263522, -0.49659008813150096, 0.4575704602523943, -0.7641461652389335, 2.38967435913358, -0.03950870220893901, -1.3018422737545177, 0.30223340531964227, 2.8856625158147686, 1.6433509224678213, 1.8723949679800531, -0.5003891225371123, 0.93223618714064, 3.528603259385771, -1.8852971066793107, 0.6618724852073962, -0.19248487268911174, -0.020962654048586164, -1.6314064954746124, 0.4170760069750711, 1.255831231635851, 0.4968536302612045, 0.656078373747817, 0.6521461390353297, -0.16560817939987607, 0.45790994711189914, -1.5344980412784854, 0.9517890429806092, 1.6634465156328802, 0.40836153467063585, -1.1062760242644027, 0.41034121273516105, -0.7525076684528891, -0.7482291602591986, 0.30446389839520926, -0.48972440202185624, -0.1756336771963484, 1.3338343530940375, -1.4600876097012858, -0.35074572602546794, 1.5275254534956693, 0.7383378837778197, -0.02081788193537522},
    {-0.16790201463783305, -1.3602423775854315, 0.041519762252787834, 0.6451395779543256, 2.140152011169297, 1.9700651367429924, 0.022793180321333775, 2.6820946968552373, -0.828844040230964, 1.2994650827206202, 0.16615738618920228, 1.7766488252437633, 1.0593409095343689, 1.2823517301981684, -1.2288428546110797, -2.2050878693811575, 0.17379350724953574, 0.4590745104128792, -1.0410942369134502, -1.5116829720439244, 0.3232862351247288, 0.7199697507812525, -0.25370720960199794, -1.8338650623691657, 1.5799438639901477, -2.43535715897254, -1.6554209620452813, -0.03133976219162527, 0.15707257288181736, -1.529149615907531, -0.37025421471937375, 0.9326258038678035, 0.6654812715620756, -1.6750908846894597, 1.8722330014653208, -1.9100594244979219, 2.417316482004633, -0.5202335867081926, -1.1710784992245502, 0.2604297793057311, -0.6208527768490422, 0.24634243097056013, 0.249425188598475, 0.7212310806349604, -0.238384141664262, -2.5317558855964215, -2.203294820122271, 0.6101221240152936, -1.101306128622336, -0.33936888406222854, 0.8506634656514791, 0.27760093441520006, 0.16375050237920355, -1.144125290826717, 1.3051020745767319, 0.6489101600594043, 0.24509733698245642, -1.7488172347199842, 1.54456058392336, -0.4834788603092451, -0.626878288237489, -1.3377348199229964, -0.5065298919947772, -0.4616478940425715},
    {-1.2146300452422003, 0.3852751302962204, -1.9375154702079982, -1.6112330955373666, 1.1458845252910432, -1.1830026858763307, 0.43477327694435974, 1.6861138085119884, -2.2571707076561958, -0.9763169760698963, 0.37434475250176574, -1.5415450166486335, -1.6361292608976992, -1.4992166646805065, -1.149741120107893, 0.6411235469500183, 0.5777770714029532, 1.5060794034733638, 1.3204992138765987, 0.6879982406444138, -0.4747745412478988, 1.1026278860542924, 1.0828909406077278, 0.2625202087004314, 0.5429669225273112, -0.269109568249854, -1.7875136730547194, -0.5324673987435345, 0.36124158049115923, -0.9464409685013828, 0.2551596000583553, -0.5206472282512417, -0.7310044126276095, -0.4269364011575151, -0.3324188543573399, -0.7834028352088213, 0.0723476469242871, -0.5385644895489105, 0.5972917417302919, -0.5783789469863545, -1.446990301133135, -0.6433516932134039, -0.2783652899377991, -0.33974244239433743, 1.665209059693949, -1.8680136698501777, -0.4243416482950055, 1.675076109129574, -0.09888746588493103, 1.7216678739754716, -0.5743320507230433, -0.11487608076247513, 1.1000428095368302, -0.2189852250336264, 1.521572231042427, 1.1310394787880687, 1.076762762897215, -0.6977247606990337, 0.1911774491699072, 1.38800647520763, -1.9080678899715957, -2.189882158815117, 2.55397844779027, -0.24755896751235712},
    {-2.2690406742038998, -0.09006906938426168, -1.214487111727922, 0.15860465118828754, -0.310876837458464, -2.077455027826541, -0.6648906128346886, 0.8134690259174112, -0.05372494220491212, 1.2461103134877416, 0.12322661551210565, -1.281244158970298, 1.8609365017841997, -0.4734664929548477, 1.0740724541704025, 2.8235824635366886, -0.8142856209576164, 1.4196533907105133, -0.24931436912659435, -0.25330488695947523, 0.10334895668133627, 1.6848263775178314, 0.7055367283365447, -0.6678937618173711, -0.5192746640092014, 1.7724703622170437, -0.24987984827700227, 0.34731130417939315, -0.862865610411329, -0.40958374117805557, 0.3310428563099603, -1.3582099518643607, 0.22862933341646002, -1.081181596550094, -1.480620660533135, -2.2835449188898362, -1.492127381086282, 1.665116590947742, 0.8389707414540826, -1.352555641130077, 0.41931120838847863, -0.6342511613965455, -0.6738335571033175, -1.7569353375778118, 0.45726218613375275, -1.4029047090044708, 1.5760364405315985, -0.7270707136548715, -1.4142377137268278, 1.1273670744326751, -0.20179438017310283, 1.7316109170420804, -1.3864836900622053, -0.39630938113293934, -1.693749204322976, -0.5296233994537324, 0.9590838305774182, 2.2534299184013267, 0.8989735585991158, 1.1951851665689732, -1.6521692448911176, 0.01785507046414317, -1.0829533277330212, -0.7498911112872427},
    {-0.6644473844172273, 0.22007806557710272, 0.27818709107336653, -0.48505342017659303, 1.1776942277687592, -3.010232721118697, 1.7664344496139763, 1.2661305560844351, 1.7256145422527784, 0.1475053008864445, 0.5086287697321218, -0.37272102141553065, 1.336580728503187, 0.20689783868892028, -1.0723061160992726, 0.7308962536676346, 0.4711559546558679, 2.1072332417834785, 1.447867957954048, -1.6661722103764192, 1.9792832591940037, -0.20151029175108076, 0.3981990324027222, 0.636104013801403, -1.2697058004016608, 1.3661794395902944, 1.356077191823625, -1.5576363855165458, -0.6262705432569373, -0.6432157769311534, 0.030849870839600935, -1.8169819522520383, -1.257313641248501, -0.5556027803636927, -0.9586168807789965, 0.7102078905262413, -0.08232931427472334, -1.8907889451539415, 1.652263919794895, -1.1821396787894964, 1.4976623246103666, 0.6185599942566965, -0.5030359450435656, -0.7468608757695999, 1.2137850055401813, -0.6623247259287041, 0.6760791626124742, -1.0357348536673252, 1.2482429558028834, 0.34142809674719893, 1.115489530505237, -1.0834545604765597, -0.10994021605112539, -1.4691292427704847, -0.2715761722933294, 0.8796511946356409, -0.5560512623273719, 1.7324980784638042, -0.30743112219685037, -2.3633103928681427, -2.1504946809177006, -3.6452695031383824, -2.0381842191598536, 0.9404494677660034},
    {-0.2607220583341404, -0.3297920186161792, -0.20176773187067987, -0.12349039438462597, -0.1335169123358241, 1.764679207614947, 1.0102183852542599, 0.5159020049207782, 0.7557497221262849, 1.7565920852324663, 0.6791015880317607, -0.4892236342466008, -0.42603582755482067, -0.8556971934526661, 2.118474048533805, -1.0375866739887558, 1.6072427461043357, -0.14541741719910836, -0.8512236350176041, 0.86285222292439, -0.10301048264969918, -0.3776941559366285, 1.4755558159762323, 0.47839087754524545, 0.2524152373742222, 1.1101680746071525, 1.0767522602532844, 0.6166872318568919, -0.7137991256973575, 1.0943196554155115, -1.9287510456116777, -0.7254007308305108, 1.518791384174725, -0.9059660710782824, 0.9062919853008484, 0.3828528606286455, 0.8279869262549652, -1.9596209642195073, 0.05183381490718495, -1.2415982079786705, -1.9690557738127612, -0.7537988765229552, -1.3072341562434318, -1.3095681573458775, 0.5769753890425714, -0.928022632684258, -0.2522043036941339, 2.083230357586457, 0.4935039960273252, -0.3774393234514875, -0.05923654515072808, -0.28821991202419656, -0.7083254871681648, 1.2169327422412943, 0.8997662259666805, 0.20878829760576806, -0.048586109007750476, 0.6877742874119808, 1.0760912328995376, 0.7113052627955293, 0.3459497994214632, 0.6982451789407997, -1.0729174365817635, -0.4033829604891221},
    {-1.8341868578013536, 0.7661198799238025, -0.11718818854269938, 0.8102988816419633, -0.511002296663399, 0.7431226679668758, 0.5384855304455884, -0.891719277573521, 3.768853530954195, 1.3898631884730812, 2.1273784757240572, -1.2045596549101214, 1.1753385253915838, -0.6650782951347277, 0.42764947900471106, -0.197408769837522, -0.37603213327720003, -0.6562582728862765, -1.3890022833601483, -1.495090376911196, 0.7585760710384015, -1.109062969565176, 1.3522247419793438, -0.29936509135219597, 0.5866836166891766, 1.8081976973288982, -1.8623376638179179, 0.39204110066012243, 0.03156661281052148, 0.29721588548070477, 0.6773018198227287, -0.45343321919127044, -0.8388647884553511, -0.8219265857874618, 1.3536608845051028, -1.6011552114612393, 2.1006554847829766, -1.141586721757852, -0.983215334496712, -0.21362335858678314, -0.24708887532426627, 3.155065708315157, 0.5563994687647171, -0.6277181812688444, 0.3736487227272404, -0.3357132551469081, -0.4002523569910273, 1.5859899604675496, 1.6748692221328187, 0.5112990185422792, -1.3418937024658013, -1.0825822600224568, -0.9955484817896925, -0.2682388532462724, 1.4407563615886994, -0.48525927200971036, 0.5313765931077689, 0.3501437968665483, -0.7055955415101052, 0.030724604868292992, -0.4035780220739868, -0.05840222697103841, -0.7815772284588156, -0.3862616887928047},
    {0.2705498304558131, 0.6744717101171048, 1.4216546220555841, 0.39585522215692687, 1.0002020000563574, -0.5940198367046957, 0.7520385191194942, -1.4272700272330903, 0.6499460460458323, -0.11603335383989949, 1.3086154787401307, 0.5257063244001089, 0.6968680180048058, 0.9288463223709467, 0.4942186624355248, -0.45704974212869964, -0.6287017359512856, 0.44846553158043206, -0.5673254618314557, -0.5158595038263409, 1.2504271501209807, 0.18029291567370792, -1.4742949437521535, 0.30144366186257565, 2.045508511210696, -1.3795457499979988, 1.3461075682344512, 1.416015926222424, 0.35804122352619583, 2.2166308699936277, 1.368774667347255, -0.2640892206704525, 0.8291285416523606, 0.7740925778408382, 0.6743812669481594, -0.8105037696131143, 0.40643078523436627, 0.7787538811347815, 0.8268112921869278, -2.3109792272872207, 0.3340199480291912, -0.26200656780274056, 0.3449835038138958, 2.7981108107095753, -0.17194723768380155, 1.1302033780726166, -0.34838370647762035, -0.11164297992605479, 0.869684038391032, 0.3053197891693072, -0.6917498374180597, -0.4775155516230396, -1.0838959059158795, -0.04604689045377722, -0.8981876889274237, 0.19303092532466104, -0.763591250029017, 1.2128225156258132, -1.0348885663101377, 0.6192636878443746, 1.0701133192976628, 0.3598404995843085, -1.092237382149279, 0.5729162267930837},
    {0.8703300211521715, 2.8078010046876236, 0.047686337117564426, 0.9735072109331461, -0.027942922603322817, 1.2488230664646374, -2.0947258384601537, -0.2500159743128566, 1.1749764949881212, 0.2888767280073846, 0.016037512006093248, 0.7488895647435491, -0.39735105964104067, -0.2658652762428011, -0.5614536860178149, -0.10209417553460963, -1.7484039140837484, 0.40090691824442637, 0.11435412084498216, 1.3635016478742321, 1.1972900589275994, -0.6203333495525386, -1.0151261029473688, 0.38999449877098774, -0.22855745728913057, 1.0380173727290618, -0.2561801836269123, -0.10095121520360739, -0.5200574557820521, 1.0317843249361764, 0.1743591186437725, -2.4907254975103816, 1.5192613357170612, 0.8343585705248889, 1.7109193300061085, -0.2315001839593815, 0.0387155081989406, -3.4271099350593572, -0.23218300459537106, -1.2894864397429953, -1.179899009777318, -1.2468213621719026, -1.2316767385972378, 0.43586552261337014, -1.875002709207472, 0.5403038540118826, -2.5357943549079107, 1.2329459679709172, 2.774798093538533, 2.033908638119294, -2.5434613967051076, 0.2897289962558034, -1.90771826678511, 0.5134808181048999, -0.21530104603411124, -0.6023775536327405, -0.3798013358869331, -0.7179304267152, -1.3644077863164998, -0.8055732181785927, 0.436175446949248, 1.5365065011041066, -0.4227105119954938, -0.6535164253790984},
    {-0.5462979566229721, -1.1077431392743087, 0.5373635105044371, -0.20473854254228535, 0.15998198360000415, 1.5001518704512042, 1.5182908562561723, -1.137913532750622, 1.2161974371033937, -1.8396984125744893, 3.816228158641668, 0.10302980825900865, -0.6473502861773386, 0.28731678508686326, 0.1799493982336555, -1.7996027398954628, 0.45234323143605437, -0.40240171562219823, 1.6812009068102223, -0.41635862588687184, 0.8590358474385313, -0.013932634109655319, -0.5947484632198049, 0.8788113607789418, 0.38967590861292467, -0.974100524964784, 0.1952427776484256, -1.357939020461203, -2.331686568748144, 0.11403459992846345, 0.7879686775551552, -1.6053342804922857, -1.139403838058711, -1.6049920951067933, 1.3130648403599627, 1.2841981261111675, 0.10948438505419185, -0.3749502618014877, 0.9060987302586562, -0.5842735543162838, -0.9307623795900474, -0.19663065965156576, 1.1362061477839682, 0.44954446799910175, 1.3589154343916532, 0.2541817330783121, -0.047768875075677154, -0.2930303428656115, 1.1152034014378815, 0.4754555589763839, -0.6922874688884395, -1.993461767427178, -0.48886460519242747, -1.2414838424125754, 1.8762416600370257, -0.9063604828535612, 1.236744973137014, 0.519806735000723, -1.603360779663458, 0.03916478188896515, -1.4204290325196447, -0.4260129309955582, 0.8750682235235068, 1.532352695275602},
    {-1.6654389247394203, -0.733620191930939, 1.3171613804780875, -0.3105155052868582, -0.061600050808238424, 0.1194037414188445, 2.3831309506380105, -1.0626184414786208, -0.6147458903036965, 0.24801975574284196, 2.0191750167657143, 1.223581088941062, -1.0947951329478014, 0.3478297508977242, -1.4215463687123386, -0.38293117325294274, -1.8734318004026498, 1.7540793307051894, -0.39745742916193233, 0.4987023879652118, -1.511823050379575, -2.0259375845888616, -0.6766850314097076, 1.5633330748865768, 0.6798716821716938, 0.5256600824840703, -1.3075773844094185, 1.2249357272573838, 0.7945066972224185, 1.6682846002421647, -0.18325291611119204, -0.612897184812885, 1.3294215888734626, -0.6624811660486575, -0.9009264515927862, 1.12122862882552, -0.8965446895401967, -0.18622789122877492, 0.23713604628613957, -0.8933847704544529, -0.2916139868040839, -0.3701782235009155, 0.5502995481766887, -1.4651304140926895, 0.08442002919505101, 1.3318042755646817, 0.27395180892607757, -0.028950948305088754, 0.2356787996371032, -0.959443063502025, 0.32377276566447694, -0.45460035292206435, 1.1364920371777008, -0.7629587934015409, 0.1657586609511689, 0.3360695506498753, 0.6360135861094116, 1.9276801552127347, -0.6737718753652633, -0.9093160453318658, -1.6176256543664929, 0.6660987577821511, 0.817729039991816, 1.758044352718451},
    {-0.4752922088330516, 0.08490291971384709, -1.0082130207379971, 0.31355347558077645, 0.9496277915988157, 0.8581969746885989, -0.5304735754539779, 0.8234614922897301, -1.1578400707451346, -0.6488248036967241, -0.24697900890335714, -0.9432610962036824, 1.478340445321413, -0.8919551855762833, 2.093330546141021, 0.16430924423773252, 1.623796591869474, 0.45466018152983034, -1.5151720845882257, 2.1471697294918006, -1.0139729393985861, -0.838251593462662, -1.0468236346920452, -0.8706064894463936, 0.4231259220476054, -0.8623329707496393, -0.8230184314839725, -0.6089837100674609, 2.7887789536709344, -1.8256246467123456, -0.8046088249998875, 0.7608552634162317, 0.3377483030695806, 0.9981029492204285, 0.5206278321900881, -2.386929660868142, 2.380397129872346, 0.18088165468847212, -0.24566855140226146, 0.952957417470741, -1.4535713439532498, -0.47970750162008347, -0.44142999683116524, 2.0995424791407458, -2.2287722923299347, 0.687875004861074, 1.5873802713502858, 1.4541806489713534, -0.6892825402503617, 0.9402575660188413, 0.08053535324252864, 0.9163669379318833, 0.039226197385153094, 0.8579606125026271, -2.8365991019760113, -0.9606089706347315, -0.5757828475240987, 0.557730282141429, 0.06342709220870504, -1.1436050354665663, -0.856084309972695, -1.4589083045425857, -0.011148484328534948, 1.6890966870604067},
    {0.6749092298369824, -1.2904761025534164, 2.4660962083080005, -0.19537170869800402, -0.08403754016267154, 1.022839256232137, -0.3024375825911517, -1.432939246533369, 2.1557655225473193, -2.324733538783931, 0.28664191495711355, 1.1009933153222313, 1.8621723310377636, -0.7194733264627937, 1.6256091582874248, -0.9024420672100434, 2.5344484759273946, -0.2398143300844235, -1.4567363058372178, -1.3700888272811893, -1.2155053897524926, -0.059987926447531544, 2.0533479991057813, -0.524430283500549, 0.7941655452172955, -0.8947855082365334, -1.33907598404377, -0.008659133380026674, -0.5617140304088176, -0.7710242427070496, 1.4162577813083137, -1.42334632946853, 0.5782600383045783, -0.7742775786728953, 1.12179979521593, -1.0706792079772167, -1.0443835173936342, 1.8795205698870499, -0.4643137422305045, 0.7496754277286513, -0.07902135772352566, 1.905040536287974, -0.015616908324268649, 1.087331234847226, -1.2393071685730483, 1.0586058917897325, 0.28032916122391804, 0.6714428819667789, 1.5844197934652422, -0.10216479591911264, 0.2938798313059962, -1.0230930202540007, 0.8516276873002873, -0.20715535232951718, 0.4619429585316579, -0.1114148351602722, -0.46671421046786854, 0.5445810598293956, 0.7920426921595259, 0.8926457815688794, 1.0460367489946751, 1.2617957893234666, -0.7813778458172331, -0.1611127512038183},
    {-1.8361888867673066, -1.5081959498650697, 2.748903781747619, 0.6406964474515976, 0.6895644577265453, 0.2314861728649448, 1.8988658467110995, 0.18551834998283712, 1.1978337728928043, 0.4212862997360527, -0.3483382256552917, -1.396561036369453, -0.4666944539412458, -1.2669338376288595, -2.108682072687723, -0.6457588700448198, -1.607560954995841, 0.7433197527323121, 1.6871295630520553, -1.2976770994643483, 2.296576976826967, 1.5767050978906474, 1.3243872576053366, -0.7695447715540276, 0.1996457291713835, 0.6066879738356442, -0.7819195928631432, -0.26718451292096296, -0.6863133409343533, -0.18373356718438447, -0.5717266533548835, 0.5661124453521821, -0.16982077930452544, 0.2636640869765174, 1.3676313513979543, 0.21091352193316032, 0.879797538708035, 0.10214397654878385, 0.7480666731953551, -2.145520617001019, -0.596913472014718, -0.4712907984490846, -2.4237015133129067, -0.6021291598252402, -0.8089159064855221, -0.7033193908042723, 1.2987338888969355, -0.46231224614314875, 0.8554200868513755, -0.32583307533218275, -0.7764014951682223, -0.802306828830566, -1.6766542751407592, 0.5035264894341126, -1.3438973644009562, -0.23158191112026585, 1.1202218304316636, -2.2196319522295735, 0.9535153112620912, 0.013516110071834581, 0.5134014107902424, -2.1417070706246277, 0.6859337603070904, -0.5664656280566444},
    {-1.495001509940312, -0.11897075439744098, -0.0024868624554016884, -0.7224787637642709, 0.6918486154565407, -0.7881285852879925, 1.8475813649215203, -1.3303514029514092, 2.8018385427986616, -2.0471377365678745, -3.2210342739246456, -0.3252428197510899, -1.2035775386020322, -1.0097227440162764, -1.3558038077661487, 0.925333033681198, 2.9129831752785416, 1.785431576396715, -0.021929642168528954, -2.2894602506849435, 0.1391101891364, -2.3458713822234905, 2.458612491208275, 1.8942823876277803, -0.36473085581407627, 0.609966456335541, -0.6830980453153294, -1.0344057313318509, 1.1869387552557318, -0.971548821198371, 2.6990322091553463, -0.7737670861942685, -1.3530737358278275, 0.05594790324743235, -1.5433686716015542, 0.39393525152358777, 0.41201259435628845, 1.0060072909978053, -0.9097632504179836, 0.8256096220918344, -1.1695704213053046, -1.1141864581807297, -0.4131559616969065, 0.2851394555618184, 0.6611234536879471, -0.6065493068381358, 0.5894856310877177, 0.3680023258239726, -0.11010564071042081, 0.7280977558205693, -0.19396271854286715, 0.43535544460808606, -1.21426932999325, -0.6134279782101092, -2.7153583645513226, -0.24711874974967218, 0.0327532206059262, 1.889967571266441, -2.211388706175551, 1.0107410295663792, 3.058755827435458, -3.328031933165124, -1.3317856537557744, -0.09644208985167665},
    {0.7852140068364324, 0.2775481655098545, 0.49693715646066616, 0.11403839668775965, 0.2639808628899722, -0.7881113409065156, 0.13117729704596717, -0.006112702616258359, -0.8734278854115387, 0.10426377918005304, 1.1944350288514347, 1.5523148927972286, 0.4134247592075195, -1.5023274428103457, -1.4568877393705504, 1.2338308275222551, 0.4609548928221705, -0.10676778164131484, 0.5090575421611039, 0.5681243467134512, 1.2094242891447238, -0.8350882552961464, 1.653658803868875, -1.0970781025534928, 0.38737125240492226, 0.7154813055184348, 1.0578990654054952, 2.0124210429646565, -0.5768278040290308, -0.53213118333682, 1.1698855029261188, -1.4840982264815028, 0.9873414470876991, 1.6629880600172875, -0.03102237071833375, 1.6939509135740545, 0.25988365277126535, -1.5425015444314698, 0.1433544333227454, 0.9454392972710479, -0.7053540548594529, 0.7184188614268535, 1.4150327813404624, -1.0027979746914863, -0.8845618493581666, -0.45343121724878777, -0.8406568400582156, 0.162491237507176, 1.0956410366479434, -2.1264682559214387, -0.9724595089186777, 2.8232104252753762, 0.951101529971898, -0.8416548288878456, -1.065439158577887, 0.4850993492866034, 0.03340314580436002, 0.5553770337450136, 1.4934638905416115, -1.1969323130574605, -0.42484259065002433, 0.5173372397750833, 1.413702009544643, 1.844131505155978},
    {0.24604638068505758, 1.2938909487729036, 0.48496033142336764, -2.7333963190011685, -0.45231300312748973, -1.0220446850873772, 0.009174145152042915, 0.818173976751322, 0.8191844028724138, 1.4719646916653653, 2.2497358170492596, 2.7850922498822404, 0.05445039075937495, 0.3573938142871152, 1.085759459220451, 0.4471164983365552, -1.4388193625409245, -0.5045107372138927, 0.66489474281329, -1.3302957457066982, 1.103618773707329, 0.8456952698514885, 0.06242685487547882, -1.7088801915527139, -0.2640237605083295, 0.5963711721837536, 2.085636735208315, 1.6228404933752345, -1.3133518057961886, -0.06348903979752955, 0.20490472531698523, -0.41989367000078126, 0.8230517796044576, -0.9683778711392736, -1.9065284769997397, 1.43816878083252, -0.09627159123724248, 0.2335637644359904, 1.6878096587712077, -0.40546436623561377, 1.3043479832254607, 1.888168154767084, -0.6982384234537189, 0.32833869990543507, -0.5676247997426542, 0.7791694086880836, -1.6899153435311667, 0.7833033061999086, -2.4934411361262616, 0.6515327274913417, 1.462719526663222, -1.5211727012991239, 1.8104351686941156, 0.7593318639689046, 1.2991672978657063, -1.5456806866951645, 0.752152007165047, -0.15764613243684034, 0.18643204099666694, 1.7264678535787865, 2.0673422640330306, 2.05753027202108, 0.8332470104810703, 0.45565202347486566},
    {-0.8678181302025817, 1.9232117361122167, 2.2590045351181143, -1.77716074654294, -0.8372776234299235, -1.8701831044324964, 0.873042992849021, -0.24075902051861045, -1.4839756066706855, -0.2485314348373477, 0.0757357043779532, -1.8222466976351752, -0.6728072651508062, -0.4371546721272215, 0.266509988743124, -0.29946150617148887, 0.005578439062725782, -0.15309379734534972, -2.6523571706432776, -0.5531092102737127, -1.1049851706769713, -0.5210046907920911, -0.045545083479210276, 0.42532079510095805, 0.8268731117083681, -0.444313909133437, -0.9129792938049652, 0.5702902395545446, -1.4423484497435988, -0.8714411405178674, -0.8423802850413183, -1.7868159930360483, 0.38615474108493547, -1.2394328566257202, -0.3405151435732456, -0.5655639747515642, -1.2249907499296386, 0.6758759770043166, -1.033585141272987, -0.3244904336946279, -1.4609230509518045, 1.250083125447686, 1.109341836064006, -0.36761304244160214, 0.8492552618774455, -1.37815049420868, -0.7531095476278252, -0.47752903373900524, -0.0012774352077292593, 0.10231122684840117, -0.7558092832922211, -0.6634086695380256, 2.0924981159177714, 2.1439080680252034, 2.462113269779627, -1.9361383948532034, 0.5698410447655111, -1.145683554890887, 0.13956187471170414, 0.2571987793877617, 0.8146964095675737, 0.10158152483878462, 1.9559321397620553, -0.720393402570032},
    {-0.2910541183283826, -0.21050010432005128, 0.7395833790559009, 0.512933379245721, -0.4636192710895416, -0.3631312071924461, -0.731101248203097, -2.385161736490884, -0.2128274895410054, -0.06051452348312877, 0.009915396894176726, 1.383429333862625, 1.218952449579408, -1.9108864001874086, -0.3788309276603467, -0.32680526486920414, 2.2509103941628177, -0.4407444657901351, 1.0622239878359352, 0.38993121554396953, -0.36439898246692365, 1.2384760625930056, 0.5136495334109364, -0.023287208326748052, 1.2336081798416736, 0.19336686668328779, 0.636351539718116, -0.12364723029261818, 0.42689542962897964, 1.6637028102217375, -1.172218377636133, 0.5461178520845663, 0.09270224546066372, -0.065180418375551, 1.2765773882439004, -1.6647735487543, 0.040015691114147454, -2.462676286892969, -1.0801328335934381, 0.29963770964744363, -0.7014982275107448, -0.3519966801327962, 1.2882564910218692, 0.43529446986797854, -1.020137045718278, 0.37016571720950586, 1.6061670217167219, 1.1900192755029946, -0.6188047243624463, -0.7013341304371198, -0.39917723562164564, 1.3375202785027374, -0.08073615684670823, -0.5960167447836368, 0.13130598873659766, -0.409605564922281, -0.6991351612845099, -0.5042383801081325, 0.9153288255873696, 0.8930738329074164, 0.29640152157658606, -1.5342290437530288, -0.6081646866021103, -0.5044865722443799},
    {-0.3379037718934124, 0.317866657581853, -0.9772887024870284, -0.2574994907531599, 1.5362559613657023, 1.9759726223746024, -2.5361806215268343, 0.022072618636279708, -0.7503545439197445, -1.263729570214203, -0.2532069004884963, -0.9181891557073394, 0.601260578334832, -1.096792620742116, 0.023956376722913685, 0.10713774369966435, -0.7488474171418341, -0.4580016072582451, -0.39618576801292915, 2.74380893187733, 0.06442487488905556, 0.6089879073422717, -1.9639103750115643, 1.107085064632645, 1.44309228688516, -0.7395985151379053, -1.3645548140576662, 0.5490594820905246, 1.759039890237929, -0.6170976593989589, 0.18850643622864013, 0.8665058239353566, -0.40699278788638427, 0.006375173196744395, -0.18099803189089536, -1.1340397991341327, 0.7747636763106568, -0.6408887067297129, 0.20237975643343736, 0.962611554743445, 2.0696386279224073, -1.1659765112953393, -1.1310902057323329, -0.739901597459241, -1.1107182423733306, 1.0807938545251639, -1.3947919168031755, -0.09676175594628132, 1.060024010812191, -0.3937608317209107, -0.008950786727861424, -0.6827306195806987, 0.859965289338343, 0.7535198931824975, -0.04712390255427797, 0.16461127829428396, -0.6045381740502039, 1.0418974951529394, 1.7907334013130256, -0.7621743031314405, -2.165029182308621, -0.631420714508463, -0.1860839606913283, 1.321579350044657},
    {-0.6064483191506523, 0.9787404342155743, 0.80358830815481, -0.46286077974200124, 1.9026299456965945, 0.6461787867261573, 1.3002001379355488, -1.2017215415313498, 3.246220500286655, 0.8278009608284286, -0.8842366658700183, -1.7542901393728414, 1.063105281909029, 0.7710373947167796, 0.43591502452118763, 0.4255644373147985, 0.027833887207926077, 1.5365301505742313, -1.5675565469097241, -1.1278682632435602, -0.7213828730349221, 0.23764228733497259, -1.2515747112471798, 0.7386660299374723, -0.6690691573804118, -0.7634488434020221, -4.334149137976998, -0.12178189811488037, -1.2979102577159976, -1.081752481877055, -0.4039991745101025, -0.706752202166834, -0.6408570907216081, -1.075136473915509, -2.113483729302857, 0.5027749303094942, -0.26119823018622573, 0.6091972898245547, 0.12258370649776527, -2.1393996373447908, -1.005425715913598, 1.71714359135837, -0.22470673808404168, -0.13007131712167472, 0.5160038024233558, 0.5874937157586009, 2.993494177876123, 0.6300694808047623, -2.85806708884444, -0.49143669120551553, -0.021445013646797687, -1.6920420900385322, -0.22329043794467654, 1.1608797969192493, -0.7092726376856753, -0.03871750677035146, -0.7148172520881468, -0.12789508775797484, -1.1708976385284044, -1.6496742014840304, 0.16783073475317337, -0.024682208438253327, 1.3725601412536685, 0.7017639847103299},
    {1.7362590728491558, 1.906577399868334, -1.860390278565411, -0.35072256626171566, 0.10414394778837026, -1.8372599109282486, -1.0529281255891898, 1.5046222702942256, 1.328470798218717, 0.8772062341012391, -0.3588444713439477, -0.3072019510491801, -1.2308286200328415, 0.2312637808740314, 1.02479465887898, 0.284126368072236, -0.22309965209360744, -1.197100195622358, 0.6854971012373033, -0.15626825555045668, -0.06670484724583861, -0.310949055184334, 0.3392904611999918, 0.5796169371012226, -1.1968647918027604, 1.1674771236012478, 1.3740883396765073, 0.06717483357644768, -1.0515724020787194, 0.9651918582364696, -0.5232580817555152, -1.0282344491852509, -0.8593547370263227, 0.9129089162978252, 0.11996598303388141, -0.3558580029950446, 0.9938956022973938, 1.6729667405309538, 1.6154058709267423, -0.12402242022956189, 0.9538100545653153, -0.48501554297666205, -1.2650079107146441, 0.2548106108233803, 0.9510904617123481, 0.5905362171238429, 0.5555408490096604, -1.5022689262493512, 0.2344468547887108, -1.6686937501793635, 0.8483472866713632, 1.2005295844207868, -1.6958467581308676, 1.0194165905074233, -0.9758621993332124, 0.40791732484269405, -0.4760974227457078, -0.6768739031770751, -1.158208937276045, 0.5110866203800157, -1.2312501525327137, -0.7963503456803558, -0.14194736071120384, -0.5755501658842631},
    {0.5137786843179024, -1.6052472226820078, -0.8967884302353357, 0.38489474892429093, 0.44278682526736635, 1.0277057442054678, 1.030809835393886, -0.5283387914226857, -0.6736463140989329, 0.25315371341229104, 0.5425789571272716, 0.8399163990636948, -1.5044073531557403, -0.6997061642103198, 0.17035457631943046, 1.9955202040596582, 0.782315035914385, 0.9932695958694367, 1.0995490313891352, 0.9834804426638227, -0.38644810379706585, -1.5226774461723827, 1.1533161097986773, 0.6357369359382837, 1.8694490351320014, -0.42255559122928027, 0.33984261423705897, -1.4803306447196025, 0.8239420072502315, -0.18800651363450682, -1.6640775279130324, -0.1457253855564823, 1.2119419098595083, 0.7529230947415823, -1.1530187349430359, -1.6621414198927698, 0.5856795921736213, -0.2211254760149101, -1.7736687346752509, -1.1677684604263738, -0.4561357302002158, -1.442390190787298, -0.02123416008496117, 0.41355737653369523, 1.6132115017442856, -0.7550180640607064, -0.02269316724760931, -2.2400439971748547, 0.5640709761648283, -0.11600983492799172, 1.0586713148388531, 0.0184657311299019, -0.39251517233847344, -1.300107924208027, -0.20829969542385002, -0.14570166327056117, 1.2317083747570419, 1.8672907781976587, -0.22071405106831743, 1.7639933255867992, -1.948551045702615, 0.5160288948572421, -0.09429560829575476, 0.6087017517317305},
    {1.4545812002119793, 0.5468018825175082, -1.0092923781248364, -1.3695072655462874, 0.3923807204559247, 0.07731099352997821, -0.5878368288820477, -0.3731868589167992, -0.1512532936429174, -0.5991835481946165, -1.916054402861429, 0.009376217598545684, -0.708608206115288, -0.6484338923985519, 2.8258668808896457, 1.8318596038201171, -0.7682672959964616, 1.253824428003485, -2.0709338347331254, -0.8599052312845139, -0.5424691055609118, 0.34623278731221674, -0.967507048080895, -1.4061267897023941, 1.1644687498775625, 1.8941854097780548, 0.738742607383896, -0.07428145420566239, 0.7807664443539383, -1.285120581440862, -1.5275161551696903, 2.4440665033981688, 0.1412696982057064, 0.3932774142021404, -1.1737135461592774, -0.9690461214894353, 0.12396221662112808, 0.24592403539966162, -0.8147978646027463, -1.164380630866812, -0.7052635301813667, 0.490711754090854, -0.0016091655770817987, -1.5417468639182639, -0.9188319649340924, 0.9859273711858212, -0.3601188150061869, 0.7027855565458703, -0.27787003080826306, 0.35376405715587533, 1.7286196375766247, -0.7132407422782631, 0.9171325276081945, 0.4298765388510225, -0.5325998141631483, -0.198590249703995, -1.5143723865231793, 0.7299524292826053, -0.45790327923823987, -0.46748065449612947, 0.3181204733362812, -1.0981774687157104, -2.550361851932142, 0.19999040439710425},
    {-0.923550128175477, -0.5173390344871123, -0.7173756238565969, -2.608599643275716, -1.4838107901203397, -1.2018345448192664, 1.8011654359419464, 1.022490548306375, 0.8570983411707818, -0.8847149073145427, -0.2988810683343048, -1.5114246562113447, -0.18704149846566526, -2.600023195504078, 1.1612972749842498, -0.5877590622146592, 0.6166198309484959, -1.2776202252757447, -0.24501368743168106, 0.6399279015513731, 1.8340090485381717, 1.041334722999615, -0.19249580931782942, 1.9255463791983811, -0.5601206930653505, 2.2123192965798846, 0.9331123221147112, -0.5505552550820396, 1.2391337808971528, -0.41087119962752855, 1.8466620558836568, 2.1944120715818958, 0.37910959296136093, 0.6930819087493877, 1.6558899376585967, 1.7933840884167276, -2.5353203813401466, 1.206468146181817, -1.3843639337848161, -0.14937643634227676, 1.2967955501539323, -1.0018195859878098, 2.494253593762989, 0.7053551084901386, -0.510873724074841, -0.36487652279983945, -0.4527725961299741, 0.6704355084392253, -0.8549318229496314, -1.072739279320029, -0.2665432737794796, 0.9458129345323901, -2.4074118593220732, -0.3308816242022079, 0.26738833622061176, -2.1970051697700526, 0.15502820813735224, 3.0392629926633505, -0.7712392580791286, 0.3642180008247959, 0.05329339211560255, -0.2285699985561496, -0.2960364158272795, 0.2345474525572096},
    {-0.060404415482198166, -1.6088833209577527, -2.129685287653168, 0.7269921323449122, 0.37777378090725366, -0.5436291874606884, -0.39780510273452657, -1.6178171490858284, 0.8304156753081402, 0.8892170542689198, 1.4549668730707124, 0.66731100679613, 1.4924388240588922, -1.4020567983470125, -0.7659885158711602, -0.5680275202987083, 0.4421561348720211, -2.04785715021709, 1.10678458423195, 0.3972837022300237, -0.12702787365611398, 0.5401900028843385, 2.403931471270733, 1.471573963657746, -0.1430775231096741, 0.9123600360453114, -0.7781427534424088, -1.7050326518014305, -0.7858983018363733, -1.9814326044365198, 0.8526414353054897, -0.6585274106407496, 0.058528388633112806, 0.266070605404502, 0.0759786948216833, 0.5487247719695026, -0.722776762542375, -0.9168348664083596, -0.17164055884549043, 0.8499275905841355, 0.05437340949920867, 1.4015715408259608, 0.3257286638018766, 0.2107542786408087, 1.239524350319548, 2.2846373057633187, 0.7948897007638374, 1.3863203484358786, -0.1610371276949912, -1.8867857571978093, -0.12218820014924293, 0.34368603360381994, -0.5840389695412307, -0.07905327903194223, -1.7527013624627164, 0.3388237377696963, 1.9627347519635658, 0.6366209531463752, -0.6113736920329464, 0.8401155743091222, 0.6005422149325669, -1.6778849025969518, 2.2211997587541306, 0.689285753967659},
    {0.9908909267665219, -1.6331428914652641, -0.45665079487808385, 0.7498776984255082, -1.0938700860588582, -1.9006683611847326, 1.3363686822388152, -0.4069625245929809, -0.9853974325411432, 0.0982328817184973, -0.42798661593363413, -0.5697498096521498, 0.8155564529731303, 0.46058741526326, -0.9528865683612282, 0.6296080240653352, 1.9992278017369516, 0.987174049348582, 0.03674290332375747, 1.461895722462391, 0.049685519740985354, 0.4217793104165905, 0.2781089576903461, 0.06358637947830341, 0.09011047970190827, -1.2197202517554206, -0.25125362744500673, 1.1543830808625841, 1.1663109533438316, -0.2994807539704622, 1.4501869660275242, 1.64836822666314, -0.2898452376383803, -0.3927438343844352, 2.2361452943653903, -0.43416315538807276, 0.7042666697424196, -1.434714766703824, -0.6695182798772962, -0.564783215806132, -0.22126497785671687, 2.058092166072342, -0.7064414975496841, 1.0361273903243253, -0.29573357680005674, 1.4922069978873695, 0.4249164943341502, -2.4207628559483196, -2.5735497113299943, -0.7884500619283954, -0.5284625031006833, -1.4605552865290805, -1.0487348707630484, -0.7462576849884525, -0.1253248173772211, 0.9873128081123802, -0.3760395007539041, 1.2211534655670362, -0.6235320068107275, 1.540650447891169, -0.936865203144813, -0.11465727015474235, -0.5545896200579525, -2.7272612596214207},
    {-1.0642786397621595, 1.5986103045049072, -1.5605969565649247, 0.3367498420829416, 1.5567277366287589, -0.05993483970501448, 1.3857692961715256, 0.4797827499820983, -1.0722244245482049, -1.4855508415994818, 0.11218359233351433, 1.141189543376527, -0.5991934501668379, 0.7049208635064125, -2.766569641813797, -0.08173999690583364, -0.7229004069267381, -1.8325032758887132, 0.714661113847912, -0.6721895570558303, 0.4764485396272381, 1.4001916290495389, 0.6009890348850745, 0.8986512615695486, 0.9598601982284375, -0.9848901193530651, -0.627791886860919, 0.629319286159504, -0.28254332203420196, 1.2501127636580067, 0.15801758681777067, 0.09796580103216747, 0.889199483891478, 0.008860473942931869, 0.48286779359713866, -1.7875760852984734, 0.42930654117771805, 1.3494276959750742, 1.7480113346643509, 1.0713912915317065, 1.2277499166222123, -0.008283579995971267, -0.27719121441616995, -0.25799868847357876, -1.1533186547654755, -2.2295333041511785, 0.11306808860188482, -2.3924125241831167, 0.28270100937472803, -0.5866444311778972, -1.4510253611932018, 1.2556060522796666, 0.02820708597950155, -0.2885529132726523, -0.45911564421175427, -1.872320858400743, 0.1431238246157296, 3.0310297225361627, -0.35628628589119715, 1.8168804572412591, 0.5950606147948784, 0.7693126908552785, -1.0099588314186851, -0.19500655920349283},
    {1.9073700567297096, -0.8600227838282011, 0.02918508251763884, 1.2886186355464888, 0.8713861298257317, -0.38297559587635477, -1.2186090795511328, 0.8292487686996217, -1.4544571577925212, -1.6683404641727124, -0.07499220288330058, 1.0085426153753925, -1.4058057261299535, -0.37976188306489306, -0.24719738682108922, -0.9886142212807337, -1.262006261944025, 2.0453726292157124, -0.29248459633589496, -0.21977020887693235, -0.49229378083323616, -1.396061457920829, 0.6276929089749697, -0.23089997928803127, 1.4368339744499217, -0.45624834926263874, -1.3829746306375976, 0.6331849714755587, -0.48420362040100035, -0.3833936181617448, 1.66741450520086, 0.008586789991786239, 0.05159854388248109, 0.23113175759748228, 0.9097533465043731, -0.7623707171426907, 1.0360985718812135, 1.8653141754466347, -0.21099232745949426, 1.2252706120898595, 0.7306511119122836, 0.7429966918207556, -0.5398867737364674, 0.14603880067862507, -0.6793333368131297, 0.19276194869167076, 1.8696965826250074, 0.07956501420435944, -0.6150932705219526, -0.416637533338529, -0.6353091165393999, -0.7472180590362666, 0.7540196514604848, 2.206222492127212, -0.02121800078437352, 1.8202577065774141, 1.1905025725037712, -0.7057901022042844, -0.747504003368014, -1.799193583427474, 1.8235071883981337, -1.2013386621768278, -0.17093521004660245, -0.2826879264101672},
    {0.43638688735492687, -0.16914378871179855, 0.8916809430985421, 1.813259879540343, -0.9720237213191957, -0.36813620147595205, 0.5326363440278171, 2.4996584396491537, 0.9003903354721703, -0.25864669707880195, -0.2761080498646753, 1.0416486068332942, -2.270637959918547, 0.5694749391674411, 2.0478086059151592, -2.3371341386339277, -1.4667727269286692, -0.7009756624509378, -0.9333378048363324, -0.14085117248881088, 0.01195965572038596, 1.0242809795175056, -1.452846226748698, -2.2121490218400472, -1.5515622813102472, 0.8549934197129498, -0.5724134840040387, -1.9722691525102727, -1.5176040976302412, 0.46704419616270304, 0.7731910567291351, -0.04849713076301218, -1.0568598733556769, 0.20134641023563338, -2.06399550604906, 0.8577461032954933, -0.11917847429369308, 0.951252288848436, 0.5474138006911687, 0.24157187867812926, 0.5783307678172263, 0.06960802100274123, 0.12362135005610082, -1.2889789625300339, -0.5854877073494592, -1.1057657740377502, -0.4069296078432848, 0.757286152338129, -0.16083463955650137, -1.2740424262530003, -0.20613940986342866, -1.3590750628075368, -1.6592863379439224, -0.5581882225779632, 1.4976453351798353, -1.21002135673343, -1.0778048604104473, 1.2747641726320573, -1.1677415241009719, 0.095704995422348, 1.841777707634258, 0.011777098878506535, 1.6395958114324096, 1.6320519300736909},
    {-1.3440961502538606, -1.2128092920824103, 1.9671309663568861, 1.3111436868033672, -1.0502685860602012, -0.3693794670680823, 1.1062904409131653, -0.21566009416561066, 1.11571109333406, 0.7495873624908793, -0.6492979638307891, -0.0178622855570226, -0.28680344040658556, -0.20189062942371194, -0.16486460174053866, -1.1651833778419556, 0.7431146048846281, -0.7856702697734232, -0.8580077976309861, 0.08175069805104712, 0.77897073093626, -0.6278104550296595, -2.6606584166485554, -0.34986631746927477, 0.45296423681007625, -0.8431659881386172, -1.1672812427543584, -0.2474850985686042, 1.40019066096193, -1.4693706634631252, -0.6779513472115798, 0.3093774233868251, 0.04897756624789909, -0.4539553990059574, 1.5192808496500618, -1.2006155817776267, 2.091210738241153, -2.386126460061745, -3.0333340646571183, -1.0607111832041363, -1.5331582408346902, -1.954664055908293, 0.4355884728643443, 0.5813984439244767, -0.9615578153640272, 0.6719882503624734, -0.9109443024709615, -0.24310820901774846, -0.010097116278965123, -0.2932912651614592, 0.3412411357369623, 1.3707479116431223, 0.8431167331583307, -1.8209432057290917, 0.5421220629494123, 0.23798448459049545, 0.034601075497537936, 1.8405316839835089, -0.22072247529271274, -0.14413068141561838, -0.0018344868696496088, -2.8609089690486176, -0.018423382936917407, -1.5400527791456313},
    {-0.8959900524070887, 0.2830369185022672, -0.1908325844748846, 2.1648174474424997, -0.6208085974756149, 1.0833698066351232, 1.2264723870048002, 1.04466873169506, 1.7185257053754024, -0.9517415140778632, 0.9550120733664956, 3.2139956117655863, -0.3233396257366439, -2.7947301203235875, -0.5704520525708315, -0.5276678807269396, 2.448749256247403, 1.3234909589050663, -2.380262986404234, 0.16164691406204162, -1.1984283051019526, 1.2949298240176903, -0.2324190291781203, 0.7682161051405534, 1.899971958046762, -1.5832313604586306, -0.07838674547187902, -0.8337863866369202, 2.6824024512356592, 0.16256584155330708, 0.5770346501594106, -1.5331969517536894, 0.035547950774849756, 0.3740771015080225, -0.813321890892726, -1.2912804151413722, -0.900788126510101, -0.018328520689816236, -2.415065265997802, -0.5276277505854262, 1.7769309496709804, 0.2289645223927356, -1.765341548125424, -2.356899617272293, -1.0827168558206377, -0.6665489810020141, -2.530841790665375, -1.5293436594614376, -0.7557679726244086, 1.3236831717117308, 0.9149257186565473, 0.9704751996584765, -0.2068918170572455, 0.924389682031556, -0.8675818453633066, -0.09572451078616183, 0.990694727089629, -0.46160501074704874, 0.22456038433449496, -0.060137541673981575, -0.8433376653825607, -0.005302912946528585, 1.3481389227147587, 0.23331269088699655},
    {0.33275902058858714, 0.5812333566396394, 0.990018480774104, 0.5955221464568569, 0.7606717371664216, -0.10579568617733816, 0.8183636035258436, -1.1855352135200519, 1.0292640380521254, -1.0233102518231536, -0.5677420663606638, 0.6567162945426431, 0.18240065054610347, -1.165811810568104, 0.015721949222335743, -0.21226604802023816, -0.5632125224052383, 0.917952240201941, -0.8948404290986253, -0.6280677188706326, -0.7716974148144137, 0.7297058476240262, 1.454144419741115, 0.7310077076150282, -0.6004450165187573, -0.8361791198821297, -1.2452093101757356, -1.357579349133347, 0.1646994592208259, 2.6990401145151637, 0.9260441564522097, -0.3317162830366802, -0.23744965170589258, 0.430561084086224, 1.6535944031494825, 1.7941434294543956, -0.07261312695268447, 0.6617932211351097, -1.639070367975843, -1.0001340002755312, -0.08535512076437712, 0.16823480879856162, 1.7979953909569826, 1.7813016735802014, 0.15013840466871672, 0.6229794367971101, -0.3315567012436047, 1.1443391706897572, -1.704042525234911, 0.3437678664110734, 0.5694888068741684, -2.1486542462142384, -1.287910214553251, 0.22731373544525543, 0.5272526708713005, -0.8835400211805102, -0.010820615106193329, 0.23010962574792473, -1.3077418278526711, -0.847365009477218, -0.07432998810327295, -0.14551176471101424, -1.0643875254706605, -0.523178687044025},
    {-0.3776430099207845, -0.932696965786874, -0.8705474689939219, -0.07774516545741396, 1.532962351835446, 0.0811123164006066, -0.16768282462150247, 0.22561705741087218, 0.4932705866131274, -0.32355369612710344, -1.8835113794288778, -0.5827536522976773, -1.0156537104212569, -0.8984079814509115, -0.6421008730334061, 0.026273080844409318, 1.1835119281229824, 1.7733613172623535, -0.42218203051544634, 0.18007607577213378, -1.048198057825336, -0.0024737001740680518, -1.558031838248639, 1.5110916714311242, 0.08378827404440013, 1.8010458296160388, 1.7375481053870514, -0.8779260699438068, -0.19646286599174267, 0.5567091887360385, 0.911535970348693, -1.3309379749803347, 0.05307133672846882, 1.4868754136197866, -0.5984644273999785, -0.3291251101771414, 0.9583225651992414, 1.3886440150217134, -0.31097556250190733, -1.2975194414780316, 0.023321986748471725, -1.5661516614039386, 0.6903320755090703, -0.24313379049830625, 1.0001605063002703, 0.5549625896252968, -1.9076848546938021, 0.14924947439642075, -1.9876180632594245, 2.066946677311157, -0.66408219543449, -0.6628454255735806, 0.04397838943758068, -0.9292604292834781, 1.2084040242318692, 0.3005501339452422, -1.0102888202864815, 0.9963137670927784, -0.6680207912521249, -0.36763888431900976, -1.3153222601300365, 0.8091915042785595, -1.5253618324761573, 0.13253985421651968},
    {-0.06482678499714427, -0.5615530751274487, 0.07331321446463698, 1.9204686386199261, 0.9827433139800614, -0.9712109567237045, -0.4924700453484795, 2.3001451437306346, 0.12840475220407463, -1.4718560430727325, 1.9251571136761332, -0.34922379583323276, 0.15642272382117342, 2.8302689287855096, 1.2427978275924219, 0.9472142658168186, 1.2160541265651543, 1.133027840115426, -0.6611748325509942, -0.14482432560286262, -1.2080881056545796, 0.6561799169879903, -1.5836590770223244, 1.6574857180986429, -0.36902734358992756, 0.03637958414627153, -0.5589210243880338, -2.155116152738165, 0.5197654103175827, 0.7201630149635476, -0.1993873765256805, 1.9903256421794244, -1.9485733638831437, 0.16728964762859214, 0.5035220083055869, -1.1941903466807113, 1.4073426795864334, -1.0389385483007578, -0.4916578606779183, 0.4237615038414059, 0.9322374255105633, 0.23024142031101844, -2.1960645311843363, -0.7132705964238267, 1.315302379744208, -0.7589902467746698, -0.9873799469891936, 1.5564008569002885, 0.6294810481718364, -0.6996117530986159, -0.9274563755048961, -1.8040323565955092, 1.4673136242842086, -0.7079392915426201, 1.6817397433310006, -0.20383224485401524, -1.5964677798326612, 1.3760789774785442, 0.7402602905060003, 0.5279941726489465, -1.2196797304407643, 1.0427247327188458, -0.11164739275072949, -0.6127760895983948},
    {1.7274664751995674, 2.4183500014905497, 0.46936763611449245, -0.40389837029022496, 1.2624259789077987, 1.0876042419858096, -1.4210468014580337, -0.46950131830751884, -0.24531565795443314, 1.1646931511721434, -0.6549090892504835, -0.5233708299383542, -1.8351180177645148, 0.01069811508192457, -0.10668268029569611, -0.45258528312080315, 0.3705397194363493, -0.48795541788984215, -0.11763769024273067, -0.15915100541052485, -0.23158533998894135, 0.7272100490128538, 0.4396403774094096, 1.139451598210875, -1.5534289181273142, 1.0622702348742414, -0.3942685878759818, -0.492792030734627, 0.5107902203001593, -0.011183062048717838, 1.6709393289553955, 2.117415707360247, 0.4991192856054286, 0.5692707289675172, -1.806685348128739, -0.08087435522926066, 0.14817271404007715, 1.6263838145905138, -0.08959510055136459, -1.3170612724612396, -1.7660321012486586, 2.865996850165538, -0.11455372022018087, -0.1328828856125734, -1.1014558016330662, -0.17077191830876526, -0.5113845780220907, -1.0015486766569726, -0.76128651772362, 0.20236221943768956, 1.2980075434814156, -1.187111264326888, 0.283284207827745, -0.45033886348275703, -2.0677604134796157, 0.2651723884200778, -0.565270944738686, 1.4975800702847832, 1.8793776680394436, -0.7792727245644492, 0.5943254788180135, -0.5175243844160031, -0.5805708672179982, -0.6830628291807347},
    {-0.7128250971695056, 0.2024872008302613, -0.2022401885149467, 0.061039495684762364, 1.4403463677157786, 0.09162693737247027, -0.4019139437909116, -0.9235642421698489, 1.9579412273544539, 3.216313136756119, -0.029330859497030255, 1.6476458912273078, -0.9895504216633905, -1.0502696759981607, 0.5075822744770605, 0.9995257765996927, 0.20840840684644124, -1.8913775803592685, 0.663977090034033, -0.22153042859730876, -1.4108807525105003, -0.9382091956969473, -1.0826327648803071, 1.7573260597020084, 0.5560366581175746, 0.9567656255410711, -0.2174002275587618, -1.9552853474692278, 1.8872467266251636, -0.2419377828218703, -1.7119572587821292, -0.6717183140516333, 0.6094110188915453, -1.6055049999497983, -1.252872771265092, -1.6549916023320848, -0.6057028630824169, 0.6697697077941482, -0.0710443937218293, -0.9519448291157468, -1.7396930404937416, -0.09258762102275908, -0.6265664995508343, 1.0489613562001372, -0.07595869818857363, -1.415844015738948, -1.0142295301839763, 0.7217709950421949, 0.3364745505777527, -0.8063608641607709, 0.8241128435599163, -1.2315105215068418, 0.8287209186376652, -0.047720798918121435, -2.2030576311557155, -0.17023934518612244, -0.08962297789224904, 0.21295501143665077, 0.42863438487989475, -0.8340156642693869, 0.47616110810466145, 1.9454425089223122, -0.6129108250675162, 1.4548396264683754},
    {0.8638609233491854, 0.45143205760127936, -1.8512161697787433, -2.1681926734042065, 1.7924304827645172, -2.055493705119229, 1.465244490899505, 0.9868172616696302, -0.15361197662286288, -0.3913458019025872, 2.0339583232819907, 1.6383219718304742, 0.5453832430681036, 0.9048565290531112, 0.8455885197793652, 0.7827250930572801, -1.9501907778827645, -0.6323707703318504, -0.3752626401128165, 2.5136910262339027, -0.2812537466093472, -0.22873501026467372, 2.676556323108875, 0.5833201659465103, 1.0282455005655922, 1.6261225099912133, -1.0295027819058862, 1.2031659498854388, 0.8216024312723215, 0.5434435952741119, -0.5169236232311746, -0.07184841352946032, -0.5343702064112438, 1.4412870112519154, 0.4876479757605125, 0.2308079803403884, -0.21012889334012466, 0.7414924360724148, 0.49079971525937666, 1.9421466851093745, 0.8079654110512139, 1.828246636128593, -0.15397658152645047, 0.7711246290268534, 2.425934651591097, -2.114760767368462, 1.3984146703062568, -0.01547722472953579, 0.4865323683588148, 0.6989699046231094, 2.328575530066872, 1.7819698617081376, -0.5487509927266541, -0.9421234898391625, 2.6493515869559876, 2.015745476325671, -0.18991314157235123, 0.9073482401475174, 0.6660104900244356, -2.7098039917812144, -1.1151759626856415, -0.7370501665665911, 1.0677408735901655, 2.14028592421213},
    {-0.6183587837711446, -1.3583628033046777, -1.2554480121579341, 0.13708975664243628, -0.023773964971535697, 2.5962155851307442, -1.9864986097638657, 0.7599827852390221, 1.281741271736946, 0.3666092797448608, 0.03744930939484916, -0.9095515343925443, -0.31995790925259315, 0.8500688626022429, 1.3947515717911094, -1.6604977912738825, -0.143782652377881, 1.2563128805899133, 2.680199481034604, 0.3276179829692171, 0.10356484528400907, -0.696843814623835, 1.5260626730234916, -0.044569910003569996, -0.15841247932287444, 1.373574160065999, 1.0462965799706465, -1.1955846427949233, 0.21605589605914563, 0.13244192906430752, -1.7055413853907837, 2.2487732966327485, 0.8636601984606077, -1.3599018405828438, 2.2623340423537046, -0.8984669577869269, -0.3031743061474209, 1.251718898052314, -0.9547552648485821, 1.5691471832576025, 0.7098677928413039, -0.8906197184688136, -0.22313164834064564, -0.4022294226528835, 1.1252561896030073, 0.5127724433210585, 1.5910394264404748, -0.1693651038262408, -0.21337939485644863, 0.37067230799387346, 0.8953968713335886, 1.5333444741078257, 0.027069319888602516, -0.5141287886179786, -0.2634642782517675, 0.5615940564596785, -0.590173323963203, 1.1266551709436883, 0.3412906460170746, 0.61613594658403, 1.294199002196443, 2.3404424157266708, -0.9550495679243184, -0.6141824722563666},
    {0.04902565715119696, 1.8126950534332993, 1.9441678861329919, 1.2925309991840193, 0.8165363364957794, 0.9688097397282437, -0.5652043479152925, 0.0052898215159830645, 1.9110959681971242, 1.307894202699726, 0.3112609709253246, -0.1177596593802713, 0.2987733600181304, -0.47491511869291486, -1.3718375099274644, 0.8754053564996084, -1.0745030303796534, -0.7554902932745265, 0.5058862028815684, 1.1371701324073245, -0.2654104406795669, -0.826044001560555, -2.374321339973525, 0.8898478387082768, -0.5864684778931772, -0.21262596407796372, 0.4992302209497278, -1.3810969849373005, 0.5696250168647768, 2.301872388074945, -1.3897950409633777, 0.589766902800733, 1.7079606737673052, -0.7692815237481249, 0.5500846600968697, -1.450086785070685, 1.5014789039004086, -1.4572870472530268, -0.2134758470350652, 1.3638899809612737, -0.3043551898888727, -1.8046757299682727, -0.045575767004216304, -0.1654863347257376, 0.22352262561286432, 1.1670897811328766, 2.2142810197871405, 1.0803287088751523, -1.3041239360235846, -1.7933182570311876, -1.6250677686371175, 0.9136364639853213, -0.6351661622165514, -0.6301364786683367, 0.5707479628376775, 0.5234463492995949, -0.36447455770237447, 1.6418791222584526, -0.7835927863164364, -0.9253399934654514, 2.0241245507397214, 0.8796193221446136, 1.0980905215545802, -1.223472857597499},
    {0.9511735444767848, 1.159771452162778, 0.7154152467420131, 1.3623883567155255, -2.207880795679253, 1.1159213433117503, 0.7672257037254062, -1.4446454013536407, 1.1918964460140566, -2.2398705210543577, -1.2850494584537036, 0.6312867980775206, -3.1627028780611064, -1.0545352302989721, -2.2103262608233747, -3.140347492610537, -1.0233867625090134, 0.5474185816274587, -0.7587855841726824, 1.5044376695726087, 0.986746853235626, 0.24842040334269355, 0.3504880638778905, -0.03308154754706229, 1.3363572504450671, -0.3311065059408558, 1.982160005560613, 0.19990018577756782, 1.371726888372876, 0.22239446138737126, 1.159825114550023, 2.1266244107525396, -0.597077714537891, 1.1563325220645337, 1.550024911348619, 0.7526384210694625, 0.5775514340128141, -0.8159578714803697, 2.446699361231181, 0.4792371636582228, -0.4527896904041357, 0.30195743374857803, 0.48624900904379076, -1.0612760784955977, -2.1879656195752655, 0.9339206648383238, 1.6193869714351214, 0.4048315291103946, -0.9696673024783827, 1.0871591306345254, 1.143965333872402, 0.37876951769353545, -0.5608573527572555, -1.3620303540672418, 0.38777770022221547, 1.1673310247427047, 0.1055447757897725, 0.5693319490147258, 1.5278903863865905, 0.7309786496173682, -1.1033473286659743, 1.12124820868972, -0.36060400837114565, 0.279831963312461},
    {0.6944623589906344, -0.6375267137273721, -0.5296450710619913, -0.40949871813669825, -0.17499854291595715, -0.7090499242509497, 1.3534163272018436, 1.6784957752376184, -0.21368579791563053, 1.2711668411751442, -2.173958547248849, 1.8854831320787935, 0.5709917823431936, 0.5560050783174555, 1.5042959581863313, -0.4783861564722518, -2.051864433352208, -1.6308632487168562, 0.6513848482014282, 0.1613160359981786, -1.8023444113367304, -0.6065777959339559, -2.028862001365979, -0.5952223114976907, 0.13758184085452005, 0.27792541627289735, -1.0682825794468762, -0.9771996431965512, -1.271178918276484, 0.16710181488873485, 0.6966680069768979, 0.14130762903752303, 0.8377172666806972, -0.9771061834735111, -0.10117395839244539, 0.9007354918413387, -0.6408782514869862, 0.7161042586964078, 1.1228737377206408, -0.5915608156369072, -1.254626410553189, 0.9624050679048907, 0.8823122313935241, 0.8801910341438139, -1.298457881945246, 1.387612904655019, 0.30611292021430747, 1.2795014002422946, -0.06062480122175513, 0.6500390207065443, -0.10936698948059402, 0.9004937021780558, -0.1877639698575839, 0.7340613946309716, 1.299289103863944, -0.16081622363448064, -0.14735693551841048, -1.6088747598417608, 2.0791975013820094, 0.757851502995315, -0.219246188365107, 1.139836785166161, 1.3034307458211425, 1.4476357205568746},
    {0.8021298765061291, -0.09198098399407896, -0.9051184925063227, -0.2670728062293329, 0.40987587515558166, -0.2828723771467813, -0.05024429662440297, -0.5547950824904501, 1.5885624977439905, 2.149295036971546, 0.338644449602221, 0.18260417819396055, 2.152198586163191, -0.9838988609326655, -0.09548997822072557, -0.41238772403747775, 0.29441452480101304, 0.3923421768174158, 2.0140617182709595, -1.518416817315187, -0.32836259420815056, 0.8292360837468653, 1.1561227453688514, 1.4317023116185494, -0.5382194982805992, -2.396534412755904, -0.8181990782241905, 0.29728331919814815, 2.584742487596899, 1.024888923274389, 0.27700193491205005, -1.481389992560424, -0.9076802734344815, -0.17881495126323926, 0.5996221860533717, -0.5964349810773187, 1.9293171377986704, -0.5271335999636195, -1.047227483085505, 1.7026935044984814, -0.06540735924604411, 1.3905965032045933, -0.29135418924203593, 0.010591735006919416, 0.946134466332001, 0.15599853580844256, 0.4962767269388637, 0.6278610108480401, -0.5404906189272664, 1.0046598336611074, -0.09873310258137638, -1.3727725976113416, -0.09951502006701593, -2.2250272772197612, 0.24215252846388508, 0.6115711723189284, 1.6373990295967302, -0.806054558130239, -0.2566236106444213, 0.4266659474376444, 0.7538791662271962, -0.651381024947209, 0.55398717089968, -0.10795156989504896},
    {0.7784187994841919, -0.2827892117234977, 0.2768516755538712, 0.8646639546935658, 1.1359330155995426, 0.11936459242686707, -0.9680003453280467, -0.44107674985317896, -1.7919144498707937, 0.8302890554560274, 0.21732493828476593, 0.9276061318731742, -1.6530582769427205, 0.27600047997200294, -0.6568399976243894, 2.2240406816228324, 0.7182103385677219, -2.5029765581467927, 0.6006168237679157, 1.6253781214176006, -0.14244781126556028, 0.40960959517737955, 1.339598675071445, 1.2829816192308758, -0.38906210827411175, 0.7322442401947001, -0.6741620765832317, -1.2702186464080545, -1.3041256302264486, -0.056117276470847834, -0.6165992173428407, 0.07270165073613556, -0.6020276745981726, -1.0415611752002667, 0.8527250501147967, -1.8647715265892086, -0.9305800054023745, 2.8321402915349463, -1.3504130430629198, -1.280962574774409, -1.4911250633169926, -0.4597714967650219, -0.6896194312375322, 0.8914667576181127, -0.8250498157453606, -1.580466676634515, 0.8329661552652917, 2.524971080965658, 0.1126167054625121, 1.419308844469213, 0.45007548200539993, -1.4215893032911044, 1.2216973134691325, 1.6792363205946768, 2.430321395050431, 0.612232032288416, 0.8607446842255442, 1.0105668679868496, -1.971576704117109, -1.377513165176656, 1.8984547114623573, 2.0070959294418858, -0.04579163971803255, -0.3811925468043536},
    {0.4889857134531831, -1.6181463769784712, -0.5875312432549725, 0.6916223288050224, -0.3928436507452419, -0.3488305424596165, -0.21028629043050798, 1.7978845837575717, -0.0771922058636736, -0.758726319464076, 1.3064704727905045, -0.3300730845633002, 1.9920583332920432, -0.2516803939067922, -0.6733777979159133, -0.9187947913353393, 0.7250766225179015, 1.4623146472516744, 1.4603857207691584, -1.8691273830708581, -1.1014591613204312, 0.6696460737119331, -0.985172771817388, 3.22027978447706, -1.1890237034472175, -0.5499837220202125, 0.20855371919390187, 1.5542554742819719, -1.123680277752172, -0.27595615171346066, 0.4466714997154105, -2.9319199180923188, -0.07435798694561878, 1.0741313966253887, -2.0774963251076537, 0.8847914241756951, -0.7385034437494123, -0.8906132638891235, 1.8162107232939861, -0.7450235427707104, -0.48838996656137074, 0.5089363488541561, 0.23651107142409716, -0.18299580465426335, 0.42730270148509697, 1.5241743608034448, -0.3592388732282245, -0.18769162374216583, 0.9487626811884109, 0.6077159834629985, 0.773771939275373, 0.2539319699722901, -0.9071298035767578, 0.7367528961355112, -0.33368050437387065, -0.33812735972082597, 1.5879885206572733, -2.0090646249987976, -2.636649432389508, 1.2714197151424584, 0.005035142497765401, 0.010981325578897428, 0.8895569541441014, 2.3892814558937365},
    {-0.5537935595765308, 2.0176943941904097, -1.8157409224418828, 0.7646856328215408, 2.498798203183804, 1.3991130426222844, -0.3287055080491857, -2.653685484596039, -1.0783972679559, -0.8363274368456475, 2.327475319125143, -0.34712733720755495, 2.51430617214501, -0.93001515703637, 0.5423517276466114, 0.5119660221894289, 0.42259592453203476, 1.5424740653015616, -1.3897981214182191, -0.014826117653216498, 0.5000139276507094, 2.730992377643018, -1.396791705085832, 0.6798457939235877, -0.2821558270584348, 1.5592584062357748, 0.41200973532696455, -0.6813129256354828, -1.0490192472360376, 0.2892061948155798, -1.2186767630760968, 0.36431147557535626, -1.862212061000466, -0.8476670764902263, -0.9388020408112304, -0.08661104214438209, 1.4540700410527287, 0.42914477901019304, 0.12087622706894698, 1.0150383901575046, -0.13296342869553, -1.0485323149697048, 0.9840494855278957, 1.4062772255760976, 0.9895477775592729, 0.5622410957783457, -0.5374337281038291, -0.4047223775346139, 2.2776484344540946, -1.6176286236121582, 1.1815876243951686, -0.16063876589620152, -0.5283617147673269, 0.12122939948607378, -0.5862960481784538, 1.2142557049302498, 1.947319884675505, 0.8856202110923032, 0.17679297243303135, 1.6253374840002517, -0.6792144531766955, -0.3539926765921153, -1.791896304915829, 1.8827993825970886},
    {-2.360982101394677, -0.43769171334108486, 1.0215308387474267, 0.9267211977286673, -0.35956293183707616, -3.0099589986655113, 0.47173657938167535, -0.5804828315579555, -0.47558159323883475, 1.0919748876457, 0.9660250900494328, 0.6719997560124736, 0.29121760830302784, 0.6747921584341715, -0.009571686162403328, 2.099060176108759, -0.3264917800629276, 1.1797914117077808, 0.22456735620908133, -2.737778193866156, -1.3507805677138967, 0.7538982372078793, 0.6675400932616259, 1.7957976867563585, -0.5008695620171003, 0.9321292304851011, -2.018351661960912, -0.3880801451305754, -0.5399643122128687, 0.20849490525830247, 1.9155491743989566, -0.6171275798970035, 0.6355629278639313, 0.35153312878505083, 0.019912124149966376, -0.6744642028181075, 0.06776069089950754, -1.3860040961793745, 2.2188432422227655, -0.8236507135222535, -0.9435038929393685, 0.8294621807634154, -1.0981515788936802, -0.40437027363863787, -1.9098937516951804, -2.9099663516822187, -1.7445036868503807, 0.7278739673277147, 1.0387474069374272, -0.4457394394296301, 0.7930791518208846, 2.7291127637060515, -0.8176353592738196, -1.1191666657525223, 0.4382658226377784, -0.056079274578292836, 2.0689398147869915, 1.1203288517658812, -0.9715083883356671, 1.571068132677119, -0.646829621690393, -0.23730996867911824, 0.9359175736263845, 0.7926276540256884},
    {0.5949496427160056, -1.4275852399973488, -1.6848500940546989, -0.43409990784384644, 0.30164177779239293, -0.13556006704899312, 1.5806028632957867, -2.0057734335924664, 2.2599000858654605, 0.5077393091585968, 1.573278253154104, 1.2761280891628675, -2.1053458973318153, -0.08125703026010193, -0.3758323186558561, -0.04988640437089669, 1.2866792132278926, 1.3224212327413651, -0.934545562450718, 1.9362132479994645, -0.9679709040159327, 0.7391221136227676, 0.8573428017099012, 2.823449359612268, -1.5902173854387394, -1.2917493371261126, 0.27560835986731747, 1.6333293172483514, 0.07892640758510604, -0.9667645331636132, 2.126788265404769, 0.40957405123310064, -0.7459787236328663, -0.3154179976621123, -0.732791356829644, -0.4560175455084514, 1.7046300534388883, -1.219472127900797, -1.1281726698006656, -1.6066729130245092, -3.0195327224821935, -2.3268677246198477, 0.1882567044588861, 1.13079595409372, 0.23628168235669783, -0.34060420223276305, -1.9000664870115427, -0.1885563717132052, 1.416973882814794, 0.011303412990439925, 0.7023225719079232, -1.7700048869921436, 0.4792996068957211, -1.9135234237186522, -0.8629806144840961, 0.2039437029376884, -0.26085913872088334, -1.6292790248160194, -0.8151732806953773, -0.2193433750609846, 0.09481772311741626, -1.8751630127284962, -0.7116627814089621, -1.2986268147903035},
    {-0.2764221014853443, -0.5938147186069649, -0.20414490284543577, -0.5955936478945462, -0.0322943968322384, -0.732226305337946, 1.8470845178772457, 1.673702391385168, 2.1874946496868666, -0.7339319929197529, -1.0352315213641996, -0.9858510591489481, 0.12130394669091757, 0.6629093743085793, -0.24425358764195118, -0.09554890810750308, -0.43465946786391235, 0.3513936806290741, 0.07903101458220274, -1.5073414578282907, 1.2911836593084673, -2.1301337757379764, 0.3907967732230496, 0.13288557941006196, 1.284453178200548, 0.305655599001744, 0.900325595718033, -0.5780531521988612, -1.5659647202319849, 0.49896025631325086, 1.6617018288536596, 1.4733731039942135, 0.04113955763214239, 1.6261297380963733, 1.0887082552590985, 0.5307695734777741, -0.1555801566129531, -1.5241408703380797, 0.9477199574013809, 1.2447445818063982, 1.130725248073174, -0.23401937922850907, 1.7641123990542569, -0.8032494577322346, -0.7564243626045394, -0.44498501229875365, 1.1590903985451948, -1.9038785721722644, 0.194738406490596, -2.1845683016272, -0.33050236499026975, 0.13528438850086386, -1.0709965437644038, -0.0988143764862397, 0.14481038242315294, -0.3221966100589099, -1.1348141549170514, 2.8461826922865163, 0.3869654446073813, -0.6970684739397606, -0.04963744799882746, -0.20036459854426844, -1.9334954012176382, -0.5280063371932344},
    {-1.1925147632762898, -0.07079057407481217, -0.44713113436318247, -0.5465486958325391, 0.4813484948472612, -0.5751884189380811, -0.7478167964719861, -0.42358523528305575, -0.02361019586943117, 0.03224170911321741, -3.0256284760856977, 0.36363626032809704, 0.17572030589692023, 1.2740329740789809, 1.408272382923983, -0.4524814827841313, 0.42650786282370173, -1.8897712410222183, 1.9215050622179244, 0.6382294586027956, 1.0384176751625052, -1.1303626693109279, -0.838807253987768, -0.09527250400413903, 1.4869669681670714, 0.3605217784752819, -0.15774331598168567, -0.7099001639329782, -0.7302838675352984, 0.9031861241402248, -0.3304007540293535, -0.7934804365696496, 1.391482721579019, -0.4602572597036967, 0.29857809605183805, 1.1248245338049718, -0.05196171965325666, -0.8433151261298754, -0.22225682182864054, 0.08073831455925895, 0.7288973040882951, -0.790068993538248, -0.33199807316321894, 1.9675371518385556, 0.4437606960913794, -0.44688637282279187, -0.6489576108718911, 0.520296001106622, 0.3986904999294714, -3.02018460769718, -0.9677512237703095, -0.9209581888625618, 1.1870237331525522, -0.48252311110430834, 0.0461887645466592, 1.257057504516113, 0.41900586991550914, 1.8274770021504376, 1.1272464959546837, 1.693699811854388, 0.2641267900082781, 0.5547305831816827, -0.0036047425509593486, -0.9919120931162703},
    {-0.1306261810775165, 1.0358419946083133, -0.6312498815231182, -1.4149841858678973, -0.09349110951851052, -0.5065526535557173, 0.5125172937973231, -1.3327048283745795, -1.2520797054548582, -1.1655734241821838, 1.5812526667645634, -0.8139251220672018, 0.02136449653576601, 2.4489260931703916, 1.0715171618005443, 1.1945110679549393, -0.7371831763147491, 0.36786210589083207, 1.2943014100267787, -3.3559860427422126, -0.3982534912278655, -1.0112025753880127, -1.2609356458949357, -2.4346677118151523, -0.876259565788655, 2.315773794014008, 2.560852824287247, -0.386615198309897, 1.1087435375808294, -1.165052636545278, 0.028809701522719878, 1.2612655351225932, -0.13923171520427555, 1.10491739692873, 0.04506466890804368, 0.5761175878490719, -1.5099789315522014, -1.095741217565819, 1.1982189068001057, -0.38958543730075135, 1.3434214416308543, 0.40616855060186435, -0.9098522414806705, -1.7984692758158292, 0.2803957596650817, 0.3339244778779562, 0.4766888740149741, -0.09332256221321211, 0.29701074197962024, 1.6081185936604463, 1.1185138128443033, 0.24164434091385203, 2.3465859365073296, 0.8236753303498551, -0.043775275965481586, -1.1576241085267875, -0.8601297717049031, 1.9046506435149229, -0.8820983932130161, -0.8017433628694935, -0.4153837919583845, -2.1662825852456553, 1.0265770522489706, -0.7464269966178885},
    {0.021244960433660146, -1.639594615626164, 0.07125686537034362, 0.034627721379733786, -1.7160852777723083, 0.3470124255291006, -0.6101917293057677, -3.0305117821169296, 0.7998023783015944, -0.8364455203060146, 0.23372711572387864, -1.0304499193291616, -0.5971826348813222, -2.318760157190018, 0.2478151402026141, 1.0356384480086043, -0.9823911102018772, 0.7072073302226931, -1.055658390357459, 0.2563261710807411, -0.5400180128273461, -1.710275018826563, -1.2807258710145712, -2.354726111795429, -0.3494626259260929, 0.03197065898587295, -0.3946760995328967, 0.7678711454354802, 0.5352562205286966, 0.8715531725824297, 2.187993630115396, 0.6834401957872508, 0.8608730235390362, -1.3862777285915886, 0.5786549387139088, -1.38594127538503, -0.523312339165275, -3.3592554654593747, -0.1807383426960347, -0.0304532374057203, 1.0757375747824163, 0.9783724796821709, 0.08856367899499458, -0.5766944883847036, -0.36170486816981084, -0.17353065284541622, 0.5694934006904684, -0.22059223022360278, 1.026238742816988, -1.1998512677176443, 1.6627070951612448, -1.1552202891562755, -1.4232392337800608, 2.4526250442138995, 2.761899100041771, -0.8547085180697448, -1.3042775360988874, 1.1988732613432367, -0.6288550935459402, -2.0161722651578446, -0.46686792933216786, 0.9298809948017329, 0.308916366936122, 0.9891206287142816},
    {0.8000941703917458, 1.138151139936778, 0.8989414324551419, -0.6618251614630299, 0.1516934934643272, 0.04113229531665629, 0.7199534729432185, -0.6038832209587154, -0.6332963374531579, 0.8040244084340311, -0.43779218106365647, 0.831387672611126, 0.12018849246964622, -0.21458298008420712, 1.606140932212967, -0.7463622088206388, -3.25892082719805, 0.2071915107143916, -0.2200145559087508, -0.9072128746742706, -1.398171223372086, 2.079603721127773, 0.8283865631337122, -0.4522400443945113, 0.9230675022280224, 0.8745171055013216, -0.4929476873172095, -0.08410700806879083, -0.08191161837860503, -0.7012107361357415, 0.2963375236657615, 1.059462135723365, 0.8657602006127709, 1.9235354723482592, -0.4321005605808674, -0.5061136242556002, -0.012370721227800854, 0.175081335015533, -1.8217367269897955, 1.2126421492456008, -1.8708293663731572, 0.19124687302789076, -0.6009706216156094, 1.5361743170918996, -2.621697534030297, -0.5581348776212621, 1.3866624921692563, 0.7828163137834426, -0.06695177541841495, 0.5492945560931208, 1.2547083866218802, 0.0958644886699212, 0.14423210698421318, -2.9852435860808675, -0.0453032614864125, 0.5229727554022396, 1.4028852735349264, 0.6831640894952202, 1.8672485042811597, -0.6592870330898483, 1.707560141261408, -0.8148809920508812, 1.2090881219832246, 0.02834254465919381},
    {-0.048075153405114195, -0.24486367325992245, 1.2191096001420625, -1.6985056958088118, 1.2029573439496182, -2.2556288536670945, 0.4300497405457152, -0.6705339952291945, 0.9656493686256515, -0.862226712712561, 0.20642499010754478, -0.6117687495187395, -1.1332643019256246, 0.5756384194504278, 0.42183837300463134, 2.3371761314803687, -1.214907571215407, -0.4960866432531995, -1.1583675818945367, 0.6994369663528626, 0.1465376050430254, 0.33298188246258187, -2.728499255887133, -0.30150189257848703, 0.4182117068781238, 1.6446832083112186, 0.9728815785320539, -1.393381149832505, -0.15039850398721483, 0.058713544757262724, -1.3026653889549074, -1.345151001820829, -0.5789673946956285, -0.7207841769085928, -0.04819697740853331, 0.7035111863762011, 0.7058770168779996, -1.2440663686413205, 0.4011507129172381, -0.09017892371297984, -0.199766507249932, 0.15946519171508264, -3.124935227778294, 2.703118362405629, -0.044164760992166846, -0.6953974889975069, -1.3215538725184028, 0.9311618540084244, -0.2337216100875727, -0.5575076946846016, 1.9905272081705823, -1.0841578497335613, 1.5690619625919189, 0.514603720794896, 0.10716427392343388, 1.0713968359013153, -0.5020833170962717, -1.1269538696751311, -0.35736038470231535, 0.5561363436350995, -0.3028745920881043, -0.3716995673126085, -0.9856018643325261, -0.9286369674158628},
    {1.6027572701767836, -0.027917620745135808, -1.8059434517535786, -0.17688750981831974, 0.5874750609626097, 2.5100053991066065, 0.20411360086691016, 0.04117096526074695, -1.5960371043305164, -1.9446121305412214, -1.5340580455573498, 0.5673198716019191, -0.004263849557037125, 1.0422607705486453, 0.9247161463529164, 0.09098262140353919, -0.3743100691890581, -1.17921831114434, -1.1216785329655516, 0.1899108208705826, 1.134901039641188, -0.2503272678577037, -0.5476278404307605, -0.4980173302031227, -0.45582159071805617, -0.6930590794476457, 0.718445446784879, -1.0621647060249944, -0.15145961516333764, -2.5696902118219573, 2.271321741236432, 1.810402937913808, -0.6518933932996375, 1.2568243974319342, -0.14223883033814333, 0.7610717883265793, 0.19238626651081997, -0.16050794692274747, -2.3793383792108407, -0.25620714546555357, 1.194200470050707, 0.005912650396308473, -0.9544959158981193, -2.367205104361457, -0.7697383038056791, -0.12535770977320848, 1.6055952322587208, -1.9826541440066365, 0.9090444033747114, 0.06039455104543497, 2.9092009215991896, 0.6927539456768117, -0.29311106430662565, 0.45475127852168606, -0.20684739002437164, 0.13905619671948494, -2.302659603275533, 2.454617888101821, -0.9316424114190267, -2.7546755282464956, -0.15713626022563967, 0.20478444262846301, 1.7670327644458956, -0.6089805606657118},
    {0.24830919812544291, 0.4264110601045302, -0.7077384591271533, -1.4064733507963687, 0.6547215835092464, 1.2529184371415094, 1.9620247686052747, -0.525682629010704, 1.795895618341808, 1.6962892303585722, 1.9769208257321387, 0.04558936795071059, 2.8051211675517274, -0.01088476131251596, 2.022810850999855, -1.2239095852300461, 0.5420363573550445, -1.321960268850083, 0.5620539580809678, -0.05754156502772435, 1.968895303724556, -1.6711231187849869, -0.756930209081372, -0.6038044041609177, 0.5479184320019282, -1.5623040845065, 0.7958593065331836, 0.9254971015863653, -1.28977928864823, -0.17159473523770513, -0.9782984041093667, -0.4839956133645237, -1.96351479340021, -0.8270763054588904, -0.10914527032329421, 0.95226249700488, -0.8714507029077654, -3.64521908884178, 0.9617358468508546, 0.5978294897948627, 0.6761664944632586, -1.4991409227476538, -1.4084746560125576, 0.8112091381576081, -0.4856438350906865, 2.233566782494606, -0.2560923410370631, -0.5717813808382028, -1.2507739362015253, 1.065506866871634, 0.5716817397944632, -0.40009680871522363, 0.2078527829281706, -0.19960850043772466, -2.4972727157155683, 1.0017336576005367, 0.41525412339551776, 1.3470268096975029, 0.16618707412572947, -0.5867845800004434, 0.07660019212241598, -1.8557372029176415, 0.18663536075719955, 1.1648330300297578},
    {-1.0036223667637238, 0.5124892220172116, -0.7050231512045572, 0.739940467229659, 0.32226960025754603, 2.727649540050481, 0.06983287912886378, 0.7012246289329174, 1.1352027258918242, -2.4690667821646075, 0.10761807318150837, -1.059920873010637, 0.6963766034527599, -1.6897473151490008, -0.4723230607531478, 0.7988635358463244, 0.7629421074815999, 0.8550063069177662, -1.4980372638208186, 0.7545030214389291, -0.31089217713979045, -1.3576219765684072, 1.7164690115148635, -1.4102570509230492, 1.7191357419442344, -1.6774740417406986, -1.160702560966411, 0.8463148266535575, -0.7000111170389954, -1.033768133779288, -1.5911296934439643, 0.19267636583877965, -0.14578724815060112, -0.9940007711441189, -1.2961409678404365, -0.8044123547340895, 0.9236079460377701, -0.27767418401479743, 0.295064746834204, 0.18395286238152184, 1.0287532420040513, 0.24051575341808556, -1.018354099282716, -0.11047667644973584, 2.2636394680479963, -0.39537192084632, -0.666623671627371, -1.0741893711219621, 0.9344149555380022, 0.8450121361773345, 1.5677011705779964, -0.7218979473371564, 1.0799801870934944, -0.7025256611235934, 2.0115534765918595, -0.306689717927625, 2.3310144229969607, 1.0599959474047669, -2.335969325604615, -0.6611014048493329, 0.03839919757433739, 1.2212065075580703, -2.3767393516624864, 1.6325688570749772},
    {-1.6482900097219295, 0.4469395547072714, 1.0735727569186964, 1.2985149157019684, -0.3054719021340718, -0.27852504208045975, -1.1457655376059346, -0.49095760652822173, 1.6531950651395935, 0.2819305911120709, 0.9695207773963868, -1.2855170025169627, -0.5859531441280665, -1.942404466849866, -0.7602667127610321, -0.3809750676554595, 0.5054530311140588, 1.6240011061694781, -0.9772344035720926, -0.23973315869868017, -0.6785662811648656, -1.1592772358702423, 0.32601529842249144, 0.28770573864538745, 1.6872427710713473, 0.8194318594082693, -1.1299322159905716, -0.3039362167589998, -1.0485409995141197, 0.38299644646612957, -0.6978540117327542, 1.5734262390699016, -0.590862827916055, 0.6547152225389273, 0.05994410229479939, 0.48366357286295225, 1.4310618709016938, 0.5618236830144753, -0.9122375384646425, -1.345279514316598, -0.7645297281194182, 0.39542351765834644, 2.357244452640748, 0.8161347999807492, 1.6196439264948295, -0.4850759531559924, 0.6328885594258814, 0.8258253823036759, -1.0822569778677946, 2.7251052054725076, 0.4913888568627669, 1.2749207432902256, 0.10231341446320037, -0.8363979076543415, 0.6019927406588359, 0.09148274489792137, -0.4959549470472459, -0.7057212241637926, 0.6811706865997575, -0.9666844812082683, 0.605786657364491, -1.5428430782088547, 1.2809676308846638, -0.6068209059387992},
    {-0.22664653480566901, -0.06491274310767343, -1.9265592433983263, -0.591183731507028, 0.3976651554497194, -0.32519293544288763, -0.2856493992788758, 1.2778789235015302, 0.6224512081441481, 1.3768545443875608, 2.1212700802420206, 1.5771931569529984, 0.1112014174178074, -0.9534736777838778, 1.886444251720393, 1.2274347951828941, 0.6342675887724002, -0.9833091574291477, 1.365276225073086, -1.4281616043656853, 0.3789502933545507, -0.24748042259873224, -2.8252061142717575, -2.2946852007780256, -0.7922748593415203, -1.511662769773548, 1.6863461406468523, -0.02250202418990684, 0.35664728550004887, 0.14948166705041124, -0.5188111213658078, -0.4925746083294336, 0.3401861997135925, -1.184685582281797, -1.7170817090999282, 0.4830719084160675, 0.5119385752027892, 1.4305764049322904, -0.3923421401037459, -0.2382644286856677, 0.704974915563388, -0.21164407133148389, 0.22843546472501555, -0.03094960390713295, -1.6521088707390619, 0.2557831861654496, -1.4247348437869471, -0.6689878067123382, 0.6275648701884159, -1.0824263448437066, 1.306920068117609, -0.5236168803256354, 0.7767281617641177, 0.15452168675330955, 0.7231443189453067, -0.45082199039804205, -0.03007546676327562, -1.5076693272778885, 0.09053286253504671, -0.07058936725836892, 0.07428291161864006, 0.9347011983756817, 0.03396287093391722, 2.267840907709467},
    {-0.9376191116436493, 0.7106420165216628, -1.936087803204536, 1.0900027212555667, 0.7144037611878653, 0.20797135805816827, -0.3222415129272497, -0.343882119514137, -2.433820093616066, 0.9282509254103556, -1.329500235216429, 0.6669305395939163, -1.0678799242298136, 0.725242671772375, -0.28044651818726185, -0.15118847140898373, -0.4677458501716348, 1.6838944476771263, -0.566283610230357, -1.3142265426027797, -0.8187424102767938, 1.9898215702605813, -0.18743972206367635, 0.14162591572616734, 0.8507562277036801, -0.9882411118378959, -1.0437918757480824, -0.43912703167441836, -1.5789476382056717, -0.2961831303888197, -0.4055030830598268, 0.5522646645459808, 0.20275300906169738, -0.6913670937063272, 0.26540001628607096, -1.9487415344870511, -0.7708377509631467, -2.8630973091372605, 2.293815164572703, 0.63594322090262, 1.2031472432277333, -2.320199762256179, -1.0363359782307018, -1.4456613600404273, 2.1524886120447264, 0.398455809209306, -0.7669442434122523, -0.5388032039042494, 0.6918581145662216, -2.084826987370304, 1.6389444960791468, -0.7647261434147008, -1.6952302373999764, -2.3706743170345206, -0.6627599864345439, -0.7707350828820562, 0.6965657341553881, -0.21013722688612937, -1.2199035109768734, 1.5411020117626775, 0.5501770182806549, -0.47974243959365437, -0.15005934739595303, 0.7282844638646407},
    {0.7236083326238106, -0.5903170923545166, 1.3648067272891389, -1.5144371373514902, -0.18154499853970127, -2.580796021534156, -0.27753759182525567, -1.032030163547404, -1.6713991967267068, -0.3974059047236282, 0.2226484145833992, 1.1296756947508557, -2.0423308025114375, -0.03994244944529677, -1.0905348832144741, 2.2304425589246355, 1.568426655468786, -1.1777687722702517, -2.5147327243498467, 1.4665629906959257, -0.42690263649132, 2.492493586325624, 1.4495149545835178, -0.5775862049888266, 0.773183319885615, 0.09878480438157977, 0.9662540404932213, -0.7637042259021745, 0.1906551588706842, -0.8439699503105521, 0.17795732119491983, 1.56696492332144, -1.2173886841396635, 1.7265586727359061, 1.0593685599995195, 0.954591645046016, 0.7682734608777261, 1.4174692139500868, -1.0842961669913391, -1.9737480949706423, -1.0878452610252412, 0.5117507704004417, 0.6630700698016206, 0.4940984571175416, 1.2154302769989591, -0.7046277691877774, 1.3418975640573563, -0.8547163676763632, -0.31380816124534044, 0.4815284723679046, 1.5467219474674125, 0.7768061939065785, -2.2032314649335225, -0.6935739245200064, 2.547785048725731, 1.3698669578147717, -1.753229447036412, -2.049115524483364, 2.089316452666054, -1.1490432221231361, -2.1518250195718176, -0.3336210267421469, 0.34313836926624286, 1.8286868186017717},
    {-1.161518282521927, 0.3364777981000961, 1.5570074666068248, 0.10566368961458414, 0.7898595133412526, -1.3928937932832024, 2.9054008977727865, 1.4741549383398067, 1.0328825990577348, -1.8096802669162613, -0.7671304862937901, -0.4617884377321916, -0.2952662334075427, -1.0671352387647086, -0.625787541822367, 0.8686619743337429, -0.6710708077414577, -1.2539577353810045, -0.06756179832731264, 1.785387420295884, -1.3860239584791025, -0.7585494993438187, -1.0813393628945716, -0.7851833318807703, -1.4065774185616617, -0.8491493564257966, 0.7700197278577532, -1.036083542584243, -0.028570032719167922, 0.20726157497699596, -0.8175444453952937, -0.1665786878659738, -1.1226794960889845, 0.021563805549414495, 0.23299892013442153, -1.501155694075602, -0.855309065317276, -0.7383872539293393, 1.5187135240321392, 1.9455255963717082, 0.45688936223506754, -0.6650958508693707, 0.9596560304967614, 1.0532050920651466, 0.48033384899274245, -1.9294344814866526, -0.6159657894652617, -1.9369357282059545, 0.8515657277451234, 1.107793845227826, -0.05886345637530904, -0.2911635921417011, 1.9686838719239073, 0.4953183581752659, -0.1952078254712079, 0.18052723655840455, -2.1334769337450554, -0.2523446219426069, 1.109210862519048, -1.1200053039896571, -1.3514043360681651, -2.927033951633043, -0.847408214377721, -0.31565341653063084},
    {1.9422882252186053, -1.8341173573840917, 0.38340530497234276, -1.927799265200073, 1.0109107466078935, 1.1838833695992514, -0.9048873551326442, 0.8292763976923723, -0.41189758512993224, -0.5157652887009412, 1.0101622314629668, -0.4623553550256378, 0.07517487955635449, -1.3176149793360663, -0.4520008101018883, 0.7631709045209304, 0.4461719617887504, 0.3510703066388869, 1.2139784486086624, 0.06871275080270452, -1.0149813601475421, 0.17246029326284057, 1.457647315331031, -0.8184743265866989, -0.8372777372950441, 2.0450546950252124, 2.0435028749206543, -1.2771836814619044, -0.7682644622908246, 1.9081665062302278, -2.3757988200283884, -1.3579361662989398, -0.92528570239393, -0.7083255382591175, 2.0321943052830855, -2.084787449140547, 1.100936240144344, -0.6681274523313306, -1.5679456735580477, 1.9648121333278064, -0.4939112476861456, 0.31960917002613676, 0.4079986987334933, -2.8811532973060276, 2.345779550042609, -0.6508836806315297, -1.197075931422562, 0.14184826633373881, -1.3036583037175067, 0.053916276427364754, 1.1093964458760317, 0.9424094979534788, -2.8246667626092736, 0.004832120339534142, -0.5050833582904208, 0.7497164190900092, 1.252667236639217, -2.7851798401668217, 0.7683955387472826, -0.7411166984960271, 1.1708854758557579, -2.812287154621612, -0.5430536241828052, -1.485369734875472},
    {-1.1429314053845432, 1.4752968148668906, -0.358758955491397, 0.9767832668819568, -0.49871745402254486, 0.2733211227418641, -0.45945268942398093, -0.7847387073310674, 0.6963547481739294, -0.6604010568558152, -1.8012124268908047, 2.599259047852858, -0.40330781630179996, -0.4234136437304462, -1.5882795708433088, 0.747838134329916, -0.6484814494846657, 0.31729869244844866, 0.1527274831555192, 0.2856741528824337, -0.015283007244179221, 0.5690775479548363, -0.5750170750538719, -0.12868827987956058, -1.1560782840560055, -0.44406412778257953, -1.5386595636534433, 0.011375762385395874, 1.9708049283619742, 1.4842869380101498, 2.1605336657642678, -0.4005107967555823, 0.6506137406911475, 1.1741445526143122, -1.072280548410911, 0.3343084409866039, 1.146801369184868, -0.2628348223461436, -0.13826860659055176, -1.4217621016867548, 2.3814458945570234, -0.04126810491866799, 0.224397746411595, -1.44305084021767, 0.2609279858484513, -2.699979088895627, 0.6046964461913159, 0.6688792554182876, -0.8134464352842684, -1.3697572619643896, 1.2334722486356149, -0.468506430895975, -0.49075474265160096, 1.3318954159293523, 2.1659749029639106, -1.0332196519604757, -0.5002001076649426, -0.3097585731298575, 0.43604707082753164, -0.5777940249626247, -1.7561003407382108, -0.504515623422887, -0.2360226042477989, 0.7291170160424213},
    {-0.9117640878025228, 0.7579703945946619, 1.5026916080504267, 0.8303499547897062, 1.1256949773790548, -0.3443724745594901, 1.39714486878482, -0.9953716925667491, -0.7643388483518849, -0.2924759056043056, -0.7064549661815609, -1.9819662933592597, -0.5052869456599316, 1.2192030342228446, 0.8254698103248852, 0.47353824663329064, 0.15749742398415162, -1.7636051687127927, -1.6450885894076286, 0.5391048173351175, -0.23053122221135555, 0.1626705786521351, 0.5147204188552373, -1.0479466850493253, 1.8857442516010139, 0.5985152069856438, 1.2190327070956026, -0.007112070490426807, -1.0613420821026511, 0.9205035005341554, -0.9691487649653421, 0.05407774246421845, -0.14037575993534693, -1.9253812962230064, 0.5087033582684322, -2.437681717092182, -1.2018608735591072, 1.039057980352633, 0.5688264646149166, -0.8967800692384668, 1.7118025319102064, 0.5111083554822422, 0.8208045989995744, 0.8828469778838582, 0.3056694565147246, 0.45887045627545203, 1.4196687654414155, 1.6285210780713086, -0.28695317982886315, -0.6958265467615327, -1.2805878012714977, -1.3252145185469633, 0.10908763895940939, -0.9114160667356502, -0.45062123040717267, -0.24134104747951643, -0.8025055755245021, 0.8940790482096469, -0.10319915348200778, -2.1369673345161773, 0.3588593067161531, -0.6471077123453925, 0.175684737847128, 0.5542906180157562},
    {-0.21293403857389923, -0.8355378774881792, 0.5220169085620021, 1.0067472008766098, -1.367548622613868, 1.1438448379529578, 1.3053910469439511, 1.2594557792510672, 1.3168034547717091, 0.8838240693711606, 0.5997573242994843, -0.3057880862390756, 1.9263246242008547, 0.8265306842869914, 0.22184546796109939, 0.5885765401702419, 0.49126898181639894, -0.5998306765327623, 0.9859339474560141, 1.7641704098492854, -0.0167424056512756, 2.355829193841713, 1.1456302526706734, -0.5194146443863907, 1.0244597373942668, -0.6468757496556887, 1.7659741469821462, -0.014564581464245434, 1.6531288815955139, 1.962871965696417, -0.7444530937890079, 0.36310981551875154, 0.734550925551362, 1.2690199274148866, -0.7164176655861081, -0.1719802423163751, 0.6469881591583202, 0.12175215728993431, -0.33801077056687473, -3.4464648220744936, -0.6610397087689069, -1.3694281713654095, -0.9352660801643922, -0.5172101646338487, 0.8919659416403188, -1.648006508858789, 0.023923686170314266, -0.3563769284487595, 0.10827326931742041, 0.17948827921242033, -1.224656933980872, 0.049972353192744436, 0.3136810696287087, -0.9630684476863772, 0.5582314017320787, 0.7126451700865694, 1.518392258202867, 0.4500997587592415, 0.8354717953002458, -0.5502869318993782, -1.7753060183239364, 0.23984190355221374, -0.5128789338223337, 0.5963850414951034},
    {0.3788857633348504, 1.9856526488042163, 1.6475119753529084, 1.0700181325525768, 0.2066042765434175, 0.5611511408287713, -0.48049088391054223, -0.7658215916722242, 0.48636086028909425, 1.3486669972981482, -0.9711586992559609, 0.11421743085546597, -0.2269586288026269, -0.6293245246471244, 0.6014547085604462, 0.8718514807511087, -0.7261820396019714, 0.564458874306492, 1.6488002290895474, -0.04064055682888511, 0.8826512688272917, -1.7816607227127488, 1.8931685928770907, -0.06207001226889217, 0.5190322132616153, -0.9154994475863425, -0.9243400802053228, -0.719707062737498, 0.32160932885461535, 0.3280049121508013, 1.8522221424351224, -1.0781114016309294, 1.1908053027441845, -0.6128238537002072, -0.5603129785988736, -0.2528101601132142, -0.42371451029899154, -1.943389343183896, 0.9094658528749029, 0.03876971525294983, 0.0268594329372108, 0.3005051225147739, -0.9167623653643073, -0.563642988452544, -0.1527265592008541, -1.484495114525805, 1.8813575363727966, -0.8252702791421399, 0.6115877731035961, 0.5517498535222883, -0.8990221656184407, 1.5145123768430566, -0.1864232391907793, -1.1681284558342158, 0.7582118903015085, 1.1353578247474516, -0.11112402873187667, -0.6324822777685045, -1.6010453191913376, -1.591311584861935, -0.25415404509727035, -0.6424399457474356, 0.24225730109785582, -0.43648804619893056},
    {0.45545909408438706, -1.364185799962786, 1.8888831301261417, 1.3392795831008453, -1.7859784903558051, 0.8288563310776125, -0.7021597685434756, -1.1271833273218235, -2.0970809337729284, 1.24013946946062, 1.8680415289205032, -0.5687840094414787, 0.864274557492444, 1.4543187936663646, 1.985227270255414, 0.37887605735028046, 1.9139180739504187, 0.8590791849830717, -1.3072051814022727, -1.57708808265747, -0.45376528899303153, -0.19458161664421642, -0.6651464882100541, 0.10954830119008549, 1.5344453375991176, -0.29147490797908804, 1.053337032067176, 2.1660417629985416, -2.833585408614529, 0.8962811941331204, -0.11311544512233775, -0.48021050116655783, 2.3379715340304443, -1.073549493834049, -0.5244445414789607, -0.8726516770690096, -0.7844546063114112, 0.13757126581590423, -0.4875312418878288, -2.0270706518011594, 0.19908967161039262, 0.9664579092870069, 0.2228751529339457, 1.3647455372745088, -1.4686832364958502, -0.4084119129818635, -1.542200954501486, -0.7254016043972895, -0.579231795270962, -0.546479743855785, -0.26235245162298576, 0.7461669436053318, -0.2660261233923418, -0.3841215257302492, -1.325127628089208, -2.3333116786555856, 0.6120636103103761, 2.453632697543655, -0.4324747436712249, 0.1832511544034652, 0.44492332444411464, 0.17183381402293818, -0.44068426376330744, -0.04374133639545198},
    {-0.5024947361364908, -2.730014234943226, 1.0828835639793606, 1.751566563654741, 1.1668214626465672, 0.919684621190831, -0.7646243000136219, -0.5692558952463737, -0.7134758562698029, 0.7161309404245814, 1.30399104316912, 0.81875107795158, 1.2820567409861219, 0.8526269005237264, 3.174393743275481, 0.009045705798832012, -1.458628979629876, 2.2122257295499805, 1.623183423665086, 2.124477210639534, 0.3739698275752864, 0.056919444080372875, 1.040450821748982, -0.5846869998621596, 0.4130276993882136, 1.4488555216546455, 0.6292448150264903, -1.5742611234656558, 0.7980339232211854, -0.6279336936599338, -1.5851653860250445, -1.2382587990839145, 0.38572768945208313, 0.41053563737093784, -1.0761761784097938, 0.2178532559712043, 0.9812616412257807, -2.563075227989739, -1.1897205465110698, -1.8988762346389896, 1.129014773380267, 0.014135853752344399, -1.0515280949250647, -2.048040159762301, 1.8492973435728541, -2.752533607859163, 0.4093754387349498, 0.7332199821730178, -1.3077734803714134, -1.36000463120381, 0.22564635286423101, -2.1773441683568975, 0.4899544620943816, -0.6149893762739996, 0.5314970573770101, -0.3583953789755419, -1.0060659492013388, 1.0990888460997883, -1.136196017961822, -1.5588388154221486, 1.344793452554845, -0.12454854941251421, -0.44932692159233856, 0.12360134268283526},
    {0.7489801904253782, 1.1227570311442474, 1.3183174347431768, -0.9951829972012309, 0.5061767060708889, 1.1418170627515845, -0.8988519654424897, -0.804154320367138, -0.35832605884454455, -0.32628236892035645, -0.9007251458289033, 0.2049147244098361, -1.349074387925152, -0.08814320203790371, -0.6040516176567595, 0.7542906026960946, 1.4863039417929245, -0.7402926483073916, -0.43694574193234076, 1.4186901008513808, 2.2113612585132167, 0.8306368222828783, 1.2667151211776122, 0.30350269188149814, -0.5817900005339961, 0.8528159428843279, -0.795273964327334, -1.5566556652471082, 0.5735030557047301, 0.4717622908108405, 0.6679251122579355, 1.1188842006112087, -1.9792314846101906, -0.6905421898542546, 0.5653180373289901, -1.0892522959221778, 0.582080855905238, -0.48026467551842217, -0.41709664318100415, 0.4067570360724493, -2.8148253898431683, -0.40312911005088276, -1.5945439751989023, 1.4164437827103071, 2.074839471218308, -0.5892790143588812, 0.4294534488875758, 1.145892161064142, -0.07229935787085555, 1.0703079646968432, 1.784621156771955, -1.1657748071006686, 0.12774214165306141, 0.6130695521921167, 1.0064167601753211, -2.1060375121300288, -2.231519919447664, -0.30269262767753763, -3.255640934763896, -0.8633935073377732, -1.8907401161331183, 1.1622388458858128, 1.1815351159722158, 1.2087291052364428},
    {0.40335545980510346, -0.45323513121610565, 1.6423865233664472, 0.3507412954307229, 1.1568901911201372, -0.19336680167824163, 1.578803723163792, -3.7121265429460593, -1.3696675450186697, 1.7403600190659896, 1.4496530764960052, 0.9479657160374524, -0.1230884798649503, -1.0516560047867403, 0.4862626036108565, 0.33650330981889964, -0.8733358857009522, 1.15070087869789, -2.0673504796705577, 2.3313834024189775, -0.23126252863367253, -0.054834022159290605, -0.8360520808122812, 0.06411297560834145, 1.088134166975665, -0.2597037480852872, 0.6056640449419374, 0.5849787492299621, 0.8204042149027769, 2.1258593880534784, 2.09632874465141, 0.4074744373233856, 0.7437335901101519, -0.15714902024006291, -0.3404770027410303, -0.410923909402314, -1.4554812235873051, 0.1983700305668707, -0.12180247565268768, -1.3975642987205903, 0.8717933442757128, 1.1098576510035003, 0.059659487318115566, -0.071902344796409, 0.6864379576182779, 0.5405222234799546, 0.32018574740469363, 2.1612143637383623, -1.4758734248708918, 1.3664088245369268, -0.4016871849010169, -0.04271543659187128, -0.5021329298310461, -3.4861583962439324, 1.5161008980458721, -0.13102677385335815, -0.5619401452489635, -0.698995897759576, -0.4017604494704864, -1.994579823090023, -0.09038396490744113, 1.7636235490724979, -0.7950965800746793, 1.3185365034245131},
    {-1.8709406603179937, -0.4080474669131589, 0.4963934280819824, -0.7583384035560865, 0.8558833848941158, -0.3993562829387414, 1.5643083414834582, 0.6297045610775175, 0.8185114937101853, -0.010559345042603658, 1.7698959050012992, -1.3486206401466614, 1.00802043997539, 1.6094235670374464, 2.896388185960565, 0.6895219909155487, 1.1667125703736083, -1.4858802830090005, 0.3574642040832135, -0.8763373436074493, 2.4299164069358126, 0.11708407634621175, 0.5444126296227141, 0.188987200877588, 0.92573572445828, -0.27502506738360727, -0.29156239003759277, -0.8925325768191009, 2.0710394413391273, -1.3372306398599496, 0.5623878912292436, 0.042806338542301155, -0.6140852415678874, 1.7467261029125103, -2.3749439900802005, -0.09931249619007687, -0.782955514133368, 0.4991946130348118, -5.081882492041091, -0.030809313592232827, -0.18745619189474366, 0.39007186342040495, -0.7118033189557302, -0.4010210172414058, -1.8028564807948697, 0.4826814664731624, 1.4991641221414929, -0.2730483209081707, -0.22041226146997928, -1.282425087654013, -1.04839492566553, 0.43117313680684016, -2.0395045867277535, 1.5344107747514408, 0.39487249935475427, 1.5164832477272219, -0.1279881210552872, -0.18524570428080164, -1.717227987045646, -1.5152446150785925, 2.2371692763627657, 0.49132200739784004, 0.3206654938733648, -1.3664334702532157},
    {2.3619820919440664, -0.014074531068467662, 1.4418113998810234, 1.4352176420174956, -0.6653044243352209, 1.2704747282111144, -0.7286920023700985, -1.448493324151444, 1.8447248990326048, -0.7043428558398649, 2.3179162316941, -1.241648708857359, -2.503005085343663, -1.3207086854734749, 0.6220445930700793, -0.7790339701073614, -0.412240731236895, 1.7592930089519478, -1.409797550517038, 0.6553743956529885, -0.0050181517349391245, 1.326272440559388, 0.6323718881208837, -0.1474582015815645, -0.8873576680000186, -1.4047613844156228, -0.37847356028935336, 0.35915581308617095, -1.8841137703020292, -1.702701288206475, -2.228305909616066, 0.27020592181141306, 1.9859164513465513, -1.99439051472258, -0.26966251727098434, -1.8577820211104297, 1.4547320008553757, 2.752412095962023, 0.8293553229046021, 0.08337217741881403, -1.9539978411413346, -0.5880178398507862, 0.3946787126799979, 0.54126736612928, -3.119939345990511, -0.048020469551135404, -0.17870891002300887, 0.45226094921664173, 0.7848436478050066, 0.46455439886516203, -0.5179513128644423, -0.5576217294337861, -0.6838082537432901, 1.128021849950917, 0.5251647784829357, -1.681018970305466, -1.0062537645490646, -1.3299129652408073, -0.841921752538297, -1.445588948098644, 0.3211460151372308, -0.33691405033659727, -0.05734302555746127, -1.1983464046612362},
    {-0.309964008705754, -1.286312899603725, -1.123764501100583, -0.1842618485099505, 0.7882974867994174, -1.9224337694964537, 1.56231157213515, -0.9294133715734656, -2.1221710039809807, -0.5903087806695885, 0.4247718957243515, -1.2288758590854787, -0.03052476175575067, -0.5315704850183114, -0.13507869876503484, -0.05817332544319803, -0.3577227739759293, 0.9806177641161352, -0.6619126124784307, 0.005370615029477165, 0.47525402230171937, 0.9518322856287219, -0.022651107209527014, -0.42744582809786896, 0.637024226466458, -0.3234450137170712, -1.1808681487840027, -0.1884696880315321, 0.07417650146756263, 0.025538269976330456, 0.13656063245528108, -0.4190149603860802, -0.7213963136677582, -0.7947086231706479, 2.1351815637951326, 0.9839423483283902, -1.090865259833241, 0.5975661150768913, -0.5006347689313692, -0.8490130871646574, 1.0054525197276576, 0.1794668417295157, 1.1844831746338111, -0.76308094832609, 1.005300596713422, 1.9823309043693598, 1.575887353216624, -1.748688095671855, 0.5699583657565545, -0.144729340343933, 2.646519599573715, -0.6064751125643196, 0.5000254273785606, -0.07798768889309958, -1.1537903523315318, 0.28671975023280216, -0.38673410815788195, -0.5998989079963553, -0.33121017597835734, 0.81306608223751, 0.7938399277726478, -2.213373830013939, 1.5534673983976501, 1.6679849920282834},
    {0.3467417731581932, 1.0417246498201733, 1.1381166311383313, -1.4847977813031668, 0.7176643136345029, 1.8051179405976876, 0.6867130428929046, -0.029830972819578697, 1.531227232641012, 0.37144910816081506, -2.335601342389389, -0.24256386081011638, -1.9406928868525934, 0.439901920365222, 1.6984300041824043, 0.2273503475777103, 0.7081528962485933, 0.5518568415363788, 0.053795359689003584, 1.148178178859475, 2.0656129698514265, 1.2074802583784499, -0.1452868622211448, 1.0974073868594179, -0.19050771629626642, -0.7929075703276092, 0.8156233651272891, 1.1835290656760138, -0.4394008300602823, -0.043347733867036005, 0.3006277178607929, -2.705025551357581, -0.28378440146649814, 0.08436613509631229, 0.16253941473548672, -0.9727132353008267, -0.16331757782525488, -0.039443311484276385, 0.06206201028098593, 2.445364196506726, -0.05705708973873947, -0.6610588704668864, -1.0505216598218992, 0.8609640344880355, 0.06022996694078181, -0.22265802577878477, 0.6396860280925407, -0.3146117596278514, 1.5411632665194674, 0.3579250606066333, 1.1409074328052433, 2.1691082337284118, -0.3146598081971717, 0.57527930513571, -1.9981826337114605, -0.4902937067532035, 0.6630824726234025, -1.4747869464747572, -1.2394210249415385, 1.2526086632495557, 0.6244637054049594, 0.7766373572626721, -0.6479927211387023, 0.6899211794520073},
    {-2.9476941097024882, -0.47675198015733594, -0.9905590802056792, 1.1441543341336358, -0.24565222977520293, -0.2231864184215703, 0.5118113591435615, 1.0925849252815405, 0.8400160025483127, 1.656864069712694, -1.8155817327411212, -1.5372948010456842, -1.523276154796439, 1.1893556392400726, -1.8727227781854519, -0.4708775108112874, -0.28003890558087907, 0.9359454969749181, 1.4323895338940373, 0.7928688363840933, -1.0055379422196902, -0.7386363393954463, 0.3710257658892784, 0.6425808139161092, -0.47914514389597346, -0.9886852062598456, -0.4523917655036943, 0.40907846151590044, 0.8657122682989052, -0.13295566390974248, -0.23997413011476373, -2.14855249338193, 1.510815233429638, 0.5947658787777815, 1.037704707746184, 0.7122871532824603, 0.588692255666195, 0.3645752108024723, 1.3001066190587112, -2.191698182666113, 0.4828573924388529, 0.7351249684989537, -0.2312837534337115, -1.2548376292798438, -1.0215255937268777, 0.41018454719840813, -2.2649189501238407, 1.084078169484365, -1.2196587673853563, -1.4774881020250041, -0.40926332430249446, 0.9272416084890918, 0.9351747693906919, 1.9497764152847294, -1.4182927125885667, -0.04276002176429319, 1.2637757998194503, 1.6833376939336346, 1.7938268245220237, -2.630798080803874, -0.661975070669726, -0.71904413760441, -0.10415410600562408, 1.464371112421788}
};

static const float b1[64] = {0.5495223282605436, 0.8204731484362311, 0.5010732116215617, 1.1923874847117333, 1.215350175453135, 1.2089379020192783, 0.9404523839075846, 0.7603353117700397, 1.1968814596067836, 1.1025127855531527, 1.0107815607404784, 0.89545385086197, 1.0494145241431811, 0.5885858469362398, 1.087221736590795, 0.8092931616639597, 1.1035015808610071, 0.7979846325624643, 0.6269333297291989, 0.9215007783009151, 1.2227433200545024, 0.9060071954305695, 1.0995522632670844, 0.7672158452720108, 1.0072789679983536, 1.0438750230801719, 0.384882706067698, 1.0146671256636068, 0.7605809299735721, 0.9455823168371617, 0.9237056830103664, 0.7624271147936159, -0.1890115895949151, 0.787272799297227, 0.8002950620778818, 0.6443359063353877, 0.37727995375260764, 0.8315920665767463, 0.8508144783316077, 1.0778076030798112, 0.8017329133032891, 0.17434442390360994, 0.2710568764945002, 0.8921095878463691, 0.9724488685715571, 1.0111959697882063, 1.3431352128016991, 0.34096939308345275, 0.5817121608169616, 0.8301607522172574, 0.7100252998962364, 1.0324329682367264, 1.0812595007016312, 0.868366195159341, 0.8631268480451957, 0.6618750085329469, 0.6054856588312568, 0.9396886133287987, 1.2296949020131398, 0.9177912928027357, 0.6603516326637915, 0.6448907914364167, 0.733923192218203, 0.2653571287039427};

static const float w2[64][32] = {
    {2.182107386510195, 0.17283102766217115, 0.26314895211377765, 1.7916171256611313, -0.1779338712863299, 0.7154915398269349, -0.31772644254493915, -0.37614729272736785, -1.3325497758722702, -0.19460090863376517, 1.0246996052285828, 0.33042214953014903, -0.20968958453562359, 2.6034382813214894, -0.5971401033213923, 0.9221729672084288, 0.9521483398588922, 2.3149934163768564, -0.9044640939802425, 0.7794270726078389, 0.6655994929512644, 0.31825197692104196, 2.1741593461224586, -0.13259654009661548, 1.1844760026968346, 1.1552648066784867, -1.9269210347629553, 0.8577042379398718, 0.9993788926328587, -0.5808503331990879, 0.33856516316102564, 1.0677248432044604},
    {1.1181942333700374, 0.08072038930807077, -0.2848336343186892, -1.880512906717312, 0.9098677865598825, 0.9580651744301428, 0.7062391952576496, 0.3736651124975655, -2.156995074034535, -1.0170788317990793, 1.8162619126829531, 2.319228281725979, 1.412428334394417, 1.7971642748606882, -0.0991845440624769, 0.40183411900983135, 1.373516182440654, 1.312463029813412, -0.17567687109461172, 1.2769047904660715, 0.04902953584144394, 1.465925222324044, 0.21739600422958433, 2.1183831110206204, 1.5823756213228397, -0.6876844385167729, -2.5817227205030626, 1.5347083077513235, 0.7368881137703458, 2.1288881146407506, 0.6278666130982228, 1.9369180738493847},
    {0.15673167835779067, -0.2333228639163057, 0.8009837102533913, 0.11616355994465583, -0.13136419915737388, 0.5636177961324774, 0.7053578439356305, 0.07416766714429066, -0.512794857565725, 1.2539055583714303, 1.3763121780971637, 0.34532604130899386, -0.11797806954948203, 1.5755036212188376, -1.1221255382855346, -0.31326334512982584, 1.4715720839693027, 1.8631177469096638, 0.11847332716935831, -1.0332597152011578, 2.52767941846466, 1.4869811868240204, -1.0363024794731543, -0.6026744896872839, -0.4568198787967931, -2.1772241175369778, 1.4503951671026274, 2.0298143006768217, 1.0203521401111892, 1.993127220062427, 1.7275585289251418, -0.013689046500612066},
    {0.7427007585511421, 2.597676554946366, -0.9976481797494744, 0.32282955781234945, 0.10178554222792058, 1.6726968700617268, 1.6033135956359634, 0.9603549703436617, 0.3023674429712291, -1.1714678710284263, 1.053362851605261, 2.2947713478146867, 1.0820098936369122, 1.6112817910088895, -0.6198845036676187, 0.1439372215168643, 0.9696160112140904, 1.3643500559555508, 0.2999656669424168, 0.5027017794688786, 1.1386230942705067, -0.06564262925487555, 2.11288642354792, 0.5494527884482099, 0.221183807491282, 1.2748946543912736, 1.021502950108699, 2.544728251374406, 0.8795866079788414, 2.112633407248768, 0.8102228091756778, -0.1978982097946128},
    {0.8760117620902836, 2.0178109029516342, -0.3233755695607549, -0.8102076182473228, 0.4490758703217368, 1.9876767392587888, 0.8150990776644835, 0.9703071438485155, 0.5016871395533766, 0.3878017103137721, 1.6351523934296324, 0.812077693115937, 1.7354048915090663, 0.18376669693667974, 1.3935977935012445, 1.021460581309014, -1.4146980888097531, 1.0751827270965173, -1.5542915550476863, 1.2907551223157767, 1.248021083720892, 2.3110711738606975, 1.1955471322958198, 0.9974590938689524, 0.5131853216188791, 0.21877391363261509, -1.5239182203747592, 0.925361109184253, 0.39086248384301936, 0.34036504501759696, 0.3139526331785957, -0.9062848207958885},
    {0.3100955269866729, 2.1957001956677753, -0.6861976707176675, 0.44160235630852207, -1.5136332116300255, 0.02700016234921927, 1.5161010130175736, 0.2804015831378963, -0.9154367961637483, -0.378815549331807, 1.8745086883188666, 0.5848197689782381, 1.6927381055049175, -0.5738549896206605, -0.12515401144036542, 1.2737880144929374, -0.15786315737873038, 0.2873774120220263, -0.8909275975967508, 0.10837483391424699, 1.4082865257359938, 0.7305484953532221, 0.890949450367405, -0.4539436888455881, 0.11904059123792882, 1.2998517552555304, -0.14583696236876947, 0.5947236787654494, 0.2258799661331727, 1.8539087645058412, 0.6039428159896807, -0.5267783271655403},
    {0.1919906544201952, 1.2713569946012253, 0.2319325363622675, 1.8608810144727004, 0.7584607707598279, 1.4661117902825904, 1.0386142966236023, 0.381405788933277, -0.26081857642604905, -0.639586307368727, 0.3693642552052583, 0.28069232607258565, -0.10860349710174495, 0.9738368302762787, 0.08752702617157535, 0.48833758799361554, 1.0879351442162837, 0.297584757237981, 1.3772090914924853, 0.30264541098521214, 2.3389706039794356, 0.827591896535988, 1.7309500189912779, -0.7142896674405488, 0.398873672445107, -0.972262516146167, 0.062479682062792245, -0.33162976174088055, 1.759623474026223, 1.8884326199604624, -0.9768661713024639, 1.8171894477471342},
    {1.4187809443014452, 1.8919286137711666, 0.043309736633234064, -1.0563963077139014, -0.03290693511242609, 0.940082727238337, 1.6738700483108164, -0.2880664062787058, -0.620774489189131, -0.8159961038764101, 1.1470493534700226, 0.7465664155976798, 0.7919610799574849, 1.7885086205540717, -1.1880094038267626, -0.4445579747548288, 0.0627235428200409, -1.7900330622596436, -1.725718529316603, -1.630849261087747, 0.830962077259532, -1.011902934141129, 1.3379439038187921, 2.0090171153745198, -0.9898878065274115, -1.0869652503724123, -0.29592622805873064, 3.016738471501435, 2.346786602076876, 0.7265210884562057, -0.18663758304619862, 0.7480710800889954},
    {-1.1765715458833943, 0.7594201235943243, 0.1314972485563476, -0.7066202751064861, 0.36187910098236087, 2.704340556500914, 1.538003541706028, 1.1826123287808141, -1.4335980051554282, -1.3686213508133762, 0.007172314348398575, 1.2841723251473314, 1.7783526334075153, 0.95486374213421, -1.2932658472409826, 1.5632621136177374, 0.14378335311748475, 0.6325834786224883, -1.5413934439223567, 1.4020093620664948, 0.2099796451422107, 1.4885526300044196, 1.0890250673554736, 0.4968414499407518, -0.40182630421180277, -0.01815621669434257, -1.8721362377909405, 0.9267229234528811, 2.1090788408568533, 0.6594534254967522, -0.8869657069926784, 0.545848298769617},
    {-0.30078148331609433, 2.3828473216139248, 0.922558254980739, -0.02368028335160354, -0.2600187372019229, 1.5633501858093142, 0.7347965951635432, 1.7559228631409751, 0.4259803753207317, 0.38786732971760784, 1.315044105804899, 2.5908871249065286, -0.11374761274698872, 0.8030528118554119, 0.21197527446680395, 0.48149339540855707, 2.0116992123218096, 1.0472539899621736, -2.5372482187583487, 0.273332932128928, 2.2401886235121555, 0.520917493372701, 0.9659100502113327, 0.5941695448550919, -1.1943065486358684, -0.49984408074882747, -1.75507169874873, 1.3888423679185067, 1.3050041537186226, 1.3526869773068002, -0.20137576008347785, 0.10899109882704579},
    {1.1856122885427482, 1.689446706933845, -1.464610065691475, -0.6786502654726564, -0.3932272637724312, 2.1763295946764925, 1.5917140499681015, 0.17020852467659967, 1.450216352762552, -0.8266712079896598, 0.8609925310735165, 1.8080493034986143, 0.2749052902577618, 1.8205796948982031, 1.2771370740000094, 0.7461116178341664, 0.5632127407657715, 1.8201631298909133, -1.100795904672886, 0.7870612961137549, 1.8572031465692111, -1.1470987571098223, 2.203020180173812, 0.59316554079978, 1.623214229491484, -2.3068570268973896, 0.24140814465779895, 0.00579632352514847, 0.6048152932403075, 1.61312544043373, 0.8085552060005403, -0.1324983120746686},
    {1.551721025099572, -0.7413333715860444, -0.6167335073743521, 0.5893178562531386, -0.8243583481874039, 2.50051554053217, 0.9431030182339724, -0.13798656489815397, -2.162581252776792, -0.3825746908874517, 1.700257684089357, 0.7867066451408966, 0.9249146871259531, 0.5482429276310519, 0.2812470870608253, -0.01138155199901875, 2.5195953148608754, 0.8196401564615257, 1.7486579048554531, 0.726579452741765, 0.8652265503370757, -0.8514045104604809, 0.33259085105906216, 0.7109299379306651, -0.19087568931833632, -0.34599313273523824, -1.4344234070781645, 0.874987307138883, 0.7150523649394626, 0.9099295687217025, -0.5093853425651772, -0.34901229784105936},
    {0.389545436826086, 1.2724876225701685, -1.2492290003617492, -0.3388851278498189, 0.15842647472615554, 1.507250591697651, 1.340631033074, 2.1651122790422854, -1.6416918233341113, -1.0521780322382661, 1.4026404204375038, 0.2619558217055821, 0.6479334366223385, 1.6113853632202957, -1.3343952068122595, 1.791005736278436, -0.500783304769242, -0.12568532785589792, 0.7776525582288824, 0.7489048727975941, -0.09444725368375229, -0.6090363407139439, -0.17732249592675603, 0.819344274171398, -1.2847092074922029, -2.2492012143671567, -1.311768232615634, 0.7615321829881148, 2.03784964311467, -0.30193794135628943, -0.020137918988567437, 0.9984818019280498},
    {0.6351006003688099, 1.3738604285121245, -0.3511275442036263, -0.6599153657352608, 0.9795845055219913, 2.290890316686259, -0.3672182405435454, 0.3069856579476195, -0.7018038776614753, 0.8718806922664332, 0.36983555232817955, -0.004330435897345851, 1.1955753194555305, 0.4434026186862081, 0.17237584803147607, 1.3213189581573388, 0.33449078117461833, 0.5211173982920129, 0.4221827674424784, 1.4689259070599054, -0.6765953271836612, 0.2198726176529871, -0.0937109246936678, 0.36898906515531305, 1.011474092793951, -0.4665411622097665, -1.29310801459377, 1.6977269841070022, 1.8226833887580611, 1.4305599941285592, 0.7058184832429085, 1.1869281888502112},
    {-0.5044204965058295, 2.434831888281524, -1.9875090637006738, 1.300635853822831, 0.5542097463063428, 2.63295511788217, -0.1874801134878319, 0.7827588244116951, 1.4207891972553743, 0.2030739059701711, 1.7830639869653078, 0.6020560952838822, 1.8365150218841297, 1.4600902787872645, -0.07713792597788785, 1.8652643376379234, 0.42099718205507564, -0.5416143391933695, -0.5443977576110548, 1.2651821005290753, 1.418261337734145, 1.9423387541477777, 0.5056271293182052, -0.188434118306091, 0.5734767657930854, -1.1864514110618185, 0.2049349990551153, 0.8582209527920656, -0.146687775967364, 1.5418843451566968, -0.7775045071324629, 0.2805376438121082},
    {1.0071852961570376, 0.6250142403341322, -0.1281291117112384, 2.222685159584189, 0.5385932592193301, -0.5852006621601239, 1.8831858774064179, 0.6487867056406769, -0.7261183447693986, 1.5422231133544577, 1.4219976570926103, 0.35027198213096905, 0.9933071173568151, 0.2477596127230925, -1.8172703422886116, 0.44832454842029423, -1.050798889252449, -0.6273966340953274, 0.0168730984378051, 0.9842495904301886, 0.8755709615242131, 0.026355072992956818, 1.6501666506754533, 0.3448231156208374, -0.24550665875605135, -1.6662893250856217, -0.34553247272090326, 1.962545343576825, 2.5173922187386166, 0.5848087237436309, 0.42146670100282163, 0.8008452210687831},
    {2.359756954408646, 1.6097619516881185, -0.006534062918086849, 1.1281512816480121, 0.6677329698034702, 0.12830639533529759, 1.1943257708621426, 0.877402369060935, -1.0163340826341816, 0.615489891230769, 1.5678488208615018, 3.044045733769096, 0.4781325632330981, 1.0197925979065448, -1.1678258354464968, 1.5537801309361803, -0.19936502203627074, -1.0622199474849965, -0.19512674041597275, 1.4989409553433222, 0.9962283240304958, -0.48310171123221873, -0.19482465707377733, 1.2521063384113458, 0.9084941809749124, -0.7024122250104772, -0.28542546907542254, 0.7450961957088864, 0.4396511405483931, 0.9761928001777757, 1.021562644692336, -0.7018949984055978},
    {0.36321980764020495, 2.2551646456993657, -1.2352420533573398, 0.645342809471045, -3.305919769152152, 1.2848360694208052, 0.1657685132993054, 0.9947084498522945, 0.7256678906694297, -0.7585218701963744, 0.26478446854433874, 2.085824254583844, 0.6085334963351348, 1.2118919348099788, 0.26689765348579203, 0.2755157430166254, 2.4783462452483547, 0.6930805713506919, -0.2376799553564264, -0.4532772082759631, 2.9929163237551855, 1.127611749778106, 1.1415687707370408, -0.2994343554906656, -1.1971736846391756, -0.8044774952862829, -0.0005841316334588662, 0.7035344851508208, 0.3701760932221022, 1.7987653762080391, 0.969321896451986, 1.2003778986968745},
    {2.086420905271875, 1.3632015303572778, -0.0009521258934958496, 0.016576618728563832, -1.8520025624382055, -0.06274234390317206, -0.08585341505239197, 2.238277950082447, 0.6098042574839798, 0.46487002152812107, -0.4910106674201467, 1.5094919752060907, 1.3595048838834825, 1.3264865400072907, -0.741621179856473, -0.1074350078930836, 0.1959236676165975, 0.05347972019137159, 0.8169080801847117, 0.6975279509018391, 1.3346261438248117, 0.9271778406477604, 0.37149794439364414, 0.31283673119799743, -0.7727180188112602, -0.5465863254432715, 0.8477027236909724, 1.5156915346292246, 1.106726574675151, -1.0583541799283809, -0.5898201954683984, -0.19099939374744979},
    {2.4767063107097527, 0.512130481794542, -0.46999248504135904, 1.3451216522314944, 1.0709702986327334, 0.9023135065865701, 0.048234109446573865, 0.6316196615168508, -0.025750997834082284, 0.15872137610630668, 0.391758438290326, 3.121895133131005, 1.8803942928158162, 1.2093261649343077, -0.28580060762482784, 1.0439710995275953, 1.1292634820077576, 0.11984980104992836, -1.1696674579905184, 1.34765551996496, 0.225653156483189, 0.7381597769587656, -2.136955792147778, 1.1077584374776832, -0.24776657711374245, 0.10845799187919652, -1.3802877155773696, 0.19694818395065267, 1.3007253353992734, 0.5355048323111566, 0.7151645454156261, 1.3588932440378054},
    {1.1065040164849014, 0.8162418161592881, -2.231337498684366, -0.5998089508849194, 0.22889239957504162, 0.9396323877757556, -0.3209821953191056, 0.1546355749153287, 0.6450000453810711, -0.0631580747081751, 2.1880333927981015, 2.190572868882414, 1.4725299799074612, -0.3187529795348107, -0.4700892479108754, 2.2567841688040806, 0.010106085469491582, 0.41424343578889855, -0.6355364486127381, 1.5883582019890061, 1.040677442940584, 0.6963645100011892, -0.5725701716768281, -0.33094897420425207, -0.1792503098495718, -0.6358810694180196, 0.1854656124338887, 2.3088282680867227, 2.2677469073918086, 0.5410766815392792, 0.476040371956305, 0.9442114844339329},
    {1.497497686739834, -0.13740966559120807, -0.913842394663806, 0.7088906934635885, 0.1703560542035916, 0.744616605437261, 0.7603332606335718, 0.3695379218202805, -0.9511069644292751, 0.12377380846815104, 1.7943368394263783, 0.3822779575548989, 0.8017857195876646, 2.370558694136614, -0.9874718129594777, 0.7327916300599431, 0.05166949313737458, 0.060290021806140646, 0.6033582434301257, 0.6126303174190157, 1.6317848658545846, 1.566652878671942, -0.3968605845947833, -0.8454047310975121, 1.0587990725867582, -1.7585578575192635, -0.6880404161913878, -0.20303414201568848, 2.2324768416060845, -0.3027872195190219, -0.2000656260211731, -1.6232542268201102},
    {-0.28495233531587494, 0.18018621679087873, 0.8520352890753838, 1.912544839901088, 0.4008103932933254, 2.5310284003617833, 2.4435562078907114, 0.7356051831698203, -0.9755183575493154, -1.334378064671214, 1.1170150687542977, -0.5152941974394546, 2.9312309333320594, 0.5099138659349953, -2.0871509286528864, 1.3194073380112397, -0.19531817353157277, -2.380186789681288, -1.1734419679224715, 1.6417273118306546, 2.684635049358449, 2.2254056437031022, 0.14537381652663128, 2.1759294565387197, 1.2520658858192872, 2.326533670355398, -0.26349096935136546, -0.005093440137107115, 1.3624797895153957, 0.035980576767823874, -1.8563731007444002, -0.7882760787746903},
    {1.0611088901336847, 1.7994095653038482, -0.5279325587848382, -0.7041956283098704, -0.45470313418483044, 0.14529877450640263, 2.672129825412885, 0.7196894806986892, -1.3504709751145991, 0.09484679615651437, 0.8714777875033197, 0.5332403377056277, 0.4119286430894362, 0.786003339111919, 0.227565945726382, 1.7890158897465864, 1.7122728924336066, 0.054363325648237294, 1.03149540275821, 0.3514986400413903, 1.5317739101476229, 0.3298343535337864, -1.362544941067475, 1.2556795248259462, -1.3096982638564862, -0.8070647107252719, -0.17495185514102837, 2.594199155824992, 0.7052056982556493, 1.0491354919354972, 1.0312784181734462, 0.7642905823546472},
    {0.3580530596943699, 0.20460095643876686, -0.059674321104870184, 1.152962877990469, -0.3654002424859406, 2.2198439243571793, 0.6957803359598116, -1.6494897108232607, -1.1494042941718425, -0.14536205277243852, 0.34038295533913693, 2.9015292487294686, 0.7424270650736835, -1.1852426911078133, 0.04663722962516939, -0.17260765299425654, -0.3050888106753778, 2.5742244453183516, -0.5554432314167576, -0.17104556925942246, 0.5594743142134103, 1.2394832016885164, 0.6610829170446237, -0.30868479776448754, 1.146111539646776, -0.8113561883617676, 0.1515032761411912, 1.6696417832369403, 1.3508973471113856, 0.2148040228557028, -0.06269006241628207, 0.11273469607919291},
    {0.6857814296434528, 1.0019665933755706, 0.45227338685227514, 1.6004110720065123, 0.43361677860400183, 1.7084855136144839, 1.1976785111890706, 1.1505151608478883, -0.49516262695417196, 0.7280376319532604, 1.9197778997562644, 2.4545919542452395, 0.11584909372181386, 0.6159280033962695, 0.5344170265492941, 0.8088871048108961, -0.5690994646558045, 2.9558163841302334, -1.5293045724291152, 1.2191101614075361, -0.42826190370566153, 2.878796614959244, -0.23793250275252714, 1.3353984194035624, 0.6668205112314723, -0.3729789184213645, -0.7937268471912601, 1.8857693445265196, 0.041280959241966404, -1.1642557873180073, 1.0692213797992811, 1.5368476445308354},
    {0.6009710560661277, 0.5881123325904057, -1.0919558149948185, -0.5011408084841431, -1.1070303083537594, 1.7545223949124213, 2.6846391433767023, 1.3276063817877186, -0.7212537455956827, -0.25528875907600734, 0.01793965354435299, 0.11391591567196804, -1.1833051080519725, 0.4313483567668459, 0.9258431211028143, 0.07939743220422224, 0.43236027031836016, 1.5990582880942081, -1.7305076452446646, 2.079160720815326, 0.11179549816583892, 0.7625688979351056, -0.04506636593085721, -0.36196972235492353, 2.0712204785686525, -1.3331165476177027, 0.5639359363690359, 0.301867676025406, -0.2735668936881331, 1.6356811453668907, -0.3500364543725676, 0.8798144381158969},
    {-0.6503516117804236, 1.8113382834795562, 0.8699234061519453, 0.621453064588365, -0.7547679803449532, 1.0240414398171458, -0.16892360028995218, 0.0638389646528408, -0.5028388943025709, 0.2756994874877461, 2.140149024593615, 1.5754467457545374, -0.2105386067452613, 0.547349062581618, -0.4825248274668276, 1.4590901463580623, 1.6885600762111719, 2.4047358851326384, -1.3259469551946288, -1.4013238764583662, 1.0719917892458568, 1.7011513658704025, 0.6597078649836466, 1.5257595876521333, -1.081756165193331, 1.1098728093794075, -1.9353641587051205, 0.5799084744371279, 2.386531190773948, 0.23527824656502203, -0.8141535577538277, -0.27941813698579016},
    {0.3124962576639182, 0.8586712059838265, 0.370325163184633, -1.785277784841534, -0.6976925132395057, 0.8969920699563659, 0.6396995792638435, 0.7524525602642327, 0.5790211907616666, -2.1465920580695506, 1.7619976573742666, 2.037927419464181, 1.1378093662269906, 0.24870639993627564, -1.9230410164236882, 0.7846690693809545, -0.30747879483619894, -0.517418640158339, 0.5344543826116902, 0.5649334072680894, -0.5304979584557115, 0.5861500320325393, 1.4627429939881968, 0.37293957738225497, -1.339225124061086, 0.5320040020350958, -0.9219345580482518, 1.1207090029393614, 0.10967734887431344, -0.2831962336689117, 0.18218514814280973, 1.1538834483032248},
    {-0.6992378321130829, 2.129097804063882, -1.337386249723276, 1.4370670816888615, -0.670114963639534, 0.3952687786483479, -0.9420316487502481, -0.3229614279590088, -0.7905025581385928, -1.0448203243575855, 1.3061826650550643, 1.7424449705829852, 1.9466500636558093, 1.0278317964553783, -0.5791076115802056, 2.3836671464083046, 1.6092620689767925, 1.8323055464960405, 0.37484440424683446, -0.46084214583466127, 1.199015918226113, 1.0863387845777628, 0.5201263388992801, 1.7568461568968814, -0.045026682082986616, 0.863546445412069, -2.1213341440369744, 2.6316927431494563, 0.5488242143064361, 1.1246244552093312, -1.2126589820285474, 0.5725158659608741},
    {-0.3259228858658678, 2.038636117187593, -0.4053190039916701, 0.3849636397591997, -1.02862370506624, 1.2700311697471625, 0.5218800648608584, 1.3993216395388675, -1.0759536105536422, -1.8615249267916956, 1.1927450714957226, -0.13564757198707733, 0.8956316515924024, -0.35056482406211903, -1.128066226999616, -0.5260191306345744, 0.439968193640609, 1.406032993512425, -1.398103063501269, -0.638711415490301, 2.1544416993271276, 1.1548001791990818, 1.2018646313174803, 1.6423204638681894, -1.1235711724135162, -0.3782804000670989, 1.0564577247172355, 2.0078405049099057, 2.366308485741098, -0.25727311924821505, 1.4462396007420766, 2.4811958142961674},
    {1.6466822526934155, 0.8109037497772212, 1.2080374468246906, 0.08679045523821499, -1.4241816544529764, 1.090615873642801, 2.2778813927533283, 0.30127596480816066, 0.07678276246570269, 0.12989932546328256, 0.8362686314679431, 2.6013343176530146, 0.8472634507012818, 0.6967586906996612, 1.4089115762501745, 1.4286763587464681, 2.3567800640513976, -0.15170744684475376, -0.3034081066815181, -0.34141770001599975, -0.13980844016525493, 0.7098461072407765, 0.9647482386535899, -0.4050123932578582, -0.15419665868254517, 0.3989015209180529, -2.394944367722245, 0.32008524456318366, 1.6100538631963877, 1.477809118734783, 0.7079172662098843, 0.6739605390315974},
    {0.15092124256100048, 0.6082183540809065, -0.7569558831489706, 0.7792089941005634, 0.899675724066601, -0.17421020007537, 1.2906990413396737, -0.6203657605119647, 1.053440069334298, -1.117733590615607, -0.6796516240773878, 0.6990224572880699, -0.32811267367104685, 0.7153795538809153, -1.3299348494418166, 2.8902522306163934, -0.4156627328836631, 0.9578790819551879, -2.1002576299684628, 0.2584753861112966, -1.2694083606886282, 0.0745648838221095, 0.7930931840254644, 0.8289913972612503, -0.09971778398419553, -0.34648048093269224, -0.6513682492285932, 0.8110185384684042, -0.2951968108467028, 1.7763485309655058, -0.19269812617028836, -1.310309283101257},
    {0.10358053493708554, 0.3120840608879097, -0.2447801867331423, -2.0979158120932637, -1.2649774500477797, 1.3489155547884777, 0.5311937768162674, 2.143910145651853, 0.27574164679613716, -0.3730645574393908, 1.68406197053169, 0.05218880408098327, 0.4799281767516961, 1.2559227452146662, -0.9048572408833989, 0.7734937207199186, -1.4846626216494145, 1.226556912968607, -0.21295452565842396, 1.1553463534897122, 1.6217586847715437, 0.6617726333589097, -0.34445362122383616, 1.7088447332882073, 0.6023837547004905, -0.8722359350371652, -1.2960688824143438, 1.7306468640770913, 0.6285290220683826, 1.1447315810572523, 0.4506298739753459, 2.05498634546753},
    {1.0888246411516533, 2.1403389054646205, -0.11080337750650107, -0.6517705077992076, -0.3935359181938909, -0.324017557406567, 2.236140541008107, 1.2987510133508928, 0.5187878289271374, -1.547952410854556, 0.1288508465149112, 0.027193824026024358, 0.9329779522352434, -0.008673041983375403, -0.9067303186392616, 0.6744883212484027, 2.010408538539708, 0.28006488316445793, -0.12213479680851624, 0.9328726464101377, 3.066230211821891, -1.709218365082338, 1.42837842586107, 1.283615619977869, -0.47028007731834165, -1.3694770421989966, 0.8916276077454474, 0.5185594293164403, 0.4904603410192401, 0.6342099513635503, 0.6614723051095791, 0.029071954166646978},
    {-0.8367731401477635, 0.5263111557815302, -2.386460701301278, -0.8134323265518631, -1.0216527894917835, 0.5486615209142509, -0.1811235339429675, -0.44934440074605014, -0.9780484239277233, 1.1691382232909628, 0.3960922278021046, 0.4675745971546793, 1.6594047136613617, 0.6632885729430676, 0.49675454081040343, 0.3609340222955442, 2.134042457087976, 3.1419368848006095, 1.6656961184387165, -0.900179656490173, 1.949151508083525, 0.23826043990527157, 2.441469274639106, 1.616115220919671, -1.9645311630543372, 0.37095304965654335, -1.0464730845629882, 1.0031753111531563, 2.171472860749881, 0.901527711962162, -0.6652868187319069, -1.1944628779511395},
    {2.3711743649356523, 0.11356248516838129, -0.25665796118260187, -0.1450894167464348, -0.46842329975112956, -0.7661208307725405, 0.4294372528812986, 2.2847941721404204, 0.21821817857085943, -1.1386627258768416, 1.0101956797144005, 0.3740799438492193, -0.893681856982062, 0.6262668745197133, 1.4344373924796288, 1.0612942573117246, 0.9456152001951416, -0.023571737192729234, -0.2113703952030003, 2.060256862588836, 0.33630946888815505, 1.1210065189848273, -0.1347212079562657, 0.8362964219853763, 0.29204843701947203, -0.5498437145947885, -0.9635301763596299, -0.0381318974185504, 1.0474812314238444, 0.09954977130096127, -0.30167995945637655, 2.1338144171271893},
    {1.8157365127458704, 1.7613480837333224, -0.12274968794375912, 1.3085152095162482, -1.0336242348819387, 2.3667304566895933, -0.3891828213053962, -0.410385284533202, 1.1423886254244633, -0.7658072403881262, 1.0083184999646224, 0.8985045730821852, 0.6231443282171631, 1.4835999292401987, 0.18697220126699965, -0.19492501319775227, 1.9706348034173342, -2.3049012220635015, -0.6347574842502471, 0.916737902751064, 2.1584468140362505, 1.4932083997092487, 1.2321770653472115, 1.9905195372957953, 0.7779691406390247, -0.8626804574926332, -0.3190815617147303, 0.5589732147364525, -0.15683412530060598, 0.009925218558825106, 0.8122165318225537, 2.709834796345449},
    {0.42714663092880517, 0.5714020830457911, -0.3527158936708025, -0.2872845054342885, 0.0677724228091474, 1.3794882266893342, 0.36387305329809627, -1.4531233683236946, 0.873489619120783, -0.017294302853176725, 2.3773580613515395, 2.4984898726376685, 2.0322739146859576, 1.0733845009885203, -0.364422982898668, 2.731920111899406, 0.7256368959843892, 1.0758386467698313, -0.5881887537678645, 1.4434298195365973, 0.3887919912437775, 0.9114802394452706, -0.6207475049221807, -0.20232127477885484, 0.1932833668168899, -0.0021758036434327077, -1.5686851556777932, 0.36347048120703723, -2.3019025259817663, 0.7335614421735658, 1.5681447541778903, 1.6516042602702143},
    {0.5332768343231492, 2.090672070239863, -0.48032885519239804, 0.658829005165449, 0.30427490713928573, 1.2202465479775366, 1.8449953507243915, -0.5537259537995869, 1.3762533398385872, 0.23260782622900503, 0.9135542958411997, 1.8185013383458541, -0.12905433438542877, -1.8377808796383117, -1.1459182243110504, 0.4926722728962329, 0.2035354789594186, 1.4467045119819208, -0.045024496525291766, -1.0230797872843618, 2.5395455224105667, -0.013217721285118141, 0.8323864220953641, 0.06054247671634119, -0.35095724957213886, 0.051689410086620355, 0.10059237328575699, 0.8127846934734106, 2.239832791044267, 3.398863602694285, 1.6978690724417642, 0.7073564188047343},
    {2.141828950630371, 0.5722394771897787, -0.9740550199614475, -1.1793010688136407, 0.6257434792853601, 1.1607913649663701, 1.653568108360724, -0.3683474189150779, -0.03560443464621951, -0.3929668252871553, 1.7854546305767651, -0.0850535230221289, 0.4050163959003466, 2.0616829083488923, 0.36898131773155624, 0.32180393458565043, -0.9702481618839041, 2.284144050757067, 0.056093794508262386, 0.6437542627503731, 1.5486084064320236, 3.1915264648282324, -1.560594030529385, -0.1342939168398974, -0.3535072488454005, -1.1957907540057873, 1.5888026742293873, -0.19486897612105838, 0.4471246520981713, 0.7350338310128589, 0.8673824913043787, 0.6110850278062665},
    {1.2836889863457475, -0.11728645621532661, -2.75284235337498, -1.7580077705924457, 0.624732058217918, 1.380527134471649, 2.2871618910919893, 0.9090262033855999, -0.07260454438635004, 1.9658756692664625, 0.7340777420844803, 0.5425907738311347, -0.16346801969066738, 0.48097097069525013, -0.03674541857467099, 0.5103802165696838, -1.0058332344724585, -1.0197097018163894, 1.137648597183277, 0.13834753511721498, 0.8001110337626469, -0.3766375068803602, 0.15185004066289995, -0.6277726120806048, 0.0626127682069294, -1.090016941816667, -1.7158198660622874, 0.034914481193800716, -0.6975462396560513, -0.7544115098667514, -1.5484865636172815, 2.14672125113365},
    {0.7884875951780449, 0.6773893567526582, -0.21199760543073462, 0.0588783701880206, 0.0030814586094440647, 0.892095756634447, -0.20957140129486324, -0.9805712380181532, -0.15610929572382196, -0.3133249016001689, -0.03171153979892489, 1.0571148708343077, 1.6157424799505897, 2.6938632319378883, 0.11536653272721407, -1.1293730677561256, 0.8022837134387645, 0.367527426748007, 0.3093693892538186, -0.10377143220815553, 1.971227548283446, 0.3404699843848511, 0.8068592468502956, 0.2836315530330159, 0.487056193207819, 0.011473646315483695, -0.059468611291177975, 0.6401564871616668, 0.13842336161503188, -0.1839820148591199, 2.231831624028706, 2.0368210957385187},
    {0.5964803455083563, -0.27053816310755374, 1.3126730206457704, -0.31992963097723276, -1.2446633400584188, 1.9872154567710163, 2.007994963879173, -0.9072174425324602, -0.6639153379805173, -1.8232435507113811, 0.9899529566088521, 0.6008016965269657, 3.130553279712748, 0.1517126625991853, -0.15399145934682082, 1.5228814766890497, -0.06976400606207307, 0.3184353914370093, 0.04740071785769212, 1.297696531501643, 1.5082420550992464, 1.8548759532000527, 0.47004559361930165, 0.4811468046227881, -1.6978122022358535, 0.7005690390193978, 1.4951253551863153, 2.035315877765121, 1.4564304348561348, -0.09453363122696382, 0.13869654970798137, 1.3231628260829078},
    {3.066525978193749, 0.15918122605751353, 0.8975526511435729, 0.6443811920949892, 0.4658914515338571, 3.2292181911495796, 1.2427805579697235, 0.3954055748391714, 0.7973202362591384, -0.06753920959760787, 2.8421538967695614, 1.486332427775352, 0.9325042781482822, 1.3180235933102908, -0.3801440738964864, -1.0057917181328146, 0.6866196967242828, 0.29978364041291433, -1.4137315068558942, -0.7441803677438673, 1.2975830058461162, 0.4797207367620842, 0.9275128639177151, -0.8979833860280194, 1.5048567546091318, -0.12026971461113628, 0.007307733728104572, 0.5736106972344138, 2.7208264731428655, 0.5243712252183792, 0.2926703971375336, 1.1184651717671192},
    {1.2337444583018085, 1.512975041621819, -2.003375796822865, -0.22512570606523669, 0.2021124655923674, 0.8854851637432802, 3.613882244464919, 1.8896510824917994, 0.08678340190110746, -0.09438168061998513, 0.5129130064149885, 2.8008345204554628, 0.47006358524171854, 1.395279786988624, 0.6451457777299346, -0.4628611416311925, 2.646346569697136, 0.19621585936899144, -1.4839404096517284, 2.471306259422468, 0.7941214549735152, 3.9665185893938566, 0.3439042005165156, 0.17387129354489603, -0.7106960325274994, 0.06116990672461016, 0.38796140931953293, 2.2216804038757303, 0.2715245826320102, 1.031253217814752, -1.2057469663586307, 1.31103770866955},
    {0.5221895382771266, 2.5674301779157864, -0.8021799392968831, -1.4815100371048544, -0.18166450538825468, 0.7423340924248867, 0.30547402145111424, -1.1889461642180172, -0.15657147765789048, -1.0086972316161025, 2.4740539342303185, 1.4964501710118083, 1.9525826282007532, -0.6315466210347495, -0.09557156348907053, 1.5725188258858607, 1.8023227459313969, 1.2199994646205798, -1.2259833077123659, 0.723929516225568, 0.5826846705682339, -0.34955655384217554, 0.4972816117122732, -0.10010870360089917, 1.2298600858513544, -0.5148122261842832, 0.29986007238597023, 0.9159504873061317, 1.7845195755111058, 0.5450090698118855, -0.6921982764258957, 0.6226852222828047},
    {1.957542496962614, -0.030211122935543528, -1.95600447966458, -0.22875415858556383, 0.35014398190021073, 0.08191179674044088, 0.7333175313276038, 1.2011994533795813, 0.36696575101995904, 0.7283195437338256, -0.9680399550831601, 1.2464051637894882, -1.7795696138000172, 0.11621458711305076, -0.26618471656891746, 0.11545168423263638, 1.999032214971608, -0.18238113459030442, 0.5020982701584442, -1.2658385983325453, 2.631403906464254, 0.3741400959055081, 0.7493056193430053, 0.06289929937934587, -0.019115144525001498, -0.7095066769713626, -1.0863496529684427, 0.06223567299795089, 0.8228818663326366, 0.992783788181449, 0.5673522997228191, 0.7107116564796029},
    {-0.3586764505742791, 1.0489694850055253, -0.5249692860154859, -0.023282701199678752, 0.01448955079273754, 0.2925863620927172, 0.16795389185642431, 0.4525710209544855, -0.9424786001504929, 0.7324672152621707, 0.4306508192045476, 1.1011205889754472, 0.21292953837279857, 1.3936547013452476, 0.6366349293367718, 2.4881522200735025, 0.9699590302404835, 0.13760129371395355, 1.1018254714979578, -1.0448433250137994, 2.6475659561675595, 0.7198296441283484, 1.1716173287453362, 0.4615949852758682, -0.4624439273946116, 1.3037418885824277, -0.8732743174551325, 1.7510549749825206, -0.2572569598470957, -0.955679014258343, 1.268195505169574, 1.2311526900413796},
    {-0.26652994240574696, -0.8789516246571177, 0.2987778798998973, 0.2934651446078369, 0.9175419485542294, 0.8654193989349424, 0.7800148990552802, -0.5358002070600882, -0.42157625752656663, 0.4940091589726874, 1.0142826256618906, -0.5537227945856885, 1.0480241711878877, -0.3630670567222663, 1.0667466992672707, 1.8489751302033048, 0.5341019987441143, 0.8287740288288141, -0.9105703559658016, 1.110533364274974, 1.9349520498743313, 1.8711317949897668, 1.5840547464975843, -0.3218478119364725, -0.3706823365301192, 0.3226356649536678, -0.5976075664031149, 0.5871546063252808, 2.422419654423274, 0.9308339378921339, 0.11216313347549878, -0.016852667083627947},
    {-0.7575620090623612, 2.3226364554924457, 1.1588849128623333, -0.7252878820956769, -0.5823927069876261, 1.3510673580481398, 0.7891551989447425, 0.5882318873100818, 0.8420937911517713, -0.10982464774547064, 2.1249348612859853, 1.9897070923709717, 0.4192153053872559, 1.4021979504388271, -0.35425743814853417, 0.6898661035604137, 1.6707678494251168, -0.08417959163241091, -1.6621536425792904, 0.0016905382792047985, -0.6382336354918475, 1.5816352716231157, 1.1835736452159569, 1.8076793001475973, 1.562488311921152, 0.26717220117579116, -0.3476582709714189, 2.870049765716893, -0.12657878850741766, 1.8243094910386164, 1.4239645360518043, -0.4411492070510798},
    {-0.584617504932713, 2.759512228892251, -0.7757584232679369, 0.10180761911009739, 1.9649418339323206, 0.6741020167324802, 0.9779492235741929, -0.7651699262863773, 0.5380741331295305, -0.8001828369439465, 1.9091472225389916, -0.35095619450175924, 0.6508456416341407, 0.42187842625719324, -0.3721219302695963, 0.845162653994139, 0.6233888511782992, 1.6915159157120534, -0.7800375193998401, 0.44147255193492907, 0.6381603955104412, 1.0546089985249318, -0.3261396664861189, 2.928510628737862, -0.07521249047441732, -1.047086290411594, 0.21261977374387497, -0.1699850794514138, 1.2964569619508566, -0.5936945478302849, 0.4101273846819483, 1.339561339794438},
    {1.1761830104535873, 0.5930964703816285, -0.5996774228112737, 0.8924816020783286, -2.004392953872934, 1.618695218246441, -0.23852162322605694, 1.686309158040002, -2.5657911511208447, -1.100701890413108, 1.7684021020156975, 1.0442187768223286, 0.5257792356766519, 0.6578633402721445, -1.7639550901676124, 0.7648306838412045, 0.5874218829198391, 0.9742475717254743, -0.8336272021207037, 0.47775505965108095, 0.2560780766377089, 1.1958097166609087, -0.27213772653930424, -0.4330076841065341, 0.3399315039851477, -0.8065355964233116, 0.37468065802780304, 0.3365582488890108, 0.8692990677605517, 2.7024692346924457, 0.4544875776062386, -0.012173295883254057},
    {1.206286890301558, -1.0200578684149242, 0.9951146775769009, -0.9249686827477592, 0.5528714199530934, 2.4472084923060025, 2.2498176141024486, -0.3839086327900297, 0.9865199355620488, -0.7320488696740856, 1.1425502868896518, 2.7220245968845274, 0.1419431457984843, 0.9208405199904608, 0.44012793216255314, 0.9178889322752862, 0.05275980222969136, 1.9087216295513156, 0.8741779144329729, -0.31895228370507583, 1.9218064115019255, 0.38465978871960654, 0.28916475841120093, -1.0871335837439848, -0.684956715464768, -1.551706510748851, 0.19340370274522467, 0.20813582844198214, -0.9410589545752268, 1.039115582080844, 0.9086039623259178, 1.3234264290586137},
    {-0.15059291963432214, 3.4889523050738918, 0.194184670893855, 0.5665286898472456, 0.16130365614924622, 0.6510543506073985, -1.4469784005290738, -0.05023717200560697, -0.7035376867687944, -1.119895097949269, 0.3357585350139037, 1.4024215750648112, 1.0252855091250739, -0.5636781790585075, -0.5430382607373228, -0.5040576513476657, -0.29949250886611734, 0.749125980487873, -0.970865247888759, 1.1435147735915787, 0.7065282511876905, 1.594962541124724, 0.10922795121167524, 1.7034164038949964, 0.321896591059929, -1.271827274180632, -1.9875968087852993, 1.4865044000948708, 0.06381254806510298, 1.052058714235785, -0.6731736188437456, 0.24823392742167097},
    {-0.10088100761587993, -0.05654525465622326, -1.761822228524529, 0.829752743985294, -0.8602811480582815, 2.958349208201103, -2.380176921925052, -0.9958655187063916, 0.8323367775415997, 1.0221115034971096, -0.5157826861547996, 0.6567611409456027, 2.2016478274254734, 0.42268358260677963, -0.7926168555516218, 1.3282981759607544, 0.32157512899298113, -1.5316908105791542, 0.6848025242554211, 0.940341689048058, 2.1657412568295986, -0.3003434865187351, -0.16552545808531227, 2.0472243088017947, 0.27678265432169197, -0.6678032980987344, -3.6696915753000607, 0.9154826621100631, 1.4010967622612767, -0.9089000949794911, -0.7166882048934845, 1.823642350947775},
    {-0.22958737671379698, 1.2437741857335327, 0.403072283884648, -0.2614309603884708, 1.2890905606204757, 2.569838720037781, 1.8472527347223888, -0.3212082583636671, -1.4036492423869917, 1.5865428958944734, -0.1891702655528121, 1.076635390763448, 0.9404569925591427, 2.210695701530208, -0.22940615938593134, 2.7401998714112676, 0.09327277859109513, 0.2573883806793678, -1.144960408515861, 2.8643350325246666, -1.1275403372928414, 1.7255684082238782, 0.32767401901375726, -0.19195254687677993, 1.8356463385497488, -0.08589210418546796, 1.0290026962746024, 0.1775939056018796, 0.08355508884833145, -0.28816924743775035, -0.22090682194848402, 1.440182699029554},
    {0.6591942921756694, 0.06400102171194785, -0.19208945561841734, 0.024392343464531417, -0.8647824557433549, 1.2000515853684857, 0.7008382025919275, -0.12187638276783794, 0.5829371311471788, 0.05275130146528582, -1.1058839401167335, 1.489049827356044, 1.6845884176400663, -0.6290879289719808, -0.6911030888664818, 1.937488075409972, 1.3910682256782916, 1.6693527469915328, -1.048772892998313, 1.0584889694095212, 2.22034224151097, 0.5034062300899911, -0.2925756545518059, 0.6774547912325563, -0.49944563446672735, -1.7731821720922412, -0.30662759913910004, 0.016920928301042717, 1.70711505014074, 0.875718367535603, 0.3494989885857964, 1.180045690176366},
    {0.2772874843736248, 2.221220104965315, -0.9762257833536728, 0.09521317113584886, -1.8480243655584663, 0.4777754597885536, 0.8962297038333853, -0.47177670963345697, -0.7264861190156406, -0.1637347837401168, 0.4943068510028913, 1.5943589096768072, 0.6032884757461185, -0.3549735069195627, -3.138588817766017, -0.2358865926678856, -0.9325922401627382, 0.0478041216782367, 0.608406904518509, 1.2065692785898907, 0.8618956445960572, 0.9223321073075926, -0.5963012275642147, -0.5098162296861053, 0.22672238430297045, 0.7743738891925341, -1.1562042328194901, 0.7740216902170318, 2.7312055768390935, -0.02532469966055668, 0.09404175546426742, -0.5095140316291673},
    {3.0409038915633935, 0.5367111882060132, 0.13808714217446613, -0.8563152016150258, -1.0509765881271682, 2.516012910296473, -0.2501785420996713, 1.0316356052569837, -0.630190219752305, -0.566366782026887, 2.0954610916366936, 1.077344104771055, 2.204834708526295, 0.93246864487203, -1.5815495635472814, 1.1688883654460833, 1.2316242690276797, 2.0535826006961018, -0.540483667879292, 0.2502378189252271, 0.9663302806615901, 2.432910448791181, -1.6055883822373178, 0.4304453752446652, -0.3347783834889703, 1.2331009473421897, -0.7025593214605267, 1.3845884629134835, 0.5975710249905367, 0.5875549327485328, -1.1803203458706975, 2.519287631764356},
    {1.12522993263369, 1.2481272693300471, 1.5562408168819624, 1.3460433204443902, -1.2445932306805763, -0.8285800136597486, -0.044160444370293254, 0.6274117639160608, 0.4363730986018728, -1.4305039525478225, 2.8814666837667744, 0.7422558469799317, 1.7187613510592987, 0.7777454996693997, -0.07163859369902613, 1.484514978626183, 0.42917795624626587, 0.6178737745941509, 1.4189986402076655, 1.701236699336312, -0.35956860531914303, -0.9121130636252743, 1.3823566475574516, -0.29785231363218095, 0.10641697117115292, -0.9141568557298558, -1.4618308906862338, -0.4961692549861756, 0.9762652640717963, -0.16179731481309362, 0.2989318907408168, -0.5210060185712626},
    {0.029293854567307206, -0.1265685489122059, 0.1552206622615279, -0.11910518836284349, -0.22454027121918863, 1.7196071207326762, 1.1915554934099344, 0.5047989244203277, -1.6784858263940037, -1.7995319353485704, 1.319740451649969, 1.280672799184124, 1.510951500025405, 1.6790113595836966, -1.3260708371752408, 0.6446903106028844, 0.8587365257434354, 0.2865760604628644, 0.3683743740314343, -0.7500558743178604, -0.304547447694344, 1.3074331725142665, 0.30586726754458254, -0.6978672376921045, 1.5272677338466238, 0.4940367691316168, 2.5015237845579255, 0.6819525592941622, 1.0305016418535078, -1.5998917629339087, -0.2746228813748447, 2.062849169812645},
    {-0.8947286521361242, 1.4178340062833283, 1.3317358913128274, 0.7798434013232819, -1.8451456470011245, 1.2449584983773523, 1.0685599814201225, 1.2550809424153624, -0.3484781988681219, -1.5246419484209301, -0.4039355799484652, 1.421433892211034, 1.0105102638005004, 0.8129832911431433, -0.9138184081774055, 1.436249299349388, 0.942173687764488, 0.5797103808483914, 0.19739103902291547, 0.4783706091652485, 0.3035502898732076, 2.4663256494290215, 0.9813425784614273, 1.2968073491914935, 0.41701756274115065, 0.3848151980342231, 1.5604437121308685, 0.1473604218071229, 0.4860569165469264, 1.745890929123384, -1.0301455895505023, 1.6621673300228104},
    {0.7244084681706069, 1.1309047134230676, -0.8488087151094553, 0.7427501014065069, 0.23782663982870567, 1.2118618382341526, 2.003219226615399, 0.8443652616702754, 1.038068212515296, -0.2967052973100716, 1.1835861637914291, -0.07102754977385685, 1.2969532611497927, 1.4064559362948785, 0.5390955130198667, 1.2868390154495675, 1.633890247057499, 1.547080771943749, -1.61320235282793, 0.8698500951017129, -1.0730976680688007, 0.402062096445782, 0.8442408201797085, 0.4884425600180312, -0.4636547253488636, 0.5465182646702268, -0.4912833299746077, -0.4457971384060703, -0.6692863988428187, -1.083889209954911, 0.6281140527293025, 1.8868195639525576}
};

static const float b2[32] = {0.7893219834099794, 1.39760406085247, -0.4782352771412725, 0.10627498820143343, -0.3214882016554041, 1.3000283513424038, 1.1194736854746188, 0.5812850491900952, -0.4289988999590612, -0.6114166943908649, 1.183809477305867, 1.1858002516425161, 0.8552145949554372, 0.5644131600199124, -0.29482080846000647, 0.9301825364912182, 0.5327728944760287, 0.8445646898476659, -0.39948716198089684, 0.43942042051139246, 0.963160813925758, 0.9333773467818145, 0.6737788157224744, 0.6585231875603866, -0.07701657328056069, -0.40425589562392417, -0.4974436065144996, 0.6680997697905612, 1.1675405743627578, 0.8781408585193227, -0.10297781991319367, 0.6879558246418795};

static const float w3[32][16] = {
    {-0.7086361635229804, 1.4085835513466392, 0.07240811074428298, 1.144576237393792, 0.10999338592032279, 2.1214365752433153, 0.4737657857934068, -0.691129136392985, 0.9662864832604812, -0.010670410023266364, 0.32229136535074143, -0.7117836608131113, -0.806302035523097, 1.549192297496907, 0.7321663576015065, 2.354978784086147},
    {-1.6182632093443299, -1.2644660890826367, -0.2891496192896149, -1.5581029848431578, 0.15602659619226428, -0.0035852311397743275, -0.05879684686837734, -0.9547385837933793, -0.15963319929430403, -0.9340420420034066, -0.8447366987044485, 0.5267370837510331, -0.8803360516815322, -0.13917862943427844, 0.13625051442748515, 1.9173154447279095},
    {-2.58757421710288, -0.5137307327724363, 0.09679116924741153, -1.353331761627708, 1.916200871789736, -0.730471541048743, -0.5808911844852372, 0.7477438133991342, -0.2447951380344276, -1.0232432653041676, -1.2406299592462935, -1.3614060883506545, 0.1093868174287669, 0.8193477636366078, 1.133430698872794, -1.0448753695797275},
    {-1.1618129608049512, -0.44226462786052495, -0.013391532845344167, -0.1775458028070057, 0.06677669859710059, 1.4987414533361973, -0.618093538382943, 0.1276475563334758, -1.9223736299197551, -0.2644394492255565, -0.1190385124575215, -0.9003864093350546, -1.2722988612787651, -1.0232955654978586, -0.8253971479713778, 0.24975309235877485},
    {0.9103072099177746, -0.4891722828829187, -2.5122308310376327, 0.262527963264052, 0.8001621701280818, -1.8168113393759593, -0.7196028182653168, -1.1555942130551458, -0.7746758590417271, -0.08826617375237734, -0.33243978739016317, -0.21275937783782983, -1.5405598771299864, 0.26057406331223637, -1.2082385865073473, -0.6568235688679793},
    {-1.0522280501007646, -2.835185355132692, -0.3435605058369496, 0.9313596156176246, -0.7350853498995474, -0.8671283681820162, -0.2044305241331594, -1.0594101506160987, 0.13179364547704286, -0.3314360050853755, -0.7678514961547408, -1.234476104358556, 0.2170379826638902, -0.37194474028036373, -0.6215319215344605, 1.442820287654413},
    {-1.3581991387271308, 0.6631378086492608, -1.1773868497282485, -0.406281224186143, 0.33890703592281585, -0.3157252807501994, -0.10969613915632848, 1.5514724191379725, -2.1829890674171772, -0.09224902564014492, 0.20407896830952155, 0.32498208049313454, -0.353588277581895, -2.798896242316645, -0.42293559200655134, 1.7505483796504708},
    {-0.6208546504118582, -1.2371537170476994, 0.4976654619619706, 0.8564480399190286, 1.5207894076530057, -0.29351890482491355, 0.5202677120985232, 0.8428329472607692, 1.1448968930623196, -0.8296471156808879, -0.7421293609842123, -0.7661022544851719, -1.6653111394813125, -0.04700801278161473, 0.3666999058055875, 1.07471001582671},
    {-0.5730291321877343, -0.7713302437349097, 1.2628522794262524, 1.1242332800530377, 1.0065035282467212, -1.0910805380612987, -1.5462635474174655, -0.9547475938489098, -0.9894552571374136, 0.6563132290230642, -0.9649268297084089, -1.7444240149331711, 1.4161476162236353, -1.3691053861627926, 0.1330511416359067, -0.1920010354213157},
    {0.07681991768040788, 0.1384220432535566, 0.3598626307441204, 0.5348356760471522, -0.23641121562564807, 0.30071520314599803, 0.03839977299806135, 1.5626185246120674, -1.488393412871186, -1.9237526285162954, 0.09190147908161522, 2.882417367263846, 1.3882640651451785, 0.4875387485338661, 0.6909150475047241, -0.4554767601374238},
    {0.3194587347862931, 1.3513131492505528, -1.346998666195638, -0.03493189968036854, -1.9498888181712783, -1.2328574192007056, 0.4304074866831572, -1.1701759658289876, -0.25350177595731677, -0.8218705263919764, -0.3949186411620467, 0.29086616177177516, -0.9768120351856264, 0.3035570011557452, 1.0032522292788701, 2.2073086543387377},
    {-0.4676587974090635, 0.6035117554091021, -0.910316375816883, -0.9358807792612404, -1.3906653051333286, -0.06329141717369154, -0.14205377547867423, 0.7902276225565856, 1.01160832636469, -0.9566214611840638, -0.8892339127961449, -0.22081511358298186, 0.20180124300500477, 0.25102037205575367, -0.43933593649131186, 2.1837465584851854},
    {-0.1552597678103901, -1.6082395006838144, -0.15145388941066626, -0.7674950586672566, 1.9149684646603051, -0.030252292659910755, -1.0922176184767838, 0.5759350199030653, -1.6640888399320573, 0.31369676322112344, 0.9036140849785479, -1.0227143683278175, -0.7766540209833976, -1.2482100809053265, -1.3198727487450934, 1.2043628646537707},
    {2.4429533787615094, 1.1578186401130595, -0.03816025211132624, 0.5211427532277542, 0.6698095731278567, -0.49107073390545697, 0.9494262799616404, -0.7933307171877854, -0.003015609768673382, -1.7195799503825313, -0.646400929689027, -0.20875266039214965, -1.1377269683734779, -0.8745813604829522, -0.2402622545610003, 1.7934876675429279},
    {0.06575721690900645, -0.11262597593351338, 0.23353452332613964, -0.3332764983587918, -1.246925461209935, -0.6301955385493373, 0.29837276899659937, 0.4757745689369968, -0.40377903118589925, -1.3493641027721017, -2.5707186730918243, 0.48266892062167255, -0.7250363820812176, -0.06738384796857293, -1.0412757207377026, -0.9464853072075399},
    {-1.102245907156224, -0.9644039453254192, 0.33236638120569306, -0.5597542115045985, -1.7717103828062768, -0.44017279504591383, -0.15704047931587126, 0.39310666482997864, 0.6493317012216243, 0.11900496189488721, 0.5688675094999972, -0.7051601896192778, -0.9762781960467718, 1.2370785350031703, 0.0928914432637854, 2.2577732712049934},
    {0.6962770037111123, 1.658414533418772, 0.19668193109463272, 0.8157843080665154, 0.33302702328959455, -0.8813285503844983, -0.680798525836236, -0.41573680944918245, -1.0927613285106896, -0.8382058266638355, 0.16954198056329636, 0.11048751523668025, -0.09754683250538504, 1.300012739606184, -1.9706114239307444, 1.5515612391413265},
    {-0.5742043356516879, -0.04273162056994163, 1.5567095847841952, -0.473818807470792, 0.7445251438491679, -0.2549234380128049, 0.3255155596039228, 0.2732966755175697, -0.5474777533410319, 0.8128035286178005, 0.09046703044580752, -1.22519982226083, -0.8573945758298123, -1.4468386524903376, -2.0113665123142885, 2.3077831879142394},
    {1.2658374778031796, -0.1688061598368054, 0.9566957875307373, -1.4241194062869114, 1.0070995342999873, 0.8829500447181843, -0.22116167489563862, 1.6630308281050135, -0.9653813012089436, -0.8109768266831261, 1.0183897991709685, -1.4797447395107841, 1.8228009924180746, 2.307724101866464, -1.113758243346174, -1.6872540014991673},
    {1.2228082857820635, -0.9468013260106877, -0.8940416482200826, -2.250607312469925, -1.7729258369377294, -0.9098074452248195, 0.14280975512531327, -2.0919832099636584, 0.28140314321426213, -0.5388740466809036, 0.39311199779306555, -1.0844301981129199, -0.38358158795264136, -0.7218662258743783, -0.992024521806301, 0.46950211288647153},
    {0.6855644427371287, -1.3827404274830042, 0.08576413389975221, -0.08162299979113581, -2.109792555624579, -0.9057238354850964, 0.6649368176226613, 1.0497086926021795, -2.495524492184921, -1.0247265856180283, -0.27472001689930675, 0.3761010223446675, 0.01667646332536425, 0.26670679996325364, 0.8141582565087472, 2.6902043171744046},
    {0.3898658625645868, 0.0010581666528817276, -1.2087750265838717, -0.5207995337478694, 1.5964175916398955, 0.041901349512316666, -0.057704164498474285, 0.18760866932193027, 0.3223217213535734, 0.1132988976138586, -0.036645120625341705, -1.2295570364873751, -1.2291468767590552, -0.7015826152294469, 0.8421182638212428, 1.5696786496047448},
    {-0.9476279635181918, -0.10781684690466685, 0.0331660223789682, -1.5816821411707918, 0.1837035978782443, -0.4615885949092968, -0.7919703505698943, 0.30537063059736386, -0.6125738024166316, 0.7468254760726357, 0.5076395331353594, 2.0647815278637687, -0.43671339053805214, -0.9131038618417149, -0.7055426263232666, 1.007514226473338},
    {-0.275012964051734, 2.22779208247676, -0.7991030746141963, -0.1159190228611953, -1.1819489305992956, -1.4487315550594246, 0.3212644049087635, -0.29163271933231866, 1.7087017458932012, -0.6839466973799674, 0.595492809925943, 0.7676792606611709, 2.5389603627781603, -0.49431905099000983, -1.515053537547858, 1.0898608867840245},
    {-0.6869417974738379, -0.7910845423529794, 1.6631141935185947, -1.0699433577275472, -1.2584073892255438, -1.7597632621404253, -0.022031043247366034, 0.19210406192363688, -0.7682217707216891, -1.830983546034837, -2.3786124279232608, -1.0403890167602043, -0.1334362686066173, 0.1997899891930606, -0.3054946486433081, 0.23589031795942525},
    {0.5784361452252191, 1.3856585443286569, -0.5763616241941285, -0.7483600724487397, 0.03807130165626162, -0.6264486702017085, 1.1109726706037493, -1.376982141451766, -0.2115105473293726, -0.2599709642833443, -0.9882910632190683, 0.745314377750292, 0.5113614673036186, 0.5338639907799635, -1.452181019119297, -0.4932386211142844},
    {0.5768469266809576, 0.9710655789843338, 0.24480797174418162, -0.5250151963526519, 0.0728182621967974, 0.6892962441790216, -1.268414757498325, -0.7414502630152449, -0.8680283182082791, 0.8522760287263405, 0.53349516567602, 0.2956524842967536, 0.6702894331828733, 0.7918106306343811, -0.39036624412281795, -1.0975699193815243},
    {-1.499913256108364, 0.7230822233635777, -0.0924817469840173, 0.8980637606760357, -0.3921670780433404, 1.5929578570520249, -0.161579080059679, -0.7427423255241995, 1.1488002560853252, 0.13841942050136447, 0.9027542198228083, 0.03855184441525788, -0.15701266894870713, -0.4881928873932452, -0.70443337256932, 1.1776827425586749},
    {-1.8492864283574553, -0.26222928113741084, -0.16062846042991835, -0.3410676026757776, 0.7578682594300908, 0.9228922085562803, -1.4045553710147922, 0.6314102784247486, -0.6102093850679378, 0.6032921532760074, -1.9647918314900128, 0.48478392422772626, 0.514220588090787, -0.591061152952557, -0.505015491872647, 2.049177583249867},
    {0.09730906520892087, 1.0951019645868132, -0.24799668333284983, -0.48347279249295927, -0.1629068142877992, -1.3988918902145644, 0.9089292672405184, -1.7724816777085812, -0.759190735544261, 1.0233811704334699, -1.2281087116424805, 0.3340951435030137, 0.983109930865237, 0.8764161684146241, 0.35886138107522053, 1.3548645280031488},
    {0.6457084959722069, -0.2561172549887722, -1.056039793127477, 0.6022773434702023, 0.865271960563945, 1.7750048671516194, 0.08430238812607002, 0.785225652958575, 0.5421948778835827, -0.2227805438615515, -0.7131679073656197, 0.19870016541920607, -0.582455561888801, 0.4408529664803858, 1.5678209201303723, 0.49056249858234097},
    {-0.5875085191138865, -1.4619292464871987, 1.2719224300150982, 0.2578883784464231, 0.8021233765531676, -1.651157140211297, -1.0195098581101565, -0.3900269149262732, -1.8518555699436061, 1.021757349519783, -0.9966809827695524, -0.09442097127953099, -0.9097437405231549, 1.6588556697361247, -2.1791598559658083, 1.6027860303814305}
};

static const float b3[16] = {-0.28165927578252786, -0.2669655310866309, -0.41933472542531364, -0.28145596082692875, -0.34977023664363616, 0.0326681946993006, -0.08064458102166154, -0.356663113453052, -0.41279177172276493, 0.07568567636584121, -0.36213487791189325, -0.10272091271335737, -0.171203483804392, -0.33687656246303777, -0.24061051375548365, 1.1074923073474214};

static const float w4[16][12] = {
    {-0.7858241632206381, 1.041988681141345, -0.5159346710313988, 0.8893311803987186, 1.9449915985357769, -1.6007763162780573, 1.3611301334563832, 0.12404120779537779, 0.6534091851918816, -1.5557677689676053, -1.2486587707133117, -4.3722288766786},
    {-1.5789067225852802, 0.20721693612780823, -0.9992342202949132, -0.38003021413355154, -0.8805118078112228, 1.508023293606875, 0.7667553654906721, 0.3822924367488765, 1.1362989724841837, 0.18793462107065304, 0.3287461945246185, -0.1635390365687146},
    {-0.35587580580698347, 0.3893860987405985, -1.4206692455092917, 0.5405959279526951, 0.9354365352492012, -1.1002154411419758, 2.1849733491583647, -1.1474024501699658, 0.4204656491301738, 2.418849470367298, 1.9332337275144211, 0.242864379826102},
    {0.35098058981666985, 0.40982238852818936, -1.8967990375063548, 0.03196169501627795, 0.13824544705226133, -1.7359674577055815, -2.3013491017370873, -0.48378653015037903, -1.0305922155104632, 1.4120183465209983, -0.7375844382934517, 2.0821739875825074},
    {-0.04277101396028536, -0.772704211176201, -0.92971523745519, -0.40546731855070856, -2.2800271752689025, 0.4107273751776961, -0.6968322606664745, -1.6562174602466049, -0.11542858824243611, 0.7720294504840042, 0.9290159997968386, -0.3814290825930028},
    {0.06856980144168312, 0.22953178789722337, -1.8180717352799964, 0.6552638579470127, -1.2420788825672995, -1.4300454992901765, 1.2757898740776727, -0.18552673422078214, -1.0345397167604329, -1.6256884812649446, -1.0196081537086557, -0.6634016480349818},
    {1.4494781171180156, -0.774283899832359, -1.6656086396091245, -0.2991667144557593, -0.6525278353200832, 0.7519007628094405, -2.5985094203873893, 0.3356976853841685, -1.1827987441280494, -0.595433495954754, -1.284099896606654, -0.27828736157325207},
    {0.27058924611931073, 0.6535496030778825, -0.21914521369990184, -0.2837395003827008, -0.293337756389679, -0.3193569845931979, 0.4825382267291133, -1.5441078925739997, -0.9177551473600682, 0.9502984880887878, -0.8830065090815635, -2.166354141391689},
    {-0.6029578456210913, -0.09346715480822335, 0.002347213454817512, 0.4408099050402279, -1.3254280953305, -0.9625503511497804, 0.46091800173296, -0.6885579651958362, -1.2197612468923054, 0.7680062466206599, -0.892338433198743, -1.2162156536679134},
    {-0.09390929861891961, -0.19866731908496774, 0.23009368550526293, -0.28216112674254135, -0.09579629924848912, -0.7694011540869246, -0.11146200682616089, -0.3546818026310456, -1.5106226102911855, -2.8588659614502734, -0.9108861702489486, 0.5273080046233074},
    {0.3916888183573279, -0.8601241121611972, 0.4114177254503763, -1.3548458471627847, 0.13079006470918397, -0.6935652119268676, -2.1407464147357387, 0.4777015938491859, -0.0011189657939960648, 0.42239557764074287, 0.53980457881408, -0.8481864460465074},
    {-0.2524395001694245, 1.5265166046828724, 0.9383972525022538, -0.43633213370525514, -0.8841965158388392, -0.8259194043980267, -0.7299659881974728, -0.5150410782416424, -1.0003212631503715, -0.009107646182353227, -0.9156253414937355, 1.0779531158840132},
    {-0.4369860661845936, -0.8488040696484555, -0.25927048251036344, 0.19615910569480902, 1.0966368029587998, 0.5129306198180579, 0.06980453980306403, 1.70234345493273, -0.725178280586787, -0.7403364211953294, 0.6035782816099903, -0.8010745161243019},
    {-2.317397075879151, -0.1669122191455689, 0.4399408628012301, 1.0139139157340809, -1.6331936016986888, 2.219148558731427, 0.8761179468710736, 0.3430684606517777, 0.6861447710697869, 0.07976299721757964, -0.734928386163375, 0.3133429493384895},
    {-0.5841495774196043, 0.05286262250642883, 1.2779534526204945, -0.8789819146419497, 0.5664743259055803, 0.3988999509676847, -0.14365081109618116, 1.3807446646988475, -0.2166708152561834, -0.18409238107935344, -0.24118401168208392, -0.08228191931230978},
    {-1.211389890590049, -1.201862370950665, -1.5520713854279873, -1.206249004470422, -1.9114515863617856, -1.2168937382901863, -1.208359877865386, -1.213100436581834, -2.851336813317236, -1.211142769449213, -1.2080536104778066, -1.2121893199133917}
};

static const float b4[12] = {-2.4867120430165723, -2.4364602144448844, -2.2715519697807447, -2.3965786267656575, -2.1426209335510267, -2.370461225876439, -2.660354447347736, -2.379194999741852, -2.059446621841628, -2.418905939669432, -2.5264689908460896, -2.3357951125325997};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
