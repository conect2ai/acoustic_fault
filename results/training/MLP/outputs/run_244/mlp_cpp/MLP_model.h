#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.3314947529961987, -2.3269294670478735, 3.2124816707771293, -2.5126212725784396, 4.698054516986711, -3.0269159084787014, -1.1964903306431425, 2.4468592244437017, -2.044254665638842, -0.6513826411101733, 2.8464000869985995, -0.6855045284940032, 1.8344731770923797, 0.9254761885276068, -2.292609809110872, -1.1854327825697655},
    {-0.5113611167529699, -4.688938084251635, 3.042134975399882, -3.769311899824519, 2.9688796484079205, -3.021681189520353, -2.978844391163553, 1.6754799219051326, -5.400323065955226, -2.4414393309277393, 0.38452431126867476, -4.285510412405693, 2.4217037762172993, -0.04820915899955845, -0.6381972700916918, -2.594829416039298},
    {0.5981988441542337, -5.899726304060838, 2.548307314228187, -3.2454636133831563, 3.764940846130473, -2.9122953489778736, -3.7851181227814825, 5.294033292003551, -3.777386894618601, -2.9230331893483554, 0.3359142660480143, -4.739838065886439, -1.0662366837525705, 0.7844959445914018, -0.9304254519325477, -3.5034994651107065},
    {1.4791758281323306, -6.438742100028405, 5.675748331555051, -4.028494581792818, 3.9116931548122573, -5.963849697677995, -2.6771633940023825, 2.0180251589111253, -5.846067950156566, -1.8314064036925606, 1.3279645798792628, -6.381096204094585, 2.834636161989675, 0.7950121876311171, -2.0517606040310774, -5.511057715641925},
    {1.2826260703167802, -6.796596973868185, 3.531637565147292, -3.6292219360143023, 1.473770121613975, -5.3435269263014575, -7.204739204837028, 2.523994784135223, -6.013556707510155, -4.421529418280096, -0.057514209557726445, -4.1120010293302816, -0.6943912336513886, 1.677838383239945, -2.094331444786422, -6.495448734523221},
    {-0.336347129059631, -4.271709978714927, 3.292267040295733, -6.537167733020167, 0.5277201855826312, -6.317217020848365, -4.877780927473675, 2.360255310649098, -4.731563267143064, -5.560077008062434, 1.9875799410699546, -5.063369012569665, -1.3606348821371324, 1.4418634217568074, -2.304083256988466, -7.841900534977084},
    {-0.8792093536162482, -6.9802338728661555, 2.1271628081730496, -8.374126320699672, 0.5714824491138037, -4.449527686337229, -4.233752172168001, 1.4576144536106825, -5.182108931322677, -5.435797582222367, 2.1743835242810365, -5.140857221012342, 1.1730960987859118, -0.7250091705488845, -2.5700686521832217, -5.616968122580985},
    {1.908287362350414, -5.095223909921022, 3.128660058327157, -5.5722115334113305, 1.1996374050170415, -5.095359397478446, -5.426350593546185, 1.6211543221979416, -4.144188070414435, -4.382612629847487, 1.507607530808807, -5.308330979629578, 0.5155666035909818, 0.35798488207366025, -3.056238173589201, -5.412340233469674},
    {2.8820284891492465, -5.3393244624642255, 3.8656877361811897, -4.898857503791891, 1.4443097947352044, -6.176279729285123, -5.146114252997041, 0.3089546542653833, -5.243743970087784, -6.090836656639337, 2.102492620555592, -5.845939592366018, -0.260972993882561, -1.010299237289342, -0.4255588946023096, -6.224132794015057},
    {0.9454169604023531, -6.516288972605792, 3.681118356022445, -7.610611654226033, 1.0758861406645472, -2.712186385110303, -6.735424642406918, 2.096401764091744, -6.528565057811969, -2.807578066484507, 1.9464788539603781, -5.980097510127865, -0.4828646391020729, 1.4040050285662427, -1.4843378914450964, -4.931469263364392},
    {0.5031540222254777, -6.15890740676243, 2.3805770390923002, -4.714319451851533, 1.9563412528264408, -5.7447018323859, -5.212947577138848, 1.685927223101073, -4.523096914081259, -4.948407206420393, 1.543489751937429, -6.821318833540298, 1.1260011849780402, 0.33264820827016567, 0.2695565675228725, -6.063685639080919},
    {0.1277271843101274, -4.864456505496482, 3.219317854519042, -3.1027243176461807, 2.959332580622919, -3.2009585877317033, -5.368136045334586, 3.225965833674219, -6.177077862191787, -2.619457734806368, 1.8042825127117323, -5.198229115973064, -0.28380564898672245, -1.4847743454881706, 0.3802711815789689, -5.385674216429105},
    {2.7520203074287606, -6.810006222344099, 1.436681996100929, -6.62204614760517, 1.8121610003552722, -4.214998260007107, -4.801208933458358, 4.19418955362842, -6.080289721745775, -2.6163283718276222, 0.6091793127901829, -4.884314554040676, -0.37114362048255434, 2.0254848641111955, -1.453017256104564, -4.252709229629254},
    {1.6341422726760761, -6.4907809295442895, 0.0036798771508504903, -7.124843097777148, 2.7192633104425017, -5.068197029143673, -4.66592895306018, 2.8205264324099053, -6.100263343128881, -3.8962808357181324, -0.41065215047106535, -6.403147317347391, -1.1635836007514029, 0.0709575323690733, -1.3116171306997595, -6.816206808757378},
    {1.8622577624282461, -7.175303044489861, 2.5354419545436135, -6.461033474557831, 3.8025708328059418, -4.449157137078445, -6.1510949326358695, 3.369740649835895, -5.04955113118576, -4.913333995591525, 1.3987456226801243, -5.472953403233278, 1.306264099926049, -0.09989837528152012, -0.0922625453350461, -7.288766754054807},
    {2.209170577053074, -5.648467164206579, 1.8411072462719626, -5.940207260970381, 1.7437872179062075, -4.696879294961048, -5.442751870152688, 3.0272239438627153, -5.654597937163361, -3.4109517099460627, 1.1512661269385163, -6.399707947529845, -0.36066843310041397, 1.5994216755681256, -1.0529485940049146, -4.039581718644664},
    {1.9420795275284866, -5.290290407793277, 1.5245617151782516, -3.96676025078919, 3.911380641943785, -4.111218987857208, -5.415677465481045, 3.1107092772517997, -4.524808226719407, -5.1049072520299505, 0.8495567623631843, -7.37030063932489, 0.5934649463205907, 2.289548364265515, 0.1072299233538631, -6.201182499786296},
    {3.0374439016741466, -5.241942724596163, 3.161046453805128, -4.165444061504675, 6.655858638796731, -4.128268888848398, -4.857055250476742, 5.730679732153382, -3.9700120122164355, -4.97640550877447, 3.128948337343724, -4.559296902519543, -1.8289787112355869, 2.829377028879413, -1.2959339809323973, -4.333224908900474},
    {3.8934282136253797, -6.325305868126192, 2.973287065475298, -6.168539122266982, 4.368510629344482, -6.433884721938741, -4.977155939521615, 2.672685903734197, -4.760883677129684, -4.448238419723149, 0.9022051429440044, -5.444015020775225, -0.14736500116194676, 3.5762475426052056, -0.7640271694577173, -4.84708491928305},
    {1.160890539108842, -6.97621499261241, 2.7903576684811893, -5.417145676666033, 3.0335252918699465, -4.916404613675856, -5.871242416974451, 3.2702327739833024, -5.0767043503816405, -4.4359699197134965, 2.1100051092038763, -4.982151350779339, -2.4136805864378554, 3.791261055170027, -3.385982527047812, -6.287543595292857},
    {1.9536816823377356, -6.6535660168561455, 3.348601600874539, -5.7345932577748995, 2.7694200394656616, -6.202220652372247, -6.6170711471542525, 4.780377279635377, -8.359100201129124, -3.7709647464882328, 2.4093201928227783, -7.027235428400891, 0.7740459215293175, 1.5890558659278062, -0.4051806377183708, -4.880988546135188},
    {2.255021372063306, -3.9078075560540895, 7.025361698509079, -2.8939952597369714, 5.810299117907837, -5.652381737377673, -3.7999034996849965, 6.719593499576248, -6.568381360161421, -4.998755178707788, 2.09586478452232, -5.58002540873814, 0.7566975322152413, 2.5522061183004534, -0.9530972857101211, -4.614359386717108},
    {3.5521906808432417, -4.98584229574952, 4.159041094124997, -5.656497539359768, 5.070363200694643, -4.170747624133029, -3.75020557228844, 5.205569577595856, -6.425048488183588, -3.7692702911763916, 2.444668311343457, -6.353932836695152, 0.6452343535991819, 3.58751408635056, -0.9033288621277368, -5.339418666440346},
    {2.4756432828064883, -5.099467891928266, 4.0355262958568385, -5.370114850254663, 3.745205845431943, -4.204565392729421, -3.941749798225776, 3.827303689528006, -5.05551823562225, -3.780924860518463, 3.9450561626318335, -6.2774364985940245, 0.5657310321239152, 3.6783699787005126, -0.9769475423552216, -6.18785826931112},
    {1.8710527308373233, -6.816206806200428, 4.8617654719323715, -6.519050882175941, 4.382084079471376, -4.303381715647823, -2.9261531029566976, 1.941500371462991, -5.8583571373124945, -2.973127849176662, 0.8592773283141475, -7.10000762172246, 0.3364628672053085, 2.3234115501616404, -1.4554962298415903, -4.26964154032572},
    {2.8075451946803525, -4.9166164733269095, 2.5781188733489633, -4.39507346716826, 5.250944455528542, -2.9349812675483813, -4.6840407232317665, 3.4983733912990354, -5.757748606446767, -4.584705882959293, 2.9897365396187925, -6.2321149508625515, 0.4531974855022256, 1.5053994113687545, 0.20250714486745303, -5.826953126225859},
    {2.750407558719863, -6.7666974154222, 4.27086888825368, -5.343460920064988, 4.512577153400929, -4.523747978442779, -5.995939970734642, 5.392642407451815, -4.898235681049444, -3.633637259591967, 0.8420079656783546, -5.220721849731159, 1.0613638542192039, 3.0627858461153106, -2.593521356968105, -4.770259853321945},
    {1.6493630674386197, -7.5059806216193845, 3.281462004503279, -6.4188449458875985, 3.3353196106388165, -5.311731975309919, -2.987358167348164, 4.73888429453173, -5.082010549840987, -5.611899851542424, 1.8107375658187994, -6.482165918606313, 1.3934562039664946, 4.319888438207994, -1.0381787356058145, -5.869415451981355},
    {2.7579060005060474, -4.564975265634044, 4.130052857319834, -6.444201303325584, 3.3725023832640146, -3.6531915837345936, -5.381676643740095, 4.269801827457882, -6.50757115879046, -5.196814024742512, 1.555143665299266, -5.921311457432452, -0.8117460839493976, 0.12981714403208452, 0.16569867699747312, -4.008227585928038},
    {1.68254405750086, -9.269078452463207, 2.8471293347612976, -6.07667467596401, 5.866521090442007, -5.414718216217174, -5.930996244229809, 2.545512463804705, -5.629139809220129, -4.944684276352245, 1.0635043407243212, -5.106047343646102, 0.27663397403943374, -1.4098035152239057, -1.526962469608268, -5.824675043795797},
    {-1.2370090886038723, -1.0564238879816805, -1.3877429882860264, 0.048552352136718636, -2.7237533985306452, 1.117098607595407, -0.9746813906717627, -1.778644235154454, 0.9970700408564739, 1.7282503804037153, -1.317104742936692, 0.8175856329167996, -2.1588475808201104, -0.014769174271712779, -0.16990609487321015, 0.3589718588031711},
    {0.10136548865200319, -2.2583569320356074, 2.2454312619209564, -1.8231777097076054, 2.1701549957158632, -2.387465780263514, -3.127982994433891, 2.189396708802457, -2.6083156436476047, -2.4239645661884444, 0.3754796988012562, -4.237244378622727, 2.269462754381646, -1.253802752978771, -3.3819922650872924, -2.2443597659449037},
    {0.994774673224185, -2.4969672298173378, -0.41892307361490866, -1.4475707193962462, -3.3249232543094043, -1.4621184676789827, -0.27973824894563276, -1.0544152678112417, -2.0499450483283503, -1.4486424663535877, 1.0144226955594957, -2.111605305077831, -1.0667233659748396, 0.3379605335173254, -2.814879359412307, -1.625365555370566},
    {-1.1284590815288151, -0.8086924168102179, -0.287664793388533, -1.861991918059451, 1.245296106268746, 0.1795019772106802, -0.029379507959077934, 1.7957841754431954, -3.533563546293099, 0.8896850757093753, 2.5553980572621695, -1.492282810016429, 1.4439369704135856, 0.4091461227783488, -3.239691406105109, -1.5942747438116918},
    {-0.6999531581020727, -1.9296310925326141, -1.6760109039389408, -1.7336068484227192, -0.03128445581457785, 0.37272657381642477, -2.4564797895535544, 1.2377707890589453, -2.7127075985389912, -0.11665198484378593, 0.7834738472957878, -3.316538637667004, 0.8368510352816251, -0.5857363476799002, -1.968650719106741, -4.050296546500718},
    {-0.22268280731159515, -2.8140858954267176, -0.9202076982346563, -3.34387028271044, 0.371296742043737, -2.0857674181147576, -3.8918282019032318, -0.6706389071263015, -1.5673439229049089, -1.9496891831299654, -0.31053813954422965, -1.6905127646492568, 0.6864440749612561, -0.6835125220838708, -1.4339346559001533, -2.945473688613026},
    {-1.1255837578457426, -1.3872208310669882, -0.3733637835917586, -3.0031817415908675, -1.9814515165117002, -0.8717537669521846, -2.1338438974822997, 1.7252557813917344, -3.9122818957165055, -2.0396976435083505, -0.40281136992032485, -2.466912045566357, -0.7515813662872541, -1.0236377192423227, -2.0117557224762415, -2.496902525285651},
    {0.9667413317586502, -3.7268458556982433, -1.329182383241043, -2.88352533358266, -1.4252411844439103, -1.6818420256119466, -0.6029797563415853, -0.7923042648303693, -1.1431600713109988, -1.0815809088261963, -1.24136273556835, -1.2465900710583027, -0.22195995129851082, -0.33009328302569974, -1.1614509471817742, -1.72290407843637},
    {0.9283390442513305, -2.0341591106883365, 1.8179773970222162, -1.7979452395348323, -0.36210062808070165, -1.1891652696558328, 0.9287629978654655, -0.3191444042331994, -2.87044472186127, -1.938448899316902, 0.8323776727738377, -0.6529418635832342, -0.5610391091665753, 0.07174900659118358, -3.773254389442075, -2.281280936030556},
    {-0.32001206426140666, -3.404888821547713, -0.9830855180392917, -3.929902149820446, -2.6581715029652777, -1.746027553489607, -3.134007423105806, -1.1189240362607673, -5.106934408531324, -1.5430895911270583, 0.025513137020401987, -3.4279054179922053, -1.9997054344643523, 0.11144253576750483, -3.1095553964627496, -4.985932552674216},
    {-0.47943800907018186, -4.298222844925256, -0.7377400966350142, 0.2334173735468282, -0.5265410858115703, -0.4126058719972533, -0.5512069860087535, 0.4916402092723232, -2.29170002121731, -2.029565307605998, -0.7763466466911856, -1.6766692942437904, 1.2065796029260683, 1.8260554415567105, -1.3215702097052946, -1.161337207432691},
    {-1.573962087035169, -2.79588644906052, -0.2597640068097844, -2.6701356029731786, -1.3299355987269468, -1.9803132166087118, -1.782892103280265, -1.7699636698770054, -2.9764474341092177, -4.704008572262946, -0.3676655075050479, -1.1856008733709698, 1.407159319625277, 0.6423614063873219, -2.3356559227140155, -4.437162308721245},
    {1.7081378880299998, -2.6046405746935712, -0.5968183984400031, -1.290585566098234, -1.1449887027472478, -2.6096467874529, -2.397925444264364, -0.11973167027066733, -2.010593237780076, -2.071090707241724, 0.9450497930105961, -0.7501145197358209, -0.015801469227140208, 0.903991926707307, -2.2377748741646997, -3.0458087385372727},
    {0.8098716604584572, -2.8756013347547826, -1.0619453978552436, -3.122872016843817, -1.3549750565848182, -1.5276361194437613, -0.5782181161121839, -0.03767297797615614, -2.7060544162382185, -0.9872202494122466, -0.4401535817837654, -3.5515662850161944, 2.1495397657956867, 1.6118757656632037, -2.7636285325521146, -6.732665006528158},
    {-0.2924586669977424, -2.739083724910877, -2.058633735633415, -1.0796090313208364, -1.4568883519504907, -2.467684029813107, -3.264957817858667, 0.01779526465561546, -3.320519927582271, -2.134006538625072, -0.19540877206500146, -4.146991057559215, 0.5955229654823947, 1.5520352374983153, -3.957182927061417, -2.420140538243593},
    {-0.1407286665851086, -4.257197236530324, -2.168740060237286, -2.1764612368915146, -1.589825815822654, -2.7923595212165595, -2.8111450413942705, 0.25636598542818506, -3.0067361489771933, -3.182606583339787, -0.1510348693885045, -4.6295695724950265, -0.2216320521912203, 0.4476888246024395, -4.333240131650792, -4.204340756991753},
    {1.2516513516700667, -2.4102717005784142, 0.8025603404020807, -1.994965090228507, 0.12318010457466029, -1.46005104313744, -0.28736424203628624, -0.5437779625932295, -2.964440850520422, -0.6729778266942267, 0.16873573444097523, -2.319709340805423, 0.36858531548011936, -0.5034091947354364, -3.666113709916496, -4.845124282331373},
    {0.7213375931987673, -3.253623431489199, -1.333024227552337, -2.234188417331074, 0.006843806041834858, -2.5308520767813314, -1.6916124975684623, -0.1882841882958691, -1.3490170939480886, -3.1880408219220246, -0.6697392182714403, -1.8212397813207366, -0.36622522721703576, -0.09730467981816976, -5.4487580525530035, -4.781266249754309},
    {1.305086495115507, -2.2746980441824065, -0.9591326942701907, -3.6503279531659216, -2.3605384487466856, -2.7977603038150067, -0.051813654548049176, -1.9472370818331521, -4.6530740022868695, -1.9570043841673652, 0.8633466110005295, -5.2532181961673565, 1.0037229330534427, 1.172753093363344, -4.729740221300337, -2.9651133531371934},
    {-0.16093033768678458, -3.1533008632969266, -1.400530095445054, -2.4316536873050865, -1.4711931100801778, -1.2799600075915887, -2.0108239542115447, -1.0605682360421422, -2.8735942188916295, -1.453616126400941, 1.0971322462221673, -2.436391562599837, -1.2948528746733483, 0.1469177431546225, -4.742609036694086, -4.055894477375619},
    {1.6565618307714043, -2.390161597073919, 0.1076502666874474, -7.097844474539871, -2.223628826585741, -4.925840032952503, -3.6814694873860443, 0.349051108919266, -5.3986242392477255, -2.2538610419876104, 2.6603118153152256, -3.639943855807912, -0.5228804343446759, -0.10274078279179705, -3.5155239924537756, -4.8592181930808644},
    {-0.5969358907820671, -2.72660025105545, 2.088953311485564, -4.8379318300700875, 1.3448864085900067, -3.589052100017488, -2.2900460158085174, 0.843883621913207, -4.174681236422836, -2.6453316651745027, 1.3764900998314078, -4.330911108174391, 1.767039862987763, 0.7841170676686158, -4.493461509154626, -7.017497218434154},
    {0.9063473612249868, -1.9179458657991555, -0.9699581852202969, -1.055138639572209, -1.0468390501276463, 1.1347765693948768, -2.5222949136129156, 1.9691985941317924, -0.047792651608571865, -1.9557459521336118, 0.21236486527824985, -1.7063570353368511, -0.14768614796484644, 1.1525390113172929, -3.4080565425717637, -2.6788161263615997},
    {0.739946719816915, -2.549591147525973, -0.9328065369265678, -2.9092375468718856, -1.47339674218277, -1.6778828489632258, -1.1614438562395746, 0.4995132743482224, -1.9249910548005043, -0.9208687452935082, 1.687609964228179, -0.8604393870784948, 0.5107774663815886, -1.286284597557696, -4.690168402327074, -3.311445853782547},
    {-1.2905129258202652, -4.485584256885923, -2.6945428328378793, -3.6374852029221945, -0.6801521907456729, -1.7890536732632494, -3.9783749021735306, -2.7554099706910544, -3.3756904356381914, -4.2413812587220345, 0.3635837282634304, -3.837754194231463, 0.5692434488544257, -0.3203342273116344, -5.17177598110704, -4.924014398750804},
    {-0.2569818137404697, -0.374131933014148, 0.009418170052873117, -0.31452594352053054, -0.9119290374008223, -0.18607611165077032, -1.4295338856871074, 0.31302060048246155, -1.4197900907618692, 0.6278668303885044, 2.1038831418568984, -1.245984239980341, -1.146449178141656, 0.8127638292619644, -5.997407690687534, -2.065474562823189},
    {-0.16071350320691546, -2.9994114240500274, -1.9191130104514615, -2.433607287592637, -1.3316465496353238, -1.607975275775885, -2.2372612332059627, 0.4064479084837747, -2.9981212128680084, -1.2725206389285026, -0.05176412686664276, -4.075792090539936, 0.3591602043534889, 1.2009030457801102, -7.044157892509507, -2.206999221463712},
    {-1.0974044769701863, -3.9153315819313974, -2.6404757327501085, -3.0808849698233796, -1.533256227891185, -2.204575641418236, -3.98779274284136, 0.02326675366481566, -3.4128552999119663, -0.5843821820248166, -0.1643727994998328, -4.575031440167882, 1.0005617218000613, 0.5716743569996764, -5.386062572763734, -5.4990751694857956},
    {-0.17616873135765504, -0.8811457176760954, -1.4294161874519467, -1.9087297128445813, -0.6806739103538143, -1.468551975703826, -2.704237881717636, -1.7491292957937425, -1.8736380252125997, -1.3977828841720907, 0.2867593691515942, -2.07625448795159, 0.4593514350764434, 1.1416741125655552, -5.979162635921617, -4.774768241430431},
    {1.7147765294248145, -2.7719789481849464, -2.0442070201663203, -1.1828339923772524, -0.3658058047814818, -2.3248604677619147, -4.1954632487661865, -0.47731459746762145, -3.6343210644721284, -1.1875147355127171, -0.1513136365996258, -1.3635160262094783, 0.7470576200191845, 1.0151967463727298, -6.482470217638112, -2.019620995690568},
    {-0.09242316315391227, -1.1998684471625656, -2.197880493232753, -0.03528013869833964, -3.3045654840503795, -0.19244528852054843, 0.7830512210329461, 0.1713349915346431, -0.14029541008814914, -1.2948483483854278, -0.42681037947825634, 1.3919504958586253, 0.22807226683792958, 1.0730320842638807, 0.9493127363003614, 0.592460577555025},
    {-0.6516680207070089, 0.519809990982829, -0.7136809018813214, -2.589879637720745, -1.8726820675339895, 0.0619257357499992, 1.0485376845441878, -4.44447124788961, 0.3451475968520233, 0.6442035945138632, -1.276290479499315, 1.132665215513559, -1.776093698686241, 0.13164694631052204, -0.5120490166386089, 0.5844793598864817},
    {-0.6778485301518674, 0.5644341357793813, -0.2698649295478411, 1.714443907230475, -2.2218913024157914, -0.3293832285010684, 0.5060396910863176, -2.025082990465832, 1.4763307892928295, 1.109263967416215, -2.4347797419234563, 2.228067960385499, 1.480434584206174, 1.027326095509099, 0.36609762232603843, 2.2843913521847496},
    {-1.141881226838253, 0.6250299971243537, 0.12402314324661166, -0.42120035488140845, 1.560533536254839, 0.3715192412564891, -0.10276848259925318, -1.2292832055517644, 1.2773733483488514, 0.8438209625305582, -0.062068448586665145, 2.611724220351345, 3.0129212251212625, 2.876078832595488, 0.3221973349840212, 0.6838047548674832},
    {-0.30185506195893813, 1.7775908489985868, -1.1759212711146072, -0.5245180329681368, 0.0029241489804094, 0.4096149806875641, 0.11355001787311865, -0.7884532205450476, -0.31806476795569033, 1.0420590888458277, -0.7183072828557546, 1.5423551792492352, 1.1819208442116662, 1.5508411442718926, -0.14283182900547997, -0.23000618253172947},
    {-0.3775788893978659, 0.10410515447741503, 2.0836615765703015, 0.6412491928903274, -0.03111122713089085, 0.6757176650910205, 0.3926918011551607, -0.8654247644243035, 0.6666473505899115, 0.5069400167085314, -1.1883671374019211, 0.39291474457187214, 0.9718199749925969, 1.8950995127998915, 1.8952129629086818, 0.9873908136633879},
    {-0.34494350716563243, 2.432834402327861, -1.4056223741793723, 1.0413982270128719, 0.47045241708640556, 0.972265084325364, -0.31864540443419676, 0.15119206824888407, 0.35783436919449374, 1.10396499291386, -1.5359182440342702, 1.8827266035484582, 1.763310389210607, 1.2880097724235906, -2.0207368065027786, 0.8733504239814412},
    {-1.8324942333804153, 0.16039668593507223, -1.3733180145678927, 0.41042816234285495, 1.0410891360765608, -0.5886716886139978, 0.18700942390732309, -0.5236073308559565, 1.681688486884753, 1.264722062641857, -0.13273614101362935, 3.3673958460600835, 1.5795211093430581, 2.090797031134732, 1.2281215792659534, 1.2409212306145494},
    {-1.503028630569787, 1.20289484991275, -2.615802678621692, -0.3112929666553684, -3.213177946919399, -0.10269189728293507, -0.7591564931865763, -4.196825065070042, 1.1883677692368617, -1.3038017177015309, -2.6698864359427854, 2.2035964353860367, 0.5223145095415413, 0.5509741920510712, 2.556223180748967, 3.6027609147695006},
    {-1.5573605910219173, -1.6011043291585991, -1.7499460933721287, -0.11222642078717943, -0.556387483340236, -1.2309672561181815, 1.1256871760083418, -1.24686864255153, 1.3436975937513609, -1.510767035400387, -0.6711815944693638, 1.8334631144693394, 0.3168157889654093, 1.427720572718629, 1.3038388093499742, 1.5259184085272863},
    {-0.32682227803550695, 0.9365761104939453, -1.5787273906424852, -0.8647980166986154, -0.17013641747516772, -1.3051173555822284, -0.7864276069638146, 0.8341589517028835, 0.13811648308159388, -2.208739980220622, -0.05852674265940968, 0.552464708487414, -0.3121940703895602, 1.0805556265885454, 1.141228138057746, 1.0929023304721617},
    {-0.5081020016737474, 0.4103922942451896, -0.6859360178052623, -0.7075577455876442, 0.1127693025003576, 0.7914283389939094, -0.09764164570740075, 0.8797347161685234, 0.9664389860140989, -0.1348762543097558, -0.3829998889681745, 3.0361002411947595, 1.5808885194135627, 1.6341479709562667, 0.3819864219470444, 3.11221949470699},
    {1.0786643719440812, 0.2223821155973305, -0.8982853875272373, 1.097276112109019, -0.9277664023177724, -0.6505124707835133, -1.2577054288477705, 0.4734027309364185, 1.1854447249048892, 1.0996526915419524, -0.5657096524682347, 1.1113004294259807, 3.146477127998041, 2.315526830778369, 1.3791236107316303, 3.7673009111062186},
    {-1.946339098077525, 0.22972099779288935, -0.5928167384707299, -0.5150678289709105, 0.5810158259873753, -1.0019094731634473, 0.6785205445134067, -1.5314591608420574, -0.6656123313256074, -0.20104123621290465, -1.8586564586909426, -0.9172495478541175, 0.014532465738748387, 1.0000557866349924, -0.6093203818431369, -0.13449539653938342},
    {-1.412454195595534, 0.11408067834733866, -1.615155177865567, 0.09985867623286883, -0.45107195757551105, 0.25824470621761564, 0.07959585920401027, -1.1990699579341024, -0.4388728562330574, 1.0709732577888285, -0.8881523847822056, 1.2118960744933223, 1.3695126535987103, 0.5520643295604887, 0.8921652697811855, -0.13951805968129072},
    {0.29535924562516386, 1.2319216863274804, -0.5800611313437015, 0.5403425506094686, -0.17755585950188565, -0.3680298190678788, 1.1176659969339675, -2.567203224524055, 0.8911750109826584, -0.003709689202978171, -0.42800086005741944, 1.0112723378808712, 1.1877773947202752, 2.117260114997352, 0.2937747069016137, 0.3514936637719943},
    {-0.23075541329571242, -0.3867875560936654, 1.2429766073503719, 0.8632334768288292, -0.3569318520472232, 0.09961331384976663, 1.3914068711766117, -1.949059877231986, 1.0227473026632203, -0.02546527816479627, -1.7556653734981635, 0.030685798455999946, 3.498097075024088, 3.7762494409439427, -0.06435371698296757, 0.6232662449794582},
    {-1.159661892317614, -0.19991972573666167, -0.8468723042978095, 0.7464288910701066, -1.854489489817779, 2.0677620675723967, 0.40726328042431925, -2.713708699297398, 0.24378915758581476, 1.2519560200827546, -4.994098015534076, 1.4377000293988913, 2.63438362834589, 3.4679650982533974, 0.6406036551217688, 2.4123762212381124},
    {-0.6362454010087096, 2.081375591564989, -2.2422096569046546, 0.1231058420729006, 0.05860740917060345, 0.7655244793830642, -0.885438828845354, -0.7810365349954507, 1.7839623743804718, 2.2245102025647236, -1.1674290470085398, 3.339861393917078, 2.5263820067480838, 1.4979538107402663, 1.5151718529285656, 1.3753167474594772},
    {-0.38823046281783213, 1.0736715891600843, 1.3229566762054858, -0.4273103224030484, -0.12153426525464428, 0.9034006052636399, -0.002605300460687572, -1.738616369531168, 0.5709436321058209, 1.401890898336926, -2.751634059825348, 2.498831197012199, 1.8704698641447945, 1.2006145206830938, 1.7767696029815991, 2.8051353291902767},
    {0.16159611633568002, -0.1623076956720768, 0.07518145770237016, 0.05900447132044747, -0.3206800240521656, -0.34125186183335754, -1.1826571567267836, -1.5597774809431177, 2.8381112919867175, -0.6409630197246754, -2.6006200258238983, 2.596927926575394, 0.2712889152755741, 1.3586791615210507, 2.7010172964713344, 0.7201389400472937},
    {0.4020195298929064, 0.35308877760531765, 0.5851083013431719, -2.165200772482625, 0.6581422373217465, -1.0034301989529886, -0.6428104934227227, 1.167624922898677, 0.47940640594395556, -0.2517195378709644, -2.17272113203994, 1.196709702454288, 1.1426290871754823, 1.7102914561681148, 3.0625501106204753, 2.2577485266885144},
    {-0.9260277908333421, 0.5491426601822411, -1.3167241266333491, -0.8304430851638182, 0.42617348425140283, 0.50064285287476, -0.3917672057016097, -2.2570293068913094, 2.47931008048458, -0.17908172985122428, -0.7127170778412525, 1.0555215679823549, 2.862048782813639, 1.027127160417359, 4.30345699363043, 2.3936098202447122},
    {0.506010485553441, 2.1414937243946857, 0.36683925200675466, -0.8804023194841901, -2.218697896263987, 0.024240325143015422, -0.6577562777117951, -1.3045725412247426, -0.3540178277702526, -1.1755296503709285, -1.471080725994804, 2.8356606414382424, -0.3763572603145876, 1.6078222735635095, 0.6733651940542581, 0.4462335594403347},
    {0.5658607682007387, 0.7585191054514724, -1.4679507739499074, -1.073154478826612, -0.5073454833931031, -1.0879335510491845, -0.20191251998193205, -1.3316132445126867, 1.3330741035493239, -0.37940052941223706, -0.7083629646373755, 2.5617201292868854, 0.24250124449890095, 1.2356107185209402, -0.025596583727638126, 0.5665992603766604},
    {-1.3351501535385715, 0.14188104593104406, -1.1681858464860178, 0.06420056830509605, -0.004828667815519533, -0.09517479095512187, 1.9869391423028318, -1.3137686283690952, 0.7266715329886771, -0.027083897524742623, -2.7153075876870836, 2.6371468211127724, 2.591948980193331, 2.9604075333816633, 1.0031537835595978, 1.367332694496733},
    {0.007626301616449257, -0.7997656892662833, -0.8143442828131274, 0.5586060009242494, -1.4159526529696551, 0.07998984242502455, 1.3294514660414998, -0.02628127742473621, 2.526333556950485, 0.4597695746325824, -1.3166479536421676, 3.1817262075438557, 1.318384137028946, -0.8390470436264968, 2.636809325874286, 1.8417088212102548},
    {-0.3632127332510988, 0.1998588838781939, -1.7900285661006516, 1.1053657619720114, 0.4458128778768727, 0.42546293825754805, 0.7806043659164168, -0.6657447069993767, 0.6635599472990513, -0.7470773262811619, -1.3563496097282077, 1.574898144288457, 2.5454707774651792, 3.6480628374141237, -0.642709874266055, 2.487988226408792},
    {-0.39359623594767845, 1.2267230529517632, -0.7449721982179143, 0.77825881429046, -1.8261842785900007, 0.6756393458320874, -1.288673679324165, -0.9457370919423708, 0.513330693716138, -0.328060761310112, -0.5326263765298948, 2.683455598893566, 1.3556091629137654, 2.4315760051109474, -0.8373301566726161, -0.018887391645396816},
    {-0.047425981664565915, 0.5129707904762507, -0.5888695820972697, 0.9873102168969025, 0.5810473343135124, 0.041740377233769034, 0.4563648997914477, -1.0821460294620782, 2.632448931674333, 0.2537358627656824, -1.1553120577173241, 2.0464507199004434, 1.0681120055149784, 0.15163445156411592, 1.4074524277836715, 2.7447570309433997},
    {0.6061715967230898, 3.1021996185859493, -2.0610311745436234, 1.827088689433658, -2.972736323361245, 2.097135831687162, 2.0557797382880394, -0.8899416702459771, 1.617749293726578, 3.2646452180649006, -0.20683283412309994, 3.918247411217024, 0.18830270435399965, 1.1525772196000061, 1.6103223856852464, 3.808170337162468},
    {-0.6324910838118413, -0.08882192275288014, -0.012947355815722853, -0.11191873320517048, 0.811747218079086, 1.5050591695932543, 0.8914657871892585, 2.1053722830037405, -0.23418716481712729, -0.43469867313384897, 0.9817764219785954, -1.0551918478327234, -0.036209069659071016, -1.0500766706867353, -1.366952181631466, -2.0846897150295693},
    {2.482321146337391, -1.6095930335476802, 0.16359134807003728, -0.8356891871976002, 0.7375685759833445, -0.6076271079873914, 0.05571383051521984, 1.648742573517253, -0.9472016197701888, 0.24963730062446537, 1.3689569904560575, -0.5509379181974605, 2.234476768648789, 3.1200764184092398, -1.2158353305108993, -0.2005183595477627},
    {2.531404653274127, -0.41769686127742844, -0.45100408663385677, 1.5830119218088763, -2.0648378847464604, -0.4901606696127884, 0.4837579864020958, -1.2739493137204794, -0.321312563500588, 1.2173252842971944, 0.8985744779779253, -1.337478786878422, 0.013637127040653544, 2.378589986307631, -1.7587145567601823, -1.6324095015825113},
    {0.2850649428348543, 0.06718291780150008, 0.94817023154736, -1.0328265944800568, 0.6105918588903151, -1.5287785732063242, -2.0698024324274047, 0.9482676015839173, -0.9163339400803291, -1.2771942380717494, 0.7564854238670883, -1.28245944095945, 0.08634048844270915, -1.0353888973483993, -2.5730822736685512, -1.0078281864355227},
    {0.4706898820562755, -2.807309218662926, -0.5237514831524329, -1.5639966844562887, 0.06072453525238648, 0.30641345304913525, -0.5982014423115227, 0.4911378246154535, -0.8814511090866658, -2.3212132989765744, 0.3670641198688085, -0.11464958465669542, -1.2102609360697378, -1.2808792010049475, -0.7215162527860319, -1.6417361980961742},
    {-0.796906531815949, -0.1798469002173603, -1.0471978426783353, -0.9437771685884964, -0.1634704074790977, -2.288891761297538, -1.5126688344152257, -0.7242024557374875, -1.4676649965328576, -0.37013046201091415, -0.7609730035356208, -3.1216596138323327, -0.08329707751206275, -0.6471815244365101, -1.4202827985701378, -2.3280914568948194},
    {-0.48035281369927113, -2.2480380331264587, 0.8318312249459038, -0.8244911216700068, -0.11321640641898707, -1.5902315963106957, -0.08578156201306678, 0.2262546854232797, -2.614945128224892, -0.8742149179115567, -0.3265771889563461, -1.4585175416722895, 0.9599267976678265, -0.20880239160071126, -1.0811605507788087, -3.575992912964649},
    {1.9958353859449283, -0.570089953738598, 0.6279449305563854, -1.0588592145687137, -1.5867459218142752, -0.45298626119925395, -2.0417421446956676, -0.9892986745901503, -0.8510173591770016, -0.33933223988771133, 0.25147229839704854, -2.0159836345475513, 1.396435692250033, 1.7707673322264295, -0.7752133419726396, -2.437117703662924},
    {0.6424901887156459, -3.9464037362126962, -0.2654191239433402, -0.9141722166065263, 0.3163198921789842, -1.8366473529339409, -1.678826916850342, 0.7367221536354666, -1.8722824499800887, -2.3627183806350542, 0.2860682711366465, -3.1780955930472556, 0.44261050458160445, -0.40503155960233206, -3.931626100671115, -2.5259488086499724},
    {-0.47545975923567907, -1.1840081624037189, -0.4588826686080712, -0.6039617716488926, -0.8367176766752215, -0.14796561757648174, -1.2563883836440284, -0.08749509718947701, -1.3979485847725481, -1.206984747846166, -0.32725551936604763, -0.6103462960887077, 1.7011240825882212, 0.22449915411782123, -1.540528116107835, -0.846872698756013},
    {0.833850222498678, 0.2665638584406194, -0.7987211929474818, 0.5991787379042954, 0.5585671261386987, 0.8528799932698912, -1.1323286594187285, 0.43536292883281247, -0.7321446217075068, 1.2124892979194595, 0.46836895024303976, -2.246355936240486, 1.161010432164841, 1.7990398402594348, -1.896600978643703, -0.7924088267364024},
    {-0.2956824567916699, -1.0825783721238815, -0.7837144847066575, -1.1464477196011664, -0.2664721722052806, 0.3534890022156763, -0.8330534797479688, 2.2809948772133373, -1.665996619788685, -1.4498489348590224, 1.5308800804025091, -0.43712138198898975, 1.8349872140333423, 0.7515410085549233, -1.5532440038410287, -2.212931274740706},
    {0.8284779670972384, -1.5160942038982903, -1.5082248971411123, -0.8643656918050723, -0.7840591842522439, -1.842034344069555, -1.6339258420748926, -1.4624973323433175, -3.3846067980922894, 0.6693189659770388, 1.0227948814272287, -1.2248500100415352, 0.7677591064862703, 2.0863944762583997, -4.016651055145926, -3.4968950472868063},
    {1.6597648995587708, -1.6921274603679772, -1.723394665628625, -1.6438449644669486, -1.864151438624591, -0.1299812733970021, -2.502056680665896, -2.0806706858688377, -1.3603627050764953, -0.521371147475704, -0.2690646520638946, -2.092177134036676, -0.4702219159276978, 1.6719350985281274, -1.5617928473073048, -2.1436812459340016},
    {-0.6867656392479201, 8.753788354739456e-06, -0.3499809883621865, 0.35252290380933143, -2.4863840108625483, -0.5906292231007109, -0.5607030973646903, -0.9690359370883669, -1.4622246058347323, -1.8900464963677763, 1.324979389622467, -0.9469954511821762, 1.20595755570676, -0.2350551355062977, -4.3470517615348, -3.8079907420296464},
    {0.18225335246234117, 0.13994538812923532, -0.19104605760592652, -1.1504805891499386, 0.2748525716121243, -1.2079369737523364, 0.6625336523067348, -1.2068946415834119, -0.28146359568675516, -0.011347731922062298, 1.3203454494193436, -1.8742828511672445, 0.3398679751943109, 1.0475084906196483, -2.3803145522901774, -0.763416166983369},
    {0.8613991488520857, -1.4143924009847484, -0.3084429196391739, 0.6704160876267535, -0.5590956567394488, 0.8239168996377042, -0.5729530161596441, 1.4434637351191264, -1.1544546650320262, -0.21364259745934688, 0.5680436043652605, -0.5581529617935251, 1.1369790207024373, -0.5218764190803459, -3.773091672075411, -1.8220540442759898},
    {-0.7240360060921818, -1.7886280171759887, -1.5144275147130017, -0.13171734256360595, -2.228716761275953, 2.0552581866228987, -0.8335944062943035, 0.7444569717577518, 0.24671915990841697, 1.858744947914983, 0.3210036633789609, -1.236065603185963, 1.7155864701921524, 1.5416785982900705, -4.8151750905280055, -1.8410001522856538},
    {-0.46246908837949624, -1.862294431654207, -1.3124555179337194, -0.9411204652401077, -2.7744080822048223, 0.046442026172364315, -1.4589767175011417, -0.6092972735372489, -1.798856969593295, -0.025918725060163593, -1.4674641542171314, -2.4748470022083033, -0.4470113573022008, -1.660388331455021, -3.5865075185763815, -2.1660601112723086},
    {1.749051563549587, -0.19211077590106132, 0.7448903399311334, -0.031762100446025655, -4.015265061702516, 0.2587714451702976, -3.0039597352421428, -1.1357165018997428, -2.397545641455652, -1.0201170148988836, 1.4600225599225864, -1.3121842529962482, 0.31866797213061976, 0.2712767392533704, -4.733099000217231, -2.512135681775682},
    {1.959384668028933, -2.191861543225324, -1.5426350560801072, 1.2435281810495704, -4.174765547876032, -0.5629121800162772, -0.5184327604580143, -2.118413408502368, -2.7828580902929017, -0.7711625751182635, 2.744476673646107, -3.3592899820185567, 0.42123779913802584, -0.4350030114817666, -3.929122426642143, -2.440911638208791},
    {2.41347587615052, 0.40249899017604185, 0.0232051195048421, 1.2655810388835114, -3.5799420543695386, -0.659279894632704, 1.3555155048531864, -0.7822937810589775, 0.2550840619685857, 0.9229790540997573, 2.9993476534943513, 1.018384253624771, 1.3644469043186445, 2.64144033895648, -2.9851893434609043, -0.05321086754403201},
    {-2.0680855050316613, 2.8132407699352107, -3.1972962560141314, 0.5682206163622089, -2.862696327660036, 1.5140425596400193, 0.67359957066969, 1.0337245125001895, -0.1476025449778455, 0.8986941546948429, 1.9346329103026554, -0.5730140620138222, 0.1745511460645854, 1.454568712862925, -4.144117142657081, -0.3454342056837937},
    {-0.25190712959012485, -2.3147871461386718, -1.0316754922289282, -0.028275593173268693, -2.5103243587507422, 0.8013901145673278, -0.7893738465146096, 1.3594463728995108, -1.3080979891285849, -0.9304164465606484, -0.46728609407144006, -2.7343030531722112, -0.2307715772394449, -0.03145615788260746, -4.193859794688554, -2.682227411097836},
    {1.5629450242635754, -1.0749064385940212, -0.5120720141347075, 0.1449084244335547, -1.333265296986767, 0.883740956537554, -0.37103610883977434, -0.1913435113849965, -2.298968089396878, 0.9034550911343124, 1.200727875316772, -0.5097085254709709, 1.0698997099667313, 2.1993698050312718, -3.7757556918802897, -1.009033877270805},
    {-1.1261399835511892, -1.9829181980862083, -2.637935197550956, 0.4009771831232316, -3.122177807475792, -0.200289040545202, -1.352796102534133, -0.5549193368800263, -2.2691729473692774, -0.015039192426886111, 2.0517101406712546, -1.7804154735175743, 1.4937084062857073, 0.6107747532281279, -5.153931656934641, -1.7105868970790326},
    {-1.0114150811427929, -1.0292529967200168, -2.025678383986466, -1.6084025213884656, -2.417679180712959, 0.37423600708277044, -2.5532474013104127, 1.87006860769746, -1.288106174931776, 0.16063135106455056, 0.9030743117113202, -1.0131379347778402, -1.8786698267588307, -1.5730260726716414, -6.326751260165051, -4.281308746570608},
    {-1.5615176647858824, 0.4366176482511269, -3.323075632170019, 0.11935172076878864, -2.998065362533591, -1.6602076520550728, -0.8302322168893118, -0.7770968258660639, 0.3656564030148578, -0.7123826148881407, 0.3861360942893771, -0.8963644664961378, 1.4390919013555041, 0.23268659256196828, -6.665167348434563, 0.1625755095153445},
    {-0.08080212960462552, -1.5790547290880057, 1.0581659753948334, 0.48081635465704864, -2.615646716399556, 2.0480479680291133, 0.36143386701986885, -1.272846561703351, -1.1537800200582577, 0.7692154787299449, 0.9888102829372198, -0.7677219268311682, 0.8461807419467033, 0.5242060453490854, -6.057036233542322, 0.000783596164702676}
};

static const float b1[16] = {3.9277189110019664, 6.714191556796336, 5.620416771444649, 6.72295439426598, 6.2742073488782975, 5.908040098715738, 5.432574631479796, 6.266857125269125, 6.444997582212337, 4.825971798524538, 4.255367948166274, 7.202772052399084, 3.995629769206836, 5.704990782289126, 7.285825388385914, 7.428945074381972};

static const float w2[16][12] = {
    {-0.5291035725498616, -2.229208753386893, -0.7078653367101734, -2.160196330381178, -3.048117366348641, -1.273824899871293, -0.19617902958636294, -1.7886190826057697, -2.2130592010353403, -2.5316076468227315, -2.9930300750435532, -3.812834535890263},
    {-2.222963182892249, -4.5346060221030795, -4.212375092544057, -2.7638180571484394, -3.1000767555798086, -3.444058480419922, -3.1365673839376034, -4.5004794806434685, -5.279851313329516, -2.7387690233800046, -3.9354493116850535, -3.13636864092157},
    {-2.5657965851844122, -2.5086870079377155, -4.136310604293658, -1.5283457895511325, -1.9700257414405598, -3.5624574828689384, -4.057530227733584, -2.5241338033946987, -1.9020313158157973, -2.548503286854842, -2.201209771689506, -1.6260175155179486},
    {-3.2808258533052674, -3.800323755348264, -6.7013781500589555, -4.987130277262576, -4.44788281357833, -3.844717783921647, -5.347415361928425, -4.057947335739721, -2.503182798294705, -2.6006243165150886, -3.2804454975015345, -4.358634937414924},
    {-4.289657480392137, -3.333616125977519, -2.3269582009643957, -4.662798796281699, -4.395686664695321, -2.89111144634699, -1.112793324345414, -3.240814484082353, -4.59138099113039, -2.9702157297837366, -4.616880293716055, -3.731783620681299},
    {-4.4617218524855575, -2.970887655326231, -2.830118699161941, -1.7705308053718738, -3.431090746576567, -4.254632612018194, -1.5958008863539224, -3.925989015793009, -4.6959521798220445, -3.2674857146437546, -3.1181963338430707, -3.485944485797041},
    {-3.5242667161698895, -2.698064395625263, -0.8631491231230877, -3.7767640962205293, -2.923865455047331, -2.4665250152471567, -4.132125526941051, -3.781990384687373, -4.329985714959773, -4.242132520435717, -5.183052611925931, -4.040220114989953},
    {-1.660889236647559, -3.0646710518565596, -2.6942033996877663, -3.0886586786704657, -3.2856625078290205, -3.447756003222535, -4.213009390069011, -3.349737927030345, -2.7636971405513835, -3.556328895989989, -1.6868978295938575, -2.667832395563292},
    {-3.870703343474596, -3.115741676893214, -4.046501398415088, -3.5213159622961197, -3.262931616091241, -5.447919722111584, -3.5967610239010934, -2.6161591483950497, -2.521473014239025, -6.455517334691811, -4.406424043993877, -3.372423488006157},
    {-4.127674782981944, -4.2446961932577905, -2.8161341153661477, -4.569539620944483, -3.032431265748693, -2.949030774141334, -3.9732436367273345, -1.9348720068592136, -2.2490965478961105, -4.548370721865715, -1.939973463534657, -3.6150305295038434},
    {-3.7334526420244867, -1.341539110829658, -2.617193088976643, -1.4651629036086242, -2.310230837281775, -1.177559465889255, -2.359201505707708, -1.4413448579758659, -1.2790615224932036, -1.3710819307032782, -2.422215705718755, -1.443694358035224},
    {-3.5351739738706103, -3.598839257149359, -4.700545101710083, -3.8146539992955346, -4.200073551367672, -3.046469506355985, -5.16731125050494, -4.253648892329616, -3.3724922627364937, -3.748294817485962, -3.6656810887234275, -4.842065405724624},
    {-2.4183076340558194, -2.3305695390942858, -2.15911807212257, -1.7426745137714679, -1.784484993208327, 0.31145907596354533, -2.2040185766944917, -2.428460076178371, -2.6393147409941644, -2.351763520560564, -3.038054396050713, -1.1746851342713003},
    {-3.6287038894307058, -1.8592226238774865, -2.374967513902956, -3.166248261633781, -2.0020751424485144, -4.595070303192058, -2.5976498462703708, -2.118275843471928, -1.6024492975667401, -2.5623115626217943, -1.3729381442584747, -2.562973068918011},
    {-3.970663323460515, -4.386164028121703, -4.018129185953432, -3.3213604317214753, -3.145989593938952, -3.6001336303432, -4.3127916096726135, -3.2474608812911616, -3.8942971922482723, -3.2118974383054244, -3.848810213791571, -3.8657456145525573},
    {-4.802972244637268, -4.390578741680527, -2.967311889934498, -4.769759437019765, -5.3907915387795935, -4.467552556924879, -3.014168148846567, -4.857013398251488, -4.7167468059100965, -3.0706279930216076, -3.8423786378344498, -3.2996306885674533}
};

static const float b2[12] = {-4.089467219525363, -4.632754517905607, -3.177256212692727, -3.2062972558312075, -4.309925528255037, -3.6480436134460192, -3.304336537259431, -4.352566729920791, -3.005922209480068, -3.468893076985045, -3.197775104267754, -3.508392064398936};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
