#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.9323714463526795, -1.269216362482477, 0.14379612858799118, 0.7727027952709358, 0.7818020246769011, 0.11065342033694903, -0.7215922507070744, 0.12522305731623787, 0.15482534747885426, 0.5125907483906084, -0.030122007131366663, 0.5371527181498663, 0.8385795648255768, 1.2255851178152053, -2.1391926707093365, 0.8524634934419735},
    {0.35111954291032194, 0.9960304041878173, -0.5734327062108449, -0.5182195291139156, -0.4095282694878955, -0.23473485551115283, -0.3919525611195756, -0.8619712931923574, 0.9825308526166413, -1.7169556803527046, -0.21227792171009163, -0.0014777213207554565, -0.05697662974869365, -0.9584028871425453, 0.6633743178575137, 0.054391197677235215},
    {0.2996549899472323, -0.9264129949986258, 0.03279303272393769, -0.408856633693323, -0.8508407351177285, 0.28542465065827266, 0.4037393531551328, -0.8992090306188245, 0.625662610499505, -0.008366123816695065, 0.40532063780064653, 1.1450301386006685, -0.7694178050429329, -0.3748411793209855, 0.635181027711148, 0.6576713691884504},
    {0.13333327496288253, -0.06242340875721136, -0.035998377294180296, -0.4390689844131362, -0.18990169587595074, 0.1931436291482547, -0.9739976588119668, 0.015022549934631469, 0.21038575787586553, 0.11330924326500352, 0.4485127873969691, 0.169319674406014, -0.5760751144014257, 0.8528077586796323, -1.0848901223472265, 0.7149706661894945},
    {-0.04250821007140708, -0.3506077091490344, -0.27401962087762066, 0.21910914061767417, 0.20312390565927785, -1.015184894127371, 0.21213393426844387, 0.09350269584047377, 0.10280140415434512, 0.6748597175464532, -0.8543815862259959, 0.0072787903092507295, -0.5546796156499263, 0.9045542843520762, 0.6659824985623367, 0.018093674325533347},
    {-0.004550033524144605, 0.6801291883092917, 0.5860873195900226, 1.4217277282749718, 0.647817085316387, -0.4693243477455127, 0.1970692864886745, 0.1005864970433582, -0.4475868534929635, 0.774031353615011, 0.5560755210009188, 0.5270339466442638, -1.0183159522537337, 0.8073983941474223, 1.272938174962638, 0.9858625693635911},
    {-0.8204754111393305, 0.730420645619781, 0.17078357398360866, 1.4741554401412116, 0.5347100102458728, -0.1823150183950752, -0.3840374534388914, -0.002599687346069635, -0.21709505821461547, 0.37320618165095404, 1.196086648323119, 0.40474613737152537, -0.658196971476739, 0.8567593298244844, 0.7078031808639709, 1.3008464397705357},
    {-0.5986079177478322, 0.14933893830369618, -0.3827369600731092, -0.858193282048511, 0.5378166305836789, -0.049999545435105076, -0.3207965566964933, -0.265922463330544, -0.3751550649255444, -0.36253232569637084, -0.7885738161399508, 0.2850488358785822, -0.35921795512906396, 0.6649257117563561, 0.43117770703453445, 0.22552138908801994},
    {-0.5206969210083171, 0.573297516004551, -1.1164248540621642, -1.1405645980412207, -0.23023258137920674, -0.9475481810862799, -0.2681612368371179, -1.6130808949846889, -0.007517842558315781, -0.539519316861255, -0.5994310874569692, 0.11496670330511778, -0.1959927142860136, 1.0303756503551145, -0.5035799075741572, 1.2001396990156905},
    {-0.6201575700256977, 1.302623776106289, 0.7325420657247775, -0.38207722787221465, 0.8421482683314128, 0.856221412780171, -0.018023175071984605, 1.1400868027977764, 1.028421738020024, -0.5928557245540287, 0.8783062178382269, -0.055693340462758846, 0.2279621177418398, -0.6212108620815461, 0.5553710889224422, 0.029783830311569868},
    {-0.2597930599497688, 0.45562845176265676, 0.5472858846002722, 0.5933847088259122, 0.890096974091628, 1.0800995933132014, -0.4950273173161641, 1.3607344495043139, 0.2949308870839954, 0.13322225627699918, 0.7081708613214022, -0.3492795836252994, -0.1191757751098517, 0.17509530274119744, 0.4573699656137267, -0.8514755076220951},
    {0.024782069753624958, 0.1416233312331804, 0.34814245641528724, 0.0584150850435956, -0.1337679796115347, -0.08816196241570061, 0.1807820455178144, -0.3098933732098161, 0.9570889644644767, -0.08095043608173394, 0.19991519129197954, 0.31563221837453265, 0.5638242921175051, -0.498342961933216, -0.5896705943568273, 0.2655904268326105},
    {-0.4114367790914986, 0.7758139860889385, 0.16586865528166167, 0.5405682644551691, 0.45794146394630314, 0.6591779540611238, 0.8980511593261842, -0.18284534416758563, -0.1247079112757085, -0.2499221938447436, 0.9948410196818107, 0.04484559244743917, 0.23750060831526185, -0.8637597895264314, 0.9272289275445056, 0.24099129044457618},
    {0.33473659013326723, 1.094862196872462, 0.24432251481840578, 0.6161625185282115, -0.3530673839040708, 0.7679836005413577, -0.9098539794094991, -0.046230694848551405, -0.3502809489431258, 0.0192428614336546, 0.4645662273086964, -0.544554945480924, -0.2933923624344352, 0.46026829928089924, 0.7814858952698244, -0.02297793909135823},
    {0.43094444223859196, -0.06343920283493827, -0.5004652748868517, 1.3639041951766335, -0.003976749861329653, 0.848345171152516, 0.04165265012922606, 0.7226973956457063, -1.4817215466311568, 1.0782597117387862, 0.4385341677226408, 0.2000814361213342, 0.2856531261327876, 1.0092563332896096, 0.29777071110239195, 0.6649654482661946},
    {0.1573884353086332, 0.3172162415071754, -0.4154825344675196, 1.0909724265103244, -0.5016450199429373, 1.2060252512776632, 0.32337190651628206, -0.5754256990518611, -0.8383767694261345, -0.6378056508722585, 0.8323674907541118, -0.09911308406189373, 0.04573819962439091, -0.20420695756505217, 0.8692750312573775, 0.8098101145091108},
    {0.7467617284746236, 0.7342658601748207, 0.1764706713964476, 0.9387892297181439, 0.30200220732257255, 1.1007337873705447, -1.122556066508493, 0.3282048771273362, -0.7045252802627509, -0.09933378295558119, 0.5556921507477492, 0.32641241746282174, -0.41585739120675264, 1.0822715583309457, 0.8200206599160129, 0.5039761160891515},
    {0.3376218448268402, 0.0404346095782954, 0.1762595621686464, 0.884167796867331, 0.10143141553714564, 0.14188886336498535, -0.9956337911641355, 0.14763929205687729, -0.08613673279361889, -0.16994755375793313, 0.7535480915615075, -0.615656959152337, 0.16017285898376507, 0.7226455952197298, 0.16924793673525423, 0.017214951348775816},
    {0.16211852625126766, -0.37743795356064025, -1.3291544108484037, -0.5643502845788673, -0.5082315929494075, -0.4454828707350824, -0.4615885622740822, -1.269609157172288, -0.7477714555853326, -0.7471627739738239, -0.510577799523513, -0.45648117862680554, -0.13856591686215328, -0.02750384283562013, -0.2769767525405168, 0.20738003505219263},
    {0.19972510366077978, 0.07396277885162639, 0.7419867633340839, 0.16195870822614014, 0.36122821448154574, 0.5513588467143362, -0.43357854234010185, 0.5038953512748764, 0.14455477408621903, 0.10998243919673607, -0.03768060199636459, -0.7084363687609913, -0.12562790263035342, 0.641424884535862, -0.41189831003714883, -0.014458650760175058},
    {0.33357828662988476, -0.6326589210932433, -0.5038795015819059, -0.17849075231265857, -0.7933875840393724, -0.05346369241040397, -0.5909353258562806, -0.4676985551883115, -0.9158358051790956, -0.07979939688269022, -0.5788392949671333, -0.9639152348915124, -0.26698801808749006, 0.7349700142438129, -0.21259385305776946, 0.1773587912203338},
    {0.010237729069647414, 0.8639307689160978, -0.055102448892846774, 0.2566712093362456, -0.3557830200114982, 0.6611234391649556, -0.6682559075078977, 0.36373176295573717, -0.6606159750001017, 0.473322823014599, -0.7780285653104473, -1.5005405958668094, -0.1814246425143231, 0.8020751847807309, 0.18251817254139366, -0.6148766905870215},
    {0.5420240285254441, -0.9355922558534048, -0.15337875752277724, 0.1950664147236846, -0.7345674601268427, 1.148910142221249, -0.18914311742519288, -0.1987015179348331, -0.49812912895126166, -0.22701498919634738, 0.18659353910104087, -0.31047281593521114, -0.12477223465194252, -0.08080022911179494, 0.5468832739822392, -0.51304549635574},
    {0.8878405266165388, 0.4678712666006744, 0.5496950862878311, -0.13663580888866236, 0.15556208765388402, 0.6708280498197975, 0.05286679366138386, 0.9312750071434549, 0.6033531926996519, -0.03274603584215518, -1.1549390941421944, -0.3324440632722051, -0.0036840772856064972, -0.14929361372700095, 0.23656148967858276, -0.9565433678711799},
    {0.5394563783079973, -0.377432069773772, 1.0359932341045401, 1.0399874510713563, 0.7603152077895119, 1.0136859181803228, -0.5155939973515088, 0.9945574750779276, 0.7306918337413231, -0.1447518834022202, 0.6002960496686581, 0.594217287761248, -0.39415369665750233, 0.9741340736537446, 0.11133664933652215, -0.08929657427494031},
    {0.5949866565798864, -0.8665610683520107, 0.6399970069073149, -0.5450149424978652, 0.4653367817374274, -0.07261783279962399, -0.7475100158115151, 0.685641492139935, 0.6472102217868532, -0.5536348850864695, -0.16653277090054108, 0.30263224407623435, 0.08458081514948564, -0.09047804359687438, -0.649232489155305, -0.7470013075591513},
    {0.4202987962250763, -0.21871901148447243, 0.040715981360246366, 0.11325130481159357, -0.34588744604697286, 0.32387350249341423, -0.17439975481360664, 1.3014025277590153, -0.13981249584878996, 0.3716446341582192, -0.420239241302999, -1.253340957794488, -0.31855003026768386, -0.2581358110183002, -0.537439375700458, -1.297525890602344},
    {0.8960696240797389, -0.37274308750432283, 0.5929882360620476, 0.19652298670728865, 0.42490226847574974, 0.038546190626438416, 0.34021698292883107, 0.5761749961751986, 0.286969079629988, -0.10581766766361514, -0.16391898870275376, 0.08182160666709642, -0.35694492365931174, -0.845799712432334, -0.17664839672442312, -0.4899006240181868},
    {0.548360677275731, -0.19619498874778346, -0.11895378745748458, 0.1077989731229642, -0.6807713085678186, -0.3554711379060445, -0.8110271641814368, 0.2312543699537308, -0.18287697189338578, 0.032552129952447974, -0.38600062871138574, -0.8485126729425747, -0.32759265985401437, 0.2908263939887673, 0.04315176993821956, -1.227713495814734},
    {0.5885254110482244, -0.51320868731392, -0.48875160353088776, 0.4473265923642344, -0.16776489418528046, -0.22513722610582332, -0.47051996195409107, 0.09208765912790005, -0.33682476573714754, 0.1720206573189926, -0.6770574175000931, -0.43441951499779746, -0.13753205045775663, -0.08151254970041576, -0.0337632458028862, -0.7296818523878106},
    {0.8193571458069299, -1.0895650440605793, 1.0324695205494772, 0.9837826550074731, 0.9477871121940137, 0.9370849156410554, -1.324706424447834, 0.9323274171399325, -0.6001989209597491, -0.6977462943078321, 0.694825519580155, 0.7033892111912524, 0.23139877617093563, 0.7724243324726043, -1.060824087067651, -0.37653798890955015},
    {0.3414384570527288, -0.26158542374939003, 0.92573871028083, -0.036483576743667506, 1.075788120155705, 1.4274110037106502, -0.47910798890772793, 0.793572069294196, 0.5431744566505482, -0.40791338955354256, 0.44282985741229797, 0.7990108408439082, 0.43988170945976973, 0.5176991559248008, -1.0064129886543318, -0.17663482539568728},
    {0.16216289821554541, -0.3496161108326603, 0.8699131880631876, 0.12348024397048159, 0.8788595839025398, 0.8936131654877859, 0.3103898449357568, 0.3414735059249397, 0.5785258650649173, 0.18889166235175603, 0.7031710606852037, 0.5285312114983035, 0.011429999992619757, 0.3625125234787164, -0.17609159698912988, -0.22311068590029653},
    {0.4404359178467663, -0.10285358991052064, 1.096853922335577, 0.11021792558587536, 0.852057982268391, 0.8304140679754308, 0.05697191257547402, 0.4989894097288444, 0.4313534515516199, 0.03543341355555403, 0.2892103381196449, 0.9080873334158187, 0.24443682033996128, -0.11402452427621339, -0.07736671068428443, 0.327608025897585},
    {0.35205138009418, -0.40227862700301087, 0.7830501854563711, 0.5504700361176217, 0.3199064894928879, 0.38423819644836127, -0.11675534412162225, 0.567908668698766, 0.09818097815189708, -0.39301351049075567, 0.3383413902108531, 0.41574819482420683, -0.3036107730614926, 0.4465477950890343, -0.16517338288091835, 0.06419870974933314},
    {0.2487606868836819, -0.4174841806941618, 1.0395284692049123, 0.49066494970263785, 0.926061905407836, 0.46161946398584736, 3.602373437214986e-06, 0.7419555557879666, 0.29796254987080656, -0.1468869799742163, 0.4131732234129646, 0.3772793074827103, -0.1742848976259313, -0.006563001380945667, -0.28521681470422994, -0.422664336330999},
    {0.20707149396944413, -0.09626159261800478, 0.8044468017824016, 0.4962202390212871, 0.498676911547835, 0.36416603512030177, -0.11709281542813119, 0.27912186818466883, 0.3806693604650556, 0.1698476648528681, 0.42676684579210733, 0.552020778309561, 0.1855454469544361, -0.2257593912392483, -0.049660106188835706, -0.13660664411740828},
    {-0.11880903225770834, -0.1204229040846439, -0.25056671402967906, 0.5159716205989939, -0.3731403283370781, -0.1708879873892517, 0.14957075788324112, 0.12903422576408788, 0.028739371053549748, 0.2462510037836854, 0.13376832587696302, 0.29171396270662175, -0.21583566435570595, -0.22029260964623731, 0.10342674310191335, -0.15719484531629738},
    {-0.1156913152707297, -0.3656618564360382, 0.06203089180830446, -0.07413849792113225, 0.13419366576950045, -0.12276639212155825, -0.3621299888720761, -0.16603579223491421, -0.18623646506717037, -0.1184559360175623, -0.34389484940129345, 0.10296932179173567, -0.1279571929993396, -0.05573923835110058, -0.4914954771590576, -0.3248164020913628},
    {-0.021324810436176032, 0.00549383292870234, 0.426353262274177, -0.4619997835744169, 0.46287401957254154, -0.1764735514638736, -0.1694308834556279, -0.4936043436632023, -0.22289922573896082, -0.043044947603340405, -0.2746995719096841, -0.35555841853245496, 0.05579424142716614, -0.41049542437444075, -0.014503029339564167, 0.12065249708497608},
    {0.21109238597383087, 0.49972363168151074, 0.7682076199621185, 0.32754712611966236, 0.19132248595271892, 0.10564202163754205, 0.4157379851509679, 0.13493260150034606, 0.44198895453135223, -0.16948045267048828, 0.5507260943213526, -0.021115406494063103, 0.18708923260418553, 0.055147356250766305, -0.20316806528622502, 0.31538964337749675},
    {0.3004305047518072, -0.09240004076764811, 0.20733166416551593, 0.1972680840907873, 0.5324697724464257, 0.3348748170773262, 0.11922261488049189, 0.7862583134835787, 0.2787077804827486, 0.18012032063118424, 0.6826780848834365, 0.560458961773206, 0.553083665880727, 0.16865116770227628, 0.15101750085531215, -0.004139991977809434},
    {0.30599398468152555, 0.4012796349124189, 0.16329227958469023, -0.3310575146577847, -0.1764571280637977, -0.1946116103425895, 0.020171028506586596, -0.5178915769245512, -0.24960426703987595, 0.109870339930188, -0.1059870189810978, -0.4502730443287739, -0.0779726540668504, 0.2732980475928187, 0.02170519354635631, 0.09517125232402426},
    {0.3060639619419275, 0.14160243851293183, 0.46765329361958674, 0.030946397704591587, 0.24857242165973523, 0.1040499497555546, -0.1076294194072081, 0.0210420658231919, -0.07000328539897828, 0.026978311512458827, 0.08622203617138059, 0.38536426320973616, 0.0599843981484833, -0.15905009602758519, -0.23087825389647973, -0.03238440187102525},
    {0.02373118232653621, -0.21834908411106108, -0.09648364161827234, -0.3908966407475181, 0.12491401150149987, -0.008067190871370608, 0.07527342271740568, -0.2015297693139719, 0.5141468026339967, 0.1322396723730397, 0.0012893024300068845, 0.27388352664314225, 0.08140853506075937, 0.35887068462497196, -0.09276412710479863, 0.0406689155871948},
    {0.1498067471377166, 0.042336623078151184, 0.41032706252283485, -0.06436528921282662, 0.25200322764152344, 0.2306898057190021, 0.020297068888526403, 0.24124463954539227, 0.2498999814213382, 0.11123739406736735, 0.1427223024586153, 0.4139791548344695, -0.10836285219224975, 0.08196451418627779, 0.17792293188398733, 0.12854932437062097},
    {0.34597737918034976, -0.419128320766867, 0.1696538682750424, -0.1847778234405277, 0.09874847474869901, 0.06971588248009511, -0.06328575405005935, 0.14086427997879855, 0.17670884454427543, -0.021279599280765657, 0.25857865521389656, -0.07225043091098976, 0.00484227659324795, -0.007196421790309393, 0.3236271495302709, -0.027767531672372465},
    {-0.11562120514108308, -0.49155590371254937, -0.26707469171912407, -0.062465920893946564, -0.24104771453857837, -0.24724442098323018, -0.18792878280443606, -0.12086960660129759, 0.0803563984290926, -0.3421182974410974, -0.06110397881649621, 0.14238250686287054, -0.4011208447433952, -0.1861018690274671, 0.12348817265659127, -0.4041333223956042},
    {0.13041312176363978, 0.49154239685894824, 0.4520559013922026, -0.17341282758579607, 0.28526723063476217, -0.05251902060469732, 0.12637159462034672, -0.06376207204406507, 0.5283662031926726, 0.1899896209625868, 0.02426480203534943, 0.03735915722877484, 0.12841985315933666, -0.04148772245413264, -0.015119562560243483, 0.12700221532871528},
    {-0.08745352730568388, -0.3622086670866621, 0.5652722367089327, -0.3239169166048355, 0.2034348600521595, 0.16287209877330025, -0.16301655863473402, -0.10986980037957682, 0.24880561729121412, 0.04305323370415063, -0.4560998755556833, 0.33183734603449644, 0.3309208029140302, -0.4319692425847977, 0.41315608937481413, -0.20192554837106558},
    {-0.01005790946821783, -0.5132749279342721, -0.0686517763151176, 0.07163330824076942, -0.39304905100724713, 0.19237784889352472, 0.03716265229471661, -0.14404085743041406, 0.309875159329785, -0.18970330649182487, 0.1528301591112598, -0.018110639667120107, -0.031398447861224296, 0.1113965235914813, 0.07669079410321636, 0.0630582874596749},
    {0.10063584435819994, -0.32542195230431176, 0.21038152921183506, -0.13417696529259607, -0.028400436942755902, 0.5101163527101052, 0.19517702774793508, -0.04212182085809581, 0.007681155664979404, 0.05592491456116501, -0.21660277797970837, 0.24485788247023071, -0.16283445854096665, -0.1048391433778333, 0.4477732473729233, 0.14044240646980366},
    {0.2824693857862634, -0.33676507023515784, -0.0009377430929163176, 0.16226662588312438, -0.12473701809375211, -0.05114754282017933, -0.08673321273772451, 0.14867724505155497, 0.08481428226856036, -0.06870506128822337, 0.546861505147609, -0.0062790152562319105, -0.36787584373271853, 0.6816719210089506, 0.03887801088698898, -0.23794120120997272},
    {0.294373478855523, 0.2010439706527387, 0.6456614120915771, -0.08905633278646312, 0.43054877823848425, 0.7350354294128181, -0.04347330244697183, 0.5595136244552859, 0.1835805991055953, -0.09598063753955652, 0.7907824007563408, 0.33744300835102764, 0.19164134817050435, 0.030407184494901412, 0.12832554350169484, 0.030810110646705097},
    {0.4885905686108958, -0.6023240784972295, -0.09017589688220133, -0.0015304229792448354, 0.30350422086249895, 0.5297351399384903, -0.0420302109733453, 0.05235736333130912, 0.06493112686464902, 0.14085570064611533, 0.5247286102679106, 0.22092925937212246, -0.4711265056605398, 0.365322642180905, 0.12931637708632168, -0.1803615348922018},
    {-0.23551868954974192, 0.06355993276490113, -0.18798394561761717, -0.2766070852047036, -0.26150431612019437, -0.2799105373200922, -0.26838017759813654, 0.23410735098492916, -0.047791769661260135, -0.14471091389267327, -0.2871049371073264, 0.3509276541673377, -0.17869003017568924, -0.049175116926411896, -0.16352320046219918, 0.06564850251229398},
    {0.1401818144788201, 0.02348466861567532, 0.34856925974422887, 0.017844975163943344, -0.004172298194125299, 0.2674046657226317, 0.05627527162684459, -0.040070794058216945, -0.030976919119940053, 0.17328635256814384, 0.09148765204298549, 0.3637971676188555, 0.12212605762334723, -0.38633114400558494, -0.10483364706302478, 0.1957524371717127},
    {0.14304874104774098, -0.1431984365607392, 0.515241050323212, -0.016269538380787714, 0.31331198286936707, 0.4842862213968066, -0.05364736896640779, 0.13342212087411676, 0.26554484292578473, 0.18807530052330507, 0.18382653119407602, -0.09833086541634788, 0.22861212590463104, -0.46661005250905846, 0.10198006686783236, -0.15088148217103994},
    {0.4816139922446595, 0.014249994436772261, 0.8043905252513563, 0.1241329105883343, 0.6264320165692651, 0.6431663566209548, -0.1193487405687451, 0.4127078947379392, 0.17460955937207173, -0.10679311562058899, 0.2796303907996376, 0.3922354193510071, -0.11208773910149392, 0.16834464172911215, 0.24952679514384568, 0.2805436986953264},
    {0.13155528375983339, -0.005591295089210865, 0.3909009812698447, 0.12668396828910441, 0.4480587411841204, 0.5574673131594622, -0.16009245446908288, 0.49310879916101386, 0.1907481138119482, 0.3058582095604056, -0.30853163295047026, 0.7929434475257819, -0.04644825217857498, 0.017878512412533326, 0.09991832645403521, 0.3099479497116746},
    {-0.15525115828847114, 0.12297391962068498, -0.2551106224287215, 0.06299802204808515, -0.19663799883868213, -0.34321889496482944, 0.15582889123573349, -0.32231126966030993, 0.058766637319645015, -0.044067661301495954, -0.36443275581355133, -0.12473741752621374, 0.2071879758266016, -0.12676886510488106, -0.04252234232298489, -0.07018708437430639},
    {0.09154907777685779, -0.5197086903859618, -0.5686020408204263, -0.08471366801725008, -0.011531681703751325, -0.03345294698241487, -0.30841732277094, -0.3951091656447205, -0.584566443987879, -0.19397186492642757, -0.23734335723224964, -0.7219887232957295, -0.23968004047697616, -0.2287019599036826, -0.14625200817989242, -0.04531902760161446},
    {0.07517521104697222, 0.1502950735370306, 0.24294526148214227, 0.13908927080726857, -0.19518493130400005, 0.17831136858070343, 0.007069571685213119, 0.3560714754935061, 0.07493627210993407, -0.22088531450610208, 0.20559842898002478, 0.32687548066353445, 0.013651732951035334, -0.23149776155900573, 0.02265936003647243, -0.1388307957383988},
    {-0.034326031057430206, -0.1239601636010909, -0.3510939871873931, 0.2702483699317477, -0.129862314419514, -0.23985642428309226, 0.18297528731328377, -0.3610452790641986, 0.07339944696434576, -0.13334710021034027, -0.012757076093379924, -0.09409926997057995, -0.049537244456444626, 0.3089080505542482, 0.02344763942113939, 0.22962491998086146},
    {0.12518245969650343, 0.17977442500160923, 0.09216362526049234, -0.0781827787746666, -0.10733121151194337, 0.24983399099429526, 0.13718398004225635, -0.03724257764807191, 0.019078116063971966, 0.0840019330197667, 0.1576220501980695, 0.15409608694770527, -0.2178516952412711, 0.3667338056760774, -0.000610984162184408, 0.24271452072587288},
    {0.08451199441843261, 0.12818318783808694, -0.016173026607257942, 0.02561555051977969, -0.14421638469062664, -0.08770562556507464, 0.1699115556503533, -0.11513681040259548, 0.021275028372891636, -0.0034004469693873496, -0.018719566610295224, -0.19008125705293497, -0.11631655061504, 0.3886316850274252, 0.303876946667021, 0.47296837563565824},
    {0.06050184458135837, 0.07963735664087909, 0.13596076483399755, -0.018364871931044906, 0.2063813195421554, 0.46445946014664113, -0.02027230548512332, 0.25611792171061915, 0.11323210469641719, 0.1903616330272234, 0.5512287886246185, 0.06241964362268512, 0.04455603191966077, 0.07679594289709603, 0.2496817052335899, 0.1786526842268294},
    {-0.005118027400520702, -0.06424567541291752, -0.2339583714547644, -0.15793506757547293, -0.21260547291844445, -0.0017158625272960164, -0.11377951236547071, -0.27999479753494844, -0.02629767954321323, 0.15405890062282557, -0.11224252351125123, -0.03086597972310651, 0.08515803210727743, -0.019546684506483034, 0.17784220703342227, 0.010226026483061122},
    {0.0885901836501757, -0.06717643697450583, 0.31224812608009306, 0.12487664128303967, -0.10000185078332034, -0.14546439915526233, -0.10315370653159187, -0.4343159215079001, -0.32927791962490593, -0.053697817161942246, -0.36878994734260806, -0.35386194538470633, 0.09364807189951864, 0.1796392029149437, -0.0849033265557937, 0.025169590050796938},
    {0.1012045725224607, 0.00858396310532528, 0.6584741288655247, 0.11078275317767115, 0.4601847367679489, 0.36513970400968176, -0.06452910995845475, 0.4579835025806363, 0.06512345492645671, -0.001655180555460607, 0.059577327767585286, 0.14115969316443286, 0.05252844323373043, 0.07799993742967193, 0.1325268871030043, 0.0746066343194079},
    {0.11792190132308772, 0.3398917588748048, 0.2664311253695409, -0.0978159900883094, 0.5298475225432547, 0.288585239259924, 0.09557942175887979, 0.44730758634995393, 0.11016656509857353, 0.45619875154529343, 0.4309758782637828, 0.7781486600620746, 0.11228002579158149, 0.18068262732101756, 0.03834038868606185, 0.1529685413068948},
    {0.2809422119038688, -0.49772810557970804, -0.18987057095031065, -0.05115976072902407, 0.07743083688336132, 0.16506636806913066, -0.0888278218557896, -0.016737163003957212, 0.2813681434474793, -0.09096237915021936, 0.4611691630088442, 0.23457177811608754, -0.04983068044613834, 0.17792963870556397, -0.17227641188023546, -0.47279966944112173},
    {0.28094641983494084, -0.15572649964461463, -0.12194479711423013, 0.16362162740184671, 0.13023956592555969, -0.14858969549320414, -0.1347809883926074, -0.03976675911913518, -0.02083789787575057, -0.4414105869007923, 0.017329755957135675, -0.06798956801894124, 0.04940563655814651, 0.24346819208584447, -0.16615558751345422, -0.24605887968073914},
    {-0.23052993371602012, -0.3310491894405289, -0.17262897085970064, -0.05702185135984209, 0.08645833865383096, -0.22604017625054637, -0.5299744905065785, -0.2699681127125988, -0.5154544283674221, 0.0004541248864217354, -0.25916533606374803, 0.19143664246293804, -0.16978632868129956, -0.21056503160319456, 0.009989944062403666, -0.0665320031805179},
    {-0.3240615772517038, 0.09288583949438799, -0.3699343115592855, -0.32453046822471987, -0.7817766572228035, -0.21133320480159035, -0.22697216264142098, -0.5374859307498602, -0.27094729489257113, -0.019160363761214227, -0.42268761574065666, -0.7358925790901751, -0.16436739685993196, -0.2292968024658374, -0.25804204689601307, 0.1880581180780892},
    {-0.2071809064738148, 0.18385266780249507, 0.35089660476566764, -0.019015603007339846, 0.22028655799456814, -0.10119423058936544, -0.005720586711240716, 0.16723542161776905, 0.063016285091826, 0.31689695506521837, 0.35421867965419657, 0.3357363521963622, 0.3867906212272589, 0.38699503768604165, 0.11949470737252638, 0.26534209250487667},
    {0.24346156736238328, 0.01771860976707853, 0.16388253023642016, 0.09481467938928499, -0.14785676788106517, 0.2223989252302597, 0.07972481080151118, 0.19206434456122812, 0.09579454169308778, 0.046858351484670324, 0.344181884243185, 0.37487540901539385, 0.015139894053586903, -0.0593386086264807, -0.028527344351803305, 0.11438258718168329},
    {0.3182512143448111, -0.34448849185545916, -0.010181795273520084, -0.00922930877980862, 0.19881452754427428, 0.05710205907527533, -0.692667551646892, 0.3516524949243033, 0.03241350012278517, -0.10007608319919511, 0.11610771562539295, 0.29061182791551315, 0.19946928739930417, -0.06722916386584855, -0.1266698812209258, -0.1504334004378762},
    {0.3563196117470335, 0.19551061884124377, 0.8858019876242227, 0.4006179333448392, 0.43098582024378346, 0.16218737627710517, 0.09000433673476359, 0.8295126929273274, 0.19294333887544843, -0.08633480088764003, 0.5832972914665564, 0.5020347560021722, 0.17507503199727917, 0.3592662070432918, 0.22604117707553095, -0.004740008481577938},
    {0.29210698359373, -0.1413846330726324, 0.9881286794595249, 0.14042431557075047, 0.6235150267778438, 0.5987356515778759, 0.1638587025149978, 0.383203307178945, 0.031356896300341816, 0.12045407654338666, 0.7407582249196416, 0.6828856434226623, 0.35035362291938343, 0.43014342550343354, 0.26129868890541397, 0.1250280534690027},
    {-0.21765511711490876, 0.3687598859084964, 0.4502200753411132, 0.075211977895672, 0.1100507977833649, 0.24551949318407915, 0.2689638070638271, -0.09647608075857751, 0.1410599798053772, 0.04345998552292511, 0.08770289696079649, 0.4116344175902863, 0.04786572246355325, 0.06454670596658074, 0.041524980390458814, 0.1306238875259881},
    {-0.015441438884838402, 0.06402833082041351, 0.2029566722692632, 0.028038979447344622, 0.1129083816628262, 0.23969059133244763, 0.0007291766673057001, 0.2550520385791638, -0.07130994585130886, 0.2770450185798218, -0.020247702387362166, 0.0617683015801548, 0.012263917974369577, -0.12789925461979434, -0.010037764725660873, 0.391274648720517},
    {-0.19408624494777138, 0.1512863742229774, 0.47279669921367423, -0.01291047375107694, 0.45026064143290484, 0.4801693876273935, 0.08557107081875517, 0.3462687737037408, 0.08545560462273252, 0.004674826554506553, 0.09217037232436594, 0.3020950521862473, -0.09739319966221416, -0.11612502885789157, 0.09954899209425173, -0.08013852225873005},
    {0.023083434077279582, -0.05379858510563761, 0.12158640685993842, -0.07534900781986797, 0.168999967730196, 0.12751888498830122, -0.026628124621259942, 0.3345285947685756, 0.11340688305394428, 0.16863397774116826, 0.21783786205695682, 0.28098082912522865, -0.10750139855268269, -0.1448643974321765, 0.20940681793212457, -0.03943976672991051},
    {0.2117608848879652, 0.09103394096224499, 0.3640605098354664, 0.17296008006358005, 0.26447879640152183, 0.6343904317371114, 0.012643252215379536, 0.3368479666783465, 0.18696605285191134, -0.011599802396059134, 0.4388794100309272, 0.2539086719289329, -0.034466889910591485, 0.022956769337325007, 0.06904860824473956, -0.09175049399013803},
    {-0.362484902441075, 0.0593346336383905, 0.19845203400746386, -0.38848951726976155, -0.32453084353646194, 0.18506815919394942, 0.23526540464988263, -0.0244966261590011, -0.25513379540528036, 0.21842203930643617, -0.19075409319913145, -0.06992965312137656, 0.12606715849467323, -0.10236582073139502, -0.00333675268398492, 0.008367858394847954},
    {0.0854978267359252, 0.08526482602339805, -0.12474696296314693, -0.08323751705040772, -0.1325177116540631, 0.09272822061305595, 0.13865653520977825, 0.22193794971420475, 0.12998209977321795, -0.18648029410785952, 0.010373769951311188, 0.24514708696129386, -0.1813615657363539, -0.021827783264538447, -0.16090233809478144, -0.19621589127308658},
    {0.3136402578768425, 0.011804669737352589, 0.6037484337586461, 0.09597506232002712, 0.5226480953637841, 0.502686072144523, -0.016839622952378355, 0.22662189193854781, 0.11669520852290066, -0.12370116046410504, 0.34441337727319077, 0.16462144299366363, 0.4487039646202669, 0.214902564249329, 0.4010685189252286, -0.15335040072556094},
    {-0.05256467669964235, -0.1439006826126577, -0.6644441383187605, -0.6079572193660534, -0.40084002985607314, -0.20990312299680788, -0.11221458201897873, -0.07705374425782349, -0.17555166655967006, -0.042876711336675304, 0.05161520505860271, -0.3242181972284073, -0.0714974863366301, -0.046559495916201815, -0.012044921152276941, -0.39029258724165283},
    {-0.05562244015061445, -0.14891573877394446, -0.7115756245686283, 0.24798070529507377, -0.4099201143428733, -0.37159202919054, 0.09004418294236116, -0.10948013482393579, -0.20627671882077275, 0.06543543329289324, -0.02852012724734022, -0.4052201568690649, -0.11017209449865491, 0.2134412992338975, 0.14611951665077788, -0.03693374339419725},
    {1.203686080780864, 0.34565316973640176, 0.8664276614612407, 0.8060405384124633, 1.4753885604055301, 0.9120467104421132, -1.061057748881032, 1.713585976717832, -0.08203079554138604, -1.0685589477308233, 1.1652157153441394, 0.6778721805304253, 0.09448025460800905, 0.37576706955627226, -1.1575681785409127, 0.3796841755539793},
    {1.036059250197688, 0.6773082819991451, 0.8371378989959787, -0.26463458285655583, 0.9967107826470805, 1.3918170135472618, -0.5672378668169804, 1.3308212685738716, -0.04825675287434241, -0.8037882067248274, 0.11156544959955017, 0.12190140310340757, 0.17617786602981908, -0.202135364795095, -1.1048836722216193, 0.2635750837439061},
    {0.14835745091110242, 0.024226184128026032, 1.0670070903693982, 0.12782340085730876, 0.2916249952889673, 0.6834884825420529, 0.01522166383449896, 0.2417983955575413, 0.09178605773277093, -0.3618898917253134, 0.36294052835034024, 0.17426856120461504, 0.03778610696587385, 0.1974750371329613, -0.27753501294788274, -0.19234952293676905},
    {0.10864778731318371, 0.08354352208796219, 1.004673816923482, 0.1788218588671447, 0.6830967161165813, 0.28741576185664874, 0.05758690970814537, 0.6080288964870487, 0.33853189496069885, -0.055575564581943786, 0.31802161141001545, 0.757552422269746, 0.3306792903629792, 0.11706686969620198, -0.11571008776843227, -0.19630356919991473},
    {0.35334673954318185, 0.08995080956047316, 0.8398445489902485, 0.39677699232295893, 0.44062708459431876, 0.5564418467279205, 0.10718904982358982, 0.5423820473503964, 0.10134805458999563, -0.20449030224275874, 0.7647975469314461, 0.32956275444676125, -0.05613079467838457, 0.11120149470375301, 0.029640726215394438, 0.19829006962447557},
    {0.41026915328822394, 0.21967008626633897, 0.9370548870286245, 0.5893396071210729, 0.8207128655763606, 1.0037036824349936, -0.014125720638610213, 0.9135094195121918, 0.4328428516725485, 0.11943917803833305, 0.7229673407611951, 0.513206327698483, 0.23410044387279824, 0.0541660295349724, 0.28398973178728276, 0.05382832154479624},
    {0.20176522034766348, 0.16912190133892013, 0.5797784091679334, 0.11394169285351297, 0.48265440861791176, 0.5943148208394635, -0.0813391925807959, -0.22195163523350495, -0.271262134737654, 0.09852933423771647, 0.3705615598753818, 0.056737154381152705, -0.1995820259408967, 0.08174147278095943, -0.07792053606205146, 0.14616632357576886},
    {-0.03194370001476882, 0.06433393868427674, -0.27415941180779785, 0.09674591772280122, 0.20304220965808656, 0.3251516965836257, -0.003024138166270525, 0.1527471539911647, 0.08779768081640471, 0.09300068188572179, 0.15540831647329875, 0.2986112248281596, 0.045762198662826645, 0.48402748689644504, 0.07647505110769295, 0.12440154703926719},
    {0.38287431024864543, 0.11126803019102778, -0.1133326475217582, 0.13287922386723497, -0.24885346853342646, 0.3302659356341694, 0.12024578581809173, 0.2731007344465227, -0.25671726285137714, -0.2098249179677843, -0.0901151755693306, -0.10762067755814139, -0.15029645616979911, 0.043671759896408174, -0.1204527866588174, 0.3806470369940124},
    {0.05354788211361905, 0.36793376468054556, 0.5137811393931778, -0.011358537481191788, 0.7055906761424078, 0.6339241629735161, 0.023237201066400953, 0.14543349421410115, -0.030889754322415145, 0.15567989406936358, 0.317616474609333, 0.12211642115835436, 0.019502782049846328, 0.10387599250129072, -0.014559535959790777, 0.007757874550505763},
    {-0.17351329077366184, -0.2604395506519514, 0.9759176573727522, -0.11117938145636912, 0.3027820128909588, 0.04038006156276371, -0.3166450804076357, 0.4897058124385162, -0.22807766859403422, -0.03009582706065372, -0.08732417424628874, -0.059982299637647125, -0.3063081648228591, -0.11033115514433621, -0.2704749602628148, -0.13948008404541504},
    {0.4412560998097396, -0.25338776453982986, 0.5318323980730534, 0.1452993535710915, 0.698119020836251, 0.34929844147929123, -0.04116854067723808, 0.7180964458586606, 0.4350401472968979, -0.10130270076892792, 1.0121834164726442, 0.44366631629704817, 0.04810690220230498, 0.6460276707941964, -0.10248761696547211, -0.1770255870733145},
    {0.15438717252966094, 0.5294223601882775, 0.5539457375050859, 0.510910752790364, 0.09372507130803938, 0.24705184038839748, 0.29867917402282923, 0.1619885638193529, 0.3890683159037767, 0.3240049924110507, 0.06436226115520839, 0.054361970287149126, -0.1868325915114616, 0.3124169817307068, 0.20007322480132922, 0.38233243222428326},
    {-0.3078039872534305, 0.21828979621882932, 0.5286848898075334, -0.03399331261240717, 0.32792136710660047, 0.04767873244807002, -0.09259464699513126, -0.1626631337886207, -0.1351508385762723, 0.0561902163809327, -0.19451162454700124, 0.1440588648027302, 0.210552984815865, -0.2897741804129413, -0.1738778873237012, -0.5143634538787809},
    {-0.13693156809247098, -0.027971489575308053, -0.23640523875662509, 0.015196273270249977, -0.3099025662728799, -0.5438241304767317, -0.14941517495008955, -0.34068505854774234, -0.3147406687722748, 0.13056071566052704, -0.3963538104765294, -0.40439613771956623, -0.17187183768669917, -0.4523787319110559, -0.11383030011410764, 0.03217537147092081},
    {-0.15539648499841044, 0.326033378658605, 0.06439465850238926, 0.03517012577346379, 0.3383910153812591, 0.1629044529258685, 0.026465282439705202, 0.5442877376384031, 0.05441178654643855, 0.07060574324466933, 0.07693977580168217, 0.12539366584910297, 0.07674811730441419, 0.17950473024748764, 0.4352326180198844, 0.2373023907885898},
    {0.1857688293506505, 0.35654010636933997, -0.016832070755300396, -0.07972084387956602, -0.05970370787968384, -0.029892091654373842, -0.04967291846269169, -0.009195332584506681, 0.026930178221195932, 0.08744821978675711, 0.05414008216562701, -0.2909074338876294, -0.117456389155374, 0.04523541691853676, -0.33816393790102456, 0.14554451675148697},
    {-0.07939980691085989, 0.052804203521946855, -0.03992016958439482, 0.15194454608396102, -0.17492860061651117, -0.10348586885324736, 0.07122527265743825, 0.22093087819788676, -0.009940577665779946, 0.07517557433979079, -0.22993142208927822, -0.21329951672722589, -0.2351719733101281, 0.262610375985256, -0.5259273993886141, 0.401834033601809},
    {0.35031038950164045, 0.3490696794220492, 0.961180132573691, 0.4397594894123195, 0.7047534706314138, 0.8848981352782326, 0.06355415512455906, 0.7722514643427895, 0.20715049536929436, 0.22437365965154474, 0.20166261360279528, 0.6027858335807156, -0.019188310603840627, 0.10211673808342507, 0.11048859698962088, 0.41216841732918},
    {0.11332862832960088, -0.09060711269037619, -0.022509536059945774, -0.3491330240384608, 0.11829808760356694, 0.35818918718456727, -0.23502706056946168, -0.052420395191553115, 0.15198104890980924, 0.09451193499495433, -0.3582514269148191, 0.22206883893964127, 0.13297197562854804, -0.467875210705887, -0.10166332315740327, -0.06407315893605571},
    {-0.12039116866613979, -0.05203051889887858, -0.0839976326723014, 0.05157839690121381, -0.1703090785014813, -0.03907115231981591, 0.27702066952479476, 0.4442505758624677, 0.35939342641392263, -0.26128597612476845, 0.04239363935527018, 0.10502165801319344, -0.296428210736434, 0.11859326509609297, -0.357128421918176, -0.159055258365302},
    {-0.4825006464671188, 0.11121278435225214, 0.05962539216773728, -0.00872272868139287, 0.13002187689410644, -0.2343292643089098, 0.04913036472617482, 0.2847992712942133, -0.3200526229508457, 0.2445840453054511, 0.05480484028043828, -0.383364291061566, 0.030969498189927985, -0.011230089573570409, -0.19195196991066688, 0.13203693790550383},
    {0.10788833344960044, -0.15802676358447829, -0.17634982211335357, 0.06535759788565125, -0.2700048169089571, 0.19570588060545657, 0.1449567333751531, 0.16933919726944888, 0.04720104469989781, -0.16108328670662933, 0.36176066779897464, -0.057535909304270966, -0.06472316845865646, 0.2654749661257587, -0.141357510810701, -0.0488435696806208},
    {0.18728039533679725, 0.21695345749914677, 0.37565963229739047, 0.09763094853136443, 0.2955400200510268, 0.5551681718152779, 0.10222677790226926, 0.5537694063660491, 0.17878839998574053, 0.22015227765836834, 0.510528437848886, 0.29097416266637083, 0.2203993072627743, 0.4027498999288966, 0.09249453954942406, 0.1523781917261701},
    {-0.11596798873696283, -0.011795569539581158, -0.1666194346257675, -0.18104282885488246, 0.5489366494006453, 0.31862884926707497, -0.16587157380640366, 0.22039950304142975, 0.01887052878459717, -0.08420168174865275, 0.5641478461807936, 0.19680650947897702, 0.013640770040912619, -0.09167365523624449, 0.07796235355429737, -0.22942589937141908},
    {-0.0838053684942597, -0.32915963088702715, -0.1767241549498297, 0.033830333430638466, -0.1614895911844854, 0.16492328932299063, -0.19039049384589524, 0.35168446908662, 0.08079406361261965, 0.12231517058442977, -0.23023532610502137, -0.46886115797302913, -0.17871177330794094, -0.07558417021658334, 0.11571032929003677, -0.07704847808772824},
    {0.3294124393353665, 0.3636473723451189, 0.8452603300808282, -0.1188204995086487, 0.6539424964656315, 0.4543753540592222, 0.15222345196208728, 0.6977356048480037, 0.14632880125915634, 0.3381470806354787, 0.5267686662182941, 0.3804533380017575, 0.2859983470159899, 0.2952349768954679, -0.03464251647008706, 0.02824215185023759},
    {0.05702395289747737, -0.6149615025315674, 0.17066400281151706, -0.31497596298293223, 0.13237364277386343, -0.309053456994132, -0.40534466979291534, 0.06398039703793552, 0.04495794605951831, -0.07388835904189561, -0.4202241449624876, -0.18560939264680723, 0.21814511403170891, -0.7385622711551476, -0.21622243396061047, -0.19831673676033384},
    {0.4700035216675788, -0.06231079613895041, 0.6234827146975517, 0.3780627427826227, 0.3670920271233752, 0.23372722069311344, 0.09856216457721202, 0.4659836078321649, 0.06309485800230007, -0.04160396159624367, 0.2589167339869872, -0.036531030986001425, 0.29135309364046197, 0.17959460501061988, -0.08353941908780853, -0.08541576562099541},
    {-0.10012000167099169, 0.2729035266914139, 0.083246613072922, -0.1947965444023256, -0.22055019171795026, -0.006155722601776855, -0.05363009621165646, -0.1109791303515312, 0.07323453878629176, -0.21234432170477688, -0.30603060112043645, 0.28898142502538876, -0.10526864815169033, -0.4497616364416733, 0.02247715099854111, -0.01072603021180001}
};

static const float b1[16] = {1.5813905641002346, 1.5930695042357172, 1.306359882879191, 1.5916338037167528, 1.7421162777919224, 1.7278033314520984, 1.5417441335476683, 1.8632404628703205, 1.6666688574075992, 1.1964969167939692, 1.74723108137294, 1.8097668618834668, 0.037775865364174946, 1.364201609936272, 1.3803548138060353, 1.4425146271333011};

static const float w2[16][12] = {
    {-2.3248925870210817, -1.5274170361306987, -0.29951047697995503, -1.5888211167742385, -0.38684688793339567, -0.31306002195620863, -2.041688546738402, -0.5954851198798041, -0.08594952013127134, -1.103670636083226, -1.009052765486212, -1.0455732707076009},
    {-0.20777688337791872, -0.18761704924757924, -1.3059942888082414, -0.2940525824737063, -1.276770672412457, -0.13176525233824793, -1.8782367157317392, -1.662751255478032, -0.5744825202530686, -1.9602996446994523, -0.9436609683627272, -1.62118231401478},
    {-1.088124428546671, -1.6068420316392769, -1.0655908702617376, -1.7949208483305812, -1.1764373664514411, -1.952761585785921, -1.3072339069581902, -1.3356189258610516, -1.4249651169835775, -1.4283164622215938, -1.2173410962390956, -1.1232194025457485},
    {-0.6893191330141403, -0.31495748014195646, -0.8312685205424154, -1.508980120098306, -0.8508654385853147, -0.7921981226032403, -1.2939692634939495, -1.4822470588152175, -1.8399484658086405, 0.22590523893047962, -1.3114184999360798, -1.0668197551509444},
    {-1.8504949902037293, -0.780471036053631, -1.8259274120665554, -0.2331894196493522, -1.1601748550346578, -0.7601553045171828, -0.6254560882244314, -1.3015756777572804, -1.8066745715212313, -1.4115483084276719, -0.31434418860799934, -1.2071617199986284},
    {-0.3067769740531287, -0.6548117939652005, -1.323501760372988, -0.7124188799124807, -0.8756132824894495, -1.1531933811607928, -1.355646668578322, -1.5325608742455794, -0.1274676231979372, -1.4907294899343053, -2.1850045789300885, -1.6439239116337414},
    {-1.7581493560585606, -2.205635202194319, -2.171688367887697, 0.25800401854195787, -0.24284670442860878, -1.488485177847204, -1.9020982943430738, 0.23086678771976385, -1.04415689683864, -0.650224410043848, -0.39811105233334826, -1.3157000489899875},
    {-1.6039492226250625, -0.8665560288811643, -0.7586566558342978, -1.1489695361558359, -1.620014592610682, -1.443648554343657, -1.3434481056192678, -0.9528156258890922, -0.6495586176243254, -1.2987367093327715, 0.1695792873669785, -1.905246659556053},
    {-0.806136442752219, -1.4888772392714755, -1.295322221478831, -0.13283588634978222, -1.3155951241058563, -1.2190169663463575, -1.3450866722830357, -1.7712476799355292, -1.6804651630337883, -1.059205646719501, -0.5561751345235102, 0.4527029824935037},
    {-1.5831195121227597, -0.8728581990754768, 0.8028051442363162, -2.056518914170226, -1.099204144488615, -1.2295544844530355, -0.09220082107455471, -0.8945239160983672, -1.161635680580375, 0.35755756150345713, -0.734296210175637, -1.2188318079644596},
    {-0.21299580542476962, -1.6352273562170292, -1.3929491061466168, -1.727578382958254, -1.468392141423286, -0.7322780058035653, -1.287860526567399, -0.9891603887168781, -1.4683297994411317, -0.4430181976588375, -1.6160405142993468, -0.6826119527075692},
    {-1.6098437374191379, -1.6391872419864797, -1.0082099198000471, -1.482777726117373, -0.506859988744358, -0.829947796698796, -0.2721041361859546, -0.8996850539357174, -1.5222933422535312, -0.843910041959198, -1.547865810713968, -0.6442361590198745},
    {-1.3671906671232776, -0.013193637702393915, -0.16325025362216058, -0.20065773873730708, -0.8028380536544286, -0.2889916536459342, -0.7462629620466631, 1.1076990734581387, -0.7326474157309371, -0.5042456040110557, -1.542267104972577, 0.014768951761870904},
    {-1.4140287437102381, -0.4737837196716675, -0.6050738766724324, -0.8370818715118866, -1.4642918678442345, -1.399183773874243, 0.2819303817147553, -1.469261066514124, -0.9197052770324721, -1.5500386975741065, -1.3981791651245652, -0.9904941567368659},
    {0.055377339050295814, -0.6115555204463341, -1.224694325065979, -0.6934051385899391, 0.35492285736801504, -1.5848978461479857, -1.1935042189377219, -1.248964209135509, -1.3835801816771327, -1.0758606152597818, -1.4868136133360017, -1.2071036985984036},
    {-1.0478156240854721, -0.8714707018735997, -1.548500251431923, -2.158224349716089, -0.9196814269468004, 0.5764970688303285, -0.19728036030352294, -0.6213061009981213, -1.408838213673832, -0.4594882571292366, -0.43315839401527495, -0.31337349707233686}
};

static const float b2[12] = {-0.7508352910522833, -0.8862652400874642, -0.7585708244971099, -0.6700561264334817, -0.7185949382866589, -0.7089846903171142, -0.5185530242735055, -0.7245435249970728, -0.5838950809271425, -0.9221739611244789, -0.12283257760282075, -0.40676507300942694};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
