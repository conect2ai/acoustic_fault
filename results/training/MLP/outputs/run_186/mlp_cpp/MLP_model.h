#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {5.763010020823897, 0.46542659470548253, -1.4267777102110768, 5.858033254516794, -3.2667286188230693, 3.9793881474662753, 4.093224985135505, 0.7548859830705713, 5.00737677475611, 5.611947769002316, 5.651498927102372, -2.4949551599098325, 6.2019731311598125, -1.9700743858114163, 6.715235812573729, -3.302355982919156},
    {3.6869632379980892, 0.5816198183511427, -0.48081757414709997, 3.5287377164975227, -2.485073078289638, 2.0604656786286397, 2.9083812914775704, -2.6702717213678633, 4.157490868534617, 4.504797026849254, 4.447544706943846, -3.549237531599436, 4.609246364328511, -2.683926051347346, 4.753950935219, -3.826762790423682},
    {4.887265321311639, -4.822088778228831, -6.0330466522819695, 2.9915855425083167, -5.4886610318994, 1.2350363853257702, 2.4521771743692176, -6.435714646771085, 5.282070635952341, 4.493549080007535, 4.502087911288904, -5.574268233237307, 3.9184012239368156, -5.882690665196871, 5.29289982689699, -5.688524200005912},
    {6.163876136545986, -5.056636323865264, -5.808010656652325, 2.796527556140391, -5.710624621031985, 2.346560571554334, 3.9613849175394096, -3.863739827717428, 6.1246052501821975, 4.98625317619794, 5.626650725476885, -6.748869523960935, 4.769348340103081, -5.583580055709897, 5.077078842952813, -6.836395217225857},
    {4.804194459841478, -4.737269979211127, -6.755263321621345, 0.66340668695446, -7.238378916779031, 2.0460173626326714, 2.307154569614913, -6.315172817202695, 5.259662380651055, 2.7577882712425734, 4.470192330168108, -5.167939253295188, 5.172555161856614, -7.291381973019257, 3.4035666260540824, -6.648157251850339},
    {4.988849771034544, -5.2071971464559095, -6.64049823760184, 0.33637755937069774, -6.780597688243008, 1.5824167686079855, 1.1349585633598496, -6.964960424848605, 4.1644333420486515, 2.7180258809133946, 5.003863763067153, -4.890811644372176, 4.268434205509519, -6.942602949092049, 2.7223340799941997, -5.709669801528692},
    {3.156241192606388, -3.4988920146244067, -6.654336532318062, 1.8950825904031239, -7.1241961325162135, 1.3241563100550022, 1.739655078368156, -7.080479628986538, 2.7924560500080653, 3.5304507837177, 5.283357007433459, -6.150265767882297, 4.1417106909959935, -7.030247909827064, 3.98142670231861, -7.07057459726978},
    {3.2018891786645303, -4.27915359206285, -6.040824477478784, 2.6285395477765245, -5.808038800399646, 0.9138861077500247, 2.5376914856603134, -4.861530138297663, 4.486596827927627, 3.779961385356804, 3.6408154916144153, -6.256412232483173, 3.5799449739631477, -6.925614727364936, 3.820159717352686, -5.746550348720781},
    {4.788058870788018, -3.945373905675401, -5.965491339759069, 2.892351820185382, -6.820981702624661, -0.016664690026521156, 2.94640823383471, -5.197547301617549, 3.8916875615454454, 3.712809766892842, 4.169743435096384, -5.684625454047385, 3.6124058688196703, -6.767575594655493, 2.859583427536546, -5.977212441341533},
    {4.500046924306474, -4.524096360318716, -6.765278612483849, 1.9296147766262153, -5.4647271602216945, 0.6897349668734278, 2.0821635783694936, -6.49172031316031, 5.329548589208865, 3.844878692450247, 5.131417904082826, -5.880966276285253, 3.97219408149958, -7.268149828344714, 3.478524286034358, -6.09154714764445},
    {3.807427700583822, -4.320715812567858, -5.66982998767951, 1.6851523419472592, -5.5727584002786426, 0.8115572322291731, 2.771448991830111, -6.068977040089816, 4.691359129552611, 2.8816458426004234, 4.300724352880721, -5.406158868090187, 2.4503673268831117, -6.881863021639502, 3.199960244166594, -6.286192594923455},
    {2.6161089717847146, -5.570565556676851, -5.708299454507072, 1.370188873697501, -5.7747526977251, 1.8575508396172782, 1.1067473168842323, -4.805280398724175, 3.2318468463709698, 3.658718836558104, 2.5603223702783504, -6.1821357939973804, 2.7991515067692783, -5.888309013941327, 0.4329547839752314, -6.075752521339495},
    {2.2070863783280332, -5.724969691842357, -7.271660726687797, 2.392491372637612, -6.964122933386149, 1.0741978375935224, 1.7942146156447067, -5.800858887347648, 3.914813144543042, 2.8600094957640083, 4.162514120673974, -6.827843685647436, 1.7092936038481605, -6.392796492349266, 0.7218858880140475, -6.651426644554185},
    {3.561269544191792, -5.39457924455567, -7.463235480470526, 1.1663038587145986, -6.4029804335016225, 1.6814666355878989, 0.5817587183406734, -5.273213688394554, 2.966911081700737, 2.2002099023339228, 4.419610447616365, -7.157216066042165, 2.772401345916475, -7.29348160752671, 1.225766570137022, -6.210914477014041},
    {3.2993641021367965, -6.445733176448384, -5.949040664825135, 1.0151939583974428, -6.805874890124957, 0.7353897769903992, 2.575393068303274, -6.530844612978166, 4.707033707076703, 3.632854142177987, 4.775817283782869, -7.7493573803377, 3.7559868060617565, -6.156302168500567, 3.185853482276377, -6.758463444719913},
    {3.7728271926435384, -5.156266805441011, -6.544110236145861, 0.7375107426494116, -7.118298168093886, 0.02404466534354058, 2.509221252029049, -6.39936394269386, 3.9765301401386823, 2.9151599029671518, 4.717235357793094, -6.117165331106309, 4.57364650727866, -6.4247242576713575, 4.214734931875384, -7.460034578220953},
    {4.834009295576102, -6.6102753109884045, -6.130079160636896, 1.4465481929825197, -6.616642190399745, 0.28852016601654745, 2.376367551404078, -6.553050829123516, 5.213078572127211, 4.26425825147663, 4.591811307473578, -7.403094404872035, 4.966617794950921, -7.056607195950579, 4.157682486508085, -6.070872144054402},
    {5.504421561478633, -5.123035513056465, -7.511538983853536, 2.2960816911751096, -6.235205760757679, -0.019828884485024394, 1.158060343561374, -4.8050005526308945, 4.280325759391038, 5.714677550827035, 5.476670501500168, -6.68272960992968, 3.891447287545935, -6.724663514401961, 3.8826871289358538, -6.456593667805473},
    {5.739190255507294, -6.8288175646726135, -6.281311722457707, 1.5815923269639027, -6.3116712161715505, -0.22935640879108288, 1.8191200587449978, -5.585779079197099, 5.416927568222302, 4.189100156859001, 3.868628422932747, -6.99766209490616, 4.548668276199161, -7.632719961877973, 4.248304930357988, -5.874512597680879},
    {5.72145198656434, -4.871787502124037, -7.241729500844154, 0.5941831293462128, -6.368639318563053, -0.15160260839714537, 2.036585200857226, -5.764535516801193, 4.0869104776216405, 4.137393000715111, 4.470474890363991, -5.621405382872554, 3.3186738439718484, -7.640891412089118, 3.4081464646704287, -6.688276173077994},
    {5.793648461227478, -5.367918862089074, -5.793231206693424, 2.1796278540557625, -6.219809224593428, 1.465126543226063, 3.116575648712007, -6.0731280566765, 5.6289814589088625, 4.8948244183237835, 4.0914267018519785, -6.504037707211313, 3.5941789939100675, -5.853539263846943, 3.4512130238163303, -6.431078850710025},
    {6.8074889907829474, -4.351867582050929, -5.434876432928982, 2.106738069863155, -6.352395456365378, 0.9237477972281076, 2.2467984644501633, -5.368226768903614, 6.637954256400368, 4.672808785497785, 5.288129757925491, -6.877993324837898, 4.369572192162649, -5.709603323743641, 4.96905923360848, -6.630797212793407},
    {5.985846275121644, -4.225270384859002, -6.239976422986922, 3.182508582237154, -4.796541245075069, 1.045938856882148, 4.132240808885874, -3.4227314513169143, 4.962244294006809, 5.658766758929006, 4.37453534385, -6.44419725270537, 4.115996176383815, -5.633276485195384, 6.21603442111784, -6.869699789292428},
    {5.921924007620298, -4.103189015657333, -6.8573270565960085, 2.2779603406588493, -4.7998614974408, 1.4587232008534325, 3.151868873582956, -5.696129829382411, 6.204069246797706, 4.636208003769425, 4.807041660673315, -6.346867410358483, 3.784030284561983, -7.213885968269651, 4.827202873120537, -6.307443330929189},
    {4.905569339994941, -3.6079228639790117, -6.4788539183642015, 1.8001245068842486, -6.147580371104938, 1.4236643602921255, 1.402678383583222, -5.893999687227582, 4.138878412185135, 5.464697523838637, 3.638298346226038, -6.6505893908628835, 2.7562875931833877, -6.720987182643794, 4.246592726664937, -5.224646156236753},
    {5.14760743830458, -4.827560167641676, -7.069312670444997, 1.6881085281981447, -6.0145107512599845, 0.6919323442439249, 1.6127463445599657, -6.007025632397441, 5.457622057470909, 4.4369935399951235, 3.6238342981306397, -6.138599420011376, 4.223466210278433, -6.644372355093415, 3.6208419961033673, -6.839559747253841},
    {4.826519464147237, -4.850266777107686, -5.329023709447248, 3.419571677138669, -5.5220503892703645, 0.5014955334950608, 2.941849098032211, -4.600428793801836, 5.379257431211508, 5.744480632324004, 4.626927974316977, -6.636200106461756, 3.4614909701441157, -6.2012068442382215, 3.942230321088243, -6.890884950819011},
    {5.901081141923949, -4.566409570494545, -6.372779295157292, 2.821005337625062, -7.2443309834416, 0.7167518359906245, 1.6295046878815014, -6.376402782334509, 4.47637846678201, 4.519694685220295, 5.309822155963044, -6.114154403945394, 4.519793506349648, -6.0690944273190786, 4.997699299837278, -6.989004454451902},
    {5.817806820343567, -4.564321676187445, -6.074496084550315, 1.4080813783952755, -6.098775012913221, 0.2098666645577755, 2.0902206156951926, -6.4179473466591705, 4.822082573568683, 5.066224289542692, 4.215030277184197, -6.656567630430915, 4.4815460122649124, -6.194976506485361, 3.3971067846580265, -7.2130821374292955},
    {4.880945453330984, -4.313899126483416, -5.695601860856202, 2.8011892139600425, -5.44609713384989, -0.2160934947631463, 1.1205115359949023, -5.203876253372644, 4.137999896151714, 4.630567638293172, 4.66826124815563, -6.3488798135677085, 4.116926884198351, -5.444301902386006, 4.113670622205652, -6.172348410572283},
    {1.0117650937319376, -2.706697963121126, -0.9830390900607895, -2.7635100804793535, -1.1945867839127469, -0.8921671057483438, -1.223123410110972, -2.452918728682969, -1.2527709846405908, -1.3258847482735099, -0.4376471887643853, -1.2896684280079378, -1.1690784843274915, -0.911797850486779, -2.808706891286058, -0.4732010667051809},
    {2.8037317800001835, -1.3415082323745506, -4.25742010361138, 3.456154013791933, -3.645005650286513, 1.9250074717715058, 1.4389131312784078, -2.98017980364921, 2.13438343087263, 2.7061533798784447, 3.2517341729153726, -3.2252470125395005, 3.703183586178618, -5.038351021432527, 2.7853278931752437, -4.803051224339924},
    {-0.9692831905538187, -4.443877480826675, -5.526587045757996, -3.1047170162453526, -4.0837476224934655, -0.3151072513467457, -1.1872515051043098, -3.149976076415614, -1.5656493701086192, -0.7940448145101346, -0.5893240721167896, -2.600349208043233, -1.6334049652177416, -3.798782942205848, -2.033193682514442, -2.907874846415669},
    {-0.16763921773510185, -2.2497331733890396, -2.4071774285518286, -0.7591495354875896, -1.903964794313981, 1.6872132277059744, 0.3684072646618273, -2.1810738365867404, -0.015448056131268997, 0.542475486773395, -0.16094616451056035, -1.981888703481844, 0.2607647241323005, -1.8315994961949262, -1.9479390868649387, -3.1264574272980874},
    {1.3168527662871459, -2.2552672745284554, -4.045847771692423, 0.9253862346685058, -2.692115439266446, 2.206248897322225, 0.11970354328544147, -3.3291939603534266, 0.8979779766861001, 0.9433666238454205, 0.6940903306488636, -3.103619122422242, 1.2272291870226437, -4.168385835534696, 1.432240972467704, -4.0961177627098175},
    {1.5001236310591568, -2.4436651404679677, -3.8403723964528336, 1.4855081940681027, -3.648891634264315, 1.2952242105806377, 0.7199006230737965, -3.51514546074562, 0.7162262466963691, 0.785413065526817, 1.3898840727806738, -1.833138021354502, 0.5825077904468313, -2.4893297413929103, -0.04950647565197061, -2.4187609919088384},
    {2.0456890174502558, -2.59700337062254, -3.2357479482748364, -0.47834114835305164, -3.1049118687461843, 1.1358465448024622, 0.4146356515914989, -2.8834349874544327, 1.750666744216822, 0.17074746948953265, 1.0296614548695735, -2.4173661811306135, 0.5787818185034357, -2.4745372902204488, 0.7484020066588396, -1.609098844802287},
    {0.5892665158489915, -1.8854045421753847, -4.015784220442818, 0.022667275385940468, -1.9373985730765209, 0.5472234529523684, 1.9013863194476663, -1.7240540628951049, -0.044264844637948664, 1.1812143277831504, 0.43084629772742966, -2.2828605292376634, -0.3264024614089993, -2.679855933766259, 0.7853870721347859, -1.3750744642111545},
    {1.8606752602865273, -3.670532187212641, -5.166480681564117, 0.5999339866942696, -4.0437454424653145, 2.0654398954685615, 0.47383167796425524, -3.793505108244942, 0.3189936088177984, 0.33702853691330364, 2.1473973487197657, -3.139566474564095, 0.9056516737471477, -3.6910766040838, -0.3968136580823638, -3.185322490495515},
    {1.6499938654782647, -3.6674217247929266, -3.587145984447452, -0.3475036872221521, -3.1322110011242845, 0.5623046401714649, 0.35236331738069704, -3.042910215847711, 1.697555741578347, 1.4076977992205282, 1.4520818573886216, -2.6136918811637115, 1.373304767599466, -3.075865027152149, 1.216262694111973, -3.4497012118044337},
    {0.004143532310842228, -1.5837835757018799, -3.101890331629024, 0.10670988623311384, -2.550595359539943, 0.6250580671338768, 0.7400977528370125, -2.4070415007818204, 0.8270038670334896, -0.11814988781294584, 0.3432044404488019, -2.8690612869413137, -0.06370084690615754, -3.237708849859099, 0.05300727386050524, -1.9067059296699782},
    {-0.1846815993146434, -2.627975682509081, -3.7626975128419757, 0.7607985522813788, -2.7994804092272005, -0.21021203541645725, -0.5553028843454606, -2.2023625774910904, 0.20287078541099027, 0.05270731620306326, 1.2860252462014878, -1.7772616639078873, 1.2209449955713887, -3.0339497579427324, 0.8181764347139849, -1.9605165610204036},
    {-0.2536846213550732, -3.95488952546383, -3.9273787886778764, -1.279181822992942, -4.583362475353467, 0.5696253709969724, -0.4772192355024415, -2.8785066509251167, 0.32640745727404513, 0.21283465371671278, 0.23578798324307038, -3.7081210808536076, 0.27980217473950547, -3.3243059612338497, -0.32994211840240906, -3.2869676463520627},
    {1.1418817380004478, -4.74331167837399, -4.9585246227531306, -1.194344583613674, -3.509526905562214, 0.1326926536813173, -0.3466133818846001, -3.8462541656043285, 0.7185624229466608, 0.033432616413019076, 0.1431157082446019, -3.229306477329174, 1.0736018381680603, -3.4561229622703276, -0.7326570096932669, -4.702725497297234},
    {0.8937561648355413, -5.1811527561415875, -4.78030956908496, 0.45335439147841866, -4.593228391212069, 0.9462446363858029, 0.7571488555008142, -4.237522076798201, 0.07960103571761035, 0.6645729987512209, 1.2895011293486602, -2.3531010471147202, 2.1762645207500735, -3.6622551550863602, 0.11792833347763025, -2.879513495195968},
    {1.9546600684829118, -2.5455396179480894, -4.336676700129016, 0.5450242455109628, -3.93265901747642, 2.1328363713934504, 0.26026705521100735, -2.905669070410251, -0.4034691655885957, 0.9690326528470657, 1.2896044115832006, -2.6536202319108964, 0.9048903754568854, -3.5433380062571294, 1.8387189421758283, -2.350468933890549},
    {-0.24599612579729513, -2.565059140636445, -3.3226641053881907, -0.01590750930580613, -2.184143002450211, 2.110814402201792, 1.392036654787919, -2.7068594036838776, 0.4903713173487431, 0.1172010822019439, 1.8390331217946405, -2.7659717380834743, 1.2641249340389096, -3.4720829363730994, 1.8321382336499947, -1.722659958868634},
    {1.2134495646925225, -4.314356904009948, -3.451227501658013, 0.17890812812907292, -3.409591604356743, 0.8518965517181396, 1.439275271967994, -3.7783057420562978, 1.1339463619841088, 1.7409066653343104, 0.8068505316862471, -4.3998468479134365, 1.290865665447609, -4.430987549177106, 0.5657445793634098, -4.458386279173149},
    {-1.2070537135395185, -4.865309072728133, -4.7916644928482865, 0.009402822708051574, -3.6682063884400833, 0.393853299397575, -0.8234443701301577, -4.263903572098535, -0.2693686061007069, 0.0024759926119608837, 0.007062381102376575, -3.1981755689553553, 0.20542931434281453, -3.55405708957933, -0.7348662038645937, -3.3014136260460627},
    {-0.039896387940421524, -4.533867465004615, -4.289332025835407, -0.24217393687470687, -4.304636720166174, 0.7609915166153265, 0.1269537740407963, -2.915017702792132, 0.6245239296756846, 0.44651302473382404, 0.9832896473264803, -3.174366464435306, 0.4610551809723861, -3.172289542066612, 0.030986010430595807, -3.593579188971365},
    {1.4473352888397015, -3.5385414812290477, -4.603040249155883, 0.15289865928270932, -4.785167630626936, 2.264828689780053, 1.2301452530787116, -4.457827902694046, 0.4630077450714955, -0.08748340199233137, 1.513072488632865, -3.629240712973171, 1.1297741571532272, -4.627276265749683, -0.6012637974187506, -3.8009699794572342},
    {3.504539890221249, -3.8773253018176512, -4.926781409054967, 1.1987755316262627, -6.263565299291214, 1.1816693481144427, 1.1157273068624356, -4.21181698028059, 1.6933397781683623, 2.0971386117315536, 3.4809459070018938, -4.491857422401137, 3.439493792442586, -4.183116330897048, 2.9776749704163206, -4.4839296846675785},
    {3.7503283753099663, -3.224494793197398, -3.7855624952340654, 1.7039626728714161, -5.282059559936556, 2.1192501205768415, 2.217641363294447, -3.6508396945211268, 1.7156335241783987, 2.1549031795600118, 3.4303699303666093, -1.6141369317248357, 3.3979734236205315, -3.5130171769071183, 4.421510537378152, -3.0323451477457004},
    {0.14688579936436652, -5.007844084755708, -4.6322532649908705, 1.1781671032330652, -3.860988992621337, 0.35890195583442264, 0.3567685304594992, -4.4242062191760185, 0.5575610550137454, -0.6350976136349399, 2.1638098166031208, -2.0884355884902246, 1.8595197756838564, -2.894562741948063, 2.024941714680431, -3.5349743129918823},
    {-0.10810380161493972, -5.913969654020629, -4.57260534084478, 0.08557902518571858, -5.566555216877753, 1.3547889223372267, 0.5022164448684667, -5.138673053527888, -0.41572210737144166, 1.4141450513164584, 1.1832162300188793, -2.9806255255271075, 1.1529642522375705, -3.422295330856572, 1.0152265694296125, -5.194306409337707},
    {0.1732618590363648, -6.117222628239959, -5.656132926624442, 0.44353527889946276, -5.125006839393733, 1.364255602198204, -0.5208511584979469, -5.198368546795783, -0.9342793217350877, 0.5635341064287587, 1.342172744830234, -2.604221879040492, 1.047843380468403, -4.470303206818656, 0.04074614301837082, -5.170247681718343},
    {2.1477661331259292, -5.342101792912599, -4.424151577547483, -0.096919002112232, -5.132640366570466, 1.3778532314142031, 0.7572487000294689, -5.7849895016932456, 0.7787216266643476, 1.503480904312982, 2.4403118556501324, -3.886806108348664, 2.602861442670122, -5.177627284029092, 2.0641424745905343, -5.233217023049652},
    {1.3459615179013074, -4.791253853072646, -5.477283288810335, -0.6268218061510806, -6.643014336768226, 1.3346011173316077, 1.3588946361455678, -4.387204396302275, -0.17003952904781, 1.6851159915757183, 0.5617717010360321, -3.867800148175323, 1.570109532657758, -4.119235733874718, 0.3921107967590751, -5.757463014625432},
    {2.1694866254608622, -6.270128472358741, -5.368055488014587, -0.8134484681400987, -5.754291125741466, 0.36987133307848796, 1.1185805800353559, -4.401175862402611, 0.8694815653330188, 0.4254930956716479, 1.244037975536026, -2.938222971739697, 0.9485865179781482, -3.912968109926987, 1.3360312750738823, -5.131240091016269},
    {2.2853048291091334, -4.868730840362673, -1.3643116010249101, 1.0880846066762055, -4.263182090675759, 0.6515638375601484, 1.6233481816029292, -3.4576778254825293, 0.9264132463384745, 2.171813115342728, 2.4272070395780663, -0.6041847380884466, 2.8626615064588155, -2.6807918173462744, 2.6946173466792374, -2.209622977942557},
    {0.6519990935418368, -1.2814048716484066, 0.5193970992263033, 3.932673211404731, -1.4988823438355057, -3.8614595562131413, -4.282199670722126, -1.010445378965151, -1.428820388707844, -1.340261501299392, 1.3592574835555291, 0.003175911575079726, 1.248980861818699, -1.1271163832377569, -1.7177405799573013, -1.2958242093178052},
    {1.4839069946358154, 1.309147154449269, 0.8257101299831028, 3.3723809735917376, 1.571415154196491, -1.1766669014626434, -1.25014345358042, 0.009242174900527273, -1.0475167294650518, -0.6137522683776728, 1.681979057170763, 0.20591915929421126, 1.6492072925459738, 0.6056824031535988, -0.08080257351316585, 1.783968132074853},
    {0.3459014149792305, 1.4729813855272538, 0.4975157863426341, 3.449146180554104, 0.22444927320062066, -3.0397050014032145, -2.467242527224041, 1.0470961669733365, -1.6868296900740232, -1.1842945288953677, 1.6676246154270822, -0.11611147951513612, 1.4516716234116045, 0.7120809504795698, -0.7915988903968793, 0.05108673380600417},
    {1.7491811573315086, 1.018196716481022, 1.1326976053266222, 3.2012733523882906, 0.9760280413675907, -1.9005512188807607, -2.346158298770675, 0.6169698260986918, -0.5085989267094648, -0.9673205867044975, 2.113872201097433, 0.037202941524194705, 1.512049190167681, 0.2734438726348206, -0.31410387371967313, 1.4846159214706025},
    {0.8169902596714267, 2.319953001140745, 2.0332832372271623, 4.104152269894264, 1.7098778719343322, -1.0916677524880931, -1.683397238592464, 1.4814911660761478, 0.24224158595798526, 0.37475752987807665, 1.3134531368550004, 1.1041246587495164, 2.4022464739355454, 0.9906867633169671, -0.4366636495019205, 1.417348003393037},
    {0.6438643062958357, 0.35764458202009664, 2.000119576128536, 3.2347603896740287, 0.11969152092273079, -4.060205173328256, -3.4501658420727304, 1.0133759503929536, 0.18497842931855626, -0.31385671617218014, 1.6402615517485228, 0.6856161447218673, 1.3048553472318505, 0.43778733738824205, -0.7821150408293858, 0.7345017051211737},
    {-0.05931998558097264, 0.4017016984238449, 2.2506790040598554, 3.6393943361531416, 0.18955187438380414, -3.1480196053464606, -3.8232268734997414, -0.3701992071658558, -1.1336869626856503, -2.960716393424647, 2.586444095037825, 0.2805331780073505, 1.4076811004354772, 0.8665054651789896, -0.2938144103583675, 0.7530652901158742},
    {-0.8953005933766381, 1.4457551113583968, 2.452726418934399, 3.8803835614724216, 0.5233946745771653, -2.5987845761826427, -2.2608815926814407, 0.36076604010705615, -2.5337880598511844, -3.1781182820203107, 1.0019513616597748, 0.4815754558184213, 2.235009660458314, 1.8280695698160938, -1.0563648150262248, 0.9211129137026},
    {-1.6787741885683907, 2.077927411509594, 1.8139887985321304, 3.894418689216745, 1.4707185453910878, -3.5425828756157585, -2.5740320491918145, 1.8594304838325189, -2.242788036540479, -1.8416262564809, 0.8516699184850277, 2.0596246916709138, 2.091196594159221, 1.6595789352780224, -0.7597581331686488, 1.9289690339876078},
    {0.014315711200321164, 0.9483029061719473, 1.4918641896623772, 2.6847614804299362, 0.5031449770293708, -2.0837710929489623, -3.516807108466382, -0.19787969406169298, -2.028323079079775, -2.21034619890439, 1.5878480649662345, 0.8536644267655291, 1.8752436214250092, 1.251513825901055, -1.135107289121816, 1.3183485833861617},
    {0.7019288968298922, -0.1406060466464894, 0.14053327699039506, 3.404759243804616, -0.77123066866796, -2.4348178720639964, -3.728504052203783, -0.013193120807286886, -2.325869815926967, -1.152677751426312, 2.492393398644215, -0.5707888247386098, 1.7025104053485234, -1.1736136017224255, -0.9556572477150437, -0.8342793861650062},
    {1.3287548796828024, 0.839480088349736, 2.3559428979002965, 4.973113198313469, -0.47373095578657537, -3.828444284210212, -4.505894572791102, -0.35101801868574295, -2.365202211864131, -2.5504470602698643, 2.9130027628441195, -0.20563947362415247, 2.7069783693194234, 1.7639024869233015, -0.5769037320587085, -0.11415424775409262},
    {-0.27080867367165934, 0.32460744470374664, 3.4632068808204086, 5.178522237551592, 0.08656134815449538, -3.9702238923441175, -3.9779316355730363, 1.1690881828004183, -1.4047946507974245, -1.9254558158133677, 2.426722814254211, 0.9357341031461853, 4.142783693681438, 1.9743638944026607, -0.6390391444657728, 0.3134823857357684},
    {-0.14563892284745755, 0.6150041939764052, 1.9311560281787077, 5.221086127968905, -0.6938570782003626, -2.95906059786975, -4.403463823335474, 0.31154619083030677, -2.5881790755640033, -1.5526700086701049, 2.776808768300261, 0.8540508547762653, 3.9169942494184085, 1.6590719099919864, -0.4692130770607847, -0.11218997723134885},
    {-0.3548176162823391, 0.21499417343470748, 1.3145885355218236, 4.189404762297334, 0.7260644437919987, -4.197064279976683, -4.453399794687127, 0.4331106475986169, -3.1882129808687916, -3.514165549074798, 2.232455097621549, 0.20826280320340593, 3.6572774893399718, 0.11584447243647233, -2.3304393872740756, 0.09486987020061664},
    {-0.19753410778468752, 0.38247678395862117, 1.0732606740646113, 4.954641470574237, -0.06747175428023193, -4.212321103751967, -4.502485701865855, 0.014117038530091212, -1.7704676485171746, -2.6038492719569146, 2.7009048350407863, 0.5171198684346373, 3.968622624683867, 0.09943035155962994, -1.2627816487279402, -0.5552641072712176},
    {1.0014011304599122, 0.2434162105373056, 2.6925717248074306, 4.609445165763811, -0.40021077708597924, -3.151806679160387, -4.021575028447348, 0.12232817523233125, -1.5880913095224305, -2.224804626280042, 2.8580752017706503, 0.2705228815022694, 2.9466701851510666, 0.1650636016257718, -0.03935441178254351, 0.316002558954449},
    {0.7515422156285947, 0.5356289570217224, 2.6507911942504023, 5.8250517568178, -0.3482358665775629, -4.497680540485489, -3.667028245992979, -0.3008387457736798, -2.975165958792809, -3.1632846832692114, 3.8133430295072794, -0.3723363439926365, 4.298521842501035, 0.6831174301181139, -0.7111367907189591, -0.9121986402597112},
    {-0.3394074886529131, 0.3696771376596499, 1.229677663838331, 3.7344976731085375, -0.8614437937397635, -4.766766839184341, -5.195532366291711, -0.04337293969184193, -3.660304304100801, -4.0642039081444254, 2.7307861932140267, 0.0480215867019585, 2.751978444270129, 0.9721892187618325, -1.5214712055512405, 0.17394157883376715},
    {-0.0715995294918835, -0.6186318402977188, 1.4273895347799146, 5.551459809731604, -0.9018338621133006, -3.8697856690202665, -4.5405513050262485, -0.3200151020822427, -1.9816164471755562, -3.645391802775662, 2.3514396144091956, 0.8791064340043016, 3.0392291365843107, -0.02205624902073155, -1.9141238477404574, -0.6119684821425089},
    {0.5748443393965105, 0.7132721332362116, 1.6290210487730674, 5.605634641659786, -0.9804360996511992, -3.363010050568444, -3.0710989799031148, -0.8038047578147118, -2.842384583880006, -3.0596805111019307, 2.457124935977655, -0.470919987873622, 2.544345577051979, 0.8556696125726353, 0.45669795138120217, -0.06728677425157291},
    {-0.7567715573718621, 0.5919682229089367, 0.9843169139184067, 4.748269900053539, -0.9705200629803021, -4.090673189514041, -3.4825113512298, 0.6885599291548442, -3.277169837370276, -3.795693328253644, 3.0140784709105906, 1.1417862891248882, 3.8822935130582947, 1.2840636717345657, -0.379580712083575, -0.23732794856378142},
    {-0.8757171725830788, -0.4803002329205676, 2.9646071850552262, 5.476253490469759, -0.8352951415386997, -4.490503696538003, -3.568658316432145, -0.41404223114865535, -2.663911958078718, -2.9577724723755847, 1.7860668645560869, 1.6835726101205202, 2.8232307669606325, 1.9793431193628868, -0.8624244981672985, 0.5703560831951466},
    {0.26285538551980064, -0.10341996833707703, 2.5636778701226635, 5.504059002690831, -0.36539145875431844, -3.541820700471046, -3.117444599277117, -0.9787465666518331, -3.415371182500993, -4.081186536438992, 1.6339556808148492, 0.16880531652173797, 3.2618105388747676, 0.7394389856592402, -1.5041866849518808, 0.39167670226617846},
    {-0.7437499348185478, 0.4440731594798994, 2.569608453695742, 4.599752567646418, 0.05006312885196454, -3.9468230245091473, -4.9687869710403625, 0.17650832461599295, -2.0325598140836334, -1.7801136976047933, 2.2509368925639954, -0.40646663676207173, 4.150017560495608, 1.6081615415379098, -1.8746569886571824, 0.6070038988197076},
    {-0.20964866217123393, -0.6614346169486314, 1.631356533944242, 5.19217210366672, -1.8460120725574307, -4.665602504498472, -5.327232317375615, -0.9392849321543373, -3.59457223363509, -3.376430183541911, 2.4858846400487695, -0.7313586268241369, 2.4827706254750614, -0.6101348369729847, -1.8136559425685912, -1.6723463107151617},
    {-0.5897830189317451, -0.1905565065020373, 1.7912259551023508, 3.921627165529274, -0.7901093808672927, -4.434838431936849, -3.9057643241870266, -0.7758390470145333, -2.480091595453281, -3.903239813436267, 2.746698881726265, 0.3340817869887425, 3.4973436785101777, 0.2915998324036289, -1.2778815771345682, -1.3864250839106167},
    {-0.2921654051591992, 0.3576914302415311, 1.8919936967286326, 5.216110279015811, -0.951271724186283, -4.186773506347404, -3.967533862969174, -0.2153738836797777, -2.015117165625765, -2.9954813863893364, 2.6047237490972965, -0.22538909842428279, 2.928658051918391, 0.575618052721834, -1.6452401122161069, -0.9048639665926316},
    {0.11253354132697226, -1.2779247851114568, 1.1616703336505732, 4.870256703859151, -1.330475902532802, -3.873624786907842, -4.148078142835558, -0.5309656302256147, -2.158452161886802, -4.132141552210538, 3.686719204042538, -0.768572845706223, 4.190444489888634, 0.5984188442579079, -0.19955325675734967, -1.7145637901395345},
    {-0.07033579880502294, 0.17490524638796726, 1.2826195883125637, 3.691476302989984, -1.0960098044058317, -4.885342922808942, -4.940649894984796, -0.17077233148886947, -3.1733131597592337, -3.4117802042906438, 2.5404717824079444, -0.48343665646262196, 3.4380000985561887, 0.4188922530293897, -1.316555399530666, -0.8646391825687755},
    {-1.508370886748442, -0.7854142608536726, 0.5483745557941323, -1.4443803555409107, 0.6700983659882784, -1.6101845841096831, 0.38037355253014543, 0.61367792581817, -1.2725066455518856, -2.663856997916667, -1.613249912746399, 2.215501279174537, 0.38669556440171676, 1.1627092552413247, -2.4599753864759606, 1.440480561088962},
    {2.077682825261839, -4.798544885586876, -4.795709333948069, 1.0620713700520368, -2.4618120198736624, 0.08206043412442537, -0.5985466224789063, -3.094702595526148, 1.500439002710897, 0.5034464229251457, 1.3657178488551744, -3.7356006281357663, 1.1570779002445175, -3.834515767627959, -0.2763552394919647, -3.5035212811597183},
    {-1.2464166970845718, -2.9074904761668203, -3.7013083834222344, -2.910350389886812, -2.296143163897845, 0.6879776306600869, 1.0419245724943775, -3.4616158181372585, -0.8697785986747925, -0.47045338039175055, -0.2514324644787172, -1.7057873086032387, -0.4019391540953166, -2.6029662225996244, -2.4233473956817644, -1.1832013761932945},
    {-0.9647223834553146, -1.7601100631780617, -1.873827689617085, -0.7497511602889794, -0.6201819074661152, 0.9631033630425947, 1.160338447920486, -0.33123187289885503, -0.36547482835315775, 0.26946070371656866, 0.15310957175066447, -0.8619278569034666, -0.46724093860393956, -1.067372665922212, -0.3216630528732641, -0.3141062859358531},
    {1.3419870246176349, -2.2650308355732856, -1.585736336021518, -0.5090011078936609, -2.416204088934059, 1.6109290984292024, 1.3007739040575554, -1.022321274979242, 0.3194597982368852, 0.033478405071451264, 1.3857143903596512, -1.7580899880347816, 1.37400982858439, -1.7907591319273715, 0.07413341118392919, -1.3051125319367394},
    {1.7685967402366904, -2.127642988745915, -1.4003929273700837, 0.14988701738005097, -1.089511506659856, 0.8132542434726412, 1.6123899653910339, -0.6872837712134631, 0.4138384226201644, 0.7397950960739604, 1.5931615067970692, -1.2048708996151791, 1.8280922182464525, -0.8695461061316818, 0.7964990970040742, -1.1930910906631154},
    {0.9162283205047316, -0.06604818534193645, -1.6524754353990116, 0.6266877783808054, -0.4842709882060616, 0.7230053507645645, 1.5344614853079002, -1.4530247647319765, 2.0567318564137635, 1.8843926360941972, 0.38626558516841597, -1.108675416668002, 0.6194047892937194, -0.6105057064241297, 0.8719479397333418, -0.13877581433514805},
    {0.28982931890846314, -0.7315836338320186, -1.910825324226809, -0.5127618848761708, 0.1238555118287112, 1.858669659355279, 1.8005592213397603, -0.04475689621331991, 0.1422444462274154, 1.669708006822891, 1.2411435173916952, -0.48128586746413277, 0.7305385451885514, -0.4140251841723944, 1.7310925071275884, -0.7148920656128458},
    {1.295554283925461, -1.307191425233809, -1.3933388113535807, 1.3933179480937958, -2.17806972827167, 0.6831977482051749, 1.1055441141628815, -0.9671914911278017, 0.34062847883964564, -0.45035568273568855, 1.0188399464806408, -1.20189481533697, 1.2718170488284886, -1.3867666307346234, 0.20516112820670918, -1.9626254419460198},
    {1.5007383125632017, -2.033463983717365, -2.898994778773106, 0.49343874976545654, -1.6584143505989049, 0.8554167535697536, -0.23601655426808885, -2.3287954787774043, 0.3889082820907165, 1.1674949546136373, 0.3379469481144259, -0.738815238313271, 0.8869976557305016, -2.763152200532378, -0.7878111378112351, -1.3842693033803635},
    {0.12814845175256429, -0.6586129646951921, -1.971842820993932, -1.3072152987032197, -1.5949539090931093, 1.1830626801324515, 1.35176084980819, -0.6558895368350547, 0.4903064481021246, -0.4004078066839998, 0.8492658987647856, -0.5596992102065828, 0.3220974593998684, -0.13967903824022904, -0.5563270174478417, -1.3109932250666498},
    {0.7639221050107613, -1.0696373273203048, -2.170330072040931, -0.634289740890821, -1.8606186974552428, 1.649516908160226, 0.9946901010313755, -2.158090392756249, -0.9773952099359811, 0.17267988144366095, 0.5084260482645687, -1.0518901576509925, 0.1551313006671955, -1.5797696758385347, 0.64624649333445, -0.9971605893952006},
    {1.063968733418776, -1.001800282849898, -2.2794374557059744, -0.30975944550852674, -1.01982399582603, 0.8761392701086604, -0.25045741681939804, -1.954889272393169, 0.298006529096214, -0.9891553045808682, 1.1017166082009169, 0.38762070655971637, -0.13350704652841483, -1.1556721363440552, 0.2806600604810688, 0.49922550437990587},
    {1.0212842677753886, -1.2602488234500104, -1.880944903853127, -0.5910404866466006, -1.5820268308287786, 2.114731530892029, 1.5004603711663245, -1.3272788440516199, -0.8972115047671185, 0.03474199907509162, 0.9394620440726537, 0.09312475196326372, 0.08351379978084732, -0.616096198320717, 0.6706278154673252, -1.0294304639012433},
    {1.8552048557980487, -2.7158997892772243, -3.0050493316362354, 1.1655337732480078, -3.2768893244819837, 1.9191794860612024, 0.12213162463716046, -3.6056617176927914, 0.6810568459084008, 0.6933582586579097, 2.095630494511744, -1.7464352013795923, 1.5701820123659422, -2.878971173833368, 0.9138080774198624, -2.5912845648916716},
    {1.3879258678597963, -1.5422617328702772, -2.642996523580426, -0.49166620412665285, -1.3142005941591055, 0.4155389880696894, 1.9476106132773725, -1.0156670266706724, 0.5738250128056412, 1.0818546468852068, 0.9487121076147933, -0.39001544793109605, 2.111355659595827, -2.007561895003913, 2.3864157042524696, -1.869103312951673},
    {0.7181381562209433, 0.11427380659652714, -0.42488993838547634, 1.1536536980495196, -0.5955529802785625, 1.7966194851406605, 2.108821453613643, 0.44766464178258286, -0.548896499991931, 0.7091571306640059, 1.979897899473475, -0.3828700012286622, 1.8072799841552505, 0.5323371165829054, 2.138849861711582, -0.1611856789723151},
    {0.3279166283793667, -3.8529553259515628, -3.443354398527045, -0.5903177688483804, -2.6615837919424536, 0.9561000831343061, 0.1586255368196867, -2.9298438650831913, 0.04978376220481274, -0.46391608260267264, 0.050773266742055546, -0.7702543553868928, -0.07729911882175322, -2.108539212133189, 1.7785678367989992, -2.0293352448148414},
    {-0.5054248292224806, -4.208779100760357, -3.5653416630830885, 0.5148525761466701, -3.2600786190677713, 0.9341132738581732, -0.19289623233690248, -3.53069790963334, -0.04684981122356746, -0.9417889277952082, 0.3879739752085446, -1.2195437747641709, 0.3520707902297498, -3.00608885651154, 1.4342993411626914, -1.1667224402438832},
    {1.2923205705524277, -1.6353619690209888, -2.1013147003558923, 1.3432845343425563, -2.024536646912826, 1.377208809503901, 1.1055532248435482, -1.3086172034869257, -0.8833009072154079, 0.7153173254467977, 1.1809984295851323, 1.8076002493005947, 0.496098761349173, 0.07107738992227917, 0.14618923434035005, 0.785913804400899},
    {1.2920209305529722, -0.973570694818477, -1.3797889038831053, 1.9188614024963977, -1.8928428972600015, 2.254530894735907, 1.5017445984159803, -1.4459889178033039, -0.0236403576147879, -0.8201680432412738, 1.918605059251897, 1.1372685192172312, 2.1690888135590836, -1.0917875550519602, 1.1392147224858664, -0.5022573676593407},
    {0.3414571635393093, -3.8480497696637985, -1.6915984896865786, 1.012648685309372, -2.7833525375560746, 1.9269896668431044, 2.0139169374814325, -2.5730351812151233, -0.2290231366712933, 0.4904033804122156, 1.1086321952814002, -0.7033786055097534, 2.481318307697387, -1.809947554823686, 2.7461987007960755, -1.8929548165978913},
    {1.4284876089433685, -3.123841198161365, 0.30132335058086035, 2.1400005485121505, -1.6178824815066168, 1.1878304247525702, 0.5921390240243515, -1.6620115891948948, 0.14497050793233818, -0.8396698846961134, 1.043088411270763, 2.1711246209448065, 2.7327920141455744, 0.004938841919438876, 2.1523214088203684, 0.8276305920087073},
    {-0.4458086591087259, -3.555483453783292, -2.2040388123797388, 0.3302332246720362, -1.809347402619205, 0.3573270285224686, 1.3532144380025533, -1.3211005553427158, -0.2823999390276785, -2.0211691281934328, 0.5627951197916707, 0.5067350661892664, 0.4885430594753087, -1.553326623403787, 1.7830067419481, -1.2345157237144366},
    {-0.24610349189565708, -3.6516785964436957, -3.4221371071792155, -0.2808776099535728, -4.0749703231899, 0.9815494573357458, 1.1703625699329403, -3.316670336287093, -1.4899110847797965, -1.1692851737318752, -0.5836710316351776, -0.8254515471438887, -0.1151382368011242, -2.965062536050666, 1.0902410806295504, -1.8139880968464783},
    {-0.5630863131812, -3.801862302005643, -1.5879166747814006, -0.07646967753088069, -4.458914555360859, 1.000272001555907, 0.09015119282537656, -2.1697840655158354, -0.4029156959250916, -1.0348650122643432, -0.959153853379021, -0.3627247724112562, 0.8268803766579587, -0.6613492861279735, 1.7180556376133864, -1.7447138677186327},
    {-0.7530131795594925, -5.22145961500753, -2.910790584814397, -1.5105460969562823, -4.5890441854426625, 0.8911262807596991, 0.19489465329946434, -4.370274729963239, 0.3353674471925086, 0.06057383459777574, 0.4464647108650476, -0.11422509006971172, 2.0900746492640883, -3.5554092300281632, 0.6857809887599864, -3.7666253101822615},
    {-0.04270321920481511, -3.644805247165983, -2.4639934749350294, -0.2577838695382125, -4.040633004826481, 0.025490423793207925, -0.6767063073666257, -2.3102275318449896, -1.8303439627139622, -0.18397013039559412, -0.07559105828733896, 0.3399813017508488, 1.735007091056851, -1.9954344890373537, 1.2984321356067863, -2.283729353767718},
    {0.3906295364478062, -5.086450546345354, -2.2775903286773107, -1.2325113643470016, -2.649756375103543, 0.04987422215396442, 0.8434180380243097, -3.1082039585218384, -0.1064478373150311, -1.6263057941275048, -0.14132678718648772, -0.09449296106147315, 0.5233890535569061, -2.1336557713882733, 1.2275924539173666, -1.6496024922890944},
    {0.2458529373321494, -1.9826505992517407, 0.2132980880647461, 0.2086874183231145, -0.8252517294978249, 2.5085851073401018, 0.8429739062147763, -0.460543057341331, -0.6856787774144454, -0.4477341444723999, 0.09962648923655384, 2.1061355791992633, 2.437556701214202, 0.7875908710286013, 3.195714025153708, -0.29661419808810596}
};

static const float b1[16] = {7.204775801566845, 7.248063893408291, 7.450613202075878, 7.3084029054836, 7.56204814036811, 5.4077346767947185, 6.857227857602584, 7.0064906483068725, 7.069349868143653, 7.088186945475528, 6.6531408215671295, 7.644291942344226, 6.754996097790938, 7.5476324904034415, 7.143714839237407, 7.465925012372436};

static const float w2[16][12] = {
    {-2.444494676081005, -3.306308513279158, -3.7281418413223704, -3.4731445320994534, -2.881219614792576, -4.161624854067151, -3.691772352871843, -4.0636560798264645, -3.2433562247380165, -2.989508312781107, -2.6180188413269976, -3.6010172404573595},
    {-4.0333385256973635, -5.571090851304518, -5.437381947343393, -3.695590942346832, -4.455297155643786, -4.293969589523257, -4.082173555170786, -3.847177670956932, -4.642891439489306, -3.5147226800761384, -5.237849307095455, -3.3458173871296215},
    {-4.8313969684818305, -4.635236129337147, -4.583321781440106, -4.389994222151472, -4.693582273334011, -3.637750547274713, -4.004880161089176, -4.880097182485346, -4.220610013644511, -4.847258333239465, -3.6991703300291188, -4.532839369002775},
    {-3.9238855029550948, -3.6757763205324405, -3.162183314137128, -4.237313239333927, -3.654551864148419, -3.972364879908915, -3.6665157294303437, -4.0341990891467265, -4.125339742058458, -3.7487959541355056, -4.389518107560835, -4.052299419905788},
    {-5.099724570694679, -5.2686426506163615, -3.5602560883853283, -3.712344805305659, -5.045433855169483, -5.308073419513263, -5.143286811203181, -4.8504378414820435, -5.401379108402256, -4.914362317896167, -4.320181909072617, -5.228951892650453},
    {-3.391448036313067, -2.814155560601285, -2.357683585066036, -2.513444250803655, -2.772890550796508, -2.4124413004068046, -3.2064087033762125, -3.2268965824954243, -2.8430478998485564, -2.080702735770461, -2.9058887513384684, -2.5361774880532315},
    {-2.619180218928512, -2.997141049992447, -3.8340117696822418, -3.3181081436821858, -3.1424933102867048, -2.6733471659056525, -3.1093135071822937, -3.0479326128152664, -3.031697640995473, -3.7361361354080516, -2.8264854202071548, -3.4629463619853507},
    {-3.421176328325977, -3.191333699669768, -3.5646561816000997, -5.739929642239819, -3.8746018702429033, -3.6751016575077164, -3.824153928284824, -4.757786729621933, -4.188392190979051, -4.448097428363847, -5.337657888549181, -4.238899234074171},
    {-3.866122654349629, -3.5199143598906897, -3.3148831686095246, -3.765632945684144, -4.24686572630858, -3.3003954039917627, -4.063980195142937, -2.7015175974630448, -3.532736839163323, -2.9137504205595097, -3.908785193875572, -3.570744145171423},
    {-3.823922793339074, -3.416122466190429, -3.2678422985123725, -3.7121377802105884, -3.039050577985439, -4.114146391127191, -2.494648065044161, -3.5237953181809063, -4.036427170103571, -3.634857414632462, -3.3533452247736544, -3.273323846971208},
    {-3.2672467578786595, -2.7644661415820337, -3.324027359080298, -3.1454114144234153, -4.188261072647295, -3.0101568234750786, -2.962221938956355, -2.3901539390215243, -3.6663853784072664, -3.333269089310071, -2.607846196493483, -2.8377689563290347},
    {-3.6006926697161017, -4.803357628719479, -5.158970112535158, -4.099826974380676, -5.125219784023097, -4.557432616205477, -4.8302100095879155, -3.741511915807764, -3.614831847032518, -4.723841909738229, -3.2078512847325165, -3.6314319320305724},
    {-3.6178250736404065, -3.837196385617145, -3.8085812767841136, -3.031520686128277, -2.8605373361796222, -3.050334266404759, -3.5287285260264603, -3.516891483799582, -2.761135476850111, -3.331742487657098, -3.609112889246691, -3.298934226757015},
    {-4.848544464504702, -3.6807308752095955, -4.260937368320126, -4.289709657654235, -4.281762906852054, -5.595604769377161, -5.486747711109806, -4.0995918162828175, -5.46391058397852, -3.5966835579142935, -4.724532878573078, -4.727601036681554},
    {-3.6049113613052493, -3.951610858447747, -3.588457607694984, -3.1007122509431446, -3.6098428053319838, -4.081171804192511, -3.5273885208134974, -4.080668442853577, -2.942262596589315, -4.460999691649996, -4.547329139833438, -3.5257726488983088},
    {-5.0501710672558255, -4.155464059934886, -4.927786254086604, -5.2140670587594125, -3.6906804055161393, -4.076657963359537, -3.984782266764606, -4.86851264658044, -3.849177445586733, -5.097482620161169, -4.878204787046704, -5.234552704052297}
};

static const float b2[12] = {-4.696511184851857, -4.29056708754999, -2.6360865495963726, -3.6542675297804847, -3.941711644084427, -3.7060529517036715, -3.8801764154221825, -4.290037118756867, -3.7230551732450237, -3.7892164331143277, -3.2842210604312294, -3.760756747083883};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
