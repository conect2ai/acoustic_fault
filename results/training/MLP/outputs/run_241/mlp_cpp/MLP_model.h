#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.23139315560469267, 0.1629931104312943, 1.7334937997424356, -0.19411262006812918, 1.6457267674950207, 4.67338709887929, 1.0972888657393283, 0.17721318193234215, 0.2758675392338055, 3.815554677478477, 1.8182405684704566, 0.9729731456469451, 0.11680025651560703, 0.7644920512432486, 2.7671316280556124, 1.5205396462785699},
    {-1.6483533842346603, -2.5593504217334253, -1.4488979176568615, -3.4377341385181865, -2.4376704974137637, 4.230470653916141, -0.9426968227247216, -0.3572899931493499, -1.848259097224159, 1.3083463450604083, 0.02085541172515814, -0.8389984699631974, -1.7848955446628423, -2.481716698767593, -0.4324923152142415, 0.6200755301731314},
    {-5.018253205967559, -4.337017421485714, -4.143483803711911, -5.896057286074571, -4.2671209139811985, 4.681775440892974, -3.154958562508047, -4.9971771217183365, -4.084067391838002, -1.8777162188889613, -4.0731705334912345, -2.8058003719328672, -4.741305801390656, -4.8989663551164195, -3.621020544035593, -0.5365260834990404},
    {-4.687759095537731, -2.9075106221114506, -1.5898902654852456, -6.01877755406474, -1.880466691915211, 5.38406090800994, -3.147476728209847, -3.962977869323458, -2.9246190169561235, -0.5459205113328375, -1.479853594616369, -2.5606641768809606, -3.4133332210693967, -3.610025255060688, -2.110799749156804, -0.2532878287827508},
    {-4.790860709777973, -3.9584959409422247, -2.3548022643269797, -6.120006248799105, -2.7801853826199183, 4.610169929868509, -4.664199913199938, -5.363925115307854, -2.933904441405986, -1.6531589122826926, -2.0461400304927895, -4.8113415838394475, -3.7848476592863505, -4.243467358620476, -3.30908840807463, -0.5798480993167692},
    {-4.140269992653823, -4.597698783386491, -2.808718368861861, -5.7678958862260306, -3.2841182882373983, 4.172878186179415, -4.277556432425055, -5.129568093357287, -3.0558192599802183, -2.2843739465363186, -2.64575979107051, -4.491112550551533, -3.942849364421879, -4.275970007024195, -3.5479998947264995, -0.529734711600713},
    {-3.5014349871574657, -4.454766135648956, -2.4399679880092737, -5.399828442570333, -3.4881887530397133, 3.9962244769813626, -3.8180650027522147, -4.656372547700561, -2.802051760052796, -2.1720820071521234, -2.8284589579334156, -3.957147438975992, -3.357598489380686, -4.055578324314534, -3.105596170997012, -0.07890085981386546},
    {-3.761262172201012, -3.2377033503873567, -1.8487540852665338, -5.755567359034866, -2.5648524944915216, 4.459624764481868, -4.303895183720405, -4.567846447566473, -2.214092683194893, -1.7889962646403792, -2.151424574391368, -3.531645824887301, -3.341277465382997, -3.5205673724191047, -2.0980605199762623, -0.8308693443591194},
    {-3.521582577240059, -1.8336373013756582, -0.9456619335290586, -5.5237125582712, -1.166423685521574, 4.430119802294033, -3.830438105279052, -4.004366458350278, -1.7235579773935017, -1.1093222823129074, -1.1130925432702996, -2.8991178807675793, -2.728955819603086, -2.900449824039654, -1.6530555962410174, -1.0254504663712383},
    {-3.5476258554454243, -2.800304330434167, -1.6245243494000736, -5.853964009250748, -1.8664011440401969, 4.970152448492143, -3.105464132121162, -3.893426495998849, -2.0770272601055972, -0.43673876077034424, -1.4323961953730424, -2.9445251807387733, -2.6725751549577015, -3.4544860424287913, -1.5657083737970492, -0.6517468079893618},
    {-3.8463310473496333, -2.609397085859069, -1.9447258362007902, -5.9406064170019945, -1.6729476720590062, 4.355040081202206, -2.810022520911958, -3.654540874137545, -1.873722705931779, -1.4024554678295535, -0.9010732465365063, -2.9155594237043747, -2.4241289573455713, -3.569941788143888, -1.936594593402118, -1.2809247019157326},
    {-4.198148825152074, -2.096793764337397, -1.8579908636368216, -5.394229396444678, -0.9530665102318671, 4.126401874098119, -2.7086872914942033, -3.9015468205747506, -2.1339591160173508, -2.1081000710426343, -1.7525703965806572, -1.9592475700322123, -2.70780920757497, -3.1962021709628097, -1.4277214774106866, -1.332779351038913},
    {-4.811549696296173, -2.9472719434782055, -3.221177364978443, -5.727712524423835, -2.4471405456090576, 3.7587011811539113, -3.4431316814859487, -4.742858005244562, -2.8350490594348936, -2.932539615841702, -2.6771330679674987, -2.212438092089033, -3.794463545886044, -4.046860511653135, -2.2936711077970915, -1.432629471869749},
    {-5.065288112170554, -3.6387324076901835, -3.1699225358796608, -5.729896882897974, -2.958953751360015, 3.5726514757723824, -3.8876566929317597, -5.081228752422616, -3.1495123642701026, -3.56072086192604, -3.7918108490771183, -2.3591311842452765, -4.046588344883754, -4.4358602835000145, -2.701278780106809, -1.8704919007525929},
    {-4.282832916735985, -3.502149480855827, -3.009997934394492, -5.5005874157278685, -3.11916533885535, 4.357471552954455, -3.9376438327688406, -5.086658227686908, -2.979256840172062, -3.234450999584396, -3.7425771322188064, -2.1110802978087633, -4.172681405537103, -4.339569098770819, -2.7492528438964072, -1.4183927445787057},
    {-4.717809364407342, -4.060950887801066, -3.358135232085557, -5.912999141230955, -3.712513473458808, 4.779299615247328, -3.990625400118298, -4.825565867784169, -3.404475356761775, -2.3630164784328325, -3.6714040344069216, -2.88499470206671, -3.981331539543031, -4.898465634540467, -3.4817857280945304, -1.2761654824056219},
    {-5.006304362595073, -3.97629106756762, -3.1815387140982914, -6.153627839012295, -3.2828458588435554, 5.190986597995714, -4.223376723242981, -4.883751541120964, -3.230912625395367, -2.58592012464697, -3.245837727067893, -2.94696609907997, -3.6916879393985353, -4.6057291288409345, -2.9843792603682613, -1.314118350114119},
    {-4.892400326104935, -3.7503424001468133, -3.329729867085706, -5.876876943029308, -3.2878321956435914, 5.372223272639561, -3.691191765275966, -5.16482614882628, -3.227771981634412, -2.826124209894262, -3.961838866234836, -2.207073950671109, -4.15754797103091, -4.325665300838466, -2.3381907428072735, -0.7873865398431568},
    {-4.832154982562854, -3.740822455649365, -2.9983235404493365, -5.597020334356545, -2.705178365771941, 5.6195833281059215, -3.0118570104689883, -4.888527482635587, -2.694475680532908, -2.6070666248539194, -3.7920698620600035, -1.6981515675720769, -3.9903003601169402, -4.375703105001424, -2.3247566774612882, -0.4751288653577899},
    {-4.7760132994740605, -3.362553636831606, -2.266132150834737, -5.5014598954867004, -2.1122315192005674, 5.721477718600981, -2.2077643854581677, -4.525137715363017, -2.4430803693472165, -2.3399610381314346, -2.9769114594612156, -1.3594716322466318, -3.7915385193292486, -3.9696956387987763, -2.1632936967319236, 0.5175470543703898},
    {-4.753526524245025, -3.3863272355774767, -2.2582211380530626, -5.9248307605618, -2.2495436848792667, 5.560562582245541, -2.6032823040969593, -4.161983628179328, -2.522965150885495, -1.9444103812012108, -2.8111259440818626, -1.5914559852412886, -3.6563062230345085, -4.098395161336182, -2.0963277490983585, 0.13910933935311157},
    {-4.793339377350554, -3.0469314317026086, -2.2066911991726723, -5.397172728849614, -2.6834220369444686, 5.5127202704028555, -2.6802669133262853, -3.973673780068656, -2.721159471754435, -1.6806159702799095, -2.7566795153337686, -1.8437224426645547, -3.5861472401455496, -4.060459495163893, -1.7093620133507064, -0.3522164750144991},
    {-4.491967645862885, -3.131424143804877, -2.264897164030119, -4.980700064518031, -2.385010654558621, 5.88283760144037, -2.1500546685176714, -3.7202905450919665, -2.492927115240081, -1.3050901508468895, -2.627975285788676, -1.1455556146929715, -3.3990376304046106, -3.5454335080963904, -0.8517564296497123, 0.1813164668747775},
    {-4.713704478519109, -3.098211211376825, -2.385165601900139, -5.599346325219697, -2.4729109379784022, 5.78613702404491, -2.8946710504556763, -3.6801868951266323, -2.4983971529817257, -1.4843526401666947, -2.9095386566687966, -1.883636007538283, -3.547053171609723, -4.035258665756976, -1.8340938605838621, -0.3101166649528376},
    {-4.073708123807014, -2.496196522187283, -1.8404756224119863, -5.4191788050804615, -2.240082132923515, 5.718229911519262, -2.3700781135440496, -2.714571719447813, -2.5830136191990456, -1.063881944270944, -2.151821783313382, -1.5437072424425802, -3.463893816628346, -3.4081633931664204, -1.8316533117580502, -0.024788735715410463},
    {-4.238804720357819, -2.40068036140414, -1.9702087342158061, -5.213281902465903, -1.8292845549038104, 6.043277933511018, -2.2284404618071494, -2.9489264951596894, -2.1043304981613256, -1.498320097054557, -2.036200624800194, -1.1070164039904336, -3.3862146706444967, -3.4866513772595953, -1.6552723970929117, 0.20822808038571164},
    {-4.619824785225592, -3.4239690126343083, -2.858455111203722, -5.600328422747508, -2.775016883912181, 5.8744365822268305, -2.5458901765959467, -3.8703968224258087, -2.9633653561277136, -1.8883946128858635, -2.8864749727636716, -1.4072908727813975, -3.7951203749588833, -4.143569496720033, -2.5849848189243487, -0.16260812876887715},
    {-4.811930121285292, -3.4907994415690426, -3.2156794273995124, -5.723854997316776, -3.226090257866077, 5.494125548764088, -2.6697390191800494, -3.8750282190834198, -3.0317213209987863, -2.187275308051405, -3.2530328367359482, -2.105751990862344, -3.839231465752467, -4.429497415827752, -2.6772510284499305, -0.10286149805917623},
    {-4.672420584735377, -3.9491190151684537, -3.066746944704023, -5.3621434005502016, -3.0432414104966994, 5.315458820178574, -2.650546256066638, -3.5686470286462875, -3.2217031063725288, -2.3673565148245372, -3.446127939145497, -1.62811205540919, -3.6368264397209975, -4.232113331407401, -2.5096176491330793, -0.31341428150060086},
    {-4.2482484162289476, -3.2664110056842977, -2.6747048806214333, -5.9078969540476125, -2.2608809027062904, 5.39363636448886, -2.096410121022681, -2.4831566813693557, -2.7386493824172877, -1.2734587633014378, -2.4895745657572164, -1.173789953602672, -3.4461017124981903, -3.9807964062334205, -1.8979089418480954, 0.2543032202449806},
    {-2.265615797854775, -0.7950346181129515, -3.17231010475257, -1.0716512401827234, -1.821839483932501, 1.0811301799133834, 1.547699641340305, -1.3580348137761609, -1.5674238508540987, -0.44798829954145025, -1.9469542868526342, -0.41961492744892603, -1.478792536728741, -1.4002262899410494, -2.103266455257097, 1.0357209731500416},
    {-2.3839371799941937, -2.959782392564315, -2.2686554264753873, -3.9606392517468434, -2.530714226482605, 1.8549435169143942, -1.419727769604352, -2.691447866177772, -2.656984162623726, -0.899362944694138, -1.7623881586661967, -2.2498405810692934, -3.3803693894743483, -2.99240470739759, -2.467189176382551, -1.2300276543873832},
    {-2.715503685533995, -2.1650349658673735, -2.244429067735254, -1.2776511213770052, -2.0282111381780594, 1.2145605049633899, -1.9778274984215667, -3.0053754803114527, -1.6894002842704052, -2.475480082817998, -2.7496518668508756, -1.2935055179113717, -2.6463953870507617, -1.9302100456668516, -2.6621579524665453, -0.15348857672073254},
    {-1.291048221577204, -1.0273794676556172, -0.6699794563884882, -1.7880936686843103, -0.5883460262396131, -0.694911547159974, -2.76769869829642, -0.8672702712635229, -0.8061981416971138, -0.9433976477719875, -0.6525274035397444, -2.408593461347808, -1.2384913470576513, -0.6517457142496969, -0.5206942501445605, -1.2007539603989679},
    {-3.293072348359161, -2.7285317456719134, -3.041338174704475, -3.315648020348315, -2.9638934861662487, 0.2515506149649126, -3.1303471713539177, -3.5865000697345213, -2.6501411854571404, -2.2833366042665504, -2.0705414349159907, -3.1627206347220858, -3.0468530290351485, -2.924333183420982, -2.6392705692432417, -0.3501886003051189},
    {-3.2474521930624185, -3.529203479087467, -3.499935905035979, -1.8743124690012383, -3.1217532606303986, 0.8232646539511278, -2.8440189096843933, -3.620871415605746, -3.119451776072084, -2.2460405340260405, -3.1366211390427177, -1.6592369122908153, -3.7027250116629262, -3.2194475989926414, -3.229774238722786, 0.6654524303717528},
    {-2.9192492836413195, -3.4326515009828342, -3.193487363332288, -3.061267362469516, -3.0259417197963745, 0.422402427176455, -2.999780184554864, -3.4441917625462053, -3.1157607362797903, -2.391132431794409, -2.681271096394291, -2.9782691679439273, -3.4366070634887254, -3.0037735037698483, -3.0836764788590405, -0.32598264713353253},
    {-3.2255779161635916, -3.0547618980973694, -3.4944354691029065, -2.8550245466122477, -3.5146542859626364, 0.2858142049886791, -2.6192779272416593, -3.4671274057187147, -4.042157352670454, -2.627396329978878, -3.362995475227481, -1.8850630351346598, -3.7968607948190543, -3.1679328562740503, -2.939818008457124, -0.8170153146612817},
    {-3.1313877183586953, -3.2441746075158346, -3.2740524698440034, -2.757377082580073, -3.335324496958748, 0.6019079549910413, -3.135516366465551, -4.2253350563521135, -3.3570541681840442, -2.398025001850352, -3.006251213341291, -2.734981554229469, -3.3399248870013096, -3.0074548839395367, -3.3030969404961925, -0.8860900897705468},
    {-4.187013144001755, -3.8155061763154015, -3.625523323035917, -3.1145128962286495, -3.7931612195455306, 1.231746418020365, -3.393370071439604, -4.366119612055691, -3.258201046824773, -2.5770710435485937, -3.429434027947424, -2.758726580281596, -4.188661009859912, -4.075249353564937, -3.6884266305148934, 0.021319568894807153},
    {-3.2947344852608755, -3.0366008205658104, -3.324725078781279, -2.4086283042898136, -3.3232937713130104, -0.43751017399673964, -2.6027194476385676, -3.112568794794851, -3.442634211752755, -3.021386113049528, -2.5810520346632466, -2.550914666086919, -3.2916809035658154, -3.206183456793663, -3.507522456975371, 0.29776900975030807},
    {-2.5964263864197576, -2.784694673631722, -2.6513457040865434, -2.2830634752507732, -2.8161192087484137, -0.33562274622913923, -3.0440392378814214, -3.353015696573312, -3.0016507465325772, -2.756009308183024, -2.9905335001941826, -2.4213521510962424, -2.8998307176558957, -2.4267009801286106, -2.9688999189280305, 0.12041074744565972},
    {-3.6564128788379775, -3.8233060669340206, -3.884935890777355, -2.5961588370456545, -3.676163647984095, 0.021763436313960258, -2.598623825628499, -4.092961042990895, -3.877910871224469, -2.957999153062738, -3.6901742433406715, -2.059578109804077, -4.063089544435926, -3.78811963803019, -3.8182603231016663, 0.301565868751686},
    {-2.729160124268883, -2.5198330246706595, -2.679240937121624, -2.271332065207287, -2.6864918068608254, 0.49335399769569527, -3.2396088065164705, -3.0695308813196847, -2.427977169332053, -2.138174979695223, -2.7765481804636063, -2.44951545220776, -2.8785432245376397, -2.427516071867712, -2.999050335104465, -0.17371331133656545},
    {-3.6473100644010303, -3.275319143557003, -3.0001108660470868, -2.6566215337092625, -3.128492222962191, 0.21894710559736796, -3.4561080823216126, -4.1480937622645975, -2.9720689162540026, -2.562844349130325, -2.750392437339153, -2.7897057665673706, -3.7345867339566188, -3.400384469941117, -2.923787314941672, -0.01542357747134949},
    {-3.017037688844277, -3.020878306541397, -2.8974069228241817, -2.579473820843881, -3.0066902708291363, -0.5641864693327068, -3.7798605399683787, -3.7979920127579443, -2.9486639948252122, -2.203885285800654, -2.885467477721721, -3.692721376204372, -3.0843486556318367, -2.600001780692295, -2.8361228462108437, -1.0874801465858457},
    {-2.9965369403081543, -3.2496967529054093, -3.494472576750809, -2.318731104582701, -3.44409250087047, 0.0845477597423532, -3.987829224998186, -4.101193105769971, -3.4834547485521337, -2.9845802945623543, -3.6362012768765446, -2.992524434115038, -3.565370893473585, -3.102259615391476, -3.3421670759221533, -0.8830089117515212},
    {-3.7944329081390964, -3.5112790530269393, -3.7404211988896403, -3.014761940569953, -3.7750621035232026, 0.19608206096620784, -4.009464106238423, -4.505699832556115, -3.255741344064647, -2.475070890438699, -4.1552989481074585, -2.7506945278412576, -4.069670541043489, -3.7587737816171556, -2.9091395307542465, -0.8699242037097208},
    {-3.727414831521469, -3.675987679810076, -3.8785771768163233, -1.8454025092615014, -4.072550708128896, -1.1098999033042063, -4.540929187409031, -4.756695205172641, -3.7825946541715183, -3.1202436962224227, -4.251902976605698, -3.686494931718766, -4.24339685750484, -3.57338621500294, -3.8123840552431356, -1.298976004700573},
    {-3.7252315554434374, -3.6749314342416306, -3.8789317638318876, -1.5921735949748164, -3.9965234727059746, 0.199923907106999, -4.025110755583303, -4.343087788608611, -3.771949078585122, -2.929344729062155, -4.042218413070043, -3.60190736736144, -4.234099951229652, -3.7214701028247075, -3.8283023533026856, -0.3063128915060119},
    {-3.509719759695656, -3.512989276907907, -3.027100863206242, -2.4147635649592862, -3.4149640568718533, 0.5621551931503891, -4.468917174177121, -3.392679438979323, -3.078651576990772, -2.7853339357548306, -2.8484383484984153, -4.398258277729306, -3.1942813747419714, -3.230620887390872, -3.3094726991939036, -0.7861068788170509},
    {-4.342702466081675, -4.542413246065681, -3.869406214599692, -3.854204504723931, -3.7067865212283055, 1.5537819021937973, -4.593995610006794, -5.072387616073858, -3.747027281020245, -2.49523989432006, -3.6464757297844184, -4.748689675496757, -4.359839750860309, -3.587657589357736, -3.680231020755686, -0.2862785492258174},
    {-3.1408631648660545, -3.5057667420136744, -3.315355012182753, -0.11659246591436317, -3.0597487374230083, 1.6122513227692465, -3.596368507145938, -4.48214999935446, -2.969533527340887, -1.6391388755303762, -3.054605758653576, -3.659836765541763, -3.1400862986484945, -2.5379848783669288, -3.2375597061697925, 0.8735064048356693},
    {-3.723558117664964, -4.144998609182497, -3.9708104585962607, -0.3040081649694934, -4.148384109456523, 0.9627231262498979, -4.030605486163087, -4.673973679867732, -3.685889656456415, -2.9437782320359367, -4.158225725214305, -3.0522717689787244, -4.172565783439798, -3.573471280721024, -4.111344179040912, 0.2480000538726935},
    {-4.647093195963403, -4.752226715204052, -4.917601798491373, -2.430866771203949, -4.752443077796009, 0.1448896585016162, -4.278976288896385, -5.31428834360465, -4.509246506567695, -3.690696482841453, -4.911596214259516, -3.7346135714453585, -5.222435213763238, -4.540588704577885, -4.961206323438531, -0.39871924673522485},
    {-3.2134710127370107, -3.297608840303374, -3.456986600608028, -1.1567542154109363, -2.680589963858776, 0.2558075386258591, -4.086652496994929, -3.907578032581028, -3.2044930676176424, -2.5224019974599003, -3.3096436544258654, -3.601078443155587, -3.205896557016908, -2.3119774888783935, -3.3161705759199074, -0.22643917623507218},
    {-3.3287579374536747, -3.7571162245391116, -3.590274076546772, -1.4437620675396399, -3.850222866103942, 1.0023498266799347, -3.2665345071529033, -4.10106770966957, -3.188845222455201, -2.1050202587860767, -3.0715818714814307, -2.8978294087818077, -3.5855609078897275, -2.9106862415285133, -3.4088541920691164, 0.6140804897141773},
    {-3.869161643028484, -3.967459238253634, -3.6747518898514104, -1.279824401447182, -4.069679248373905, 0.3361227886365521, -3.40592058424238, -3.912538033725563, -3.5158932965357437, -2.433862185756595, -3.84815592581994, -3.2796508074087556, -4.243860354260543, -3.345837990040729, -3.782388299350202, 0.30649837083336606},
    {-3.768624793790489, -4.1448339182997245, -4.44259441876974, -1.2933449370492658, -4.026697444698147, 0.42301229016173086, -4.4633121769228445, -4.328693195318795, -3.6586097986894917, -3.1872895557050724, -3.943106301083834, -4.034060590676867, -4.44465646095877, -3.446634526848248, -4.013810941619289, -0.3545505524400097},
    {-2.7361530643871173, -2.6257555673022512, -2.046758212886456, -0.13751310779997475, -2.3765816285535313, 0.7020890471810102, -4.0544380760695535, -2.540183040593589, -1.8586685531453597, 0.016618973049704378, -2.181115894672993, -3.6140203741953267, -2.5081488056095327, -1.248069206117884, -1.6333593178259285, 0.2344662430525245},
    {2.758646383887081, 3.2562009473743214, 3.363559720151735, -1.6506010485716545, 3.40345188763951, -2.724038120080142, -2.9462424376738774, 2.3650474121910476, 3.5539072198019954, 4.189091431941295, 3.5885005957190246, -3.6756507496240487, 3.535101155432385, 3.627081479832762, 3.9641753609227544, -4.449044952430041},
    {1.606621941838494, 2.395708556779005, 2.237085140343359, -2.307372088934775, 2.3991128427903776, -3.2665114864528966, -3.1793217704539845, 1.0080612989420377, 2.741041998849748, 3.0540966171786774, 3.030147941310797, -3.9720555005716767, 2.686387663038534, 2.1287112741889986, 2.989570835753467, -4.6393405228574975},
    {2.7568794721179692, 3.400422245285931, 3.4566979888867895, -2.519652013010961, 3.600499663564657, -4.2243252814168955, -4.172745928501535, 1.4696702528999441, 3.6040610540368307, 4.641019092544386, 3.64281743184859, -4.7048646380557715, 3.5212810779256802, 3.461813492492231, 4.122913717058686, -5.565488052059322},
    {2.8043975191750454, 3.670359291802783, 3.4979495707775716, -1.6910498528537992, 3.6630516968300513, -3.391045592482384, -3.267316557061645, 2.247004673402154, 3.63576716125513, 4.087499370383813, 3.6612103028992737, -3.7415086011381002, 3.8268610774895464, 3.426202542296075, 4.239688386241014, -4.506250858174067},
    {2.5506361118723326, 3.0788806839954406, 3.2537619264974937, -1.9681648111968086, 3.1806879618908916, -2.5780631607494655, -3.051042920895071, 2.1588031603454128, 3.2051901196127823, 3.843818461877933, 3.3537403574478546, -3.7532483597197914, 3.348876766621523, 3.2766492815381016, 3.7886457819525936, -4.887267338601989},
    {2.798687861700747, 3.506882388627511, 3.1893500912542176, -2.184773760767613, 3.553641613723837, -3.3408759441174194, -3.5451473830001587, 2.3343047899676623, 3.3431251107915005, 3.7259816348392754, 3.648295217797216, -4.43675226655255, 3.603611793796504, 3.172604695482819, 3.8657014530381084, -5.36074253396843},
    {3.221507516089348, 3.678176302289102, 3.7002203774526032, -2.521958498400278, 3.6764000051445143, -4.110698750413083, -3.7837267795379415, 2.6889638882653637, 4.004020410020341, 4.3593024357690915, 3.85242976101549, -4.793432884148196, 3.7034498803386438, 3.8026458935479774, 4.510266961103327, -5.657113829466803},
    {2.946276494485314, 3.76465192931167, 3.8694153601811645, -2.433911939699543, 3.9444066397915876, -3.850282404781083, -3.4853696894051276, 2.4395336806698675, 3.7609245455459606, 4.476649233419335, 4.210697039457964, -4.545187979713163, 3.7800181475986974, 4.139858163441801, 4.506127736758354, -5.649076222166728},
    {3.0685227867567355, 3.8746122388959727, 3.777154819867408, -2.316942944847726, 3.78494412557607, -4.400837582106854, -3.988133054751365, 2.037558807806124, 4.025635942443497, 4.3586272194469995, 3.848992862535174, -4.829128939903286, 3.8646328873810423, 3.852583363606067, 4.221665458997253, -5.67297417519653},
    {2.730090027764376, 3.571999208534037, 3.4471541437846986, -2.0268235250443873, 3.2879642058861642, -3.8689906714175866, -3.8287225957777973, 2.129364414242541, 3.602320215203128, 4.461254187811157, 3.700140254710433, -4.444946036650344, 3.769858646715309, 3.931576681039934, 3.944161622217126, -5.14337703221697},
    {2.483047586110011, 3.3170057768374117, 3.128500608479899, -2.3460637947601124, 3.4027363345002875, -3.605542150292317, -3.8015145929487795, 1.558530381251651, 3.6431339237972815, 4.079655252229223, 3.4928826462340603, -4.683629443557543, 3.1939686460464367, 3.178125536489584, 3.963700118095948, -5.285545149722277},
    {3.162295483588388, 3.8101498299554444, 3.924017403083847, -2.2366683132234644, 4.175158101438211, -3.2774895077464796, -3.690083021805708, 2.497215093692669, 4.359284306424356, 4.884192038663853, 4.237736728632139, -4.414106206167969, 3.7445512151930878, 3.691786421538433, 4.795615743524743, -5.579209977444596},
    {2.8766008769774354, 3.928276664391692, 3.839248702574397, -2.1967134767218406, 3.8465805541776725, -3.2786827730396095, -3.8197883497537406, 2.40573581937484, 4.289541250732162, 4.669154159428457, 4.152650277626289, -4.497159490947621, 3.982468305422137, 3.7482756253687164, 4.537765872007547, -5.276630598449673},
    {3.077709011021238, 3.913675782152493, 3.8967591636633734, -1.2790750068116437, 3.9617712918605728, -2.963470779236778, -3.299161912157013, 2.720352392401036, 4.004038541101193, 4.551364967805988, 4.063253880625431, -3.9991192562442888, 3.7793395543051163, 3.981711801801473, 4.354743301295785, -4.372186766502765},
    {2.697269905355893, 3.5383547193042517, 2.987439546944918, -2.3161230336640264, 3.1924538992165736, -3.696215608336749, -4.572565517675781, 2.141815795744702, 3.6037255435293853, 4.20527503965174, 3.700265322778635, -4.596379513653866, 3.645097203380625, 3.8913872252173385, 3.9181379566410968, -4.889467288298443},
    {3.3718511738012813, 3.8527591155654197, 3.8098360150071238, -2.5144870096028926, 3.7925503783246617, -3.91227248205831, -4.114719861500351, 2.3200611721120525, 3.919050554080667, 4.317802948386874, 3.8640102290085383, -4.75293771273352, 4.079584062265165, 4.550098577360939, 4.082457651457852, -5.509140986861243},
    {3.2722882528292216, 3.7963916459431917, 3.890163481892543, -2.4632827855023693, 4.06645184011446, -3.714446615392906, -4.313596529839181, 2.5517106081684244, 4.078039718098875, 5.16473037962282, 4.1430210898516595, -4.861756303583758, 3.998054321918627, 4.286159996058305, 4.534509856277082, -5.634166215973896},
    {3.62304645116702, 3.905114626573993, 4.180979346427174, -1.8169452759723668, 4.06698779201456, -4.263860612082999, -4.312901858433114, 2.366419078496203, 4.248920008339731, 5.078047810066997, 4.159352937403317, -4.901944722256074, 4.441397750275321, 4.496302290201391, 4.761647776221235, -5.530919376501667},
    {2.593374060284133, 3.4559555582058916, 3.1742310852265674, -2.7460352977111326, 3.452191275336999, -4.013097265247236, -4.362259375335976, 1.2474281687774034, 3.7233595480436543, 4.344040529144285, 3.528475221776656, -5.080911992855519, 3.66539023161673, 3.7219737658324044, 3.8109615080444454, -5.960926427667401},
    {3.0664401345415784, 3.869946172408234, 3.8583800764660627, -2.427013070551129, 4.098129676267706, -4.221726197653947, -4.2723622659052145, 1.841142315837735, 4.141236407230411, 4.6690341957387815, 4.128437217161344, -4.853900683794498, 4.160623775762252, 4.147312987656119, 4.523641591666678, -5.534956147222685},
    {3.3776390700142533, 4.052033250201541, 3.697538303115845, -2.3968809911772353, 3.9017742032571614, -4.3219714181334075, -4.1559760530341725, 2.4150041257572346, 4.183129376015026, 4.767285465749773, 4.183691307602967, -5.066779287653725, 4.063650594059474, 4.316482185933139, 4.856507945432166, -5.381126740032707},
    {3.5186284877408744, 4.231870905591427, 3.940644006011258, -2.163340890143492, 4.146907552703429, -4.3499438866906, -4.4125853338773755, 2.40436063870694, 4.477968913339985, 5.26293100965985, 4.351426104260698, -5.113062132058426, 4.328955970073056, 4.529028386469748, 4.914249633520698, -5.681668613217648},
    {3.78926178124917, 4.623729666825196, 4.334737361415787, -2.373998319975597, 4.371041067761954, -4.531617526812291, -4.75114037143443, 2.685518470835799, 4.59685620688407, 5.117358755140896, 4.716199961150275, -5.493995836623037, 4.593225435747538, 4.5926491014027935, 4.777273784357901, -5.581751537246647},
    {4.02815729284196, 4.977473957932844, 4.638401538373259, -2.9981886320496067, 4.889444716617242, -4.888704830683464, -4.991691374299431, 2.5349162184423855, 5.2107384069705285, 5.248498882738712, 5.03147253030533, -5.872494162129245, 5.000164314589508, 5.075666223046078, 5.336480097748178, -6.164863410003736},
    {3.80814893318752, 4.429958204139883, 4.2122189156784176, -2.9544537926120302, 4.348893256430904, -4.538208917702259, -4.691434685795122, 2.2439855067241385, 4.847743862302924, 5.409989929115371, 4.7293267954546225, -5.309660935599583, 4.75571299370741, 4.855191231749677, 5.191248401934894, -5.994954857129383},
    {4.162238455681143, 4.925236561052493, 4.390183227029061, -2.4534345837747678, 4.265940767884025, -4.84655161930401, -4.973202541980822, 2.4480411417355166, 4.86345123099284, 5.545361496638694, 4.811941065269306, -5.431791197673507, 4.934497068398908, 4.8313427729681075, 5.06746989256584, -6.4683465324745715},
    {3.868324192396193, 4.862425950310336, 4.492376485980143, -3.2420546731867144, 4.667322129432836, -4.576431692490699, -4.940358569289164, 2.4106198045489338, 5.199165994553029, 5.450380439857372, 5.009180899433697, -5.708425122815198, 4.82642985987912, 4.870602788087635, 5.427065754306758, -6.174310162618636},
    {3.8658953117487043, 5.051680570913441, 4.876515466895522, -2.95067948267023, 5.148771200131613, -4.09423917670026, -4.752838790696551, 2.522431875759861, 5.313369240956633, 5.492321111473396, 5.082101257782825, -5.349953516237562, 5.012041746445709, 5.145198461789955, 5.325619759158122, -5.584541968690743},
    {3.6586390642140136, 4.852782995446275, 4.142672339897844, -2.7856731935341457, 4.716392357282273, -4.303066981840241, -5.14239110933013, 1.7546597743799857, 4.801460345824964, 5.254917052106972, 4.949091885545236, -5.75172666233173, 4.430834694449993, 4.566118034313732, 4.884927310100409, -6.1181647657353935},
    {4.464224447557813, 5.079595007454796, 4.885848373569694, -2.4606272705737013, 4.898685001199, -4.265544865999725, -4.7015233653948645, 2.985831834833738, 5.201208769717742, 6.072925574707948, 5.383102452992955, -5.5156787233052516, 5.138851769755619, 5.289547898265868, 5.6548670406982575, -5.814282771976656},
    {0.009656666845240157, 2.61443600332197, 0.873216610225688, 2.730475491657511, 1.4020705727570708, 1.4535033444139362, 1.7110118059412007, 0.8764517074257645, 1.3684553341755628, 1.3459142729549767, 1.7577282978950892, 0.9274066477675567, 1.5612287219723924, 2.03146526341166, 1.1813261681640166, 1.295961378784902},
    {-1.1937721134365267, -2.6604121573504163, -2.2903282653736903, -1.369568055729952, -1.5519405708009293, 1.1784921312294918, -2.0710571124382904, -3.2420051035198307, -0.8468204273592771, -2.3466310764575677, -1.832455222350175, -1.5972950899304876, -2.0661882063259625, -1.5871608378560036, -1.6130924119219856, -0.9982846892020844},
    {-1.9039082186900878, -1.942060228980051, -2.6001301038394002, 0.361528194374386, -1.9151216344597963, 2.617073490388666, 0.6141408186636776, -1.974838079286301, -2.4357088071878508, -1.4545736434787986, -2.2635179962711973, 1.2892664213669152, -2.3288569592290376, -1.7785333934967091, -2.5720624693915406, 2.5006701144427486},
    {-0.8630064674789685, -0.5561024740204576, -0.6795969882910784, -0.2641055741980672, -0.4577990500211142, -0.18465398112634424, -1.2209609302368885, -0.35291158614201773, -0.88340159566073, -0.48498747434767947, -0.9780622917905744, -0.7266827639998581, -1.0860647463211752, -0.12966282456258854, -0.6935642526776862, 0.3481165433559875},
    {-2.2406920535795525, -2.0951614687775897, -2.453545886062011, -1.8069927120396538, -2.1876256910886966, 0.3087529251043259, -2.942044269375221, -2.2339585037192284, -2.039257661308155, -1.3798807100330577, -2.026829577722017, -2.5020359994523798, -2.3255467424708796, -1.6398969536333443, -2.476791787602842, 0.2044461567410584},
    {-2.2459876822558567, -2.1764088388972413, -1.9905025219228363, -0.520854514945012, -1.759632635456263, 1.2104617680095002, -2.060567369293889, -1.6382908415258366, -1.698375283520769, -1.5935586817569598, -1.9547948110293243, -0.9818248786672508, -2.3038749828649028, -1.6675324240093763, -1.839668607257268, 0.8233803368522168},
    {-2.2115623216153497, -2.161994308884487, -2.3483957557847597, -1.570002632444442, -2.087345655936437, 0.7619636803154141, -2.0809106456590003, -1.9043519214484828, -2.2114260353038953, -1.417319970476091, -1.7265772985699162, -2.0030687052185283, -2.2940420881448618, -1.412529158015317, -2.2492418723316776, 0.3310731263883254},
    {-2.1946119212133732, -2.34448939513479, -2.6516908068322156, -1.683414828007165, -2.5601040327951194, 0.6058269395431081, -2.0042436608101513, -2.5657340506091955, -2.8451611247126003, -2.2310984520285713, -2.5835103424961825, -1.1823617621928637, -2.6756696863729497, -1.9203349119542625, -2.4117944264479227, 0.3085712781147513},
    {-2.0460431722100982, -1.7312282901480036, -2.2727255399676545, -2.170188155416639, -2.231872728938654, 0.6057907663608298, -2.4173660869528644, -3.0452289113574205, -2.1950833123215383, -1.4606045355990138, -1.527499677340637, -2.1027377841380313, -2.066623834514148, -1.64598819112674, -1.8900361795682386, -0.5057540179096237},
    {-2.85125836356091, -2.558510985709156, -2.317946470757133, -1.4951167222140826, -2.1898996086398506, 1.732606044526434, -2.0135382786585145, -3.272483229756093, -2.0933491248469447, -1.4005553160231357, -2.0599312807682746, -1.6950839706460945, -2.6934410613614395, -2.5023959891789653, -1.8836778873863844, 0.732885680709164},
    {-1.3545245184325467, -1.8057417711180042, -2.425611860328386, -0.8787299674460659, -2.3266025691039767, -0.030157754093198184, -0.9786669399434267, -1.808309574519185, -2.0900159573454333, -2.3922083766910918, -1.9257347845321326, -1.4695735578098106, -1.9058389623862175, -1.3791225381516912, -2.4040605546364184, 0.6393687790863499},
    {-2.1375792128686864, -2.2477078137641104, -2.5604129477977766, -1.313900979932463, -2.73050464779217, -0.5707128484132106, -2.6969709255972654, -2.2782891934825855, -2.7517281961179596, -2.5291387921579913, -2.539700167850891, -2.27617639231209, -2.627478677261828, -1.5353205816880058, -2.706011732905234, 0.29649752788744105},
    {-2.9260165100834654, -2.934443324819955, -3.0545231672330186, -0.8332945968481172, -3.229504929942672, 0.17503092990464011, -1.746218129144839, -2.788708277773071, -3.032390469906935, -2.6925543161985988, -2.9521344892641275, -1.3072710447769926, -2.8790931215052464, -2.2582404928023774, -3.2181156952996504, 0.8211707981303171},
    {-1.6536537855634907, -1.8115909597302207, -1.8097224965694805, -0.21052483393885654, -2.006856921508709, 0.4935404137028788, -2.002027452312499, -2.323301275751487, -1.6275847469113207, -1.7216926503837295, -2.0849468014218964, -1.455390176290484, -2.172223884242825, -1.6606807767020193, -2.0696456052026924, 0.9496930693561425},
    {-2.7235798876204913, -2.654209327784472, -2.7308206692836956, -0.9183119521418701, -2.5965578241141043, 0.9662540052340873, -2.0398959180856355, -3.6736800750411542, -2.0964014229293775, -1.672323910116242, -2.615321398811209, -1.8832242896517515, -2.7944903111080612, -2.254579098957151, -2.301982339089633, 0.8783623535418779},
    {-0.6367899519431671, -0.833892379505228, -0.9043654340700167, -0.2189847480560188, -1.0191791205061609, 0.7444858627078256, -2.1073426594987685, -1.6430836227246521, -0.8008361650682932, -0.13785394797754996, -1.157158000006355, -1.531399245540312, -0.7748462470676061, -0.28604450148898586, -0.9625257825153255, 0.7710960723252822},
    {-1.3550792132286182, -1.5141708217833085, -1.2170883044256813, 0.6161975771004442, -1.4648159666299887, 1.211580872342659, -2.4221568326257024, -1.7412498028475658, -1.223672681708052, -0.924228913898232, -1.226981535507723, -1.380079620412793, -0.9349601547666034, -0.808384276740756, -1.8416369608989482, 0.5109383463413986},
    {-2.1443602341176597, -2.015815275430258, -2.120324379319555, -0.8337211061672297, -2.2299622938237365, 0.5361561911456375, -3.101891756884966, -2.780063922863527, -2.0371006669046747, -1.3243043087039073, -1.8530381215964553, -2.3275466909379756, -2.0584898271982865, -1.4683637457761505, -2.043914531986904, 0.4372723978647305},
    {-2.061583606955499, -2.2701200964432697, -2.7789217546600247, -0.4744979307212053, -2.338236721338323, 0.09035610070145954, -3.1694295768177105, -3.2817808072942714, -2.2148883715002974, -1.9739200039509766, -2.1050392864524414, -2.532145331402802, -2.38896523730471, -1.8625841845975704, -2.562318542816177, 0.13176986928197928},
    {-1.9586703037206197, -2.2540789011477385, -2.452442583424127, -0.40400335577002255, -2.6146604366595927, -0.3848041259093099, -3.076230135415336, -3.2195687433582805, -2.036320674261762, -1.840845853657434, -1.9685454704516312, -2.913573670662681, -2.513190107777878, -1.8120370399702985, -2.587027947198731, 0.1851591792562637},
    {-0.5174237423270645, -0.7669508984205463, -0.7516133171164961, 0.46873374100757653, -0.9909037187840697, 0.547858766375809, -3.7111571299807378, -1.1699802342052252, -0.5313694379468437, -0.13332697767094445, -0.18995170823127447, -2.9928471818614883, -0.6934332102548776, -0.0025434182094619426, -0.7434836435550445, 0.230127059706896},
    {-1.258101283206851, -1.9062203848675725, -1.5447327516805844, 1.3563402215187574, -1.254464318494994, 0.9381381155635821, -3.843641247290944, -2.324341391797711, -1.399451910885619, -0.2838484576913214, -1.5268122300801321, -3.288349254083291, -1.3209882622635079, -0.16758485101320367, -1.626901398455387, 0.7619728567669659},
    {-0.7453724674591152, -1.1693028448928653, -1.4642066386103476, 3.7254487320634033, -0.48662934265579055, 1.3974822250209646, -1.2899155613948925, -2.1239861039681602, -0.9367234301667623, 0.3570133852755934, -1.078649814020008, -0.6774026996287895, -0.483822892294907, 0.3560311381014296, -0.9440770240588426, 2.6201475259815696},
    {-1.7875588512976213, -2.0280156199934667, -2.4676330121560177, 1.9927286628634424, -1.894727161299215, 1.2634026900848692, -2.390926559916745, -2.906184300683608, -1.76470273120669, -0.9837005196178243, -2.0855227704041344, -1.9929178198999535, -1.8372356844460236, -0.9899160675254585, -2.434798106659293, 1.4270452733331194},
    {-2.6257931977997075, -2.579513369168447, -2.5296972979684544, -0.25625325569855206, -2.6151703737620164, -0.11969868061266445, -3.997738826486638, -3.2194793657854777, -2.2611895827588677, -1.6092530618186165, -2.491267686789898, -3.6278800602312398, -2.9400153106849753, -1.6471185974715812, -2.623041910774393, -0.40915288735966987},
    {-0.12167877389633153, -0.45666691955908767, -0.8594392860543171, 1.6146597528903974, 0.1614911852690471, 0.4764913092081572, -2.7381441353509306, -1.7269518579562653, -0.528337906374575, 0.23105495848741334, -0.40554166167418504, -2.85346481625736, 0.15329446805589075, 1.2192570110284202, -0.6710270746091398, 0.788472077336166},
    {-1.3534986583398219, -1.4298647463064138, -1.8071061745749812, 1.994050730922437, -1.4080183604459757, 0.720473528917535, -2.2499681402978204, -2.291645339520022, -1.1034697042253427, -0.4223466921157327, -1.6849188993649773, -2.1297372759247875, -1.0246592996511232, -0.11742894940332303, -1.57684897196255, 1.3890833529405364},
    {-1.2483200367491265, -1.673897576663596, -2.0231901759236655, 1.5073541001350383, -1.5701854377349755, 0.39952852734332106, -2.8780196299930956, -2.374082896512719, -1.6188646526636865, -0.6388226310387151, -1.9192873792017102, -2.7300331757181486, -1.5261837792643884, -0.49596048774353396, -1.7905802487382871, 1.2554287066121779},
    {-1.5896655605675554, -1.9607823677483096, -2.451471137093691, 1.5911842916787466, -1.9601662585464026, 0.18360086294025085, -3.4908698581349853, -3.038268076524849, -1.977026186560995, -1.037541549676502, -1.9524512817779114, -3.531581072649815, -1.6011696517652962, -0.5468798529773854, -1.9071461717793345, 0.43180955515516967},
    {0.17999304696495466, -0.06766006820067934, 0.12809119418351392, 3.418377283136463, 0.1440263743398744, 0.46054623696098385, -2.542233718477415, -0.489793495898392, 0.6816596466585383, 1.4212506874967692, -0.032347677805510996, -2.041020874547872, 0.47244943969113445, 1.323983083932073, 0.13316361383392902, 1.3224488024347576}
};

static const float b1[16] = {6.843074005419405, 6.826647600905188, 6.652789312001791, 7.434178336652707, 6.694684563512523, 7.884083819063455, 7.690750227618308, 7.071604274357864, 6.579125928800944, 7.139977696889266, 6.915374880399213, 7.627027475520496, 6.818396998715203, 6.7882379939067095, 7.352185510991478, 7.719148374657972};

static const float w2[16][12] = {
    {-3.115984821275856, -2.679920813909701, -3.3635657538920603, -2.369386765680969, -3.076302624596494, -3.144544696247834, -2.7821611327651405, -3.3517837133431874, -3.1444630445729045, -3.57112861369232, -3.6695706367376952, -2.6403424991647615},
    {-2.9574487382068293, -3.3466792548580764, -3.0868721912173678, -3.7155120928477703, -2.4586518812860474, -3.720952882625435, -2.9000930695084786, -2.8001546517942137, -3.054655778628241, -3.123827629188191, -2.406891371071469, -3.691209538433772},
    {-2.5833323376781254, -3.8993309180602407, -3.655968991735548, -3.516788056529167, -3.7119259334517123, -3.3178415586174443, -3.2254619091691064, -2.4396641025536736, -3.0899126594788253, -3.4712033384759415, -4.009226220540081, -3.1135538247397223},
    {-3.33761241921646, -3.143084679692778, -3.5637567123355542, -3.6475460584622676, -3.557282742779828, -3.1747830899280287, -3.7330172868932014, -3.2036455635143732, -3.2356756587270716, -3.800741168523544, -3.3150000564282536, -3.608116211837919},
    {-3.0048284711445863, -2.155951274797306, -3.364169632641788, -3.123526780965466, -2.956704916859486, -3.2386224627973363, -3.6656989263311566, -3.846692999828695, -2.750123105496669, -3.2123342888497426, -3.168680727129016, -3.8927843758079947},
    {-4.335734372662593, -4.139502468028129, -4.27735422995071, -4.316281179323901, -4.452632989746746, -4.137015539614995, -4.117563145951898, -3.9898324570906847, -4.088838864644594, -4.303818359507992, -4.204360082586837, -4.0716434668613815},
    {-3.519939454057689, -4.066714980817631, -3.905329912228637, -3.6913334783475773, -3.5299650532894016, -4.206072427755725, -3.445781922761152, -3.92037629173875, -3.5962730736661497, -3.2462024505454714, -3.32507719629472, -2.9172743377430717},
    {-3.403439957309321, -3.4418397987116722, -2.885204814122244, -2.9307605430746673, -2.765055255693318, -2.8643579281759632, -2.707096310384885, -3.2476482330609193, -3.298816549594922, -2.5064826108837552, -2.9768381992191193, -2.927882560948215},
    {-2.8437864587302735, -3.363202262837563, -2.3105561930180514, -2.5702149488524357, -3.363717338195033, -2.994757438644738, -3.3147362802835634, -3.426010771177201, -3.36321732865786, -3.289904804771328, -3.0686326105363673, -3.3326914730254495},
    {-3.855020702591922, -3.791918427372941, -3.9092311434735167, -3.3092706145643054, -2.8378425008257318, -3.352906164047268, -2.7809577035418487, -3.819018340814247, -2.7609131532383255, -3.119255834168432, -3.351449028754797, -2.819700155979875},
    {-3.157032866003321, -3.1319148819633247, -3.57841858175558, -2.92652775838321, -2.2249450860188076, -2.9172353460575704, -3.789045604637543, -3.0577775307404944, -3.5114958516683155, -2.91008487448992, -3.2568696611912986, -2.6035903956464113},
    {-3.4650945312791746, -3.1374395212418134, -3.037477057528379, -3.25938562192619, -3.428333537719735, -3.0285587196893413, -3.6188953140377693, -3.3562562949848482, -3.777218571745852, -3.773352505231939, -3.9868068111085755, -4.185242550885978},
    {-3.61492155827851, -3.2735545506861987, -3.1040037803006983, -3.099755030247746, -3.3555487894503297, -3.032223524688173, -3.178591363097111, -2.7420390319445715, -2.857125440886205, -2.756592380690089, -2.8908494353790504, -2.768298844844714},
    {-2.6558203054075467, -2.96089490542518, -2.8685600750035443, -3.222577303880599, -3.3443288701106986, -2.902592413949984, -3.4425704685381584, -2.9511145428316965, -3.0360422038311836, -3.1984182255222704, -2.7123530976846726, -3.381165064109683},
    {-3.6017586076279353, -2.8082945054217903, -2.646211639061035, -3.839067121640974, -4.5081488730089765, -3.2441944689626054, -2.9250277493065466, -3.188579116282563, -4.050282295737321, -3.4888611216680827, -3.3803023787819533, -3.554487165661536},
    {-3.659662188581247, -3.695286540776686, -3.6190353577928946, -3.600009024103519, -3.5473915305301595, -3.6779060487530115, -3.540095334962618, -3.8005899270480397, -3.500157214858334, -3.340694140323404, -3.3862301975097564, -3.512189942484492}
};

static const float b2[12] = {-3.6738030777032233, -3.8766500625018923, -2.364456894272339, -2.8330023913332796, -4.111614182217452, -3.2412309400019725, -3.525065163534221, -3.91958809977297, -2.7502320692857096, -3.7374096120751075, -2.4691598600643125, -3.1084834160951043};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
