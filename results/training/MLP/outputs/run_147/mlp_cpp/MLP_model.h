#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-5.0872613090261245, -2.8780819206922614, 1.6381873268810632, -1.9508407615135834, 0.8479554703865324, 2.9950921360544416, 0.07983591113661141, 3.989591271161259, -2.6110910819529076, -0.631264214695346, -1.9671009777279544, -0.13158444238344985, -2.2435332519514652, -1.6569146886855646, 3.4860186164586984, 0.9848795775363469, -1.5440912455977993, -0.34993745255978975, -2.465158358589755, 2.2071507780575916, -3.0957630829199916, 0.2211931805353576, -0.99944927294177, 0.8789947871097457, -3.0089079360853037, -3.686824655666917, -0.187380893086193, -3.663756934737035, 0.8776667403876904, -0.27948423631612906, 1.2351487358574988, 1.7838784382015407},
    {-1.504300393410864, 1.9697606823723446, 0.504453485222495, 0.5501171737117121, 1.3374488706941792, 0.879311294982519, -3.0474797261351565, -1.764185679944781, -3.3511955929482706, 1.7164815381265461, -2.6620133781916633, 0.9258066204579435, -3.244338695838366, -1.088183500183868, 0.4385511113865042, -1.182735977064876, 1.581363499363271, 1.4209463933766175, 2.6908997599724014, -3.8173274844042138, 3.9037029405578045, 1.9257750052340556, -2.792692161110845, -2.3729175200380244, -2.2370289134597963, 0.1404348153567244, -2.3012727256684204, 1.7056225638617488, 1.5135333746961825, -1.2975156754815202, -3.771279526182289, -1.2157321754297912},
    {1.0929061695214204, 0.9618004661575416, 0.7815413677116247, 1.8854258158272819, 2.3418802026508274, 0.6590072487913256, 2.1141732340771613, 3.2693698240356395, 2.3847579724275865, 2.1569646109739056, 1.7147985060197377, -0.0973895534961086, 3.0585831690845375, 0.7213092792905658, 0.511573944713271, 4.479808367331855, 1.2611136072737161, 3.0177184202128706, 3.9199549885455927, -0.9422381157311761, -2.2943667061363664, 1.065463737001319, 3.2490519607851747, -1.3686861792942995, 2.4308065374260415, 0.9188338058110098, -0.7489341780196652, 4.4104990356107665, 3.1046479257089237, 0.8552438593681428, -1.6286370621604553, -1.9345457693002732},
    {1.4766061647399928, -2.514550851218929, -2.850319948262027, -1.9590051280303764, -2.873311489931782, 0.5939784826241158, 4.134929149323214, 1.4152196465301838, 4.916114834692537, -2.8641664556413597, 4.721632669190236, -3.695114256822986, 5.441261024729728, 3.568113100999938, -2.959196745304641, 5.514291995520691, -2.532632644389081, -1.6806970834250299, -1.3754664717842262, 2.2204450700000247, 0.3146795393875835, -3.8808224264087907, 5.58889986409917, 2.0303391627501632, 5.394960724627472, 3.6984278051502733, 3.6174983280440585, 0.7915913400041245, -2.537558233147725, 4.022509173536689, 2.0073870660238304, 2.028284142665334},
    {4.950977346679156, 1.0191872436980747, -2.016801336709904, 1.0152692995516197, -0.3280611479174415, -2.244984417140007, -0.21244349179838642, -3.1477840560513233, 1.879135785431834, -0.049101186907543184, 1.0903042448358091, -1.5727804519282191, 2.413463824974391, 0.630352066945331, -2.4007334741247837, 1.616387335342455, 0.90479326533329, 0.5879752534953938, 0.554624866448805, -1.1972846967799824, -2.191030008962647, -1.699374615169817, 1.6431840199734635, -2.0666347114133914, 2.0202175495001984, -0.2839127086955216, -0.37242951244361544, 4.567430639002507, -0.6428533442853921, -1.2475173807430928, -1.363851325603608, -1.340515436755905},
    {6.06634999180868, 2.2810750927520678, 0.0020576687753366104, 2.4128327664274196, 0.36260513035851993, -4.653955311031454, 0.25375667171178046, -2.2922271991508616, 4.215906617838124, 0.7576365903506226, 2.1953256669884884, 0.4511504623739176, 4.469422264579791, 0.12955326405474765, -1.6463071490034011, 1.8857259780347058, 2.1067596091794183, 0.7240562862562869, 4.176865371610952, -0.9975852897848727, -2.5523399703206544, -0.0182311707539352, 3.641436929788211, -1.648913332334735, 3.663470198900288, 0.9717477067089048, 0.9156648022087305, 6.209457832375157, 0.005870601418042999, -0.69421744687965, -0.43573418223472427, -1.9638223785800397},
    {5.61683806767558, 1.339870316123712, -0.5459730535745363, 1.4968026450202343, -0.4697798494371609, -4.094944762190203, 1.8694787715670786, -1.7925329168894073, 5.413058275206122, -0.14937245109543368, 3.4789195741851735, 0.06110641512331799, 5.450665223014811, 1.3428505364455277, -2.539603950008824, 3.727130195154244, 1.0988355052405843, -0.4862350060655907, 2.9333231969423488, -0.2241001178222878, -2.9088657423570448, -1.2127698384057466, 4.68317235273447, -0.42844051031828223, 4.722138142142232, 2.0579742513556263, 2.280908478451001, 5.299318583510179, -0.40666675803762603, -0.13729045901724876, 0.35403587292651945, -1.4650864284585003},
    {1.087831551716575, 0.11641245429558814, -1.849848990684694, 0.05145234965728632, -1.1200259015757954, -1.3528937353263637, -2.6657353729766746, -2.9109077017599794, -1.233488234811951, -0.03823480487461047, -1.4358620529814705, -1.0674095915494222, -0.4203116152842324, -1.3212284459438433, -0.9072775896740626, 0.749143906529311, 0.601920656888718, 0.682847986527552, 1.4642086506216132, -2.7339499157008564, -0.5132373433523056, -0.4948530209623643, -0.30646733018745514, -3.887697884003258, -0.13120324265101724, -2.294247888913365, -2.044760664644546, 3.1192060405198663, -0.4236197200068156, -2.5317205961132583, -3.0523052834353095, -2.412678765213689},
    {2.468995015968982, 2.395804145697054, -0.41073422662366477, 1.3876233203427775, 0.08648699920039649, -2.024034097497553, -0.41838451681764643, -1.965171658473927, -0.5145334159131421, 0.3869373632044118, 0.23436895173106062, -0.09731454019520121, 0.22788382422282302, -0.49626506273850574, -0.31849052554461077, 1.5077658765891662, 1.4499969818963063, 1.2957393152647014, 1.7373480981347942, -2.0826709520412674, 0.9213292013254551, -0.40302145965111297, 0.392007951059803, -2.7401075861810904, 0.1149222333187237, -0.932120137893334, -0.04737763948575937, 1.8829777378059886, 1.2373461147415887, 0.09871388965752094, -0.8960756087403158, -0.29574797567578825},
    {-1.4631806277580497, 0.7720967676568887, -1.648508561049932, -0.5290503735355448, -1.0581583873055687, -0.20941189824205433, -3.94950630769181, -3.779216104197094, -2.8776078099134286, 0.17288612674546805, -2.5462693366906666, 0.09055486421976855, -2.7792030958170297, -1.506158739439617, -1.5508383871310658, -1.6072629385121604, 0.4073683830826272, 0.2635291053961369, 0.8393917882542464, -3.4125281928449596, 4.7429240042481595, 0.4359323704384516, -3.5432642347563625, -2.392497624314329, -1.813273602104225, -0.7599747085835299, -1.4945062201703814, -0.7730554856726398, -0.48843915215947964, -1.3484887721002607, -2.139841562648801, 0.9318873010569553},
    {0.8202643168817833, -1.3218090306572159, -2.120384058105142, -0.7070794049184992, -1.9834478693330662, -3.4622611105176357, -1.1461939932899885, -3.2069669510372276, 1.0952222569797734, -1.190048075346783, 1.8484164962465368, -0.9082550919854258, 1.249934005820486, -0.08494451826234257, -3.0038322434924023, 0.5138318930888683, -0.6984280727956703, -1.9569254355207986, 0.632726140502829, -1.4619147162506407, 1.905832813978239, -1.3205555491885825, 0.7864427741193424, -1.4977371131157702, 2.930464262762099, 0.2093277203412243, 1.1416295401582899, -0.7759058368721783, -2.0541347066294064, -0.6949675861756698, -0.6898011412526189, 0.07145536660824288},
    {-2.943246488928206, 1.4082929572218215, 0.43359207125584803, 0.0620613454572676, 1.4273704922857386, 3.6307543461088256, 3.060834899954333, 2.518310352445368, 0.7828364194546692, 0.6860225560386289, 2.013207120891568, -0.04152348024894501, 1.7936969019530806, 2.48441168317465, 0.4466778444205745, 3.214757090491498, 0.2162253322673945, 1.121300399096948, 0.737077404272739, 2.3959070220726546, 3.4772373920946964, 1.2638965245404061, 2.2544982550681842, 2.203079880756312, 1.9751346115320465, 2.825066854019141, 1.9361782336466455, -0.9031952604214415, 1.5293277621349675, 4.1774521982303705, 2.504718335821253, 3.411051831193958},
    {1.3794825072026644, 3.8202295819634937, 4.617537901419206, 4.269313252364129, 3.9583541347474074, -1.8987569711076049, -2.6491407369468356, 2.2429584675490926, -1.1319967604870973, 3.934547356448156, -1.9666636949576008, 4.871165498995377, -1.8390069720469677, -2.579741130241574, 2.6174995437520416, -3.7638849892635258, 4.472372728519606, 3.5006656138398324, 4.440454043719872, -2.6801713214328067, -1.9724671757599042, 4.046275165386758, -2.572096562039764, -2.0751874501877214, -2.092760915618542, -1.4282085503413782, -2.2583953214839982, 3.379004130059261, 3.968808529685762, -3.0152857272271683, -1.8922527638811197, -3.141124335833497},
    {0.46179171548175085, -2.3144933833914716, -3.0824539155081037, -2.729105514333122, -4.085015948085632, -0.573440576686417, 5.291462685584317, -2.0237857173593286, 5.6401140560632, -4.1238520434815715, 5.513620687907223, -3.271108102398329, 5.04855269987932, 4.804887496460781, -3.6007171215895566, 3.6818023409441034, -2.5654842396150808, -4.835505606849662, -2.686679021551318, 3.642433247848064, 3.634143972180323, -3.9602008509896205, 5.019277881281651, 4.609569731020079, 4.826158023440328, 4.906895748573876, 4.998343785156234, -3.0920966533349525, -3.9308128597674523, 4.750217582070001, 5.052259531596156, 3.9803647478602397},
    {3.5875874090887305, -0.750640267943717, 0.19911002472267197, -0.001103318239616996, -2.9024003588111094, -3.2729981768757686, 5.901513221239967, 1.8180099620558712, 6.2243264886947625, -2.927999565812942, 5.943556307628819, -1.2911545154832036, 5.053612385595969, 3.7953167014050564, -0.7959290709423782, 1.741462988032418, -1.589411597117794, -3.8244986170436226, -3.0096947096190734, 5.466645831688405, -1.7476383867858853, -3.3047743801992895, 5.196243351202129, 4.8445658271904986, 4.2678910321934955, 3.6446206680946074, 5.670151234817368, -2.4291712150532616, -2.9953736723606506, 4.452834641584151, 6.055573692160014, 2.5021602571621613},
    {2.925147534102837, 2.2891572801999183, 3.9694907565001802, 3.3828077325457504, 0.9872122130884154, -2.896885215240945, 2.12860508094417, 1.2184396625236114, 2.899416325470337, 0.9329056513295748, 2.153112015300835, 2.8211657932590106, 0.6430528920239637, 0.5370087548538535, 2.682809754181214, -3.3725854241379047, 2.412920230075812, -0.8342181360103217, 0.6199999665731099, 2.7147624085986983, -1.6449538712032097, 1.496446877605198, 0.08520725557728824, 2.4073551088780802, -0.23765517235628203, 0.10181277690411163, 1.4316532950404004, -1.1800994018954187, 1.1509074067964162, 1.33974803807099, 3.7964396155874627, -0.0605060980127035},
    {2.924390558639857, -1.1817444730538178, -3.1290954552584904, -2.1603620692048255, -4.3092150593663545, -2.7393183009985838, 4.589033336071464, -2.961555126397784, 6.234112546782703, -3.900560884789087, 5.897095683886171, -3.0892314443916944, 5.909110095506743, 3.7257206575390134, -4.218720278941313, 3.607237934769224, -2.9291441885390963, -4.497004317182229, -2.4072852143234744, 3.4014040341054055, 2.7040383534001875, -4.0288265189899235, 5.788933475985151, 3.8035431684466277, 5.7650131150765525, 4.95331739968552, 5.8450620354764675, -1.8963788352225894, -4.406730613053997, 4.728831215686596, 5.023466829947883, 3.194122491926431},
    {2.5282615550619383, 1.1039050964142567, -0.06603915868067947, 1.0762904298683404, -1.4278992598659523, -3.1419916082660304, 3.8239100321457076, -1.9923774651625505, 4.906086687781037, -1.0136470835360085, 4.934712457384418, -0.2645662714916991, 4.715095826839415, 2.471214193852933, -2.765554653092796, 2.210247428409885, -0.20623222607863806, -1.9777391713499908, -0.5215183455498511, 2.229164757470882, 1.1692725071533558, -1.25086625672622, 3.7502119252969743, 3.536505986858182, 3.7585457422031956, 3.577040287498547, 4.096485894583463, -0.7048085477366348, -1.8607177586991122, 3.2380264614478325, 4.180257269228718, 2.6194432915420314},
    {0.7932507829082213, 0.24590213516064627, -0.5240865524369139, -0.6529532262624369, -1.6980356971801578, 0.6871514766449427, 3.300056258174231, 1.208850853773145, 3.5708204712719773, -1.3062585814555074, 2.6725563527463714, -0.4519358457590438, 3.1926197673993837, 1.211178936796414, -2.2680519989813965, 1.3027324214356024, -2.2216679254171763, -1.1618529079863076, -1.4255109317202135, 2.639816768053481, -1.0723189424187782, -2.153300943849317, 3.751052430050569, 2.662440186624767, 3.1019605583376437, 2.9986095878756056, 3.644370441834918, -0.7381823589174182, -0.5879425433614486, 3.1408061824342557, 3.8602204989622946, 0.8375399248639317},
    {-2.559261231028737, -2.9445123121399597, -2.18675700288904, -3.241020995547062, -2.5180155341348858, 1.821790992389449, 2.038834519411328, 0.24750155100628107, 2.9245126614084946, -2.1030735822750657, 3.2916757888778294, -2.695529110379459, 3.611031428771847, 2.400845342232875, -2.242561327200481, 2.9189172579837974, -2.6311341631552994, -2.6283826283301717, -0.7445791175657553, 1.6475176768386344, 3.0838563451665406, -2.039748809401529, 3.812528201207543, 2.0123004659191364, 3.615536465743473, 2.9375940057626577, 3.2264767983316847, -1.9128754772382108, -3.002959230543118, 2.31279838206655, 1.141761241683894, 1.3582303892371677},
    {-0.35152147158003405, -2.4809339760405553, -1.6975611541334639, -2.6807587323418605, -3.3764826438393345, 1.896611300813175, 4.827371611778942, 1.9913055153775316, 4.341427162803275, -3.2824878148915673, 4.647188934530551, -2.7397600307647942, 3.8606211151455048, 3.688597221968974, -2.295199348753383, 2.5821980343260575, -2.8064201798549395, -3.409378232393164, -3.1203944908518424, 4.716667169491356, 1.2162821855962984, -3.6573890487598204, 4.425357714527562, 4.385697771067957, 4.378037907747735, 4.12420261248223, 4.8668749020872015, -3.1998305328973076, -3.5024950357607825, 4.17943278455555, 4.576276848055875, 3.3213402451702034},
    {-0.17914794316214114, -3.9706631311592298, -4.906375274148372, -4.5174286807463195, -5.596096479064638, -0.23354874015567545, 3.8352102774128864, -3.1020391981109383, 4.6029792489259735, -5.309706915890362, 4.663456655490204, -4.6567018814269705, 4.022411045228328, 4.364784748843411, -4.032236184013368, 1.780059072257391, -4.6129219587155506, -5.689337560227645, -5.105452256097792, 4.080448024992119, 3.464243024959274, -5.220783626769719, 3.919181962586668, 4.230168362865999, 4.038978999659056, 3.7744445637519113, 4.560758343549866, -5.044144107930044, -5.4084768734415425, 3.4410020165066855, 4.241982256693871, 3.474174551009626},
    {-1.7998068892100425, -3.219250247127229, -2.6520513629782667, -3.100391531508345, -3.9034947056678817, 2.6624650396960137, 4.581721124296308, 1.6049131637856775, 4.375266828700138, -3.80007134775186, 3.8912585391583194, -3.392616209925541, 3.7115212516311122, 4.358555552534175, -2.884636873575081, 2.9301050354762768, -3.479746656182418, -4.137526441048132, -3.821457486662048, 4.224109594281487, 1.3453458503814852, -3.4105287829027433, 4.0964425477322095, 4.832395225528288, 3.6284707262375964, 4.550729773601323, 4.6249719556615565, -3.7609318522655792, -4.129260134772031, 4.155449013394909, 4.205942068728414, 2.786581259109185},
    {-2.3242712517122945, -3.853862754808781, -4.76678067946994, -4.874144271999599, -4.82152647776191, 3.6699361938548587, 1.4666821345592485, -2.996155789975802, 0.6011556807340471, -4.454176819029641, 1.6230572217333286, -4.5696271841020835, 0.7380722518645848, 3.135356139223831, -4.804551070373154, 1.177891453870363, -4.634510107892926, -3.8088811419058883, -4.5577564889241815, 1.5132766968179556, 4.120379957540859, -4.3812447785848185, 1.7273887789335947, 2.3743228431973087, 2.553182904002574, 3.4101895084379303, 2.238184876290106, -4.2131488556718235, -5.303266721791404, 2.4514395220700935, 0.9034686565069997, 2.79898749218745},
    {-1.7762436137898878, -3.3025536946168095, -4.31699887779053, -3.9761014928561877, -3.8250444320247774, 4.737476164057267, 5.08699408599746, -0.6262519836741778, 4.259706088450941, -3.488963285134501, 4.880607842268714, -4.284108296825548, 5.0930727779582545, 5.119601548332764, -3.219447540738469, 5.4058959958311865, -3.7884839857759163, -3.2950887346703377, -3.083626482891755, 4.341491658063924, 5.160482051170882, -3.9035027665890247, 5.540306245289585, 4.591562451499315, 5.327705222029636, 5.167709998254619, 5.3725708386675395, -3.0260614000913018, -3.7669198210115806, 5.031931817193067, 3.7892402075244873, 5.236272021626668},
    {-3.911325314535708, -4.088350954069802, -3.9176934626637654, -4.675428358049352, -3.7521533088135897, 5.7358554745925785, 1.8637869457996217, 0.7080931247483994, -0.007673629851353752, -3.2729300708351254, 1.8348979125494538, -4.177297584281187, 1.5867063815130247, 2.6958034112165277, -3.0762053257979862, 4.4257092816011, -4.095582113419707, -2.414966341914566, -3.4385502937206045, 1.7869516594939627, 3.4446994110373885, -3.237195405748942, 2.745136163274344, 2.2143308304069764, 2.3652452505905965, 2.835810312888595, 2.631689155389314, -3.2075208021872337, -3.840167699474139, 3.1112326669140695, 1.208807302405676, 3.7530226118180186},
    {-3.815307006092886, -4.533755429408457, -4.61615554057888, -5.343111877742648, -5.084664425235284, 3.2008236285147986, 2.6433260206407736, -0.8001788351197796, 1.6097244910598119, -4.99930613836778, 2.941748035346162, -4.062961608999604, 2.1132279130571665, 3.7278471753652216, -3.750760591214094, 2.2447557509077094, -5.168088508463282, -4.481258061478842, -5.498305535371136, 3.50286567679168, 4.041104418951273, -4.517088553212675, 2.350068121212613, 4.222504059302175, 2.6326372464142858, 3.501549562970936, 3.612696814601292, -5.580676926143984, -5.226521800363809, 3.486179541262443, 3.4878024125245166, 3.9141171071118417},
    {-0.4370559588287293, -2.2568469857831763, -2.6982926929177817, -2.68055313308097, -1.588649219098628, 3.2645970993842544, 1.7353352385208156, 0.423389037050604, 0.8534246247256522, -1.8521227342333486, 1.0637623929334568, -1.974049620130614, 2.1353068115942575, 2.5414131930577004, -3.4610710190597054, 1.2108483632521316, -2.6311196885742327, -1.2759226066257068, -1.079807003287536, 1.0154628197835336, 0.3957594526016944, -2.315009025578965, 2.2597955479396314, 1.1590982832385357, 2.322934582426421, 2.4781069749176896, 2.277798272341263, -0.1671202510351786, -1.9152716958382985, 1.276535759127336, 0.005140387955834413, 0.720363925008163},
    {-1.6912489113978675, -4.497979263607257, -5.74073410547589, -5.252178818837961, -5.567030663483301, 1.792644683651279, 3.6758926181194194, -2.9314872686735396, 3.583788874796979, -5.165888121389338, 4.421305459438721, -5.225982679595997, 4.337353311154909, 4.196485125019702, -5.283474212793176, 4.967073964471488, -5.113949835329451, -4.904196557661261, -4.648654164599072, 2.7364214097166677, 3.627682086390955, -5.333667122574881, 5.000179501399209, 3.8311920967676545, 4.7463131062585635, 5.024855037878666, 4.736468397861841, -3.995896141945903, -5.7213402568759495, 4.12934293414558, 3.090663834288754, 4.312439019774239},
    {0.7386281697126871, -1.9985199300523833, -4.150620343465405, -3.3941212343054628, -4.457726710357008, 0.9484590736452259, 4.0927705943332855, -2.75874634883802, 3.480410969194117, -3.947729148237342, 3.9587318487535472, -3.9972256067289127, 3.5126634664148457, 4.075662727460785, -4.420165964319443, 3.1209854547742717, -3.5649578126187196, -3.8760504934846884, -4.005381848307363, 3.5505869616726393, 1.637832938998327, -4.2884470786859366, 3.7870733048687675, 3.5533542067598463, 3.8635287051589375, 4.043173953979301, 4.220606771215867, -2.2216178352545053, -4.2047813309194195, 3.6380796983476067, 3.8156449508818158, 2.8575436521942046},
    {-6.077447376231213, -6.652709737645449, -4.002620723772944, -7.2223742963880015, -6.458806265164959, 0.6736868707089244, -2.3038645186020372, -1.3212370697715803, -2.762863572483508, -6.616691336087788, -2.4970876217824034, -6.079277834718402, -1.0446642823374155, -2.9864281345406685, -1.453466343809106, 0.7946555847743623, -6.661798516952528, -6.402589153764762, -4.939469631513805, 0.5822302264728682, -1.8340446258190606, -5.927968543887427, 0.04705949127809748, -1.4012701291326704, -1.1258318569499663, -4.780013152939542, 1.3784587252752312, -6.045406313540945, -5.653624257753245, -2.071944284325881, 1.0648519375895165, 1.4780302398117575},
    {-5.463710855946963, -4.9540318989386805, -4.553142112582034, -5.168481599603702, -4.299144272468427, 2.8687619846154346, 1.7651569831704008, 1.8470013898640083, 0.20170501575844518, -4.655760224191345, 1.142889087184519, -4.8696957739199505, 2.424703807750359, 1.595764979442825, -0.050372340595063826, 3.8496938470762676, -5.432029963859517, -4.508525521447122, -3.7326501246616113, 2.5840509761350177, 1.6859270795093013, -3.620872459914912, 2.023959372525633, 0.6961518457985922, 1.7865073397366187, -0.6436229181791958, 2.2870319067893594, -4.484720752474173, -3.606556825925006, 2.2921456889756775, 2.406725232114101, 3.601883332591099},
    {-4.14635650969629, -4.0373601526830045, 0.14763584286617196, -2.630829335704797, -0.44879411996955676, 2.7058245131740257, -1.9900205774860735, 2.642012337320279, -2.842920538171241, -1.2682575319551126, -2.7477765277114847, -1.784320411286578, -0.7366382542821545, -2.969001395769699, 1.0127176299566405, 0.3976694349211362, -2.539041934919257, -1.7093910189935166, -0.5771130381308063, 0.9053394625784681, -1.3828289244888758, -0.9027214933449224, -1.0297652441943355, -1.5802289130230118, -2.688990076263543, -4.002011090302592, -0.6566582312135526, -2.421325498526156, -0.35126990448092776, -2.07322468069097, -0.2609796772623823, 1.4213954529319361},
    {-4.089762463177727, -3.0359190699887297, -0.15974417690064516, -1.8779858230207458, 0.058393415314826315, 3.143735904945806, 0.4233993339293806, 2.207994242665283, -2.937489112561734, -0.7069786599292907, -3.162694788400747, -1.0555671891762943, -1.1362351901972585, -2.4218345673666954, 2.1472097906360066, 1.1060198218615664, -2.2170052651332237, -1.8447903035778166, 0.6047049291299489, 0.788819094765335, -0.774746106190745, -0.03525648826953935, -0.744011089866759, -2.1183230461070734, -1.9269750278832922, -4.091418139507471, -0.9665801253135722, -2.0963719363473676, 1.568050723877368, -1.0132240886840718, 0.8693781536888254, 1.2334448468716837},
    {-2.7018381146587025, -1.9899691478183543, -1.308967714456018, -1.8964056764836958, -0.90522001602214, 2.4028600689024233, -1.2578736760936842, -0.1292727048056175, -1.439850199995693, -1.3591811583373967, -1.0742701753830057, -1.2416487687089113, 1.140612376587112, -0.9539269879216881, 1.006634035241611, 1.295277337037214, -2.629138775313504, -0.7720321524973333, -0.0987768506353062, 1.3211057336851604, 0.2709865656318637, 0.8053828202947322, 0.5341204671735362, -0.7425950112729944, 0.2537708164847625, -2.6065714693718367, 1.1656844844664376, -1.4680829057816547, -0.25765098963068933, -1.1492532540283769, 0.23866015618078654, 1.6056766559124664},
    {-3.0400610237576466, -1.830441861274041, -2.1400054064747027, -2.4054229870406454, -0.059610783484140076, 1.2845604926399334, 0.03400137917622793, 0.18657293930070587, -2.2823426216151885, -0.236671626418074, -1.7014986961050664, -1.1634701088573363, 0.2021082478972152, -1.5596699328932895, 1.0675491316600219, 1.3459188954905545, -2.457025531660247, -1.0003526895624457, 0.5264446265648337, 0.033949902278726914, 0.8171535287988624, -0.1401667938479188, 0.04202445209764487, -0.9348584204841686, 0.8484851739524275, -1.3029882552174235, -0.46331150881074024, -0.7977575293851961, -0.36887912466398187, 0.01621903618351076, -0.25741552288642355, 2.766056045700477},
    {-1.7989146464911474, -0.3696804611007552, -0.4368554446110871, -0.3177187800975795, 0.39433893809973525, 1.6033824859757377, 0.4397249572003247, 1.293112412049009, -2.267265641073904, 0.3898233823929547, -1.6548881623885285, 1.2619451643700157, 0.4578363514333998, -0.5488410640345923, 0.27191270464482264, 0.9879406155032819, -1.2693849921499674, 0.16622948413031685, -0.23547107938272846, 1.7144955175787235, -1.2207568088145544, -0.39209032656724846, -0.1760240713869311, 0.05494090521290654, -1.6969205034026595, -1.4709784003288253, -1.300388536380929, -0.7032239046828467, 1.167130203432373, 0.2761655059688954, 1.2600927214910318, 0.5334812113835011},
    {-0.425801303487405, -1.7795046147147209, -1.294186322446604, -1.8722939407422947, -2.386988022242933, 0.04485508459179754, 1.5641980522493077, 0.10347542251075569, 0.5042511037662459, -1.934784127601696, 0.8129364551419718, -1.3274700626420812, 0.7948868420641024, 0.2817504575918341, -0.8251054582807819, 0.9702958698344345, -1.7734808464237375, -3.3803762788020695, -1.2534150447808263, 2.3906707036430137, -2.2872063896148966, -2.4379235537685595, -1.100077745641061, 0.6806891312919724, 0.20794027530227743, -1.5900599016235515, 0.31568707482761293, -1.8365789418471294, -0.2876210952340417, 0.281921758677517, 2.04558041674167, 2.4646118449002885},
    {-1.2605000824975627, -0.9180359424589829, -3.1116082294284935, -2.7189806374323964, -1.8615229621805922, 0.07976965907263808, -0.4035983734942554, 0.08471089904318034, -0.8885190964895253, -2.29251426477156, 0.3771544087910089, -3.3710055590856896, 1.447341021006813, -0.38800028852014184, -1.4055100290386655, 1.8518221337350234, -2.7676803407140085, -2.915174377267397, -2.2519568348560384, 0.867420208303013, 0.20627514861997467, -2.588715033216564, 0.9499753492906579, -0.21461323622907594, 1.5858408814053653, -0.2550664507316327, 0.9958282064755113, -2.0450843230825324, -1.8885136081779546, 0.3932225884931193, 1.136481703093756, 1.4499194675780456},
    {-0.12239600927522737, -2.0192663526262704, -1.8379112546091732, -0.21534428024738095, -0.8087527756803411, -0.27069567269008227, -0.44901741558046326, -0.11512519669713203, -1.1439630803055325, -0.5279294403632745, -0.14401471432182003, 0.6970175237990408, -0.6441024845275959, -1.3132544297918398, 1.104806877131898, -1.2726850440514936, -1.6223746815541655, -0.009308187623926031, 0.4506578786256152, 1.112542291773231, -1.185010056562384, -0.40491980005966555, -0.2879016561575407, -2.4787711055646593, 0.28113454463439663, -1.720506470449574, -0.5715950876059529, -1.1521112618996308, 0.12620164828014144, -1.5182733536734376, -0.666192556282159, 0.7052338161795886},
    {-1.923413056509637, -0.2980427699721248, 0.8054183560565343, 0.5670631219914584, 1.8427282173826682, 3.194772909059034, 0.02949033532080951, 3.5271631489296387, -0.7728105368060402, 1.797369903475647, 0.5526670049378222, 0.9857839504291083, -0.5569600876242448, -1.3358277234359717, 2.8379014633921633, 0.94878703531331, 1.037764078766815, 1.8016109997581027, 1.216513974161613, 0.6268852267247619, 1.4594752922882563, 1.6051309287562865, -1.517137409877504, -1.3255562625543174, -1.9983537274165395, -0.5849903158202437, -1.341631532672409, -0.06435752993866156, 1.8324375395070323, 0.6888665787459486, 0.5105204869259325, 2.597132408389454},
    {-2.4499589740604666, -1.1934558896321128, -0.5019658593345703, 0.8333836953794717, 0.009557709028828087, 1.9111622154033614, 0.5563433392300292, 2.4877021136112205, -1.0860124184540183, 0.6100701614009011, -1.760285635286678, 0.7213098346676007, -0.6145943915548566, 0.3402366195986634, 1.1673242131461512, 0.00614509482912129, -0.23105251393349688, 0.15462816002973137, 0.18105309578492507, 0.06725237688268253, 0.699224129659303, 1.284211011836527, -0.29991720557261464, -1.9015235961611516, -0.9050847064476013, -1.0989790470317329, 0.3324781436018887, -0.3580607110715446, 0.7934283881986958, 1.1002291432466609, -0.8024721078928039, -0.010501479178648783},
    {-0.18591898234878612, -1.350586541786762, -3.305781702298597, -1.0544649613947048, -2.7592013923838463, 0.8484295647097077, 1.7822892795533405, -1.869958964371009, 1.2968858086781827, -2.479068197757245, 1.8500539079753042, -2.848243805111302, 1.7310653307355224, 1.6404667051662378, 0.6044847184245473, 2.5975014137008254, -2.7085644479407107, -3.114129414021577, -1.9300011427582646, 2.731792958089418, 1.703600821385534, -2.3989128120435135, 0.5762181564459173, -0.4395405961545065, 1.2959324400535999, 0.8183851550458544, 0.9420955733389307, -2.1239709605939927, -1.2585004585782085, 2.7862706601618212, 1.6134707761924427, 2.7796508954309727},
    {0.35362238916018157, -0.2425590235966063, 0.5497119681106969, 0.3394693752872779, -0.15025836644494395, 0.894888437571941, 0.39748050461345336, -0.09731826810984166, 0.9575232496421455, -0.2842837597915451, 0.3107607004198154, 0.5177793687021731, -1.1780829947607558, 1.9632419608157228, 1.2416000424480236, -0.46482723612875815, 0.028930759704242453, 0.41640525480741336, -1.8129996162463848, 1.8609324428874752, -1.1790323821917317, -0.6944488357275935, 0.3289853310885296, 1.3134380731687605, -0.5482189582472865, -0.4333340473651248, -0.05131778737377059, -2.2047858392845994, -0.7794655334862386, 0.8010529214375329, 1.219118083717561, -0.5366268184526157},
    {-0.16446045399778134, -0.3418445003555316, 0.002920212365019488, -0.4306302004092078, -0.08354308161469892, 1.3981620780779418, 0.505589927379377, 0.8575598912912907, 0.12093768585436791, 0.6120683810974797, -0.09800216707392485, -0.41796770280419576, 0.5101654301619412, 1.3941655552154362, 1.2260845462173475, 1.4064421189856389, 0.5158752395281027, 0.5643473900758877, 0.35244716381858576, 1.248029906999199, 0.6301928149509498, -0.38222118981198144, -0.5186147441662986, -0.8378120763445808, 0.3407816402727333, 0.6055873462881283, -1.2001415908856263, 0.23215597198319202, 0.7827623564017446, -0.7251247092478872, -0.3051006603188651, 1.119041340219752},
    {-2.0463600907618558, -3.191930448091921, -3.5990023030553244, -2.9688357748860885, -2.705435881990732, 2.924465873219825, 1.1587412718290786, -1.776721926628462, 0.04332776462213394, -3.207856736455058, 0.9218745586992366, -3.025615723546309, 1.1558184360548376, 2.3666774824465078, -1.0834409209891696, 2.234012329733468, -2.828544111800541, -2.0182799019858493, -2.7187595940744083, 1.8604856622143373, 2.4885695712552485, -2.4057994419066873, 0.4198518879259308, 0.6247164128791578, -0.2974090839977832, 1.2431401250123735, 1.3744867198306125, -2.0072292359687167, -2.5537804492121383, 1.6688122085217927, -0.43686974840744164, 1.9014283663707319},
    {-2.0943267225896407, -1.7960506668586596, 0.08947057381023726, -0.08006406039350719, -0.021888006127306275, 0.9838197438300413, 1.1679884606591762, 1.1322287931773773, -0.0651898590364444, -0.03462331801053554, 0.1699842737754136, -0.5845955335141235, -0.6534550582002574, 1.2914064165045174, 0.07171924855618775, 1.2421127311000264, 0.3127710681520709, 0.2121695744383621, 0.008013649062842777, -0.42735946028137495, 0.8218091313754249, 0.6125131806270252, 0.5777001319659029, 1.4921267289812148, -1.177097808423485, -0.6482875050866588, -0.274183415027258, -0.1363810697547433, -0.07175352268278291, -0.207352072749233, 0.8409846638957006, 0.7963840040091603},
    {-0.8148061229442829, -0.7646308615471733, 0.4006540893521989, 0.07684497788957538, 1.9549425240774025, 3.044681623298031, 0.869199520250794, 1.804389958098693, 0.08034236355107834, 1.1382937131963957, -1.0068713319591434, -0.21956139648545492, -1.2465652623027088, 0.4994019934080357, 2.0530489100917375, 1.8809588571399076, 0.5175512728663433, 0.6836309374184472, 0.19101872662406755, 0.1392006995127271, 1.7090959473014908, 0.15575583517137176, 0.08727696921240032, 0.1064048164464245, -0.34602425696663075, 1.4734915841801677, -1.9064167310758924, 0.2938601700378117, 0.9664674891123218, 0.4325679297817296, -1.4103599236951943, -0.30274744927094305},
    {-1.4465939179832308, -0.5352758223522537, 2.1084895299105044, 1.3279734498556865, 2.5239513897565296, 2.291530300364904, -0.8860766293658724, 1.827709005989858, -1.62560231796445, 1.9714186630538324, -1.2397739125020801, 1.1166964373426091, -0.4022329952688027, -0.49238244721270846, 4.0654831744420825, 0.4768877549689964, 2.2608682444016335, 1.261747947741153, 3.1654980259513215, 0.6352304254094281, -0.4678965354595389, 1.2247107922793452, -0.6432910551665061, -2.3616721567905787, -0.5323905376283062, -1.6915201186137778, -2.532261518161984, 1.21033390551221, 2.8880890282996803, -1.4396559141302172, -1.3275473416861228, 0.6877855799472239},
    {-1.7946344623138748, 1.0232405348715576, 1.5404259399089524, 0.5818405134578918, 2.0603004354022185, 3.3414640101098225, 1.0885218717090697, 2.5621693805733443, -1.2936155293287195, 1.9679138855941085, -0.7404613663293845, 1.0266410270206416, 0.0506316714914957, -1.386150763132664, 0.3221450157077636, 0.23686859676888392, 0.9826154919441072, 1.1697471612529398, 1.0120200182548744, -0.6544513617984051, 0.2232507134410622, 1.2169261975346348, -0.06519404249018487, -2.2064261751052796, 0.24540404584077885, 0.012816376751602692, -0.7972611935446497, 1.174841708204012, 2.034803400225783, -0.6791509609735479, -2.296805831202127, 0.714215014912691},
    {-1.5828785574376474, 0.7135928376532971, 0.29240201536932564, -0.31691476086866593, 1.6850221483177388, 2.490239549264695, 1.126490938422042, 2.9732305303294844, -1.2005603377279648, 1.2094682375640564, -1.3401176885548518, -1.5085461218188432, 1.1834343513808092, 0.22539831876968644, 0.915987848632089, 2.3526385127945626, 0.22919616291603193, 1.5493208955350142, 2.967907228593471, -1.2381234168745106, 0.626796218576656, 0.5768869529532153, 0.7446910563464939, -0.31141835254094163, 0.6813360850476781, -0.2329825517773039, -1.0933510201289036, 0.27847625967372625, 1.907229868659525, 0.48519520441023517, -2.1715184878555776, 0.17277821303317975},
    {-0.5599196050921856, 1.6965043239402349, 0.6236224385864179, 0.5981279544326917, 1.5784325924915041, 1.3453568994583278, -0.5287929105672692, 2.3383045180519315, -0.07402653287707625, 1.9328791762626525, -0.6190058611617978, -0.562658497241924, 0.8703399969424274, -0.5329437671592459, 2.350621786045861, -0.3869957312256608, -0.14458561135771508, 2.272904211369405, 2.6730287489799514, -0.14451670030579963, 1.6650987055056377, 1.0675338576931563, -0.6525138234933225, -2.6573471785848457, 1.0957134285353303, -1.3199180803741026, -0.8765273351964125, 1.2343922645596506, 2.472666637559217, 0.6829201498977394, -0.5827457922439239, 0.8876403886060261},
    {-1.5449341130813783, -1.646818744352081, 0.5949646640634281, 0.9535098494461252, 1.0694270520783073, 1.3777260555657806, 0.39770391333919625, 0.36825743924642396, -0.08204495837503924, 0.8154385731160868, -0.3697078610730042, 0.1944903079965986, 0.6827775620119704, 0.08710906908826609, 1.3658825270071522, 0.3956199626125455, 0.40342237432451866, 0.9683037189581136, 1.063087826945324, 1.271508120203305, 1.3915520117524076, 1.0823329982671184, 0.6103025781077344, -0.48083144675740846, 0.5868487020820217, -0.8109146272980271, 0.9168415704430624, -0.14439383395935454, 0.496259784964485, 0.15400794795913444, 0.40813387892771374, 0.41905893262776595},
    {-1.2472150134590108, -0.3750313547477884, 0.33192037644102607, -0.9380168541414726, -1.4362586916737796, 0.7749319888458718, 0.5347365833067926, -0.2201743358006438, -0.07861349801198908, -1.444617446357962, 0.5308257113144488, -0.07688082726131881, 0.03167959352939885, 1.6582914029631157, 0.23043230630103198, 0.8046238200822049, 0.8178991675331584, -1.5435154833915745, -1.0154628688885163, -0.6287048480127084, 1.454899490189755, 0.11778819437066797, -0.32399491210150166, 0.8602072806404312, 0.7569385863388272, 1.3644216201796162, 1.4110258072350093, -0.6159745496326035, -0.40165210841289567, 2.042089869508273, -0.5586879622076628, 0.4265904210088562},
    {1.2050875131316015, 0.03754762929271343, -0.8601488777817622, -0.8781539775252297, -1.5832299172594695, -0.03254009811082095, 2.095427886972781, -0.05136699539790052, 1.2061931073950576, -1.6031823429392176, 2.440713316946531, -1.4313617380320895, 1.8602246335354484, 2.1774288138752405, 0.3945661532826441, -0.08313393714872423, -2.6492208584473436, -1.2060308769518, -1.7966193998472821, -0.15113292519945232, -0.2705461083902, -1.7148939223310484, 1.4782090588643586, 0.47341851392275464, 0.5847615646682429, 0.7530214261654827, 1.9403155294065209, -2.2816613388808675, -1.0977965637813392, 1.6974869711973173, 1.7553448831394358, 0.34792537176585253},
    {-0.39744984695763313, -2.114080987648127, -2.044810775686844, -1.2212929792297968, -1.258385426393569, 0.11842735356239777, 0.27146633349973276, -2.061033356622033, 0.36010169122520225, -1.2965732635007818, -0.6292819938240359, -1.9384112742592903, 0.8785037969119893, 1.4369818812487845, -1.946212905910529, 0.6824501211791923, -1.2639028626495592, -0.4064084899344754, -0.3161285283929264, 0.42165391947166064, 2.060712119111625, -1.3725285258143394, -0.08602588292794722, -0.7538694003475377, 1.2359322089929894, 0.10704486358924843, 0.11286904363514226, -0.7406560869581548, -0.9125935459403961, 1.6557945253067354, -0.04236623007129515, 0.4392035855053111},
    {-0.06929892308407505, -1.0752243958324443, -2.3333336570962175, -1.0637616360711553, -1.624401073102446, -0.15910172568693767, 1.200571029155429, 0.23523430314872149, -0.08116786731408479, -0.6137987217365992, -0.8238255465472498, -1.0379589704291532, 1.379469730216367, -0.7931517187687689, -1.116962642158291, 1.0296242285191046, -1.5863454495837725, -0.54279861470163, 0.8120701094217407, 0.06654964069212466, 1.0457845757925517, -1.1215938902078983, 0.9388259278175352, 1.438639647508494, 0.6718708415076549, 1.2902544567416403, -0.03263345037681246, -2.158645573544127, -0.39589235741485107, 1.9493955485327568, 1.1483235026210814, 2.0567542606772133},
    {0.5426429439891363, -0.4259719748349, -0.29124420645171395, -0.769572561346111, -0.7779028167715835, 0.0768862453249281, 2.4738831794928515, 0.41494243285699867, 1.8231899946165202, -1.0046430089234666, 2.5137470991295783, -1.081056290963574, 2.0831571718016884, 2.6849535396722692, 0.6421685664530276, 2.4588891631834726, -0.986454965999759, -0.3252302953167524, -1.132108306209837, 1.965405657295204, 2.1740396524635206, 0.29594708623078625, 2.3956560943745075, 2.8915663195326364, 2.3332071845729843, 1.4870839427807963, 1.7463109341819658, -1.0632099108615722, -1.4129883795802407, 2.2147267081812503, 2.1288300556903765, 0.9400829713967729},
    {-0.28307892532718215, 0.06944553474629438, -1.6009698862501673, -2.3846860874994715, -2.191331935860072, 0.6990320668577553, 2.675043271415536, -0.291604933250446, 0.5664064532925143, -1.560859239180646, 1.759567752033839, -1.5370338326067334, 1.934127045164048, 3.1188647462343804, -1.0818871486649664, 2.282689362318854, -2.4341249842704684, 0.23125517650932026, -0.38253251881351247, 0.8616651522329897, 2.4328715049749174, -1.855237837478838, 2.2482080549149592, 1.9340370544295746, 2.1132281946889053, 2.1679530425143585, 2.087803432120847, -0.9216606066542844, -2.5718117178013786, 2.666043568689111, 1.604172571451718, 2.655599539242347},
    {0.014862136394466237, -1.5194125114544275, -2.599568099243519, -2.9406778194378393, -1.8856225134915277, -0.017121148864839654, 0.948696967740383, -0.4996875023094778, 0.46472076169936205, -2.2933592830519474, 0.12056624946785288, -2.7190248932390215, 0.9217324285526011, 2.6363981021694345, -1.281421447407399, 3.1212728611577005, -2.852467997488605, -2.8277783340994334, -0.42130075627675595, 0.8798109892650959, 0.6066440729055498, -2.33780754650913, 1.2519732309033136, 1.4341899269793745, 1.313597970979788, 0.9323560860764422, 1.5111818455003108, -0.44390429766691525, -1.432470402163914, 2.7377531873681082, 1.6380695095672557, 1.0224400655354438},
    {0.23404769584001, -0.12929921077971124, 0.17888277753732085, 1.2423649788455542, 1.6646105633206243, -1.4999567910955087, -0.5262876116712624, -0.6579080699767038, 0.21271638974716475, 1.1946657712590858, 0.8880842070848737, 1.4446142366635781, 1.4453038801911184, 0.5380705679728888, -1.3287545547415258, 0.5316525466669819, 0.347480314067238, 0.3911471834133167, -0.9771609930059043, -0.43124085473377965, -0.5103765225988436, 1.1311872252500004, 0.08260025514712009, -0.5066672666155032, 0.22546050724005426, 0.6848756701293364, -0.6653229575981958, 0.9838185417742146, 0.1696033673539958, -0.3430397654639974, -0.9822330403933195, -0.9346155691108183},
    {0.19773103328891004, 1.6387357875616826, 1.475952662165424, -0.020099136696407383, 0.22057804323669938, -0.14098699946512236, -0.6011679772025113, 0.9867431441835524, -0.6186101575184471, -0.1272434707234989, -0.5614222276592273, -0.7068967003259166, -0.14671379320688613, -0.3765412102811192, -0.1675660040567774, -0.073930691819506, 0.7726070294723152, 0.11443613781653873, 0.6436712055968207, -0.9176466207059603, -0.682425361520771, 0.1251544392672683, 0.15940815198579203, -0.2274495275299497, -0.9574942003095128, -0.43487827421590736, -0.09339555667912357, 1.375165490654449, -0.7348908477588367, -0.9072386999283295, -0.5959342950419747, -0.8670088440972833},
    {0.17828959403835648, -0.09139328567786957, -0.4140210859209354, -0.6925605915959888, -0.3336733493341304, 0.09472207758558797, 0.7803690927515271, 0.2546528899586298, 0.4117932130483807, -0.5341710796393591, -0.6853631302557179, -1.2942593018309958, 0.26249624991654, 0.35882589067566645, -0.7304094895525336, -0.579336688939437, -0.2223121767696641, -0.1924727140639884, 1.1745741803330954, 0.06037334224773558, 0.6986276927050594, -0.6794554563698194, 0.10629636391194762, 1.0147312873468635, 0.9627921732984599, 0.3605037900813714, 1.2829364677518922, -0.7941462329551665, -0.2147143244287685, -0.0850628738116444, 0.4656350947505829, 0.9428781550058677},
    {0.491874008001036, -0.1117555376357705, 0.26115431846947484, -1.570718291584389, -0.052047006181570876, -0.14964173001783432, 0.3215121925293681, -0.15561260442869917, 0.32085004452262034, -0.8148804015344955, 0.6768920948420919, -1.3447269200825496, -0.5012522377141221, -0.1339574113593453, 0.30222619010068336, -0.04605574940076636, -0.34115491869811926, 0.3560065377226811, -0.33316603115615784, 1.1493795062829903, 0.8163742076652066, -1.5915846580302344, 0.4979661048514129, 0.694736188649963, 1.1680589528204484, -0.1926203942049361, 0.8491523111022431, -1.6259510475631842, -0.5208886523551233, -0.2785204726393829, 0.7420317869819566, 1.3434096160206639},
    {0.26122711655235664, 0.5815575751704948, -1.0288614468861594, -0.20317343624428333, -0.7576738332497316, 0.7074299007033727, -0.47198247823312856, -0.520057607773033, -0.5745723186014264, -0.7133233171187844, -0.9994278500143925, -0.6636860262833438, -1.2927041501518728, 0.2515954694792244, 1.8998632073938375, 0.37145898453494974, -0.42009521762083946, -0.4247911606272565, -0.022803645074086415, 0.3925349289469053, -0.673527416848375, -1.5406599641748449, 0.6387606981718699, -0.8403738894253849, 0.7117221068466669, -0.7980394238867724, -0.49162104721355193, -0.20106219085151325, 0.13008664480795004, -0.8608638015884598, 0.22219907854095675, -1.1327359816705964},
    {0.7035938675895421, 0.681569502859061, -0.459354170545278, 0.021666896896416838, -0.8801080965251521, 0.7879221224775733, 0.7078195836114393, -0.16598504411251533, 0.47023530201893593, 0.14065262287648098, -0.41028332316727234, 0.03233825678229688, -0.11372834952694008, -0.25178126261506817, 1.1275447518891084, 0.4529534361282051, 0.48711494660398813, 0.08702205242995573, -0.26920417158188065, -0.19735905299694678, -0.7122455574717572, -0.20065308683555708, 0.505596278323275, -0.6418382411756806, 0.5816640374964137, 1.256173945853005, -0.7578499252680596, 0.5073254388199282, -0.10664752634818914, 0.514962680594482, 0.412969454491959, 0.12940942393467625},
    {0.4195850298280087, -0.513638287358017, 0.4334187786984029, 0.6251525389142079, -0.16166737817245788, 1.4730707522650104, 0.49761281730998536, -0.06831016969062452, 0.7395188446262808, 0.21284287790420758, 1.1924349405796326, 0.4355517490693653, 0.021872390933530484, 0.2962854551477381, 0.006887716454332922, 0.658111069434154, 0.022121302355384165, -0.5054340224634746, 0.1064166015466539, 0.23823833444248654, 0.7625339926688824, 0.7072294429367283, -0.6683710976847478, 0.2149856562768808, -0.45900730119396543, 0.5437150185045394, 0.5358776681661886, 0.4512065046548078, 0.022703320172422263, 1.1341400984016414, 0.3400981137223289, 1.8554039978600916},
    {0.11300156760346197, -1.1349219342657884, -0.7580520792590076, 0.12049297393137512, 0.01896232599672575, 0.41155016522454335, -0.549145337610688, -0.5463494006165229, -0.6699175256183463, 0.1884397090347499, 0.2688066559426106, 0.466352426348283, -1.7186823057858802, -0.8920747901543157, -0.36674491092716827, -0.880638801705119, -1.3887240577710098, 0.5683569187800869, -0.9464103340378675, -1.1706754701749251, -0.56129350473068, 0.1906485971302984, -1.1522447665476923, -0.8467580620063074, -0.4662118629524404, -1.0992532275989189, -0.6701719084807748, -0.39633175819373656, -0.1794634547861545, -0.27231840733453444, -0.3768362945114557, 0.5984694328814393},
    {-0.04492616288752045, -1.014524674002575, -1.4874982399360324, -0.16349267614657398, -0.24357430513787923, -0.6378426720090472, 0.45552812323124664, -1.16900688302982, 0.5302183131785272, 0.20873243273307127, -0.4548600197122801, -0.9148710292545423, -0.3263320867952313, -0.3513103799061108, -0.4769574416866579, -0.6700083462562174, -0.8987649556861395, 0.6758513349207641, -0.09061814457544375, -0.3095530542568921, -1.0155411538858565, 0.34750810069806376, -0.8033251282169726, 0.5928195587148005, 1.126391407135829, 1.5517515923641316, 0.08075482650046141, -0.8973817941532767, -0.3160482923406943, 0.5134616085604463, -0.07406353026791633, 0.7406584385483942},
    {-0.15620015978943153, -0.7132244896353109, -0.2650078416148976, 0.5794852469376467, 0.065467743451311, -1.1761444935946477, 0.22028160704422664, 0.27776188989745404, 0.11007347311548407, 0.9669912608431686, -1.350719035790079, 0.212160061454691, -1.0244341146023863, 0.10685498649762262, 0.3356575147194663, -1.0040174226715437, 0.6295741139677323, 0.41268395367590305, 1.4603535798256388, -0.3285340014823682, -0.7279399011588152, 1.2363891679583896, 0.10252150133675818, 1.1258739352063347, 0.1312125427046356, 0.11613968405927591, -0.1241412396454341, -0.25158497626535625, -0.036479524294633116, -0.8876072919209016, 0.3027361521279365, -0.07575329023636844},
    {0.6034013101391399, 0.30725048723422893, -0.29515013052529276, 0.20636504933158875, 0.09820573865374818, 0.48363692629267807, -0.33962239486633294, 1.4940856108879121, -1.105846426335639, 0.988410455085627, -0.788144716343834, 0.2812699575737999, -0.41325156567356647, -1.037083430604843, 0.30242983508104515, -0.6517848715779807, 0.5712285233489508, -0.1399981831382267, 1.1324969234081246, -1.054044838986541, -0.9576504001977393, 0.5158821983333551, 0.43437551607975144, -0.6529646167153735, -1.3084739213650454, -1.0823950234204833, -0.3138233153314249, 0.7075039650538705, 0.5659961919723171, -1.2243406154595153, -0.6788865234548289, -0.6130477753214797},
    {0.18941003673764217, 0.08558920370427599, 0.0781152106432197, -0.49077839656575384, 0.5511203012736734, 0.26444779921920336, -0.3085568332282797, 1.5221671059242627, -0.8887662269121872, 0.34322320167841713, -0.7916949769376076, -0.7198600395608926, 0.35048565711890955, -1.0794863345955321, -0.8868249587835394, 1.5142772275394087, 0.03261280911425154, 0.1414445096173449, 1.114333427797473, -1.1286564756883488, 1.3991671541190291, -0.3692299110282203, 0.22265712431127846, 0.07278695616176765, -0.9448241418901994, -0.4667465489990515, -0.7727803104308159, 0.8279367021293315, 0.3450095169430472, -0.8099141186543248, -0.1153585050975522, -0.7977028079686409},
    {-0.3299152140639722, 0.7682728820042816, 0.6552563630924949, -0.830816819202633, -0.19797126940393867, -0.8865218408358314, -0.04434940033007245, -0.5022119998632337, 0.23599991000273315, -0.6090983636868207, -0.22656783977716868, -0.8621828348196264, 0.24769102630796366, -0.34680136163404307, -0.30810553473772706, 0.13147257585840172, 0.272013887376317, -0.6153880370854627, -0.7868460085091247, -0.18639087516557276, -0.04834638553858659, -0.4873148313076057, 0.37296857876206124, 0.921075319146021, 1.2907628727512694, -0.2285972864702074, 0.2951366369610785, 0.1492987057465443, -0.7034027601943248, -0.07957596085294527, 0.7972098362177649, -0.6476749012352605},
    {-0.03507198245749081, 1.0387744861617243, 0.7023981445465096, 0.9645774302623717, 0.6601046735068408, -0.47642901645752594, -0.9323053349953094, -0.545298751383943, 0.058456197637791536, 0.9040136363493841, 0.5428963674411266, 1.207272465202298, -0.523724232341586, -0.271085590153584, 1.6886003593310075, -1.5737783777767356, -0.3019920046835523, 0.14224468264724724, -0.20632540474158853, 1.3349612146879362, -0.6085258397503747, 1.359998292408854, -0.8399041657676025, 0.6262281035662145, 0.17474032222750122, -0.23012431400498107, 0.4704625446892966, 0.21429701447842922, 0.8914056407230204, 0.9228487495004647, 0.7730669753074815, 0.29217411651006137},
    {-0.640914796618804, 0.21923071165877753, 0.6587287695127312, 0.3823781895591652, -0.18452594769575553, 0.4151492529395494, -0.2881893973650516, 0.673193236042502, -0.5567595035284049, 0.5935632522295162, 0.9357841939232846, 1.1138681247426967, 0.7746776162297269, 0.30276490354848923, 0.9589612220441011, -1.5279324724762176, 0.3635057032404949, 0.9131839451296192, 0.10986825284028727, 0.49154229853084247, -0.2839492713533211, 0.6401485307247627, -0.19941880789772903, -1.249611586483968, -0.42560081644283576, -1.1553853089172237, -0.23178858396231733, 0.3187809283114413, 1.3858477500195125, 0.39003703307778687, -0.00303961411307557, -0.5792123882586373},
    {0.7134088529004512, 1.2010840516937722, 0.12928665656099886, 0.14355457788718784, -0.07537417725248079, 2.4742305802689555, 1.629896500030788, 1.0302424711717069, 0.532104969698275, 0.4444849979261867, 0.8443499520193292, 0.1424994491723641, 0.38071320473752107, 0.19854559453678639, 0.978671965589072, -0.31955092694300663, 0.058005370271351255, 0.6077490234352081, 0.4214253963504628, 0.7216746113584948, 0.5988788640350112, 0.35225488660601284, 0.47453252996497497, -0.22812943677318445, -1.0341102269758697, -0.6622139399272866, 0.6535150697736012, -0.11815950862801299, 0.946396444342458, -0.34429460089323877, -0.12869106728376076, 0.1372060606803143},
    {0.7171311227006069, 0.07338590243522798, -0.9384148938464312, 0.2812728028271905, -0.08810733945613036, 0.6296843469171365, -0.1953218056799158, 0.09023886322722152, 0.461952264216951, -0.2683887554442419, 0.09026146211536222, -0.4936579742164954, 0.17541804462357186, 0.19917457169600747, -0.8213562622797774, 0.69832891126035, 0.4181277441636043, -0.2487042215182067, -0.14225031856665474, -0.43400754069640674, 0.7922392589992292, 0.3129499624367614, 0.41637236391292726, 0.7027594462819415, -0.42251394470704356, 1.6788447355491989, 0.1944649533849724, -0.19057685949613548, -0.5220120062463507, -0.15566289534702074, -0.6187704267743128, -0.5280950110746809},
    {-1.212270127366916, -1.2113682848981253, 0.45653743897419713, -0.43489758457983296, -0.7172456285805179, 0.04016890278676049, 0.11342446003301683, -1.052860658036854, 0.18094313342114474, -0.8980311460371342, -0.6889179142565951, 0.3740010947949126, 0.8126405576976898, 0.40329867693933, -0.23981080624506115, 0.8845970769123583, 0.5714216596893641, -1.0915936495974747, -0.9359670261212243, -0.08828729274909007, 0.6333550992510117, -1.0105518567203855, 0.9038167219535612, -0.6504133792447444, -0.6556590945102215, 1.0508073989301863, 0.865591225510107, -0.4480847164659577, -0.7453869981391248, 1.3523973028594227, 0.20501155641975294, 0.42496256852820785},
    {-0.29220063776840666, 0.07711999756997977, 0.8114695333654721, 0.41620818057738745, 0.11883293372100559, 0.2911469231189727, -0.22902236061775433, 0.0011793569046929242, -0.16891418929355104, 0.6817747023352779, 0.4173420527374464, 1.2508992340799707, 0.5750521424514758, 0.15003048138954003, 0.08273819625060531, 0.3406045647566693, 0.7346333223430742, 0.26299623931533134, 0.7306619283241929, 1.0143810527661243, 0.9071309658193089, -0.38019992313987583, 0.5939013773079801, -0.290682559776407, 0.4364215625679806, 0.39904416304729956, 1.2461935709003993, -0.035829586769449744, 0.6327836665561598, 0.7851681416067287, 1.2392463665181637, 0.07844623057135437},
    {-0.8852613390835206, -0.5264363492953811, 0.33225552425519433, -1.006239239123835, -0.40204529737830824, 0.8678574807318413, 0.03173435820958753, -0.082944272899908, 0.41082590377025174, -0.8540603253081902, 0.7867114944391177, -0.6079259722351412, 0.4182357229470297, 0.9222729363083567, -0.037453816752769604, 0.36847162552743873, -1.1632280439715386, -0.5329772941593738, -0.2503184190926956, 1.8070095164391335, 1.8581559560677914, 0.12238866614988295, -0.6650391729618785, 1.7212212110870313, 0.7802395007527643, 0.28156764161193204, 0.48797478628637736, -1.2646317779296024, -0.3394305045163311, 1.0707602794329807, 1.5940085898273813, 0.3902503601104866},
    {-0.30124823244456556, -0.5973028377034131, 0.07881277147790748, -0.022418583253783493, 0.324378202992355, -0.06815072913432887, -0.6971404908728303, 0.5071635717804616, -0.2533754865753456, -0.3480387672498244, -0.8100400657085214, -1.1256916890467923, -0.777113654547452, 0.3118070257380083, 0.9274754156681208, -1.0537652185147555, -1.3854636575339363, -0.7611097848109026, 0.25490436595471544, -0.44467569076308666, 1.0428214952480732, 1.191739011854413, -1.4679428193724215, -0.027654554902276102, -0.11780400062499286, -0.8640996074526678, -0.6465102512340396, -1.1844043972416518, -0.41039298084016446, -0.02814509110119877, 0.46080854005915756, -0.10445994099966399},
    {-0.7503564449236746, -0.059908125158369865, 0.1331209667285588, 1.0815445190371697, 0.8338096905193199, -0.7639584278912156, 0.39719658896313415, 1.4269340815333411, -0.9003753423021896, 0.7142633322459339, -0.11951641798464127, -0.12582167967450647, -0.387942362494296, -0.31586034297804527, -0.06752091216706975, -0.8231221729655275, 0.080029628668861, 0.21267142914194828, 0.47612041288336227, -0.915396693752385, -0.332855306818988, 1.0575772952894475, -0.9434033781670613, -1.22241196363246, 0.32386824555916915, -1.0927474648889126, -0.7683804060602554, -0.516707190673296, -0.010911104356850514, -0.8261350251343863, -0.3433943257244966, -0.10327510255905888},
    {0.15933711047312832, 1.5582892792822582, -0.65668296883565, 0.5814596483303994, 0.09206537204631189, -0.4394966936936989, 0.5400641112165889, -0.5414144413825935, 0.14995701424218721, 0.44346895456519764, 0.323946351858725, 0.42317708718664215, -0.16432011159472668, -0.43461702426988613, 0.14120489188607394, 1.883615775030843, 0.15774486824684877, 0.0034425827390127148, -0.2024172641489938, 0.6039036616477477, 0.4044644294448562, 0.24661584372395273, 0.018798580426107984, -0.1169855452319137, -0.08017315636360108, -0.24478318143562297, -1.1234709145372812, 0.5548425122364813, 0.4358559354875497, -0.18502182329533337, 0.6536040693920318, 0.08154782747669859},
    {-0.31519195013911266, 0.6366269766557913, 0.258290861980211, -0.3581182745808002, 0.13923523335721136, -0.7498762250585773, -0.7092684502030034, -0.6011925372436254, -0.8656744191624024, -0.4525618549272473, 0.2583775474268204, -0.7468863901141263, 0.21350759141457648, -0.5024296156395532, -0.9759177730461964, 0.8226012019287977, -0.36118412252206356, -0.3522173464431283, 0.2445130282507637, -0.5491587588123674, -0.6063984821739087, -1.1073226955918676, -0.4541314928376105, -0.34378337142719834, -0.5108143140280966, -0.682438998292834, -1.191960067424491, -0.07950917692721043, -0.41731731311853715, -0.06385106780256908, -0.8034216865870966, 0.3942085258158127},
    {-0.3614520595018798, -0.81057227799862, -0.5054918131286794, -0.48877529827272626, -1.286516068162114, -0.8238242300172883, -0.5435022691988002, -0.8777206277404103, -0.7554185164316369, -0.9431442534547914, -0.21822317055827992, -0.775178452609501, -0.08165419481565575, -0.9028210082445292, 0.0027764182911951506, 0.7331198271408489, 0.012129979775907605, -0.6838299979066721, -0.5834864833151885, -0.6267214901314881, -0.34639641781964065, -0.8189860747904687, 0.1274893140055357, -1.9863522095968897, -0.3401370718148417, 0.10593495190574884, -0.471146866350811, -0.484428336478217, -0.8758826296616944, -1.180363065770718, -1.2401892628204907, -0.34352620446153126},
    {0.3128666687502151, -0.6483842318816103, -1.260946389060559, 0.6532167256558788, 0.04467967783698891, -0.9840299313682966, 0.3620239282885433, -0.9952403598359512, -0.4066663660861541, 0.04334199380639379, -0.472499646958162, 0.06552606475874143, 0.29813977714396456, -0.039157315896546134, -0.45024759666805886, -0.38041731087589803, -0.2321817613714138, 0.47945223307342183, -0.16445512641290308, -0.11957808370434643, 0.8605893606267289, 0.8543246311168717, 0.5101491159559486, -0.6838043711172437, 0.6779187728135504, 0.05432818459822832, -0.06745373799771505, -0.21653806905445028, 0.3277815898846136, -0.34287713271478454, -0.004774552031120344, 0.00828827467862855},
    {-1.568286955861865, -1.1125347227272744, -0.620028049522944, -1.1225494431090461, -0.13664230901077554, 0.010685045297135185, -0.10469055275089226, -0.18003205206000222, -0.10255644301459077, -0.2452532716242984, -0.09491256577423124, -0.8730455730603063, 0.30018396674589454, 1.2437681689134348, 0.06349780106322973, 0.8367390035875695, -0.4516160869028435, -0.3625854706740359, -0.24555993725300757, 1.4114809688579135, 0.38983395247136565, 1.0842629077691648, 0.18427910627328387, 0.8308421292227419, 0.2974850222936127, -0.5200523394091556, -1.0510107358736889, -1.0207767601161983, 0.2965554536771773, 0.7188356413609144, 0.9140325342861798, 0.5996539675883265},
    {-0.5583135672016989, 0.07019919088164883, 1.4291424350674482, 0.2185614714851009, -0.5771075676160452, -0.7879371871703933, 0.0361912682295179, -0.1917937427106681, 0.3347338042323949, 0.02314902628170008, 0.7627156578787092, -0.05753832171540846, -0.5056261112073989, -0.06831476533611436, 0.368298817914553, -0.523797821510974, 0.24670278379644425, -0.22994189211354218, 0.04966556941960104, -0.21024330389598248, -0.762639890666882, 0.34715036745303957, -0.5819630987505334, 0.623805636221194, 0.20594769648703157, 0.06565698990307303, 0.6515604859638789, 0.2476810576357882, -0.8970790399290633, 0.7637491920553555, 0.4072546184296745, 0.7167740751840661},
    {-0.596932356919118, 0.36226441631640205, 0.7509164038910855, -0.11583284999356995, 0.3774860694126523, 0.6060390752814482, -0.9684378051147134, -0.22075218998205667, -0.8214276237084949, 0.5723900737954238, -0.4466883595820983, 0.4830698316917965, -1.0217675095545546, 0.04347068937424199, -0.4343831918616956, -0.865880030634772, 0.4074832276275996, 0.5210183376360127, -0.7206896160427012, -1.5697922788059055, -0.34755636633122416, -0.9388024234909486, -1.4704030493397675, -0.13640337183809498, -0.8439628242956224, -0.10434808269057032, 0.15040545203327227, -0.7409525406135843, 0.23700551913583354, -0.4764096620997934, -0.6882415371308754, -0.4427389263303958},
    {0.46542706002578355, 0.25211796692879707, -0.28727846639004434, 1.3371650583522585, 0.6399616388200561, -0.3056826072097745, -0.16462810128936653, -0.05459862221392647, -0.7100739013361679, 0.4869786578055973, -0.1657261222189263, -0.1622570294578242, 0.3450027785592336, -0.07753198812967547, -0.13670958360154317, 0.21733177825982358, 0.19456236367760574, -0.821389243629605, -0.4248516120177917, 1.156064077263509, 0.36975910482120417, -0.5544810284792069, 0.7943468728426258, 0.21441205208847397, 0.25475369280020294, 0.2189740448304561, 0.2850106361809868, 0.194596053214722, -0.17956471266716093, -0.011467143836910783, 0.6237195692244196, 0.9823509099866344},
    {-4.74865753800266, -5.609060953159303, -4.680698448657607, -6.74277828868017, -6.034041076540507, 0.924322923779829, -1.7131163791420005, -1.692118541169068, -1.1540927809051986, -5.908124308455133, -0.5153590608995988, -5.624630323367993, 0.30323282957099545, -0.6429798060842074, -1.527569537797676, 1.6225435826702723, -5.740363843976847, -5.951543398882741, -4.456611189843443, 1.2423404466552945, 1.5754952371535855, -5.333023153608902, 0.7152953964372363, -0.9573158583742248, 0.6316932687720616, -2.00433972164773, 1.7421954275582403, -4.996240601232589, -5.644603187383682, -0.3277463522216074, 1.7768082482098206, 2.7195415604983344},
    {-4.598150987341882, -4.873179101134041, -6.030382890887983, -5.999981006411801, -5.512034012385764, 2.6112773613604285, 1.290919355537515, 0.01230726866491274, 0.8396976435645493, -5.490096186866923, 1.712352066896383, -5.6884913674662885, 2.0929183900231565, 1.956657221566411, -1.4664794883409227, 3.5569978910866364, -5.999985296193429, -5.2109973585149785, -4.506333085599851, 2.6599385229720642, 3.805096963789858, -4.3189126768121, 1.9583058552455483, 1.5530666430809483, 2.314674508835962, 0.9603347518693388, 2.6320288170331283, -4.89290195660724, -5.0323908053556385, 2.5450303727551025, 2.9326267936655763, 3.924809046560913},
    {-3.5238843955079093, -3.9932811221522346, -1.0189276077696654, -2.833133967867155, -1.390121612787428, 2.8488010128083063, -1.4012924855326985, 1.6186505563274676, -2.3349056117464904, -1.47214162892417, -1.9700484341676898, -1.566428605156694, -0.9088131159225789, -2.3351209730100213, 0.03426933629848277, -0.5509008811877303, -3.0189589827775487, -2.263404992742947, -1.256974485788925, 0.6417107889465818, -0.44972926938660296, -1.7698828858271154, -1.3200708179510467, -1.0017554280511578, -2.641376468300346, -2.7962995169495968, 0.3294718566565376, -3.265447500324406, -1.2536535266631403, -1.2266836756231712, -0.45947512167253446, 1.6619787628012905},
    {-3.0016091921333525, -3.1222444925433637, -0.2538645730564454, -2.0031364200868254, -0.5733754234649009, 2.403701965282157, 0.37957184232567637, 1.731413085776235, -2.3121562364054853, -0.8631815652701272, -2.5153307604163833, -0.8054563736697122, -0.8706367273987395, -1.7334067599974936, 1.4566307403958998, 1.4025277838080483, -1.7762933715747122, -1.3560653756587921, 0.870097431478317, 1.0237597917951093, 0.3624441069548528, -0.1340326696470209, -0.9900085416810038, -1.9605277246441348, -1.0811239032609863, -3.7859236345353597, -0.8805173659218912, -1.8102910421162204, 0.9666219352209224, -0.491832548133977, 0.9556470422517319, 0.9935288388907901},
    {-2.8478784826741306, -2.302345791665244, -1.009569290573221, -2.019827271685366, -0.9691627205515799, 1.7015361258518282, -1.1147458363627138, -0.5588665184972679, -1.1519452664082284, -1.1053324769419632, -1.016600712237096, -1.5896740285150002, 0.43809787471216904, -1.351409542554903, 0.5988356258065078, 0.7258224168555234, -2.1923059540863794, -1.1622715557315715, -0.600710212273807, 1.707225100613424, 1.043655613998784, 0.6501400144779858, 0.24372077814487522, -1.1157955561159296, -0.387629192266645, -2.650609276498918, 0.5426623347475887, -1.7645732372917495, -0.7951873846656152, -1.369848233991584, -0.0628213185664319, 1.468009938366883},
    {-2.479155077866646, -2.1816286622379732, -2.244651685941231, -2.306760765233664, -1.163185172780405, 0.5107914378828443, -0.08808178474046986, -1.0201878427288102, -1.6836893904983263, -0.8295371991266524, -0.7918609640371288, -0.9249774420198704, 0.3399425337716182, -1.1278475218754753, 0.5616274597619241, 0.896866873064135, -2.110131163865337, -2.3465349458002662, -0.3762792527374049, 0.7235206621488769, 1.6629359850686338, -0.45328993655950856, -0.15880116410647951, -1.0966642838270761, 0.5507506038303118, -1.1081073886426602, 0.2059375222797682, -1.3006877718883596, -0.7908959796221999, 0.05904724896626585, 1.0099564106538423, 3.050671102362743},
    {-0.28292447105686813, 0.1320065078594049, -0.9869308732870582, -0.7513564451008146, -0.6008221563233039, 0.846558322371563, 1.3104760894439917, 0.3811942477169661, -1.2112548239455525, -0.8814239869580709, -0.1484430172754678, 0.732680182945823, 0.6935471922088803, 0.6011310043738102, -0.06259681053320544, 1.0372464612192092, -1.9709489910175364, -0.7402325076817577, -1.827426451080407, 2.671415507097015, -0.3783847793872946, -1.0859253680166832, 0.504631515088753, 1.06062476999887, -0.8280156280788932, 0.13875111023920164, 0.28075667568836343, -1.4329751221247922, 0.1609406684319903, 0.916304932808348, 1.623226441274241, 1.8391700317082402},
    {-0.8024807340240461, -1.6233486415925957, -1.1350459620401143, -1.7700254224405159, -2.3462863316598424, 0.09017094419003509, 1.259649694225052, -0.5167764232778231, 0.8819447008699796, -2.0451595448453372, 1.7602870955133856, -1.500321434994948, 1.2934985952599094, 0.6346371356741989, -0.49793881769331044, 1.490842004393327, -2.2007663385189624, -3.6890032187622803, -1.3950811278813837, 2.463280649969226, -0.28968362844543927, -2.674512859812954, -0.9723751308222752, 0.8881745822824728, 0.8283253108905322, -1.2786932831843676, 1.2219580922782542, -1.6224255869476543, -0.5406464155904139, 0.8318700860734792, 2.8420797329675187, 2.8148900023573997},
    {-0.8985703630538302, -1.3687738689098752, -3.9178145903944293, -3.0395502261534273, -2.9995114324877594, 0.17418687461174018, 0.4003149000673163, -0.5206000422762486, 0.10879134526184533, -3.3493613872553345, 0.9748880358387287, -3.2225765995181996, 1.5562439024604766, 0.1176428355059007, -1.6431790194289868, 1.9529671597726943, -2.982493983804641, -3.219583824665488, -2.9111180993586117, 1.7524358309711725, 1.289082653231234, -2.9696426017311666, 1.2723897482862903, 0.5734445445342788, 1.9844818894981529, 0.5581067030831334, 1.7053122334191209, -1.8373299283364388, -2.404819684197291, 1.0975020250148142, 1.784981291767707, 1.8760811591171842},
    {-0.12393833319262243, -0.7470332699286266, -1.7117050918138705, -0.10333241080322471, -0.5564888697716902, -0.9403451235126946, -0.40254206424202715, 0.22090485854318972, -0.5063591592840218, -0.2553579105246165, -0.07603941140082617, 1.2405150243142977, -0.4242032862707828, -1.4309331901082682, 1.265711775069611, -0.949327389163903, -1.821321417825051, 0.2643437885622828, 0.6979192149293674, 0.8401673603187356, -0.28483352251303595, 0.09396138969524925, -0.5109021483547249, -2.307604638209886, 0.2529974350322498, -1.7531061263178163, -0.5781372670618224, -0.3289543546661524, -0.0859498053509059, -0.6465665617229396, 0.04196482149395961, 0.8368938025312364},
    {-2.6424269549678625, -1.5054273683867827, -0.07056941793750218, -0.12353387592777917, 0.2214508817968954, 2.607230971499446, -1.0475813120081139, 2.3090359958468403, -1.1412963276448227, 0.9413557719850237, 0.2557618036733273, -0.3323713912745503, -0.47337382630829633, -2.244223432397524, 0.6752360345614642, 0.6038056680554003, -0.32993228842704597, 0.4296178478010713, 0.44471333054854734, -0.2618003220189737, 1.679078997301717, 0.27832153678460697, -1.7674420419130308, -1.6364298347178559, -1.5758829761955926, -1.026584348155881, -1.5585495646696113, -0.5700229853965956, 0.24834448187410005, 0.05390762991866945, 0.1555671370169323, 2.2950241229418142},
    {-1.5933061285380878, -0.9450937659166785, -0.8635582155813377, 0.8906909945249776, -0.29623666980031804, 1.1718585725454613, -0.23947983103659076, 1.7908413496126232, -0.6224955119694835, 0.2130081002356588, -1.7466128229033835, 0.7849828225507223, -0.41085132690080134, 0.3880287077157374, 0.5187668078683915, -0.071669396122642, -0.4970476824525181, -0.04896514348999808, 0.16107900078412102, -0.3050383375988653, 0.5327183290609108, 1.2655023917104882, -0.3452600441684462, -2.1471383875867494, -0.7999190532402596, -1.240005970607078, 0.8188752649530205, -0.4260029550572659, 0.3372396075071448, 0.6228918340314155, 0.08193509324267735, -0.6050037065052263},
    {-0.21744805449043839, -0.18129032573204937, -2.8117307601540555, -0.46024112425602226, -1.7763569538010069, 1.1904422855604897, 1.4000435096297397, -1.8077089395367327, 1.4112281221368441, -2.1584295783693164, 2.1157398347008547, -2.345539281051956, 2.119447045142778, 1.968696425295749, 1.002700319217855, 2.1402613081762114, -2.292685535296498, -2.5742665654437404, -1.4850509977661557, 2.730627957691365, 1.9803888288047176, -1.964355792106376, 0.5577636717300121, -0.2374291670691077, 0.7820548109500908, 0.6338580937843312, 0.5911802280462953, -1.8845860435075867, -0.5611135170435798, 2.921201800505655, 1.8368158837093622, 3.255409972686361},
    {-0.07030460211366128, -0.37265492158683383, -0.2800161590128003, -0.026299858530172963, -0.5438441333063218, 0.783007342835694, 0.12013791421430024, -0.5879569139905257, 0.37310446471980074, -0.7665162056644825, 0.17593002021343437, 0.013169699202945046, -0.8173906605962532, 2.4691944704870896, 1.8192754800810922, -0.06968402825812732, -0.2599040119296596, -0.09360910753698888, -2.0890135434365042, 1.2991710300779176, -0.5420595750585249, -0.7430696540117794, 0.14230391523517846, 0.9647118169149127, -0.3801291335524258, -0.20609924991714088, -0.062323133235296195, -1.3939591346921594, -0.9100276656291392, 1.3436964206105657, 1.0451576109754936, -0.27605178695090016},
    {0.18408763985434426, -0.8723487420576457, -0.5070979253538146, -1.1285518693497467, -0.8400388620814975, 0.19673887690534408, 0.5099988613462668, -0.37885395914181286, 0.43326700989207084, -0.19994036026816125, 0.6349769545650539, -1.412663257931781, 0.30211565879265007, 1.262311314044233, 0.9834920675259764, 0.35250518942081394, 0.044177639378004986, -0.2951594738195573, -0.9881434172108818, 1.5283172312626152, 0.7555743431899127, -0.9600931313737457, -1.2759166694268627, -0.6010737496410052, 0.07787242160114297, 0.5358884562877007, -0.6896859186986488, -0.8349490400749837, -0.2597156665062393, -0.6850585595372602, 0.4290359741305076, 1.5372148590584682},
    {-1.3671667212894896, -2.62896078288985, -4.004810407337373, -2.9875870546585217, -3.1232096592054157, 1.3495640928355819, 1.0878384964790326, -3.155435679916146, 0.4075205866381369, -3.14269999867533, 1.1346423980017246, -2.812902756316852, 1.6543296623571884, 2.518898393710874, -1.557168004085705, 1.6102260566607665, -1.8585044215109592, -2.313232531609044, -3.4122834766235477, 2.2582696188906275, 2.121341968264515, -2.777189434872874, 0.9665415824536268, 1.2883813185169928, 0.28908113838369853, 1.1433210910491043, 1.8392323442359935, -2.5824810386182744, -3.0943808679998943, 1.9351992069340611, 0.576388442693794, 1.9811113376360416},
    {-3.129685380652025, -3.4090876124969265, -1.534860913591534, -1.5234015875042126, -1.2879299087560199, 0.6361046361749544, 0.4350306151684552, -0.5242906004865341, -0.12447382543898114, -1.458992339569057, -0.19678439711158333, -1.524280629335742, -1.2857262126950533, 1.1186112552041998, -0.11748196354270969, 0.6275409886251627, -0.35917606698197335, -0.45027898188107907, -0.7549629988139867, -0.6692276425065655, 1.6305891833664612, 0.11058159418256461, -0.5795603320357711, 0.7035202174055755, -0.7443383612974889, -1.286204330108662, -0.3422760931806963, -0.800277620679009, -1.1978951573917698, -1.0560966158115153, 0.6790992985859157, 0.9515794416001486},
    {-1.3055744962029003, -0.4999762919536737, -0.3714325254062528, -1.3529149052209055, 0.8442642607412838, 2.758172629477489, 0.36915395872124357, 0.9949189274920918, -0.2641432547765796, 0.40228621796805497, -0.9066027329769303, -0.4832279843219176, -1.2333610257999952, 0.9518602839942382, 1.3934167068508816, 1.5156361856087521, 0.10312502930433236, -0.07848996613324137, -0.9333000465824626, 0.5297474644271157, 1.9806875027647246, -0.3108918982730771, -0.27431376476325525, 0.332046442027028, -0.5744690512621385, 2.1284346147359003, -0.8316976129727282, -0.6817031589855215, -0.028906158842685055, 0.8055418797656119, -0.9845956613182671, 1.0549105918242028},
    {-1.5956204660085007, -1.3652030730056939, -0.0749089114508518, -0.03565998783594283, 0.8958106932217095, 1.7034208527137185, -0.8061535834474629, 0.027513101009165382, -1.3610798247272313, -0.026127142806507544, -0.8215729908877266, 0.07372165480483434, -0.35699981057259106, -0.5932599563381314, 3.020414609909148, 0.3131052783931792, 0.951240595302661, -0.4796874580983273, 1.2158130470394621, 1.3358639743438667, 0.07448212953878966, -0.03001909423437704, -0.12247262240170399, -1.4356223490852305, -0.15236072913591686, -1.826649619542065, -1.9888580245203398, 0.12227686287586456, 0.35359697781736155, -1.3498298817123726, -0.004678606727697179, 1.3089202459073566},
    {-1.9422041552167926, -0.16189517644324328, -0.2670151682294825, -0.10732728187934742, 0.9609711365531288, 3.0118983845015217, 0.709499661648959, 1.7700586176608322, -1.9249676593666387, 0.7101514518363716, -1.016136540192862, -0.6509861273501067, -0.5411937375123967, -1.8775749569039313, -0.589963801690844, 0.08308874526508825, -0.7097633266931913, 0.30561006750315434, 0.01449835173300485, -0.5060301081210142, 1.623289578756473, -0.10148806406429793, -0.5819444297516012, -1.9431414137243557, 0.39061166467811537, -0.1077435034045473, -0.6588440911945227, 0.042816927451338374, 0.9359180608956565, 0.25096145913423473, -1.658561189660825, 1.2929045826306707},
    {-1.916033794676059, 0.1127392031764883, -0.21288146589623316, -0.9398745359715164, 0.9263886735379442, 2.459593770168524, 0.1368468865764805, 2.3268235651432265, -1.8709282624409336, 0.4777483014797959, -1.581297870522017, -1.856336175461661, 0.3175450539168309, 0.6275045067503136, 0.8065391843668914, 1.587033333312146, -0.40991693971738596, 0.7843849582205489, 1.643816480472055, -0.9568052361383756, 1.3279149440383935, -0.21409218527627338, -0.7646636448991635, -0.7397501313957927, 0.2903123148026078, -1.0568311822479959, -1.3253578256436882, -0.6463857145575105, 1.2627268766666873, 0.04131193780816283, -1.4447357058072734, -0.42282840761582285},
    {-0.9264385925835243, 0.6669627178667241, -0.06267266245989042, -0.1894347620255395, 1.1087396270009362, 1.273319192858118, -0.3002309557508531, 1.984151481457377, -0.4016686991060695, 1.3046595663293679, -0.7110079539977486, -0.6323395115067885, 0.9281922179337649, 0.030235639759511063, 2.702292145590508, -1.022603037062222, 0.03651797166744569, 1.6757768030384692, 1.7633696603575442, 0.5137357015575702, 1.9935758256559963, 0.5531647451360506, -1.45141560954895, -2.1650297850252076, 1.089185230098995, -1.5327611841806525, -0.8195840144374517, 0.7431094511984273, 1.9270177848804433, 0.08397326657161344, 0.1272242854316748, 1.087414217879249},
    {-1.984785641700481, -2.448625087421348, 0.4553000877829423, 0.4322719965525188, 0.06608345561011089, 0.5379132673398676, -0.6283976298522747, 0.28278235053202666, -0.972137435298693, -0.26282038726853035, -0.6228013559613389, -0.37206260934589835, -0.6236179459653994, 0.12472753685731501, 1.4085029244407898, -0.11757755209405228, 0.5241218677870574, 0.6616680300482961, 0.02753081193566464, 0.5789958410624754, 0.7908103988064719, 0.540982439705705, -0.22112162227767054, -0.42488244279489545, -0.30401902028437916, -1.1677984465424607, 0.6884427053413332, -0.9968909127541533, -0.5785105345435734, -1.0701119198546822, -0.14166508669154207, 0.6162432511967393},
    {-0.8444078783047863, -0.7278737686696349, 0.5846096352845332, -0.832916029995296, -0.47728057351155023, 0.5696611430317814, 0.03485093356019184, -0.5352406579187788, -0.18004598264690358, -0.6431672424730547, 0.980797383570352, -0.0805767028966006, -0.013173278400379724, 1.5498500337641912, 0.41506432702531176, 0.27084098573369303, 1.2036337029674555, -0.7815125727071545, -0.40947033982801634, -1.0178974119742097, 2.0617373028300063, -0.2161360083631046, -0.5118018109482962, -0.1317781079605291, 0.9901194131911571, 0.9508531718204919, 0.7547747640035677, -0.07501707847032965, 0.056835526651442765, 1.3949635724303409, -1.1008658786121261, 0.6369615701879173},
    {0.2965012797780838, -0.21190040126902124, -1.2059976879707983, -1.4888096983650534, -1.7668447949327049, 0.66503704077232, 0.4815136265248775, -0.39838382031012115, -0.24437928386577906, -1.3493398051442531, 0.837064749399175, -1.9274025402804704, 1.1398988712975293, 0.7140841206162912, 0.21469645381888605, -0.6125124729526106, -2.7071777355988473, -1.1269135898899882, -1.9552120510473616, -0.6215161924320487, 0.1230682810356052, -1.765877296264208, -0.12355575457006437, 0.1429224957452517, 0.1517716564873363, -0.4755180792649505, 0.7994257325048016, -2.8239512272542395, -0.7487147153323929, 0.7636280900991504, 0.8061982691449816, 0.4432307026732257},
    {-0.9238516102420657, -2.637263428116006, -1.4784618926168074, -1.7641420771657756, -1.1466753235913003, 0.6812388914977179, 0.2363899890535257, -2.1410894394393396, 0.24227371079508045, -0.7006100474653622, -0.5418175629283738, -0.8449627774989659, 0.39696887992543756, 1.7765214196008599, -1.0080746100667735, 0.20875195081734463, -0.6410676886020484, -0.31442312444918524, -0.4286219108365232, 0.40288746143999926, 1.719399698732964, -1.0649171470478027, -0.26964869803956343, -0.4377730643311517, 1.2306720451030957, 0.06696058044609576, 0.3899475621497938, -0.8357174543520297, -0.7899951280430693, 1.1786994911968607, 0.2127622738170372, 0.8326607418941432},
    {-0.5787632751541542, -0.9492713812855373, -2.103386781553354, -1.4219111455128683, -1.3566450533500303, -0.15115693585963824, -0.11576935725978453, 0.26027664715705084, -0.69855738866612, -0.6299807075028839, -1.1450057609259658, -1.247932842175754, -0.061962034401371595, -1.9493868568186814, -0.16866014041872143, 0.1059645689577679, -1.7248300476448648, -0.18870433890826363, 0.7843500555524883, -0.4348048968958378, 0.6790603806846551, -1.2375885341275883, -0.10164144618486493, 0.7466548464487801, -0.1861931716532606, 0.48990082617011504, -0.6868707698789005, -2.716661327514126, -1.1426466174246297, 0.9163629210236716, 1.1196412001757463, 1.2314350825515228},
    {-0.4138140605626551, -0.6352660683269441, -0.5272755996203247, -1.9199712569595069, 0.0890125873513766, 0.39085583672094537, 0.7796530964918164, 0.45223431065501485, 0.23883965723148454, -0.4867989979916953, 1.036550025013197, -0.6899494860274374, 0.8440292266553416, 1.318268046939826, 0.6928929212729026, 1.9299581466061246, -0.5698826014186927, -0.032880882371060974, -0.47967492346150326, 0.31830371030031374, 1.2693840263234053, 0.5169252985108241, 1.3076397729171727, 1.4777286674858139, 1.7655744033899288, 1.2161407880016302, 0.21404407058647815, -0.5809731336790871, -1.1594824052876658, 0.8724261001559381, 0.16596517632156943, -0.5712480522242898},
    {-0.3415870412363208, 0.712868859891217, -0.7555281034919014, -1.5516205416074864, -1.3288967169442942, 0.09158146399495261, 1.6186954060918795, -0.3299130202986099, 0.68498045912351, -0.7363751940584473, 1.0287681511989806, -0.6641056624018844, 0.9646569725271873, 2.01998711949765, -0.7863942981645643, 1.1518003503182417, -2.2428170297713605, 0.3455184377712321, -0.5917497971470548, -0.0489069639025354, 1.2492200970586793, -1.3472926244245989, 0.7965381493730898, 1.2921678976231876, 0.582474497602749, 1.0025610946624743, 1.038929667627309, -0.9741561380914894, -1.8431871713246073, 1.9901261016417957, 1.2249197200878053, 1.758943590920179},
    {-0.2576737961046324, -1.7285730461717637, -1.7305369547872682, -2.723901604734469, -1.2664227866580284, 0.33653174424771803, 0.31448862495121893, 0.16586114023162016, -0.15849030327085012, -2.0730985614067285, -0.9555114180716991, -2.4914658084039605, 0.19985111674602996, 2.0599841590475236, -1.259872266154936, 2.1574480147888875, -2.27069536117189, -1.8663878543162764, -0.056416706517042635, 0.17549906374456814, 0.3640941950817621, -1.3224838495010658, 0.4491372391879311, 1.0756900719360762, 1.6643414126021514, 0.3435744096425043, 0.9087593984338077, -0.2980075253548434, -0.9898272252681897, 2.3302750852437613, 0.9629318210481923, 0.03257563698585534}
};

static const float b1[32] = {8.298727805637526, 8.402815672240688, 8.387031539227674, 8.35292752491681, 8.389624120325646, 8.309622301401951, 8.276532486143804, 8.294796676910993, 8.144899122668148, 8.055420978623664, 8.19070301429743, 8.303639215646271, 8.369599435341053, 8.205061312198639, 8.185020148287963, 8.434176620834783, 8.447531092456654, 8.43513187280151, 8.470817666082873, 8.217934228291938, 8.346653641104995, 8.363940567967083, 8.314628569007587, 8.140274660027154, 8.420781789786927, 8.383575705769148, 8.214690039679274, 8.454923283401351, 8.320838610221491, 8.180020730490638, 8.133712946786229, 8.144136944527002};

static const float w2[32][16] = {
    {7.708961590040948, 8.127114638783151, 7.9029968727757876, 7.695316255530929, 7.709859347433197, 7.623847507550949, 7.886559778229088, 7.432503896163067, 7.673779364318127, 6.982269964265105, 7.692472242852436, 7.295741292313641, 7.701545762794913, 7.86846282438942, 7.68897105835775, 7.635322440918551},
    {7.161454464823198, 7.585890897184536, 6.998010908864631, 7.486670064474962, 7.011087133874109, 7.536770578674596, 7.437549590233142, 6.987192620780436, 7.392688187857158, 6.397453709684157, 6.864645384777056, 6.769658883685156, 7.745966243609598, 7.576974334968162, 7.383010236632204, 7.095437525671035},
    {6.842014965103667, 7.079555235271558, 6.837536310025641, 6.835542149884851, 6.974038924146773, 6.80984996016506, 7.140284600813209, 6.714461705910845, 6.988236536422282, 6.335984341796484, 6.720470757898643, 6.69078460661364, 6.636394980348199, 7.525988685455897, 6.399811210719178, 7.318674266067412},
    {7.134662558158322, 7.0236051511816, 6.9863127041836925, 7.654972791637129, 7.101347695346544, 7.454399424471926, 7.239142783214401, 6.969794232243421, 6.886724941392761, 6.551929990109869, 7.262681011985554, 6.959365129850474, 6.793452205555978, 7.504763568707858, 6.784383312177019, 6.792679039323234},
    {7.093508704112014, 7.347776095500877, 6.635327009211095, 7.079807004111154, 7.367552717894617, 7.462458176337902, 6.910139237942746, 7.197827350696649, 7.358990067833702, 6.952192459049984, 7.250632210183949, 6.830250392694457, 7.537081486167909, 6.931204160146941, 6.718767406906126, 7.221905941545997},
    {7.429556799780557, 7.316138155415251, 7.067874152692298, 7.535064908065832, 6.738845479722213, 7.561070402556212, 7.3214400391603505, 7.122489552178985, 7.168302725649358, 6.982938083165942, 7.710338198032129, 7.179835639655526, 7.145162177832026, 7.52061622745278, 6.994310996503102, 7.730233168544273},
    {6.735841828127199, 7.139979314774657, 7.121567651604904, 7.158275223107564, 6.856442164708562, 7.11940904402316, 7.135420648890624, 6.80231245792698, 6.666526287916465, 6.521590668681253, 7.299165217318549, 6.739399273219519, 7.232151833659687, 6.985961146252971, 7.139801065748988, 7.196554786174723},
    {6.951205697857782, 7.236035740364116, 7.490797223184192, 7.898469214001032, 7.323050899825565, 7.896045882455991, 7.5026214460322835, 8.182766478985226, 7.777439679618094, 7.1731497366709345, 7.954461306912631, 7.056862853809685, 7.795386909356325, 7.713470670240625, 7.812333103499666, 7.384485094004373},
    {7.214337112292391, 7.016148945421174, 7.4268688224179495, 8.002661108059979, 7.364855276745244, 7.723940979833993, 7.30418824461785, 7.540152596735228, 7.7254819244608495, 7.0109576795236395, 7.330007424434381, 7.370264758670315, 7.21321371452616, 7.862258382900499, 7.595648813827212, 7.708360228142145},
    {6.69236864355691, 7.185573220580338, 6.658250445796933, 7.051699291489763, 6.874894081689183, 7.428616242468107, 7.587024317438661, 7.600160642695508, 7.186021556488377, 7.033023170023704, 7.555990453392898, 7.225976389665578, 6.928252738268607, 7.2584247053261, 6.717007234522302, 7.937982046183685},
    {7.483346391543329, 7.156283080114159, 7.335063884071428, 7.275222033087923, 7.424965279824882, 7.4956142725957156, 6.840579778518618, 6.763401191477553, 7.212840040016174, 6.680101197368077, 7.047815600126759, 6.811755788556237, 7.22506693142215, 7.128373585145094, 7.146163774847542, 7.102964329894834},
    {7.044071927561187, 6.691134261386692, 6.484759888960653, 7.448481380269475, 6.583710493736756, 7.134699551760558, 7.3192428098773314, 7.086986329742142, 7.1291659655299116, 6.6794011345218, 6.860115190100432, 6.777249197023113, 6.794007736881364, 7.391384190233117, 6.876209252732825, 6.999972463900479},
    {7.228848138317158, 7.110139293933466, 7.333551461390537, 7.5161708444331214, 7.156640687143545, 7.313228858971404, 7.016286749062589, 7.679708991410257, 7.335000634858556, 7.080358219711508, 7.542377609096376, 7.16319220143818, 7.116784912771088, 7.2897736728906395, 7.69994705292664, 7.116623230473049},
    {7.242810887415408, 7.136375628015244, 6.391528104732489, 7.160637912165853, 6.46614405125961, 7.20258098197268, 6.459006975269332, 6.791198712535038, 6.781406333549355, 6.572763888081046, 6.9507564179162085, 6.489315650623256, 6.885845837253615, 6.9502235156759395, 7.136359413309013, 7.3266835629904845},
    {7.328388903945663, 7.077794282031677, 7.5404226031136465, 7.303825353774802, 7.130742399883536, 7.359169006616014, 7.3966503735797575, 7.149140308624759, 7.22166769978124, 6.555883214858415, 7.121907189472187, 7.020805415698733, 7.485739548717679, 7.398012229813402, 7.038461609029633, 7.418109955277758},
    {7.436758505316106, 7.049161082771927, 7.251092972954394, 7.14679091919164, 7.091910302597563, 6.9213682515347825, 6.984556560862562, 7.063546178705333, 7.260177978815731, 7.260386297959474, 7.316286529074971, 6.988399411389563, 7.212273256416772, 7.298628050860587, 7.359704115531381, 7.190645076218783},
    {7.017112640943954, 6.949376069667957, 6.630149501585072, 7.004590330212477, 7.409218078259714, 7.2351945989902955, 6.93025296119222, 7.1096670320697815, 7.084935431948472, 6.714142668126963, 6.616567137959781, 6.402179486848051, 7.110663129965591, 6.826055021396778, 7.0243923738532, 7.140393210139294},
    {7.527637670643695, 7.432538255652718, 7.440074960135845, 7.336105750923046, 6.936038020941012, 6.997276527604911, 7.08174132479133, 7.137546933695737, 7.321166401300261, 6.8822947414118385, 6.716324276264569, 6.800655644744974, 7.233155014386732, 7.373695771578911, 7.3575951422680825, 7.42096069137634},
    {7.582434745574423, 8.063923543783092, 7.104165317845626, 7.695215451042431, 7.282504201158764, 7.428814141154227, 7.458940888908213, 7.568585984100887, 7.36837878569768, 7.2947625485327, 7.21264759629617, 6.986430203629892, 7.346073004507363, 7.593250840207026, 7.429265617212976, 7.053557875587095},
    {6.678995814875083, 7.002262137215986, 7.109746782480371, 6.730980800058429, 7.106543969065239, 7.084436892059979, 7.426348706678608, 6.932730207638079, 6.987386017875737, 6.67799168286426, 7.099249318885375, 7.134372104651911, 7.491689552201474, 7.178284466886452, 7.11072864206368, 7.039990677915558},
    {7.112403726877287, 7.311909365828657, 6.780509938941281, 8.070108653782388, 6.919480064451016, 7.575315409810763, 7.459823405549564, 7.4420321051782246, 7.438781543819479, 6.843979110724517, 7.1251029143640014, 7.361873739002247, 7.214586992284996, 7.3579549246542, 7.085293540656041, 7.895753400348488},
    {7.37445147807735, 7.441821435643085, 6.478978480779225, 6.957947508444747, 7.174731220834873, 7.5663842217887405, 7.508532335890105, 6.954939833877748, 7.505700832176218, 6.411245163721664, 6.830220546081732, 6.716478312368761, 6.707795203041607, 7.319353816956599, 6.964470549933871, 6.920528651088304},
    {7.379432034995324, 6.858171135248219, 7.17464445261948, 7.242179040860316, 7.199056136223227, 7.40268285054852, 7.129456898463365, 6.676748642563998, 7.1256818378323095, 7.182263761917028, 7.314881665756795, 6.965318477167736, 7.563624097898563, 7.563683210083456, 7.206401168648415, 7.403291665575726},
    {6.847171521422727, 6.678068814607272, 7.017063633574689, 7.401469998336873, 6.605863214380243, 7.085390032778985, 6.707713769834169, 7.101367413328584, 6.538232540321982, 7.011364918011479, 6.957712763680289, 7.053823810627721, 7.083985463438604, 7.293767988596807, 7.359427811266389, 7.201438514617834},
    {7.211904419938055, 7.034074901528863, 7.038865786943106, 7.393556117618037, 7.246000588511057, 7.267438546010983, 6.908503276595892, 7.036356089615927, 7.465298794519401, 6.714523493345711, 7.294407667483576, 7.628820165673719, 7.156437158204963, 7.282566276719758, 7.239584441306096, 7.281760889784119},
    {6.40629800776151, 7.259663220846482, 7.057694510391481, 7.244430399877671, 6.923453804496426, 6.975439567540036, 7.334313659265666, 6.499595926069704, 6.848358875234191, 6.389512180533705, 7.631038677342564, 6.67282863791496, 7.085260456058685, 7.175594533011922, 7.5632931507403045, 7.076722248168483},
    {7.195649765507612, 6.860597698106506, 6.962824957293336, 6.662227051654844, 7.134426028020801, 7.234027453972529, 6.908910010203275, 7.251510168096342, 6.9881489456375245, 6.971883487215669, 7.211498679785977, 6.513902835552805, 6.921337348760632, 6.762082109213794, 7.040788274060966, 7.3743136418004624},
    {6.953343108843866, 7.765313807276156, 7.500288929537518, 7.691499121223915, 7.746946892708726, 7.714721608085735, 7.4291172303060735, 7.246361288293747, 7.616851838980237, 6.8749319585398565, 7.857106370394252, 7.419275051587987, 6.805769528409509, 7.5357049030966206, 7.333195503175277, 7.734364881806753},
    {7.337004379388325, 7.541780002885127, 7.3553948236869005, 7.111301908864679, 7.110178612793384, 7.354184388847903, 7.298554610899956, 7.208971859450807, 7.186836427780276, 7.120853807720443, 7.0304584485479715, 6.873205022105441, 7.418935489517943, 7.486621212450265, 6.697101447714622, 7.017325332747391},
    {6.796506041227565, 7.072106978430147, 6.962737926924838, 6.776604261262164, 6.861042523499735, 6.978328270705816, 6.920241149588392, 7.082768574968229, 6.619003246605785, 7.032194041165224, 7.150005644001765, 6.683410824143937, 7.176443215085482, 7.054908596178, 6.960030050653681, 7.134496478245382},
    {7.1494675030398716, 7.1555325687168, 6.918406047865327, 6.883435862267799, 7.363253895705931, 7.364165015294305, 7.3856002488668135, 7.013873909405504, 7.276611122388195, 6.820360887876463, 7.227304616007995, 6.865096769827476, 7.279689632303435, 6.8567247671974165, 7.313344814660218, 7.411494304887148},
    {6.761971391174344, 6.502945967119981, 6.912045150647486, 7.379017333616146, 6.706664389299172, 7.093423932494046, 6.895076472273717, 6.493004331982224, 7.0576602207461185, 7.140063662548124, 6.942080791534862, 6.714316352869197, 7.332955963253808, 7.437359281562886, 7.349096564913858, 7.224168012183012}
};

static const float b2[16] = {6.80558235966306, 6.8315766358082906, 7.0474971120287035, 7.067839721301252, 6.7121788759827306, 7.177205612892495, 6.992044086935067, 7.2355913171755795, 7.24237750422457, 7.291553340322766, 7.1945906586540636, 7.329300561756951, 7.042732437168721, 7.146797055962669, 6.9486432764037005, 7.214743389763067};

static const float w3[16][12] = {
    {-5.460756085570098, -5.660119351553143, -5.4270074734052205, -5.066844465499159, -5.289456089193766, -5.494217133627307, -5.610286714389332, -5.998011900101173, -5.364673735806481, -5.509677178349189, -5.265944890766214, -5.432559196651579},
    {-5.297153989322344, -5.386375327993027, -6.253967605708746, -4.876477454666817, -4.506778693742631, -5.179177705747886, -5.576914039128535, -5.135960288727346, -5.0604170445407535, -5.321372684088709, -5.6920344665266, -5.396136326107803},
    {-5.352578421284754, -5.6459655574121435, -5.07442626144095, -6.031736489327607, -4.931532260670206, -5.144204053876138, -4.430190901799537, -4.739685675093686, -4.560157116975036, -5.187940063730113, -5.7727711307713125, -5.167247120394158},
    {-4.562498482495789, -5.245682046964314, -5.62476869138253, -5.293077686352142, -5.495959422912279, -5.931633016125658, -5.180133906336409, -5.4479892522634445, -5.49648916392276, -5.745114235918932, -5.311191309308692, -4.976229320285854},
    {-5.269396510844371, -5.535035384155439, -5.227638251348803, -5.353925868012331, -5.20321158395447, -5.2593450696959305, -5.354277545793326, -5.465124032786841, -5.543869370568339, -5.996012731444367, -6.144749122582019, -5.583052027632261},
    {-5.365310394795486, -5.179466760577614, -5.2532000907452945, -4.934349300233664, -4.913307935926399, -4.885967416893688, -5.309236829270863, -5.430194759620891, -5.687402302193033, -5.297434714741945, -5.488137072712601, -4.977754175918096},
    {-4.918863699873495, -5.256807867635771, -5.126741452726833, -5.139231290685339, -5.187725993682773, -4.856096375190815, -5.767361010176659, -5.401787734993488, -5.0969545392162905, -5.422461442787614, -5.360863341588193, -6.048846610072439},
    {-5.324804641024485, -5.297912846557908, -4.918434848929659, -5.637417647774505, -6.250223558373966, -5.290721808297549, -4.926753338110999, -5.60003132401231, -4.082501980907774, -5.157417979645696, -5.651744543066545, -5.56909459969272},
    {-5.205741554426988, -5.028157672750572, -5.378360817075932, -5.289517953082373, -5.519532197170033, -4.833301755955346, -5.56845905724232, -4.931033654632483, -5.329283590491829, -5.045898449476049, -4.555620074594738, -5.808975902087227},
    {-5.051135713741471, -5.154754205417986, -4.762597553915699, -5.004614708031593, -4.507938759540511, -4.989937382817666, -4.77096357805597, -5.137016961009467, -5.18836329669106, -4.919248332197104, -4.771070013383742, -4.158535497922667},
    {-5.911003356182148, -5.100089316237573, -5.024484306921389, -5.421818104105057, -5.029284839536074, -5.469626502610708, -5.204253537464527, -5.1581945979749255, -5.979445663804794, -5.451002038450032, -5.077558264642323, -5.470916955722769},
    {-4.740705501942813, -4.950326703989157, -5.262972674947802, -5.313225349436453, -5.168039093773117, -5.459513398610287, -5.041562667194588, -4.927681934990119, -5.482401277916173, -5.002726565516088, -4.455071956112323, -4.873660564881766},
    {-5.308256750205152, -5.236631775150788, -4.411637862896529, -5.178186699248681, -5.427864358072035, -5.1504330616363445, -5.6159056152099005, -4.691013075484828, -5.029175568057308, -4.647139127918893, -5.527703598267981, -4.492346853246572},
    {-5.149330704553066, -4.794390457685652, -5.697100371425255, -4.94277425707676, -5.377071402973246, -5.618618645699257, -5.455567376326834, -4.96415034109704, -5.098681857399376, -5.023292483614743, -5.22268487742106, -5.143486510208232},
    {-5.571866604355562, -5.488125109184128, -5.270972008189026, -5.595500560078913, -5.903983084465094, -5.185547421875046, -5.480710716390875, -5.682489394927491, -5.599404451366387, -5.413859718220675, -4.80298438369726, -5.548713536614326},
    {-5.630087510007739, -5.1950007440271975, -5.410895472843757, -5.079550360435726, -5.431235916233326, -5.388362327527624, -4.850705876755937, -5.480790924584182, -5.513561338145643, -5.0291403374380375, -5.070560278567393, -5.457999161781096}
};

static const float b3[12] = {-2.7752522972225866, -2.685003746156079, -3.796586121130227, -2.951623451527107, -2.9450537935502155, -3.007612871642193, -2.5299287393200154, -3.3808532884710516, -3.2459589419097505, -3.8059942135066964, -1.9402451302666675, -2.8227517205394994};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
