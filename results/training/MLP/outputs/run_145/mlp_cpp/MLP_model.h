#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.991981818254517, 0.8056556890121445, -4.48716701436652, -5.3467883944053645, 0.8079114387310187, -5.454141486373983, 2.194510566777257, -5.874160931884927, -4.506923757923757, -3.8148884280884676, 2.0043537695579854, 0.29796259929461294, -5.6451771030076205, -3.5519434240539716, -3.551345594236547, -6.016018868488281, 1.5941054244520987, -6.056103769108014, -4.6367110422501705, 0.1847515881687565, -4.8611850413115585, 2.2943078579027016, -5.294470507973671, 2.190203374731551, -3.16455713414156, -5.60816404523771, 1.83449153693943, 0.6795172564800472, 2.8841889937169345, -5.38416279808452, -3.673096080413107, 2.239624057639532},
    {4.3141818681366715, 2.885306433912945, 4.1995549833850125, 0.502367810299465, 1.4741615198417315, 1.7188705435702285, -2.754338263737948, 0.5564958056784658, -2.577669409554453, 1.8533254425947407, -4.389661289058965, -0.12082453429131158, 1.5857881550324147, -3.3186549415792563, 3.132540450536337, 1.336653228976969, -4.618066332238233, 0.7637791266570142, -3.211663809235832, 3.400323756480613, 3.980012387708797, -5.14044543251186, 2.7551508663128956, -4.3274006504105165, 2.254334324298723, 4.6678449511521105, -4.74927427162224, -2.593728535397861, -5.1159212182615565, 3.848877003533424, 2.663601055870451, -5.113098636435992},
    {3.844508409822601, -1.0408919586147676, -1.7115424808957311, 3.2354834939707215, -1.3684993902025924, 3.4067484012406424, -0.10948135620029964, 2.6502063987171187, 1.1411477576024311, 0.6942801646237934, 1.2282628233021873, -2.073121083437515, 3.670176752908209, 2.341565385733115, 1.7809306484488356, 1.827415923744902, -1.9459084548258676, 0.0528474784711776, 2.352238337169694, -1.0791262610917396, 2.4099220391294387, -1.6602309259092296, 3.155090906886625, -0.8549041509368371, -0.04495724570659011, 2.416743897125945, -1.3914181129219545, 0.6808308988188948, -1.8914834092368094, 3.505306837647024, 1.7104525672887547, -2.366364964010188},
    {-2.470824578326996, -5.033726121571006, -4.244512793617073, 3.034940096938676, -4.775289236713767, 0.743995263341847, -0.5822194985171091, 1.9182789877515747, 3.973046866552485, -1.6110713127678635, 3.3678273987688625, -2.183045341541387, 0.24054823619071514, 5.2796709296275495, -3.615836981990878, 1.2929946427381032, 2.704579260926185, 1.271506692476383, 4.697843001697163, -4.780291885384427, -3.104408673976574, 3.299527887700146, -0.5518834579156341, 2.9387340534328974, -1.7125134838131146, -3.0401036966617947, 2.856971646576338, 0.8663269834993104, 2.734859259656944, -1.9191645923320997, -2.9824036311795474, 2.460624411489971},
    {3.2949055182520115, -2.034096704749977, 2.156184351110621, 5.321037504857502, -0.5313582232912606, 5.497239972576399, -0.056657932170713785, 5.216357593416358, 4.428295606817931, 4.2878397440380045, 2.83736512786194, 2.7034406336491634, 5.467172125524484, 4.401866701481951, 2.2485242208368614, 5.628336186999096, 1.3617281615133077, 5.583194574114157, 5.311292901678022, -0.5785824759859592, 3.2022552542156473, 1.954211792892293, 3.696501434841095, 1.1721022748196093, 2.9521118883708786, 3.565251068964472, 1.9496330899627126, 4.494329420123022, 0.7718367336999218, 4.148129905317977, 2.486184632606592, 0.9086624662325445},
    {3.6315666553859924, -1.2903289870478698, 3.1304207669885753, 6.653076451466066, -0.84001675123469, 5.685781586392849, 3.664344076538205, 6.808251015101753, 6.498928767237497, 2.3858662771836054, 6.380918189459096, 3.4165295087683907, 5.573370260194177, 6.521689542774148, 2.712039309179185, 6.055673615156472, 4.997730337831037, 5.770550505688539, 7.053959753222486, 0.6039723390131022, 5.022193502223761, 3.7305844123222283, 5.641661620608414, 3.4787106387488547, -0.6197583290203951, 4.407437726377003, 4.613007602419094, 3.8874922319154845, 2.1969855666968354, 4.999443641165719, 4.3188281791556085, 3.0349436414679385},
    {2.987156267954258, -1.5436564877026526, 2.527909293899938, 6.460964450858356, -1.189597905017585, 4.872042263164403, 3.439685391314939, 6.61197407074495, 6.055218089144156, 1.9364141681251636, 6.019440550007307, 2.0086451825961817, 4.79161839634661, 6.572913041675435, 2.580668912584306, 5.591160496264503, 4.996029570607485, 4.930957146003205, 6.9819110555785135, -0.08347746264988998, 4.59399268412749, 3.8552339177259576, 5.486101891221299, 3.10397959942084, -1.3162511344236614, 3.562538682177355, 5.016242326048872, 3.3316832074325977, 2.445812185019684, 4.176209416121746, 3.878024563359082, 3.3496112117914127},
    {3.370574839492141, 0.7846095032693468, 1.6271793396127, 3.0561808657973653, -0.10629473149938956, 2.771069990600005, -0.8068933613105258, 2.6420808672081977, -0.37245369676273016, 1.1214743457745016, 0.0008220933414246855, 0.5474709046748538, 3.3112224648487505, 0.33602330228513944, 2.562222603092518, 2.93786100716945, -2.713834229116971, 1.3126899813313582, 1.3574375243594614, 1.8041638529331732, 2.612661355737736, -3.024044776663685, 2.541770712769602, -2.873841586578827, -0.35891798696330957, 3.522308402009581, -2.1914533471610413, -1.5794202108099895, -3.6369553419432754, 2.855856940561622, 2.677618865863297, -3.7298955021920093},
    {3.6857294847952264, 0.42129847959195227, 3.0100928790914856, 3.828134922496724, -0.05497398361587226, 2.4618699654171463, 1.6731563064688864, 2.922760194005276, 0.670901767794828, 0.2701356134797405, 0.7088886081224754, 1.4242388948115519, 3.6068979273925845, 2.4834003698938676, 2.0206173347589265, 3.2169313944359126, -1.8441524840692671, 3.121541757347115, 2.221778551254407, 1.7634203832188602, 3.814413639423904, -1.1520672389605964, 3.8332128527192424, -1.1538847024070815, 0.7329517681520298, 4.35029325051992, -1.2024841759979754, -2.472809982916544, -1.2531313716975314, 3.6163321715392973, 3.540559821703203, -1.6818053782331954},
    {1.7717483023543916, 3.2378894948993597, 2.790088302731961, -0.7189376721247347, 0.8116440514320802, -0.8184238775232837, -1.5827379980200427, -0.806555983056261, -2.7580314207282686, -0.9095389888454444, -3.3664718324841547, 1.8401651589162407, -0.6613221820239694, -2.7685935733233857, 2.2594169738714, 0.004151537595892936, -3.1307676447814785, 0.22902833981503662, -3.023659709872801, 4.504281841388889, 2.496155900635523, -4.0322786362388126, 0.6252271978239079, -2.9781319528964167, -0.11708768073275735, 3.0158052032851126, -3.5224635294945714, -2.3931952655506565, -4.140459186941801, 0.7468543660166234, 1.4647350029586061, -3.571850531155298},
    {1.762586431005599, 0.05605384876953904, 2.4401438456359292, 1.370360490688022, -1.3133415878479786, 0.5925096098065687, 0.4533107970750009, 1.3731476340957152, 0.9414821456628925, -1.1093351285014683, 0.6852651866494837, 0.8749321328606746, 0.675296409949217, 0.3321604684548318, 1.1678261028126464, 1.7303635623197593, 1.0451303791935278, 2.2955549787047698, 1.0562045898244137, 2.9434102840853313, 3.249570361428738, -0.5378893247377197, 2.348046829321417, -0.2429747226752128, -1.352455226656641, 3.463639783852452, 0.1550138905933559, 0.39431501741380576, -0.6500030251406081, 1.0907535946763276, 1.5389584677058397, -0.8575720606448949},
    {-0.11818897063162148, -0.1592512837602934, -0.5665587980122034, 1.743061001959472, -1.0851356772918759, -1.6843447524344746, 0.1590156253465681, 1.2142586455334483, 0.1861963742581834, -0.982996705364269, 0.17994124578064322, -2.7951141793889756, -2.2711963345213495, 1.0188281442471436, -1.2333697369997358, -0.5968705532243425, -1.1522740874281396, 0.2402943790047437, -0.4894422147861889, -0.6743352291218283, -0.25275812610683474, -0.21563268739824967, 1.7674903759449356, 1.4013888939553556, 0.780205698052448, 0.3284911753407706, -0.6538586917724094, -2.002438160631481, 0.6939361870387424, -1.409461892356094, -0.7912485712788379, 0.02876458108570537},
    {4.970452246720231, 4.538978211212463, 4.633251537678168, -0.29524539576390335, 4.545239716696004, 1.1860813855776713, 1.2731235084834127, 0.08347133156737935, -2.239113226673628, 1.6280650153723442, -2.53850345998352, 0.2056387074433513, 1.78718200614314, -2.706470805259994, 4.878978012594121, -0.024930075720224314, -2.4066949650957237, -0.5903319191687416, -2.7112493597817906, 4.278267564518087, 5.338045430686666, -3.497008203633784, 3.502898538611556, -3.3017567690244123, 0.21878191275863873, 4.570971923909214, -3.2179916930066796, -1.2980794939024758, -3.6127067915612563, 4.584340540075235, 4.460542772755759, -3.4232163359467194},
    {-2.8576522483927707, -3.74616979485835, -0.2620950558255921, 3.7735094875736923, -3.3128829586514423, -1.0006598636390112, 2.911086049349444, 3.950379939630377, 5.302143290638613, -2.6385762883842303, 4.974301925675794, -0.6286197013565107, -1.4341977720538903, 5.599045423051106, -2.784375844847313, 1.472015542747703, 5.41884661193828, 3.123841267973847, 5.315006705628563, -2.483965715000245, -0.8795612965417525, 4.943871287416801, 2.3982876364512418, 4.928911205910655, -2.9427517591636314, -1.5106796805897937, 5.164844580632836, 1.5645061109447767, 4.911641415479813, -2.2233514519668915, -1.6730403893550858, 4.657968201368335},
    {-4.438033410044801, -5.012119635015717, -2.166057207203124, 1.1212471628368466, -3.726472644290788, -2.5070898651621234, 5.567495341394931, 1.2955996058494144, 6.135807223204051, -3.4646675633510884, 5.744147550261926, -2.0337510263873013, -2.497667935421655, 5.879855994248411, -3.4965425337640936, -0.7523759074615204, 5.973073684074785, -0.18365207946994777, 5.896488078010182, -4.876290031383776, -1.8783546903493598, 6.244412344358701, 1.073534852524225, 4.844708604727238, -4.799376991844586, -3.2000586411306067, 5.675448535274662, -1.3185953541778872, 6.2367211214285065, -3.362736994006224, -2.0550912364205987, 6.25403209225442},
    {0.31823876982932126, -0.011208524678507581, 2.5587202780642797, -1.048070648141314, 1.205658519653022, -1.8221985205149351, 5.368277766185739, -0.7713816573621005, 2.9887968121048107, -1.8749362656409834, 1.973708161337452, -1.8353021895104773, -0.2272593398076026, 0.832372992997378, 0.5874843644170807, -0.8814089241199257, 1.7873680033146606, -0.31992859364819615, 0.9408662089622265, -0.6722802486477293, 2.3018135781519784, 1.074752836023605, 3.0105784283218155, 0.43455810817507, -2.058983867568854, 1.01870955596484, 1.1545491742223806, -2.650366461836164, 1.5463943728235685, 0.2598232161525035, 1.9231746797913747, 1.7907792061722287},
    {-3.2377750665301366, -4.313642940316911, -0.6215800888479408, 3.833663024804552, -4.120197036039677, -1.3247835420403544, 3.4174224471721457, 3.413342857450391, 6.3283231915247, -2.7204989139739677, 5.4493070225457405, -1.6127389777473176, -1.3721158972375378, 6.21684373189792, -3.1079809653289945, 1.5665995466750975, 5.707466477783214, 2.568006219567006, 6.434293339311616, -3.6855273917980265, -0.5939246017677248, 5.733923568028366, 1.616086612065502, 5.001233386143884, -4.4955729652723795, -1.2987877740635, 5.397562653050203, -1.2999341194047545, 5.016372816563625, -2.383422456127031, -1.2878763104536473, 5.470026740638373},
    {-2.2929758187457767, -3.389810929673819, 0.03328028254366489, 3.2248802731530244, -3.13463801272124, -0.9030009541853795, 3.669372537925232, 3.251923618173547, 4.968405068240777, -2.7588427513456395, 4.216744528832505, -1.7528282988225767, -1.4840107742876933, 4.972720777599671, -1.522037596352088, 0.9550705379308069, 4.767236473121679, 2.1992938205464045, 5.2334909914589876, -2.5619197704779073, -0.06811719757348865, 4.624669172991987, 2.0874496480059177, 4.3264328183404785, -3.9082939420488274, -1.0677509513555508, 4.316925706237828, -1.1722359660343489, 3.955470053533899, -1.9859106745257997, -0.10146283458725605, 4.707094209411296},
    {-1.5456098747387266, -1.9073796502821332, -0.2550690723366535, 2.1041683351195526, -1.0975304582694754, -0.7575918980430169, 1.0827116446713922, 2.7231477951645524, 2.635492615402636, -0.08322361415585851, 1.5888803551743467, -2.604234384753402, -0.5915380894347482, 2.721771379872673, -2.245250051584021, 0.10497604553938504, 2.0468119766844253, 0.7075161179643958, 2.3101960952136245, -3.258152874022433, -0.49987225505037, 3.3971881284818997, 1.1480966740900884, 2.4753510101635743, -0.3773648996884894, -1.357764307669889, 1.7953448093659838, -1.0487878714592398, 2.875752172514583, -1.0614601374893422, -0.05339838808092963, 3.3489207389594657},
    {-2.126401835580595, -2.226381261694401, -0.6700110519468595, -1.6165272483151478, -2.6477272660923488, -2.002638558153029, -1.629159357213293, -1.3575153280408359, 0.12631749234666514, -1.460408765764721, -0.1750403984181425, -2.3883925894619757, -2.73076539541596, 1.0819131670508673, -2.097370165009647, -1.9836484832760741, 2.288959771898812, -1.2815016383521975, -0.44967140363671076, -1.312144123666608, -1.5036663408472237, 2.1432431541069605, -0.35159771614502866, 0.5338338467602063, -3.2734055352801192, -1.7787599390793132, 2.3894034950871417, -0.9331139195404059, 1.2437775442180659, -2.296003915463986, -2.8538622503493847, 1.3293867175543255},
    {-4.191043129035338, -3.805473597728944, -3.6958626340499086, -2.2852892810455363, -3.15717361816864, -2.9656378257362954, 0.4788293898316462, -2.088593422481169, 3.123275417667141, -2.0187518615881324, 0.9672862112762135, -3.221867705157738, -3.2716247303087655, 2.7333718626549217, -4.348633876047359, -2.028084984518895, 4.213708447138926, -1.9172581601170646, 2.01134410836794, -4.731590829117642, -4.538071306062236, 4.782350298083843, -3.275588240313287, 3.3396615433765633, -1.9152886993646925, -4.181861887412583, 3.9961482509761415, -1.0330370153996815, 4.513897730487147, -3.5221504345076866, -4.067465865377943, 4.484402340417081},
    {-4.848782220117117, -4.5031116902915995, -1.5464653393901229, 0.0341392134956082, -3.8480870205803117, -1.338785735943153, -1.8525629703655384, 0.7952354152730682, 3.382901068452547, -1.6313347475836881, 2.20811777036832, 0.21066407097081652, -2.6325384342536613, 3.719539566383277, -3.762790835818615, 0.5303561044735416, 5.071125594929718, 2.1668729463679344, 3.6161266604178635, -3.6398061191671127, -3.2399034794686123, 4.644183968451783, -1.863054784213839, 3.486225173986043, -1.7451997553754082, -3.683810864434855, 4.7249598910039925, 2.0557357260797993, 4.573089634795614, -4.209582505406799, -4.027691307733813, 4.658950283606177},
    {-4.1651509469691845, -3.5520493714645105, -3.589070081746577, -2.6573299676377666, -3.1085881072005916, -2.2262060809936584, -2.855104096049115, -1.5350250788845716, 2.196309425964949, -0.8716076321693351, -0.5220471472305371, -3.365452638442395, -3.08073026244537, 0.9929970559217556, -3.221628128113137, -3.054469321506654, 3.52474780999696, -2.4870278894867694, 0.1629292559852022, -4.927572893026005, -4.375309816706029, 3.598592332061441, -3.9641268447821236, 2.8232245048144597, -0.14616872492414426, -4.174496079218281, 3.242416559928447, -0.11370648779530627, 3.644759841831092, -3.631749298784781, -4.458674798982956, 3.336280000903022},
    {-2.4107959312606217, -1.0654246841620467, -1.26708238281047, -1.708971374741652, -1.28971750339571, 0.31575942974697213, -5.495080097657924, -0.2095072497598968, -1.2159159593045836, 1.1990985682710604, -2.755679093614568, 0.12533983100767435, -1.2991374050634497, -1.5047646369311292, -2.3418132500792987, 0.2678324694203092, 1.1848002435882492, 0.36881939874023434, -1.7378447681783655, -1.2555250097194246, -3.667260450224035, 0.7385984419613334, -3.661799685854741, 1.0372257404258487, 3.19716425309137, -3.0585485898252327, 1.0834496558399143, 2.4392985174546733, 0.6492704929068891, -2.1782485899791935, -3.5799150921223206, 1.0277850053790754},
    {-3.6308138576174613, -3.405903531051932, -3.345220724272138, 1.1874455447894106, -4.203966364770846, -0.5951777666481957, -2.8756282121785492, 1.588602923717103, 1.9285554712319701, -1.0482827842446134, 2.5182613876308495, 0.048161849724771444, -2.20994185592239, 3.308080962494224, -3.39012808246332, 0.26579185656378373, 4.969121741066563, 1.0037697145731388, 2.6595967290459823, -3.092107342411146, -3.9648741122132645, 4.6436770177523705, -3.03841681127896, 4.973809310973274, 0.33494000392078177, -3.6488444835407594, 4.874195838581624, 3.9931410080347085, 4.313215262341264, -3.4445648114911593, -4.24155369961022, 4.667337518714045},
    {-3.5313379119369754, -2.7222774138333867, -4.68240081892826, -2.5664669450118542, -3.296375563622809, -2.3373111863094325, -4.763052803923534, -2.278071863073373, -3.17619336598404, -1.1534277440029013, -2.5252799749824693, -2.194335417927712, -3.435979696066137, -2.203799764959786, -4.302720537604513, -3.245396736927903, 0.7567298425881289, -2.004391170079785, -2.6838532795837993, -2.585982768971569, -5.196685394636846, 0.708056355044179, -4.942451990528009, 1.782824935122491, 1.6393460180303805, -4.70389427581321, 1.3266319944080558, 1.1814511835020658, 1.6870176572003353, -3.9388152453474046, -4.462263252740246, 0.5536242619957181},
    {-5.919338615871611, -4.782450011289041, -4.554102072979446, -4.0893595229765465, -4.062904949726496, -4.201831314093677, -4.633309901018967, -3.1849554625988157, -1.0166906227559163, -2.407801152549935, -2.5872340872712853, -2.0058471182364683, -5.379544958000825, -0.8829057872367417, -5.149757839811689, -3.7593526157016997, 2.3727722987690076, -1.4079657961130563, -1.7507199281419534, -4.614508621829591, -6.007354656783668, 2.468720519231295, -5.963089230084293, 2.0840082523268837, -0.44477400610192064, -5.863734963206272, 1.9703314960077434, 0.40035756496703845, 2.9691922577170256, -5.763449147917669, -5.656945654072576, 2.4424944130096056},
    {1.0537782146217174, 0.293522461170741, -0.724051663998366, 0.5085714935620683, 0.7146805124503344, 2.256342716631338, -4.04247946172868, 1.2760145302182655, -1.1316796138186487, 3.2627059762759822, -2.226057417928204, 0.23500555556430813, 2.2800338524576973, -1.2463178638517936, 0.4065566035845165, 1.5481031780031778, 1.3408875521404937, 1.799946077305915, -1.3094723427533965, -1.0378348815805192, -0.5599084149127391, 1.3866630819698873, -0.9012274261234308, 1.1971168639917893, 3.3286050359422843, -0.005463272556272223, 1.1039870774097105, 4.505743508780093, 1.1923301794438468, 1.4533040354176245, -0.30936192210003066, 1.343098678054046},
    {-4.937040865434347, -5.47503351276035, -3.99792127672508, 1.3682037777637437, -5.634291729029157, -1.1691404026461245, -3.3090073406568585, 1.797739129525866, 2.465858661081171, -2.0726496136673758, 2.2600081504679075, -1.498183142722593, -3.0527276513468817, 3.0949504330178574, -4.574596121479935, 0.18350600200036907, 4.465256564017466, 1.3840984690007572, 2.8022242394439982, -4.285942218330175, -4.725137290436061, 4.3377764652132305, -3.084226267360804, 4.333252066287857, -1.3781558109897363, -4.688892185196624, 4.731925471635937, 2.400290227610659, 3.6539890818311926, -4.667608640489123, -4.6378786548960065, 3.8533170904763328},
    {-2.7839485779483844, -3.637374565998112, -1.2591415012285405, 2.7695963234226233, -3.066807320648635, 1.3865455049280193, -1.5189726814492446, 3.4725021339744404, 3.2341516377918316, 1.2061677003736986, 2.3142153033384596, 0.0426522053727239, 0.6785048964534593, 2.9486830638480184, -2.7414185103478492, 2.4511437228808046, 3.263905191950789, 3.0758816062127625, 3.1661204775385072, -3.336976033053585, -1.265149069054963, 3.7203643989903528, 0.348966157968989, 3.499334256835589, 0.9865038016745772, -1.111258697248727, 3.3668865305097055, 3.1950869278777767, 3.510743968991485, -1.6357066792424089, -2.089422979131083, 3.628820329545253},
    {-6.89983911033893, 0.3229488099424806, -5.599177444651244, -6.330957242756172, -0.07461991232746866, -6.349555328450579, 1.4933607378133233, -6.062701935415749, -5.110049242071255, -5.494412972853019, 2.1448022173989365, 0.9849941451228771, -6.652850914209869, -3.6718714463422297, -5.495729996153215, -6.661238941061428, 2.4530012327104997, -6.446965696734255, -3.2551082354648284, 0.9319275398563485, -4.59863755335288, 2.3162884033385107, -5.73214634823041, 2.5254598473530647, -6.709767633834755, -6.503175840880582, 2.58576128089567, 1.4338156527187906, 2.137865970806164, -6.313415031249183, -3.6259856049512362, 2.092551804702193},
    {-5.326511268218853, -1.060298372986031, -5.539220734508081, -4.381101598469957, -2.138787260722784, -5.690535291734451, 1.6811725501744226, -4.96123789368672, -4.167289439203195, -5.703835409476025, 2.7047308052638277, -0.5285846177653502, -5.625364939753989, -2.8376112428583298, -5.001159727613507, -5.332754079374955, 1.5487661669302861, -5.692181390261076, -2.050813079902191, -0.2989350817681637, -3.7992605741907717, 2.168980479055656, -4.697156679087468, 2.7871022219575297, -6.033682327091689, -4.71891336590798, 2.1441339427381556, -0.06423804968297628, 2.461307581833233, -5.589673387461681, -3.624653196585046, 2.060280367861108},
    {-2.990204629027942, 2.263535637312743, -4.4241870852239105, -4.188303019386145, 1.5148503920333836, -3.7696998915577167, 2.4566067055269625, -3.624715941815046, -3.759168846398964, -4.23228294188185, 2.0432647020604584, 1.2617319605220847, -3.4976997596623898, -3.233914460589235, -1.224832866123489, -4.876842963455619, 1.2482713020861642, -4.4806231800860665, -1.8274917926263392, 2.4479289899594603, -1.3919531153702789, 1.025752293160445, -1.95868286262614, 1.8741203751991264, -4.417264354592598, -3.0737588210556206, 1.2329126185733132, 1.4151625153713692, 1.5657178643262912, -4.058035820368242, -1.4679915055413852, 0.945263810459819},
    {-2.516332047778855, 2.478221182326472, -3.6946819745377635, -2.774317748322084, 1.104025210462056, -3.5642120172684817, 2.514881072310464, -3.1809247442716817, -3.9181585906200453, -3.8191773881413833, 1.978534886933513, 1.074522675720116, -3.485949653160993, -3.359586826441445, -1.78216750480804, -4.498353740663159, 0.7274150612245089, -4.443654782412309, -2.1123486642910883, 1.5209972246341807, -2.1057864985226087, 0.4835723067385086, -2.1467930481126634, 2.32018623551312, -2.683469493542514, -3.432437984597389, 1.044184882080964, 0.9223336977877796, 1.7733550050591762, -3.5665465859023966, -1.5824792796358864, 0.5283207648930502},
    {-2.0205669584161905, 1.5515141368408532, -3.607694445800517, -2.547128395238807, 0.36752342621639755, -2.9578050245488585, 0.4776583366117516, -2.269741196655408, -2.8024118204843527, -1.373393137972873, 0.7907065906786126, -0.6870623692769424, -2.1169188545372135, -2.285009861325226, -1.9183924544460713, -3.403524740904572, 1.0862721766336492, -3.32321826671369, -1.3871974979074568, 1.1864745152037437, -1.1314551735907077, 1.4142320290838388, -2.212856281811223, 1.7246229031114082, -1.8016728500229917, -2.4485713520263213, 1.8948128585220585, 2.663070388932713, 1.59280893173215, -1.762614531984341, -0.578916330221662, 1.2634856934129748},
    {-2.439682995949966, 0.25616472827915204, -3.688343074052121, -2.3218817587726095, -1.9655243305686103, -3.5717603828232396, 0.6835301234791213, -2.7337953453282973, -2.0570220552201652, -3.2288017396081985, 1.9047781716783925, -0.2228465084239887, -3.548114602462522, -2.0753525679494906, -2.0377980820638157, -3.1021295234692876, 0.5757614335406225, -3.3327843020385712, -0.6025240103358871, 0.9061299202585553, -2.345026702752232, 0.9823057447379251, -1.8759937323406073, 2.552732213045413, -1.1557157456019331, -2.849404623451843, 1.0967890391417319, 0.6294162994714769, 0.4787555432002544, -2.3041258946821555, -1.400120141105738, 0.6190327226393793},
    {-2.272996369739414, 0.9729191221577872, -2.7086694372534286, -1.9717806157917783, -0.42965165784121856, -1.6653632120189752, 1.883913928488494, -1.0351800340275328, -1.5237670966063828, -2.239822309715814, 1.1130622305726299, -0.3766149470220087, -1.6846717591064755, -1.5413072972556359, -1.8884846579822396, -3.0428194372617954, -0.19089194773674412, -2.641985348948728, -0.7620492219752149, 0.19100156617001848, -1.6607956486665842, 0.7657104467020606, -1.0164757501192239, 2.4106191387254436, -2.606356526875076, -2.229052845939416, 0.29050741285918796, 0.42840195215347643, 1.2234793028454343, -2.341126529028329, -0.6559076623100925, 0.2735087589391961},
    {-1.73825176920588, -2.2449723195775855, -3.2064898764346705, 0.3952757008691602, -0.9617496362609498, -0.7339232780911654, 2.187597646842947, 0.5683121183927614, 1.3293639950067466, -1.755370932003792, 1.8889153027139824, -0.8536307908692878, -0.3629427423113255, 0.5820672014144899, -1.242496426558192, -0.039211032342061226, 1.3182868505086935, 0.6241192917121295, 1.1403772360492221, -1.8122527233736514, -2.183078343965576, 1.9705326314072045, -1.860222177490021, 2.672571824251081, 0.4324836820582294, -2.4453741670025533, 1.2037781771575808, 0.8283126562687054, 1.818164166255993, -2.5067148438450153, -1.5181351441821043, 2.1588736429380226},
    {-2.123472229156351, -2.3200026393076305, -3.125731234814436, -1.064188724849972, -2.635092720934968, -2.570225506838313, 1.4370180696299395, -1.6933309898527835, -0.9269968249560212, -3.399350514314226, 2.250279008164739, -2.306417122866759, -2.0517349691515925, 0.28794208878426547, -2.860333677827161, -1.9532300006880523, 0.8882010020641964, -0.6400541340247823, -0.06041736323839191, -0.2899889909192762, -1.3351322089024977, 1.3603990240891817, -0.7810780853793146, 1.9702459083577848, -2.132306344925613, -2.4298132835512534, 1.0636298246774933, -0.9731493754384528, 0.9789847423597391, -2.6047468689671436, -1.0390766039169717, 0.7047188997092232},
    {-0.22751524539196558, 0.2735743103481652, -2.5734319728496833, -0.5454365049783936, -1.9219663939132645, -2.169384111028584, 1.2375707082839607, -1.0413740452520512, -1.6891541176222904, -2.7477037042576877, -0.15728334068495375, -2.6921590186180846, -1.1975395417611963, -0.31532965421129455, -1.2343560951240524, -1.737468672047951, -0.3550146863825326, -0.72279615217503, -0.4904613567319224, -0.182799808072911, -0.06388858195697561, -0.09340008843531426, -1.2053121312226542, 0.2741912691948316, -1.2386840311401288, 0.6092227555802208, -1.010158211282908, -2.125949212867764, -0.8765570433950604, -1.2994822289918995, 0.5839255380484314, -0.2170033894264507},
    {0.7172319469661371, 0.3736563469654547, -0.9912769380252878, -0.8432168664039428, -0.5185962901150462, -1.5529355875513338, 1.3107117515869708, -1.6771800342254557, -1.2115270996889782, -0.4712197329404861, -0.9192295164150888, -3.2325951378489504, -1.9021583499757824, -0.6059555719763131, -0.4912559269027502, -1.0661747758421185, -0.3773443100089161, -0.6697042170629629, -1.1567301496235476, -0.1230483412109924, -0.2712217368916593, -0.17931834514296116, -0.9817224402290369, -0.6885703078343081, -0.1175399116244599, -0.30295346454686084, -1.142174297020888, -0.9707504357451453, -0.370411549236799, -2.002070575161867, -1.292052204514241, 0.468805751326724},
    {-0.2035962560947179, 2.1470416999606607, 0.7073517160740864, -1.55673866993783, 0.7050152479868697, -0.9004610254349875, 0.9212369246189165, -1.2065816385580506, -0.9853673297594803, -0.7937142562805662, -0.04586242936233246, -1.4148972658743555, 0.07422466713746383, -1.0182470207696204, 1.3566286209547953, -1.4109775124154549, -0.47401738985293485, -0.5578161521734735, -1.5859057551865399, 1.9575594391252369, 0.9813437648353338, -0.7771081412785933, 0.4091679373538015, 0.16340234751319088, 0.6965966349566954, -0.559236762399732, 0.2125967690875407, 0.09218067782092601, 0.15750786248912144, -0.31321368268065414, -2.0436710292148366, -0.8664062523576929},
    {-1.2256947844563102, -1.6332316209795426, -1.2580784262164844, 2.1405568434548368, -2.187390075517422, -0.008661035436354977, 1.2862855416015222, 1.1585761002047128, 1.5413999980663236, -0.2906430256980149, 1.0504437932583157, 1.382270889445515, -0.2156922895777474, 1.7421967330080914, -0.903875064922144, 1.0308629755508107, 1.5028883461871512, 1.6615485290623806, 1.8026912964017778, -1.5574554276162265, -1.07400711010495, 1.7637769425968846, -1.2359695001317585, 2.5839009562713047, 1.2432954691207883, -1.593882295925392, 1.6343123820796428, 0.7719653979942294, 1.7861089285140943, -1.1764847517967525, -1.967334642256151, 2.0410471145251496},
    {-0.5577145283580118, -1.320857242354018, -0.41756031996908033, -1.4693202839940185, -1.5510623285675194, -0.5391711424584359, -0.42893724200524824, 0.22481638607572535, 0.04251353927749531, -0.3832035513399788, -0.6221209538475138, 0.9794762117682673, 0.07060576606952436, -0.0906427882219718, -1.0138119201763105, -0.6580944259625442, -0.3413036998615502, -0.9900234409681523, -1.0448950778741266, 0.1561228693775759, -1.3406940636205342, -0.1924538685594705, -0.7119065522627485, 0.9804344139599747, -0.1524429966457087, -1.613239800207086, 0.75825277570674, -0.793914988711888, 1.019860539268998, -0.5161191452272629, -0.9563853855963267, 0.2724073504812739},
    {0.5937104005340779, 0.13813563088153774, 0.0410466675504254, 0.4466388123985538, -0.7828779298160997, -0.411985113422017, -0.3819946356680749, 0.802328572671087, 0.4190336700914877, 0.5330812832786427, 1.0513894313448071, 0.7051394259911747, 0.09321758613807331, -0.2439652393791835, -0.07225751852523433, 0.9219040319589118, -0.6918240000476991, 0.6057179725849676, 1.0390909769311076, 1.505952072135154, 0.22053122649880802, -0.18169904617974708, 0.7886677452839816, 0.008859252023463628, 0.8840290052346481, -0.2807016741874521, 0.6070766130604801, 0.15596868073191952, -0.7298254110466851, 0.5691782854524838, -1.5645146423021534, -0.7463742048249604},
    {-1.4008650190064067, -1.6733413752068884, -2.6059038118426914, 0.10595218374510391, -1.7844991073133791, 0.06383418320270676, -1.3116401924299508, 0.18608270622632192, -1.0064419695194176, -1.8506115473304865, 0.3143100338657744, 0.5428020837207667, -0.2498944036804775, 0.05260067842826358, -1.4473418101530706, -0.4475130015862426, -0.4447155280952113, 0.7213863318274532, -0.459345946501601, 0.020043042724978737, -1.3200867340703708, 0.8617618361230338, 0.4053145137719806, 1.1773613650845765, 0.7032785717262973, -0.1750975688015913, 0.4858215330672163, -0.3046949684649346, -0.1332833618812778, -1.3875119987732079, -2.113456709315364, 0.7915444634567371},
    {-0.0186416848559583, -1.2992118977801312, 0.1965847702218224, 0.16923095076876124, -1.1883023974641613, -0.4926857722573375, -1.2126843590724412, -0.3265403282930691, 0.3110878757529723, -0.3087199182912684, -0.26494430429690397, -1.7412198732922672, 0.12883335881359548, 0.38728630738629793, -1.6714971670332728, -0.2214453046047657, -0.33293637707862817, -0.47875706936822354, -0.25181748261458625, -0.19278807297153588, -1.1144359754871573, 0.2427499045941947, 1.52724709790913, 0.12632559485865053, 0.71442087262832, -0.4792605037965856, 0.19481426115650996, -2.6842245888390437, 0.5291925644764631, -0.5064857470993753, -1.0832293421257566, 0.31328388259011963},
    {1.318227213941024, 0.8038461711366246, -0.8755398959584035, -0.5280583760970345, -0.04908728037197615, -1.1121146934944974, -0.6387800020209375, -0.919733670173428, -0.9890215581495339, -1.3380550816047612, -1.7377100474935878, -3.207093793446885, -0.10179753111688418, -1.5895500042856237, 0.6538282706241638, -1.112069416055702, -1.2761737890904812, -1.4420033349205787, -0.6253738219425715, 0.43022949208382155, 0.28359424135721145, -0.8795078028139601, 1.2581034999315743, -1.4420823508603557, 1.656238213771287, 0.04883283339764647, -0.8331790661414529, -0.6815707723081943, -1.465493202127622, 0.27845058198318123, -1.8480673557232414, -0.8839769719677932},
    {1.7835352421432942, 2.245140110132247, -0.6034935019238754, 0.9002883739948876, 0.30054478659114076, 0.693565085159766, 1.183998046631603, 0.43047039624652617, -1.0361206398576843, -1.1783500974675043, 1.151542098036994, -0.8298098580400792, -0.6299963801113309, -0.8554865024114744, 1.8423140549518302, -0.38754545301112603, -1.8932362129108622, -1.1123681117173128, 0.013291683349221936, 1.909593219038801, 1.0421547589216946, -1.7871114104282904, 1.9762342805875939, -0.87558170149804, 0.7827787084433533, 1.0140637863152815, -1.0086574238619144, -1.2498963659992612, -1.7733940703507538, 1.070045662019832, 0.28137532607399485, -1.5141502117837657},
    {1.8051730480753343, -0.11730199418424891, -0.7014224960225747, 0.04272798869678551, -0.8854113512562071, -0.3065799803287238, -0.07000705837621007, -0.13452225147794858, -0.7228615596918, -0.4959932512218619, -1.6362934470776742, -2.541164872767143, 0.2129413454001281, -0.9563949167779101, -0.09015323423976412, 0.1987862981371092, -1.252801886225997, -1.3007172992609008, -0.4542594771794504, 0.535566720135463, 0.07836312443407306, -1.3817872276035104, -0.08113263648325908, -1.028387610194122, 1.3549620700969305, 0.9460863946862723, -0.9686892415182017, -2.9595476965077148, -2.407192713949107, 0.4721014336288692, 0.3168735702819622, -1.1915521005247003},
    {1.0309647787406924, -0.31328108072140515, -0.24392964012661386, 0.7385345679085586, -0.49951530575825676, -1.1530716419176332, 0.9372044034364585, 0.5437450414591739, 0.33534846811738867, -1.247862394323147, -0.21849155655200667, -2.542027932725701, -0.29948650236728047, 0.2487268323096337, 0.7635634586190444, -0.28012246642880745, -0.0306920446598673, -0.39527549254885597, -1.1220985060293613, 0.8331777876134561, 0.0244444083939041, -1.1026040677038895, 0.6785694737146671, -0.1627404218138027, 1.4462547822739322, 1.093878865644043, -0.19418487563980527, -1.2910591742596447, 0.03979950594673826, 0.4029356410127877, -0.8524076301003357, -1.7794752793389175},
    {1.8240256431110036, 1.4484029736352704, -0.5578099199137175, 0.3934406388262313, -1.3886768231959503, 0.8376638455644577, 0.12968432512791883, 0.49298542174660737, 0.024142253909635553, -1.3770453326530112, 0.8832116362150434, -2.571507552324934, -0.022134900556873078, -0.04967196213656895, -0.5521088688081379, -0.19647274114317564, -0.9249580038469785, -0.3039917936282124, 1.1961136711252907, 1.0776952964376125, 0.9080394898854195, -1.8677475493456812, 1.3038153005480342, -0.05773042807999016, -0.5618273344290374, 0.7712845221717447, -1.4034444536399298, -2.7122838467827544, -1.4261627753483919, -0.26509988244817173, 0.15408207595158763, -1.9255872379957397},
    {-0.8566274560028467, -0.3091845391970864, -0.3031453309453482, -0.18575668950597632, -1.0471395671136228, -0.6124700559731258, 1.1565511137958233, -0.8170580078046091, 0.48938672364385166, -2.06157462744736, 0.3238531812180706, -1.877409979848944, -1.2844725336082665, 1.0588693577898116, -1.7356156320546896, -1.334050670314527, 0.3487484732347227, -1.8409586183652216, 0.6392943880960403, -0.35277374649023213, -0.36200819774550114, -0.6568345508719962, 1.1901944907070912, 0.8067732180617734, -1.9194536665128161, -1.29247543866098, 0.9485630874046094, -0.09925608404264055, 0.1507590060337607, -0.6292108501738131, -1.3737394017970648, -0.6953617519532619},
    {-0.5573076023900233, -1.4238176580293254, -0.6161578937836149, -0.05393943556195529, -2.8058303117900345, -2.1721987748157825, -0.2549864179483839, 0.5928080320002027, 1.0726575230294966, -1.2725902106173304, -0.6090346797079517, -2.1558867481370307, -0.7457756207045981, 0.701036491995064, -2.3814637535810963, -0.06736404997805441, -0.4853102449941955, 0.9773449171862401, -0.04168161694297576, -2.3340852529873732, -1.7713398982808406, -0.7060769743364684, 0.4744035676610429, -0.3766399688077398, 0.46026736227209364, -1.3862764086701336, 0.1773481546127518, -0.045899861039455724, 0.2641737811586111, -1.0947146318022984, -0.37786699241212024, -0.2764323625105613},
    {-2.2908777778813163, -2.350597768752693, -0.9925575502662981, -1.0046708342840485, -2.0582262213566693, -2.0995499850383545, 0.16631127811206597, -0.3427769974007421, 1.3861475311411373, -2.1890653069729917, 0.1875790711663912, -2.043167511674209, -0.8749540128924496, 1.0375823408565779, -2.0630148348650277, -0.6673794280743193, 0.6439479190569017, -0.05996145689014064, 1.0513371020636972, -2.339353266129728, -1.4923896662442289, 0.7900958843616196, -0.4747584362999193, 0.7557628034715881, -1.7188929608637409, -1.9758879871321915, -0.10730505740828156, -3.283227299754612, 1.2375012088972634, -1.7208389047982413, -1.5899257480793543, 0.49868446311740616},
    {0.36292006678247407, -0.9426384064728179, 0.20337658416863666, 1.0749099534480686, -0.1872077410156491, 0.25184723662231856, -1.9982964812200665, 1.4757668438300557, 0.0231432263481225, 0.44766729181212433, 0.41461261536299865, 0.24229949631316353, 0.27259961623016965, 1.165363755128781, -0.5866836963281674, 0.29939070295965026, -0.045612785397140754, 0.9870319213423575, 1.6413841664875237, 0.016308371901137046, -0.5719841753915299, -0.37621662634519426, 0.0527213439521324, 0.21598607320076063, -0.048358446816867295, -0.04225211604998132, -0.08285821907773389, 0.23753299505722036, -0.2679486316328302, 0.6020898881779108, -0.05710299224700063, -0.9386788098596658},
    {-2.0801383764908166, -0.5948713767451622, -0.7355249033198699, 0.7666360979373255, -0.766954109008477, -2.3132017521651624, -0.1046860013695089, -0.37788083805184114, -0.1406869686522428, -2.6271247196740304, 1.3241791201446174, -1.1789842758566795, -2.336202652777457, 0.6119360205215768, -2.8049604773436885, -1.9302317050956268, -0.002707117341595787, -1.0034765784250619, 1.4156839998122508, -1.5332764776455992, -1.738727011594213, -0.3856584032785685, -1.3800645222557337, 1.1070834983500448, -0.2303026985765443, -1.739623664810674, 0.027105185386526384, -2.914718247122129, 1.2121600212683905, -2.75447199141414, -0.9780117084649613, -0.031712711294866254},
    {-1.0421386285429948, -1.68365311251327, -1.685231868708349, 0.12958028362284718, -2.6539187640054327, -1.0580078559296837, -0.45744438644492214, -0.15383726350550625, 1.6794211768615666, -0.08218272185627662, -0.5163241806711862, -1.6386382108035327, -0.9512785026446058, 0.47609257265469995, -1.8548634277007945, -0.4439237619649331, 0.6350272039920214, -0.23808093980263167, 1.1583989019756933, -2.9895157438064186, -1.3667765108572456, 1.2265722729126778, -0.3622328272693979, 1.6213646571211249, -0.7294167452358286, -0.8922235639243504, 1.5561504148840688, 0.03668225167547509, 1.497303020556015, -0.6998499079053967, -0.8036163864745445, 1.5397682187988293},
    {-2.0392659609199413, -2.592083763071962, -0.714197544299064, 1.7529484913036237, -3.800050939516681, -1.1503436891785783, 1.1848040916187947, -0.45691751359485333, 1.9248783160145233, -1.604939809888009, 1.502984283093771, -0.1514347907509211, -2.059159960498234, 1.706774487984985, -1.5020733101193806, 0.004119352966635732, 1.4200018737025155, 0.09227496945576714, 1.3740608050555305, -1.8043612981129302, -2.1175107929383423, 1.5215912812286099, 0.4123800803771538, 2.168811936036564, 0.4443140039707441, -0.9958236989121224, 1.4849177902870814, -1.5387882683220415, 1.4441164515082012, -1.412733611929265, -2.8842639141071045, 2.1948603059100087},
    {-1.0396587553379066, -1.1518955042314298, -1.6418909160273285, 1.0639204063890735, -2.658902281639768, 0.8965159726404265, -0.8045265080311775, 1.4319139336520044, 1.2404700623686709, -0.9373407969102467, 1.4351200611246904, -1.4972190751997128, 0.5231684025470439, 1.3329113861319835, -1.6315869207496727, -0.22870794662791022, 0.7934280988560365, 1.3610826640645326, 1.5864482647528422, -2.072121940663631, 0.045551402264481275, 1.099289699146403, 0.7014469724831915, 1.832112602115337, 0.21255285020373468, 0.16839605911062674, 1.4624227462429171, -1.6764238127907685, 2.2705303565532033, -0.9533691590958587, -1.0885819363283011, 1.0441881301850646},
    {0.6705492635617316, -0.4967594310127837, -0.44968347887816584, 0.7381383984698604, -0.9328345505291334, 1.2127128936654734, -0.3737217777617439, 0.5786825993306098, 0.22435230336188272, 0.3738819322868036, -0.8028059219614405, -1.0054234196715168, 0.5593582126854306, -0.14411899708031414, 1.17869386280762, 0.4700264382463775, -0.6842572622969086, 0.6927665969697866, 0.7179780930853762, -0.5359555519487799, -0.05869577835045271, -0.40021286602380257, -0.40276592016737905, -1.2877064519392374, -0.3099495783780243, 1.4898882148923036, -1.035727927006986, -0.002778634664795604, -0.38670507715903485, -0.2988968980170358, -1.1165593236358407, -0.5032488152999447},
    {0.8867618729291342, -0.13612426748178297, 1.0148970781050446, -0.9037619072385487, 1.0697573822192628, -0.17684639138943892, -0.06154935696416603, -0.5170126402514279, 0.39888984191177623, 1.9209822860676797, 0.4028582727947397, -1.2890910030234937, 0.5532059118988228, -0.5406693098763201, 0.33899735824370797, -0.044693554430268234, 0.2037409295140367, 0.23816767397436067, -0.6104025337374707, 1.3039707336950725, 0.8047796348524513, -0.4723082121634613, 0.5582596804744411, -0.303650025844884, 0.6632879291986971, -0.5366885676302372, -0.11436172949400326, 0.002330331500748125, 0.23417925984179686, 0.4828818117154541, 1.3235800521239056, -0.8267460480600167},
    {-0.5393013274937097, 0.6630806462061725, 1.0470864336025971, 0.38992026244986117, 1.0047286037628786, 0.09880759746846296, 0.11370020457399083, -1.0714455369393556, -0.015604513721838312, 0.532083145986804, 0.7770112957511072, 0.3278989823415333, -0.5628633902548161, -0.3922715606195645, 0.8087047239960216, -0.8356020962470778, 0.24558044596814269, 0.1699686065691607, -0.010073084471698366, -0.15259266634328533, 0.4626820176303633, -0.25181366988278636, -0.2925790063584243, -0.22833562695917864, -0.07073569084788052, -0.4070544829699247, 0.3935093163169561, 0.1857293900884634, -0.07553166544667739, 0.4070676142448304, 1.1936426826601918, -0.4517294172106563},
    {-0.6993542815096958, 0.09623657397631395, 0.8155245380964773, 0.49638910602386577, 0.14649536303974084, 0.5407276997218367, 0.26625551216807347, -0.5481739765763104, -0.5154563615354454, -0.2229360211727927, 0.537706609947745, 1.4007258846460862, -0.5136870518677444, -0.08218164245183868, 0.30550574921985346, -0.4054108577721462, 0.9283611657977621, -0.29681025589487375, 0.5371823284395405, -1.083975929717963, 0.4781617786244281, 0.5881791686691917, -0.27145762973466914, 0.6418141985760571, -0.17123018500441664, -0.7641834242474557, 0.4677195383412677, 0.2542000910759157, 0.5193192222937587, 0.8961536044413092, -0.3124386982453121, 0.5932669092072977},
    {-0.1414898280095568, 0.46224447157400195, -0.6384380047916217, -0.14973986864801825, -1.2703416968852963, -0.6453330137173517, 0.0938849241230178, -0.22379252304556166, -0.6379829733629838, -1.2093296488549845, -0.1286773045011983, 0.7241335628966581, 0.4414868631836885, -0.06311585216747904, 0.08165597929020653, -0.39476235032703844, -0.6812020202755861, 0.5475327066725804, 0.28033891884477274, -0.6547306074185482, 0.4048812645521922, -0.25952420816074157, -0.3593920775597975, 0.49472244758898487, -0.7685954012229083, -0.1587888297873539, -0.030148097557274975, -0.93035790293601, -0.5090518202217985, -0.5204493754479269, -0.9800230593165911, 0.33200006086927586},
    {0.16106002045668266, -0.844486524401332, -0.9642903578558564, 0.3709859313058123, -1.4866878237259542, -0.5165666436862711, -0.6003668762097594, 1.177467629209205, 0.21554588586475826, -0.039941195788445384, 0.09310129559029033, 0.14708087832423206, 1.1133558423637822, 0.5996720594293935, -1.0327128847859786, 0.43635113128617564, 0.3752237643020227, 0.8788740660912514, -0.10934301297324582, -0.5022174950301505, -0.928900148329382, -0.026047599097212108, 0.8435205645593193, 0.5183127285247124, -0.3833602968895789, 0.8846833647729365, 0.23564694556217763, 0.9220448618347888, -0.6198846973055346, -0.04980523898144877, -1.2205185184629055, 0.5164544566227756},
    {-0.6413777729359923, -0.823522951179838, -0.5745193303042947, 0.17497688266869688, 0.2324496063338882, -0.4068612633285047, -0.379984018367745, 0.3362750049637976, -0.4542397422395752, -0.3112840524271091, 0.5409537748374094, 1.7973198602434732, -0.2300596933341348, -0.36645773694439476, -1.5037095961318874, -0.7163328208881552, -0.30356010462106503, -0.2861265738837514, -0.7997139166745437, 0.3510140593558839, -1.5296073750482717, -0.3842551436434154, 0.3717916438720223, 0.4786860003125595, -0.8542052643900895, 0.44092279557000835, -0.510171802416704, 0.31600579181130817, -0.8037453982337017, -0.6431926758492568, -0.22147481220178644, 0.34012454840699363},
    {-0.86636996114353, -1.3455822726488478, -0.22444489014894073, -0.09151106871773569, 0.554653702380318, -0.3532218698707507, -0.6188888380733114, -0.30269744567811674, -0.8176568834188019, -0.7952820355185077, 0.15867037250086374, 0.9458401481069965, -0.963147890530502, -0.9169477776430031, -1.9794395779547271, -0.48282330294866377, -0.8140116791125347, -1.2140686872755484, -0.9387798287602237, -0.9733307915825583, -1.3543481682644558, -1.2024889494746005, -1.1062674194740196, -0.689285749105322, -0.8694474974782015, -0.567298906365521, -1.4031574165571927, -0.6000301081400665, -0.3453012989022107, -0.8221887875657456, 0.3432748632950963, -0.4400777337458222},
    {-1.0273994641547974, -1.070468453082646, -1.2404462434497345, 0.3039549685522681, 0.08721590496126012, -0.45103612622111694, 0.30111197295856407, 0.2574762650695601, 0.09591236971282843, -0.46402000226508916, -0.5097555989851429, -0.4851477398055384, -1.2414063739994572, -0.2753649606623869, -1.3545852819128215, -0.6284109720745169, 0.0533112747700136, -0.5277825347416181, -0.3152819649025698, -1.543772714458249, -1.421879598295772, 0.11664085392090831, -0.9106523737359529, 0.012032144755826684, 1.3861587271463074, -1.2545590669680957, -0.46724311528023327, 1.5110094935950107, -0.03719650029148715, -0.2818687328182685, 0.2689012393780695, 0.32723801294696836},
    {-0.6822547112911849, 0.2463233188644929, 0.7936163568320654, 0.2617865617452737, -0.18096545924639226, -1.0672173084108418, 0.16058860423241275, 0.3783581879141385, 0.253679835035723, -0.31430290621567614, -0.4939663483599417, -0.43499470206385865, -0.5770749744356797, 0.02732039521910135, 0.17291622210329585, 0.8324718005160776, 0.2784270828845978, -0.6534471611392945, 0.12518953665857457, 0.48213445543303096, -0.5993188409771069, 0.3061271873864942, 0.8700996111983487, -0.15671997085558825, 1.0497653117762287, -1.088649272016392, 0.21277564042676528, 1.6796902905842745, 0.0847351873646902, -0.22504388140287485, 0.5589195830200111, 0.6798680160443974},
    {0.22997580386602656, 1.932247206643474, -0.23595669967539606, -0.08750985224989644, 0.7784551100071807, -0.7159538918176871, -0.24474810748416298, 0.3140824181290493, -0.8484867968417489, -0.3119779118489544, 0.4440260362321477, 0.4420847606259623, -0.23166598568128327, 0.3708061849481307, 0.48507568475877005, 0.8909774249562059, -0.20006431524049056, -0.2992258020953758, -0.27629000365164696, 0.8104306370150252, -0.2294002507196257, -0.5094760572122943, 0.5204642688415583, -0.1459814981907077, 0.23769518932687897, -0.16711221092034892, -0.15231247125995248, -0.10468737624071475, -0.7054634131637599, 0.13645967911480414, 1.9141482564105567, -0.08932695652912498},
    {1.0178350531218883, 1.2279253443303428, -0.6572161909843693, -0.6335693719294031, 0.6050560435869388, -0.08357771562612407, -0.3578107230575417, -0.892826352307452, -0.26614353106579886, -0.10868459409964341, -0.3932623129657566, 1.3961142915077525, 0.9550301370905306, 0.757118936821752, 0.24040164756300947, -0.5879489084090075, 0.21894579432833675, 0.32558104167152985, -1.115472992841848, 1.445162129083479, 0.3905911306701583, -0.8555431115659419, 0.8308495433416817, -0.2042216996408823, 0.7415635642000706, 1.281805881693558, 0.3416180613952415, -0.35939199976343233, -0.7538129562797407, 0.8317261883163002, 0.6178294807561813, -0.3466217931105788},
    {0.3979826599960559, -1.0210699785701414, -0.024754983316110733, -0.5777702278456236, -0.8259646489657272, 0.41280926117094335, 0.6204668875461435, -0.45063477849960637, -0.22239451547159111, -0.38968024221749437, -1.0957932144746165, -0.9774928482130021, 0.6170912299611796, 0.315811624440709, -0.9941748028144731, -0.7986442487862426, -0.1988013692419328, -0.24859772572377312, -0.6796736127099522, 0.3888022460452889, 0.7686093669246354, 0.03745292653666929, 0.5813166068165904, 0.9664964962786302, 0.44574590174628365, 0.22184393966131807, 1.0444134621268661, 0.20915103033862698, 0.3765647556655356, 0.3921336782322952, -0.5306113808193857, 0.4549090136442651},
    {0.10062811247316257, 0.38678330838653796, 0.3992028954312811, -0.8906991658382066, -0.9191330158542571, 0.6268411818122601, 1.0385044224820095, 0.09865846411662231, -0.19488528833836177, 0.6899877242587912, -0.384212037605929, -1.5385376407648035, -0.5015598912737426, 0.028425468906217586, -1.0003808389087296, -0.945727360814055, -0.4110195399928788, -0.34657937457067756, 0.40311219571447804, -0.2465151981148638, 0.416728729582047, 0.36087193258175637, -0.5035956664199114, 1.6712635245414604, -1.6351397568525539, -0.762573257732646, 0.6414353467790628, -1.2749745453792758, 1.351854508401973, -0.4356457411502786, 0.45385344242440945, 0.619242653344096},
    {0.4413353866867587, -0.02928911665610118, -0.16518246916461526, 0.8213629189163231, 0.6298601364220388, 0.6212698338768501, 1.0481596529882675, 0.6367369897810866, 0.6739723287526007, 1.0302214129603215, 0.5893357876725286, -1.840791517140732, -0.01590985182262857, -0.06010360976357873, 0.89782614476856, 0.3183600656197412, -0.06338676043069867, -0.19454949591214732, 1.0069230489394565, -0.35587419287174066, 0.8023408628351758, 0.43741152000796546, -0.736865761518234, 0.7215262002594961, -0.1259872163786459, 0.7154354685944633, -0.6684703319385645, -1.1011194502493478, 0.9271006628830417, -0.09592660302740916, -0.49129346385294087, 0.24146766901586833},
    {0.23975312587699926, 1.156966556711783, 0.3016694466031856, 0.41549969612562937, 1.6416642239332908, 0.10213911323367719, 1.0126229172729047, 0.35629407880653263, 1.1546105122061499, 0.5832785502711803, 0.8986324716465747, 0.20902965612532054, 0.9910617754301743, 0.4773539532848766, 0.9633429060257335, 0.6005731244503196, 0.37766539598551013, -0.006212894898098302, 0.3509465087479625, 0.7924515979309597, 0.6316261920381996, 0.009012887093620308, -0.1198871512230341, -0.19079696381260938, 1.3481051109719335, 0.12122765604921884, 0.5709646170091726, 0.26575690361146553, 0.04351595013278563, 0.4601580960693171, -0.1599092154082225, 0.23127923030908296},
    {0.6073878352088827, 0.6286801609744045, 0.5671799471826253, -0.19397025054392875, 1.5137389339281473, 0.15229575269573245, -0.891288973695295, 0.8399013606391661, 0.925080272793702, 0.10965688153348886, -0.02306488105301295, 0.5576893954157358, 0.9660116398861796, 0.038987123298243824, 0.43360495228263235, 0.6968194985392785, -0.17923875981805487, 1.3095707860916677, -0.49947159719561235, 0.31363574321076376, -0.1257887479782135, -0.030101100301054572, -0.04641552380472859, -0.6856176971981406, 1.2490955588320696, 0.568418303285069, 0.5086404158923624, 1.486431000109701, -0.4316709513135559, 0.37124985958870044, -0.07666628882154469, 0.13194261475835106},
    {-0.8829086780163102, -0.40399670436820695, 0.4120205137950043, -1.101030955873412, -1.3852397135773105, -0.9976491331450019, 0.25269758972663464, 0.4054708908597276, -0.1707888224065295, -1.3134042182066918, 0.0814625195195964, 1.391505792607744, -0.07440007606257264, 0.3712730376213957, -0.5277242560213393, -0.1886851805541993, 0.6548316459144295, 0.03956760905604195, -0.040345408753802194, -0.8476697226338017, -0.7372730678746426, -0.04495390953033481, -0.3057042649397175, 0.34087167298899274, -0.8439676087632992, -1.337717000270494, 0.7637564674012399, 0.3514446280313139, 0.5720081171243563, -0.2607854047816903, -0.7135040874066862, -0.2968409516408345},
    {-0.016144580369588078, -0.4742137095123108, -0.5222464365939259, -0.31577176615972036, -0.6318632498815873, 0.43352530850223525, 1.2469536709625746, 0.31746839760102724, 0.091378756382522, 0.20629953128260184, 0.46995241694666146, 0.26811863821851967, -0.26094919320745735, -0.24762616957664693, 0.00947146698736136, -0.5853375384280911, 0.42866185833687576, -0.1539073561035123, 0.23099749388555574, -0.5504664880950998, 0.10227348040182663, -0.28978912563123715, -0.3793324287968655, 0.27001341352985475, -0.6496657806687021, -0.621340322986006, -0.006749561398642099, 0.673281312224304, 0.8733929974345469, 0.2658993286767037, 0.14426327669216643, -0.07170136896694054},
    {-1.039697293130055, -0.07803126658099406, -1.034771772503238, 0.4990537196191203, -0.6826616936279074, -0.20346389765278067, 0.5042345499211348, -0.6212479907940719, -0.24926501491260558, -0.8912919771283266, 0.3468417671956262, -1.1403629953106174, -1.1982438485149443, -0.991632911092959, 0.46724582107506285, -0.8446480807846325, -0.38550055078633555, -0.3739082105981616, -0.027111804199712132, 0.13508391983626372, -0.799214983520615, -0.11067039883016268, -0.070807056084339, -0.6718746478608777, -0.8446418615282938, 0.06340510923705413, -0.5643987282431001, 0.3867151552038089, 0.22181451435269206, -0.8039130353883197, -1.4173417685174967, -0.305241811002141},
    {0.03783417158123135, 0.7719957965906898, -0.8195532322666302, -0.22271409505072634, 0.5037050311020654, -0.15475478911737817, -0.047076659320206514, -1.5299474946065736, -1.2654463900496407, -0.011887653743217078, -0.3997345145450585, -0.4419863996648837, 0.031648176249345676, -1.2663866292662975, 0.6123053710728211, -0.6360430412698479, -0.9163366758743268, -0.6686604423304827, -0.28633398481290306, 0.6230620863162379, 0.6026617717193079, -0.2446136474343207, -1.1068659715602605, -1.3049364969278492, 0.681334641491166, -0.18549321315510223, -0.9382490587946638, -1.0927736688687841, -0.5996491372499785, -0.4889420329732723, 0.632758070242333, 0.31719839182289644},
    {0.7996870443126044, -0.06232348036288168, -0.14973211700338585, -0.4979742273061082, 0.32645292600571507, 0.47384815245486367, -0.4034507543466624, -1.3696011415670106, -0.5588849656112521, 0.5134335323415582, -1.153543699602494, -0.03770462132176251, 0.15985991895713084, -0.40719105848795073, 0.8704265056812008, 0.6451699545594131, 0.18671017490302033, -0.31055926541823614, 0.353042912065453, 0.6040324395539495, 0.829977174346689, 0.2492722448957853, -0.6536861701742931, -0.788189998439747, -0.6231189638338455, 0.9539223402372008, -0.3662406041835235, -1.2820198598933317, -0.3450272509737745, 0.40274109343688524, -0.1714593048050498, -0.05907250323375252},
    {-0.4708721953945873, 0.7707286420860755, -0.6666835052355953, -0.12462810413567219, -0.8943235521796098, 0.4459458570931897, -1.2462646094442507, 0.013129321197243178, 0.12982936291813182, 0.6108221020721449, -0.7703274509391375, 1.3189656775572915, 0.2503757855899423, 0.44263859589456483, 0.2084485853053221, 0.3460459625653026, 0.32484690846399844, 0.4602011802961924, 0.5680055895516832, -0.645652771642047, -0.14627809503656128, 0.1264574984192564, 0.11132597761761215, 0.9051605649175009, 0.825050761224973, 0.5586914432708985, -0.15582703117187005, 0.7674329512964237, -0.0977007004312738, -0.01188923319087211, 0.21874872399642348, -0.3177103312536188},
    {-0.7366660326553025, 0.17757684901777157, -0.6701297962991157, -0.4312534945516101, -0.5499751782996866, 0.15855494878652407, -0.16145293816269057, 0.45470542916457796, -0.3148818079087064, -1.2150908267027412, 0.7641733739582744, 0.5979090810984632, -0.3947933248679668, -0.4138222496553185, 0.4559168161795315, 0.29713714115321077, -0.09266361237150904, 0.5597154674424522, -0.08288712184975237, -0.6715793718707987, 0.40264436845201346, -0.36830724420885735, -0.3736572318305483, 0.7701840421012862, 0.04937552131799607, -0.5048691776301938, -0.3279231444517423, -1.686988902019194, 0.17144011803044798, -0.7498313917394882, -0.04670906844277404, -0.08885300546194033},
    {-0.244699502857325, -0.2470449601963242, -0.7449660535775163, -0.9067903149484812, -0.5030602422420908, -0.3722415467947892, -0.08922222356055, 0.20457719403835678, 0.010678428382715812, -0.5333197470514079, -0.019329329031709124, 0.7466351905746824, -0.8265300266477125, -0.3224115885078682, -0.8603419277188284, 0.49650267553570393, -0.1653825428968625, -0.5993372043128491, 0.12912336158670676, -0.2708859218515785, -0.5532278479597957, -0.6067550148956018, -0.5936999846814466, 0.6155164986203909, -1.1420427881944368, -0.6214796742083004, 0.2881135864856117, -0.9476321758943166, 0.18937109234510616, -0.1601140128430778, -0.20099446956555603, -0.7156902135180686},
    {-0.7403091397186793, 0.8235859490724564, -0.872474773117388, -1.2050523446596764, 0.3160748621338235, -1.1821699008883946, -0.21688964946993908, -0.5883056686989826, -0.8507239148244039, -1.076420987086271, -0.7837972848535459, -1.0116067794588035, -0.24433215917792858, -0.05335974580493573, -0.7914369636114275, -1.0004143387778115, 0.3208852273860399, -0.07758128990036475, -0.5327056709117638, -0.13588676140985248, -0.754369554658817, 0.2743194085504462, -0.12316024810171602, -0.12842497524433077, 0.6667059506341649, -0.27170144774774935, -0.809790818989681, -0.10560726285487626, -0.6377417697615599, -0.28488458260289407, 0.6693498602315958, 0.09359373676605906},
    {-0.3371481304473591, -0.6334833214714213, -0.4917865534638063, -0.8344954905236854, 0.24473342710361268, -0.8193110917242539, 0.8925289373799791, -0.8888317516900257, -0.8865044530618147, -0.42757277054527587, 0.11732531435173575, -1.1761598392682424, -0.8781963514714951, -0.788292050211106, 0.3562264150885506, -0.7867116151850083, 0.29592336961392224, -0.8926016128636126, -0.7938661035789449, -0.4061730676758717, -1.4157882206109116, 0.6728333766557126, -0.9253554036942289, -0.6471921394596777, -0.983738175701804, -0.6156208357890509, -0.6165328884160582, 0.8371330250750239, -0.15233583222941688, -0.762770871680379, -1.5132686458486226, 0.292529788317681},
    {-0.3038802082681347, -0.35398543634856583, 0.6251147505836293, -0.3719850976647832, -1.1797875512905458, -0.8244876102462098, 0.7117435646697885, -0.6503090615346975, 0.8633393302713185, 0.4557398845182954, -0.09404249265415647, 0.09533936781778966, -0.7103575317428433, 0.5682172054530761, -0.8629789999203694, 0.09418251871208493, -0.08814404964606148, -0.044130930127811996, -0.7122251311292644, -0.7213540431082884, -0.8076781567786212, 0.06378126843690662, 0.23967172126092864, 0.7745121502821992, -0.5327269209847643, -0.5169681189738224, 0.23123763555688656, 0.1013993154883897, 1.238517424015703, -0.24538671440172757, 0.6381738508031013, 0.5800570404486797},
    {-0.2270215476901941, -0.8473219933380205, 0.23973110537968828, -0.3189107853310461, -0.7587471530917667, -1.5456157901419447, -0.9368344407056655, -0.6795476883287752, -0.7929235877373578, -1.4233541827256533, -0.5288479125738456, -0.6856898971560905, -0.5606479181402926, -0.7490220737987034, -0.3264569449632489, -0.5436894584047137, -0.7074983449657759, -0.4686233431472784, -1.143707084849171, 0.16503130586222522, -0.9562995830401563, -0.8417185308220761, -0.004133398794699361, -0.9498387570797403, 0.9105133310112022, -0.8122176288514459, -0.5767755521804686, -0.6161742895521521, -0.4877321702062662, -0.20716092710793588, 0.03733899529435357, -0.02452454027820835},
    {0.1675465427174427, -0.5404204029741898, -1.0953489754044923, 0.3671022775671172, 1.0636175560794563, 0.6232484177558583, 1.007333847861953, -0.23525662691787855, -0.636567217807105, -0.3604889102869194, -0.7234135401959109, -0.3919933040555071, -0.1819700473907779, -1.0256125212868556, -0.6306061642987381, -1.0413482767905284, -0.3564871764348356, -0.46070558085242347, -0.12857948809555314, -1.2657982569337167, -0.46884557256041887, -0.7539726622958762, -0.7585578016304881, 0.2693965425746382, -0.038570969855770514, -0.37949566176567967, -0.03040278033021671, 0.07688287272737812, -0.7028484778777012, -0.4078582346429794, -0.7746182121379733, -0.11853033330287689},
    {-6.517393905540656, -0.7499997959868892, -4.289183121518322, -5.040125281299278, -0.9540821237209841, -5.9117720658131745, 1.554244103613146, -4.85066084157138, -3.5803194672627874, -5.274452780673092, 2.2000714636008327, 0.775675159192806, -6.060893343375529, -2.0543483900035073, -5.845448945679632, -5.176222511838069, 2.113500637659602, -5.040250048166463, -1.9997075710891283, 0.6243510319895945, -3.6841410445675313, 2.0308482978110742, -4.074717289688347, 2.399895216834322, -6.72870321177561, -5.301521737063386, 2.3236071040583632, 0.41070972441555564, 1.816672016462336, -5.686510918050703, -3.1134241048495364, 1.6277593300439435},
    {-5.924821558044651, -3.346748553959968, -5.146335807455937, -3.910861990863494, -4.442505059446296, -5.936307986566288, 0.276144989172069, -4.332812659991831, -3.233514701681292, -5.73060392848413, 1.6477003566722055, -2.349481849031311, -5.747939447192078, -1.9465242470987252, -5.984889899898243, -4.7703653944985565, 0.7223427320938554, -5.132826042537529, -1.3974180628077904, -1.8428983963007581, -3.994338796973887, 1.2835784563320471, -3.992303242446005, 2.0307230319752643, -6.3436498625162665, -4.140547507996835, 1.6462693510113475, -2.041056945088246, 1.366833689637334, -5.38338286555761, -3.5746660054303216, 1.1982759920083201},
    {-2.938961989086139, 1.7293589264063547, -3.0844742328832457, -3.577652324557567, 1.6202687820432549, -2.6705561803431235, 1.4442125237916932, -2.9442282762533267, -3.207886204587906, -3.6279534352964946, 1.5334134372254322, 1.5881593245971481, -2.99466463111701, -2.5363742552393016, -1.2539206943092482, -4.106877592570214, 0.9838764746909717, -3.558792013237015, -1.3736261233142528, 2.128304121754408, -0.8245185596578022, 0.8473127549191966, -1.9163540953903828, 1.7857195121291625, -3.415193689523397, -2.822764828857643, 1.1870543096449593, 1.2654791999394972, 1.4921649217068662, -3.657070279301489, -1.7081352383375903, 0.4445792858023964},
    {-1.5491740034568346, 2.1247944233172857, -2.2029359285676513, -1.765441640151844, 1.5081699509086397, -2.4119537594815514, 2.2208179867145263, -2.3603426149927382, -2.3790067261467005, -2.2484318756849935, 1.4442125392884195, 2.013208704764872, -2.423168883394733, -1.978806927485462, -0.8072484735210813, -2.708882649377719, 0.8456517970626565, -2.880022110872909, -0.9366532335867673, 1.6212888957383969, -1.1626995691955606, 1.0847452073919677, -1.5969899589349552, 2.1068173758571755, -1.0706223078329313, -1.9206971354331153, 1.1728055583394112, 1.681132300898337, 1.89900916930186, -2.44800529657086, -1.345550912997043, 1.1188643510201604},
    {-1.829343310769228, 1.6640856169657028, -2.6546430664285454, -1.6415290373144653, 0.5606421364242661, -2.3621817548430117, 0.3062253467057716, -1.2301904881881114, -2.1846003728851606, -0.6989794605662892, 0.24716926135569384, -0.7845953139510548, -1.7388733262770668, -1.9699622657786844, -1.1696549689166147, -2.3354173948838466, 0.09149492558620058, -2.549285795882232, -1.4811044048195576, 1.237214679681998, -1.1792752094976564, 0.7848349218786385, -1.804523894305112, 1.541592551242976, -1.8069147141151864, -1.4781118180336044, 1.3299997415653895, 2.3591468186007254, 1.2369558195630423, -1.7291021136851348, -0.4551226598103283, 0.6659463917641594},
    {-2.854080842855008, -0.23933253372193372, -3.2182961462874826, -1.8836031845473922, -1.8930387156483273, -3.650657795935082, 1.1973825392687667, -2.166695126460932, -1.1968716376362885, -3.895845015729341, 2.2372152263239977, 0.5829735484064434, -3.4919309943058945, -1.4089209074683555, -1.713757875238288, -2.57831802057428, 0.9270864314150197, -2.2224591651398655, 0.17600960447953629, 1.1757402093339397, -2.2858723365104643, 1.3367194299852296, -0.8880140757809488, 2.7228368101569513, -1.8044338707708878, -2.230528977774482, 1.4123051546077316, 0.5215092462379524, 1.1792431252384756, -2.5319236014933675, -1.5556279506180914, 1.2099587769352596},
    {-2.3404063858148625, 0.15889629218588316, -1.3566843034412166, -0.881107522341445, -0.5268861879152248, -1.180819853638266, 2.20750217783653, 0.5644421314129328, -0.5766896697192085, -1.740125568866555, 1.2519288648184905, 0.13652817153630226, -0.7928220483315054, 0.05759265559505523, -1.9642227882880954, -1.2038948153549787, 0.5374118846508179, -1.5297976041037384, 0.14250085501232582, -0.19582895265863237, -1.3757990160946105, 1.6978887830653802, -0.3650947247725796, 2.873553141158569, -1.951524990106189, -2.0107266003362603, 1.3812578129954016, 1.1077881124008904, 2.422985683064476, -2.2177546005444544, -0.55118920732751, 1.3749683464610447},
    {-2.2485761146372605, -2.545244386833162, -2.936349892180921, 0.43926305421235917, -1.1342766146279974, -1.3891341382806595, 2.1507164985981784, 0.4588091206704821, 1.196316891086125, -2.3765941550427203, 1.5266408020045656, -0.47340116217259115, -1.248915626617019, 1.0220436194934934, -1.347757995464363, -0.6892088496600403, 0.9750205520921101, 0.031093655187289366, 1.310560604668619, -1.3113869529285458, -1.700727240322129, 2.011402575175779, -0.6608640710174594, 2.9859203678920423, -0.9605095736766625, -1.9122293783906505, 1.5744803468143365, -0.06664618283494389, 1.9591878380064476, -2.6173835336457145, -1.3672994296875025, 2.3981210287345447},
    {-2.9142935504160112, -3.219892764790135, -3.4738390673047026, -0.7018852856362373, -2.7419032886597563, -2.337358830800479, 1.5283434174368271, -1.2955266166646209, 0.13820581337932542, -3.8509950656038936, 2.563796120941901, -2.5148838463374728, -2.673416411544267, 1.1534593665184398, -2.7726110965098707, -2.0546502023232565, 1.2188553570349192, -0.24710534619501737, 0.331611127103298, -0.5039919634750057, -0.3153800502794273, 1.4802761438582783, 0.21174807501917076, 2.1792229971436052, -3.28684639487085, -2.231583561090229, 1.742223834196407, -1.403888005974752, 1.4538639188180598, -2.6604264191898555, -1.3686270165321044, 0.8057300165576766},
    {-0.5444717594555901, 0.8072507174428354, -2.3075490963535294, -0.17827022710244778, -1.65974126921759, -2.4366643219759547, 1.082063413767656, -1.5878759431138774, -1.0886976036739806, -2.549036544787994, 0.09348878971972657, -2.5772939442894547, -1.1599644090786165, 0.11961342022541548, -0.6941187788141321, -1.4957786505192052, -0.33903646825731293, -0.6982800487805947, -0.2798671942145396, -0.18732338745805535, 0.006113832918590417, -0.14528738708817684, -1.0163411722742075, 0.21500311112069703, -1.1805645251265324, 0.9517972204905901, -1.1563395845924882, -2.1063629675307363, -0.5589872321849049, -1.2672761601122287, 0.5388901676476566, 0.1595508636907558},
    {-0.6331088524205366, -0.3813757763936844, -1.3759332389727061, -1.3474235421790128, -1.5548731910390803, -1.9411620413779629, 0.8225462176285054, -2.4025218445737697, -1.3589022839746079, -1.2157051109426484, -1.0220576379653241, -3.445481455357478, -2.456961280323375, -0.5203528213452994, -1.9107805262365078, -1.367674739618624, -0.9169590545143359, -1.1539278352516895, -0.7941948386652924, -0.46002386721947003, -1.4647032413121805, -0.5166449940714907, -1.055357267877824, -1.146906441216786, -0.9880743570187521, -1.1127127835625692, -1.412769100740023, -1.1879553462080354, -0.6850446988776386, -2.6745973195439947, -1.836621340081592, 0.04472216208793387},
    {-0.3092783415815121, 1.368425711465672, 0.2836891666104065, -0.8306168657158369, -0.5081586413924254, -0.7687337008430659, 1.2202881001201356, -0.9969263976633349, -0.8307129768672153, -1.0638173278243566, -0.16800473944992225, -1.844462582898926, -0.25846739042482464, -0.2575916587808057, 0.5771976248104445, -1.219711987998842, -0.09029302752961284, 0.005049851211445328, -1.1353575088892762, 1.4383429275280017, 1.043522097993858, -0.09410973944984619, 0.2264965803096457, 0.8280908501975281, -0.05071582941903057, -0.18973967983899026, 0.10881559493827192, 0.025889458824374344, 0.4146314891922665, -0.9635743292703234, -1.9052058445482563, -0.7571462881075657},
    {-1.3963806258632427, -1.2538964471200962, -1.5168582066431848, 1.3549648070872204, -1.2697500330139913, -0.5749453289338028, 1.591954254271713, 0.4234452921198261, 0.7265293048979424, -0.8525995635876839, 0.9864438867204246, 0.8564053149696018, -0.38638881225700333, 1.1655288382670375, -0.337504210350124, -0.40533117875072777, 1.0067955845896122, 1.4070049275980492, 1.4468338949719637, -0.6613878765618167, -1.064341736524916, 1.7326154887230194, -0.8126218246390581, 2.44133854218546, 0.4727101971637026, -1.2701095272691976, 1.1328977836462086, -0.2249948108390388, 1.6856197087758114, -1.3147829340597306, -1.3222391052347826, 2.0314509479929},
    {-0.5134992200884181, -1.3593753749370188, -0.002649997106211729, -1.638904925780113, -1.0234698429760305, -0.6917621431172737, -0.6726982616871909, -0.2695246770160631, -0.3763209375288016, 0.0006427685478189376, -0.6780389504243806, 0.8013167573753674, -0.059840210599074566, -0.1158969885886542, -1.4092212015519985, -1.1102967034490743, -0.0186287206616636, -0.8590922923547069, -1.4799039686852786, 0.09804301293197178, -0.7618365427382473, -0.4312641275006576, -1.014911829331568, 1.0738455853941424, -0.5439117820221299, -1.1843520550624307, 0.4958516307139646, -0.589099786949888, 0.876950428724306, -0.22002102841129248, -1.6663066535479507, 0.22060884427395544},
    {-0.4716421717452556, -0.7867710159010891, -0.5466713685075766, 0.1036245305260919, -1.0405692281071928, -0.9986597474763791, -1.1181800371715096, -0.1269336031491184, 0.37146340349234713, -0.21810859332929325, 0.3649544254067543, -0.2514820898972118, -0.8625726327499017, -0.8214486293212087, -0.21941085548976766, 0.39498529105447755, -1.0447175644773403, 0.3793249736602507, 0.6913517867626565, 0.37172701868752267, -0.6610119259522412, -0.758655418416868, -0.3712964853971714, -0.6608204318062835, -0.3330227433918428, -0.6098515059824643, -0.08722219133784054, -0.37576166968268176, -0.8185753401583459, -0.26072901559901607, -1.8876733713310598, -1.2397355756340394},
    {-2.4136882570991234, -2.257526993630343, -1.9445433174811464, 0.44074721560354513, -1.8726009798075474, -0.746883556128687, -0.2556742576307837, 0.12338127318792473, -0.2899652843281421, -2.684240756256301, 1.178957492490305, 0.5558527187841946, -0.9112606252629551, 0.9495316204798465, -1.3405058228350502, -0.23775861250759384, 0.3764896555481059, 1.1070970153450108, 0.12811692838014793, 0.6318568907218299, -0.48045897461001236, 1.8447131032909752, 0.7581111636404946, 2.002065239672094, -0.7867976088380061, -0.27849707538085683, 1.1386588421156005, -0.6400842708877739, 0.7412342954598077, -1.592594944207404, -2.118802493108707, 1.3460578208355587},
    {-0.779454579496809, -1.9590286973578, -0.06229988326143953, -0.7810402331264926, -1.7581660914930584, -1.2834344154806714, -2.3330499477598474, -1.5473913331447118, -1.1225089741331626, -0.26575063588661235, -0.9498673237545113, -1.5812350375642157, -0.7237264417915077, -0.4350922959111449, -2.1925342875780367, -0.7628814209466035, -0.8145306320371891, -0.27802642005032907, -1.0268261987054885, -0.09311402226760647, -1.7663192829230039, -0.2557554969411882, 0.8454398838615897, -0.25896022858011397, -0.7256939243575511, -0.8722017168909648, 0.14726092911586305, -2.3474962074399053, 0.26435780050047264, -1.3385703339899773, -1.3555504506841964, 0.041907432529572915},
    {0.29353627010122746, -0.15673447203863033, -0.31929387889823907, -1.010264237569585, -0.42452103808773883, -1.799209778536028, -0.3642605566119165, -1.212709799165585, -0.9638880746408168, -1.031090891005694, -2.022811282420103, -2.6146923454767603, -0.7375810893458762, -1.576636820957153, -1.2199102994076356, -0.6550155275130787, -0.6924196523826521, -1.321007862251964, -0.8409923318111043, -0.2972596939027455, 0.10571724226933556, -0.5966707639678847, 0.39546703024884833, -1.183067256495515, 1.7612755561679094, -0.6795616668227358, -0.22467177418646267, -0.2856154561648474, -1.1549789818600327, -0.9326787654007463, -2.114111469988834, -0.15931314057938611},
    {0.09228807939137253, 0.9532762025781933, -1.4717985122752937, 0.2111658856533941, -0.8098017341896832, -0.2317515542699936, 1.2924047054919818, -0.6420221227889115, -0.8196137614299294, -1.3078025188659845, 1.3061850637396373, -0.9962690546403132, -1.502775002174911, -0.30683946615110796, -0.2438425820100674, -0.2235144663947214, -0.4099507577772686, -0.45442073048627296, 0.05555696692885826, 0.9975773361418478, -0.36067423008743277, -0.9524558312133987, 1.0849702635366016, -0.4380466316240446, 0.2621357494689898, -0.092373214933312, -0.43096176030163524, -0.350081499370186, -0.8343068270381587, 0.0042281453117643635, -1.174954844412599, 0.05459437625626302},
    {0.6947968356621766, -0.09574727020670971, -1.3677336572214658, -0.6964633553387657, -1.1101835841261405, -1.1653423695056075, -1.0264893683975844, -0.5249323307540086, -1.6696162441043862, -1.072374570566877, -2.422514083332456, -2.602355630088356, -0.8755680330579292, -1.551886963114219, -0.39650195713437986, -0.22143978342839568, -1.4594525392724222, -1.7113897088062442, -1.2233475050978504, 0.4800000359837216, -0.5625863194709531, -1.2941163193626901, -1.5670107467690164, -0.8523435525247677, 0.7989155522099829, -0.003543350963089302, -0.9769171364222232, -3.064852275804907, -2.6032092979733, -0.45204063113483167, 0.1453100316952843, -1.2315848176309792},
    {0.8237284078852201, 0.1971669947585856, 0.23068082155545677, 0.15493992245231875, 0.7368015756253111, -1.0740598465355315, 0.19067281785957982, -0.39134035093800684, -0.4409959169382867, -0.20131361385326185, -1.447025046088936, -1.9770126663380823, -0.8380606897160552, -0.873101407654862, 0.9753272816794035, -0.6320344193398315, -0.6613568439236265, -0.15739490121210103, -1.713222670332773, 1.202392961525612, -0.14083076972216785, -1.4417999741707996, -0.08057721715428384, -0.8919198012673338, 2.0592036964972484, 1.0477824654896508, -0.4909654047038295, -0.7155369394386726, -0.21978731263672613, -0.004420332997946767, -0.8411051515940288, -1.9319671457602594},
    {1.4185980639826956, 2.0506603805044503, -0.3781267864725085, 0.38237805526776897, -1.139915394254719, 0.702393831122616, 0.4253774729408187, -0.1994902170646055, -0.32649881643235523, -1.1335559344884063, 1.1507361144673252, -2.179677867829109, -0.5849353612545267, -0.5276647963115062, -0.9187217178737216, -0.7335648418530318, -0.12948742415642, -0.6585322693249588, 1.0498267698654282, 0.7299956957088168, 0.6168422132215944, -1.157316811561239, 0.8447231434094391, 0.1094997899751648, 0.10996530645314916, 0.8382120335169508, -0.28648040628088417, -1.9518434512685947, -0.30201382704203833, -0.25473784513683057, -0.0998298418993623, -0.9121585712217772},
    {-0.46163367741212585, 0.41759733077241684, 0.13977080229709404, -0.62411092216215, -0.18415056629082563, -0.6561573376733866, 0.5869899229681459, -1.1546969881216502, 0.35132297520503547, -1.8657754622983476, 0.8247676457192019, -1.7135601660647863, -1.229410347597188, 0.49506866887464857, -1.305360826618573, -1.4540809359863087, 0.20978069160677537, -1.6643110588682535, -0.6328053422243586, 0.5014103379161955, -1.0129692936602572, -0.8908652412379465, 0.9174455201513696, -0.07441176602897151, -0.7805026265320223, -1.592357055959606, 0.8226435891361134, 0.193587315823894, -0.0008891259743978376, -0.29484319667499165, -1.392457564604762, -0.78662402479489},
    {-0.08217715562418991, -0.6877071811284109, -1.0705076475914286, -0.343442834096179, -1.8679031068990228, -1.26519953509007, -0.12475043584704935, 0.3134881694875024, -0.08594996299759547, -0.044561940573946364, -0.47078296246777285, -2.1045594905910123, -0.35863043243658804, 0.0912326736311372, -1.778577406940108, -0.5085829079302059, -0.6103449947449892, 0.8434449333622869, -0.7599008957828854, -1.508881893385589, -1.3352499020326978, -0.9477255466996303, 0.6256868356761409, -0.5651448435607013, 0.8204802022716129, -1.0356232938694343, 0.023233250092402447, 0.9624052074849194, -0.594417695302144, -0.4564457408202979, 0.0913193878393071, -0.13405422977672599},
    {-1.9648842004136935, -2.2072052334030703, -0.8587973346544013, -1.5435468049848458, -1.8736592878668206, -2.111858831661911, -0.506004882882471, -1.0609848585044694, -0.2089027338135402, -2.5321073723187375, -0.5090813041278003, -0.9451420886578649, -1.5532800772071025, -0.45056178139779274, -2.541253162857691, -0.524813940557741, -0.051597732331555256, -0.30344659776956334, 0.04631420674513958, -0.8914677463716962, -2.039758074800469, 0.2815495101475223, -0.6953199571083439, 0.17866733376567526, -1.9335188949345405, -2.480409479751753, 0.06957543513261093, -3.2466657714381215, -0.06218073068293178, -1.7711991373016613, -1.7028650134474463, -0.15835764328688626},
    {-0.45171725665566964, -1.3370737912987556, 0.522082671183817, 0.7229564433522289, -0.27331055403115817, -0.6356404373283157, -2.0437054113297957, 0.8370913229774087, -0.5853860433198012, 0.36434572368761525, 0.4900229563654764, 1.4628378287701012, -0.37971686606863797, 0.7397753451794132, -1.058968930439595, -0.17930106349252514, 0.0025905832500266574, 0.4794791777440831, 0.8134249054716374, 0.1770116617695631, -1.3198504730877996, -0.3135910171915218, -0.4287128042553125, 0.2260929653711839, -0.670526618201252, -0.7468291391183733, -0.013137072122521984, -0.0583606109471682, -0.28149183492172597, 0.1634558668843242, -0.9615281669336271, -0.7196781365638171},
    {-2.5216575281667337, -0.2032091100550244, -0.2843961179581291, 0.38215671632662684, -0.5152973886996118, -2.3703653313500865, -0.1080207637116764, -0.8905563599678386, -0.33287078736866166, -3.0108096335357035, 1.0939003034492623, -0.5818070351016922, -2.552018218658219, -0.027288075714854376, -2.2573663776498205, -2.4168402585385556, -0.1584134929165747, -1.3109467231664709, 0.5929277541547368, -0.5984850076513992, -1.6197727623031013, -0.502591966054272, -1.3782563011923266, 1.1549311866629546, -0.5474842108173893, -1.8868015857011007, -0.08419485129446537, -2.7450301983063454, 1.350922120550748, -2.7868419925474517, -1.198392168764294, -0.21703367071182506},
    {-0.3421223469324173, -0.4877377832604861, -1.5496228536182177, -0.5467748840012974, -1.6943601103774752, -1.2682838784132393, -1.7510250059553125, -0.8380060760104434, 0.038631974157380296, 0.0880803764500495, -1.4810986454418855, -1.6727808501070383, -0.4095092456729436, -0.956498284596965, -0.846867851151892, -1.306664969631361, -1.1357927495587197, -0.9345937111882212, -0.4976494384403937, -1.4143413644409166, -1.4496761582608655, -0.4197615269739277, -0.8365342210644714, 0.44161295448001214, 0.07671449688420957, -0.3585069925549113, -0.3169611376710575, -0.5228442826432105, 0.534910518568451, -0.3309738496904308, -0.2711044742945136, 0.05512441533831512},
    {-1.3794671465615502, -2.234244328488578, -0.28036365375286737, 0.6240876082455612, -3.2249250359221873, -1.4563426393594785, 0.8079552215374822, -1.3436681224541709, 1.362935712995743, -1.4279031471034067, 0.24423592076641687, -0.6869616839191232, -2.3558095685349, 0.8170122155592155, -0.7229043456074266, -0.4834502205859505, 0.7103419243336607, -0.901698654657713, 0.6051429487161669, -1.1636615625259827, -1.5707408128901907, 1.2888622500907807, 0.4332416285651172, 0.7581941710759353, 0.20270706891008722, -0.8684408547006577, 0.7215757734999513, -1.8715575453484783, 1.0830108446006403, -1.4275001648734988, -3.0326370399154237, 1.5426371724274333},
    {-0.6935838653777842, -0.9467617399173806, -0.8916067824605567, 0.12219959740509094, -1.4976992607541373, 0.24953247207510085, -0.7482434675474466, 0.19799597827597573, -0.11481368088543063, -1.00451834503142, 0.2867742326233285, -1.6432739502862075, -0.22794783294602422, -0.020134522403466217, -1.0356331817712876, -0.9585294866674373, -0.2825180895060142, 0.4775486459176684, 0.27224103998310745, -1.592960474977882, 0.16116833908721817, 0.1394407377196239, 0.48444631959834894, 1.0160785213700865, -0.4174802602131763, -0.06114113908125662, 0.39593464511966203, -1.6982334835554374, 1.1765844818806237, -0.5028424511234706, -0.8918470018530478, -0.22100469390726227}
};

static const float b1[32] = {8.205119413697819, 8.354385851644663, 8.148655661813955, 8.269630751320609, 8.08215805455237, 8.22778602194284, 8.21097516349731, 8.14513241760733, 8.119098101980464, 8.218166578274012, 8.200829793962438, 8.341000705770444, 8.172265462215096, 8.15089778881565, 8.094540642678016, 8.21493964452604, 8.101253371130296, 8.288869719436176, 8.139682858686635, 7.987960495764276, 8.193530713767842, 8.186414476027897, 8.266825481370855, 8.345030493022234, 8.33708064700936, 8.154384398016251, 8.027090610621036, 8.313650444877169, 8.358394332139138, 8.197941634863618, 8.126200463076241, 8.202285496728736};

static const float w2[32][16] = {
    {7.090667052938242, 6.787780955286582, 6.790562594726602, 6.856199504047562, 7.4127926875825345, 5.660692307693238, 6.726323725192288, 7.224880046355242, 6.587118524772616, 7.421924870488347, 6.917530919271163, 6.806007750736614, 7.139900321442438, 6.833438891612815, 7.109038871908212, 7.000765186361989},
    {7.374091318992315, 6.798100630310552, 7.232715513658244, 7.199326925104949, 7.206437440041465, 5.637903249069377, 6.8268764562761906, 7.201421394636563, 7.491878765113457, 7.321136216945465, 6.972399739216891, 6.444121254418604, 7.127356641266788, 7.482377857371123, 7.275933742942743, 7.517775086587949},
    {7.060260615782853, 7.003351047056495, 7.272271819802674, 7.161615647996355, 7.262525675045154, 5.7075189791426695, 6.939677290681193, 7.083115672838008, 6.934119291816231, 7.501094662271352, 7.232075992891482, 6.32794597502421, 7.6042587327734354, 7.574247869139307, 7.199943254264546, 7.2865055242099706},
    {7.220736424621939, 7.2815694662177215, 7.155828065247056, 7.733111477139443, 7.869651625994483, 5.711556346831966, 7.191656342495951, 7.48494622893738, 7.4710848098557445, 7.836576446461746, 7.12519680598839, 7.189565611460586, 7.650452510230965, 7.306711008656581, 7.524128108542222, 7.4113676897342975},
    {7.018427148988663, 6.854615367777914, 7.128494067558588, 7.157970383665083, 6.925985853607959, 5.27161372586362, 7.3487381576124875, 6.919426600751734, 7.181048281267785, 6.921481872996768, 7.2336065123809155, 6.507107278801339, 7.010193230704429, 7.387081882978365, 7.252688495320149, 7.262474509076644},
    {6.864822618951805, 7.092088157770902, 7.228950923292928, 7.537112382769096, 7.183240710165856, 5.5026656726909335, 7.065675724224175, 7.481387878984594, 7.533891382544891, 7.75852212379681, 7.096334742791696, 6.691542003807969, 7.30440586200606, 7.477130394467348, 7.377298836639614, 7.449680875161172},
    {7.018062281969137, 7.601300825183602, 7.228767509592003, 7.724421682573932, 7.153190477178916, 5.824990882014086, 7.607083347343913, 7.008776612976589, 7.34808114587332, 7.543580664982842, 7.130580062455424, 6.992711205975636, 7.093333278003914, 7.201476258859158, 7.267933236144462, 7.289088280251568},
    {7.108543448075283, 7.24155631174898, 7.658118723831651, 7.800939374445889, 7.6710760389815755, 5.351284182017176, 7.694073525237133, 7.377358725941885, 7.695792804023701, 7.43155335353433, 7.633811016390786, 6.864687490003326, 7.589376146642717, 7.407702927822269, 7.441799325216051, 7.340566801390675},
    {6.962015415528343, 7.341596428395849, 7.647098472059409, 7.406211604167174, 7.338008530476508, 5.622411292525056, 7.360514272577334, 7.193533281849538, 7.26384720763451, 7.267763612429162, 6.976734880588987, 6.490280856424461, 7.582890757780172, 7.539065883591585, 7.322661939652249, 7.683214532137736},
    {7.031071384132171, 7.355623018136615, 7.0804720391701546, 7.140716790830469, 7.553582845278909, 5.435179067999045, 7.4048764203890025, 7.425488056829037, 7.1908223852429245, 7.380081535778857, 6.942981336014671, 6.679455352261688, 7.06948348992784, 7.126644442788074, 7.543291710806537, 7.530905154587385},
    {6.916042317726926, 7.5286611623617095, 7.004215910983787, 7.613076460581879, 7.563480056716004, 5.511318296834245, 7.185005305906548, 6.974496742388361, 7.536692225218825, 7.056729153690981, 6.984391408003444, 7.034639108661421, 7.238059520728945, 7.263142876376847, 7.506928246840292, 7.713444488252251},
    {6.914769272369112, 7.095083581142785, 7.0318547703575485, 7.33479749681932, 7.324784312625063, 5.3943734714414635, 7.232360287294736, 7.344070300557704, 7.056307656703487, 7.206497711429396, 6.968500214553564, 6.96329654589939, 7.69879733869176, 7.177965414791531, 7.395026110641989, 7.7158616718229265},
    {7.0629104307956485, 7.455527357677269, 7.1861087593141, 7.679981575925473, 7.136039995353144, 5.916845226660054, 6.889552908384772, 7.289748415023999, 7.147056769831657, 7.361779360585585, 7.231351718385702, 6.647247963943168, 7.014560053396715, 7.351397902033411, 7.134096611934276, 7.34296873211701},
    {7.1417105147603825, 7.378304456993533, 6.992103600288636, 7.704639008010643, 7.805053564411399, 5.6398442248903855, 7.187683449873897, 7.094863264853966, 7.302246801814604, 7.717567660582349, 7.380966139253001, 6.947565399687435, 7.317372015206686, 7.34880308594561, 7.383602846239255, 7.404334040507406},
    {6.975396008709648, 6.825440016705744, 6.970912123651051, 7.0942406089211865, 6.970991334528409, 5.946874079221602, 7.262248218493294, 7.18373716318089, 6.866315035141476, 7.080619709935488, 7.1646981142965505, 6.605776125568991, 7.3564199811115145, 7.201196692789713, 7.096866993160717, 7.393875334886638},
    {6.852210747171329, 7.672901149469117, 7.272934387068721, 7.586086064524718, 7.172001084341068, 5.9354476177627, 7.4070312933649785, 7.509244842808829, 7.064592384510987, 7.714504337408949, 7.301962522357814, 6.790471007004438, 7.224493142646633, 7.815681406196278, 7.458874706143707, 7.826538472459418},
    {6.963488456268151, 7.150811824267319, 7.490630139054266, 7.15311529159134, 7.732791968556488, 6.014737817514094, 7.573833473828709, 7.220269694569402, 7.535622551091507, 7.139886601464478, 7.228461300433272, 6.4827940224208715, 7.35416672302064, 7.354101865364988, 7.157595984459396, 7.467947584502839},
    {7.199786162115351, 7.109667449976363, 7.287999946762165, 7.411552888670624, 7.8145026546200445, 5.346885554120642, 7.200370640316854, 7.626664096178494, 7.585964818794972, 7.716505642284669, 7.74475339642545, 6.601612949823566, 7.774870451005864, 7.742078205878416, 7.2875520613657105, 7.429468814436253},
    {6.950164937178181, 7.5049285803319785, 7.045246810834753, 7.019860023586273, 7.179597257253291, 5.243227143087308, 7.380853320751502, 7.182610379278714, 7.108406976895493, 7.58928388736235, 7.389259389421919, 6.318638902168065, 7.024563319815747, 7.273524083388671, 7.016869745527745, 7.676435229009764},
    {7.207110448081251, 7.028923501672273, 6.866987148127555, 7.1424228846292594, 7.441758533129709, 5.353661133805012, 6.9255411403887095, 7.08402689194157, 7.470328235700546, 7.107747544721973, 7.160823205304738, 6.746206424789936, 7.420386605592967, 7.81851533447086, 7.211058765457184, 7.363211596753099},
    {7.040627280875958, 7.284679007019351, 7.476126101096562, 7.377426919251972, 7.045522950682332, 5.453539085811839, 6.929593525972982, 6.816498195621655, 6.942899545244717, 7.211745833764428, 6.9054847159066925, 6.344608567182587, 7.550630580278425, 7.015889014627112, 6.962280377481948, 7.599902780777701},
    {7.054361841852573, 7.224451790417727, 6.888016810372848, 7.588047905395451, 7.48519667518665, 5.693068202223034, 7.474062627679, 6.957766548078909, 7.287672772108338, 7.180685058370279, 7.074719174089065, 6.435738958080102, 7.083523767660006, 7.117073120048973, 7.352981515502511, 7.390982450584784},
    {7.364398032005246, 7.38024263268422, 7.779659122537102, 7.3578827704755225, 7.586257676505123, 5.496231739491109, 7.74316573772595, 7.198489243970096, 7.51669987782716, 7.58119548614489, 7.325007391708565, 7.084050645730166, 7.872294718839414, 7.259719181397908, 7.636879104290198, 7.608733477220576},
    {6.918081642805773, 6.845681213778091, 6.931934316307748, 6.992739259570183, 7.542298318337219, 6.016636443279851, 7.183073465754839, 7.423856749877236, 6.909976812917573, 7.488233713741998, 6.965494902877856, 6.742422111688268, 7.536834091041064, 7.238281011112185, 7.351853004726012, 7.406550031165593},
    {7.399399635629187, 7.362649470744405, 7.024581132429035, 7.36324931906005, 7.37772656072987, 5.494236635529277, 7.240168310988165, 7.468443428968048, 7.33739793728793, 7.199321862243593, 7.202260392277984, 7.065413889541871, 7.508344648962738, 7.497810006542337, 7.631055085219763, 7.115739147753015},
    {6.811738499750474, 7.267799445694338, 7.331200935649433, 6.973830833784823, 7.334553288654215, 5.45262929132431, 6.762312758173978, 6.976033486414853, 7.199089806202658, 7.095702556581864, 7.096549495055956, 6.335149852083868, 7.374578202327503, 7.052833803805221, 7.105532563625992, 7.034365564711035},
    {7.122269085082749, 7.120360784750825, 7.0893623680492315, 7.033597202231029, 7.473104014984, 6.071098377645949, 7.539233800161622, 7.076893152684853, 7.323291760990076, 7.186676127908784, 6.919017516578025, 6.4686207188419065, 7.0856602910644995, 7.666105843142142, 7.225625062433878, 7.746391164953017},
    {7.151544054471821, 6.877618060694728, 7.013580473268763, 7.161163549718169, 7.593429693075387, 5.770024785823831, 6.977425656251815, 7.3273450581047115, 6.976695516832432, 6.941194279921594, 6.98144308262809, 6.388283276281981, 7.434946338403622, 7.443231838366737, 7.047609959983107, 7.101388249282168},
    {6.759467697974862, 7.253036227421907, 7.039659536591155, 7.254850563423415, 7.48468097034845, 5.569546565645201, 7.275960783563706, 7.196402453627618, 7.136577331391806, 7.0654616890315145, 7.311640611591551, 6.811313659630516, 7.348510947206935, 6.879207747354727, 7.568804873307265, 7.433502288593705},
    {6.907084692171755, 6.978863279486665, 7.148798513610067, 7.4221982371684705, 6.920813815792263, 5.575999007111521, 6.813759929676276, 7.074823118883768, 6.900156530168103, 7.1221871443295015, 7.160048120141402, 6.271463144687769, 7.246622610835753, 7.129981596827998, 7.1506668474797035, 7.039340361013988},
    {6.842155017396448, 7.057400301166162, 7.054802369385247, 7.439173070467218, 7.212254643745116, 5.859447985202688, 7.118361374965404, 7.214012579581571, 6.909832936046251, 7.405169727130936, 6.816455609943244, 6.411104352306285, 7.332398775856227, 7.245469698735213, 6.916722002135183, 7.480299331855515},
    {7.379626795467259, 7.289396050071016, 7.499151892614081, 7.142961945528553, 7.66388926894503, 5.4682379512947445, 7.286329225220644, 7.204375088495366, 7.562087669442447, 7.377416941385835, 7.042125634765258, 6.381445734391637, 7.0510184980244155, 7.595732520756459, 7.021673712717239, 7.606021503467282}
};

static const float b2[16] = {7.103875837982813, 6.796283403626602, 7.160339548523825, 7.020765283142312, 7.080348601720493, 6.5193001075253285, 7.088158222178213, 6.78290049417682, 7.1434376785113285, 7.0618144418258, 7.016019702354946, 7.112051952008793, 7.081672668734359, 7.1682447508260285, 6.951215439696744, 7.031962317195209};

static const float w3[16][12] = {
    {-5.0424863087341105, -4.740719146503132, -4.6058528396374925, -4.405284212805844, -5.04773909533049, -4.306934122178464, -4.949217119886292, -4.451654008204164, -4.5075068015246, -4.50456990627665, -4.76513607443025, -4.412227948909208},
    {-5.147809156539024, -4.470896413732478, -4.498648066072627, -5.244856433796329, -4.374601624878951, -4.58209786740169, -5.042168615740388, -5.256470032005436, -4.485909222455818, -5.069405751746486, -5.075623724288963, -5.374186826767316},
    {-4.665236734674027, -5.278308366819304, -5.014329694275826, -5.170813192794075, -4.404491369575024, -5.05786952012479, -5.150692246971707, -4.840749716985238, -5.337397588906704, -4.484863129466565, -5.188468158988482, -4.976951468882492},
    {-4.894658300127189, -4.765254876414396, -5.09417609803834, -4.994699069686723, -4.644729956695968, -4.601808378258844, -4.304558077206024, -5.023758267276391, -5.221994002547059, -4.8549633739944715, -5.1787345214527845, -4.732258105140833},
    {-4.775834844582255, -5.105877786578522, -4.542035955319644, -4.370162383261789, -4.931092026722728, -5.2572043948910645, -4.890506642655448, -5.323924596534215, -4.596135833936371, -5.092634261088188, -4.517224456086895, -4.843184110058833},
    {-3.5956482805147036, -4.015092584048451, -3.9848146496927463, -4.134847833106445, -3.6054964420520634, -3.87443370415169, -3.339178360764363, -3.689810653109947, -3.046736597821085, -3.798979769509202, -3.5425530970249746, -3.409771571459744},
    {-4.822849571218015, -4.881278760146813, -4.314534767599575, -4.7884875000263625, -5.035681850977941, -4.887596756224803, -5.2645833700299045, -4.394967834631591, -4.514162492955014, -4.5989671203429365, -5.272891378215496, -4.899744640549112},
    {-4.9274808594134765, -4.806772643789511, -5.122509460769101, -5.059219391663476, -4.936721612688257, -5.291760246185688, -5.222596044736384, -5.039716960511812, -5.301657426210155, -5.121486324740763, -4.6177589357941455, -5.013886518468097},
    {-4.74441904509624, -5.38229938392131, -5.226473296741012, -4.406048631801605, -5.28831275838498, -5.1118426408167155, -5.073566423598082, -4.939536809370075, -4.742077532464087, -4.841123538361427, -4.647388928403254, -5.3989811790657605},
    {-4.7185924155517895, -5.058695210828684, -4.8664896446329795, -5.112720900263155, -5.194511620037862, -4.930927386779473, -4.491890275417768, -4.947135001321341, -5.013745913312262, -5.007197469305115, -5.107230357044292, -4.634826304103209},
    {-4.818441425584672, -4.684048438248644, -4.287563986620631, -4.792095676636232, -4.856887058824607, -4.3481619259924535, -4.5286318876018585, -4.810658712540243, -4.561191460686297, -5.1173249132884076, -5.135253581637973, -5.3547330159086},
    {-4.674634971435401, -4.22043121632534, -4.705705554748872, -4.465526731963727, -4.87005190304119, -4.171941017403311, -4.854609863053074, -4.400641146520073, -5.207659993646756, -4.535924848756473, -4.379471239783464, -3.9252400727297974},
    {-4.6719201209448205, -4.523109547268333, -4.940380477429956, -4.614230867326825, -4.839157351298815, -5.089549552162217, -5.286344233549208, -4.8453418444374465, -5.139210582824596, -4.8434423064732215, -4.748094051297483, -4.819586366135522},
    {-4.716827283182943, -4.871595680897056, -5.132842267974716, -5.01555892016967, -4.917189173016944, -4.698840588207062, -4.826369083024835, -4.7642623898893595, -5.188682305196952, -5.120447121211754, -4.41259934512274, -4.987970328608982},
    {-5.341020802265711, -5.017802912378009, -5.00680015059215, -5.080299088241326, -4.475240324986888, -5.311421188658128, -4.361919167119835, -4.6878330282768585, -4.52943809803669, -4.856598336494691, -5.172607597723229, -4.441830813761167},
    {-4.692223228227211, -4.611360965149747, -5.085025753702807, -4.850015481308474, -4.888314613527627, -4.775288913650379, -4.838349247004389, -4.909792918610122, -4.8376447377864755, -4.496313272508006, -4.563353936908651, -5.0391615097045905}
};

static const float b3[12] = {-2.1422913896189106, -2.936101184416726, -3.365203044080377, -3.564530822402732, -2.649197458523644, -3.269452234271985, -2.6778086595375687, -2.5708941169410053, -1.9915240637518632, -3.3357019782022452, -1.7295623678388452, -2.0971931116488536};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
