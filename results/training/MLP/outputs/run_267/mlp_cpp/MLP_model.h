#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.3460115057170561, 3.5776202537090884, 0.48421132228683933, -1.0575479195879343, 1.1120538254809305, -1.3044517321147406, 2.1415299044713247, 3.2403275301573022, 4.036353738669552, 3.675045685977885, 0.33642334430609644, -2.2535507178250773, -0.6659483894039716, -1.9100741324618238, -0.7126212691450281, -1.0586084580638968, -1.3982156245522241, 0.9996219289319758, 0.717550266923935, 0.8992701264206585, 4.403905378894151, 3.9605485433457437, 0.32343029071266743, 1.2667959750535562, 3.4469088839366013, 3.3290238331867195, -0.9337608421202698, -0.5021622053898618, -0.4006641588041804, -0.8297134258904079, -0.8718214305624413, 0.976735068228153},
    {-0.5811262017722473, 2.5856261024666405, 0.27671640813236514, -2.0451731094489807, 1.2762743168264001, -2.298452020436716, 2.7073340604214295, 2.986981900276698, 4.082961388272131, 2.8645070718697934, -2.0393147334430606, -3.199445710528031, -2.319692380856383, -4.173898861257882, -2.8569611040265124, -1.0688703067307475, -2.289776070801247, -1.0088039529650097, -0.4246664173656105, -1.2457736767202228, 3.1293631394703856, 3.8984813007554706, 0.2934819189559033, -0.22975022517031962, 3.359305100966324, 2.1471034518420877, -2.633963068592127, -1.1066413193952709, -1.9070423683555333, -1.579364717506137, -2.7439061490236982, -0.6133285212174471},
    {-2.038075840969057, 3.9674704095676554, -0.1697271870774682, -2.3795466619199472, 1.3783448018646596, -2.794760579977327, 3.144361114069424, 3.68353045721126, 5.0949176248862065, 3.9579110072873056, -2.271580892887897, -3.0302871979350328, -2.1138620409940416, -3.6567646818675534, -2.871225217936969, -1.3845902436912083, -2.5260774993863646, -0.9131727360069277, -1.276917704741687, -2.004424088217717, 4.1622347473196815, 4.74186201346452, 0.11881886072074277, -0.5882003926678444, 4.295509417550686, 2.4789232022037937, -3.206923579807777, -2.185705952446203, -2.3140227293055706, -2.0332643502170686, -2.94318210770082, -1.1668765565910029},
    {-3.423264678787007, 3.3957242769814417, -1.4510120560186954, -3.762401326608381, 0.7252726947907533, -3.8153719362767773, 2.4377066783149552, 3.2914035920275717, 4.819542508881817, 3.5480486370439337, -3.550066421577108, -4.355314971200167, -4.347040944273923, -4.822993316497918, -3.906877637038051, -2.7656860241369823, -3.9772011466836195, -2.2430289088932205, -2.3436958952527336, -3.13575235985815, 4.491962646757569, 4.249374056502702, -0.4435726240500778, -1.694315083543839, 4.226263008908858, 2.2834791539403927, -4.3910361805483795, -3.4802399247076554, -3.7036670053707788, -3.4051514392971414, -4.190077650243579, -2.5752646660378464},
    {-3.7788730626323845, 2.2232127417954883, -2.723278797991292, -4.511093866553877, -0.15077873935021283, -4.516900060638827, 1.5886807101227245, 2.045008502961536, 3.966504702480788, 2.414431024403273, -4.412425224620688, -4.514116690265482, -4.497872797162812, -4.915362508868383, -4.769299015363489, -3.4080272685935045, -4.2388618365115525, -2.8301950075590234, -3.7002457979953425, -4.471891290791799, 3.6617694327869206, 3.431377909460135, -1.5052183307534026, -2.8106280598723474, 3.4870967461735813, 1.4089572846689344, -5.115931970092329, -4.248629493832431, -4.268641810991052, -3.885413737456543, -4.723330044761254, -3.7445226020829816},
    {-4.16093548450569, 0.9200734480036198, -3.305699940089323, -4.187410844964399, -0.8873766475521065, -4.267255303809744, 1.13947659143781, 0.5413329435941623, 3.010386338228036, 0.846196982990598, -4.437417972330329, -4.324694034749684, -4.6801552560094475, -4.478105814726091, -4.522661092210765, -3.4571791069962394, -4.219280629959714, -3.126877033110562, -4.015635199409764, -4.686685801463602, 2.877755253128113, 2.2389661482225716, -2.4515017411882742, -3.5327020122359043, 2.5689614905358384, 0.3690619589295203, -5.106726972909436, -4.332461542914322, -4.656581546530516, -3.718534353692133, -4.827790618186499, -4.082503393553338},
    {-3.8222876504127985, 0.0708013244128866, -3.297176172057841, -4.195792431904295, -1.421159259325398, -4.512581084694252, 0.7124647767698667, 0.10964289631549945, 2.4663274327607585, 0.48193736097954654, -4.657266855410879, -4.302332163038623, -4.505321247830838, -4.786776252594971, -4.48133184883195, -2.8849159497066923, -4.105746525126743, -3.288528237159414, -4.032103264760018, -4.555792479812115, 3.0166246001136616, 1.7548897308696167, -2.1007348389916705, -3.693413002967103, 1.899618818316854, -0.44767278338632793, -4.955714242179828, -4.122896976114064, -4.451699493029753, -3.824757628874327, -4.902018770401839, -4.168562423503657},
    {-4.182065664412029, 0.7007668568954841, -3.4409774596960316, -4.258294146433911, -1.6256334932074992, -4.698631996497403, 1.1262872066738556, 0.37673952858948123, 2.2906831678265163, 1.0950942413412856, -5.080825048149636, -4.261080639598125, -4.9521989767306085, -4.613055876561008, -4.970761366200995, -3.5285409628792364, -4.4169761012531294, -3.6525457547995854, -4.0709745662982675, -4.578142067246891, 3.0439696535654526, 1.7299959081954155, -2.025892908213625, -3.6724716426233313, 1.7531488824634305, -0.08747621510137292, -5.383652657631424, -4.475111331121828, -5.129957333835794, -4.10089784120982, -4.960796241831779, -4.557946061317259},
    {-4.0036152894403365, 1.7498028434482185, -2.863456959134624, -4.53272724358092, -0.8637379400703342, -4.597001831845893, 1.1772871363651727, 1.4970793998913743, 3.008796999824327, 1.6563553771296504, -4.754452192821387, -4.3320594234388485, -4.802139168565858, -5.091323955269173, -4.924010708918165, -3.4440927416623226, -4.546868805384133, -3.2888534864588674, -3.8370519105450906, -4.608001814109087, 2.937771069729755, 2.753025943495163, -1.4514194293174705, -3.3455193651245736, 3.0405236274771084, 0.7762099214231709, -5.268633670753189, -4.259267435353563, -4.897181953596593, -4.092529569451898, -4.899867681188415, -4.161699010341694},
    {-3.699760091629908, 2.0530718613163694, -2.0837777999016036, -3.8592866683968983, -0.028250403726038473, -4.393847894484528, 1.7089103465972002, 1.9368983898234746, 3.493782765130533, 1.9213778874506673, -4.604348594228566, -4.468062640617354, -4.895161524815055, -5.335138921881301, -4.658419555082128, -3.1570458514935504, -3.943972088374561, -3.066200520461424, -3.2626240915216296, -3.9190877036012646, 2.9295839746464716, 3.4560952697844693, -0.9256029509991058, -3.0076733989210105, 3.3786721692022312, 1.3978358052908435, -4.976028993333958, -3.7307274226545486, -4.250680991749689, -3.8822471319906566, -4.968241317940764, -3.5861438228564113},
    {-3.190051711603016, 1.7696931635569133, -0.9568128938501674, -3.6110618681974955, 0.633747873790339, -3.7949089484604563, 1.717840499120693, 1.8061333289346226, 3.5668178284158407, 1.3736959479574344, -4.150536979899409, -4.493593415152096, -4.333319537007068, -5.11171935464376, -4.323056757045755, -2.6926859609722196, -3.7966046697623854, -2.8983774560412234, -2.654980987484033, -3.823170028283003, 2.1268983930077843, 3.4181939841471825, -0.5871301745751363, -2.283015300338445, 2.805675802357051, 0.9406764607353695, -4.502030809319761, -3.1995283706269726, -3.8110092117116707, -3.254313181097656, -4.425980626373386, -3.007467069098146},
    {-3.3773409716847604, 1.6117779032300565, -1.4090562887810465, -3.348995133421087, -0.1845747406876296, -3.908560365531007, 1.814975856301733, 1.6186998225156677, 3.0251513994039234, 1.782396693071327, -4.392637335477992, -4.146544509746007, -4.14264105668835, -4.97417376814147, -4.292670458556709, -2.6086477410221707, -3.2289041467911903, -3.342415304294417, -3.0877474117666717, -3.8465813411322456, 1.6189765811603225, 2.8755025748377046, -0.8868962064777383, -3.0101077636619005, 2.5857342466952873, 0.9309030350733043, -4.415628128668918, -3.2183135155424956, -4.240623856606235, -2.9743242478768543, -4.715355509054772, -3.4399347723488605},
    {-3.1247287868146256, 1.9551142132534431, -1.7432024784668334, -3.1737560918463505, -0.13369077819351646, -3.846786851677454, 2.2040065376189895, 1.9948475697229169, 3.1030052132446007, 1.5741765554292273, -4.4829029600101915, -4.349925069308286, -3.9447619617853773, -4.85538944800951, -4.5525053175106285, -2.4426129286263905, -3.3760301340398113, -3.0456390193639242, -2.9898228320799696, -3.785084034389445, 2.0997539761545747, 3.0709454065521795, -0.988098596258489, -3.0209025137027483, 2.60622127457247, 0.5958916958451369, -4.4039222713380815, -3.2757454345107497, -4.030202284953599, -3.0926545355008432, -4.54053139404389, -3.490416233837363},
    {-3.461265042960951, 1.8484034978905517, -1.7029579461724487, -3.8103309848286138, 0.07838035695247439, -3.9654941786316713, 1.897290479844886, 1.8567240301971424, 2.953986710030779, 1.5446153555338433, -4.392112206201647, -4.200995625494946, -4.613902771687052, -4.950947589381683, -4.524856878874242, -2.4858816068968252, -3.463821061659163, -3.450052149246749, -3.432192490208693, -4.139580153365209, 1.561961346332644, 3.2611210070547325, -0.8113650421567037, -3.050440881628361, 2.3803509627515482, 0.5577984689255944, -4.47938772501273, -3.192563549968621, -4.044810564223952, -3.454369898027214, -4.812547475759167, -3.7216865561709764},
    {-3.762932460712982, 2.2843407916030842, -1.852807847671903, -3.5435924775642795, -0.2202106181789094, -3.763515447069259, 2.275289592705289, 2.150556510971455, 3.442594535425372, 2.033907857777493, -4.476309455105313, -3.971492936909413, -4.482619455524676, -5.178700332750318, -4.499247642295036, -2.5841015535009566, -3.6867574805932626, -3.2868245562699316, -3.186344292414384, -3.757775411685411, 2.6439905260636083, 3.2733248080390203, -0.7538645597719077, -2.7954501811228565, 2.9732069619190993, 1.143376308164704, -4.287909322638074, -3.361702718180978, -4.3563120394997865, -3.2287103448875674, -4.357413094504594, -3.458563007547309},
    {-3.8646458356237017, 2.145722543678177, -2.109221892881931, -3.779997528504728, -0.28251650106576054, -4.202552681419233, 1.9618257545735267, 2.238082668636149, 3.5084163963038946, 2.2649427888928377, -4.63661125853027, -4.487379211865356, -4.708747047221844, -5.433895834504121, -4.531219219068092, -2.775936148442084, -4.06385096211222, -3.4166937038955805, -3.186125443680562, -4.197100737347536, 3.020519642501242, 3.162052524093389, -1.072754252325113, -3.290921511315473, 3.225210045006232, 0.6588645053670686, -4.749889375193233, -3.840503342590583, -4.695279561153581, -3.221865657352242, -4.81261908195478, -3.9178620601876712},
    {-3.547970660768877, 3.413806133235438, -1.754209858770664, -3.691274553017172, 0.3891612923008989, -3.9856775401201436, 2.3118769778839234, 2.9537110220724654, 4.185245732592834, 3.1774678216539627, -3.820838421401842, -4.383020562708259, -4.328179947349634, -4.889921532715728, -4.37403964465568, -2.637099426573032, -3.9374867332543304, -2.735580419588937, -2.7474973583667053, -3.8269730953576513, 4.036535187234234, 4.067764311984195, -0.3546147756280009, -2.4771281517213937, 3.8602975335562513, 1.4993452377059138, -4.48241054893086, -3.3689760051265734, -3.916318243693797, -3.2338531088358597, -4.3275250921902835, -3.2588060808680783},
    {-2.555121511167109, 4.074128607723189, -0.40907993751315097, -2.4584604244470945, 1.3228267095482942, -3.2506154282385196, 3.298247576826113, 4.002592994798408, 4.742168701099797, 4.017167036762439, -2.9293810379810825, -3.2886996854850916, -2.8398171123717697, -4.166810685865511, -3.23516905519185, -1.5770694471757216, -2.6201257056446683, -1.265686849944924, -1.8029853145838413, -2.72330484258636, 3.850189089242463, 4.742783157493883, 0.16420116863419393, -1.0296180233161591, 4.466488371418268, 2.8107965161319965, -3.219940257745414, -2.417490617181325, -2.7491300535400303, -2.256362063943125, -3.421667508582091, -2.0089030407130757},
    {-2.612583526352768, 3.552314742210271, -1.0758841090390021, -2.7831495717997097, 0.8073981288833931, -2.950709662044015, 3.2379904453450132, 3.660289649280978, 4.483782110253954, 3.612259411473006, -2.7778743457066946, -3.492172684210428, -2.6272681423757565, -4.119889025872909, -3.2714460318442407, -1.6227441317540168, -2.555686216019545, -1.746865688268807, -2.3828634624426455, -2.9950052608046667, 3.5587716876760744, 4.350286124217035, -0.24017374708608477, -1.5379875260176896, 4.037070977437617, 2.3885072369361247, -3.443968730745291, -2.734197133785278, -2.9386091464284556, -2.3953185141115343, -3.416359385153814, -2.4424889145921247},
    {-2.886405045581715, 3.434935716844189, -0.9507446249825376, -3.439513186215148, 0.8354412535951715, -3.768338143355883, 2.89804706449645, 2.985487010689161, 4.432665387040332, 3.3521685487534394, -3.954682738702467, -3.7667139615543457, -3.5538299871767656, -4.856057596754019, -3.895869290982222, -2.1320095178099407, -3.2063034154746677, -2.423658441495011, -2.413947144875246, -3.491281874007733, 3.241442810592001, 4.144912988052402, -0.11064871340627082, -1.939754952418701, 3.8658357578523375, 1.8349468697560078, -4.234285494918111, -3.131968732422618, -3.5028684507360084, -2.7999545874232092, -4.511566011456069, -3.259964303759994},
    {-2.472244871716111, 3.4306369859924453, -0.14896244712681658, -3.2389526453813446, 1.4339388388487115, -3.5926254938960502, 2.903834918514013, 3.267398210775954, 4.525883712049915, 3.243082740247704, -3.5381869802314885, -4.007160976410317, -3.6026863898274937, -5.124878773770704, -4.0300094102702175, -1.5684788782337924, -3.064665909539276, -2.3723019897218807, -2.000676500377372, -3.1917593572121397, 3.1108535746744517, 4.264959989420612, 0.8218957343795551, -1.5927475706906524, 4.03083021819641, 2.1388012218313888, -4.106055332718866, -2.651148839788614, -3.362762363172541, -2.6541283014841217, -4.141721313692557, -2.6291366128447486},
    {-1.7542508234995131, 4.562248665492336, 0.18518298309096642, -2.2049397472455916, 1.9289717405755546, -2.66083051333317, 4.138563839448568, 4.13342494784244, 5.262124608640071, 4.5964665479769184, -2.0575408253689424, -3.7169344708646057, -2.778370130134499, -4.366925871880021, -2.6501250245286907, -1.2309205603813214, -2.350915269297536, -0.9542919680282176, -0.9363498287033543, -1.871585494565969, 4.469023369749084, 5.09535879946402, 0.851801216145795, -0.5436981150581923, 5.041828503110421, 3.115251225158135, -3.0255747063263945, -1.7475411018946205, -2.3321138454940455, -1.9940644480495382, -3.0271940398698147, -1.6624732794150143},
    {-1.7138272254493747, 4.549448469933173, 0.8972828302076032, -1.8271948063626344, 2.20880863082289, -1.8895453735495216, 4.111370564595106, 4.643760652671494, 5.347058086683116, 4.789845352083921, -1.1064023547826074, -3.155851034943007, -1.875141751233936, -3.6527693363993134, -2.208242313528452, -1.0960386203307906, -1.9870530395797439, 0.03426634551861658, -0.1554765640565908, -0.5950618375483104, 4.847167185320988, 5.091694764445308, 1.3108292023477055, 0.33056801747414194, 4.912266550335471, 3.8555857830852234, -1.81214168859726, -0.9691473994037232, -1.431023878611855, -1.553316502964061, -1.8394934069147026, -0.2227325764500971},
    {-2.4999603604494944, 4.098137520207569, -0.1351311394714975, -2.5459807153195, 1.6322831643869204, -2.8762066875725134, 3.4788014026993936, 4.110635755394981, 4.8352880115568295, 4.158574849799437, -2.345022074717888, -3.495575852319431, -2.4831847702605345, -4.197180953079542, -3.0698927633103494, -1.6197561745185804, -2.9203721223184025, -0.9868704159359055, -0.7783438955029353, -1.999836898400471, 4.092957748320378, 4.908246318990772, 0.916592169205669, -0.47155372936437157, 4.562956239691623, 3.1915605185515736, -3.036950438637313, -1.7824496930392395, -2.316143889136997, -2.053783632960048, -3.093172538562934, -1.3561841286540885},
    {-2.0804475391677264, 3.7073698269684985, -0.10617908154000233, -2.755884109642127, 1.5833011073447691, -3.2832525698434942, 3.0839101443542556, 3.458458463219281, 4.499430053766074, 3.459714461302278, -3.1106296159154683, -3.932050324068733, -2.9370136351130207, -4.77522008798591, -3.729362841057857, -1.3402667297130886, -2.803991824072707, -1.884538057657512, -1.2761258104026272, -2.6652851941651856, 2.940626679899968, 4.523296117895759, 0.8552339282016126, -0.5864051498517886, 4.152013150653681, 2.2686958497629552, -3.36944085683637, -1.963215394934142, -2.407897176284662, -2.1608758449591425, -3.705331354443235, -2.03095934984336},
    {-2.2335527806683633, 3.500166243080434, 0.17941552827150067, -2.1542071212485663, 1.5221149117405346, -3.0225185648244484, 3.3458888172948065, 3.5333224308850903, 4.5104846025694725, 3.730644400934591, -2.7815010213200333, -3.474243318902596, -2.7585959848932466, -4.006698145148028, -3.1760818796092183, -1.3552368377180322, -2.4702693161405787, -1.6715779962199158, -1.3798748369799008, -2.107943464704522, 3.144986113031926, 4.31967513639074, 0.711102466563595, -1.0091540573153943, 3.9653083620584364, 2.573364601833541, -3.042406527966949, -1.9575151319349786, -2.1993621444645792, -2.0245656787432535, -3.260944090698118, -1.8757130883688602},
    {-2.3032409094437245, 3.74846208315771, -0.14034912634648408, -2.4810354996219455, 1.7901822734919524, -3.1038137343900463, 3.6334757255994043, 3.8762619441049453, 4.968399840212662, 4.26004253251851, -2.750091143429542, -3.5783413047414867, -2.714360727763106, -4.186704943715457, -2.9317009999723957, -1.3831605912985745, -2.8730873572918725, -1.8879142057683242, -1.3895504029749013, -2.521180158311138, 3.950639694337905, 4.7570558100485645, 0.6209743727202397, -1.129695438547827, 4.472393143586545, 2.5600696412062693, -3.466423777384086, -1.9839256698541918, -2.6011532665543386, -2.248113160198626, -3.2343941752710723, -1.802507522238076},
    {-2.481788661386395, 4.24115300921657, -0.26018475451908846, -2.923749285686225, 1.6760137737105663, -3.34761019802328, 3.623397707304162, 3.8274032157149396, 5.037874880807803, 3.813357082366306, -2.502560044229745, -3.7146745308666005, -2.861991489728809, -4.549963737131186, -3.3729047949105273, -1.7288786884059084, -3.051005004848292, -1.9686976939410425, -1.662244107717139, -2.5567304768751105, 3.9275959916574092, 4.833492361802613, 0.4656641555502345, -1.0746982156973686, 4.402209864348971, 2.8730870165023012, -3.4763431964348483, -2.4519469090370394, -2.7406716427729245, -2.4189949920596034, -3.5256123301773465, -1.8705790850094508},
    {-2.2733302833556306, 3.8400984208723785, 0.2847518627668534, -2.7446112891643, 2.0379719702050605, -3.0491611785532635, 3.354579637417675, 3.7617064961673448, 4.869950116487314, 3.420397714329686, -2.695932924208501, -3.6348577825994792, -2.593504847259321, -4.335404580347498, -3.505911558323535, -1.426189970361047, -2.7603720275363384, -1.650538651013713, -1.0346144621147366, -2.2987160680611143, 3.3489349379984694, 4.744513074200293, 0.9280504105805789, -0.8361735585828999, 4.179335753552589, 2.840061031070496, -3.1887972486123948, -1.8720637044144, -2.279583158702242, -2.0845322750614272, -3.4688066344586725, -1.5236933763301197},
    {-1.8811019640099669, 3.4912760705056516, 0.3610314107189337, -2.193547127619938, 1.4984938357834523, -2.8835374072954227, 2.9576291666546, 3.471271761962939, 4.650831965352456, 3.6838171146643552, -2.2120496106951046, -3.5203676583047785, -2.353489979760756, -4.253134065301985, -3.3554060439579882, -1.4958782896732528, -2.6401035690069174, -1.4521386355568147, -0.9911416213821893, -1.7395207165014728, 3.2448304171544464, 4.407278483203789, 0.8544735546707684, -0.4245896966670399, 4.323038536168009, 2.3980474950980732, -2.6572770047176064, -1.8568609495790893, -1.7347496875476556, -1.8626221802518674, -3.0513640349649407, -0.8167958762894919},
    {0.5881126230201539, -2.3104750760113917, -0.2755435199259538, 0.6459082328589562, -1.3893354117371552, 0.7088100110160607, 1.375661889073412, -2.338591398832378, -0.895359801172756, -1.635243118947792, -0.6806386357940729, 0.860656699088216, 1.4409749734992312, 0.31619313399586246, -0.5046653233328188, 0.7024668572066134, 1.3712968030766977, -1.131102620124656, -1.1770758461214275, -1.4749680580875093, -1.9763860994381193, -0.5211622841095892, -1.4072870016298935, -1.8064942014719119, -2.012495763929067, -2.2716203271065187, 0.23575573992111595, -0.2327142145679691, 0.12311236589760192, 0.864417951411277, -0.23346693472231544, -1.3025069297892409},
    {-1.7209662273917834, 0.9738212958165142, -1.0776762458753013, -2.273155731831954, -0.13917898559610264, -1.7451412743424757, 0.4398309449587301, 0.8443551528694693, 2.439904790924729, 0.9335147910952195, -1.2364887909013325, -2.5296911977846865, -2.24076358455025, -3.2139159108134736, -1.8764920042614062, -1.7602293598669794, -2.684648405166619, -0.5468068021345666, -0.9604885858689182, -1.1024338019633555, 2.069929551257076, 2.228248894922358, -0.7385375467491003, -0.23091756325214852, 1.7021328074240702, 0.5705812352148243, -2.2407001545116723, -2.3741359916547706, -1.7349256603366978, -1.6716887930405528, -1.8157353402758245, -0.5234013730634114},
    {-2.221209501641668, -1.6347974741055402, -2.742335699406336, -1.8119622663468253, -2.6005692961374534, -1.3792276416248936, -0.41160576246549213, -1.5783891068248306, -0.9512533519508782, -1.4303563945902154, -2.3996090369273153, -0.5010733020330215, -1.514649802955982, -0.18446999302831463, -1.2290974126462122, -2.15559215046344, -1.691431575307364, -1.38812851541468, -2.6572541778893943, -2.3085021840778426, 0.04750018299608667, -1.3273906578255408, -2.610316526420955, -2.526466736631759, -1.3207732275903805, -1.7498568627257993, -2.106156488629786, -2.265686612301728, -2.1116442634264785, -1.166755618234129, -2.3080784494592854, -2.7048041026240837},
    {-2.3298801724967806, -1.0451473235731839, -2.0609012041919446, -2.069107739881033, -1.9578561974182025, -2.0121235794770995, -1.0234884548256018, -1.1857158107901349, -0.9227229236089896, -0.36314661153815153, -2.0575706312585313, -1.4814321402649957, -1.560956937406842, -1.3154472239375297, -1.2839327578253614, -2.2843191207637967, -1.6373448854338508, -1.6312732149466251, -1.897625665847356, -1.6757799300781189, -0.20236001568329148, -0.4873668334633247, -1.9572649573582659, -1.9303721434249987, -0.7559913587352987, -1.2542712025370115, -0.7791713385177192, -1.835184591752315, -1.9474166582660462, -1.7279973093027117, -1.6247581922747993, -1.9269195342083685},
    {-2.627244434282927, -0.1937612862224978, -2.158348694195449, -2.5569963425000672, -1.7256930747093935, -2.3934158804495924, -0.24875310351450633, -0.11633769138242285, 0.6544286643428324, 0.22412343036355895, -2.8420566662727995, -2.3013620300035105, -2.79458923448833, -2.7753076769727767, -2.9233879429640086, -2.4413712126355454, -2.3616151815708313, -2.0674874449154776, -2.475282588697733, -2.705588164104159, 0.4759528014134318, 1.0420926837237379, -2.3100775275927297, -2.031627926287924, 0.36913258195464144, -1.0474519772992583, -2.905909468028532, -2.8403810009919708, -2.880031756308861, -2.509869708476959, -2.804892545862045, -2.6054474548151103},
    {-2.897700200128571, -1.208552977166793, -2.800534446363202, -3.020781266170296, -2.526762871787769, -2.9251431982185423, -1.0754638711678066, -1.4801340966004648, 0.23143709206575364, -0.8054447034757098, -3.1105939194075436, -2.254112957780926, -3.2012635094267714, -2.3720562206346654, -2.7433285775920764, -3.309722143310863, -3.0838647298260904, -2.5657380537216965, -3.211652337116673, -2.8402539131519267, 1.0160026087534912, -0.3709611260869902, -2.7370329654605183, -2.5687079975939566, -0.5491637399634477, -1.8560683467619135, -2.8220736526509467, -2.658483111152757, -3.13314853476223, -2.6191102265525594, -3.0508132091978126, -3.1931525882064764},
    {-2.9221380229690457, -1.5659878158225609, -3.052521891647782, -2.5320662403126737, -3.1358261654448265, -2.352113428518098, -0.690858753572142, -1.6813900894358638, 0.002392358956657095, -1.159397822634569, -3.1037412541383076, -2.2294029211780586, -2.930836224039954, -3.1224471325620695, -3.036159054888198, -2.976710492497144, -3.1520706733508836, -2.5445430303802206, -3.282041534218882, -2.8149306274188644, 0.593346334723864, -0.23492306366128157, -2.8006872355659653, -2.7159092860023173, -0.6044528100886517, -1.6427348593201074, -3.1544750626284213, -3.027428402330806, -3.0366762366847517, -2.7986906464537737, -3.106852121216719, -3.0284514361240076},
    {-2.9436438609206683, -0.9016863587797637, -3.0864579437060593, -2.756331482533694, -3.0545308647471554, -2.4724526343098483, -0.34729575354257075, -1.0213370196157554, 0.23494443501175158, -0.29922054357594385, -2.9916623189342046, -1.6097354563925375, -3.3280707432593215, -2.4732115529595955, -2.7183208604565454, -3.070346549678902, -2.774350597060056, -2.4818273727656255, -2.9869454523702084, -2.75420346170417, 0.48537285126249863, -0.30678624531296156, -2.3978652047033053, -2.3506848987934617, -0.5026722931163042, -1.2583691693133665, -3.018891085061422, -2.2647196206992724, -3.0044243304236, -2.5767409947854403, -2.947491668594733, -2.866417453489755},
    {-2.8555587561920777, -0.6381102445148208, -3.2623514463336987, -3.2446783580032172, -2.7982728125546767, -2.6807898118779887, 0.005290386429881632, -1.0113569696869966, 0.504722903849222, -0.20660507647820817, -3.506661632326966, -1.4765911652396255, -3.34783063007915, -2.61090750832001, -2.8026651939645277, -2.961897715443961, -2.9985375628127735, -2.259105442697756, -3.2216150259766207, -3.1880348893044936, 1.080448816349686, 0.5995701734870554, -2.9076850568781776, -3.3188663768563953, -0.23130645060388771, -1.5436390610950197, -3.648891002372154, -3.205371468273938, -3.0530680346083225, -2.7069972948995655, -3.2443887315322257, -3.243069356640474},
    {-3.0138563018284388, -0.8318834709780795, -2.917516142208047, -3.10140553983484, -2.6603534222022116, -3.012379051904802, 0.8274512668928643, -1.4760959654935715, 0.946645064302508, -0.5476666926585734, -3.546847290533608, -2.438491082175115, -3.0618875343374263, -3.1790106459620646, -3.253867615014596, -3.100514292715311, -2.7845733175284804, -2.8390328921268044, -3.264718299854361, -3.4739811004266246, 1.2740307138881939, 0.9607111269198493, -3.153999236779155, -3.3490023762336194, 0.17957835608288378, -2.0600918380824735, -3.2584262047045645, -3.386161431597726, -3.274719041445592, -2.356183942580535, -3.282718785927843, -3.2274245562095705},
    {-2.3110648395425404, -1.6009473198402686, -2.408796170923379, -2.1573643689333464, -2.2750000734674907, -2.3192333388596453, -0.5517529527917746, -1.772775326884759, -0.21353572515519947, -1.2756877926582895, -2.7594167709319164, -1.6383742575487055, -2.4150139583331334, -2.3847050797648057, -2.432378284365478, -2.5119286248608637, -2.3012559552270773, -2.5259999534079025, -2.3101168009789808, -2.409683580736572, 0.25670559912760027, -0.18800569089191785, -2.377357442141789, -2.9002165053002784, -0.5805883385781938, -2.115909269777672, -2.7046693689495824, -2.2297312950274577, -2.3397198219581474, -2.0431453698551625, -2.4715065947212635, -2.546817340103646},
    {-2.781750922706267, -1.4631401128196742, -2.7914046611542553, -2.9848756217806924, -3.035699640905211, -2.5255592883534987, -0.23247653672547455, -1.9065699638391156, -0.14378303719459534, -1.5020296602430827, -3.1419212114508848, -2.088427600111578, -3.036442366076306, -2.9773909585699343, -2.9608741987388854, -2.725187162826224, -3.0681216588888502, -3.0672191343270607, -2.924967164362226, -3.1601102866639037, 0.7993693783483128, -0.2321150040205805, -3.122035226726744, -3.1501853022042656, -1.0333566680651411, -2.2479558913066335, -3.1680443380046834, -2.8881449461043887, -3.24275281151169, -2.58398906791892, -3.441503331304359, -3.2343045008596785},
    {-3.0700449681052864, -1.799984640068197, -2.9988425965934375, -3.1547096914240886, -2.9233654984271595, -3.079387151594473, -0.5669449480189114, -1.8576732543644061, 0.3889698359793409, -1.3130118651200757, -3.552946429905568, -2.4553961076902975, -3.5638537384313937, -3.1779434427013737, -3.439908522753447, -3.0736685342251135, -3.0311686640629056, -3.0721823569188915, -3.3701287497166574, -3.5837031417911245, 0.381825654800696, 0.1416174989108192, -3.517236687755796, -3.3278021018043136, -0.731209315085171, -2.5784358013384967, -3.8458627682633986, -3.459690796341557, -3.375224641485258, -2.6173316030127998, -3.425345846820193, -3.499507696893333},
    {-3.3677033537457173, -2.0253659305191185, -3.6474325604728373, -3.295942811767176, -3.425923126790824, -3.2014684749225015, -0.551923690514265, -2.4645862473100157, -0.016535895075186706, -1.4906703894196722, -3.1299319431511843, -2.897446837492019, -2.906519148664391, -2.7316542492327267, -3.0414479511811274, -3.5837078476010364, -3.2403149476025077, -2.9461069117069085, -3.5498553868593605, -3.4397791152450115, 0.10063924252445226, -0.44520086694198435, -4.043270945791038, -3.403565804840183, -0.7654008672807173, -2.69068156927149, -3.778329313833626, -3.762033801173809, -3.1731283679164513, -3.03527876338419, -3.538125937722137, -3.590551010881801},
    {-3.1109489507280226, -1.6844656194337007, -3.590396191958331, -2.801207724437453, -3.676519542118604, -2.939207865606046, -0.3993767442519423, -2.1535022364144383, -0.05088345219598286, -0.7296605990559402, -3.524745067825912, -2.5095856403709607, -2.756608553561154, -2.4937885876551964, -2.9872391186268996, -3.155817488763867, -2.8647513397348314, -2.680268401321371, -3.4675836774823803, -3.8079015834917023, 0.8379179168216682, -0.7518702860143638, -3.8917697774101807, -3.4209645145003114, -0.7322998488631677, -2.188478158021848, -3.5440359185445116, -3.495195354881234, -3.310887480896261, -2.499854182052865, -3.2499695334300416, -3.5613938838445147},
    {-3.430123734285009, -1.7706823525501498, -3.927246508616312, -3.357890939872362, -3.8327987422658683, -3.0961858631720145, -1.4008278892550765, -2.194827473671017, -0.8720663371327543, -0.9598108462749858, -2.8425136390794745, -2.54478997446789, -2.5410064399597037, -1.8247651734787316, -2.2618302177453775, -3.63934508736567, -3.2893062235233854, -2.3738753734272064, -3.3622681360133093, -3.2781785784546233, 0.7071900184717943, -1.6156954430510928, -3.6459214086721237, -3.2556121779059417, -1.313134747136316, -2.125912331250128, -3.324541162643004, -3.8421552567904675, -2.84505445512108, -3.1228463144989753, -3.006707146761203, -3.3323241698276314},
    {-3.2545577727268498, -0.6998086451910782, -3.0446745768215555, -3.079293427166794, -3.24744547111946, -2.691530146257203, -0.7590062092909994, -1.3646000447261657, -0.12904121785028785, -0.18832465224924272, -2.446229147197208, -2.3841640939230695, -2.5826782728286606, -1.8463958902454183, -2.165190024191606, -3.5815198926423557, -3.16853099336659, -2.043447003847956, -3.1037630617526997, -2.680220524347965, 0.8351781559082352, -0.8668922873884232, -3.2782540849267305, -2.314177291997308, -0.5958914117889784, -1.5028307755627366, -2.312250294899264, -3.1341039362182164, -2.6226695123794133, -2.6437010734846913, -2.8031173973900723, -2.8363767125785935},
    {-2.873037391382872, -0.25453704286531015, -2.6649646181679154, -2.4745444318534524, -2.7111151724929297, -2.4443834706753447, -0.46881016153788707, -0.49928239608359976, 0.029223134062592634, 0.3454553250674524, -2.064006793854136, -2.0093140631024586, -2.076657996652471, -1.4770989778684547, -1.8080862671350642, -3.1498407827375567, -2.594049232530902, -1.5429491805349527, -2.542313726829034, -2.197273901070661, 1.310216464322188, 0.41007600123534893, -2.6525786557668067, -2.4004451440803667, 0.01123288560475434, -0.846423383327696, -2.193246094966156, -2.5618557682819674, -1.9744498377274877, -1.8996182550364948, -2.040296622630291, -2.4258943955096757},
    {-3.629535389840038, -1.8481324083781712, -3.381572367392511, -3.0699907088996836, -3.7552254771733447, -2.7906105662466536, -1.1842061981021021, -2.5151635750273496, -1.087383614291149, -1.3039674838086992, -2.607435072073115, -1.6717953091740334, -2.5307288549634284, -1.3373551708820155, -2.1245228302642976, -3.156693357487417, -3.277551811088848, -2.1682870207448777, -3.356023359946621, -3.0551345372907277, 0.15501318455687346, -1.4083592337450381, -3.862501881080943, -3.146134046206579, -1.6478248895627763, -2.3968385110826946, -2.7888387373204213, -2.925416945901072, -2.608725382977679, -2.8304237452637397, -2.564598799566903, -3.1428294926913596},
    {-3.7467277299757313, -2.3821269018640914, -3.8514082187023613, -3.5279965262525663, -3.743709152915742, -3.2461800236208367, -0.8939843270526022, -2.7279836643638795, -0.5086125700404891, -1.6896788193557086, -3.879954738508668, -2.4501400753675955, -3.37506896548742, -2.171155069274828, -3.049840411029259, -3.5751421207918144, -3.5562003362118695, -2.8759949281070796, -4.0228043530790965, -4.498861083365011, 0.5530312631675532, -0.9946999418683538, -4.252172240543131, -4.034770142504191, -1.585909609337345, -3.302827687464379, -3.7372836956335673, -3.887906704711712, -3.681264322144416, -3.2253317083667397, -3.8541239678128023, -3.990519028981399},
    {-3.633728535245693, -1.520221054786396, -3.515694861020633, -3.913590492500676, -3.0864079574114527, -3.55631641564572, 0.06008108514063864, -2.0265018918172615, -0.1146990781232249, -0.49896021997992096, -3.7780029214836675, -2.956204753233463, -3.0417538055695554, -2.4722391097722207, -2.874885270618247, -3.505207760756613, -3.776761161622216, -3.125649337440173, -3.716602197400997, -3.884002390724558, 0.8557938115170824, -0.17980449553666591, -3.8403543553361654, -3.8195432854088245, -0.7233897730110257, -2.5246859015671284, -4.02675832146379, -3.9054696503483024, -3.780409050507035, -3.2341725459090824, -3.758529751514514, -3.892886391244337},
    {-2.8428757439685093, 0.2275845552795524, -3.468345685318029, -3.1517259114060585, -3.0775195675200897, -3.033740434121547, 1.2261835084922357, -0.17728500756402832, 1.5000103730381433, 1.2131294912187156, -2.252391344895546, -2.739532747115763, -1.9120241238635085, -1.779712145215802, -2.1168156302814913, -3.118886610304868, -3.042518827663086, -1.6282295439855483, -3.1392239550761447, -2.7768027026300732, 3.123567625446379, 1.0486102579739032, -3.5799050474786682, -2.7219078098761744, 1.088006030411631, -0.8034005554603677, -3.1007541414749253, -3.3379304860695873, -2.4629473851376713, -2.686289855876738, -2.465816902500265, -2.552440496040403},
    {-2.653309292822805, -0.2845465246839517, -3.7986877841324502, -2.838261920563824, -4.066485644850533, -2.2259354084873775, 1.1400159597680914, -1.2163805558164222, 0.5936101364659249, 1.1316968126517668, -1.5881306465580645, -0.9407468257489141, -1.3867922184530195, 0.5959238326727828, -1.003510469170834, -2.9400312612756836, -2.3626098157562088, -1.0229054297778044, -3.0409549472563766, -2.391583974148398, 2.9562050139419043, -0.25544726472811313, -4.160917433753154, -2.553647361302045, -0.01982260603562735, -0.8005261306326269, -2.407687753222504, -3.0310630538372134, -2.197550806063025, -2.0634832474160714, -1.5437341213078937, -2.6711848438169636},
    {-3.4807478987712455, -2.124414689577008, -4.283127767683725, -3.542258235129637, -4.655299033107448, -3.068290355372631, -0.08356908584598502, -2.6855158149244316, -1.027330550846169, -0.8115482833599184, -3.0272570744503895, -1.7649771555679639, -2.315392797389106, -0.9284453406715326, -2.4082980520495063, -3.8029128622266626, -3.1321338134111754, -2.5499122735285464, -4.103814251501893, -3.5531246157468623, 1.7974176463472755, -1.6519130580629078, -4.669450129322648, -3.871401562681907, -1.5980215626692402, -2.7017685700394685, -3.2354313890761386, -3.789784149280215, -3.1799558680338444, -2.7918643709224784, -2.7760628520641344, -3.8046699718739236},
    {-3.728497357940411, -2.602498511298223, -3.8885186299734587, -3.904138766770899, -4.530447641607646, -3.1715880953935334, -0.6714149615583064, -2.8030669951113576, -0.7473266153224762, -1.4947547231805587, -3.9678014551021876, -2.826487019450535, -3.1165404218225445, -2.0610607691888787, -3.0288556565485836, -3.7388788782571516, -3.4008377398209455, -3.3352063808654835, -4.231542549544797, -4.19428177630217, 0.7688865751627879, -1.3535154505533844, -4.599925291243534, -4.281315906216458, -1.7581045840305802, -3.0879102007668946, -3.7684827641596725, -3.776066177433322, -3.744570171679899, -2.946740810520299, -3.7583208264095327, -4.310815559868036},
    {-2.8783543373537195, -1.5383329245729398, -3.877918539227793, -2.5640018149271167, -4.320126421977079, -2.21672633712706, 0.32579439904754676, -2.283704013220251, -0.9492245252625059, -0.38986066082202486, -2.3019920748339, -1.4589086245689409, -1.4510808731028872, 0.5616927941293925, -1.1873953697251762, -2.829334223076102, -2.0852885428284123, -1.9528150857071065, -3.5190161795757513, -2.9033406405180147, 1.4790737817406663, -1.4095437455905313, -4.54102731827346, -3.4793616508757963, -1.0136590062828745, -2.057341309837574, -2.3946216339181343, -2.9385088585605597, -2.245978021601137, -2.0599532974528016, -2.201752188364755, -3.383017371267579},
    {-2.9855744315179535, -1.757512832549222, -3.9042060322271466, -2.865198829870015, -4.235934275214189, -2.5660402749938984, 0.5538972148179675, -2.457502305565666, -0.6436233153267875, -0.43535966459594416, -2.9572700781963097, -1.6951187851579828, -1.2844581640228494, -0.38090967248979796, -2.0054008980117786, -3.2885092213478435, -2.6221107193743696, -2.2310201381162775, -3.9355420497055063, -3.573040807436295, 1.565443663823452, -0.8939079027583807, -4.336845095043677, -3.512033067083444, -0.9614233572532452, -2.2627693780913085, -3.3130746688913995, -3.180873248102088, -2.9140590930668915, -2.3217313730294857, -2.7954155487410643, -3.4562504849794187},
    {-3.303721313244387, -2.152976514968047, -4.213210576717591, -3.0915359560428577, -4.520553508347983, -3.372174095808102, 0.13332285517213618, -2.7030653237808027, -0.5937789928849474, -0.7186212623285676, -2.8294486814294624, -1.9764203953250783, -1.4375238868042859, -1.1227666858050025, -2.4608571158934276, -3.4258828378726016, -3.0011473499125585, -2.571340125881296, -3.869687383214664, -3.825972090808713, 1.7362305887296665, -1.3217198477421712, -4.547679974379213, -3.9050620872412174, -1.302572171441751, -2.6307073960846825, -3.402394267983499, -3.4679837257965644, -2.898794911074156, -2.7383568184468623, -2.9265246506226434, -3.488183752146202},
    {-3.3680614202831727, -1.659778914771599, -4.033392152860014, -3.2529567700235926, -4.438987125106922, -2.6739857945285608, -0.015834490372576462, -2.523507463780853, -0.903187680206236, -0.4323548362092493, -3.142252661495604, -1.7035954892196354, -1.1251459058778577, -0.8468244066328746, -2.101433499939214, -3.347049018871703, -2.886784953976333, -2.3528901357755605, -3.995888318245173, -3.5474411941125563, 1.233741796827111, -1.5104816259453762, -4.310268743833896, -3.602890171981534, -1.515548854911781, -2.582351760540232, -3.008968653250892, -3.566245242511084, -2.7024181937619707, -2.7267067945506365, -2.5651303914820387, -3.5354510701772566},
    {-2.9568449997746034, -1.4649656081638267, -3.9063935033855905, -2.8708305334381468, -4.461305730449695, -2.572921901020274, 0.42261195323427186, -2.0069796873023606, -0.6952607231843065, -0.05847324706141571, -2.4856605561522715, -1.1748127186164756, -0.827786516550154, -0.20382910685706665, -1.6203921152052176, -3.4119825763851845, -2.559393752926739, -1.7599082966141988, -3.5899143983860435, -3.230840774457981, 2.1708844581685893, -1.4692942081781437, -4.468410866391086, -3.402831184911603, -1.4398334365382572, -2.1128707370983473, -2.347548628502166, -3.3683101354712304, -2.3380985413161843, -2.3096807736169134, -1.9954515755363118, -3.0507504128074587},
    {-2.156611905100446, 1.4882434692727178, -0.8650718120357354, -2.026158027689728, -0.6604253724427926, -2.272503222045574, -2.436040544813027, 1.4908420327223038, -0.8244905733222813, 1.2287022087854624, 1.0486955595430423, -2.440540607072989, 1.0209220869103537, 0.15263728565496681, 1.6382562151584752, -2.42184371523593, -2.2901580629258858, 2.130483119632128, 1.133856544372421, 1.300309223468027, 1.328557452180722, -0.8054974913708308, 0.25006341985421465, 0.9390595152481936, 1.1323650423970515, 1.8333313275786147, 0.26203481078977775, -0.48161944367361914, 1.1207680757063674, -2.795998158900838, 0.8228636721777584, 1.006335095812389},
    {-2.3394392051926047, 2.079426018477398, -0.9666768006762073, -1.811054237485408, 0.12156060952603606, -2.222614906837103, -2.8804163320209026, 1.810478300182686, -0.43300065711275126, 2.1925401354893856, 1.3033017457345701, -2.362453485890358, 1.1685220364183107, 0.9120467751427154, 2.285227278290803, -2.452963739840143, -2.063465115956608, 2.142448329466247, 1.3423993340369407, 1.5605983640035455, 0.99154202105843, -0.842853738778951, 0.8981384104038077, 1.1978021812199113, 1.0755964593508356, 2.8353627119076577, 0.2769498112124849, -1.007274687189261, 1.048982218288787, -2.7361825251521137, 1.068462147143274, 1.3279548750171655},
    {-2.577819918941971, 2.2324398261271887, -1.93692252107753, -2.408773307347895, -1.0105030922147036, -2.154443008056557, -3.2296752674158085, 1.9809748823928846, -1.2388704433249256, 2.5655358911747963, 1.6600585699063577, -2.3309410603993688, 1.5824751400980903, 1.3622943286419102, 2.316188361762544, -3.108729201280564, -2.55351694629908, 2.682075523815047, 1.4197319934904522, 1.6286627889152774, 0.7530530932263794, -1.6909505005190546, 0.5097483959890234, 1.5417443600725114, 1.2614978357277193, 2.909348162229022, -0.1670926009708313, -1.5743010271102489, 1.0847426830842717, -3.1237435549127675, 1.5032562603169597, 1.6087991551384635},
    {-2.804862213719265, 2.4217398802630115, -1.4394151534007886, -2.284969803300663, -0.9995465467019049, -2.208423957340821, -3.2066030677200525, 1.9533643052141376, -0.7929878340449382, 2.57582197362058, 1.9142511218966254, -2.2453756802125673, 1.6408230893642612, 1.2947984592951054, 2.1806811629912612, -3.0415942852048246, -2.487909977514289, 2.5301637084812025, 1.5493820124955424, 1.5139462579617367, 0.8732109676443685, -0.8028907021360363, 1.2329339041838674, 1.2263491558312622, 1.4154903357377657, 3.113175589482948, 0.7943652281235144, -1.4465864368120551, 1.480655393645867, -2.8596925362129353, 1.4261456509471084, 1.6499045002134616},
    {-2.510065370604108, 2.23152157627605, -1.1528151597538603, -2.2058613504562445, -0.643557018451908, -2.1356251340093833, -2.9579008467648524, 1.8785983222096232, -0.5296937375794504, 2.3773901431118123, 1.0707796490404629, -2.256110488458205, 1.1329009383323065, 0.9102946057041632, 1.5828371751314716, -3.232288043083301, -2.4912989226544027, 2.2406116227102952, 1.459184369069926, 1.3752912075726003, 0.7433518768537757, -0.8911458508667334, 1.4692657251156764, 1.400594707403652, 1.5229116759301577, 2.752900301829681, 0.9873196035989152, -1.2141516122591134, 1.0314573856131148, -2.698257702831011, 0.9523450667367104, 1.798000902339601},
    {-2.445502890582845, 2.041928448852018, -0.9124800011653147, -1.8907220860287672, -0.7001206808387048, -2.1079720849053216, -3.311993306601805, 2.0068855103410503, -1.1940643341539443, 1.994652756771248, 1.3090758845218744, -2.4905371633997144, 1.6011058651620247, 1.1813048421802128, 1.8511424180841431, -2.723862304179132, -2.2814190647187753, 2.5524114395387314, 1.2056279602641773, 1.201271121878282, 0.5084900327327085, -1.245423784973575, 1.2278110228695633, 1.641469479739951, 1.4739988930450336, 2.323663008650574, 0.7332323293687236, -0.7736803034147353, 1.1292172161208265, -2.6986954246225223, 1.0120669208045763, 1.6119991432998126},
    {-2.2753385050858337, 1.743327468985512, -1.2287920021733205, -2.129847100588408, -0.7812397658191739, -2.689704575589932, -3.5121169591063865, 1.944564479293807, -1.0869878116290854, 2.143841276238261, 1.2281833099928876, -3.062981576548146, 1.619588401238152, 1.2045719749188835, 1.784288442369062, -3.2267925501545047, -2.287788958493064, 2.5556922792019248, 1.0527792616299019, 1.2867240516821399, 0.7124954694122656, -1.2061602600061574, 1.2953337474705722, 1.0724650249697942, 1.1288370914440744, 2.5322323510967455, 0.2850523479076554, -1.204929928705931, 1.0594748991096958, -2.940345752191438, 0.8647077742648984, 1.2407980375031598},
    {-2.4324283971017544, 2.097959326832759, -1.045132329561984, -2.0279692952102386, -0.26119290001157935, -2.210743853825331, -3.8775370381281435, 2.242386093138721, -1.042589480252181, 2.2322176667472236, 1.6792339086263033, -3.1472416231577176, 1.739809621717398, 1.3826252795876037, 2.2048406552441264, -3.162162390760525, -2.549965137840749, 2.9024105213615177, 1.3808316009901151, 1.7638037505404431, 0.45998698475621724, -1.2816884745172255, 1.3841436495900146, 1.5001469938729595, 1.4687088978503076, 2.216070767563113, 1.1023201970852554, -0.6915930818545005, 1.26550735915564, -3.0624578193371446, 1.591555702013872, 1.7498540987580224},
    {-2.8715329453064236, 2.2490959443508443, -1.2776300661640072, -2.358433736804188, 0.1086810404670115, -2.5726366987337848, -4.043634343463108, 1.845387955732035, -1.2618175543577645, 2.3809346970302, 1.7173384404494396, -3.3019643570332344, 1.6983178197989577, 1.4824476396396291, 2.3449778639107777, -3.369831620853993, -3.140694215602291, 2.7911617605679986, 1.072081112054146, 1.5339793550238545, 1.105120065153578, -1.3235505986048834, 0.8671912260626823, 1.184776482094623, 1.5642235854545683, 2.8110617278852494, 0.547853706900299, -1.0864608776240887, 1.3659988050051994, -3.4332740018040484, 1.7076747973221968, 1.2549897817068452},
    {-2.536220488415946, 2.1815647366350484, -1.1624490023005254, -2.4995342486917536, -0.9493906029456783, -2.745494964140068, -3.493180490280342, 2.0146896449599763, -1.0320754573267168, 2.4866834865152057, 2.0305732517116932, -2.887374820625196, 2.1983965597409068, 1.5001515605013696, 2.382862633883983, -2.914129220105613, -2.8668330918407263, 3.0435672719748443, 0.8648153819380435, 1.777772194017387, 1.1595349760271052, -1.1550585206640078, 0.8542872814657231, 1.2035430438719417, 1.8300807247470103, 2.964429962979895, 0.26129816601677874, -0.856674007037521, 1.3358274042202676, -2.9987531681753232, 1.7721535359386025, 1.6255871528846364},
    {-1.9895014224420076, 2.1787820003347216, -0.8218360460482532, -1.851313974249735, -0.2780833231286165, -2.221373644900931, -3.3352394031840125, 2.2509138111761584, -0.7293216230973246, 2.6586774198230003, 1.683642898390095, -2.52882289873325, 1.70862495612537, 1.3653145550208634, 1.970216295430702, -2.885225341187945, -2.3232149571395064, 3.074745719944455, 1.010825660013815, 1.8908111804505336, 1.1583717694833346, -0.8734545807834911, 0.9566596714497102, 1.3378779405638954, 1.4932478306807122, 2.9228544507125087, 0.4088956353946487, -0.7566429577042735, 1.4655222454357724, -2.870778104179706, 1.6181621244499516, 1.584350821264307},
    {-2.5964589365478363, 2.5276608163053225, -1.1685540364483427, -2.52774881442368, -0.3506320196858575, -2.2991157385440055, -3.2286191334115943, 2.2399983483761265, -1.1202687853003368, 2.5290015985733336, 1.8085289842781862, -3.2521590946830243, 1.9926993076003279, 1.779979285843217, 2.2070615750031206, -2.8789562698615248, -3.067419007740075, 3.0942707586711906, 1.8899599525013324, 1.9762111022907645, 1.391170843974371, -0.7495583478121224, 1.344719797562783, 2.0777924363887306, 1.869755672365608, 2.8141498106814846, 0.33720738432461456, -0.8142381954436204, 1.6848981520712525, -3.3321617494818225, 1.6682024567410862, 1.8412333284604965},
    {-2.8886448143460335, 2.3483198370816987, -1.4988468431475737, -2.7604547407857276, -0.35783482751814927, -2.501331682121062, -3.8889575237848515, 2.251863653919646, -1.1351529323294853, 2.780655098465629, 1.8367975663766711, -3.048195249462555, 2.200483699614381, 1.8053494824737757, 2.362145784154974, -2.9880056034292855, -3.1046036629649936, 2.902860433504334, 1.4868015479695658, 1.8592362141045409, 1.1401306801718987, -1.2750138914981184, 1.1331681857737754, 2.0274440871912724, 1.898100261224505, 2.9673381269443846, 0.43174216349241734, -1.002191628826459, 1.8374486723768644, -3.663258840811125, 1.989538649811979, 2.0272821649887582},
    {-3.0170093460134204, 2.431896533543229, -1.4079009592804423, -2.7624341915034454, -0.19982507839530925, -2.5251748169439843, -3.752391786625944, 2.4033860117791663, -0.9476522568617851, 2.439082479380503, 1.9742126838344418, -2.681381495856508, 1.9512044115758682, 1.4891272102912403, 2.511273234819409, -3.140830424392065, -2.8435837024547923, 3.1072273894554394, 1.2811464450353245, 2.0804870580677868, 0.8218699392116041, -1.2676819796944165, 1.2083371784877948, 1.9224938898424007, 1.7769553180748288, 2.9944208929667147, 0.6675921851823831, -1.425749499850722, 2.2227975822183152, -3.363647645368791, 1.8049260863212866, 1.9495282728724748},
    {-2.5708155722793338, 2.329365286211919, -1.6701758501640123, -2.360255586300575, -0.23138832313580746, -2.3235811331213876, -3.4884990644491807, 2.4037087857869572, -1.2258908574669458, 2.2758557723172994, 1.9238106568302464, -2.46130009953435, 1.8406286989725162, 1.940637115441228, 2.428258586337577, -2.995073893747564, -2.612463046886151, 3.0599463793759, 1.5875225398628268, 1.666338651519995, 0.4667615486609735, -1.4355240975517083, 0.5271218772269751, 1.926161097216722, 1.6663144038340725, 2.7495328201172295, 0.9259582779885221, -1.048459586446294, 1.991218827078481, -3.072632865222438, 2.073881251157973, 1.7007305644783661},
    {-2.784281106927487, 2.613425761946412, -1.746279707713106, -2.7643064843755525, -0.5335530192065923, -2.7144888492687214, -3.381984914085433, 2.299136597230098, -0.9453967537654554, 2.666421140995697, 2.0975902554211636, -3.207674865143996, 1.8524315376787506, 1.2543289266023165, 2.380545161431413, -2.9282358269580233, -3.1417402859218253, 2.847114741969699, 1.4698622924208842, 1.87702276239379, 1.1312185963293835, -1.5255346120660094, 1.3962328055311264, 2.3355717173029507, 1.8377381191093611, 2.971027438424045, 0.6263089718526119, -1.6911489369207962, 1.7402566705483666, -3.301517680781202, 1.9618899153589453, 1.7301860891378142},
    {-2.8690106107883833, 3.005863095840109, -1.6240014287394113, -2.4455913025380274, -0.09053199265069907, -2.7376141968611534, -3.0750690632940354, 2.649913679321883, -0.4376582222408803, 2.9968167945569846, 2.4616853260318754, -3.1102364532193105, 2.036798117363932, 1.3529842442681446, 2.721755604720604, -3.1981091794981693, -2.9404845550744643, 3.131619113794708, 1.897786347077855, 1.832156367024875, 1.2744845769691993, -1.189124952149635, 1.75957286223922, 2.3997338012898304, 2.2398947133548344, 3.077972720703155, 0.32892792287388267, -0.9369475089280581, 1.8322856747457075, -3.6055948322437605, 2.09198507002637, 1.8843909586453336},
    {-3.1695145388625163, 2.6253923716523855, -1.8043567231783133, -2.792377323548366, -0.6156118873116888, -2.932037951852281, -3.548455131695948, 2.555626828347388, -1.0729484961041087, 3.056305483491342, 2.2441009309218094, -3.272325308156653, 1.948927151777596, 1.7178032777367032, 2.7119792790104813, -3.4342108719399644, -3.1692222525276104, 3.0575688947878974, 1.9753459099636812, 1.8679819303062937, 1.117250059525375, -1.8547374202532625, 1.4963881453680858, 2.297953110655812, 1.5586554226609974, 3.2292887884603876, 0.26215265918295105, -1.4814822173503404, 2.0565469854139655, -3.6264972003929667, 2.1818714061588387, 2.5100418505827258},
    {-2.920984145649896, 2.6285427365997234, -2.042018801399256, -2.6110110688977257, -0.954812995536341, -2.5670364162365016, -3.7389362065489893, 2.1501169535295253, -1.2662930840593913, 2.767806259210921, 1.9557001156610403, -2.9169723582273974, 2.085380548539583, 1.4694884908206414, 2.7793703432133103, -3.2071594431338597, -2.856780098095613, 3.4439418057370164, 1.4773961006031897, 1.7509508855096478, 0.7570480478303508, -1.3877153668480842, 1.7707797717543121, 2.266246928400146, 1.849907161730662, 3.1205424422355765, 0.24505152267025637, -1.516175346074909, 1.871245422070191, -3.4404557098980275, 2.317182928182936, 1.9386117007538777},
    {-2.7875933912258244, 2.939907598470587, -1.7100283314415499, -2.515999993868147, -0.48351738980364306, -2.4392375560373196, -3.817464815198886, 2.7548435142974337, -0.8523019696626036, 3.277116360156561, 2.5064883574034242, -3.154936110476402, 2.3635227716190066, 2.446077043150971, 3.101132839265993, -3.434393789669662, -2.6596294146148294, 3.3705591720167813, 1.8436653059518133, 2.3269331704062575, 1.6128219437013978, -1.218114137332334, 1.832820123354985, 2.5363126044055755, 2.1633485554619343, 3.2745511240581107, 0.5954232149448465, -0.7114815749210711, 1.9206449576681264, -3.216471827482489, 2.3328353461548903, 2.0907954695648776},
    {-2.6446367045195203, 2.6728391748431397, -1.6329517299167533, -2.643318568238251, -0.2227840994913158, -2.7480397900304574, -3.8667810730519045, 2.8370454678621204, -1.3180121297556653, 2.8541361524941697, 2.2140337955441867, -3.1625213409439663, 2.053224334304714, 1.8385380611454658, 2.753669607364751, -3.0692458648347283, -2.9649532701007835, 3.4145639161470838, 1.466877227986475, 1.8420968102430613, 1.059078114570633, -1.1338723684414724, 1.7594790976618968, 2.3297342804173646, 2.094495233458486, 3.2609193092543944, 0.6540229919289247, -1.3044444153908665, 2.448337257265841, -3.6981121121176064, 2.18252779642435, 1.951499128131437},
    {-3.0186791028497977, 3.1663598815288054, -1.7581038732835201, -3.010687827705695, 0.4346097099846674, -3.105996933011331, -4.049402768384292, 2.856208451515726, -0.9151028075585288, 2.9214647299005483, 2.8869825021949036, -2.7571076602000844, 2.683915173037779, 2.099262444350619, 2.8934969875952077, -3.453212134842179, -3.419972151786006, 3.7061621492788337, 2.0661198072763525, 2.189270417017679, 1.0633043138334188, -1.2964987110263515, 1.9094550321702226, 2.7555534256790777, 2.269622990847742, 3.411390786016915, 0.30511543025549026, -1.3730218129755183, 2.5068618607852065, -3.540875445468496, 2.673111035999547, 2.627335207200588},
    {-3.203932107585819, 2.559364601168117, -2.0306252802096085, -2.8393149278355314, -0.23736067541027786, -2.8045698440477467, -4.0306802247606495, 2.7695500708384073, -0.897453731674718, 2.8271071120256344, 2.6819594969570506, -3.3192044727440217, 2.5520015435387045, 1.8553948781587355, 2.7905268362812947, -3.3609751513624304, -3.115092336919908, 3.434731288122952, 2.154451395166342, 2.1635028637416194, 0.8924971996735761, -1.4685048633663345, 1.2997538726631004, 2.6477162139987755, 1.9625443281629715, 3.4127176694736368, 0.47269558273742457, -1.283949692144785, 2.5281423700488443, -3.8189559869426697, 2.68736024575802, 2.6422870303873616},
    {-3.364244327955949, 2.7977037185396485, -2.209103969081439, -3.133659480779719, -0.3731864296523669, -3.0227953084883548, -4.277417223191064, 2.8149710062791327, -1.155723901739588, 2.876064949230272, 2.5046769929815125, -3.5713272568672125, 2.073016361901369, 1.8660914241535358, 3.1618409275933352, -3.2828884676352152, -3.3071902423317243, 3.6515357397162655, 2.2810833115955544, 2.544845396401102, 1.0773607565804106, -1.4868396429485164, 1.8306159771566226, 2.7799610128924064, 2.0696150957024804, 3.379611672942089, 0.24735823357069212, -2.1255750063460783, 2.1321825714502953, -3.6188278227201933, 2.6144499105235863, 2.546500670555695},
    {-3.215644965166146, 2.8496113495432622, -1.7084263533443524, -3.445332360235923, -0.5168046177966757, -3.3090449128217316, -4.028884429853843, 2.686177624472725, -0.9597731489677452, 2.9826005214920657, 2.2552288245563554, -3.208968876677972, 2.327752912746745, 1.979598719789581, 2.863502403786506, -3.4635351111023023, -3.336925695510766, 3.453311039695071, 2.0464563248774743, 2.3544635973771197, 1.1950854621081852, -0.9884925091533985, 1.4519245499266473, 2.467049357169896, 1.8157465918769728, 3.4945942133265286, 0.12837470669720027, -1.7708503093902137, 2.025639881621477, -3.8092694103515576, 1.850777771410417, 2.2786149916726606},
    {-3.467538809138851, 2.8125164288663633, -2.3677007353562, -3.396587053641628, -0.6929086176527832, -3.5251563404183024, -4.168429609425876, 2.8090398728591612, -1.2103767883489203, 3.042066896842591, 2.267952758127148, -3.445737527412703, 2.5494150776742086, 1.661492145494411, 3.1378007724837254, -3.938073087061792, -3.7674711018366116, 3.5434319637394234, 1.9310679360604823, 2.423752266852074, 1.4903075172325255, -1.1976575272080143, 1.6850000895244055, 2.870392872427015, 2.13774918152037, 3.4387320723141297, -0.30168646053757886, -2.0803890392521964, 2.352482715790075, -3.901373350512464, 2.7376151157924253, 2.3736984716953216},
    {-3.2360340675035584, 2.82729192901075, -2.268344287985726, -3.595579217035144, -0.3465494185484043, -3.110939688574806, -4.1683641151581154, 2.8451956622009638, -1.1054271416988224, 3.1573059362233282, 2.614830117360819, -3.3240444755477796, 2.6243089879789143, 1.8149705333881105, 3.2990141101074766, -3.464881134022427, -3.540390051394679, 3.5384876458900782, 1.8850612827602886, 2.4097534488872454, 1.355842316768458, -1.3680829551800546, 1.73905132304842, 2.8348911581449605, 1.9148397740957817, 3.128922359197749, 0.0004898966012383927, -2.1168193756516214, 2.335821457226206, -3.6961816387662165, 2.599257245358283, 2.532686831016512},
    {-3.170092329349778, 2.9178571404322757, -2.7090469290482853, -3.293293482903425, -0.6012910827482378, -2.706041676693354, -3.800880803438089, 2.4624640978289007, -1.2238757737191295, 2.9959681556066493, 2.331959596322017, -2.980969097662603, 2.120315307236895, 1.8519259656657827, 2.724691152864285, -3.2032066411906612, -3.226281377627137, 3.3141685040983146, 1.6377052690730385, 1.8474029661275118, 1.1756539540266677, -1.2658717125598526, 1.1586760333624537, 2.1960690963864424, 1.7611417033540435, 3.2143755653955868, -0.20491953143357136, -1.957040912329654, 2.0710417503489458, -3.7162121308934983, 2.074198594350578, 1.893103424700462},
    {-3.304689468226189, 2.907119659696138, -2.511413710528555, -3.305088463692275, -0.4151798087885815, -3.2685462625893384, -3.9145678333324407, 2.551024046510822, -0.7220371746579972, 3.0581579109888866, 2.331733654461764, -3.4630913966001384, 2.2419250743170296, 1.596815673315254, 2.8628239225973253, -3.4477630870479126, -3.650864624359829, 3.5021525716609627, 1.6662002102687803, 1.530544887443658, 1.5277329492576055, -0.9854853220946695, 1.2649891097768744, 2.414090181951805, 1.8799541468066328, 3.751897083899526, -0.04584790232103347, -2.205755142239716, 2.4271459428889166, -4.0462088687134035, 2.2638367238442307, 2.0828264323070997},
    {-3.6026520424213504, 3.034299161675072, -2.5430685038109098, -3.577035601449267, -0.9472337551240796, -3.6906219098795443, -4.378602171109491, 2.7668179656987832, -1.0442796841446698, 3.0238115376810333, 2.389525002487506, -3.8204699158829363, 2.187871264312652, 1.478849162210957, 2.7661852404676637, -3.7080075824576166, -3.6330558051950756, 3.5302311218365436, 1.9627236966502566, 2.231883000483622, 1.3253997962594928, -1.180932763270268, 1.3510473316375706, 2.320826139934827, 2.149829529906636, 3.4874548518613393, 0.09933500289087578, -2.0867558553773957, 2.203984595937867, -4.044871117749424, 2.395575420003635, 2.44030451671477},
    {0.7377387178113569, -2.307943233749442, -0.9781712298112176, 0.7532356346450192, -1.8793411649252734, 0.839494058839434, 1.111177262268064, -2.7272711558646567, -1.6601534471922128, -1.4842228313281758, -0.9737268215832836, 1.4114664129388756, 1.2232968920722054, 1.7832249442848624, 0.3723705102785503, 0.6028474617261493, 1.5543450137031105, -1.0593398783639003, -1.709154886839917, -1.2848265529551592, -1.6164755924349707, -1.8686004169453923, -2.5125185736963855, -2.2374778006923344, -2.4583848633945093, -2.1568532826857676, 0.656699349779886, -0.22012708366543007, -0.30253486546315744, 1.227462637148804, -0.0628910851277938, -1.4872323052909788},
    {-1.099137166910158, 0.4319249386974101, -0.9053143824946857, -0.8731404338282853, -0.26698489407030385, -0.14645042588075524, -0.17520071191154205, 0.21157642173763133, 0.44346422790213286, 0.38045973596562005, -0.5945823766779992, -0.22520755425165154, -0.5902392914604264, 0.8991661448806141, 0.5169021822910734, -0.6210563616162498, -0.5225070584587076, 0.39938899357900304, -0.23234598116751257, -0.2954811651069299, 0.6108092444709907, 0.2613710859750574, -0.9699021293219521, -0.08058396456760474, 0.4434218986615724, 0.4538286645074282, -0.38366936308599026, -0.27302457062443863, -0.6124094143841787, -0.6822840925976768, 0.1887455405367573, -0.24304762227857393},
    {-1.494226351980045, -1.979156358981157, -2.3746164415180893, -1.4870521747157341, -2.253984905585431, -1.406556478259649, 0.7006178767370169, -2.209107537344894, -0.6739562231862383, -1.4597275261930296, -2.4963878039934655, -0.5379723827665507, -1.4176226387499313, -0.6244241019227712, -2.0109916414135705, -1.6131218427663736, -0.9799567584976381, -2.0189319130182124, -3.298581813743945, -2.9575802179008233, 0.45764192994080316, -1.2564860882842859, -2.6648507449776293, -2.6244325339080725, -1.7774814809956454, -2.432757169624253, -2.3786600993990348, -1.9557935530383193, -2.6037108368603366, -0.750188411985581, -2.4233776499959783, -3.1111910657269495},
    {-1.7654195244834592, -1.3358510227422413, -2.0672110717652306, -1.5031056713760291, -2.5545132825317145, -1.3528202897906936, -0.28241361964359074, -1.645563562786375, -1.3790333967260446, -0.4749884908342785, -2.70639762510202, -0.7333873354240213, -1.5972804351167589, -0.3405028028857499, -1.357682258794849, -2.030272346519912, -1.114461305879509, -1.5576821847227806, -2.001124682635929, -2.166871275242033, -0.0859380719585, -1.3927941005750242, -2.0177141598349935, -1.9653469230639566, -1.1843451032070949, -1.4915552284596667, -1.3543061889276395, -1.937204123269122, -2.175323151707144, -0.8955083174833768, -1.7167142143332805, -2.254749257512063},
    {-2.68472042460454, 0.0561063847882216, -2.300074996152194, -2.491922372973479, -1.902650871569898, -2.2467853342351916, -0.29897063544499736, -0.37414713758020524, 0.20046345099886073, 0.2945544967795045, -2.105939343025307, -1.3775566960252004, -2.1256605220016715, -1.1841099234270842, -2.011205679329105, -2.5944652388948795, -2.567443653220683, -1.1687645469601975, -2.0153963228091767, -2.2594244672369057, 0.9581387470174019, 0.17272390121404818, -2.1318129974829767, -1.7029028563656075, 0.5411903991751316, -0.6526959390589271, -2.203213927007406, -2.5371798304146096, -1.8590763026421977, -2.032032655531162, -1.9535814475594386, -2.0312845259593177},
    {-1.8577833919968374, -0.5136811255392294, -1.588287165971345, -1.6812656019592538, -1.5518553378032849, -1.972097002602621, -0.31395398653086903, -0.7017835066205246, 0.19469060517631498, -0.21500190685901202, -1.7857437360616628, -1.4768866355632215, -2.1145953679190463, -1.513221150001748, -1.7529534316420032, -2.779811467442851, -1.9182222162766596, -1.0661284533330946, -2.3116952246937523, -2.013326630019823, 0.9925680455046386, -0.05840209988880877, -1.9610895042808594, -1.7002475404801032, -0.4541595170865585, -0.8535264938131778, -1.7136553601184419, -1.7672698844712242, -2.2278302610820973, -1.5197925127585141, -1.883756218199509, -2.2166347820803485},
    {-1.909320704471829, -1.132275167392689, -2.233048529443568, -2.2618478290827984, -2.600691174352372, -1.5500660427294795, -0.24113494568668967, -1.3826619893508358, 0.08958251880381027, -0.4043308101284634, -2.2644052896124465, -1.478253590035228, -1.8370096133062894, -1.986855308045432, -2.1608093887950544, -2.332007030057837, -1.9718832383295246, -1.93563151135245, -2.471698482626778, -2.3226838251186237, 0.7259467671674315, -0.12368184928682445, -2.212199508698057, -2.0418817129425335, -0.6673424961425498, -1.1333388624045355, -1.924781803455928, -1.7852129733519801, -2.1265229477659133, -1.9657329941206965, -1.8823138653382034, -2.2620759631693272},
    {-1.8338672056397802, -0.7595257440641145, -2.1794247893892402, -1.7056972188022077, -2.119406412788031, -1.3269694979917566, -0.333079326443203, -0.9341827769007027, 0.2541281304747718, -0.22752385280865603, -2.1307998457086725, -1.0513706614709304, -1.9560926230222018, -1.822506719640034, -1.5148520432270471, -1.9847608670301324, -1.882232198507347, -1.6283503383211158, -2.337542107767184, -1.8556368155313108, 0.6790737161626245, -0.04713780138800755, -2.031476682707537, -1.8354554682946742, -0.3004649389145942, -0.8514512202572, -1.4109677227220594, -1.8786809121425947, -1.6500324003079998, -1.371217544916741, -1.8212802410939959, -1.9911804602616607},
    {-1.9454747650005682, -0.3607070826556406, -2.5503147617655477, -2.017134130923667, -2.121568916351617, -1.9021704416003178, -0.02828406171981853, -1.3111035397369581, 0.21121163263437367, -0.5977812732289949, -2.2780931695948023, -0.8920590789464642, -2.3658938512581664, -1.8493441060327005, -1.6762293651381344, -1.8321613033133222, -1.8854941099681375, -1.865735084352517, -2.179381646796789, -2.3981181753256107, 1.1298598013257082, 0.35850212341988025, -2.2195768827480067, -2.4540370014397377, -0.22331161434978716, -1.3878000026515291, -2.505088768306577, -1.9994435065639153, -1.8986251399814333, -1.7333082889990323, -2.3842156178423193, -2.0099056603245513},
    {-1.5419544096616231, -1.1514981518794785, -2.2281189565919983, -1.8680681616901549, -2.400689977735875, -2.0516108392917687, 1.031171995654226, -1.6537608267439137, 0.20012743589772272, -0.4449617140956661, -2.443158016650418, -1.0504184959861018, -2.2416530292607963, -1.8809871828430744, -2.327083636769508, -1.743972533542714, -2.0496284328945626, -2.186732762225071, -2.341425264212217, -2.6718394408665658, 1.4436272850690444, 0.04839303552026396, -2.604989419744179, -2.6534280475894665, -0.4025377022041038, -1.6819886062140554, -2.3916350281301155, -2.4382841358289866, -2.2102598159608937, -1.4214956426253915, -2.075743047617449, -2.574437318802008},
    {-0.8999691034340304, -1.389214534134164, -1.376969360544266, -1.1845125462294983, -1.7069068748350458, -1.1824767464816646, 0.2594538035063147, -1.6966123845672083, -0.26046551915472266, -1.223766060253435, -1.6979047643120073, -0.5836048979560682, -0.9924835982036053, -0.9045338152474375, -1.014502391684701, -1.3067240209149853, -0.9731143800696126, -1.7977377111412236, -1.7592995679052328, -1.9200114917744786, 0.5201645504277955, -0.6005433562739714, -1.6320032235274877, -2.108413843599394, -0.7968583257597232, -1.678972235555331, -1.4536501926635264, -1.4451450353222173, -1.3990390946610942, -0.7169024118084896, -1.29473135680329, -1.934947896934019},
    {-1.9736891916059582, -1.4189371662737935, -2.536594922421177, -2.0650040901112408, -2.743452157390782, -1.695981153520754, -0.16145595872666874, -1.9942877477841319, -0.4543885072979326, -1.537049273623817, -2.4023201047664413, -1.0793018828167793, -1.7159621931581794, -1.52646171058891, -2.0339533719558336, -2.0580879406004966, -1.796632610277572, -2.3967227246980864, -2.463285303550586, -2.568882944457599, 1.074408327471043, -0.7237109684654354, -2.6311160396586395, -2.77127856985018, -1.1501946763375857, -1.9799334124028236, -2.101943654656785, -2.3153498899585023, -2.022619235591, -1.4169940184365695, -2.1589151127212722, -2.405958969727543},
    {-1.7883147920054845, -1.591352291063001, -2.147904129908085, -1.6755271737379134, -2.162747955679212, -1.5971708065737689, 0.2847000388197868, -1.9579760053101913, 0.08410242035351133, -0.7586491412980726, -2.2142247125195005, -1.0609248373561015, -1.7683497008835503, -1.1868128213813451, -2.1046516834713724, -1.977262711292452, -1.6373387926692107, -1.833292188738005, -2.095291818381269, -2.732482582308841, 1.1652745616501259, -0.16161566210964448, -2.355232423411376, -2.5027764593993407, -0.8424694325240728, -1.8460009894293405, -2.149312439833238, -2.246242866739443, -2.1480143252827752, -1.486594324439279, -2.0567849019384328, -2.552190573432112},
    {-2.316691216047439, -1.4199719441331526, -2.5723365480752, -2.017123362882644, -2.334953185832912, -1.3875897439366194, -0.2409245558620413, -1.909367970142813, -0.20993525729366821, -0.9871421933348898, -1.564012479093607, -0.6118840122906849, -1.196674652412481, -0.3509079493767997, -1.6690264078456163, -2.187156117198632, -2.064545333783165, -1.9070042623880608, -2.404807408074471, -2.4968607988931026, 0.9612236563800014, -0.539002493668223, -2.884773039628621, -2.395157204928997, -0.7528877975321722, -1.9521384272392046, -2.0555049080688295, -2.7929131850538456, -1.6606254541540313, -1.7988005921559695, -1.45164942633752, -2.334382564976293},
    {-1.5149549466061654, -1.1176242397054343, -2.8036994829518465, -1.4786753627913856, -2.770350590185451, -1.4807199907886945, 0.4205458624814534, -1.7640702995010724, 0.11413900627357948, -0.6269435838489245, -1.9213516860591713, -0.32208813411155923, -1.4528756767676105, -0.5323670183659521, -1.6372764279246093, -1.4345574825032386, -1.2214943956933497, -1.6293246589649006, -3.0524194858817584, -2.8171613833221127, 1.3620468814775282, -0.7227301894649595, -2.9674171141246517, -2.553554235732529, -0.9677076361790823, -1.5785937263696015, -2.232636249700272, -2.1499171984884367, -2.2264387332960203, -1.2550748495608013, -2.0571720261731, -2.643422278604148},
    {-2.6472559982565524, -1.1731126205317355, -3.0903488590678645, -2.310170726239309, -3.306433675451251, -2.310991703990616, -0.6599635379118228, -1.6107247059760783, -0.6127315203382242, -0.5792242442031105, -2.203596382768769, -0.9045238636853618, -1.1538385885999332, -0.6966398250145801, -1.1878772115980236, -2.5798219401096922, -2.213572922008453, -1.1712784014870075, -2.9283642669438614, -2.392319148025531, 1.0205743811911898, -1.7528527347626015, -2.9764687754553356, -2.583190431451592, -0.6828376905397584, -1.353761780817057, -2.2839156505431504, -2.9918295390381693, -2.1943244511622786, -2.1458720524031576, -1.463112776888191, -2.482522829668961},
    {-2.269443299390504, -0.6793313746876035, -3.017580475195515, -2.301065853029236, -3.329508032934907, -1.4643466619099508, 0.03924141280830219, -1.5072914154855468, -0.7500313540707887, -0.3534452681176942, -1.4189358322512728, -0.7503219984381246, -1.8167902305319865, -0.04133792279843768, -1.0163877851751595, -2.826946967303303, -2.087190139489997, -1.4859547015807033, -2.765615966318538, -2.0463931216253934, 1.2531136496118513, -1.3943797082304787, -2.952413471236094, -2.2024362852176904, -0.8650526784912489, -1.6025569916848488, -1.3960982490258365, -2.3001365389774677, -1.93736476238961, -1.5326631612884376, -1.5271521290435477, -2.4945430063265275},
    {-2.3710656210892216, -0.8282564617828049, -2.8363882898836015, -2.1584901999052857, -3.482775477912223, -1.9006722395008926, 0.13901759926642762, -1.0303897208074406, -0.741557793534052, 0.28387225016857015, -1.2632992659494326, -0.4681549654660627, -1.1871631678149637, 0.41337324494844374, -1.1813242296622026, -2.702588943948318, -1.9000349420134592, -1.2381968335808287, -2.7508320510458995, -2.260199667020036, 2.164498721831411, -1.1212480916023981, -3.018905658346735, -2.3497652789563257, -0.7982806886886115, -1.072985543375212, -1.132946502430233, -2.588945730957225, -1.7420251525196464, -1.6234274911337816, -1.1627598451809906, -2.2838166414055374},
    {-2.2063821925018208, -1.5323471491350804, -3.063982960270959, -1.9119470615834158, -3.2846539108767874, -1.727468051996519, -0.3190347779860232, -1.8952256045969662, -1.28018655244608, -0.7731129372860036, -1.6167674163963799, -0.5343760670423963, -1.3811441581664459, 0.481049056964636, -1.0950958670633584, -2.2430291973422407, -1.717463588152357, -1.4134108901005331, -2.5511735976576335, -2.1883856989370183, 1.2307783327105466, -1.7639588116420017, -3.4167264374471524, -2.25182850877306, -1.5183763567587905, -1.6461654830490289, -1.5694395724956947, -2.1601305475510975, -1.8304813658570067, -1.6815731104944784, -1.5008219301640524, -1.989696605263139},
    {-2.7734335287762026, -2.266769436900613, -3.633004819279084, -2.9759621255837465, -3.50742132147196, -2.39849818813922, -0.836434820084282, -2.6117685554836405, -1.2182259331064755, -1.5896699173095357, -2.6045844876461652, -1.1999887956556998, -2.1855689676541354, -0.41797647522003506, -2.0455616743792264, -3.107764331809119, -2.496028474369036, -2.000397268691017, -3.4911330962902523, -3.075762434580174, 0.8451325425904644, -1.7743458574021007, -3.9333173711179623, -3.333700488529488, -1.8110601334964163, -2.648608589585128, -2.3753131357150825, -2.850009358282081, -3.0894647443786196, -2.1801653995726085, -2.36680183164983, -3.1720059097119315},
    {-2.630705169209697, -1.8983049908480527, -3.589097817657837, -2.9269462757857347, -3.7101132260692524, -2.310535398847752, 0.21722276503966165, -2.2651079302762516, -1.2159288337754321, -0.29594514973612274, -2.492378787021187, -0.9439456041175753, -1.3799670422350725, 0.11700134804415306, -1.2938055231071093, -2.9142695476596323, -2.2228753156353815, -1.6730759008094953, -3.7867874517581854, -3.122045217022199, 1.5889062792855293, -1.8782238492977132, -3.697162350634303, -3.2932368938999015, -1.1104728326496673, -2.221963113418175, -2.5288952737418375, -2.880177716141874, -2.998912017667367, -2.1451491986985993, -2.266281755320669, -3.3610394942519606},
    {-2.4171047030362223, -1.2508528690287917, -4.212752842051516, -2.257092107968963, -4.718864245043799, -1.7503935742447565, 0.24656129332626933, -2.2446880367880584, -1.8477302501479664, -0.11475301747002888, -1.792378303384281, -0.33115088068101717, -1.1829885756352567, 1.5638628353183994, -1.1990680111958893, -2.9798310718981793, -2.12523451408152, -1.1658145790389067, -3.3453159972824738, -2.607727452399738, 2.331079872101922, -2.5424559293690105, -4.645400500804149, -3.3946939337071895, -1.572569745398801, -1.835512244225958, -2.039408230316583, -3.471829638251526, -2.1306371884322126, -1.6195163659834464, -1.6925978898364462, -3.043734739329299},
    {-1.136150290413187, -1.7121586126955952, -4.083301449956847, -1.4834456507066907, -4.9479454212195515, -0.565145600540149, 1.3378670021978538, -2.348439500558384, -2.121891906632521, 0.19329249678910884, -0.8607875244876769, 1.3754347732279524, 0.17386464903956322, 2.644305845647262, 0.45434643387043183, -1.8017105246465397, -0.6923127120813968, -0.4591729614877082, -3.0314018260901974, -2.2407691305591917, 2.5102918086584385, -3.317636561161562, -4.681302123751381, -2.8571212819542486, -2.118000079128857, -1.3323982305753954, -1.033326474490356, -2.633911182072843, -0.9248954923536088, -0.6972210917084385, -0.5825860591167401, -2.420180915118167},
    {-1.973060425818505, -2.3227675916310275, -4.218470370931703, -1.603389537137789, -4.736798528054706, -1.277478176946246, 0.7154517867967938, -2.8981369210976147, -2.158549002320301, -1.104248610093021, -2.162302279552265, 0.2611475862550306, -0.7688436065766189, 1.8802105322040095, -0.8403289182913942, -2.3150692016983365, -1.5615699329737731, -1.4890897776728176, -3.6566761273015986, -2.7000708576434547, 1.7880190863337626, -3.3889304488734115, -4.445965567669714, -3.4831897898614828, -2.4788563906328114, -2.277967386067746, -1.2959421090378571, -2.968534855068943, -2.0621036430978914, -1.1455636164761513, -1.2647210959423392, -3.170249158582203},
    {-2.852972560069127, -2.5859173573013754, -3.997441390005099, -2.8438457135964508, -4.40706936073587, -2.485897262516928, -0.4697507113458247, -3.270831847250923, -2.252733644926065, -1.579431184085592, -2.9874993583410006, -1.0045000400028699, -1.4114711657937493, 0.07761983510612604, -1.6640298620101048, -3.093142358588304, -2.5990948000870273, -2.0433075961637077, -3.6545183824634524, -3.47240094621604, 1.1613235184029547, -2.81027550713901, -4.504097112683181, -3.6302398754810783, -2.5358048365792945, -2.9261870175702938, -2.355523575447758, -3.210625971107102, -2.6859293600117193, -2.436276353456761, -2.3900835196186745, -3.8796862837656585},
    {-1.786183639433509, -1.7655181690265132, -3.975222270851025, -1.546716592124524, -4.70322363374158, -1.2364478294551835, 0.43094573129414965, -2.383917215883034, -2.449965308002232, -0.3236307142289539, -1.439849969783438, 0.16159149554168487, -0.2606340644993426, 2.161846993537777, -0.2328700481797094, -2.4681664819631206, -0.8966422949358759, -1.0792154869175203, -3.4757358652390318, -2.358019694696763, 1.9172785488782524, -3.1507154388876493, -4.29848761315956, -2.9966386971388226, -1.969468322841499, -1.7348426359841824, -1.0433579826121533, -2.7840042592189778, -1.5666982558890568, -1.2920963305541406, -1.148603977801621, -2.767376634349789},
    {-1.6643541895160794, -2.742468417226827, -4.140088083554952, -1.6167692203603, -5.0088106909003685, -1.1788110334488144, 1.1246979950736322, -3.586302019972483, -2.5568000071785804, -1.0991956086855912, -2.064139920287643, 0.7371243621014941, -0.03519496292812998, 1.9263084501507663, -0.9321289997068644, -2.1508680324439826, -1.0457104951904106, -1.4504214213858992, -3.7949839497161597, -3.05165681535981, 1.2623218659671382, -3.1280224078032415, -4.495240822217504, -3.53829848077789, -2.3701552523859672, -2.744893255451925, -1.8886048734003105, -2.60887110382568, -1.9498407887731508, -1.0849038312629813, -1.2248306143110137, -3.049380002479602},
    {-1.981719436456208, -2.4094994111785266, -4.269905896624621, -2.0020574774651037, -5.131166263331989, -1.4771847466515666, 0.599990252364154, -3.3047220930573915, -2.5484574803601814, -1.2994467515563264, -1.8362469412137963, 0.14664642402328829, 0.08576945174301258, 1.3830972840012794, -0.921272546487323, -2.2415553929423706, -1.4738918201222535, -1.4300029855473597, -3.497172855737431, -3.1902888569864802, 1.4830582797390104, -3.4775002575465574, -4.64723857427464, -3.809964971004902, -2.446196110865842, -2.918757977079902, -1.904157314360014, -2.7732854005449306, -1.8911797757317035, -1.2663971058894379, -1.597929362875825, -3.169567277752477},
    {-2.0396225683386615, -2.68274960023642, -4.237951507433964, -1.6673883858108078, -5.1326284144970895, -1.3575487691373254, 0.16866413159682617, -2.9325828853061733, -2.515385521883697, -1.1041552279173141, -1.9786157122756896, 0.5905188674441376, -0.138607165231051, 1.8077978159436119, -0.5468023400971272, -2.1214049608565206, -1.4269285850485078, -1.6950414635964555, -4.053294410098675, -2.7898870107807276, 1.43438045971488, -3.36204679345011, -4.899659621387958, -3.4846658559135975, -2.6975818083102694, -2.671725492462448, -1.7305640400948206, -2.965833282081929, -1.9434533488349577, -1.6764874648878516, -1.0898319779403385, -2.946983532119689},
    {-1.3318603422603683, -2.7333384913686523, -3.7464688645424222, -1.3146109603548966, -4.939554677537217, -0.9562232861019121, 0.5664841117766666, -3.029235426006462, -2.967203277496515, -0.8756252764015322, -1.3330083413991138, 1.0199744421280963, 0.7977367380590058, 2.3613667796683364, -0.016227259717121946, -2.0624449404596183, -1.1229173361529612, -0.6810891687836798, -3.457062880968307, -2.5487898697631626, 2.0010183739004885, -3.9375739469794904, -4.491808181233948, -3.321930016576556, -2.71531239681, -2.440706637152296, -0.5212178358346186, -2.5327557804358634, -1.1694241489995263, -0.8414458368327227, -0.6711394618755222, -3.014974157548181}
};

static const float b1[32] = {6.166968595769591, 5.916325007011866, 6.17489382551141, 6.166797661926349, 6.136223792727756, 6.089601769125576, 6.385254255297031, 5.955080231984903, 6.125783223348314, 6.098943040699197, 6.12955490094532, 6.119836399485242, 6.030029249787059, 6.348550716623041, 6.117207610378941, 6.269626644980364, 6.160654999158168, 5.973249635944398, 5.9901832933146135, 6.159126573121838, 6.394303014995292, 6.006741800886791, 6.163248747530259, 6.0174069232306024, 5.853258919910401, 6.278085943573699, 6.253982741147102, 6.141574520357347, 6.004420969125515, 6.195239143310213, 6.129008310380485, 5.9945967185679345};

static const float w2[32][16] = {
    {5.224382026104829, 0.1191950198365734, 5.756028079403754, 5.475912988670835, 5.646838319569249, 5.0105543113856665, 5.749493172100024, 5.021149738132871, 5.310582156903311, 5.435910414492377, 5.16228842876134, 5.059205680710423, 4.911798987629206, 5.208003477144704, 5.125265994149314, 4.89766522412975},
    {5.337732563596357, 0.1829768723961843, 4.962631377372011, 5.281914183578595, 5.322846597968722, 5.546026103267399, 5.48965028292699, 5.310489095084018, 5.104821143405092, 5.156749936729548, 5.523785404098634, 5.025660183262188, 5.132226975705875, 5.182075159177703, 5.381096226649656, 5.043174247577338},
    {5.750051884986621, -0.792197405422401, 5.1663576396269395, 5.578282897509608, 5.538961739385587, 5.423508424450684, 5.554284863977516, 5.477752607714609, 5.420294969770173, 6.112195854591072, 4.9177515148447295, 5.4476001759806465, 5.425164951888945, 5.571318687448381, 5.718156297964808, 4.557509252596986},
    {5.505047330707492, 0.1652102762220674, 4.603336525892149, 5.274570903272286, 5.468264930277425, 5.390060017106953, 5.703930100270795, 4.729757962204474, 5.230929605815927, 5.484658391436629, 5.196681987754345, 5.110128848390281, 5.408960792731715, 5.091685494177185, 5.478016084655331, 4.538042022221771},
    {5.759514722453422, 0.13542596833916695, 6.181566820385455, 6.3209869311568205, 5.561083426034008, 5.928431752464538, 5.459266110865312, 4.871800843940406, 5.6110466749871515, 5.563004583109327, 6.0736057708077364, 5.638663275636726, 5.579916793273006, 6.18516640263552, 5.680759523471223, 5.37944675028327},
    {5.21356686099504, 0.046040252617482534, 5.35512185572712, 5.3087355154979115, 5.306332353036579, 5.310043252486026, 5.408899022744453, 4.696782807713547, 5.346824768101162, 5.397326639361487, 4.837967190967082, 5.251609464502224, 5.380530832295568, 5.527349448043713, 5.148107513387097, 5.122153113870416},
    {4.904198789738159, -0.12681254175255, 5.413611148360283, 5.541725953536474, 4.588277966115182, 5.526711887323469, 5.6762442966611895, 5.241988053789934, 5.328341434041053, 5.534807539298122, 5.5319803247868045, 5.598269641619529, 5.123471216765863, 5.302576183951823, 5.505951357976596, 5.025198560500363},
    {5.821396393099759, 0.20136271656514973, 5.444299316378549, 5.206108922003995, 5.405494430877143, 5.2039968693498695, 5.230046654209087, 5.304180140552504, 5.560534804514295, 5.0922950078761, 5.2192528954641775, 5.617912938057218, 4.789049799718629, 5.438053200541511, 5.451390711219119, 5.022047185920588},
    {5.109432679994395, 0.3045690773766971, 5.297850963673778, 5.343300765129823, 5.490579369377727, 5.095891946230624, 5.186058916020693, 4.890967679036509, 5.036848204772837, 4.901804405561327, 4.902993060277507, 5.050874110428422, 4.6727968360022745, 4.772729478299282, 4.747533700411461, 4.238487150763039},
    {5.410529990624928, -0.13950960913672603, 5.776455148730988, 5.146558281439482, 5.46567775111842, 5.419823726665195, 5.446326238325016, 4.651026850761618, 5.15013237432664, 4.9246315587196605, 5.914276828332022, 5.1457315081622435, 5.443713986255079, 4.963965396726111, 5.276993806633051, 4.591812335721811},
    {5.210267410167809, -0.5897489077310182, 4.801293557382959, 5.223574343289694, 4.900072110755, 5.365030250614446, 5.200066233255637, 4.642344796288628, 5.182195134235689, 5.529531392110827, 5.177928725705572, 5.045178119625067, 5.032345736409773, 5.370800918958249, 5.266117313441474, 4.7606890197155955},
    {5.411040181217364, -0.06485709875781019, 5.368549402548277, 5.777990741719005, 5.306901113994232, 5.502782397587133, 5.108477955774476, 5.095559731121161, 4.44530543644628, 5.595773223964647, 4.936792486289245, 5.433869341477298, 5.172296549088754, 5.548854763527649, 5.7903694226701745, 4.927661568045523},
    {5.502636181135207, 0.1551635196603705, 5.164825425943712, 5.375760446754993, 5.300778371591968, 5.013404459375852, 5.236487325492871, 5.246867336910981, 5.378911230805858, 5.462176761286118, 5.513015509185488, 5.855456612273672, 5.168819367284776, 5.516650735535181, 5.4103771482213805, 4.764044069586793},
    {5.237822392673047, -0.06143974705939073, 5.251068204051996, 5.330240082077803, 5.143909279956857, 5.359686833244211, 5.78773495299993, 5.223330723942391, 5.5827537479450005, 5.3130846394412705, 5.429662310734912, 5.2322998421679525, 5.458556148377888, 5.553541634112854, 5.439859538537959, 4.855705782483205},
    {5.689196110928386, -0.27089865112734945, 4.661743582999464, 5.441616117159052, 4.742560459858669, 4.872193746026993, 5.534914412329818, 4.313739874557479, 5.4640592384091935, 5.76528773261444, 5.119559818077308, 5.18796064395077, 5.308345471906788, 5.600812530641062, 5.1802884937945874, 4.998607750537216},
    {5.536997845585554, -0.4865405500165392, 5.174766189437096, 6.012154649100794, 5.257598709570906, 5.5922002310608745, 5.3413234630856135, 5.278626897147037, 5.387581864164178, 5.095004033464304, 5.41891151060117, 5.503939695703279, 5.189877716543975, 5.458154165733816, 5.3954787672847, 4.7398362403697645},
    {5.001678886348687, -0.11043347878537813, 4.926451103069115, 5.209321328703774, 5.406169551207378, 5.478096144823712, 5.900244864662298, 4.5137125687561825, 5.399531264440428, 5.472762813300313, 5.282209912433808, 5.718239661826898, 5.113239661504034, 5.51682682938971, 5.337749403099895, 5.040015951973665},
    {5.6500457957945835, 0.024154141184258283, 5.826055801722167, 5.3109216438577524, 5.430958043690637, 5.298221962112632, 5.371873994552346, 5.667551533398258, 5.234339407797165, 5.009932658224187, 5.710844943941001, 5.373093188979222, 5.0865529825666895, 5.426433234791866, 5.550993134159107, 4.765053436268354},
    {5.407925352232194, 0.2866848098041838, 5.310398266537705, 5.563246048324281, 4.862327967445326, 5.062409874041861, 5.17846390851033, 5.179642398635669, 5.217685583433945, 5.7136658316965345, 5.415751201167889, 5.279328839891212, 5.045769288337337, 5.7008700179099625, 5.505677388954194, 4.584920929877202},
    {4.809676918908815, -0.17275259961676273, 5.054630849171886, 5.315629435976048, 5.138899929885691, 5.369918297278195, 5.308275202793765, 4.963131790313401, 4.927034145952005, 5.1238360252238, 5.219762554045512, 4.533580569920561, 4.894844651379462, 5.434246560728227, 5.170568951775488, 4.4955780563945495},
    {4.374131390851011, -0.21017824068408705, 4.737852528012777, 4.897449481256651, 5.1497512906475365, 4.993369129063496, 5.287921722222458, 5.125275231720185, 4.7237593594284855, 4.846493974073652, 4.862415389532713, 5.002638732867635, 5.1497830416918795, 4.532434748895506, 4.810383114552777, 4.404398433815475},
    {4.955027372054487, -0.19629186862898362, 5.01192419974566, 5.198483610754385, 5.2431792937444985, 5.357549444392486, 5.494836736151867, 5.197383424884645, 5.5408442920952705, 5.2058846821646165, 5.261942924407826, 5.2194690102276, 5.056727535773288, 5.20149430441948, 5.403685717805211, 4.604882771510418},
    {5.653475036341639, -0.040243750468561164, 5.586123874318499, 5.739435045596355, 5.422823384246628, 5.155278612405561, 5.1300858510323355, 5.566789113538678, 5.4629922487589315, 5.520406031701669, 5.472042490169445, 5.356009498681206, 5.7058747004867945, 5.727514617668958, 5.280362803570955, 4.907719114234808},
    {5.294254757763944, -0.7901924072707848, 5.813260114533761, 5.255222599379339, 5.6787430971485096, 5.5097670477655525, 5.534655075840319, 5.329182190441333, 5.529183518429313, 5.75666276275768, 5.463554697992686, 5.4216845292636835, 5.299640541350368, 5.4179240195097105, 5.479660786576013, 4.624402584413606},
    {5.452520925196711, -0.4035042068809765, 5.372906686911246, 5.421013180195781, 5.1479767700254095, 5.360565176969703, 4.8376872204429375, 5.3794972599982245, 4.827713709682796, 5.087471474802178, 4.705776578754803, 4.997374698566184, 5.451988373487636, 5.271416358816803, 5.1767135907379185, 4.576342958149759},
    {5.451619608482152, -0.11421849389722727, 5.014042546394261, 5.657445490561793, 5.1166145108908605, 5.255260154578377, 5.501661704412412, 5.392494969284355, 5.549373808531296, 5.383390020527414, 5.413079710345171, 5.56689837614343, 5.0819282429334, 5.670223137601274, 5.204443530401626, 4.927782197505797},
    {5.201515647134951, -0.11849060628703789, 4.782431892185909, 5.14724807182602, 4.517707782388988, 5.181470251126839, 5.128871073573244, 4.887048990049092, 4.999034098715795, 5.3080030120096575, 5.168159027050676, 4.9669647978055735, 4.948754496610842, 5.325744042731686, 5.173984278161199, 4.612403229390049},
    {5.457300893895853, 0.5073935260782465, 5.081560728137453, 5.572300390855451, 4.943757998502501, 5.162512984583018, 5.33551749876904, 5.326731076878384, 5.482550639781763, 5.248922156417547, 5.096446216723496, 5.043263965774374, 5.107274313858874, 5.234671373138095, 5.3524309505883085, 4.737311049846622},
    {5.526497169214128, 0.09280750497798242, 5.497914434097177, 4.966258302909657, 5.4387212384440815, 5.007313363367677, 5.286436396537469, 4.623042799462912, 5.607133256522221, 5.729141914954578, 5.3244491222661265, 5.808883371877479, 5.295695893874179, 5.527975786595488, 5.220343981764813, 4.717894357205161},
    {5.583235180254293, -0.5471296646874007, 5.496300257216924, 5.679366163657756, 5.267545413218209, 5.540688122198384, 5.334627094326208, 5.422701421359117, 4.9035887637878615, 5.881354569363211, 5.382688415142554, 5.352364763510627, 5.204614586953595, 5.273088813405237, 5.453508294299433, 5.521495431469794},
    {5.19961329050076, 0.1511357502138874, 5.293146027929475, 4.7777433560562415, 4.759344794427821, 5.044065528873358, 5.511884985409114, 4.685020910936067, 5.145493660874699, 5.202956755895751, 4.937676910103831, 5.201979462747473, 4.887351207303776, 5.33372505698784, 5.569670166257648, 4.821258492096102},
    {5.36881768210963, 0.09009833644659691, 5.342205426806997, 5.706149493846241, 4.8245606557640155, 5.0813515194795755, 5.577125683113829, 5.06752104718601, 5.609255431676446, 6.106177914483673, 5.171876836938519, 4.828624441823705, 5.174977112128867, 5.2512840868408395, 5.0961530040901515, 4.591107784290815}
};

static const float b2[16] = {5.214986436342705, -0.08205267120848683, 5.415835267912027, 5.2722464465233605, 5.389001824526802, 5.527534214461921, 5.201114733210632, 5.469271805213972, 5.326833504449959, 5.280842889625438, 5.185460968457392, 5.343970749995394, 5.5103522809597285, 5.177485213280917, 5.361853443823715, 5.539502403659108};

static const float w3[16][12] = {
    {-4.567070081926498, -4.22182396924634, -3.4227416181563366, -3.3132691265727026, -3.652209482864241, -3.6825120971846395, -3.1809367469487206, -3.2445537340678405, -4.285600576306383, -4.196266827591996, -3.9684460028112483, -4.189874787728615},
    {0.5113727456367338, 0.5180223553573563, -0.0534257536020099, -0.2863375838429712, 0.18255045430788716, -0.22585569713045564, -0.1480935780381458, 0.09932657708317502, -0.34980513307947253, -0.05984786970073746, 0.37592055825241927, 0.3279416428595279},
    {-4.040254778102873, -4.161840079336065, -4.28656335926863, -3.5647142996297743, -3.428628220480197, -3.1381092212427104, -3.72252216050784, -3.411170326960369, -3.73228971996413, -4.490833425695633, -4.281259336108906, -3.441908811799751},
    {-3.933676730030997, -3.7590605766885843, -3.5348602843810166, -3.884970980031456, -4.03117154878248, -3.9892954994532235, -3.9071101365268035, -3.472126732058362, -3.8832385882620093, -3.775473493596827, -3.7781764434255383, -3.432396586417364},
    {-3.160877247635018, -3.6795532122363985, -3.244339110052783, -3.297526327722928, -4.142247110294699, -3.4266997085602924, -3.669810216169749, -3.981568671386383, -3.67015771256552, -3.1664558090502233, -3.6738454509259295, -3.549894745652341},
    {-3.718177337229304, -3.7163136749381254, -3.351561281397509, -3.7789768134445776, -3.656790896309536, -3.886172392578594, -3.2660107077156963, -3.7453500046805788, -3.3823299636711948, -3.475518180079982, -4.352020034352383, -4.050203536839927},
    {-3.255521486568574, -3.680470600209691, -3.9043820247597827, -4.426218504561918, -3.7199544702967464, -3.3836090301457014, -3.8949299641333184, -4.084852570782794, -4.055100654478116, -3.8556232896814073, -3.8137316178087595, -3.7755142419187444},
    {-3.461445704708701, -4.0695072958322145, -3.665282896482093, -4.045905739239132, -3.6706393227689427, -4.357205691755134, -3.5887259376040763, -3.582815691695902, -3.2853293691618304, -3.959236191432265, -3.302357025856788, -3.786518009161623},
    {-3.8025794666286075, -2.8047911394508587, -4.01041452097138, -3.932117719809932, -3.8418627683854267, -3.8671474082223747, -3.8156503834608295, -4.16332371752502, -4.255362468870124, -3.9991975201917467, -3.8597393363184773, -3.2665395767687584},
    {-3.566058232032287, -3.595163765475776, -3.8664947887019445, -3.8907659296667116, -3.4879694701566772, -3.710568305115105, -3.564343138408936, -4.311436438304356, -4.00446148220275, -2.9197780282675208, -3.7232999924105488, -3.7794067381684284},
    {-4.233950203308966, -4.359119748649417, -3.937352974965248, -3.6577001688591957, -4.3617162221866925, -4.380063716992098, -2.9694491980614526, -3.8079754366326313, -3.322122084170659, -3.826532649536393, -3.2442141857406264, -4.3112473230481365},
    {-3.3264066277176196, -3.7285480571071377, -4.1948495756832305, -3.8752605241677363, -3.747326781317543, -3.5526013855590586, -4.009489515912607, -4.086532876222615, -3.876416238624741, -4.204050811344834, -3.261741425653328, -4.298572753369182},
    {-4.1168112935010885, -3.774679051296136, -4.163429598993133, -4.106208458662836, -3.264471992888697, -3.9367577385972385, -4.399462189473825, -3.1840108355408305, -3.707397303722866, -3.6951955496927784, -4.3084236059344105, -3.5261084561498786},
    {-3.1706136602518384, -3.882843399168366, -3.7657282118164033, -4.111712363471344, -3.661598296196509, -3.5703715740615802, -4.620514517121845, -3.658044539561049, -4.007909225914533, -3.416270365650639, -3.579720766369693, -3.7680175612119005},
    {-4.127240058677697, -3.577504449939573, -3.4298542559697767, -3.217149906118996, -3.7487712785791616, -3.910150887821979, -3.9332090665925867, -4.236689270033076, -3.2758692301831664, -3.9167688748896485, -3.73610584606637, -4.024297063240355},
    {-3.7724977923939154, -3.149232631017913, -3.373038018045097, -3.0247780686568855, -3.7886324073757076, -3.393855963028065, -3.660435442785225, -3.141784200174665, -3.463408108289406, -3.2367699139950106, -3.332324859624249, -2.771174509668913}
};

static const float b3[12] = {-2.1738125690356993, -2.2059259411562384, -1.8916336120349602, -1.9264919585292943, -1.9307874796786004, -2.035164636625432, -1.8282952160807702, -1.939318697299175, -1.423214437614397, -2.0135946019649715, -1.2551907537605025, -1.7740332077154};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
