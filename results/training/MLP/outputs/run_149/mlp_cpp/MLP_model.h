#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {1.4801381171804824, 2.402371855820288, 2.143955756681538, -3.548619880253157, 1.8573770755391206, -4.5795906468826715, -4.426618676201702, 2.5167854408633277, -4.393300734885772, -4.076110932778099, -3.6239063071127595, -3.5107338002592714, 2.3844040709559726, -3.565384256554615, 2.2756251280054434, 1.907703659177993, 2.5772583252922963, 2.4742564120612083, -3.8392142576483503, -3.2544272987121974, -2.5418243131588008, -4.2573735666796555, 2.2885423299341814, -3.2687362553878043, -1.171011849425257, -2.1897049429689877, -3.2147989000479678, -3.992570248547412, -2.8743689596972715, -4.997684609305004, -0.7333909951479948, 3.198988973327059},
    {-4.191181115222315, -4.619907183817317, -1.8638600032670327, -0.8204168238011692, -4.087565553467746, -1.3237797653040473, -1.9610263041594607, -3.376706197736382, -1.4252235442861372, -1.6602026829680285, -1.65152699726054, -0.9205230706751186, -0.5947116983780386, 1.1478490904907086, -4.4633416897675335, -4.366878765533587, -4.384792563646056, -0.18524561999066572, -1.0828679420110479, -1.052024869810019, -2.359245895163849, -2.039453578867373, -3.592779077355231, -2.260967051508765, -1.999373686832959, -1.1540312066583027, 0.4318888457658423, -0.83001246508589, -2.3968463621344713, -1.1006918991535413, -2.9223844081831856, -1.3813982964366145},
    {1.3528997402550773, 1.020173966281228, 3.506517777382892, 5.005966273110006, 1.0225259154997124, 3.858032627173031, 4.559072313108774, -3.7810897955994185, 4.647327395126928, 4.253511483280132, 4.806991737048716, 4.365781988959067, 0.1745470520910303, 5.334090472239414, -3.751970034440831, 2.570718256180288, 2.7879202120407625, 1.7635226035801939, 3.717414042208672, 5.582253607499304, 5.1398390822921005, 3.955144119354031, 1.8180912984167021, 4.594668708819888, 3.9748884281370347, 4.912511524096737, 1.970196119880472, 2.335338560707717, 4.0561779375130165, 4.07335345648964, 4.656710475556857, 0.8093379331352923},
    {2.36715450875961, 4.062370362189014, 1.2786653084660502, 4.540935778661488, 3.2458526728724353, 4.94634246214225, 4.393905563330726, -1.1131846381471031, 5.532735102498335, 5.048930084488172, 5.28776735452012, 4.203872048205789, -3.0413211885130096, 2.892202487760209, 0.28997414658711096, 4.119323918618445, 4.574994216323607, -2.0905548710299087, 2.889106321457543, 5.052246390339608, 4.84111720536313, 4.000655854093431, 3.147285295232404, 5.5929095932287956, 3.1736547706111997, 2.7334089163511077, -0.44623483029524896, 4.035026485520136, 4.415747332386191, 4.4659927485141395, 5.2915037462671775, -2.0837470117913544},
    {3.47799975044362, 2.310253041069001, 2.8489938202860885, 5.052551203199464, 1.9551744615383904, 5.459314165577711, 6.1899781683332895, -1.899189288969084, 5.009165931622671, 5.726720193528273, 5.997718541282161, 5.158796139131551, -1.8204728230780598, 4.979027417101338, -1.0849504392037412, 3.6724096104058646, 3.6541745144441062, -1.3231825484816095, 4.846719867773273, 5.946636039864548, 6.2495955848879845, 5.636998205592877, 1.4355640137484316, 5.350572887195784, 4.503984367623805, 5.562459991922314, 3.8592161123062994, 4.53988549995976, 5.67349439694314, 5.3707410946591265, 5.075976438662966, -1.0715907571829058},
    {5.212802965247961, 4.439452902255272, 3.2068482826872504, 7.073232538331528, 4.8814887436977665, 7.037296908351849, 6.581689670367272, -2.4734934193002283, 7.149331381735218, 7.248185826740298, 6.884855179085958, 6.752894641802098, 0.44613027560227814, 5.182834893946841, 0.252477003160694, 5.341121894758775, 5.322794434530058, 0.22428877727531343, 5.7635259412534365, 6.75806042761754, 6.800161988874641, 7.31086626485096, 4.22897973335649, 6.6953561804665025, 4.300185380546892, 4.908881946147841, 6.397778123631038, 5.756224560796631, 6.50472468094089, 7.3381510064327635, 6.202957329247478, -0.7292340382700294},
    {4.8070879976842935, 4.80248590054628, 2.249200004127835, 6.573822373952858, 4.762197057842715, 6.25630872509168, 5.729984761554054, -2.918695529351245, 6.368847434490736, 6.509198727795734, 5.835156687836863, 6.1935184549923505, -0.4880735209673729, 4.53295068236641, 1.0336361131234204, 5.443462762589138, 5.036360610358657, -0.39051478813431134, 5.400764415945313, 5.933154403944126, 5.833004239582502, 6.742357449166816, 4.311184946078858, 6.30105429349205, 4.0679100369682395, 4.2030103861199635, 5.647466151754874, 5.364623239200704, 5.5714774671063045, 6.588186496470344, 5.649893428762818, -1.456951225184426},
    {-0.10372034521994467, -0.10679987538743266, 0.5845739650316919, 2.1445333177722654, -1.840803269599197, 1.3324663739297689, 2.1055549010351022, -3.9617264464733033, 1.6711854128837103, 1.2326035098048143, 2.237887875404729, 1.1851671642611774, -2.025397026431625, 2.7834656424544724, -3.69622336869575, -0.3270034805594446, -0.4316300744194808, -1.1608285610453064, 1.1888599052078241, 2.410818691546066, 1.4424782433604755, 2.246139933930848, -0.49729419221924925, 1.4476033679749067, 1.0851186198275706, 1.8038855123111632, 0.4705885682880512, 1.6033495718832553, 0.9528087615754616, 2.0685340084606074, 1.5297424687296053, -1.951638346706184},
    {-1.2347371762492096, -0.5479750800552163, 1.01438610281644, 2.74288522665288, -0.7306329087772359, 2.753023217820887, 1.163608785784864, -3.7986247483260893, 2.565912465924976, 1.2390916901106006, 2.150823547394255, 1.8179573901728208, -0.5076594257821724, 0.8886942312835389, -2.418468749793627, -1.3613259326780895, -0.5659791468830045, -0.6446165943972891, 1.3006404261766589, 2.232291364599828, 0.8700953139085124, 2.255839404751123, -0.6275866258388259, 1.570828185563896, 0.9130952985908767, 0.7214682524319677, -0.5447356505927277, 2.3244925070846896, 0.07589749269439237, 2.288803027952738, 0.8709879398251565, -1.3280948520039642},
    {-4.281752090914427, -3.7694680500093893, -3.7079959106884477, -3.340037716454304, -2.9823047970956473, -3.139940694394674, -3.409794490365946, 1.0008169073821314, -3.526764271576509, -4.17179248121563, -4.310187847256416, -2.8034933354905944, 0.07970127453110785, -2.743934343463425, -2.540922009325995, -5.039217428033767, -3.944351467076384, -1.5044544415333376, -3.8715162163777537, -3.5658349843090162, -4.616632299057472, -3.357008313384184, -2.638094555194463, -4.40684483037469, -5.026537502367814, -3.9952683515239955, -1.0396583639170984, -2.9148612426837555, -3.9828158462701855, -3.390657031888654, -3.6752266558546505, -0.38033503891723835},
    {-1.666225113635352, -0.38449654366660346, -2.7211932047129173, -1.1705432669210474, -0.03333750661470756, -1.0684792359772988, -1.8118276708116219, -0.6240228983928481, 0.005219368641921599, -1.8611045096611387, -1.9160027739140724, -1.0959609369433772, 0.05387209981203777, -1.8556065640167196, -1.1786771894965535, -1.9915872051591772, -1.0947651937409824, -2.2957844758367916, -2.613206151568231, -2.1367400526274714, -2.988868032568468, -1.43826661621171, -0.26824920610249686, -1.8227850380411557, -4.109491250223907, -2.689349483863697, 2.061934248624945, -1.0093543656987864, -2.442505733357631, -0.7438918862107379, -0.9990288410262298, -1.406314281153564},
    {-2.5989622187129835, 0.0269318729639789, 0.747699485904923, 0.5198168032188281, -0.8616944480399183, 0.06349897082573847, -1.579244451846634, 1.6581518349488418, -0.8806272801279497, -1.5431172149482981, 0.6349584084616727, 1.0227329564877423, 0.8204367387421634, -0.5441846054640275, 0.2918325148364129, -2.063404745431767, -1.0574471985957248, 0.9506919171929673, -1.6684620603188927, 0.0884162653420057, -2.3550982557465434, -2.0175719364033022, 1.1693638918685967, 0.202402825186944, -0.33263660844447973, -0.6924488103976904, -2.6216464170506777, 0.9193054702530488, -1.3360475505783937, -0.4541775650463424, -0.1050576608333305, -0.04570164721768335},
    {-2.4149487643615566, -3.949105005258689, -0.6779010346394972, -2.1977312733175705, -3.50054575999126, -2.4208915871927696, -2.368477217102374, -3.75944508864504, -2.9591785582429893, -2.440281230231604, -2.7399198003119967, -3.130883413285265, 2.723509858073055, 0.280503857376087, -2.807790860423097, -2.540314961301479, -4.223255595486128, 1.785308755981166, 0.21805714176748756, -3.3449065172928996, -2.054724082773206, -1.1503395463021762, -2.66062349793133, -3.197306186496761, -0.824196344152334, 0.09331245703654487, 2.876786377375023, -2.1672727618955934, -1.8097473121411727, -1.5774103338874135, -3.752285812018633, 0.5450466204482369},
    {1.0605491285441135, 3.501514522262983, -0.8845171762616042, 3.276578306417846, 3.855783298135809, 3.9201311654934465, -0.8297359017201582, 0.8682073511304206, 3.9502700931192702, 2.8866787563723197, 2.360786166012887, 2.8089463607356797, 1.8122202069394215, -2.448577965567467, 3.713473072423147, 2.9640495302487726, 3.1635911994925534, -3.0288162578501145, 1.13960143271701, 1.1851308938290561, -0.9549100819770279, 3.3808087190979785, 3.5242845468997643, 3.7284845245492932, -1.545404292200627, -2.244889663974383, 2.863198145308725, 4.881899032498145, 0.30160040442848113, 3.5078895273785076, 2.110732097198888, -3.342100221196503},
    {4.8447676799088, 4.140274777683738, 0.7020226343729816, 3.4556126787748744, 4.144895759363286, 4.388052046686711, 0.6902595672534816, -0.5032946143430659, 4.303700424916198, 4.19343334228678, 2.663132634295719, 3.0143846780184242, 0.4782818831707993, -2.97524855642032, 4.823309673327206, 4.433377462690711, 3.67804047771231, -2.7604244408277596, 4.191141783551141, 0.9233509588038716, 1.2064843593054466, 5.0993072327316495, 3.840813700116694, 4.288023148308256, 2.083677728662408, -0.9295216206479199, 3.4243402241976817, 5.387646804705184, 3.369725447004499, 4.635180267620394, 2.244809698944472, -3.4663574527008794},
    {1.075481468857832, -1.1812833409596986, 0.5547810808923919, 0.1796967970816008, -0.650541801680165, 0.07940197815724487, -2.2870881113524164, -1.5709608858627198, -0.2581123181781752, 0.16919514217151846, -0.6112674479808771, -0.3937647413916085, 3.1669392912803884, -3.0614004931554377, 1.7281273992987856, -1.6477078622772587, -1.942366419999793, 0.41027193540111967, 2.566407658250351, -2.635327177131044, -2.6253387411180142, 1.6344520708897972, -0.4554980298050947, -1.3175906285921366, 0.26889022860358264, -0.8850450423054915, 3.599958312598289, 1.8817774109589809, -0.49187325311230345, 0.8268452345710059, -2.309897636384164, -1.8246190038779664},
    {4.139227034580014, 4.904819749953215, -1.614771972588419, 4.264417773509228, 5.174485715012361, 5.702722788949163, 1.7401435091160122, 1.2085009992021791, 5.511509956699435, 4.611891164773932, 3.740265197050365, 4.6348842983403395, -1.468057686712094, -2.2630012053807596, 4.5404365608130615, 4.41660924317846, 3.8846792610635794, -4.3410030246128795, 3.3129126066879864, 2.0993589746670858, 0.43499360036941326, 5.247226315186676, 4.580382282694477, 5.394458433587209, -0.41824342305957063, -2.3630884145249134, 2.8746378900814453, 6.163950082298439, 2.997303489828561, 5.434360237417628, 2.9508252739180967, -5.3012828990730405},
    {2.6798187050076505, 3.0483327947455923, -0.676710440494596, 2.4442414773715657, 3.7219496509052203, 3.209407927699273, 0.2734555600005058, 2.4304431551962833, 3.299265098916722, 1.8775999810726056, 1.426926974515792, 2.3050036635118434, -0.2728422367085691, -2.0662931233883697, 3.983606518927145, 2.3028116764491466, 2.3949166645237216, -1.5934811975074785, 1.2381997670874665, 0.6619586133819317, -0.22431704242120762, 2.825192077421728, 3.0523722422538815, 2.644966360189033, -0.28012181850453716, -1.7666128904305325, 2.9808985729254465, 3.283316074190092, 1.1702125804226036, 3.237001828584382, 1.5238531623278977, -3.210041372342845},
    {2.5580993650409742, 2.156730752248979, 0.7939728514727528, 1.693894600929432, 2.3523438851932053, 2.32984893594565, 0.29217289222693227, 0.36376036491357194, 2.2031965730683405, 2.155180443651591, 1.940980981896703, 2.0675632277592437, -0.9945628039028348, 0.11570757996039888, 2.8229088107142544, 3.004018364109165, 1.4734320820202718, -0.40922435454744877, 2.310187398208881, 0.7385373622713773, 1.0266768314987873, 1.858829876300016, 2.9787954024574694, 2.8674916150781735, 2.24536502044201, 0.6158982866210198, -0.39044103704698857, 2.5789223555601803, 1.5873517923627312, 2.6126620139025154, 1.2644887888443388, -2.883567386510224},
    {-0.8126511424964228, 1.7115528547187546, -2.590682262678696, -1.2861451762050502, 2.247615332817797, -0.9578604540704879, -1.5953970905592807, 1.029163450993303, 0.1968615421052613, -0.9496185878579823, -1.9282638621917263, -1.1047352468360354, -1.3144631778801945, -1.3381734033469879, 1.756370037123494, 2.1615874218234374, 0.3482919300081475, -2.354608667385072, -1.8849214434456618, -2.046891483483476, -1.3815054280336685, -1.60394096028934, 1.4212436318127921, -0.9486329824394418, -2.565687606723057, -2.080759101448877, -0.5614713048129557, 0.511765365471979, -2.336826181536668, -1.0761407082065795, -0.3037817327234999, -1.8076661382647234},
    {3.743273005574589, 3.29244726215992, -1.8946855110544003, 0.08223111439155527, 3.3995440509233226, 1.4006084772748846, 0.42791561829119973, 2.5351731331738003, 2.5006090753393293, 2.937092982090359, 0.29771973347890685, 0.6911010495088722, -1.814111351319758, -1.0787678308505697, 4.908786856500037, 4.135086666702747, 2.3651913315250344, -2.01584154315006, 1.4105207896806895, -0.430088036154045, 0.5010783413122446, 1.1325341223803769, 2.2611863925663105, 2.4400534722322704, 1.4702878245402433, -0.5030213760847132, -1.021289225943492, 3.021685203167912, 1.0061069008598458, 1.8060938152138708, 0.6951373386876718, -2.956899056783721},
    {0.9319139039510816, 3.3950046272793104, -4.171254880628538, -1.250385736860073, 3.002685873896345, 0.9200970531402828, -1.4339005395827056, 3.5493171138704485, 0.7232981586338032, 0.40617505765575057, -1.2492639145977764, -0.22513254623626167, -2.5496573058660807, -4.222912832525683, 4.408021715482402, 2.440354047736306, 1.9551130212527834, -5.75680085629797, -1.8575364265146708, -2.34001462737596, -2.5895879985227483, 0.011205460070700146, 1.3501044985417707, 1.0230846161684148, -3.2771942996645382, -4.324717223598215, -0.34951679622926235, 3.015203840849521, -1.5201889425471367, 0.8694711225026416, -0.4803988824005903, -5.29129898549914},
    {2.153154838026201, 2.501137185400103, -2.174139029617478, -0.18252942947002374, 2.5091899006993215, 1.71431190018435, 0.7464558575100187, 2.7199889794119216, 1.629940131431944, 2.192636090735737, 0.39281877966354095, 1.081679728724416, -2.2310535686836555, -0.601463982631051, 4.867111298891049, 3.3077665293319143, 0.9863592125087071, -1.4834696973580133, 1.4678900476001153, -0.9479064102136396, 0.21944173154680818, 0.834546063134353, 0.7608772626466909, 2.014421422562702, 1.4607282820397458, -0.29087630440567713, -1.2839663398159895, 2.7904936964503597, 0.5983994600289231, 1.3952267397279288, 0.8482430271848278, -3.500711187131276},
    {-1.0786885764542415, 0.9118508582478656, -4.616503633128883, -2.676735397703809, 0.26128729788702065, -1.7928605540253226, -0.9143422791408622, 4.23066704148895, -1.5531860367677626, -1.2522440822202565, -1.8746330875538695, -1.5679003083097478, -4.1862017276548595, -1.7940031151122933, 2.27421104568207, -0.10461209037476626, -0.8967049447835358, -3.0862530909396555, -2.6604799937939756, -2.038571695839002, -1.4319950957855232, -2.4760844107566484, -1.4986062937783877, -1.4579147246368083, -2.456404855708074, -2.0577515267673765, -3.5325234708383064, -0.2300225882547587, -1.7754516110177323, -1.4923593710850294, -1.4020053812601954, -3.5028222016240824},
    {1.3503078763243068, 5.510663747729612, -2.229899522926066, 0.5835601367099864, 5.835495259388356, 2.009673551183564, 1.0729899767519946, 5.458964582980652, 2.1424758762151392, 2.3421965036421564, 1.4156922196954882, 3.0135250758034027, -2.5412324245166245, -0.2143053763244854, 4.9772279785198075, 3.933543151750001, 4.660846010501889, -2.3820991833864382, -1.3633153237730935, 1.8807300553085688, 0.6763672030665828, 0.5605404815180327, 3.915467517385184, 3.0515963377588897, -1.052415593256282, -1.1280548328455438, -1.315758910814875, 2.7563696426629716, 0.45863982514037543, 1.748519871010629, 3.094234313667445, -1.8132053343599555},
    {-1.205650793505846, 2.990041585655014, -3.1216529072411787, -3.1182343731816227, 2.2206632541540694, -2.6767858698388642, -1.0756115367119603, 4.45774890981421, -1.9257063603219429, -1.7027315391442763, -1.9786415337832812, -0.9656497648011119, -3.5197556831772716, -0.6113174690696194, 2.947606269199454, 0.76349809192853, 0.5652586809480246, -1.2697227463636294, -3.7553968115361323, -0.7978438172724395, -1.165774539613805, -3.4789469082284183, 1.1307823364751397, -1.0514628401318775, -1.3646764247269716, -1.881899034393206, -4.9867451886704695, -2.426804568928952, -1.602871782453217, -3.1423846557449093, 0.23813595284336947, 0.0647567674054044},
    {-1.7586584670169045, 1.1175106508779435, -5.643437466262582, -4.750600469488985, 0.9098007918757789, -3.616493705499725, -3.207813721144172, 4.519474603396702, -3.234197678121607, -3.672296045032883, -4.191253718544153, -3.133223742606494, -3.544252501417116, -4.807706171419601, 3.9827749782147515, -1.5336451346069948, -1.2917105789445587, -3.9471437834032392, -4.8106461948715795, -4.151916299453527, -4.251636367590933, -4.39614439239794, -0.8092339306715769, -3.050144212274487, -3.850888483987413, -4.734475518452766, -5.184715305155291, -1.8651310405521997, -3.6625203263433783, -3.837524614075977, -3.0559947226337614, -2.8324199886411594},
    {0.7366904443194143, 1.5124831925257751, -1.26353657980062, -0.6015687899521438, 1.7827821206715386, -0.7871479468858191, 1.7629370689486712, 0.9758747046452023, -0.6793487342330379, 0.44192425469505775, -0.00959243467261995, -0.8203748246101739, -2.5057437730658476, 2.6349999436440377, 1.121660119211909, 1.9227019036246464, 1.1499437316047827, -1.146587865511206, -0.8625652193157585, 0.7267295287842231, 1.238258744006472, -0.5199135070366186, 0.25178433194595073, -0.19440954010230518, 1.4775827278442817, 1.4931431838552707, -1.4776343780973071, -0.7880934985391184, -0.6060129527511222, -0.3146447987401639, 0.5281128676913934, -1.0460418471197863},
    {1.3707428142246876, 5.004301108721227, -3.4515128204020544, 0.9224676543271345, 4.961618051469602, 2.44517759762127, 0.8801675213722696, 3.49107193794275, 2.2367101942353034, 1.3365882899472947, 1.4640779871216505, 2.327298006056105, -4.96916297313453, -1.7817411810568151, 3.479496742392749, 3.2722144297249587, 3.457999512063344, -5.1091422830224555, -2.5200548944335064, 1.7127351143658824, -0.344455975298577, 0.1555450582091018, 3.492485698239586, 2.572705175924163, -2.091761335530949, -2.709393003463661, -2.5310540225155154, 2.257834442409452, 0.2840469517571012, 1.2469907918273937, 2.2704374800542046, -4.260433141870148},
    {1.9779521355045364, 3.0595417995203764, -2.041471792150133, 1.4009397363621003, 2.64354895225203, 2.675059141730536, 1.7539579048560134, 1.5657401370170332, 2.150506026879567, 2.3162818578330584, 1.976769969941719, 2.9728953511478364, -2.772140161715337, -0.7655145722357914, 3.080203151262068, 2.528523821558098, 1.7525865120911837, -3.6825487229979674, 0.7347018842172854, 1.495391620537315, 0.8243922348165261, 1.6992820721482191, 2.243188199104111, 3.096919270443815, 0.6029686535229166, -1.168126542240962, -1.0546648625271176, 2.4019125105262407, 0.7178768923157809, 2.273911623671458, 1.6877899831942607, -4.210290432620446},
    {1.2729255180379058, 2.6482904487592775, 0.7926792557497045, -3.9211824788698566, 2.331374797782466, -5.376061888294005, -5.28412385612145, 2.1461487941893838, -4.041002572094531, -5.53115604570902, -5.245472070882692, -3.800132011228161, 1.1168995846124166, -6.030112780927373, 1.6879613994564582, 1.9426870276249313, 2.5761773235040923, 0.3008336050392459, -5.87177359079747, -5.470802355895488, -4.396675315308709, -3.419556411685233, 2.47131612986637, -4.358941937979473, -6.554799001216367, -6.261035027614274, -3.7802250633392633, -4.6001443652364795, -4.963339502359959, -5.3117381529962815, 0.6966950879030498, 1.3297222322971847},
    {-0.3333301593255718, 3.222636296614573, 1.0874236011788485, -2.170170939752797, 2.2277597327952576, -4.664679205258834, -4.454773210588134, 2.7285026196176374, -3.2905969760655256, -5.031469647886105, -3.837406598735718, -3.167152063140444, 1.2176506703044856, -5.073964832004021, 1.3228943812589515, 1.6056300028016386, 3.0757691568509697, -0.2043477863764887, -5.277026085461082, -3.2345644916448837, -3.8798260509557685, -2.8612037206615146, 3.0688824100975207, -3.1458831289517466, -5.21458384952039, -4.866357146428975, -3.8137491261351975, -3.6357742159612543, -4.496460880284127, -4.540968754111553, 1.05464334847212, 2.0632420777585176},
    {0.09684187183209172, 2.4262355098153328, 2.371336151970418, -1.6025503659497191, 1.8613843180585943, -3.4703883455299542, -3.7262235437668063, 3.1478093781960372, -3.027960539291122, -3.6721287984419937, -2.1818154006191186, -1.840579837599417, 2.772493365471398, -2.3100592661029213, 0.7286666708321, 1.5933700229185035, 2.2039266812177285, 2.16653812374724, -3.7497122220139225, -1.9905565026872756, -1.3701791174193896, -1.5816573336213922, 2.715445078302389, -3.960300601014043, -3.805179588513434, -1.9195146995600727, -1.000714724948631, -3.0842597674113326, -3.433343268902647, -3.5719959114567494, 0.9145651762735721, 3.6786043569294096},
    {0.4724535707569461, 2.351291167545218, 2.3218858559074285, -0.944801442532488, 1.2148536267420866, -2.8914742914250913, -3.4621138193165084, 2.8547924933276683, -3.0007756380713206, -2.936902064374443, -2.4688078259188546, -0.7514543675312901, 3.118156386599363, -2.354539213095583, 0.6230885595083203, 0.7849670827772686, 2.437717803625123, 2.265651539068237, -3.1519226236760063, -1.017636689576192, -1.246361051877174, -2.325504710033087, 2.669081768689891, -2.9033564778570535, -2.0687292585846526, -1.52006569605099, -2.0241316925683974, -4.042899447786121, -2.6546381355337907, -2.9629771274978323, 1.2479726960750543, 3.5878901214182664},
    {0.6802310166075194, 2.9269639228814417, 0.2081659667270984, -0.1649676374444006, 2.689576484754014, -1.8968498200289925, -0.943835182640024, 3.515646272272237, -0.5224133208281817, -2.0143882166511555, -0.8322391028743797, 0.25336661730661925, 0.5687158392861912, -1.3401630738817576, 1.0464472125517135, 1.9858378238263985, 1.8194957906318, 2.375794965988199, -1.9188866682456982, -1.3127346956959243, -0.33168556693730156, -0.9427936389238029, 2.847365078612631, -1.3273820920091302, -1.6622654500653113, -1.0450773488095224, -0.7650881987101981, -1.7872522747000703, -2.1220948031526814, -2.3637676245250026, 1.7034000156180185, 2.205647782797966},
    {0.13371165291032366, 2.342300519786118, 1.2541310331718873, 0.05070358509434439, 2.397014688239085, -0.9263429221700005, -2.274424992614064, 2.499885310631595, 0.03355187745067499, -2.041902452580046, -0.9359007449042239, 1.7820351719110032, -0.17186786925097716, -0.9637438936518077, 0.8833460887093664, -0.019783184799063342, 2.6442669759614357, 2.608558312070718, -2.705338171813506, -0.26222886141811236, -0.6405573850619245, -1.8106238082084378, 1.4214438961545095, -0.9533128665102943, -2.230669984896007, -1.187492271772715, 0.48540524290498627, -2.724785441840743, -1.411664634553174, -1.6060281216721681, 2.725610050530373, 3.233389652804182},
    {-0.3615650664923757, 1.8979996799945227, 2.5810220054602913, 0.0015382497592237988, 2.1790225028755197, -1.576944097154958, -1.6255602257504298, 2.234629437778761, -1.7846124671821804, -2.513176660931402, -0.9333953775645324, 0.30180155164912487, 1.6449256657673046, 0.13743440189015074, 0.24617012536809468, 0.6088260877895939, 2.698890596833145, 2.256220917975339, -0.9668190092963641, 0.8947830692692151, -0.12524076647986082, -0.5886916292283306, 1.9936921364774776, -1.7792449180298184, -1.0806791128634083, -0.864971871150211, -0.7400407146662542, -2.3637617375013265, -2.0810881215589707, -1.0944695665525894, 1.919363211351418, 3.423680176418051},
    {2.2575209722087655, 2.185260639145301, 0.5977995271938268, 0.4309884414200313, 2.274924270805091, -0.02166707952290493, -0.6229890533142686, 0.6347149449490989, 0.004657047227227411, 0.41774943681719656, 0.6164283962179741, 1.5277304486870327, 0.12599585794615983, 0.26425308438138384, 1.1278365803320107, 0.8527449548538715, 2.2428228977559588, 0.9187143375315698, -0.21402052129428314, 1.0645592403207487, -0.14357021181304006, 0.5487696080048271, 2.286717311588711, -0.21833610804864478, 0.1906266308237806, -0.13459838177895242, -1.1299359785014644, -0.805652313460695, 0.540642793677958, 0.4947595387069381, 2.5696164686580922, 0.9738487326571129},
    {-1.316902183004716, 1.7946297389337287, 0.30610401757014777, -0.023804373090605523, 2.8931406655021217, -0.5266133786092487, -2.252939538372981, 1.209298304394295, -1.287712812468111, -0.47415509392407446, -0.9506993710118286, 0.35244366427298623, 1.3815971029598737, -2.071583472990317, -0.7252468502544394, 0.5898183848455013, 2.356342395920888, -0.38880820785456294, -1.8544546973358378, 0.05345220247179188, -2.1271210138589227, -0.7990562842923121, 0.7446175219173571, -0.6219025665230282, -1.8263430092983919, -2.0562204661833396, 0.47494212794192453, 0.1221036951803979, -1.0071876805299795, -0.7355469010946152, 1.57006428549717, 0.874499894050061},
    {0.011337597372298587, 0.6735820102745356, 0.8883328738496558, 0.600987532978715, -0.00418912692984889, -0.6308947900243143, -1.6054485025536627, 1.2708966502660142, -0.3816273319422633, -1.2578768917829388, -0.9077223355777739, 0.4865410941726851, 1.679687881229475, -1.1023027977698527, -1.8969126408578727, -0.130734685394999, 0.40135175385383026, 0.8529509906253392, -0.9329586914924876, -0.24316023230466569, -1.4898060095506613, -1.4603298189398393, 1.312536494444871, -0.626419039101531, 0.3974981818253014, -1.9712421139865335, 0.7783871999284079, 0.08160112222990465, 0.20268878156151054, 0.09648948175887258, 0.5721374852311534, 0.39070023268324094},
    {-0.8032650701243711, 1.039694346839841, 1.8844454353688376, -0.7122321550697465, 1.2548155646687567, -1.1246009650027278, -1.415962822923691, 3.356280008618523, -1.664280022075859, -2.1555629787545523, -0.44797218156464774, -0.11410213946878005, 1.5777432806013896, -0.3065882202445779, -0.15981457785133027, -1.9598595130221768, 0.5756909235502347, 1.477471828061091, -1.1637948252183632, -0.6304265857273106, -0.8366743498412857, -1.825778325249477, 2.197031268603761, -1.1354215710293851, 0.6636848972247209, 1.0103497058296615, -0.4190954783604535, -1.0684952922917168, -0.28098317345395196, -1.175682343249252, -0.7965315203874556, 1.8405702622669589},
    {-0.18052478101549074, 0.2805333164098953, -0.10454860024792564, 0.28827385528335564, 0.5613564550100814, -0.7688749586480689, -0.8526575280722003, 0.886902546800162, -1.3745510010419535, -0.5485355721600254, -1.9600860938039186, 0.7724813116258584, 1.3474078412027075, 0.35667215325122076, -0.6949519348934139, -0.11629360146493774, 1.1695046118248498, -0.17315958827852157, -0.34410290730968873, -0.47279739345732297, -2.4128854052782884, -0.36238007629895214, 1.3810874588659106, -1.3350178367610241, 1.0176159486151042, 0.20382425764673961, -1.6367463653489442, -0.3150592659146659, -0.8996269315344557, -0.5051719005452657, -0.28734215132278734, -0.14514504936800524},
    {1.5353703472329858, 2.793902746108429, 0.3863655320926992, 1.3570115340307882, 2.056425678213506, 1.442961833252153, -0.07627854612553872, 1.479639431706373, 1.9800760751058026, 0.7619063316754721, 1.0159991762241958, 1.4384933621814664, 0.1896917802755017, -0.9556121197737666, 1.7819916675794152, 0.4785274891446929, 3.051951181851139, -0.10966588124159742, -0.7404448915980628, 1.9190167332692385, -0.19725073201901208, 0.9616011266959221, 1.4355498674883371, 0.6385416750277275, -0.8122247945163252, -1.1240503410824512, -1.6386419418628049, 0.5325129802058001, 0.6923756533700101, 1.071750122119332, 1.1628631378371188, -0.4297402607597869},
    {-0.3879995951313092, 1.1586325918783438, -0.7194080733217209, 0.35828951728805764, 0.281547289027188, 0.1975309116929308, -0.6890898830073763, 0.29794791318854597, -0.6285258313108985, -0.9823338337339942, -0.42265609024241135, -0.11263279296578851, 1.1649075829682973, -1.1607512728921263, -0.542073442672527, -0.17880149812274637, -0.39659939785583825, -0.12940386935158257, -0.8881187659207693, -0.19904594513240279, -0.9915207979682024, -0.7808995238426295, 0.46385657905554983, -0.4619729987101725, -0.7925854762534267, 0.15722307302918567, -1.8291223996128856, -0.2725949285355365, -0.1725107241615997, -0.6043430039904644, 0.06076886842232079, -0.5938706255065387},
    {-1.91225602724599, -0.6338542457229455, -0.0569041673928957, 0.7204382878633254, -0.609235976326864, 0.6433813222032104, -0.4011156815786766, 0.8854871822893933, 0.17871842169981192, 0.8939338097764845, 0.13375583422505008, 1.5553645462869006, -0.5391536736113051, 1.482795098279244, 0.147475795500768, -0.4519683904842985, -0.8217860023602849, 0.4674026268059504, -0.022206291344654846, 0.029117009200938397, 0.5328172112818879, 0.30826402316329604, 0.13564204233538166, -0.8549816983306378, 0.5801101364159801, 0.6237791620761537, -0.017087413756100966, 1.0471889340435465, -0.659349070399986, 0.10679436602105535, 1.2377436971042832, -1.2137399487341347},
    {0.9233882620087404, 2.561502645586782, -0.3545642058641825, 0.11962914484541852, 0.9007369622875133, 0.8873733433175367, 0.5665059155554483, 2.4248270992821945, -0.47607966678174674, 0.25811574761957173, 0.889908488110063, 1.5841993826267802, -1.0576113733508266, 0.3557095427766825, 0.19932923404397543, 0.1952640723816896, 2.842891340498432, -2.016244700188026, -1.687641608940973, 1.938835531571044, -0.8096129356621419, 0.7418427612490252, 2.181980805516888, 1.1080123442707828, -1.325954415418341, -1.1962631439564204, -1.3957731916882001, 1.4387214163026263, 0.5155839086297238, 0.4389390011040473, 1.4702924885343993, -1.1633433850246349},
    {-2.256007302675743, 0.4064401451816842, 2.275879269121948, 1.1577028142788173, -1.054729203550251, -0.47673036057151835, -0.4198780508397085, -1.1626612632299305, 1.5155323188707988, 0.5330774686128429, 1.3105814392601363, 0.49473362823061695, 2.210976038832221, 0.8187335398343688, -2.0625090031368023, -0.08930775483403516, -1.096914099237821, 0.21590256366107627, -0.3845928179920216, 1.3307482690507129, 0.6308492661288035, 0.28320556659856305, 0.07839704196686668, -0.4561722695183445, -1.282757885019568, -0.9297377713865738, -1.2020063056400374, 1.541890875375397, 0.13051365385929237, 0.5334852229973236, 1.685106015387637, 2.116251926968297},
    {-1.402518721988504, -1.0573919624135162, 0.9429272271655865, 0.8394102092127205, -0.8291497598630361, 0.2678770241950079, -0.48052975123744124, -1.1378521037559657, 0.5981885299107575, 1.0205863080567577, 0.7214994652742891, 0.9410937838481068, 1.6049171942714697, 1.9806158632252724, -1.978000097931354, 0.033453031198808256, -0.9520106155643764, 1.060396588130092, 0.3784696751323642, 1.4729888679102374, 0.6173783489049192, -0.06071253040513114, -0.24227192271270312, -0.04029576696910552, -0.08918455434085328, 1.2324904711226323, -0.43134376486832254, 0.6345461809134917, -1.0245404879782267, 0.6944629508600106, 1.7669749790608305, 1.7245941783264946},
    {-1.0783406456008735, -1.8954782468605433, 1.6895892798273113, 0.3550065246772912, -0.22363933035834663, -0.8691529515645582, -1.4515378953026115, -0.8014123189908279, -0.6388215809947306, 0.30143193532734625, 0.8587036158990645, 1.5812399161958886, 2.652563983589415, 0.23313492367247937, -2.1911782378678093, -1.3776169412505823, -0.5319856451152672, 2.341719133982268, -0.31763097340279334, 0.3234336208059709, 0.03345966715494565, -0.22567147024093792, 1.3886488816106892, -0.38914248382797056, 0.06695567420344614, 1.38034082260778, -0.13630898946714934, -0.022478056466638432, -1.8850302480967118, -0.17310088390475944, 0.8555851511319121, 1.8617792743933372},
    {-0.55185783139417, -1.4337271765236554, 0.8803922307582558, 0.7923141155675049, -1.3720113524134623, -0.01496471754165856, -0.6363435668619937, -0.8350652865794614, 0.5631805651953615, 0.6043132692434667, 1.3264721356894453, -0.5482415004928354, 1.587710906213648, 2.779873130558702, -3.079865008992588, -0.38505374376853596, -0.13463154481117895, 2.556403075960085, 1.129860885548637, 1.604310135192384, 0.04911228820489443, -0.908092692947961, 0.3189961602776448, 0.4555243688209269, 2.073061902172902, 1.8561028026942574, 0.885460824014126, 0.5895265706326617, 0.20990181184398038, 0.3051151439347311, 0.7965545421407966, 1.2483004601594356},
    {-0.881453804746718, 0.6965343097423051, 2.9031730310828006, 1.8905217828835594, 0.581408336402813, 0.7386862142635924, 1.0219683177649765, -0.8962490423418176, 1.7758141787086075, 0.9851429560006629, 1.932697835213459, 1.7329254814997521, 2.007551634319084, 2.5516715715046994, -2.4983203764078312, 0.5287585435898262, 0.9780014937706709, 2.5497376680388775, 1.2005557350457863, 2.7310076042172273, 1.5027090193096073, 0.5873435944276438, 0.6943059751890083, 0.4773276991149126, 1.2305884410497427, 1.863395363331375, 0.7884702280338017, 1.204913794105823, -0.5810997470478744, 0.6384006603223319, 2.345351615077345, 0.89244555638615},
    {0.3290766636316829, -1.146313353423483, 1.8276977674617059, 2.1183047867420686, 0.30492125701753847, -0.04867933658643735, 0.4018917730133218, 0.8271355841078849, 0.19203372636839353, 0.8204636775178272, 1.2646169899345472, 1.4946700529229866, 0.04869722260131841, 2.3083953249839997, -1.373771460081957, -1.42668537902987, 0.2271277670872499, 0.2248065297061136, 0.6751428033928145, 2.311849629926196, -0.12786513274937877, 1.109275900854017, 0.12939742837614096, 0.6047011060920358, 1.02393788143906, 1.403119727873561, 0.7476695331048581, 0.8611045941447636, 0.9690759649002579, 1.0848609767277335, 1.8849570666142057, -0.7025787771610438},
    {-1.021292436056864, 0.15136347695611133, 1.7099249866858572, 1.4680282544210486, 0.6740978262716771, 0.20595335692377278, -0.34510520482812573, 0.2996934071404094, 0.3120544854252123, -0.858425705491644, 0.8711994985280952, 1.3508207334513642, 2.397419172962873, 0.42122443867387566, -0.10919481367885234, -0.4422272212415754, 0.29051507663305526, 0.5932483357690553, 0.36501906025404696, 1.8255087444444122, -0.10802068195968574, 0.8629407689902427, 1.164593790779091, 0.2605910427625207, -0.003838582892884314, 0.703472638306855, -0.5418433724269078, 0.03270443265279488, 0.3741325247300314, 0.32255115337067386, 1.8032103441645333, 2.4269130832108465},
    {-0.5922716896298604, -1.428117427166258, 0.17447143832238735, 0.5037766750499825, 0.17086051700576652, 0.42708735058255376, -0.6316339293712357, 0.21738475454273648, -0.476910378610846, -0.09444041671805659, 0.8614673885143221, 0.7157720355748279, -0.29899772448093576, -0.46402150575420253, 0.0758279804771437, -1.1378643782992703, -0.36977123065079986, -0.5731557514363443, -0.4588760673923892, 0.07724297403434381, 0.08735239330982, -0.18983714026206816, -0.9503501280407708, 0.371346367370686, 0.437568670273392, -0.022445847031060166, 0.3432957006626473, -0.28895615158742466, -1.2331974718373324, -0.18905288611919469, 1.086751102506087, 0.3274844886106938},
    {0.4055720465779895, 0.15362098894577098, 0.5787106386075463, 0.5364043823918, 1.757196018863167, 0.8740215742958589, -0.29314275531939993, -0.2161453281535381, 0.6222695330852657, 1.6891914400892551, 1.134185615252289, 1.3349321572320545, 0.7292232283228005, -0.008424050844845155, -0.29091525846159694, 0.27090197772652524, 0.21540835721555354, -1.7889092775650688, 0.9338314959299849, 1.0672297590616735, -0.4344336780924567, 0.5936230548210948, -0.21219620574465128, 0.9121678644920673, 0.10696007619624648, -1.3426296647091418, -1.0599917283078464, 1.9675217213243577, -1.1794716866556343, 1.0590310741043807, -0.27989435890107656, -2.0666612745420303},
    {-1.5559509437204029, -0.5705930470146434, 0.7962420162224817, 1.4699209239478033, -1.265249967513371, -0.09539184689259926, 0.2761519909293469, -1.0442872600476907, 0.7552368589634254, 1.0552420634826738, 1.040017065292779, -0.3791585759742018, 0.6046938933362688, 1.1113597678047218, -1.161412178876925, -1.098012202620023, -1.6303991501468187, -1.9307110216406205, -1.3038158895973342, 1.1253163421980237, 0.5471030973846783, 0.24189513881870217, -1.7215587026442194, -0.7515822021041828, -0.6076813727681134, -0.4429761729369164, 0.6849779801837418, 0.45543981514324583, -1.603740091989989, 0.335043447132491, 2.087129627045429, -0.3203017313619158},
    {-1.256492365869335, 1.4375519321504122, -0.4231840719792401, -0.0963517015570832, -0.41126362648786036, 0.08175962948058038, -1.706711929901291, 3.1517590717681254, 0.9541768346290933, -0.7795560695887361, -0.7287749246034515, 1.3387674408159294, -0.09775167577133914, -1.0652682621512768, 1.749935264665937, -0.7997031620789444, -0.269832410251812, -0.0733957357828348, -0.7614385240966384, -0.009403391721285424, -1.1452544614585538, -0.03373673869201715, 1.4855190936938123, -0.9657358690885861, -1.0020302436675137, -2.2577945903735963, -0.7898261590857466, 0.5712560556052427, 1.102924507552033, -0.09080791335992489, -0.9163929048114213, 0.48682223365302457},
    {-0.9083831563381201, 1.089785304954783, -1.920339376624169, 0.9357232123193552, 2.0711938409110893, 1.827785932134542, 0.8306829099491344, -0.33759691769709743, 1.2250803126023337, 0.9149631298502691, 0.818186734984875, 2.1113103531244937, 1.734231320286029, -1.0146278548523684, 0.12945726609966687, 0.962321645901887, 1.3730937534013061, -0.9948626577311359, 0.627716680586456, 0.9723051032362304, -0.5136413961389192, 0.30047203020163193, 1.6408327013441026, 1.2527801674099712, 0.41471257752077123, -1.4049517635424607, 0.1911069952645648, 1.58473348303858, 0.8811047344463325, 1.124435471054565, 0.430802341747619, 0.6631055261541616},
    {-2.1700918929518282, 2.406615372789601, 0.531884844344746, 2.369955996746894, 2.5068674529866595, 1.7023301988609705, -0.1166079585159718, 0.8925173258841098, 2.4060290503170743, 1.3864413976672632, 2.6849091982714017, 1.5578033320730484, -1.849107338151308, 1.1616220310686396, 0.4073692193820489, 0.35327757809508264, 0.9808694442992874, 0.5892399733400702, -0.8700460504273188, 2.0914463323250674, 0.9569496234114372, 1.6253726863421472, -0.11841574806762677, 2.066424780297818, 0.004118614130016047, 0.028668372838460264, -0.9735113950049951, 2.1211696296780382, 0.600850770722569, 1.2686345108308936, 1.2033683592287643, 0.07320825311253505},
    {-0.9662701286445128, -0.11216202369562177, 0.33242379177138764, 1.3678218624245424, 0.9823843863873911, 1.3123331346054248, 1.3538381871640777, -0.36524097828231133, 1.1303258316575764, 0.3586043628613116, 0.2880885135616738, 0.9511448933663548, 0.3829169822077703, -0.47285841951342583, 0.3760834340625362, -0.037925666104331734, 0.6305963736788647, 0.3550329327838098, 0.010531102670761919, 1.5923881527792318, 0.004943275221635999, 0.474561917504052, -0.2029284695673802, 1.9258957965271428, -0.6874927769174366, -1.619756248695572, 0.4960441583405683, 1.9405702717146682, -0.587354069063162, 1.201798407403999, 0.827021273491017, -2.450517623672447},
    {-0.6150174290291576, -0.30631219787388964, -0.3006055759023314, 0.861075566547503, -0.254551429733234, 0.7778868891074001, 0.703528140883887, -0.23473781302915717, 1.0145181307198887, 0.14699279851448394, 1.2384418031884916, 0.9325161003541391, -1.205187028552064, 1.177363721389904, -0.3790661896570714, -0.3634084394331044, -0.6895262228092633, -0.2196924920654582, 1.0383557349313306, 1.1984919295167058, 0.6182091578493597, 0.6894068860781135, -0.3724723744118775, 1.3392707437340892, 0.9648221269710097, 0.8810797598661521, 2.126684954137095, 0.8996830848810743, 0.3078304324058688, 1.1333832251896554, -0.14673607283358073, -0.8864008765104693},
    {-0.37942484446101743, -0.18532934565171383, 0.6054888675923554, -1.3258833688163536, -0.28771959043109574, -0.5225359180702466, -0.2507647690421881, 0.28806375931465383, -0.7574192022686457, -0.2750908806842812, -0.33652708596897507, -0.5927565453967961, 0.2520796708446299, -0.45621643624352953, -0.6834760267222426, 0.043481838134390945, 0.017969908875368697, 0.38374004581957566, 0.8730349434202478, -0.45452577609772515, 0.21134136957006797, -0.5734572563985904, -1.3782605297171253, -1.0004588685429863, 0.2142596873324331, 0.8036600205592558, 0.07447430993651007, -0.14539050625319438, -0.8983160626675222, -0.7720987147354338, 0.5391552968602379, 0.07708619824032738},
    {0.20922495641396627, 0.06860814444545295, -0.24520097450955572, -0.40197189654017057, 0.29993592124263324, -0.347839334619741, -0.7573018557339319, 0.17157566661066345, 0.11716311194359746, -1.1236889846548241, -0.4971020005579369, -0.5343610805085214, -0.10730347735702363, -0.24296453775227825, 0.8411270881979526, -0.058381966157708735, 0.16441079517974708, 0.9846461640182607, -0.8295501180728918, -1.6800155482081962, -0.9752754763089253, -0.13396732371821746, -0.08875212585387768, -0.17696590475695576, -0.5615019116206014, -1.0421425818760206, -0.8527264792733823, 0.04130229031242241, -0.1331638604615686, -0.22846035318532446, -1.200361635519232, 0.49123260558191795},
    {0.256081193448193, 0.7144602143064294, -0.43164305491103394, 0.23172333071562054, 1.7169809924406307, 0.28151892717216265, -0.45709413709289715, -0.25486191529343266, 0.3727238935521846, 0.22200422508744133, -0.36898456398696783, -0.03867963638491242, -0.27852167109524306, 0.5097247970751222, 0.5431675154152853, 0.7346848973345128, 0.9609665560650089, 0.25695116399163426, -0.2683974459997656, -0.5613512745622457, 0.10201545921963932, 0.11712789832712618, 0.9082307854709383, 0.22323362881781286, -0.7137999839437407, -0.06123957572871631, -1.2644959914121612, -0.447125327586219, 0.02406558802464157, -0.11830786550398029, -0.4717772236928763, 0.08056398244742007},
    {-0.46338017105499657, -0.4530991776421011, -0.3861636337178138, 0.5272747089502469, -0.3334118873562462, -0.7700441353615982, 0.5986808226545416, -2.616018466919641, -0.8577153696204891, 0.6234521319303651, -0.2308246367664485, -0.02533262367155687, 0.3231740071608783, -0.11302207486591542, -1.571492878027152, -0.8722833935416338, -0.4467075816921064, -1.037647601358075, -0.03241875191967155, -0.03668238976964234, -1.4707896449513185, 0.19558723549168816, -0.5485884081686175, 0.12076960248869514, -0.4624080432172347, -0.7881520537475722, -1.120736783657053, -0.6914742452904437, 1.3405790888199176, 0.0046584983542098226, -0.36012750976756214, 0.09742547890238783},
    {0.7742186353408, -0.09856524363151858, -0.38974160952552495, 0.5253224637827614, 0.12196756931539514, 0.21422989944958115, 1.0516307646047907, -0.32245524823273813, 0.20918502161461036, 2.083496502813429, 0.649850154359521, 0.4978559630366856, -0.8454623029993917, 0.16872192538605743, 0.6136823556218224, 0.6137605887024491, 0.29294477035772226, -1.1096280388824522, 0.6625788884909546, 0.8952463714932959, -0.4999510683434924, 1.1237120463930452, -1.017233726870444, 0.4914526384338026, 1.0589056117446094, 0.2987121899983359, 0.3228613834119672, -0.3194659318023351, 1.1685367921233376, 0.019662142587712515, -0.3998849416595043, 0.37417627878355125},
    {0.9129653265199591, 0.3599373480292606, 1.1496008007819658, -0.5380325446642555, 0.06931431002409653, 0.3671038212727423, 0.05302020733714972, 1.9587888078263562, -0.26141590951829663, 0.08376916420502085, 0.3577312739218263, -1.0494481148140515, -1.0919834948387177, 0.22780783259128562, 1.2930278375690696, 0.6156342751955033, 0.07967556181904276, 0.4486327213511606, -0.7356568474051408, 0.04572217503743087, 0.13489623997221803, -0.09138148144839014, 0.4037869699574458, -0.5012561674131585, 0.40990969277686345, 0.770845672361286, -0.9826513577312911, -0.4141720127141616, -0.8096888397484835, -0.6665002577393003, -0.29894516394127374, 1.1310651746743234},
    {-1.1401814241659185, 0.03258637995363743, -1.0459025954006034, -0.38130323731386173, -1.2465463587125503, -0.3082994175439051, -1.0754302848284922, 0.4331287799920735, 0.34286662901364506, -0.8122644142534756, -0.7026251246985946, -0.9370881322383214, -1.7857202135041517, -0.5811504690633723, -0.3322324285541369, -0.8868279099788435, -1.247894874584681, -0.055342157955000915, -1.1520860672369853, -1.1756975328930692, 0.4462842613599749, -1.203087970657824, -0.4416923160957921, -1.0947076707522194, -0.7577476928715731, -0.5289499433158329, -1.574105079352568, -0.7306156957873204, -1.0482452217463725, -1.2266344856189093, -0.19487949875384003, 0.008708646272600883},
    {-0.7307233778286871, 0.5919861700075936, -1.6634781239917396, -0.0013530233518769495, -0.3597204313506064, 0.1625409261130655, -0.733840995950275, -1.1434947025516713, 1.295077386838564, -0.4122888697918819, 0.14276719354431422, -0.4972218388982472, -0.41799841610338206, -0.4589635801900996, 0.22156394447355293, -0.2552701451391605, -0.49218720820606676, -0.3415455874136218, -0.4206930051027059, -0.20418568995761485, 1.6307488024076808, 0.6322713009876909, 0.5046376008206436, 0.06048583796573319, -0.37033668348062715, -0.38575326664935455, -0.17309444327660106, -0.6247960672053079, 0.87427884813328, 0.0174143887275378, 0.05372150681366457, 0.2215849950195372},
    {0.9397624448741058, 0.23821526944569738, 0.17625795850666173, -0.946647129076519, -0.2989318003663909, -0.349853315927766, -0.6472266796525404, -0.6181551766411885, -1.1961161577960386, -0.8291625518793676, -0.3964058660967185, 0.34094643974136385, 1.3621344749876312, -1.0464272778653048, 0.04467999308339611, -0.4538846465336898, -0.12144443013109751, 0.1372962644386188, -0.24033449981317836, -0.4845420550842844, -0.5253253122060176, -0.5164126935388418, 1.0002478749534396, -0.20212010818575143, 1.2386418315071106, -0.1711032015280207, -0.08961872750330774, -0.5891269853076597, 0.5881733907050715, -0.044935105032365474, -0.22201735391066438, 0.9527088354359389},
    {0.9382592941407158, 0.4169170344627212, 0.9419903614845805, 0.10194414317266112, -0.7810026970654403, -0.8030219121223654, -0.2682592510068184, 1.1354501173849447, -1.8966354540541648, -0.2903067592772545, 0.0021253735327498393, 0.524341358709427, 0.1352819263480547, -0.8894002866460683, -0.5325089710436053, 0.07432782643621709, 1.175960319642541, 0.3427913726516279, -0.042673940654328675, -0.20135952652482572, -0.12188922576578627, -1.2400674011630468, -0.08699700454846684, -0.6119339433459987, 1.4782721847279654, 0.17097053608778168, 0.16708068086347969, -1.1002118038874529, 0.28325794841965324, -0.3700908973642216, 1.3397828577624182, 1.2907906899822699},
    {0.5578104982382088, 0.004982799097755365, -0.8545066776779521, -0.2002344650242698, -0.22673614778181175, -0.39760878036322295, 0.6483013382982649, 0.20472525711841655, -0.03417569077504387, 0.1544898760699549, -0.44987796587292284, 0.11529623656722847, -0.18447102462118345, 0.6110895879137546, -0.3070207797872265, -0.11955072012608144, 0.0747890680877389, 1.3375673984016911, 0.03636124272887784, 0.729843333287256, 1.3083534894000282, -0.165049767218391, -0.6159530184484928, 0.6323401314800812, -0.3714186635124958, -0.024947306405844392, 0.8542490202316327, -0.6485907813188041, 0.10889518330269148, 0.496021180805759, 0.8278555413332305, 0.03360006248066156},
    {0.2190073763715573, -0.2743786025178961, -0.4466638105527443, -0.6450636290518735, 0.07477977963056232, 0.37143612981406027, 0.7510156030850802, 0.1376758272244724, -0.04432363550022114, 0.6301326059172516, 0.3077455948822396, -0.43005534903967463, 0.3697481704065429, -0.21871839188796352, -0.5054616620662805, 0.1598838578984621, -0.2006813591542942, 0.41094049080997797, 1.0315765128139147, -0.20454496196893626, 0.8257158638510308, 0.5309502203221103, 0.10728235138085415, 0.5216148973703569, -0.05143683964043258, 0.4514133025697744, 0.5078720166539653, 0.5322733767475041, 0.09232929197307735, 0.7687149655691203, -0.34458924651177203, -0.6750293552826768},
    {-0.42902236613112965, -0.6888745051145261, -0.4271075081163186, -0.4626273107184993, -0.4024754265216483, 0.32870830454441163, 0.5852045318490334, 1.0981749293931307, -0.27072326830773263, -0.5334863488103446, -0.626915785898385, -0.8252033125218639, 0.827028294438903, 0.15698199203280264, -0.001256521464166099, 0.3930602951366781, -0.8204565068142754, -0.7960703595688023, 0.30190053180563614, -1.013167433105967, -1.240497870221034, -0.21802817792620474, 1.09953574098791, -0.8667820365498304, -0.8649224843681651, -0.16049772654272337, -1.2235611305791152, 0.30363121987771763, -0.19316622895447452, -0.3351114130604177, -0.46028262942630943, -0.47265892147850863},
    {-0.7371755406533639, -0.7929260119027797, -0.07543107534247455, 0.7706281983894597, 0.2617088030211697, 0.8130753729728779, -0.08168299699867795, -0.08698122621550818, 1.2435063906958082, 0.6146114353067208, 0.23039748260057388, -0.057970637671081605, 0.5691331941029234, 0.8600536198402126, 0.5326802193581729, -0.012213289371157236, 0.0825129433295758, 0.7656284134714272, 0.9639790113491973, 0.3021035993068983, 0.25663697016074694, 0.7047175462974756, -1.026244323145464, -0.08512369228198478, 1.0931808284382787, 1.6384710765558854, -0.48469998381766655, 0.6517698401376326, -0.34946037719057216, 0.423899918102167, 0.09531520773768185, -1.17567992331638},
    {1.1961657039681208, 0.37177164865024104, 1.437212605001452, 0.762511264284975, 0.6776981792714517, 0.33194850717429136, -0.419049960289182, -0.16742349954242466, 1.1583259393700327, 0.18849925145658938, 0.35662992268177124, 0.5473089515554385, 1.5135660491917287, 1.5588873109765224, 1.3207340249555957, 0.9615287253383259, 0.9069668031260577, 1.4370375972427103, -0.33596659217360075, 0.441770495714053, 0.5924827019275095, -0.2875757816132967, 0.758241979858237, -0.01084725084693055, 0.5452736612949146, 0.9745888984903922, 0.12716105542685915, -0.23757550160673435, -0.24463419070938014, -0.41624478641121954, 1.1556405412269048, 0.6466946316295125},
    {0.7874822936498403, 0.011081776852697331, -1.3604953941321594, -0.9233181066279696, -0.321257254521299, 0.06536321183325064, -0.02244105869483943, -0.629460204340516, 0.18765689007826403, 0.4073263147222912, -0.14591301019915673, 0.6220898077068362, -0.9265455514801473, 0.9377780589201169, 0.9841471235671287, 0.4228242139814368, -0.1461564596658958, -0.6660517489413641, -0.7342172938554186, 0.23782900931583176, -0.3570425134706493, -0.0743321439901631, 0.9031502419948266, 0.2864667155235938, -0.5468211593014966, -0.23822372677386408, 0.49593208390815385, -0.3443983219073088, -0.41008725276786917, 0.16126389744424227, 0.3706146856750602, -1.3144839215932222},
    {-0.257024881957249, -0.21875020866552852, 1.1119779758820598, -0.2592045143179802, 0.020434938580439044, -0.6457093559290332, -0.026846788327321392, 0.3923470378725987, -1.1702660917333891, -0.2523433451654536, -0.4886615819972782, -0.5961144018957015, 1.3413256897962222, -0.6522640087664376, -0.19196398656003824, 0.5284772615893603, 0.27566009995472224, -1.7566782913666543, -0.5857566200782817, 0.3041396651556037, 0.10635354185060683, 0.7417087370666013, 0.03933338318426831, 0.3657493828992266, -0.29223975750098435, -0.24596027932413775, -0.10614435198928564, 0.0951254910523959, -0.6660513879650015, 0.12756739522730148, -0.743246163071513, -0.5998830795760631},
    {0.5680196602238037, 1.0849767334715972, -0.003220109240614691, 0.17501398087418055, 0.9088621086047834, 0.25960798577641686, -0.5755867959076167, -0.017997383954989423, 0.549332877666671, 0.153744868423771, -0.6303775686308885, -0.8737138086251766, 1.5977245616261948, -0.006018325794956787, -0.6808782444787596, 1.025410695813245, 0.39629230360475304, 0.18730891836916097, -0.7145742399273624, -0.14263777204263847, -0.05327426453252917, 0.09897460878655703, 0.8207222387289449, -0.319872383122999, 0.3819422413167427, 0.8297598673507102, -0.08121568865357502, -0.09207916483826425, -0.9759068210191875, 0.18722141693767708, -0.30402663542579766, -1.1073229668767819},
    {0.03373805797438424, -0.1321524360734479, -0.8050773216462128, 0.3792843799162743, 0.3674933772340222, -0.4187854548884283, -0.1593638364104215, -0.48402488673178273, 0.250675031708207, -0.09097695448379382, -0.7203736174309152, -0.21708302672224916, 0.41350113793511833, -0.35849873252456854, -0.5095600014154681, -1.0961292901433404, -0.3714012121278698, 1.3944781549885035, -0.2614917830802485, -0.7032405752435757, -1.9275844654985588, 0.14760768288031698, 0.07799896460654969, -0.3980851582999573, -0.1012658792555427, -0.2297413990824494, -0.8651137202320704, 0.1208211847532994, -0.23609502421550663, 0.347315325327223, -1.3639868317371764, 0.47727162637957266},
    {-0.24924280234036938, -0.547510996433996, -1.051985257860582, -0.31300834007748535, -0.619916822249178, -0.09775538115281122, -0.20191604325165322, 0.4937749332463768, -0.3100533930843068, -0.5975808397690071, -1.0079104274519222, -1.0668824921010136, -0.2514329147590359, -0.8139717095849667, 1.023807544110318, -0.7740803151850613, -0.35903303391787766, -0.36842813662966506, 0.10813736462341006, -0.970415224919314, -0.952311564898081, 0.08672244904996831, -1.4104886808704453, -0.8340708337383138, -0.21286404273147932, -1.0084590743949868, -0.1518282256866337, -0.2936738849130871, -0.1636082774404494, -0.28848656643203957, -0.556177553694937, 0.3140972573145218},
    {-1.731993197448413, 0.6104783935071503, -0.9275715587273066, 0.3409585824939956, 0.09845325078616578, 0.22411766285686363, -1.1186930169400984, -0.5585526091221612, -0.6541043357204377, -0.8575878453086097, -0.4177309726969888, -0.37149144953705876, -0.40408599465121764, -0.32811823529839224, -0.3350119405214747, -0.10918796151306571, 0.649090803620081, 0.4911405740372402, -0.9193110643395387, -0.20800257692346383, 0.6606289709415689, -0.7026663480203956, 0.536953839100442, -0.4013377153758714, -0.67649047557508, -0.9336889600235302, 0.5875924757898887, -0.6845790779092754, -0.44545021479796454, -0.09940134078368101, -0.2148806500489491, -0.10085908063229633},
    {-0.14502936272170935, -0.46796626446145145, 0.3339836749365879, 0.34702310123588503, -0.15333095408968908, 0.3901234136695195, -0.1283501584872343, -0.2766803952714091, -0.15846388635201622, 0.4823582741937344, 0.7604743068641521, 0.9015771443966663, 0.41872147680569777, -0.011054924530284244, -0.03391523888599521, 0.6890090341439629, 0.2642971316005516, -0.7374850080486516, 0.4453672799145295, 0.290910208913037, 0.2344153774129179, -0.6084393136931054, 0.8442807120575382, 0.721522603350949, 0.1437862998096836, -0.5778628444149599, -0.06551848135047303, 0.13091297756803955, 0.7340998959216711, 0.09557842117745231, 0.8438392650614331, 0.5687441245214653},
    {-0.746547979677828, -0.2965376996532174, 1.5091930545525711, -0.29017018041388276, 0.889821269947103, 0.3784946748024888, -0.1745812738728425, 1.077379163178865, 0.02089381473764023, 0.18457450926799382, 0.25823787142520743, -0.5363693444554838, 1.0987320697616878, -0.18385279083898562, 0.6383737995796072, -0.6171794135966984, 0.017452419390195456, -0.34966959258270064, -0.07533415070189795, 0.37725273497607165, -0.025524258933681918, -0.24059516327102717, -0.6939851366114901, 0.29041822040107973, -0.5378518224594109, 0.14096878513417246, 0.04806587920283069, 0.2620383594758499, 0.6898311673353399, 0.23357155063302212, -0.9365903517009302, -0.4708815811975001},
    {-0.6282634986038221, -0.1891236247279691, -0.8620568151862331, -0.6427208380945525, -0.04878415268153348, -0.31777623829013313, -1.1311355456826309, -0.7400191586459846, -0.13557795242810894, -0.010679877639913897, -0.262227029126894, 0.27408362395895514, -0.2983521307414468, -0.3460219317241571, -0.1914815469387177, -0.9217127651198846, -0.01956310128158827, -1.2941010607030077, -0.5220733578637686, 0.2021512392104317, -0.6585159232541726, 0.16324399496214362, -0.6400961360493016, -0.37613428171525837, -0.931724088225391, -0.3408747616759025, -0.6512978977673477, -1.117301481662435, 0.276276308070673, -0.03593235629685811, 0.6936760263601731, 0.44392549712540513},
    {-0.4917530817969675, -0.7609568194724947, 0.042617010904859795, 0.23233188177110392, -0.7165770604800963, -0.654123552812214, -0.4708645181477556, -0.4730918876719812, 0.01684782623035018, -0.11746603453128, 0.12834885386253994, 0.14540276992425588, -0.359051938275242, -1.0912079521926166, -0.47191408485168507, -0.3380372401606945, -0.3094770070327388, -0.8827164458162626, -0.4655312433380466, -0.5414960630082374, 0.12998810787960008, -0.1294978876116364, -0.5404980776995505, -0.6669107605303406, 0.38626411390579923, -0.074916485986934, -0.2508476210902028, -0.649674485086823, 0.07104374069444111, 0.016419853403418738, 0.9489455135482899, 0.3166095039630349},
    {-0.061738635312503586, 0.6607765802973615, 0.530526090322459, -0.20979747158548284, 0.7304564850329038, -0.4870079525245655, -0.24394034248780758, -0.299274649464386, 0.07077863168149934, -0.9006294846718184, -0.5716251499239393, 0.16899457812352003, -0.9284180639436015, -0.14377745791489585, -0.07653222200441585, -0.6584234333418183, 0.5939869083807787, 0.4507542747815274, -1.7211512250718954, -0.9913560473845942, -0.6422047886675477, -0.5062403090895794, 0.3740029647271169, -0.4816717190526246, -0.3845299895548603, 0.737291027080011, -0.49136725102357726, -0.6957623901907394, -1.08217845509211, -1.3101593203031738, -0.37959722484558306, 1.1387356508774578},
    {1.0450357636754461, 0.4508093162709675, -0.03440758049377889, 0.25231695582614855, 0.7517220339196157, 0.15525365259439164, 0.9335037432713736, 0.052985780116233484, 0.3211644164786155, 0.8157608055944745, 0.009478045222393497, 0.7563581052335978, 0.7247173052461896, 0.4655736515256726, 1.6287801580349583, 0.5574092997524194, -0.35825783347889856, 0.4055248323322599, 0.5342827557497422, 0.2742933165336445, 1.0462099329356718, 0.03290410118180468, -0.6762549951964113, 0.22696877071121976, -0.01222558983850627, 0.35434791175848945, -0.37784735671720765, -0.08609985205309437, 0.6841785380246211, 0.2684582386653636, 0.5476878771796038, -0.007586066370094949},
    {-1.8398281130268126, -0.9135810549872064, -0.4769916251600078, -1.205783404873528, -0.5737929679188772, -0.8568084638491765, -0.5143149072401335, 0.8904560543138651, -1.0523026603209664, -0.5360891528221787, -0.6283227561361315, -1.885419906147418, 1.637756715004376, -0.46163658959783066, -0.9349002418348886, -1.0392580077033304, -1.3256106825807337, 0.814607033512726, -0.3080408242208341, 0.23673623293567306, -0.6663300968602123, -0.8129046916785015, -0.7393134248297784, -0.5103530694717779, -0.6999975738873288, -0.30939811734941924, 0.1054032134465347, 0.14727899077587422, -0.8317250563884598, -0.23611608109133775, -0.37576635005026565, 0.3682673199040726},
    {-0.373853797079881, 0.739834012893731, -0.42851723780865375, -0.17449648476307678, -0.18944494038816503, -0.08173677856620915, -0.4021557580934181, 1.685427248720874, 0.1274875650196238, -0.38121897738965893, 0.250415147158587, -0.09716739804112091, 0.7035190566261141, 0.6517186392298059, -0.14676862094512977, -0.0010125359386367683, 0.4595617914573741, -0.2093502622181874, 0.0836350921442889, 0.008884243128670335, -0.4865822286950972, 0.503442607464459, 1.929706056650152, -0.6124199064866223, -0.39904065325345794, -0.8550991448397035, -0.392653875432556, -0.23176526999859354, 0.23252754308155815, -0.03981452729617448, 0.24545260064473673, -1.1346241284647973},
    {0.25188790002360906, 2.160916412812857, -0.27099100553423633, -3.402066717011061, 2.0240472360511594, -4.635414759124702, -4.6982703399294845, 2.438883024332678, -3.487919187843927, -4.7293283943924855, -4.707495383283167, -2.9086609608069693, 0.5348635760845684, -5.656536795775212, 1.0369098387554347, 1.247696215294888, 1.7184513555346026, -1.2138142299632075, -5.697117460348573, -4.688461475522495, -4.115702067919668, -3.0114069673607298, 2.2079454776318705, -4.062046610132415, -6.3323641469979846, -6.1407102578688155, -3.0606823699217833, -3.5791554953865576, -4.6940020414679635, -4.455105695892649, 0.2593422048837996, 1.140271317896182},
    {-2.991618041644919, 1.0276783722752372, -1.5981142064303475, -3.6318073211583095, 1.1362767543469818, -4.237849302135316, -4.883833062548645, 2.4628471145079707, -3.91847861544832, -4.925484907857419, -4.371456580983092, -3.795238425717492, -1.1510960324484267, -5.784094558195024, -0.3798380078396479, -0.4048113372360445, 0.6320568350662508, -2.7390801867169396, -5.588525846060243, -3.796363248454088, -5.158335291307831, -3.875974305099445, 1.5374222402743816, -3.90017881160679, -6.238151756276156, -6.217021679574155, -4.249096790558521, -3.1456845980660937, -5.220072780274133, -4.36834276994424, -0.6682454331060468, 0.3284903616442826},
    {-0.24473147155427113, 1.899211189163315, 1.91352872703574, -1.6916210178027589, 1.409614927264512, -3.244843793528448, -3.477602105801334, 3.322190809593358, -2.9003786133861125, -3.3580917450598533, -2.670362091785421, -1.662772120148062, 1.5508086235350191, -2.111077971332996, 1.1663211471874277, 0.3331496952330272, 1.2246139585175633, 1.1772666541691237, -3.5845773885329364, -2.8651760203574477, -1.5745326168563636, -1.4824636786788898, 1.9156380502529007, -3.9761061664762916, -3.636358532574315, -2.151379389942069, -1.172717668139505, -2.865544634092645, -3.5949489665604726, -3.3086070812449546, 0.2578111338646937, 2.838314606846422},
    {0.2661107311402325, 1.7595712374011199, 1.6771026905514577, -0.5241473995104405, 0.980963320657741, -2.0836646692312537, -2.5296051344892367, 2.973555037618987, -2.5747097902155596, -2.216794858627992, -2.2055010745366315, -0.40579751650935975, 3.100187219761498, -1.7467084564150959, 0.7201485341805718, 0.6731476097408299, 2.2928953669436187, 2.11896059679797, -2.6041358762477667, -1.072513178690228, -0.9347698014852555, -1.2130491587323502, 2.5087200510665184, -2.35928439706653, -1.3580822291952739, -1.5046590649164213, -1.925630983710816, -2.9531494206105995, -1.9478672844056721, -2.3344533191180568, 1.406387085066746, 3.3463964811975826},
    {0.46344142358765933, 2.6153195195764667, -0.9030603670521533, -0.1912966674145769, 1.9132218885580132, -1.3160436212239264, -1.560958870409169, 2.855603444205816, -0.09762670495112519, -1.9626108670387472, -0.6725077617078569, 0.9473840630217057, 0.9801634263157257, -1.7681746019600737, 0.44551139228912223, 1.1429916560355806, 0.6922842123528727, 1.1645058590269346, -2.325985797496912, -1.696604201758675, -1.0276846088273233, -0.9362385968455963, 2.522260893083832, -1.0977664891361658, -2.389894901133062, -1.3867041308797752, -0.7979454411036158, -1.2045051739703427, -2.0347468469137056, -2.2911118204763237, 1.5649336813954433, 1.4308823865008742},
    {-0.8843425617854274, 1.7299152851409993, 0.30996642451565176, 0.1960377217581227, 2.1093810763273466, -1.2871021016499684, -2.732572174929892, 2.5119000378689322, 0.26112742044495785, -1.8965489553520638, -1.0550912648577069, 1.3465223300989364, -0.34140255165921946, -1.761303627309548, 1.2477943752533478, -1.3695488142714798, 1.928774189014113, 1.2354245953243084, -2.496386199022911, -0.9334520267465247, -1.7939529586713103, -1.5465591819325977, 1.1225369929910154, -1.302404142805641, -3.0410244157252895, -2.321371479999376, 0.8897404567821766, -2.4427105661379604, -1.4719799611231894, -1.3812877942155648, 2.150512083583533, 2.552478625344842},
    {-0.5240513131426313, 2.2037166778288273, 1.828186727396428, 0.649278972579896, 2.3316861345383035, -1.0731095941238245, -1.92030371266397, 1.2811761546896474, -1.588135819177926, -2.2234991631719208, -0.5718253870852319, 0.635259108626936, 0.6547250908542218, -0.9357278305041241, 0.7034891286589159, 0.7343603354896828, 2.5548521993492703, 0.9907093038160988, -0.792152672385572, 0.7385107076862764, -0.16537597517078592, 0.10941578223164675, 2.083969188084775, -1.058634651624373, -1.895506712091034, -1.9550863794094246, -0.45150511056760834, -1.7773946404054757, -2.112252175794866, -0.355590047681242, 1.1324060994538607, 1.9610961801407711},
    {1.486467058350466, 1.9486382473410555, 0.6301187262418892, -0.02272587211929898, 1.9326170750174076, -0.24882539663766426, -1.410808580045432, 0.6085099214550467, 0.1653169326043163, -0.10616575356261762, 0.42040195019518195, 1.5319943262384228, -0.33803048242581724, -0.7755910233731077, 0.8513996864920783, -0.02449462550006281, 1.4002085301794143, 0.5889178147916949, -0.4943781740663972, 0.011111637282785252, -0.8798762760573877, 0.11777584159319136, 1.1426142836757858, -0.6378314149515047, -0.7080148389391142, -0.906936139020556, -0.7694359854564359, -0.23091783801005436, -0.34927554233380737, 0.10633736602073736, 1.691629009373794, -0.08802675398719165},
    {-0.9172243908905411, 1.3333376394292331, -0.40892958659970047, -0.1730184636678682, 1.797208772696707, -0.9070988376995149, -2.8390939629622833, 0.28433025638324494, -1.1809903076274268, -1.322765381986456, -1.0538293159217371, 0.15360223506526272, 0.8385901282509174, -3.095637876629255, -0.5501817689373498, -0.17824618742616233, 1.734813739296675, -1.2674151495902317, -2.0944916675171488, -0.2907730284700866, -2.593096580952881, -0.6700156060458284, 0.34991231392195155, -1.0818638359826482, -3.127706519608607, -3.5515473525690013, 0.5201738809073488, 0.40717420629470175, -1.3393100086950414, -0.7260976180548534, 0.6726049470374534, -0.7152686436437946},
    {-0.5444677832779143, 0.26409208658436334, 0.7686386818114666, 0.17189367548298568, -0.5408508372822999, -0.3232533974608309, -1.6737600768104828, 1.3783098188665772, -0.44221900728042174, -1.0539148604814532, -0.7288163187470315, 0.651378052800973, 2.1244904288902533, -1.5199917917520163, -1.6655808293505465, -0.5148467908843012, -0.06295036046857894, 1.1975544033251075, -0.9798473814239516, -0.8035528000733448, -1.412156030293813, -1.085314762064004, 1.058405798606204, -0.7067887068657693, -0.14862466510626887, -2.1652080795795525, 0.46300535297686773, 0.3776740324131147, -0.11183414392766035, -0.058066743327920396, 0.343594706611186, 0.23671528399338382},
    {0.03131597766627819, 0.8663653213137174, 1.1824118796469951, -1.01902936026205, 0.998783613189526, -1.2960498688983846, -1.7475259129844456, 2.8356288515579675, -1.72745961985614, -1.7926220237818922, -0.9845953963803254, -0.1244085731588804, 0.4576619886870118, -0.5421468253535576, 0.07470917579363993, -1.2400019793378925, 0.9352261643540127, 0.6968528482386633, -1.2404301657674088, 0.039291639476173555, -0.5307990430169875, -1.4419836705053006, 2.262421568536073, -1.3198489271631317, 0.08734494824181553, 0.47556992156150596, -0.3014163736972244, -1.0180804099432228, -0.2031386429072454, -0.9294727683670627, -0.8153483072850818, 0.8598133596478216},
    {0.9109929072592194, 0.9768985655523498, -0.49502318672630685, 0.5786369678807507, 0.3278027467142793, -0.9798623497878224, -0.9588495551104965, 1.8229540222771237, -0.8056901710223859, 0.010476656980167084, -1.6591914927901799, 0.7756427274865382, 1.0157091037324255, 0.08009683566459236, -0.3505513393614527, 0.23784467542097598, 1.3159009163063107, -0.2545208212989825, -0.14754101002665795, -0.2580432842035859, -2.074943762717365, -0.30820509180851663, 1.6891298887539574, -0.5480402114334513, 0.5902195507891179, -0.39437477840833524, -1.5207351302129957, -0.4229970841565669, -0.3702717949380135, -0.019049074658909232, 0.04959114519237256, 0.008968487462263346},
    {1.2161280299856407, 2.157671760826057, 0.5545400301321219, 0.7250351612493786, 1.5369345147043352, -0.052179451203729466, -1.132104081293755, 1.628624891993355, 1.3474794703848187, -1.0712362358607437, -0.005184684962948185, 0.7600809667492635, 0.28470531913848524, -1.9419060060953057, 1.1863302916041591, -0.35085431543797474, 2.209055656549943, 0.6224382153376666, -1.3345231723426438, 0.9151677187002626, -1.4379745369907848, 0.20495029771052853, 1.0973855411410385, -0.44524239306594504, -1.6937452116941318, -1.3051181482636056, -1.7082188106225589, -0.028789231871329937, -0.31135181064265993, 0.2731770475066844, -0.22416153365999203, -0.42692581260522655},
    {-1.3597670945620182, 0.43472033841018476, -1.261632571908506, -0.47790910668086956, 0.07764154704292477, -0.624448452999134, -0.9522536916242734, -0.09573515363663222, -0.9824656212068167, -1.4058456307313218, -1.242427934736081, -0.7072492173308226, 0.9419554772475588, -1.1612357601526213, -0.552920729583871, -0.7194317637778332, -0.7951705277600731, -0.7251660710819998, -1.4921016005736258, -0.7234494241246623, -1.3594578775170159, -1.7339671650264088, 0.191597162371232, -0.852010297892287, -1.3147619870041056, -0.32079502950166006, -2.1066210798494946, -0.6730984908610833, -0.6675096607200859, -1.1316432202490334, -0.29160691845033576, -0.3371836359709848},
    {-3.0244686817092994, -0.9963503825846192, -1.9866402786852186, -0.5035321324282701, -0.5483468996539083, -0.2338115245769446, -1.5821596349322222, 0.49920227202182377, -0.8364146555446514, -0.2465185692530436, -1.0469871076976944, 1.012380460000682, -0.6319476878898576, 0.3582891108480415, 0.43702717732185725, -1.283027029331995, -0.8649995969840987, -0.032558525204096515, -1.0423862852917398, -1.4602514613576552, -1.0129658455426644, -0.3934774978279322, 0.22005960820658893, -1.5213010610252777, -0.9782811263155832, -0.839796460709118, -0.2061228847382507, 0.9851501118120678, -1.2966144133853537, -0.6283375033561069, -0.26387683487375024, -1.5445194302193563},
    {1.0130250680229906, 1.9170080057355772, -0.6595540510331763, -0.11847391236977316, 1.1450025932077532, 0.6672487229388095, 0.14832475126412514, 1.501583913446042, -0.20400410664315155, -0.2927677313747711, 0.8390317425126474, 1.6362984417776518, -1.127832831989593, -1.8842893376334844, 0.4168460227075106, 0.5272261578892418, 2.0149049640470387, -2.887925331388543, -1.1826570971562589, 0.7783614547265862, -2.1884715034789117, 0.7519972392641405, 1.620420890951831, 0.9592160672992107, -2.2387141071517327, -2.2334577995016636, -0.8438308533920507, 1.6621540387339695, 0.4730577402411248, 0.22589797144454882, 1.2387674639480444, -2.079166613227543},
    {-3.26807955356694, 0.03531218914678067, -0.0050852473277360755, -1.0630137357209972, -1.145042825760422, -1.839845984925171, -1.6577979117492914, -1.1489688320568088, 0.10388084318731737, -1.222340711530811, -0.43228488004533877, -0.7776603167152236, 1.5295577143934955, -0.8918524166416747, -2.3865661696405898, -1.3385828331096883, -1.494971162062007, -0.6799867038210035, -2.24466652470477, -0.3456558350133496, -1.5290996829693724, -1.4676812392584144, -0.6827237624762975, -2.1281472017237157, -3.4544397350787643, -2.773371006062565, -2.2612016251280886, 0.14075223474382376, -1.5740083666337839, -1.227144695321977, 0.6640966736759831, 1.1510529458214005},
    {-1.1919552818025905, -1.5418806198006807, -0.1741210172271882, -0.7837137063030426, -1.3752708528906878, -1.2774170304657342, -0.8555020011095325, 0.12964457575500302, -1.2590583555248092, -0.38976373860479074, -1.1133507260360103, -0.4059476947301106, 0.6421288050343604, -0.44158004835414916, -1.0959014500569504, -0.8028732324176008, -1.3648348749447203, 0.17173082100146825, -0.5713931680727874, -0.11995391070991002, -0.6060358026427102, -1.4958611667182373, -0.25390920351614227, -0.9688259338948978, -1.3403192905462984, -0.42071650622671686, -1.3442612445965871, -0.036347207649467146, -1.0901354416639486, -0.9130976694434589, 0.5044507603537001, 1.046114696059403},
    {-0.7269764086702168, -1.3847171084805376, 0.2479027898583018, -0.620077204553691, 0.1948920098466459, -0.9113539459936159, -1.0349481817906199, 0.016107749008598057, -1.3085995092624128, 0.05489566671272487, -0.3446376702255996, 0.47610744158506707, 1.8567952439237163, -0.5337172296395045, -1.5893324968171803, -1.302382673909155, -0.08154718782200225, 0.9141320765100295, -0.8977453278771077, -1.017427422017033, -1.0455966199234614, -0.3517200801355002, 1.1227297565393597, -0.5785820987486207, -1.083940924937788, 0.39734714163752444, -0.505819752800408, -0.1875596003534796, -1.7749380438338602, -0.9489148184908844, 0.5313962628254232, 1.1194486944825397},
    {-1.8417022820768791, -1.2267346591273662, -0.7621934306241015, -0.3857650913352457, -1.1204733354422092, -1.2528052933948117, -2.337797860981131, 0.21037715981446037, -0.9649105651495291, -1.1019367708746943, 0.017087905963536158, -1.2326498958534322, 0.5090911667812388, 1.1637553215099192, -3.170400388917102, -1.275456266273081, -0.6206126729897313, 0.26327009490450887, -0.48452661920416984, 0.5134249831569526, -1.4827268244512006, -2.072334468311816, -0.02179066375429092, -0.6478818557750166, 0.0993257015821425, -0.13555688290950824, -0.30630813902296034, -0.2301880294425923, -0.6250426690720152, -1.526450146031998, -0.4003423030159146, 0.04308264330454751},
    {-2.0145176665048226, 0.3893456108773832, 1.1779776706557816, -0.05723562477442811, 0.1449184556012253, -0.5088309532987132, -0.4502633674797012, 0.27289106524085355, -0.08765368534417277, -0.509257062653199, 0.5754098167959437, 0.8047060426227095, 1.1565022954661528, 1.1021977252062376, -2.384887055966945, -0.8030860807673634, 0.009003389812437729, 1.4533773866059807, -0.3031719669917858, 1.400042357692132, -0.1273768633873841, -1.1958377585302278, -0.33599720976751396, -1.1201740062930738, -0.3085792760988359, 0.34437333280558297, -1.1418210684537184, 0.19389217569654743, -1.5999452832663386, -1.1011384028636158, 1.4263325757232563, 0.180324895793071},
    {-0.3135521969314875, -0.8368883063560565, 1.9614382607091823, 0.7821411934484143, 0.13090291070695212, -0.8426894562036481, -0.8440585751069312, 1.3439263229537433, -0.7561763723049587, -0.3470294107092191, -0.21028680154540091, 0.2282985219577447, 0.7262747978616934, 1.1919557198802317, -0.8500853434997024, -2.1162640576800484, 0.3417658123883514, -0.08500580330659392, -0.28746152308706185, 0.8991037853313947, -0.7282062534429308, -0.07860439556097386, -0.5694650508209321, -0.20381816428066676, 0.1789977905327572, 0.5634969382259062, -0.1834159709519012, 0.6475321025706342, -0.07442573099957778, -0.02992825687492665, 1.1052085623888925, 0.24498400141644602},
    {-2.3192124934809653, -0.7608105895780081, 0.7382498472199155, -0.10472973780932252, -0.016620984318287308, -0.5007135529158279, -0.3745372122231614, 0.7139900993453021, -0.31495200141525254, -1.157747273959222, -0.04621711784390545, 0.24558938395577742, 1.9435696387891344, -0.01588528122314062, -0.4657996206428407, -1.1942324252341734, -0.8237050855551856, 0.5054097172910109, -0.08050645749518705, 0.7890654214275864, -0.5689791352454141, 0.0025507010947662698, 0.07801195316420226, -0.4057785881838929, -1.099586103884759, -0.6929031800170777, -1.904876531429968, -0.6980384672934794, -0.37470400130316067, -0.5571153532180623, 0.5837358464938839, 2.023079870543509},
    {-0.4486922334968369, -1.2668674530204485, 0.8632168847534701, -0.0010788535318819765, 0.5176390292018358, 0.44239389691794523, -0.40910011730225976, 1.1178285620314876, -0.8952822435757176, -0.4910858097248094, 0.847410325627756, -0.016379949305909292, 0.5589692629494474, -0.004149755484278252, -0.5081351433315575, -0.25445888685587537, 0.3135378276398817, 0.7806213379851333, -0.03364136503985181, 0.5002357021824139, 0.5733352535932804, 0.1997999429793248, -0.9494242454471361, 0.3597921755157906, 0.98678509990256, 1.2513092549419509, 0.11485963025815837, -0.11883678408476397, -0.9242866374734146, -0.30312784673872184, 1.0877837120942402, 0.8050802477554369},
    {0.23686102601711267, -0.010628005629951809, -0.3284058304843577, -0.9132865487520525, 1.4642253200890503, -0.27780565480091146, -1.603469283855153, 0.4778757019087227, -0.4960919493670146, -0.26964984233774225, 0.15972927633355324, 1.431213974159426, -0.36078652939145, -0.8190132536766541, -0.4486531762095705, -0.35628483875271927, 0.3230203070340878, -2.6111363217195263, -0.7010539744854546, 0.19890867711934201, -1.9236703340804286, -0.7585938236130502, -0.2595745495201833, -0.8587463279903295, -1.159692110405879, -2.1114382940426055, -2.781072063158245, 0.7855859341770829, -1.6768534171794816, -0.8989621468155268, -0.6076053636951856, -2.133451456206465},
    {-1.1619605194834928, -0.694486523158676, 0.8117699731571063, 0.47970170064826767, -1.4734464060017818, -0.890699104528892, 0.04187030168871628, -0.23582621946428015, 0.2769949048117431, 0.21058094470538571, 0.3364510006404322, -1.046758101317387, 0.003664433683355073, 0.3983228676669173, -0.5878408168107113, -1.5405585291099504, -1.6104485338272991, -2.2015597005574, -1.816345144552882, 0.1655166098206573, 0.07945332398457097, -0.4638297617716637, -0.9251739183748546, -1.3628864830774658, -0.800795807725553, -0.5931253105368237, -0.7095126103232275, -0.21063546613667516, -1.8261189334112555, -0.5351063121208345, 1.0236564650966644, 0.23397509124681296},
    {-1.9093920210464301, 1.3247948054338041, -0.5750444157562592, -0.9191477621697213, -0.3067404438597703, -0.4656174342047588, -1.7835270051808279, 2.7690824148432833, 0.4354043971229412, -1.2442592208614136, -1.6789443119736436, 1.1602182485915846, 0.6892730024639339, -1.9365551520383963, 1.8087817914639879, -0.9471301153035822, -0.6787284124534182, 0.18429035234575583, -1.2857175624950599, -0.8962641858702777, -2.1816458833350127, -0.46680152907922806, 0.8160355960748684, -1.817041985465708, -1.3000941040139797, -3.0318930498868437, -0.9453486003565557, -0.1643319059856651, 0.3697448618411277, -1.0437724827684782, -1.037074171148087, 1.4993686716377361},
    {-2.251534581972639, -0.39482167587291167, -1.3014805021156512, -0.913026453439543, 0.8679543247741328, -0.10073597577050256, -0.21570142203780904, -1.8993577756102977, -0.32413589865163495, -0.4596609523327959, 0.388392096666663, 0.8847414089434998, 1.1760618207174103, -1.3295548666160877, -0.7198125906159133, -0.6109951114837676, 0.008863616123441791, -1.1797888194313935, -0.06795852795701715, 0.6120775004146386, -1.0612901361609655, -0.6493686612449444, 0.5722400117016136, 0.44310248366364635, -0.0034253924661900234, -1.719341759618395, 0.06933198548299155, 0.40535411117897335, -0.6975672379514445, -0.37808981796575136, -0.21900144637890057, 0.4026512808329252},
    {-2.2893412612478334, 1.1179020312079782, 0.17535236352995506, 1.720569557736273, 0.9436346452957242, 0.4018051992106773, -1.5487537554285338, 1.0296404346297692, 1.6869337354509097, -0.02559678572241553, 1.0456643143246969, 0.36746655134395584, -1.2560889929233219, 0.7332636797882343, -0.14526707427592025, 0.057607124506529835, 0.25163034406428236, 1.09297612039386, -0.915870286537192, 1.3666638323017426, -0.013283654134474486, 0.7601467275522706, -1.2124882265083463, 0.8101617925516399, -0.7453722304462028, -0.3036058629136751, -1.0980205306597277, 1.0173724702701261, -0.3194427788058481, 0.6639099535411822, 0.11474441078427704, 0.8740225444899147},
    {-1.4595961709647227, -1.0483744585386234, -0.02967586924018161, 0.5808587485231996, 0.46955347388737884, 0.08912577042473609, 1.1734051061236181, -0.5745332952217987, 0.4722467202592578, -0.7368441892462697, -0.9054507349785017, 0.10271083378215483, 0.49937838644201893, -0.32224997245552306, 0.5043742165691321, -0.612675778016786, -0.018092400931158527, 0.5368668468999396, -0.14683693001189413, 0.844296945196773, -0.8664914350123507, -0.27850468374487675, -0.6459756173227374, 0.5709205452322007, -1.3828628146718018, -2.2746034623689253, 0.32127165756032405, 0.5205734411316566, -1.000030365341889, 0.3464196563838996, 0.6258954675789837, -1.6906055181247934}
};

static const float b1[32] = {8.234481794634101, 8.317540196892779, 8.29584622660059, 8.27461106512568, 8.370829800121962, 8.16257119510944, 8.190435751880456, 8.54830858868281, 8.355550808015762, 8.288242085640388, 8.143205470989978, 8.405650211899887, 8.543676540242723, 8.390745610866057, 8.368945663177266, 7.802078734794397, 8.179951555892597, 8.582956214116253, 8.074226812766806, 8.397324476196683, 8.294793785356804, 8.072334393596387, 8.356328630377515, 8.266339311304668, 8.25105799971921, 8.439918424104949, 8.282796684561164, 8.381802771628054, 8.326141897849771, 8.02765797863762, 8.432804404358642, 8.341137995255044};

static const float w2[32][16] = {
    {6.795967017421516, 6.7338381846631075, 6.934173547325282, 6.928065724969918, 7.40534925376733, 7.2577039316572245, 7.309209995499793, 7.249097030050176, -0.40041929961354056, 7.490584528259324, 7.442003015430042, 7.742911048783824, 6.826659133333464, 3.453636036744114, 7.327638594707557, 7.159620194547148},
    {7.633236194054207, 6.8443140129187965, 7.531846594766713, 7.271371748915407, 6.912695498433944, 7.587124578813843, 7.841098096032639, 7.203380219389715, -0.1834041304850916, 7.120109218511549, 7.4030509276422745, 7.149205251558361, 7.404303243141296, 3.901304100934336, 7.443352072400267, 7.211305981619489},
    {7.698040558769413, 6.962328739049169, 7.965755979466129, 7.7837296227415305, 7.325487481005137, 7.3025278803446, 7.504803150428178, 7.739790468252705, 0.06977670667440623, 7.528259735375928, 7.732297586459285, 7.651181519091025, 6.838374249523245, 3.6207533466158517, 7.288359662604777, 7.404998547338182},
    {7.086817469938867, 6.662201119787292, 7.597314499952307, 7.684527233439117, 7.712251039333512, 7.98016727668133, 6.989749460958522, 7.6494594347875084, -0.13378810794595547, 7.82154101279138, 7.884483769596348, 7.761778898283562, 7.329481434670676, 3.848307796302492, 7.892302988531215, 7.7122237392903985},
    {6.956164675290273, 6.655057065667442, 7.008645479943183, 7.164382214862393, 7.42291683986617, 7.119668837627296, 7.427607163310283, 7.684831456019809, -0.21687972230298902, 7.156658519127418, 7.637298854079843, 7.841286758563695, 7.753494256983318, 3.26861073730933, 7.983856078626897, 7.609620722214377},
    {7.352369599503326, 7.177738456585546, 7.586862158585933, 7.743696316210683, 7.5688284145466636, 7.797695635432754, 7.22332842460863, 7.294522522522632, 0.06692856405701532, 7.975319546197481, 7.976594063499522, 7.828055838835535, 7.7222729611019165, 3.9726887213042614, 7.8220009983126815, 7.685796887166834},
    {7.558186483744774, 6.821677687593429, 7.05653407150116, 7.596693513316552, 7.212661515070904, 7.484723160295709, 7.180963163590572, 7.492903394612636, -0.2138968879451871, 7.688345676468985, 6.993436319594958, 7.378435733136675, 7.36431502902283, 3.922465284479015, 7.791244039636022, 7.242194358853162},
    {6.942051469126198, 6.877156242826841, 7.274161794171347, 7.367401329797577, 6.966838287854162, 7.36766563268172, 7.349133896833941, 7.814859967738223, -0.21194550256147068, 7.172663688527192, 7.0484275568358195, 7.36242676362711, 7.257384354601864, 3.1646265890449277, 7.259568369926895, 7.440279463208161},
    {7.389751223391426, 7.400519519816465, 7.432895350964143, 7.589155963530158, 7.47727636905455, 7.222394321279601, 7.8352601953998615, 7.90578437719359, -0.3641019655581667, 7.348492886383277, 7.369370273664831, 7.533240556374119, 7.414627467678221, 3.791129982730379, 7.479014440461983, 7.292417309759926},
    {7.037256028363268, 6.84200947703345, 7.370303318149447, 7.32121744150317, 7.127807319405658, 7.316131709341316, 7.387320292649585, 7.3857873834849865, -0.33618911727701295, 7.39250379236674, 7.3254719223635085, 7.0850347637088165, 6.782856680457098, 3.9642696124352357, 7.733497080359526, 7.5919704558575445},
    {7.287711896458319, 7.303306984390739, 7.374891822613219, 7.591426723097552, 7.647469336747532, 7.660826682298731, 7.239160504375292, 7.3162475710027035, -0.10830087714759278, 8.056701059757074, 7.518266517634964, 7.408544214712418, 7.811792610541849, 3.7469415890941375, 7.349562335657665, 7.089164148155339},
    {7.769984616457915, 7.143911467663097, 7.697776916676332, 7.4077507303732375, 7.262259831327794, 7.557218788051795, 7.677203217013032, 7.626508229417755, 0.06134145505902161, 7.97435934848822, 7.3692762164866625, 7.46772032897849, 7.57946716644427, 3.9872839302738394, 7.3662627048657265, 8.01178847608392},
    {7.07790521935208, 7.047971742330884, 7.282760232037723, 7.721102068121494, 7.453093425846805, 7.967287396589862, 7.845399745127439, 7.090142087020482, 0.04896003513159634, 7.780840636497231, 7.250770834573867, 7.844951768872769, 7.392885419856774, 3.160861779673352, 7.727961358097003, 7.3832938914850565},
    {7.1848547004905265, 6.727781582928981, 7.226594672270062, 7.467827930542561, 7.201288718583757, 7.54841433633399, 7.621696034788537, 7.602614877210044, -0.40676926151765136, 7.568742574495045, 7.159209547272599, 7.6493868571297465, 7.4596214336582145, 4.038922593058916, 7.3603816861178615, 7.666061035484418},
    {7.148333651603643, 7.286236177691609, 8.000147730524004, 7.239284473587758, 7.252280735948427, 7.554670347969275, 7.572113589452961, 7.340903091564793, -0.3477015339585508, 7.60455901295518, 7.755520758215135, 7.447534377344443, 7.806545086340511, 4.028953657533944, 7.602718571559553, 7.385972008377419},
    {7.603054046552233, 6.850224082384469, 7.394144995484203, 7.7855291314619155, 7.085266010319399, 7.153180952274141, 7.407557430669904, 7.059410554673464, 0.42755398531158656, 7.288933204948721, 7.428241382350987, 7.5255758887420505, 7.513258507021627, 3.7224700519801073, 7.089112620713028, 7.23356172845215},
    {7.7883003556456165, 6.520121174878509, 7.48363028452171, 7.644439730041079, 7.234841292387022, 7.587192270719929, 7.337670317106671, 7.67060252130565, 0.1634028455571243, 7.323666856804459, 6.933596318868028, 7.178914640372558, 7.106878091976073, 3.574383311205161, 7.152638026366099, 7.032621315127036},
    {7.300056054051734, 6.681615022184895, 7.876430287929993, 7.25841366527712, 7.635511046330598, 7.264393936841822, 7.457498333574896, 7.434331548892384, -0.4461214323865202, 8.11104385411558, 7.660791307628324, 7.906293816982585, 7.0062004544753105, 3.9066649302179806, 7.753736048381168, 7.802078652557983},
    {6.703141151846458, 7.107905230690138, 7.395216980130608, 7.52203508290595, 7.22202160993902, 7.205673650626559, 7.0068919819730615, 7.174319902166345, -0.05387411034314677, 7.3480202641217245, 7.479631439219111, 7.072296980534041, 6.931297186195139, 3.595496637481512, 7.4276712585257325, 7.546182431982475},
    {7.399148566518503, 7.3522102989117535, 7.486337902050984, 7.422161050118733, 6.950454792140138, 7.622886705726001, 7.33463530237657, 8.067769434012634, -0.5111537266326475, 7.386591831386313, 7.494892688670004, 7.617758912889389, 7.507424121355353, 3.990986839672476, 7.19954920128742, 7.389557090925562},
    {7.378185646881186, 6.448894862918828, 7.093159527449509, 7.658702234375558, 7.1411304027542455, 6.871153018180518, 7.1717171175615295, 7.130242699482971, -0.05985893586678365, 7.542089930108418, 6.986650581375115, 7.393347728574315, 6.680997017552335, 3.621773398376711, 7.580127205986087, 7.541324618531098},
    {7.643262964413496, 7.2526224221511, 7.640076074593749, 7.488078706539794, 7.6996274080316836, 7.518694006852484, 7.159771773337325, 7.501801190226423, 0.175197813544905, 7.618871639351501, 7.727136403448255, 7.828849056667613, 7.3195545000241555, 3.4071875241261664, 7.964635017852752, 7.741831671697882},
    {7.135093684428236, 7.120746302872749, 7.70390272709595, 7.496119676003398, 7.614341638801041, 7.328877909242355, 7.220554170762173, 7.795540094255711, -0.034139489416978454, 7.224826859767757, 7.570623976142319, 7.610859358533262, 7.105719118624022, 3.5350395973355715, 7.718567338205258, 7.4849633682787955},
    {7.368927495347116, 6.980236445697386, 7.718774202662848, 7.335586021783009, 7.212380965669205, 7.880292836159205, 7.427442562635492, 7.509428335171958, 0.07521247946470347, 6.975858912439005, 7.440360795013324, 7.337168928330746, 7.49894619016042, 3.352799910753864, 7.232994402697069, 7.687333947895777},
    {7.211510920264389, 6.878370174997628, 6.962022138568457, 7.396316777682013, 7.012768397782065, 7.174530498036588, 7.233424546767226, 7.568097608112609, -0.5070142474743019, 7.00624699414509, 7.057548974680373, 7.1243160123479115, 7.267620022569804, 3.5353210353452025, 7.450766061249953, 7.526241941864566},
    {7.164502650166994, 6.806972150669881, 7.181378948418329, 7.132834781653414, 6.708747042636962, 7.082648178627013, 7.425580519153523, 7.31706635489251, 0.02253325823079127, 7.348694873215514, 6.979803760497835, 7.240220236106237, 6.991182611381681, 4.083072051801998, 7.298723232788778, 7.276567693331022},
    {7.406537896151438, 7.25153508385156, 7.514504465035533, 7.299319618842299, 7.363895667818312, 7.272075118992474, 7.4572952746642525, 7.274216524091697, -0.09544362454272404, 8.067355708027401, 7.3342680224278745, 7.9929493751318015, 7.074603241392988, 3.861248858537161, 7.40792212260533, 7.335788633051444},
    {7.508690576955085, 6.82770896925302, 7.8626287758920475, 7.552251341720106, 7.500372084632173, 7.387669598560336, 7.4883156175266805, 7.852721355224371, -0.30511673261857863, 7.537420185931084, 7.690268086465053, 7.992463523130967, 7.435642259509535, 4.139008656331271, 7.44789341798121, 8.162554618906231},
    {6.853580141451931, 6.670686928351929, 7.015274719883506, 7.180654890109515, 7.137975587683506, 7.336361019022528, 7.19510585075523, 7.262066777546233, -0.22825479397113507, 7.119746502337189, 7.607273138678615, 7.516461463824878, 7.716917252822842, 3.506621012836744, 7.200911625684342, 7.913154556728632},
    {7.610332369455585, 7.2283791566441895, 7.469660389550079, 7.4681806472609775, 7.546770612667172, 7.857694873029847, 7.232129685642586, 7.364803092321314, 0.07730762203872463, 7.484001968608318, 7.595449828197414, 7.259348225583564, 7.9109233295353025, 4.304902402644464, 7.357403829067543, 7.490850420513493},
    {7.608131141798721, 6.9195670816630095, 7.640512149811146, 7.799208943294324, 7.3125462432485175, 7.067812051185966, 7.68282727493032, 7.554632875602947, -0.18328495296942449, 7.13405448081619, 7.550084742177364, 7.7988505605383285, 7.447381531610468, 3.175604879865418, 7.9619157707785835, 7.794675658502366},
    {7.492595728856836, 6.512454681649475, 7.270548049918537, 7.4481482433410475, 7.0685279435149, 7.095093712828175, 7.235361975627705, 7.550833455276222, -0.24059080386424947, 7.3011325591039915, 6.878500359105747, 7.42759128517633, 7.23218030854594, 3.599426485406817, 7.557886705150292, 7.832132839214791}
};

static const float b2[16] = {7.0668478708511655, 7.226885102706589, 7.235135748555296, 7.210704558491838, 7.2384039697801645, 7.161338104031905, 6.828339771240925, 7.1599388794527945, -0.0837245349435804, 7.12767370244522, 7.150396974575658, 7.236160854631629, 7.05746177426093, 4.922466695771309, 7.211364892753632, 7.299629252550667};

static const float w3[16][12] = {
    {-5.338504321544432, -4.278282704602269, -4.850932887317015, -4.668110167945885, -4.22023477179564, -4.556789110563241, -3.9369863233038145, -5.067385794939634, -5.027443137414482, -4.856084560086183, -4.615699404562363, -4.342886814822149},
    {-4.103030751789378, -5.371023429443988, -4.6207518754718535, -4.764213954143563, -4.40845146378352, -5.048757905715503, -4.92244347280108, -4.818096121521824, -4.7870116650085315, -5.360042016853868, -3.746718352671343, -4.522958274722475},
    {-5.099595276163107, -5.015848302979211, -4.529794038347887, -5.627425856686652, -4.70916383140605, -4.918067981174564, -5.020314754309584, -4.229324312988737, -4.224354608378186, -4.718753488534424, -5.448086142322024, -4.943031639280795},
    {-5.106267456666798, -4.453411802411862, -4.903475411027459, -5.324639990526134, -4.963635519757787, -4.703284691578316, -4.9675501119588175, -4.4980721283031295, -5.20583368098577, -4.143416473284569, -4.950542798508746, -4.976250415557939},
    {-4.7998114535794825, -4.0064765032396314, -4.629182779436638, -5.000403174862386, -5.249373644046831, -4.668430010676274, -4.825856643755773, -5.0490086784459125, -5.836376086625617, -4.750472507542502, -5.157511596419396, -5.3827238103478035},
    {-4.782614491374908, -4.946091862815564, -4.934931551287434, -4.7372226904698636, -5.1449847904297314, -5.266585837180585, -5.180462105284737, -4.855302535091105, -5.3324341461438385, -4.967963531378198, -5.453125605506824, -4.884989755015116},
    {-5.023615762919711, -4.944798690244896, -5.212291006149012, -4.850935511704545, -4.981695219112192, -5.699097370019831, -4.657475214247161, -5.149460654396302, -4.799778203889961, -4.787781236273187, -5.270725467743539, -5.021346106026335},
    {-5.352043979160011, -5.726398223366189, -4.865654390137708, -5.021379542093676, -4.6421038882160195, -4.78232495759845, -5.252064119925589, -5.193571282303714, -4.6938017396153455, -4.442829834024299, -4.6145542076332395, -4.5132965558272415},
    {0.46374825346586623, -0.6716220218226128, 0.15438720181916998, 0.373811254188908, -0.11644141498969965, -0.3291613926894278, -0.0785592038994768, -0.6066380393802152, 0.6142706356014599, 0.141114078520255, 0.11401300575766381, 0.07043655363846847},
    {-5.0788702510822, -5.104282630363333, -5.111869509809425, -4.190195951004513, -5.120342358551179, -4.699091539728906, -5.3159720307590295, -4.556787455306899, -5.551406222680753, -4.611024126647583, -5.0962342973384915, -4.13597255425484},
    {-4.604548768616415, -5.072458044834143, -5.276682461108907, -5.644832822738453, -4.8291121102463705, -4.188464621704415, -5.274598615883262, -5.421071551674496, -4.672870224291597, -4.587876156987762, -5.700256544144166, -5.178720623769897},
    {-4.715915496181054, -4.639907375491581, -5.601630234916692, -5.026379131642625, -5.512379101963585, -4.932539385347403, -4.583991495272927, -4.810390644665055, -4.63765655531628, -5.5895635584278605, -4.513023658026152, -5.225907309904172},
    {-5.482883183618703, -4.397758419163651, -5.037061266907303, -4.752087211336393, -4.983698192476677, -5.842608037039654, -4.827206157493819, -5.525202536279968, -4.848402793799315, -5.498355658290723, -4.488266219220929, -5.015560714576786},
    {-1.9370807338092138, -4.0136651022097025, -2.867831988318845, -1.6401944488185909, -2.694282250696754, -2.8654406706662656, -2.4553233055454533, -3.2541472061757752, -2.845862951859842, -3.4260999629673914, -3.7270564095022434, -3.0798400720058003},
    {-5.100595888401862, -5.563657969086469, -4.4781067295958605, -5.071006239347243, -5.580190653166184, -4.927765849556149, -5.178164412612457, -4.745578719789515, -4.789772850669555, -5.0648979410972315, -4.6681107314381345, -5.772142564306458},
    {-4.922977407620703, -4.984427145371912, -4.992320748020051, -5.047423994920176, -4.793358559541747, -4.873343342203746, -5.310990673033115, -4.980742602604692, -4.701321803485051, -5.448523915954982, -4.853714712194578, -5.0178243099698685}
};

static const float b3[12] = {-1.7751124441712798, -3.2260420554034694, -3.192299661039563, -2.054866539734732, -3.290229053231821, -2.708689846654131, -3.1481560875486334, -3.1057022503786027, -2.548595261260479, -3.4022400390149192, -1.5537107100099852, -3.142959318852701};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
