#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.6292745243146698, -0.48814131345293255, -0.7878545073829522, 0.1881115277174939, 0.36075101689481864, -0.6791607216224053, -0.3181563084298584, -0.6396773837583535, -0.2630625824491501, -0.9111098433748861, -0.1518171501663783, -0.5658297867063697, -0.7538909053144769, -0.5218716091228612, -0.446753055683506, -0.6354021196201679, -0.3290676156490107, -0.8132662850568787, -0.703893721480013, -0.6772221936753837, -0.8249176208481744, -0.4122176524560363, -0.5609459634288728, -0.394601499279676, -0.47846210878241846, 0.22479233521889355, -0.7311376141891847, -0.7835012626179089, -0.40634705233244034, -0.12477063321091522, -0.670902675854493, -0.3591301608771401, -0.9515706802291688, -0.6017879526537778, -0.5750898939595515, -0.4857744606313784, -0.5139303159114491, -0.5100440784729763, -0.764665835352424, -0.5858823861573824, -0.448205805419803, -0.7838597765252103, -0.8433767900048028, -0.6725055465500213, -0.6337189845971968, -0.8909321925380796, -0.5046153721182298, -0.7223233378770266, -0.7785913539584545, -0.5256554328069553, -0.5366591030945637, -0.6999036729356497, -0.8506291900735015, -0.5587813150725306, -0.6708127115237178, -0.03577939516630567, -0.6164143432290976, -0.5775807148368717, -0.5433966522548274, -0.4660877693375422, -0.2850337363985631, -0.3682869195343191, -0.8445316997963764, 0.2982170844444988},
    {0.26532814797163995, 0.7611816353163945, 0.16259237451294364, -0.00886718240401923, -0.7593124072646713, -0.3088936641596157, 0.36940427819440436, 0.2558725169841396, 0.1285112698095717, 0.21918151191828358, 0.27246864861754333, 0.6222071972001082, 0.40725991343107437, -0.3588673087348234, 0.27569865681065964, 0.1637860492171138, -0.7267178923787302, 0.8223115613102703, -0.1011737241457798, 0.04145066700061477, 0.07594317259258805, 0.603003116265277, 0.1576901280544077, 0.13856554671376514, 0.26430260754064455, 0.029446252356272972, 0.3581796244891443, 0.48353043954977337, -0.09925860945560112, 0.1520940205457315, 0.2545983988233867, 0.34650838535842887, 0.45711456988441634, 0.7089279908906035, 0.684280289528982, 0.5895517999745754, 0.5379507455772682, 0.3620676757940065, 0.6941302971841259, 0.7321124246096766, -0.22733849069233958, 0.6964060409387984, 0.5656872636268201, 0.2913904466955807, 0.26365793296038265, -0.12614047619357796, 0.009746124310946727, -0.317961583788414, 0.6192001506090989, 0.09496810853671109, 0.23687114926579894, 0.4300256466040994, 0.05073367542562794, 0.6638142889223042, 0.6342131633620804, -0.12038465637972316, 0.35408571173904063, -0.08071315962393134, 0.06841257428074693, 0.15542218487671952, 0.4709248682917388, -0.19473615521552, 0.17034251421509872, -0.11777338659644807},
    {0.6373139387407337, 0.22998280597366744, 0.5319040395881645, 0.5458463474245595, 0.44726828801426566, -9.927045572866211e-05, 0.69490550107167, 0.5678430579349177, 0.5137533635157226, -0.20184500417878862, 0.5869863660326871, 0.25976846146042276, 0.6928718789071711, 0.7098257875461488, 0.7756374241999617, -0.31181726684359784, -0.12369922165053245, 0.4018520375254542, 0.00646464330432058, -0.5973850678117406, 0.409549097209577, -0.017740199292367406, 0.31475498803187596, 0.2394699036704524, 0.08788642911958035, 0.19331447555609668, 0.4481859640846036, 0.6219605363775961, -0.37827275405476035, -0.37364608561684437, 0.18843544842717055, 0.5777896678786745, 0.0852540541076922, 0.34848452877653907, 0.33348642019375196, 0.49238567480095924, 0.5809847453541139, 0.7762332491365801, -0.03053244248977541, 0.40937867982649806, 0.36950812718000153, 0.21790140102254887, -0.5678244924737319, 1.0230734740705456, -0.20191989652943765, -0.089524479490923, -0.18130149776321747, -0.1278851376760823, 0.13893233839065575, -0.11737075847846813, 0.2700832754845097, 0.5194121652656662, 0.09525254987816516, 0.13818141128885375, 0.1741820803998545, 0.6171300218381087, -0.17682222860261165, 0.11352106741479884, 0.5682590393628932, 0.5788775779513602, -0.3200894003288748, 0.8343896185373061, 0.7787213473718312, 0.03721516313076085},
    {-0.2102032004788949, 0.43891888408559404, 0.6032568332787208, 0.6781295079591871, 0.9874150231608031, 0.738682383744077, 0.11766156417673629, -0.16843207307785568, -0.03245549426706979, 0.27181942531240094, 0.5953857726641812, -0.7348355646571866, 0.01146784634759035, 0.5264659067881288, 0.7060188040813261, -0.02695938546460509, 0.07922511478108016, -0.1276866863050825, 0.22988350454830075, -0.7144113840217111, -0.31599985967154387, -0.5686060231271717, 0.5196699591963462, -0.22276885742594718, 0.030202611287548503, -0.021051831428701363, 0.2631941328699645, -0.009464510172147327, -0.21024660643990956, -0.5016496513062817, -0.03249608268671144, 0.40035484042907565, -0.21440944851685909, 0.6697410504985665, 0.08858168786071322, -0.27420310044687907, -0.019544276371201274, 0.4625521265341835, -0.10343789868826368, -0.17516760801345285, 0.3637900080286017, 0.20805112155263422, -0.3155477974609966, 0.8514213654783542, -0.5886949237052891, 0.41302367782988486, -0.2820801177923492, 0.21031231328216834, -0.26461281284592275, 0.413110355188907, 0.07866988156713565, -0.10067138414821063, 0.32520184374545946, -0.18783592775783098, 0.03738415673966517, 0.7551556283502048, 0.09936291054379848, 0.16543971781652858, 0.8693625617139307, 0.3603154311364344, -0.6061414165211695, 0.9577529653923507, 0.4888655617635738, 0.022266758666730304},
    {0.7075895829878144, 0.6940891377293047, 0.5620019695894245, 0.6042304321839526, 0.3190813316009443, 0.5297922677242487, -0.011136177385703546, 0.5145480110255186, 0.3168999689827785, 0.7531509582054853, 0.2894039622804517, -0.11580404655825885, 0.3907758189286711, 0.7523146779824365, 0.4127566954355916, 0.3464949331681436, -0.4066342498206597, 0.1366087836147426, 0.362740268497128, -0.1404181798453912, 0.4520890488766537, 0.48341170135797545, 0.030344455615627628, 0.4689991864217991, 0.10193616496065414, 0.10632432559822434, 0.6049533683833657, 0.7552349764476969, 0.18868095064112722, -0.18088526568222502, 0.1049631934295748, 0.501098892683893, 0.19123064212084998, 0.31284283438469196, 0.15293868857964632, 0.6292850076876191, 0.030999079175069583, 0.28221507468933466, 0.2470570636179451, 0.15766757510295873, 0.6500161389214011, 0.042190695974550135, -0.0966424076662259, 0.4506666689981139, -0.5349308584299001, -0.18313222615348348, 0.45913553165204746, 0.5017027186006713, 0.4721706564647035, 0.46487704968664106, 0.5485881928815919, -0.0001288303204134015, 0.05506194417647417, 0.19921187151917044, 0.04050793710817782, 0.49066337220428385, 0.38690067840907977, 1.0477539723506792, 0.4340757192398694, 0.12344636011770178, -0.4766886380411138, 0.8099306146101221, 1.0229810860292472, 0.252283850256553},
    {0.49241905830462346, 0.6498019217638851, 0.7318309551488693, 0.22969798072030675, 0.6688357579304459, 0.8985382193674831, 0.6612669659684083, 0.8400925826006185, 0.7025542293336715, 0.8207024710724916, 0.3764653165498678, 0.11264269054332178, 0.940661025874413, 0.7438291801796912, 0.6762346080857871, 0.8451392928962406, -0.08535903079210538, 0.7675845925851602, 0.6750390964858642, 0.5976054168578033, 0.6727530257501287, 0.44008991799594616, 0.31634828635688833, 0.7427513751507033, 0.7459353934194007, 0.6667530161112535, 0.9031416132014415, 0.7767728401802386, 0.5256960415426071, -0.4335183595649646, 0.6106426733944633, 0.49124741430794716, 0.6994690354919889, 0.6470411550158739, 0.9208713949342077, 0.3521790548942957, 0.37989255267594746, 0.42102430623548137, 0.4246383318228464, 0.7608848509468633, 1.09146420445904, 0.22697940595923732, 0.2393191479083946, 0.7959915826832527, 0.11952174055143398, 0.5105850903613665, 0.5148921017766086, 0.7058425390628953, 0.5498492115507883, 0.4978855735715074, 0.9231598659087504, 0.5781741660874381, 0.5244122993638181, 0.8399140235975505, 0.6036401168480563, 0.4013793917277749, 0.9999200441237064, 0.9351033635177788, 0.9341961453240591, 0.5671398709434559, 0.10668448103277574, 0.7860033634770679, 1.1396936734842853, -0.03951486497821116},
    {0.6642972977250697, 0.5881951417319213, 0.8438669512641852, 0.06736959026972753, 0.17048657883582907, 0.6072687577393674, 0.7203226869229405, 0.6987835209655388, 0.5755644244259052, 0.8057943176864497, 0.4031824102792959, 0.21111082154342245, 0.8937419425952121, 0.987771233382888, 0.664118125748529, 1.0119778787522644, -0.20148311880074307, 0.6140852885081518, 0.6443159668786584, 0.5599929880910762, 0.6837938789799252, 0.356543789285814, 0.5430934862839228, 0.4869674430097208, 0.5469606963586133, 0.2689164252359758, 0.8266049570623235, 0.9176437931821164, 0.3275747825152559, -0.40543991898624976, 0.556168642966422, 0.763793787568426, 0.8755156067729691, 0.5798119902762423, 0.9249496217980648, 0.1390951316772934, 0.7422425359934474, 0.3001849497920007, 0.3558542286613775, 0.7161063147509453, 1.1208240925562483, 0.38338943059345676, 0.3793733941537617, 0.6457228721223702, 0.23315587213806285, 0.2391018752419891, 0.3533527267637074, 0.886749148420293, 0.5955575756175564, 0.6643314504133797, 0.44627332682173526, 0.5631001539141943, 0.47709424539649903, 0.5060693890535327, 0.5575378577348177, 0.6742688188096196, 0.9135143537496923, 0.9536890025093223, 0.6925958923479691, 0.4883027489740764, 0.04457307219764883, 0.8965546041818169, 0.7154730257444079, 0.046451828658902045},
    {0.42363365706736855, 0.6033876472879898, 0.2772761049318312, -0.2811188848519279, -0.3804939061385801, -0.34954583202275596, 0.2780903060759042, 0.4482866794492353, 0.16327945866998847, 0.568855047884813, 0.4646453118187462, 0.5732390606343863, 0.3495647144528742, 0.02335229614981769, -0.09513033832690831, 0.13061845540939698, -0.36551554009771225, 0.36640548739618084, -0.28428734919003573, 0.0608727388999577, -0.22352214803692894, 0.49580307587818373, -0.27783620248608343, 0.5611303750237138, -0.26081176896180647, 0.08809370939231087, 0.07168936419628888, 0.3557993853964468, 0.2569673115521642, -0.39042164193844686, 0.47828426536155927, 0.32865899723805936, 0.557352454324482, -0.2236666400940471, 0.29567771123489955, 0.2669666719774152, 0.1941673945019732, -0.0254600758925226, -0.197039233659922, 0.23138580166580075, 0.32719560136246895, 0.058085666367464824, -0.00063180686143119, 0.3821817348630755, -0.3852936508788602, -0.45950617230265073, -0.24981444802115754, -0.21190448667307396, 0.49700793653395803, 0.4984161813682882, 0.08674857698804717, 0.1486765556444702, 0.016125049721033066, 0.5940173439201188, -0.06874906775320568, 0.27108156170237213, 0.30147512555206646, 0.37195643326374644, 0.27892396777436784, 0.15116875755119577, -0.02592809065670848, 0.3214164454416794, 0.47165464819418396, 0.2683971442247359},
    {0.035881911623424224, 0.014089061013106951, 0.33376483279740804, 0.05976500215884767, -0.517880733200897, -0.5154744896301033, -0.2376967606872109, 0.05365261093471705, 0.030238173372969263, 0.5546433053206311, 0.47355089043446913, 0.27962953623061526, 0.12430749249585571, 0.06676150424539082, 0.3162249015302922, 0.6879929065939883, -0.5292920766755377, 0.43951460566111666, 0.4137058493474499, -0.37814513566666785, 0.04958595259634822, 0.06656540895467605, 0.13603738182465255, 0.26234967088412453, 0.46655252622156473, -0.03598235121988194, 0.3011597609011001, 0.3522958948302938, -0.3108362891365535, -0.18918183462295451, 0.2320218995455252, 0.5540875106228268, 0.2923528142190039, 0.1478802026529526, 0.6405085460518711, 0.0760269005822387, 0.6426455876602822, -0.11905104758214866, 0.06457470713177242, 0.23703904266087902, -0.048701081230446745, 0.2989824408491491, -0.19322922214498767, 0.41953262469599306, -0.3721715883861609, -0.2027280313019778, -0.5107252588057836, -0.004346077287337802, 0.23991935082804447, 0.23423355833229906, 0.5504089992339057, 0.33153542497492705, 0.11646022976322414, 0.3568632886479141, 0.6027064059365043, -0.15243831444660474, -0.011130014422864714, 0.06990642720364773, 0.24558620491078068, 0.36911003976657264, -0.2925737904283643, 0.4232332443588776, 0.37530299752207297, -0.21941079887062734},
    {0.15961160761673168, -0.31329631908600714, -0.028012430626255268, -0.28227219128750486, -0.10196574283378089, -0.4972789511098088, -0.033657062743833885, 0.33814245640812723, -0.11398748210678591, 0.031107784199077518, 0.06356370491063591, 0.5065633009204603, -0.13931589526525268, -0.2605964692580199, 0.16306851250779153, 0.6041698200268012, -0.14812762304575952, 0.5925206507042975, -0.00964871961956896, 0.6004134454279023, 0.46856063698993994, 0.4419801288483453, -0.05088162852567951, 0.1125304507671808, 0.04624698831564764, 0.19648721430377225, 0.16104792739849952, 0.04335820318248565, 0.3111157755283579, 0.32005998493069826, 0.16265569107755987, 0.3759086541553931, 0.3605331481451378, 0.2182243941343533, 0.6635910053901388, 0.20278223567209755, 0.7873711130043324, -0.4689722790347074, 0.6593105738926096, 0.07645490341771781, -0.5581498686904048, 0.5785011722037794, 0.4612512519887687, 0.2443984093728114, 0.3197843572634102, 0.4570484079831274, 0.44015138382285196, -0.2806435233946971, 0.39241403681606024, -0.11475986216146708, 0.14894256673484887, 0.3119825917480787, 0.451123515166454, 0.3948023066662423, 0.6534608083331213, -0.22682748860624002, 0.13245004436889707, 0.35343900315351184, 0.4149986017509334, 0.4428285382966896, 1.0050088872547827, -0.49356860478646963, -0.5784662227659104, 0.4411815264690931},
    {0.21605218069906412, -0.01604345767367189, 0.10062461077940449, -0.22745860099778395, 0.10457699908214323, 0.1466126569305195, 0.07027842197916064, 0.08828923836821626, -0.21903656742775637, 0.30996171531397526, -0.02577136895660037, 0.4934500085596691, 0.06657327887049522, -0.27501914801609695, -0.13900369867150164, 0.4602115076120147, -0.33422428076492766, 0.8899750618582214, 0.2210375475321121, 0.6724419806307709, 0.3295110646148953, 0.4504354538385245, 0.6312177441297043, 0.47689779231550633, 0.026366192359041092, 0.022328830813928117, 0.29663346764178167, 0.2933602525492801, 0.2230468792375344, -0.1379743337651193, 0.04465474456804366, 0.29651178105192777, 0.49087865620480947, 0.24741239011502003, 0.268830560687816, 0.03480339578042273, 0.5835240108610628, -0.18289824773078223, 0.5862977374384033, -0.13115551701158823, -0.31170208029451196, -0.05186207882080534, 0.7574991381858006, 0.15862701117541408, -0.003057817305883079, 0.16196213814362173, -0.28065058594345177, 0.5156186636889154, 0.1022929595785593, 0.2830866102985804, 0.13024089652218598, 0.7614803376360172, 0.6128943611392594, 0.21462640858496432, 0.5939318512497838, -0.5138866647523096, -0.5565803194940258, 0.010979922609257675, 0.4468531278666534, 0.2991123727705976, 0.2518452273786111, -0.5124576595701217, -0.21676484079690356, 0.10272268706735575},
    {-0.04252832912494307, 0.17160543253429497, 0.30870732980050336, 0.12979370322802258, 0.3210438017688909, -0.22917351617884898, 0.10185894418562982, 0.39045158836073585, 0.3199715441143102, 0.04108551882256637, 0.5452494174760946, -0.16182187549577753, 0.2919413948438834, 0.45923305905511347, 0.18278742890503696, -0.33228426343549305, 0.46820874316085326, -0.03080142106365966, -0.4072492055398969, -0.5186319434057928, -0.21499590530771887, -0.4759448301023072, 0.2270733446582804, -0.24890713229358893, -0.28278471578776204, 0.5361961629300541, -0.29893229984450986, 0.01480792904642053, -0.27818776239636106, 0.10129011433475543, -0.04183471553529137, -0.34667159577194834, 0.09159778558380831, 0.43637508950762854, -0.04376950233550086, 0.1335731173809263, 0.32749130331343695, -0.07521114666227245, 0.06342550277811441, -0.03129964687839051, -0.3491762921384616, 0.48332914760752965, 0.21221707958831998, 0.7694758624873408, 0.35913468698319523, 0.5281320217644564, -0.3227307001241886, 0.01444697617498859, 0.09352336914757221, -0.5212273321481968, -0.28519708386024967, 0.30603413227631326, -0.5476996439328435, 0.28174640695741426, 0.31349335287169866, 0.0852826701981758, 0.3645353024203995, -0.5603703334523763, 0.44918392266831875, 0.0660557453446415, 0.369490040626299, 0.07539202222825594, -0.01258631496676375, 0.10175271399248373},
    {0.35441367082664527, 0.3513604063809339, 0.08204450866348288, -0.6241672731574712, -0.6947039443034135, -0.18866301196080248, 0.6642132607248816, 0.6045080598601473, 0.7252648802956942, -0.150098868800707, -0.2619487317076352, 0.7440134564381257, 0.34105200062724883, -0.19138969362087996, 0.13961002565127453, -0.10290774073571662, -0.6012554074957547, 0.6881444238885497, 0.6481347152620114, 0.41560055371198557, 0.5634535205293894, 0.3331800052520894, 0.12731689399495946, 0.6753963805688415, 0.4969586378332039, -0.06689460697292066, 0.2903092097632625, 0.5612419495057533, 0.44513480210056056, 0.47536697443430065, 0.08595229511611874, -0.10870177139975193, 0.7456068117683565, 0.3233676980361662, 0.6262570193602705, -0.057703556258368364, 0.8843429221484376, -0.025168233489830435, 0.03549411934374376, 0.23961247069384187, 0.17400365749105753, -0.2577386407231042, 0.28971966923377296, -0.2667659564725877, 0.1884884645398541, -0.3685727120357011, 0.12654371667124625, -0.03928330900087118, 0.5756348358426595, 0.40166360560828485, 0.8086919617029761, 0.8060503987862527, -0.42716086849423734, -0.2551820810382527, 0.07180739134733642, -0.34159674472832746, 0.10503034637939927, 0.4135943638105462, 0.21022477837797507, 0.006614661588291297, 0.39805912707088004, -0.0005215981309834862, -0.011399144899663443, 0.09212788839530672},
    {-0.41106335605031463, -0.23683462471253425, 0.41751361886812444, -0.29002863217341807, -0.39334375391064674, 0.4977926187136706, -0.048283452780019685, -0.21134948105359708, -0.10019226405614315, 0.8279853915406429, -0.03769265321894143, -0.14914636358008054, -0.1496677367224589, -0.4074269987654773, 0.7180964655574468, 0.6444698097309277, 0.5765447905011011, 0.3027490464370016, 0.5096869738094736, -0.2847942259828673, -0.25746069325124676, -0.2323506504339078, 0.6283770165684974, -0.08302364548865741, 0.43127242592579296, 0.06465669189043678, 0.15848886668125445, 0.19207813530919965, 0.4748611630892199, -0.7670999000835078, 0.7475833716152523, -0.05148093444884295, -0.09895261466688786, 0.6671863456014884, 0.402577750462631, -0.7121798489174623, 0.07437357909966796, 0.19205755013268844, -0.0005644187467925964, -0.4629347591319611, -0.011384759407704824, 0.01425661239254464, 0.6407866169596667, -0.03281997825155733, 0.28392001655700166, 0.6399852451559953, -0.36160412822824256, 0.5408046063218198, 0.4271544282573732, 0.397972484484292, -0.0399581990753004, -0.09173693943349052, 0.6955328342142502, -0.26702993599790553, 0.33057336290923983, -0.3509172429565503, 0.471579207555437, 0.25279991647274513, 0.5573532979734436, 0.15703924411678863, 0.025743699461298838, 0.2114826901531622, 0.26264009500273666, -0.8408447564524311},
    {-0.8551392211379613, -0.5098200555090163, 0.4665450057196851, -0.6062117584943394, -0.2872746329987597, 0.6606008782203749, 0.15073493242934458, -0.0443766836368419, 0.1834072544980204, 0.6322200718942419, -0.13164851569767458, -0.8367716656687608, -0.36380214584405035, -0.2645803652019321, 0.4321375557848475, 0.26749360558882224, 0.1484527127059747, -0.5881048964790951, 0.629969160343956, -0.2699755186551299, -0.46301647544805563, -0.6070664577435142, 0.37447217999057764, -0.5330060805307865, 0.7051322175335, -0.15042293545852142, -0.35229115998877575, 0.36574122796990155, 0.23322076516675044, -0.57574531344812, 0.901267474790747, -0.43102144393218994, -0.1359698684390809, 0.02868648411329193, -0.494005849026141, -0.9286299972047418, -0.284460971852533, -0.4961952581220788, -0.7725575146712357, -0.362982778300738, 0.6344277186471977, -0.5850412705469853, -0.4585309235203071, 0.007536786665709799, -0.01281846719780434, 0.5295094169860478, -0.689202595200557, 0.33363130123441015, 0.1820568647042705, 0.255405979537125, -0.06796604162111243, -0.38256240218043286, 0.16481118868219588, -0.1880730025416099, -0.4292337152238646, -0.7147377135749986, 0.43191617816983874, 0.21719115143182283, 0.5453485264385168, -0.2162526876554805, -0.770729338336806, 0.5451887197025663, 0.3080113789702201, -0.6774532098620862},
    {-0.5844662378932985, -0.2668598339345182, 0.020104278441975296, -0.8600841167145956, -0.7435163890647928, 0.00039544212565573427, 0.35956416428193344, 0.6539631592238832, 0.49227353543282504, 0.3655987087099892, -0.6810753577245254, 0.27308334826966363, -0.04533962900857822, -0.9856051741769997, 0.25688492584665934, 0.039148138798077575, 0.06898752037448815, 0.28794291452184134, 0.8009074554104889, 0.3738846555649243, 0.10723411636143658, 0.2749117353036992, 0.29686148647835386, -0.330206006985486, 0.6863699341643458, -0.487263039462672, 0.15240663963056747, 0.3455170724441981, 0.4263391107511019, -0.3185722439380401, 0.6570000369185992, -0.4162426495942079, 0.20763354152377142, -0.22129698218316157, -0.2647663863761648, -0.7463624838190114, 0.15831132841953074, -0.24851697363289957, -0.5980520448132186, -0.20949517548066826, 0.6318241475703168, -0.5577563503595356, 0.20983378657633772, -0.4164806448967686, 0.3999008037263929, 0.42189539746082183, -0.23470437442758918, 0.41545076578774653, 0.7055866127901851, 0.22656178319526135, 0.6900945542269954, 0.1550223960447762, 0.04905559658796734, -0.23640383079465307, -0.20583778311952985, -1.0347956976187735, 0.0662126008036866, 0.07931761130281181, 0.2524218111531753, -0.13136442778799234, -0.08477662455111265, 0.0726446184846925, 0.1023741592156092, -0.742087158724101},
    {-0.48460985200576806, 0.20340900823832783, 0.8068930416966593, -0.1209234128555023, -0.17431346918545326, 0.8014850263975025, 0.14646013190882878, -0.17193532890719024, 0.3766100944552955, 0.9065324735191596, 0.22404862121326474, -0.5330392694109173, 0.4347005383311318, -0.03995216014188858, 0.7607932177500248, 0.6667518363527647, 0.629072711812342, 0.2059470251983717, 0.8250102368294796, 0.23929900226447368, -0.2862595020855723, -0.01303544198779848, 0.6943700324900695, -0.08800954815517324, 0.7020714138865304, 0.26476937701779646, 0.2620063213754257, 0.812953043728061, 0.5990432227395536, -0.5012590297983198, 0.6986758128256071, 0.27767198750315825, 0.4337438380452122, 0.3725866425653958, 0.4531790213617529, -0.48927673475474615, 0.2890520783477932, -0.04839515049940673, 0.24708651078287225, 0.14222223231246642, 0.7184439647835345, 0.24183052324797788, 0.406485937312626, 0.30483582812815474, 0.6840925794518666, 0.4692544847546952, 0.25617639409159126, 0.8342766389513555, 0.7614398877460404, 0.5229065722587438, 0.42075360856456867, 0.3180443143553268, 0.47953505050745876, 0.4517511770547557, 0.414557756740594, -0.42057355582577316, 0.8053186987023372, 0.6003128168184191, 0.5887776927670667, 0.5021730857488942, 0.06681686900251761, 0.572360241635201, 0.39865264916770665, -0.5663797560242174},
    {-0.09346287519219619, -0.10860393277942484, 0.5982446391909705, -0.03669788123614474, -0.29554107233665905, 0.52774544834024, 0.18791721111427687, 0.04295150381616838, 0.48409914876083604, 0.6789989067331598, 0.0683687929347124, -0.06283905628151079, 0.36981304991458824, 0.4048274574366185, 0.7383049935343237, 0.6411858075884863, 0.49577126714813063, 0.6622907188231447, 0.5851264514513146, 0.48493343038084, 0.27587894712669203, 0.4162029691980362, 0.7378349640809816, 0.2680372571796405, 0.6075070861044397, 0.16997039480295745, 0.23538626294505877, 0.7913949873413352, 0.10189190212955963, -0.23338050659916362, 0.28512946153131086, 0.262002211288865, 0.21129796522630198, 0.7759802766796516, 0.21765772997092425, -0.4302403103838782, 0.6262283327706167, -0.3649886158306858, 0.22298564971683518, 0.1722595098372711, 0.5638149681413105, -0.37628074255108723, 0.6607279293082303, 0.6552593201026401, 0.9197212179766093, 0.8237445250988676, 0.18626115154449718, 0.8015078606898741, 0.3882403388266519, 0.5131435900214585, 0.19164564663342315, 0.6307620839345912, 0.48843065962192034, -0.08501773245120933, 0.4326188498874892, -0.3095898437235904, 0.42937601062925196, 0.36807596037978557, 0.7679726745808921, 0.2292260996582663, 0.04786193803848768, 0.31179322807823323, 0.3532310653205658, -0.7148765977129179},
    {0.008165016466646306, 0.10892494476880077, 0.17798395734582287, 0.26433225540681876, 0.008911776121091178, 0.7593625480146249, -0.03883535745563531, 0.1510486823845843, 0.011707785320905117, 0.5578858404397324, 0.3126101490414916, -0.21755559072290495, 0.2542560279502185, 0.3874087083217572, 0.49242003679570095, -0.2975144998120691, 0.3436008984101321, -0.2546596493288845, 0.05943847228714523, -0.5419285588275523, -0.5747860345237519, -0.4238058628395359, 0.16168683217043, -0.007713856935330407, 0.9029663573999341, -0.40212244730964203, 0.1941214741249085, 0.3288656317531935, -0.4148117920365236, -0.20492580885184428, -0.052681642948746006, 0.04728395815173689, 0.1323124957583299, 0.4633307493034412, 0.042851625580003945, -0.7433014020477761, -0.10037068025488684, -0.3770467833836546, -0.3157538091079204, 0.1986553706423702, 0.46409853296584713, -0.11256245462530864, -0.14396767798550958, 0.5349080957166688, 0.5544770672728904, 0.47693166667124265, 0.19766926098796614, 0.18970485879967255, 0.06897330499981764, 0.46811727875655285, -0.17767476753125896, -0.5458695378168493, -0.14926364526193303, -0.27234928599805636, 0.01573868656842189, -0.5402279355868586, 0.674301395282731, -0.0555771507605464, 0.4198254152612749, -0.31792332794277733, -0.2502733896193647, 0.359893373356204, 0.177838716151924, -0.5970994844919597},
    {-0.269995433067736, 0.03202514479833256, -0.025288418970707282, -0.09190182643725031, 0.4933437959265603, 0.5240646337603146, 0.015800422506748405, -0.5382696174691032, -0.37732840490185793, -0.022977568597485887, 0.08645839741723602, -0.33972597099591667, 0.06558203931827264, 0.47859460365001066, 0.024406463753230127, -0.19067687828348276, 0.37231654148663534, -0.37173283371890314, -0.1733698863469005, -0.07321167906868527, -0.23603925155699093, -0.19691947216786967, 0.028540254288969707, -0.17031446110917595, -0.2358715870002382, -0.03041987137603783, -0.3811009833240274, 0.17153040608439588, -0.031583856242117556, 0.08989194572738402, -0.12614150267105925, -0.3156063513497624, -0.2656502946236813, 0.13422173322412775, -0.5254459356440316, -0.2619182362479154, -0.30053269597390925, -0.0015325138899742578, 0.4975123089273962, 0.017283570246536123, -0.04152623910558527, -0.18745378089751846, 0.5197961901006851, 0.10229690981439526, 0.48993766107962505, 0.18064924070715854, 0.17849226957747832, -0.1954341239772846, -0.11805664843360085, -0.5613613851307026, 0.0007971487495820557, -0.2855866613142543, 0.7577479900026753, -0.21982707660685627, 0.35309162442334613, -0.2605199805390311, -0.15321796934838788, -0.4291915499420748, 0.21674274537218097, 0.3597817331646801, 0.10005451117741634, -0.26329626020088287, -0.4800215712837798, -0.394977419275764},
    {-0.4159540745421766, -0.11188001959025705, -0.658589992073, -0.22653157527272422, 0.544094674957742, 0.5345513211049644, -0.12278922075567165, -0.6562964333775876, -0.501865230563283, -0.10816855616963662, -0.3787364724263952, -0.5922070829833435, -0.132015815961341, -0.06965043986810489, -0.06620912849277835, 0.3856531332784884, 0.7014697093481596, -0.7273961417485802, 0.4293236327941604, -0.16333902727336908, -0.30919532662861987, -0.5364272453391932, -0.41774239966309556, -0.3911351725356868, -0.28869018022059306, -0.6362605950633368, -0.46331710358045686, -0.14714881037447922, 0.10932047741912702, 0.2564790110704531, 0.3199444575872007, 0.03705114534962314, -0.4303782643161216, -0.3125763784557245, -0.5284860262224677, -0.29021548144725867, -0.6424767278892357, -0.23690312339245592, -0.20174745008702652, -0.4344640319534963, 0.3393870044834867, -0.2589836480535722, 0.1831253051573569, -0.29931665568824967, 0.3684230971500696, 0.14873875359687383, -0.1631790384979499, 0.21062812741854003, 0.09111039827478798, -0.09001949705538533, -0.4265814995007594, -0.5174199856577613, 0.30265137308557316, -0.4952386556146893, -0.12532486505296284, -0.36681521716319176, 0.44341918589822116, -0.47799044430285575, -0.3668487365568188, 0.08880637980289355, -0.23437204357114275, -0.07468424007933742, -0.02702484629898974, -0.29582039810428923},
    {-0.8441106538830249, -0.17392841650518015, -0.3438603168160858, -0.31381488354611287, 0.1569031805440124, 0.36301359095469793, -0.5790692877095995, -0.5375347723994922, -0.5557864541212219, 0.4036159570103238, -0.43521442902556984, -0.6358143281101638, -0.6421924053640193, -0.12101925388028369, -0.18182245707834646, 0.4001965259711549, 0.3320861829310034, -0.3892493532457388, 0.19330160534275292, 0.1368747444793736, -0.3281072338685838, -0.2939311447401805, -0.44714521851720623, -0.5269666016883446, -0.6447653957507029, -0.4236113251508221, -0.7009378350838307, -0.7120494788393688, 0.26095463231158206, -0.5014132337398002, 0.24932610042380202, -0.04184236787057389, -0.4664294832951345, -0.364905738459076, -0.5052557866218369, -0.5402566863771049, -0.5641696979780791, -0.7376208006644359, 0.13965258748256631, -0.5810093491639542, -0.20885341952787487, -0.30948968860800213, 0.43848897362693345, -0.4605801670559281, 0.2807855696390886, 0.7512584295788494, 0.1882159663718449, 0.05470776696669343, -0.1714364144049665, -0.16448063613889052, -0.5163511244532427, -0.4903612872460616, 0.7092404400547623, -0.21688421110312492, -0.17967612894637391, -0.5249469718847865, -0.0994424049345966, -0.23944111613456312, 0.05392800317420842, -0.3756353441697871, -0.6357250576230208, -0.03949392410462116, -0.18298395365762146, -0.5813961755818562},
    {-0.28695781780524654, -0.10730827972795723, -0.33506243900188104, -0.6292060184992128, 0.13090084058863874, 0.5048301331268783, -0.2563470900000269, -0.5620821426812146, -0.44385465423450476, 0.03151295333767642, -0.4914717390411103, -0.5413069421334211, -0.48598143837798974, 0.3845828039835355, 0.1696459258184437, -0.3083649458022206, 0.6622048727814479, -0.5498520355733796, 0.09157672643214597, -0.272458913437922, -0.6033456134211969, -0.5372872969880257, -0.33410230281881015, -0.24091954939982357, 0.03921425512697803, -0.8761338111242023, -0.5993701715143083, -0.2182897031144679, 0.16710007027580626, -0.11420799218322279, 0.5545169233256209, -0.03097856569351179, -0.6978915225584479, -0.20294375075930213, -0.4007545751199209, -0.7453415343498039, -0.973296666551849, 0.0472849588484941, -0.02340794545931048, -0.2968652198161217, 0.20923854891345356, -0.39305813954794033, 0.4938880647898037, -0.3358081967204898, 0.7159902447029943, 0.4776462069122818, 0.6668943890280808, 0.17596976937648276, -0.12070895015901818, -0.34884122123806194, -0.6617638732169642, -0.7428212167405076, 0.7512510399760772, -0.31908136318111463, -0.041662885670612965, -0.4206492700296404, -0.02991400985628169, -0.4994637697120345, -0.2789260721059815, -0.21351304012625358, -0.47461773709363503, -0.1358464678411719, 0.2808078638794967, -0.5183670218062028},
    {-0.4174221021129563, -0.2319990530196456, -0.49100791531481264, -0.2867918396114044, 0.3834152710447339, 0.16676298588627667, -0.3014007591423879, -0.3029401982660746, -0.5152686011724175, -0.4410160251368827, -0.34185689917302725, -0.19421683780888988, -0.5136784714761478, -0.031955803841607434, -0.022076902944443564, -0.31968907955487136, 0.7614787688567589, -0.2582572811265539, -0.506489784765833, -0.05077406211760971, -0.33015439245458444, -0.5262579133781093, -0.3007989548923694, -0.44491308098539945, -0.5608886785434044, -0.1919257332899859, -0.6005739494647879, -0.628059486683045, 0.20496932049725794, -0.05883535161443078, 0.03889860666302901, -0.3619103194711724, -0.6862704546803944, -0.2757038729756625, -0.2003251881521352, -0.17026596990337595, -0.1830224203294698, -0.21574049478981777, 0.7772070973356774, -0.5606560636402033, -0.2840383614746404, 0.31144889309370444, 0.9101315813042177, -0.49176415302376386, 0.5477983490968252, 0.22902355728811832, 0.4375218693838067, -0.33132788968125515, -0.524819142340682, -0.521754077270336, -0.6307492965237212, -0.9413757622791359, 0.674658026581614, -0.27122981443209176, -0.20070200020520632, 0.20487789285148358, -0.4227978463415632, -0.3559778904239496, -0.31946329207991875, -0.48468196337326225, -0.06323358919757624, -0.5765848151675904, -0.13927125218489622, -0.22611460414286347},
    {-0.09673690363617561, -0.004295387500540289, -0.061598536081206925, 0.3605266667452436, 0.8647367362067933, 0.6029458301083129, -0.2950791317885265, -0.516723447440047, -0.6320683974205019, -0.006497633001389599, 0.6325516431545446, -0.33523985788596444, -0.44782223968042256, 0.5848074014774791, 0.4779847840713758, 0.3184732269674245, 0.9613483580757248, -0.6030985598594396, -0.49093578168700464, -0.5478146239557228, -0.21329984588999143, -0.5745194014307894, 0.08361194072960489, -0.5223924811014792, -0.46460402614763774, 0.30657203864587873, -0.3322493253633357, -0.29329162115708585, 0.10678690770907348, -0.16508245541007419, 0.005864174268193918, 0.2972263936664696, -0.5646478017145514, 0.6042067667425162, -0.4110161230180706, -0.1494277201519201, -0.4433026393982755, 0.16347524145385714, 0.450843388885972, -0.3405576332683089, -0.35222048035673464, 0.5030514023789532, 0.5629425178811633, -2.7490373881837934e-05, 0.22753312719478672, 0.16589294792723752, 0.15128452600676395, 0.01970738819275344, -0.28331715293724485, -0.20021196992020202, -0.6474211745820734, -0.7450923158290677, 0.7248482374772314, -0.20881296416390555, 0.37771399973707814, 0.3443013594655919, -0.01196155115505182, -0.3293827361168229, 0.20904541243910896, 0.13417899193823105, 0.1690297331849616, -0.014993366355047158, -0.18675750095637317, -0.22665911698102578},
    {-0.13880810331514215, 0.06940519235337811, -0.6363137479895202, 0.11578726852904477, 0.6978689532076002, 0.3921360940315223, -0.4811215280614811, -0.820186945923519, -0.8636372295056869, -0.3889116654622079, 0.3704122302997379, -0.4866621907882295, -0.5248657394310582, 0.44937553797830926, -0.3757526077971364, -0.5892256292661834, 0.7658311397383692, -0.4481381456325578, -0.7108513054189326, -0.5654627202944135, -0.2858876952566347, -0.7372497518811775, -0.09745812069901912, -0.5005739997170026, -0.7092037138419592, 0.24923588768681243, -0.044915618154786285, -0.8387670772230752, -0.48591316310389265, 0.22514507203706616, -0.4921745586631317, -0.10863916928402077, -0.6599214671058434, 0.04265438451246084, -0.52948894038649, -0.0795370402165228, -0.6091604895224951, 0.2203698985988195, 0.3770231080298326, -0.2476035465684302, -0.3235988693206547, 0.05332452552934971, 0.1931993918900918, -0.03158311115977443, 0.26462462832503475, -0.3082193775275932, 0.5598394491980486, -0.6203316219519673, -0.7179627772139895, -0.4620309440146675, -0.900877903030499, -0.41586999723339085, 0.24592619137315383, -0.6378677617000514, -0.1191267764120147, 0.4612695214761626, -0.6512724982488156, -0.8569704239440565, -0.6433059891864931, 0.2884140797718445, 0.6221722359815139, -0.5645073884418514, -0.5304417624234103, 0.6788009458687898},
    {-0.5743218804983714, -0.26735965387160204, -0.39537382472938704, -0.19915308664591735, 0.35880928210260465, 0.3518020565669572, -0.5943373425556009, -0.8178267416564335, -0.9925503587796354, -0.5534438242190907, -0.32701023757480413, -0.8020777156742449, -0.7160221389614153, 0.1863987321631033, -0.5148222985650571, 0.03926333789927471, 0.7529489141661052, -0.7004952109542055, -0.636184369772755, -0.10052450752090998, -0.4390132904591968, -0.6212841720776789, -0.07708416006168592, -0.6575294707087072, -0.6351521819801796, -0.30498260715293046, -0.7925057438411236, -0.7340129408166884, 0.01008983021906562, 0.2282411213715922, -0.14362137839468636, -0.3531706161007883, -0.350486083253282, 0.10294855775661269, -0.42730833598548007, -0.36683353411642605, -0.5944697822142463, -0.1181272776902045, 0.37995153227880774, -0.8539026757791998, -0.547853247583367, -0.06726786108053094, 0.21956027605075162, -0.4601978547960131, 0.2856134141748684, 0.14240336227342743, -0.004062210259897343, -0.575183780974531, -0.3802752817631892, -0.4515677326106968, -0.8747885158441931, -0.6394777495495355, 0.11457814733626374, -0.5193141600419556, -0.36389700554944887, -0.19989255341072545, -0.31681882637752834, -0.6649837319615792, -0.43439523965524257, -0.35942275023574494, -0.163224798650462, -0.7452663981172506, -0.7759023257527966, -0.32580182605961716},
    {0.31283465756433865, 0.09372892214941234, -0.7576318486384322, -0.18110883897154828, 0.7067309058640886, 0.1903710484443339, 0.24714645956524642, -0.3116512496738392, -0.4020440256357904, -0.5591709462870411, -0.3299101294296595, -0.6839932229107755, 0.08312486394589945, 0.7398036687022949, -0.5976494131443314, -0.42765715957438616, 0.6597436431161464, -0.480930822173701, 0.10828204722795466, 0.24100019634692924, 0.22756095784726216, -0.027840566350299415, -0.164850417036125, -0.45405563437598506, -0.2414910281826677, -0.44630316909292744, 0.0038953652541870616, -0.29447522124179715, 0.06711352138711867, -0.08020452148956654, -0.4150171259026093, 0.003840152417660727, -0.04541118211133937, -0.10884391528503337, -0.4424065989542427, -0.01973264395656242, -0.18609915900517313, 0.7530935607350631, 0.3856678932635799, -0.320812218115619, 0.02921848214903705, -0.27827850594804215, 0.3283805002983681, -0.2853873144495823, 0.5423185486372853, -0.25679275131525003, 0.3876013179385975, 0.006545261443114416, 0.01455840428602612, -0.2086332647792873, -0.48914712937395605, -0.34797186451507683, -0.04729374918885004, -0.533472077254323, 0.2117266781555341, -0.02686590655347193, -0.08094159417382983, -0.3398469473619564, -0.675576142421217, -0.022411998953980203, 0.17829992375681047, 0.14388694097724977, -0.1948796497514752, 0.053288465544110014},
    {-0.7026073767903617, -0.09405644627413476, -0.030413132896393448, 0.5360886674792875, 0.8866459352306905, 0.8658065009052196, -0.021231334710513586, -0.4805400650937184, -0.6928736143545013, 0.021200225951286965, 0.00779639316159852, -0.7213028017836252, -0.4035208485481182, 0.7714572347796771, 0.031744674255672164, 0.09323006163207623, 0.7293246097309058, -0.22334711895362822, -0.0876305628089862, -0.08713377507462618, -0.09212282191182214, -0.5504923727627302, -0.1558307009657515, -0.5806990412518869, -0.7713552376501683, 0.3345037749143054, -0.43675053649965284, -0.2576698421672802, -0.10899062280353942, -0.11703441432231074, -0.1557587948638947, 0.11727671589835188, -0.3355720535577819, 0.33995642290168204, -0.2837524980367394, -0.27310757688788434, -0.4968352108883962, -0.17017662032430153, 0.7119963867798708, -0.5645707374520842, -0.1774941097090617, 0.4428303738081363, 0.9588343055000673, 0.3835528824001315, 0.7679597224083581, 0.48005833508733226, 0.43038202781154866, -0.1551570332870975, -0.40584965335786727, -0.020090071649608004, -0.279869659250676, -0.45951260331409977, 0.7073247290125704, -0.4524022476043461, 0.39870264291885726, 0.1808780279048212, -0.29778268167793936, -0.5599907138333656, -0.025974722738932265, 0.03276471652931041, 0.19808310791945288, -0.24742211908829378, -0.1352859266261191, 0.29411963461313145},
    {-0.459279484703572, 0.1973933150465027, -0.38086260947174233, 0.43580506282286846, 0.5757308389389696, 0.9104473692929658, -0.13615600286935747, -0.6062573245997263, -0.4283962327328009, 0.5239134776414316, -0.15709077865920298, -0.8120031036965029, -0.16956035694658417, 0.5865532060595884, 0.06628564480678166, 0.2678185153004683, 0.7012184973618264, -0.7335962720248174, 0.14251672114447267, 0.01930603965642588, -0.5189173737814522, -0.5342240153781688, 0.07190984996346868, -0.4197633188186171, 0.01882897704169972, -0.26039065839422604, -0.2554829755247623, -0.07045090913138198, 0.06479496829285876, -0.7056379996891678, 0.42331863149759236, -0.1499479925550999, -0.03770304186721049, 0.45063272423378825, -0.07750980769343181, -0.5252749417858167, -0.5041672898368849, 0.286318234437148, 0.4588990874836895, -0.6274729303230036, 0.17312928879110534, -0.088725483280693, 0.5163423912672959, 0.15986975368069592, -0.10201798908880033, 0.25132108466126374, 0.05728895093517682, 0.8027589438294274, 0.0005242355072832, -0.11761092091382123, -0.4664214784623099, 0.18507325566225358, 0.1727630334353581, -0.5353241826907873, 0.13260298545419497, 0.26742393339500964, 0.32097113352643597, -0.19887585978332237, 0.32236455110397244, -0.6022733890362723, 0.18670649697666636, -0.03556725443863, -0.08252644615620285, -0.3862789107150357},
    {-0.878299042201636, -0.425971429996314, -0.8927095722248204, 0.4989045241692612, 0.24932932111843947, -0.20076709666118908, -0.6631900839821088, -0.6314671646265603, -0.807912241073824, -0.8314488518992458, -0.2048183495829898, -0.7710488874075941, -0.4917611837083794, -0.5010693831968615, -0.5341632543651117, -0.4740191670305718, 0.2223562912126747, -0.7718809762016376, -0.8048134923685352, -0.5833198036782755, -0.713016047772844, -0.7676180742896445, -0.583907003806805, -0.5213461522830939, -0.8034014164756064, 0.16162563167855185, -0.5726609781743035, -0.7724852289605137, -0.5733328303368193, 0.08222125119518083, -0.7056474156722726, -0.5770556235962897, -0.8234412021966697, -0.8968259687466985, -0.7316449321970916, -0.3658511914916413, -0.6910686686118102, -0.03630108897523008, -0.15120337916774237, -0.5046791806323693, -0.5338445597456631, -0.1634071297603184, -0.765335036330471, -0.25724470819090006, -0.5742529699076598, -0.5798947062447952, -0.7453972389083005, -0.6467186831483427, -0.7897934206905568, -0.5407726464973084, -0.6603329733825234, -1.023783901837866, -0.4962667431709572, -0.4357223829411928, -0.7086671373077411, -0.01044529351718468, -0.47627013687526876, -0.8137588308581555, -0.7237413601826214, -0.16191853379705703, 0.2274258926911405, -0.8814057830684332, -0.579272768107357, -0.18138887721534042},
    {-0.44853453156648, -0.4870746632934702, -0.3229072921045589, 0.46995717104675405, 0.6305612375816301, -0.21739098007976126, -0.49938910446252366, -0.676017391595489, -0.6490028306264719, -0.9744671452201367, 0.3204339209609023, -0.5384009169008734, -0.7021839967465026, -0.3399605245988776, -0.432370639271907, -0.13624525998951884, 0.5994496616415054, -0.38551746068040094, -1.0090098948112987, -0.5984653776563009, -0.6070561093343666, -0.750017429268468, -0.3383488305531744, -0.6190832184324976, -0.773561347210144, 0.2957590828087487, -0.36537393246005256, -0.9051811033616951, -0.8930053549473276, -0.023878632260987576, -0.34365090579471325, -0.5329849612271963, -0.6736761390593027, -0.17248834514329828, -0.597696460915567, -0.18481608284005074, -0.5655124929307741, -0.04645102937185179, -0.43342203353096687, -0.3481506609845043, -0.252163984739952, 0.1717762357118967, -0.666713831594663, 0.25280709088881803, -0.7650776732071293, -0.10769661300148145, -0.7040470854563217, -0.5099944658163232, -0.5377115921141339, -0.8168829749935206, -0.410811814636553, -0.8176377595009476, 0.1973962921264877, 0.22479667288771688, -0.6557197381365966, 0.07558153702861438, -0.663757420954091, -0.8879118160240287, -0.5705048497337843, -0.031097701745480846, 0.47149302520206626, -0.7319100297390754, -0.5011021980828945, 0.09773320216459035},
    {-0.2833172530357855, -0.5458571394797919, -0.514486855866237, 0.5107265363635365, 0.5142765090336064, -0.8275312783108835, 0.4358808970465941, 0.3979881023381501, -0.35655800327300824, -0.9413289093307811, 0.2547207831460581, -0.2663358306119811, -0.5657808327361177, -0.10057756621429524, -0.1088268107256924, -0.43719654945997327, 0.6288988880007845, -0.5801112923682727, -0.717553346992366, -0.7240885258711091, -0.384759615438617, -0.43719305994188623, -0.7755660204169084, -0.2602571772673788, -0.7543913658214115, 0.2065161891754744, -0.3179802686635331, -0.6099072107778719, -0.4726694505484563, -0.3453739516182029, -0.38107522110619746, -0.22186864262224545, -0.6434506675578769, -0.382185496315107, -0.6194080681117542, 0.09898686609385969, -0.5147480123917899, -0.28626639230179474, 0.14534421923188567, 0.05211768152040412, -0.5962174555301719, 0.4136687345323173, -0.8312106469900492, 0.26314563786949846, -0.3184680247554614, -0.264503745988933, -0.6545657246694896, -0.19130825674085228, -0.5191828672539363, -0.7760031440876445, -0.8448071496884034, -0.482772461537816, -0.574769425000892, -0.2451715080904419, 0.1956923790001654, 0.586136987590941, -0.13050872652822793, -0.7867711421516247, -0.4575629212345395, -0.36599496359252154, 0.36745413709276475, -0.46056651778584656, -0.6688468377272694, -0.08405017753666029},
    {0.07382188107567604, -0.8913309953043482, 0.033232455407905, 0.1689436212264865, 0.39527352400613286, 0.3727082301954621, -0.18748294912204821, -0.21380104407098266, -0.44168609107841705, -0.609329950861643, 0.40211344177656977, -0.6114219920277458, -0.45576453546584167, 0.045745344619637376, -0.3097212562723876, -0.660907691368024, 0.7100204595084694, -0.27036393859413776, -0.5161053079719816, -0.6771120686141863, -0.2003386599498985, -0.8305674221688848, -0.43873260480887244, -0.14213485335293438, -0.4203419394718246, 0.4530576113003387, -0.1089066047737608, -0.5946070474861975, -0.8857354051208594, 0.16771507010449718, -0.43174697779451704, -0.12221483766414602, -0.5833880490278645, -0.02539707920656783, -0.768984025112992, 0.3332846543490863, -0.0782406620245822, 0.28029343503703147, -0.19858325915986377, 0.16093219370147263, -0.21069959295950663, 0.2600297339772978, -0.6762312486380148, 0.39402764628736725, -0.3647239367174834, -0.4927898504583867, -0.8184163643165423, -0.17412377128625797, -0.6336161755821499, -0.7397594728709241, -0.3450877550103735, 0.030886925458525765, -0.45759813976135677, 0.11559614994717357, -0.13784837094048602, 0.29641618589443053, 0.008472165543097555, -0.2601615511183577, -0.8708389786077304, 0.09176953717394985, 0.5192710368709871, -0.449249930023241, -0.547501697216254, 0.4907686973008593},
    {0.016083019596164472, -0.00603811493246548, 0.0752004268385089, 0.6470750038525928, 0.628148699683314, 0.060085320752935864, 0.29822408415801627, 0.2772676456080883, -0.02168076746511928, -0.5577994609204528, 0.5677763805831945, 0.12988258220947968, -0.2036614534159251, 0.4493615341169729, -0.45993614056578125, -0.5170091007015144, 0.34513807826517484, -0.24174008958703744, -0.705567947877428, -0.13522768617714415, -0.36371578016815737, -0.43304299518928524, -0.055482697314604895, -0.15289246626528877, -0.044093263806069864, 0.8009944291865473, -0.22000905246268437, -0.782568276685013, -0.5920582984006296, 0.13194535505788932, -0.08969351078747831, -0.310409509791653, -0.2910134959611885, -0.4368094040105498, -0.6908739499379815, 0.37427047800609353, -0.11655796822264754, -0.13599195168276687, 0.29491999935086255, 0.09494798500875742, 0.048122628097616166, 0.24234271948894473, -0.0226721217828911, 0.19743613404929575, -0.2967076507139448, 0.3115138654792549, -0.2746240281637913, -0.31525266254092976, 0.05740208181976131, 0.1956341415348922, -0.32174875404069225, 0.17268955930354699, -0.061926327575000904, 0.19413238766412508, -0.23981352260113314, 0.5010107908963295, 0.04199812431165592, -0.5301510641122544, -0.42825739602869267, 0.6190969651778713, 0.6831523848929063, -0.6071888626095031, -0.17542351013480442, 0.5499065313772298},
    {0.2771513390606827, -0.27304540641523833, -0.17562069720322793, 0.38839572139895845, 0.5732841250732915, 0.16880360097957076, -0.48949319500008603, -0.36681720588479233, -0.17694275576490587, -0.539345118556522, 0.36503938772935934, -0.6684849978659008, -0.42091065011547457, 0.14169794456638007, -0.7638958760935879, 0.051595716941564174, 0.3112202706654425, 0.04940228218679884, -0.121049175847944, -0.03357694194075835, 0.48625140365068803, -0.47461837898741926, 0.02860279157524364, 0.28287103951744036, -0.22474262619386084, 1.054300942287154, 0.19931960866863632, -0.34529346340925643, -0.4174345253149737, -0.1343191489843715, -0.5062239209153719, 0.599831501852858, -0.40283222910424593, 0.13986772842493153, -0.33829734467831374, 0.4255620337968491, -0.7012401847509638, 0.47470927901985505, 0.01822620502574675, 0.43383641853602, -0.32075860618038976, 0.5179963504428363, -0.2069707204508037, 0.45017199337884134, 0.03122464621118903, 0.036134372403285146, -0.10653155335003374, -0.5003691513345556, -0.5260443675649724, -0.5029199203549664, -0.5034034122008321, 0.2600131197447638, 0.6572176728748624, 0.38998574832595057, -0.15289361206042104, 0.7571128957419693, -0.11728811354609087, -0.4714142309440108, -0.2768865909762094, -0.11484986311699677, 0.2932241165069135, -0.3293655539084878, -0.629441652839043, 0.5623237708908024},
    {-0.12050086696676157, 0.010755036954172341, -0.16722578584866765, 0.5120567905098555, 0.4726771691249754, -0.09734271914253172, 0.3707796949717568, 0.16649995535362402, -0.21456023178786285, -0.5989965966126958, 0.49172154049401684, 0.010222580143226894, -0.6589478660986374, 0.3110031312089554, -0.14077777736733466, -0.4032964711123784, 0.2110939015144517, 0.020579554497318443, -0.4272157374442254, -0.11337333415955263, -0.29986048934521264, -0.3317423910730789, 0.0028737752370019444, 0.3143498012308198, -0.11218198502486358, 0.18397898358046236, 0.43301015054763053, -0.31758284823455646, -0.33061156027528205, -0.488761317595477, 0.15293005670844395, 0.11236243285429579, -0.5663322376076388, -0.21536582543581542, 0.1391714121892836, 0.15458682827416628, -0.4886999003460649, -0.2965731972454806, 0.4077258149754628, 0.15870008018483953, -0.3220876400682106, 0.46344398745811366, -0.4618123854713353, 0.3068157512784747, 0.08043316333743288, 0.018511465716446567, -0.02962299242026306, -0.021973150847446842, -0.44906224187668037, -0.7598148326392288, -0.24066457730293925, 0.016592804329507566, 0.6080363632843361, 0.27851328561180827, 0.12142000577059832, 0.5793397324835065, 0.0032101902691009632, -0.894615523831628, 0.4653145652116066, -0.02760470048872233, 0.5342933134464385, -0.27467728907467254, -0.4119068270519936, 0.03088503008981535},
    {-0.020488230069641934, -0.2204498044032022, -0.33151885719805607, 0.20839856817753008, 0.44921003924052905, 0.35292845668633654, 0.19024865029614427, 0.1323645218990432, -0.43319279393530424, -0.15245338500217745, 0.06935784762021359, -0.41901263206238853, -0.32020562859188917, 0.2283144498184973, -0.11138867641022956, -0.28076110181211933, 0.4541073105758991, -0.38179464763093934, -0.08996451550912775, -0.20371075898652144, -0.09152571176484761, -0.4767775479395994, -0.45634616065206773, -0.3840176829916568, -0.019428156803543557, 0.5410514948124306, -0.09790978504276754, -0.3962716951401226, 0.26564585125939366, -0.30688575276848873, -0.40398771063503797, 0.615116069492985, -0.2542222338148209, -0.1078632860154995, -0.3708762935819025, 0.17057739205413472, -0.5528520842057453, 0.0805035848890837, -0.15245290050588167, -0.26593097012265443, 0.2505212289321463, 0.5056731529979219, -0.6043943466407046, 0.6533504317558064, -0.14991668972877384, -0.05280215262319973, -0.06061733334202514, -0.5498330604974458, -0.13930339823189605, 0.06381500053054492, -0.8234541998504428, -0.10289464008776453, -0.20860915904321597, -0.4461311084454418, -0.21070030290044384, 0.05336444509685433, -0.034168627686034604, -0.3750515082632543, -0.1617209844605392, -0.21281146622030175, -0.5789223861046026, 0.01255989785846139, -0.1085013324623719, 0.33176441661155054},
    {-0.4553137358507329, -0.7083611698256306, -0.2529706589784639, 0.2338757307050092, 0.5899641352488918, 0.43297894313904944, -0.2511058304827539, -0.015482462698121717, -0.4300414366287504, -0.1986374852878306, 0.09110231569193368, -0.6367241449222305, -0.5293689775340862, 0.023958634828232225, 0.5249993696728187, 0.08851917803510301, 0.2347272803134031, -0.4346800856256994, -0.6542820916848734, -0.2926873347235283, -0.5625004698573235, -0.058750330431348155, 0.14305409225518956, -0.2293941400595351, -0.5718978843008532, 0.6172732372684646, -0.10983109171013182, -0.3475179889733451, -0.22012602542241658, -0.31527592370256774, -0.17252187367941915, 0.5058562570214152, -0.11118414839107083, 0.1758352678113526, -0.4188114620179539, 0.4792000455329543, -0.706259847576936, 0.4234359250595852, 0.17016813236656378, 0.1573328023186216, -0.08052676916990727, 0.5148708673155538, -0.24345020517381152, -0.09103880510252751, -0.15842251431356105, -0.05160106443105116, -0.6480676374907877, 0.052622800631267036, -0.15448743199082818, -0.5772892226835362, -0.49740293736720254, -0.015017238844763752, 0.3956954137827734, -0.11393691855245658, -0.1257922291721242, 0.015171390748037581, -0.910760469418055, -0.1263099176000712, -0.2552530042023923, -0.5158015979440912, 0.4887566762244048, 0.0544055717733676, 0.2361126770534903, -0.3269982268083653},
    {-0.4008105122546263, -0.550840121895734, -0.04973357493877719, -0.19038840559000164, 0.4476216538161207, 0.18871284936054644, 0.19933448745567287, -0.11215118114530025, -0.43672424177964136, -0.11539882598049293, -0.4794876510004578, -0.14047951448176327, -0.4889853574311972, -0.1363127041626758, 0.4459965207083775, -0.2885721124750972, 0.358591709173709, -0.06114637442551633, -0.5597451184569522, -0.1460817652548191, -0.49511996662910074, -0.013933175429712123, 0.5445931548684058, 0.20919245773758272, -0.30670542516491806, 0.7912374771456159, 0.1087156589812596, -0.1310284725738996, -0.19356592294156275, -0.46958778658958605, -0.18994867189016248, 0.8911906136381397, -0.18328866925384676, -0.023852189669250717, -0.32061189340935004, 0.5539753157030585, 0.2698438637332619, -0.054216365437670326, 0.18009263935597686, -0.21043444635589806, -0.08042972713075222, 0.22969984750768876, -0.1643152361776304, -0.2817063622823075, 0.29003650932927727, 0.13120273692102266, 0.3207913787126261, -0.7250039587021503, -0.1252025434621956, -0.4120065926323868, -0.38877012619068063, 0.2501901478338528, -0.3277076370367214, 0.3801512054372487, -0.3429563870483836, 0.005887119929561277, 0.16044208633264578, -0.19466598183931658, 0.2795976200378395, -0.08248013357443257, 0.02976502349556658, -0.4013053133574262, 0.022559825785467804, -0.28745897772939477},
    {0.36065754797404503, 0.021700317707447535, 0.25517092306065037, 0.08095907148336742, 0.1712589379921308, -0.0781720818822592, 0.48502308076266365, 0.09013930101213433, 0.29469513044024126, -0.0790449464166046, 0.29474028220738374, 0.08942027577315405, 0.07452411807960865, 0.13452703506487554, -0.6404341896881508, -0.4071753174512471, 0.20443307711618422, -0.5338967857368725, -0.32403786618493857, 0.41863925009520697, 0.29978494471018025, -0.08043022388376281, -0.36309929727294327, -0.44603999341857536, -0.17818887467107894, 0.6924342714615838, -0.16887517887468453, -0.12393988906570236, -0.14208588397008767, 0.009334723579051693, -0.3205299213892452, -0.20596601395969438, -0.17087244668683338, 0.538680765459548, -0.32212262721209445, 0.5334822359450835, -0.0004931856285077668, -0.3949527545991338, 0.3906625283917139, 0.47036740449781866, -0.25099052579317543, 0.20477651389169574, -0.568195415964621, -0.09729851166791355, 0.029750965290068397, 0.451696290030252, -0.2804921127429742, -0.32065733256420087, -0.07534023718266117, -0.025607578976234276, 0.2558695980733395, 0.1754315243409662, -0.152530152587763, -0.5592237314268154, 0.35450446143956876, 0.1279809599912266, -0.1772688624663988, 0.10069540223312823, 0.0663104724439991, 0.3826544793117582, 0.13476010435213587, -0.2575102057822312, 0.25047756056287346, -0.2674559027735851},
    {0.307661928667661, -0.3737756604975099, -0.9306202217726102, -0.5357411236786339, -0.40671924900094136, -0.06284645103666224, 0.24629296433457756, 0.16797058823372926, -0.28642803571832187, -0.40176736073606145, -0.42755478328890134, -0.33038925700907484, 0.26746440321664944, 0.15748523201457323, 0.2537394767826876, -0.07450448210641045, 0.307173581153505, -0.5986489790659942, -0.27294405346026424, -0.08783438378245367, -0.19203542618200542, -0.18038554426054793, 0.2971635965412457, 0.007420277352137148, -0.06165328195438918, 0.09459861836727364, -0.147102154112009, -0.382622394845332, 0.1567120083850542, -0.03384750639657592, -0.2958665784025708, 0.32013606651372556, -0.31121466442802614, -0.388029692552713, -0.30636059984896524, -0.01795429122534152, 0.5020635434665304, 0.19701544699570375, 0.1963577822210838, -0.11861558587589631, -0.7435093020888913, -0.24307931677184536, -0.43969284677854187, 0.03370397058791538, 0.7878783518290267, -0.5753108982358438, -0.014485387721182874, -0.5559121028818945, -0.9201697047401642, -0.32006942371994573, 0.41809840603588294, 0.11842572441030871, -0.23446276481715617, -0.05955461842763045, 0.14616393727896074, 0.7269125283110404, 0.006967157744745882, 0.07427478277537063, 0.6087674782858425, 0.03550918523318279, 0.12158921460835846, -0.29942913918888936, -0.5648502269742469, -0.17986012638327795},
    {-0.1012614103531043, -0.7037086247626103, 0.1789821195385174, 0.2804132919805478, 0.26962715744480215, -0.24265621940359894, -0.014589016568083733, -0.10728375001175237, -0.4241364255986981, 0.08123378893620453, 0.17749707653833988, -0.6806630517842208, -0.2537657715593618, 0.08556694074265662, 0.20187771913477678, 0.16916305260668324, 0.810967952701397, -0.32735289184238436, -0.47610642711241496, -0.11260459357330402, -0.10131245342953939, -0.38324185247310777, -0.39770400600608036, -0.3604516038563842, -0.2304478873552617, 0.37836068529258055, -0.023571517194289848, -0.1507147357715785, -0.14705816718600925, -0.5303368280496067, 0.2135513388951032, -0.15550649254697635, -0.40039972501984444, -0.3012922615934888, 0.09610138704136187, -0.09837214324097394, -0.015231695538406783, -0.024209356177325614, 0.1534498656109857, 0.057705497601868265, -0.39000813442730925, 0.4542012321287297, -0.16695953671062658, 0.3973373209610617, 0.012046770552804061, -0.56972299323899, -0.1651979854246356, -0.09233911516710795, -0.41537875603263313, -0.34492869922662156, -0.36139268834040594, -0.4083096850195239, 0.042494397642240146, 0.06249944641668489, -0.29017997516142013, 0.3284655836122936, -0.2198631355923475, -0.4949090211567027, 0.002788914530924623, -0.005525632139322991, -0.4156892711710197, -0.493557601718111, -0.36179392207768535, 0.028224407974366792},
    {0.03347301252170406, -0.696104757063936, -0.35946596646533996, 0.30205241426326995, -0.12241675279107551, -0.28708558636659176, -0.019999907783567267, -0.4343997820087337, -0.1775576588766723, -0.5735817950409478, 0.457830829363066, 0.14829093953491004, -0.2831421989926447, -0.10035456702405657, -0.06105171915634535, -0.11203835494425485, 0.18490520958320295, 0.05452501472668121, 0.4145718213765665, 0.08492137244914971, -0.11944767441054135, -0.5407660682759219, -0.5729376346794006, -0.13367397563288888, 0.20107963468858633, -0.23576884930755904, 0.10433725571849274, -0.333299013934471, -0.42529516498094616, 0.24672701596800078, -0.2266478731920868, -0.03266449395358721, -0.6561640196704699, 0.16771345054610895, -0.7217523147359142, 0.05828490883607869, -0.30434524979205496, -0.34666282767688633, 0.0826003458180879, 0.011433394337010589, -0.020336541641638117, -0.30659361141194197, 0.043532647631434496, 0.06283572636803841, -0.39527294905503185, -0.13548131692239007, -0.06428444815908496, 0.17515483854364858, -0.15287353219362382, -0.4230599159259754, -0.07763527074765868, -0.5287291970513456, 0.09155748047791339, -0.35878236335130076, -0.12101610599801105, 0.00923490296493252, -0.12050787118361406, -0.30839636231993994, -0.41233695950515015, -0.5518330807199568, -0.17495238886599052, -0.3448229958280296, -0.49144654471817506, -0.05137461889212525},
    {0.3131376239570919, -0.4430024688499512, 0.34805016498620356, 0.07620775683023523, -0.35646333738006347, -0.8098244426053158, -0.04594136351918422, 0.33748225006805704, -0.01205767771119751, 0.04855501224387704, 0.7388424557252343, -0.025175726960735462, -0.07090497099963351, -0.10719100529433832, 0.1652413973238033, -0.041378645980044364, 0.20479437218894486, 0.29576715091530675, 0.12378431987111178, -0.07388251691263707, -0.08582195087503681, -0.02716022221585669, -0.6522507972284434, -0.6149399845859573, -0.09670636733364955, 0.1856065545752575, -0.5981808542512114, 0.15453085020188528, -0.21722278741091183, -0.6074512667380193, -0.29253344404671455, 0.14751824853977122, 0.3592483579966446, -0.5062655669109529, -0.04765605182108985, 0.10376830799015353, 0.44132176193220507, -0.09268171436308785, -0.18419088949897802, 0.33283097702932213, -0.03113550543556174, 0.750825883880135, -0.39903057555925797, 0.14032177219567987, 0.34128145624747575, -0.09039463074115064, -0.026507569597315754, -0.07474249286209417, -0.423931218361758, -0.00013020316981223414, -0.4799222512424887, -0.2631067858020963, -0.3131058435968971, 0.5951598786069007, 0.5216991961995362, -0.010969332440804816, 0.5268407823661927, -0.33001677024868414, 0.40211761790160994, -0.19186773544459845, 0.06186345078468269, -0.15556546327456136, 0.3565105048343618, 0.11651570655426428},
    {-0.290386701014568, -0.3832002061991928, -0.248443661017557, 0.6596171883115844, -0.3197635746380428, -0.1709751394608824, -0.09792564644389512, -0.18413966301965357, -0.2713393033403097, -0.07138933456549561, 0.10834328563675157, -0.3371582671394704, -0.5371308567324156, 0.07793658989355909, 0.3762864872544251, -0.49176371602237895, 0.12822241219063885, -0.20707191406642958, -0.3455945344117602, -0.29705823401261167, -0.7239714315451462, -0.09097441439986984, -0.2131975216913487, -0.24348614957976436, -0.4270242073825568, 0.5789958993497475, -0.32027060276661834, 0.1989874567902517, -0.006835664511842281, -0.2975819021630177, 0.18873072258332965, 0.04692308894315907, -0.39731898429084445, 0.03229831223391513, -0.2168313517833345, -0.26987680321659835, -0.12823195590086117, -0.004261608430393076, -0.17079785123484503, 0.37694953949674515, -0.369421127156066, 0.040482824875077, 0.0830434290036181, 0.5230602756675962, 0.11587867714266066, -0.16216358105235615, 0.37106700227919065, -0.14581417207713773, -0.18718996843250527, -0.9273443833704663, 0.10550563983298303, -0.3714877068625299, -0.11161328328198396, -0.28811469259414324, 0.70764302541038, 0.19070716162046084, -0.16223648740806998, -0.0832547099677791, 0.07325995207227913, 0.3187330525055227, -0.48238280956569735, -0.3979091679901853, -0.3335263230551174, -0.45460169003138107},
    {-0.0394381885869332, 0.05107587911006057, 0.2928751469681928, -0.10292865397011207, -0.011834254962566662, -0.1328209465801255, -0.3322857485901555, 0.030287376874609955, 0.25467143873300097, 0.2551587855081801, 0.5009553716819392, 0.01355589242607301, 0.09329663247304791, 0.3373499466697555, -0.001593954653140484, -0.188645324507464, -0.011762957973852343, 0.22101157117937756, -0.3284015617157631, -0.061272683447612275, 0.04883068031549814, -0.5317188682925619, -0.23631337538116542, 0.246439334442094, 0.5260046538202623, -0.12837294509677322, 0.6191981822424067, 0.2153356487234246, -0.24279289421298003, -0.17186469100537569, 0.5216399531098476, 0.14986783004026294, -0.6293272229082502, 0.03331490867237892, 0.09168955174327517, 0.08686475254288109, -0.2320990033233819, 0.696401003285571, 0.029482905056265035, -0.008981796928824773, -0.06465559920455405, -0.20813028934908814, -0.0243855821527693, -0.027727333321321004, 0.4180810836741536, -0.5970590708479487, 0.46526029777971256, -0.02022026311689771, 0.4177176029228779, -0.04246596502386954, 0.11867792032049716, -0.2726353374487612, -0.07704960415543904, 0.42517477952149413, 0.023371425649725063, 0.30015296816921355, -0.40901432501810997, -0.2633836857063236, 0.13834287851680405, 0.1207978182488078, -0.11159142858128294, -0.14233545837541436, -0.0494521657084581, 0.06917959187199282},
    {0.6005549061508194, 0.6991489296052285, 0.1265940745221952, -0.3634420266214266, 0.16402490683391877, -0.5984719857501625, 0.22601937631461777, 0.26375140765530164, 0.48230593847567854, -0.23302130735766877, 0.070188775302529, -0.17629393902927123, -0.4837429888029494, 0.619531613243586, 0.23265919458674122, -0.643451896941745, -0.1179429225000244, 0.31596579086865456, -0.5190264240989677, -0.15432011090054087, -0.11464170251344642, -0.5267267774157545, -0.5572468812965585, 0.2763610504101731, -0.23507667715310632, -0.18493040666709137, -0.4069339680245664, 0.14069380242448193, -0.45428844647726224, -0.157312294540859, -0.13468315371561299, 0.39172900705899044, -0.26770025594136626, 0.2375894760861962, -0.036639202423538006, 0.13307703823386596, 0.1324177455253992, 0.7848834248813535, -0.23881254805497515, 0.7813674803319702, 0.1791326535473195, 0.4483611824087318, -0.2933106891831492, -0.3209886740823611, -0.030167939953860193, -0.3357897243445658, -0.4186542993753603, -0.48667617624449655, -0.31943796135174485, 0.25581131754769987, -0.2366706550051034, -0.11133552504490683, -0.48791801309520266, -0.5027221877905451, 0.34655697682734266, 0.040532189712878884, -0.22670821111790954, -0.22916802568778422, 0.04882916207760186, 0.02352130599252418, 0.06154659249308767, 0.17299275661880292, -0.28665186921285063, -0.3848899305296376},
    {0.366403082165746, -0.02000101779682546, 0.21769383611006904, 0.39005366467732205, 0.41537583124802446, -0.810108409443771, 0.14989947637369871, 0.2875136757919172, -0.15762272674229227, -0.1572193219895504, 0.2798923889928946, 0.1883901509904621, 0.3815861151534089, -0.10662134119293304, 0.10738527288804475, -0.41594463323971026, -0.24914614610551644, 0.33884679983849597, -0.33618606659998196, -0.2824655617246149, -0.286907658767769, 0.32414619932483874, 0.21465194892923187, 0.452476584228497, -0.11185418115031875, 0.2609942677451851, 0.035060563196122, 0.06954915222736022, 0.08582095200042453, -0.04790966645297991, 0.0756160553431084, 0.17828895004584652, -0.09390552123744472, 0.3482501489113668, 0.16036844875377274, 0.23172140185120477, -0.1415062016191235, 0.5088859146434075, 0.03105209817858963, 0.445290010404682, -0.040510016534151906, 0.32865394636033207, -0.2053074086799185, -0.1868448446335071, -0.4015644362306846, 0.07850662478719851, -0.38031942843786837, 0.2723314748175681, -0.2988986994018771, 0.16307601959926604, -0.10078449227474247, 0.005666787354478867, -0.33273551682591845, 0.5277921823765476, 0.5077109405973856, 0.6310824486875072, -0.5052786430104678, -0.16053098422781567, -0.2086561369069005, 0.5071582256774073, 0.48177691256530614, -0.40548604880793343, 0.21422282869644904, 0.23737597344193948},
    {0.11568259110889151, 0.3119405417763496, 0.4612053585773216, 0.22877781169440303, 0.12609747542677552, 0.32379982357421877, 0.3933195912310948, 0.5272604911919484, 0.11483523343348694, -0.373453990150414, -0.005395326419286045, -0.12658772605670143, 0.08894477641599667, -0.19311772521662496, -0.1508197380859385, -0.21903654690384058, 0.1992082013511524, 0.2133705084267848, -0.04319451305559603, -0.46763764627205445, 0.1460715993233759, -0.16405875005805537, 0.018348813552444693, -0.08981859166433326, -0.419511733774982, 0.08208450114946735, 0.227561640268736, -0.5934412865726579, -0.6722589461630575, 0.5523680710442016, 0.002087105350616268, 0.39832683013553566, 0.04211438870463458, -0.04742863822151276, 0.15623486794396177, 0.32312395559589085, -0.04566240436043029, 0.396107176723347, 0.3040071559451805, 0.6271548920164723, -0.11935759381513956, 0.3094448085340241, -0.38030294984258894, -0.1403301274182097, -0.12826048766213435, -0.3452165269695151, -0.0854068888381748, 0.07939046956354527, -0.20664848286832693, -0.6910978230358529, -0.3634514201247274, 0.16326126915899858, -0.36080414243141173, -0.045998974793429404, 0.0007799954983746143, 0.5670919813327945, -0.5264224120516872, 0.08398175183550324, -0.07068035894913287, 0.07488590210355088, -0.03936098020716444, 0.0013351742733904146, 0.2031443728871191, 0.1664096588465005},
    {0.10219583871943656, 0.42385346983904204, 0.06545342854002702, 0.47978897599839143, 0.4848398128116255, -0.12952006665989443, 0.4731497718479376, 0.10353979072200109, 0.303266987275381, 0.02954477967769017, 0.6005980371306292, -0.06764052912741612, 0.16836971951505955, 0.3781154292382703, 0.4820309290987197, -0.533163942078824, 0.3547204038092051, 0.3107534937312596, -0.1669943373489761, -0.39640654894454147, 0.4894680518227801, 0.18982989921756954, -0.10347490842396294, -0.0895423558880971, -0.017424402343247818, 0.3165230294717149, -0.2765496763837105, 0.1540539161100132, -0.8351380332099602, 0.03277196095303209, -0.006373465887273975, 0.19291401281343085, 0.009516436525888567, 0.5054452260499935, 0.2933873620521641, 0.04459938682008728, -0.11390834103524178, 0.1060804053561501, 0.2016568335385751, 0.4881761182724905, 0.06124593281756759, 0.16319590526605599, -0.12159487274742, 0.6470347327860086, 0.23012067061514058, -0.3713576411531082, -0.15868100324822806, -0.003600954583084164, 0.1182820706517679, -0.12908624230296456, -0.1617034133306329, 0.24808745811541869, -0.29459929698147924, 0.17277995932346912, 0.17690600575007773, 0.6812179512713676, 0.46990673092889806, -0.3808971777022753, -0.05817409792403081, 0.11550523128697227, -0.1220940109657123, -0.08049036881054047, 0.13636779660781292, 0.14073036356433863},
    {0.2150915411718813, 0.5273324026432152, 0.5170659205593837, 0.14885368491462322, 0.3298247935146684, -0.14999823615138916, 0.2496008199532914, -0.06815737968247856, 0.01387808562582069, -0.20035433555767673, 0.7705259786001153, -0.24313227495812484, 0.45384318496645665, 0.16161196264297506, 0.14988205346660435, -0.32342491776306076, 0.38108925091199475, 0.42907305949299057, -0.3377216794954351, 0.0260647735101626, 0.47201967490180563, 0.3046020147569944, -0.3338058220983117, 0.06250698475821571, 0.2548794526113287, 0.35112656779212104, -0.1574450181652065, 0.4244438375716531, -0.3528581902109293, 0.14856738793434468, 0.12142510332215799, -0.09397843426022127, 0.33754903102224376, 0.3283000958230331, 0.4783265390809071, 0.16418096780187816, 0.1510601388225984, 0.46840828046600586, 0.5771555330880754, 0.5582126650381918, -0.2215365185077519, 0.324133926156029, 0.3872415037984009, 0.5512627941163998, 0.12992008243318096, 0.5328653897276173, -0.20830565935616263, 0.22058111026221494, -0.059974546097677287, 0.3776751416200544, -0.06621983484620149, 0.42730352420236356, 0.041675784710130746, 0.5991213603935763, 0.5465155026080605, 0.4030337704332329, -0.38553938860381703, 0.2853840642091129, 0.5938903546825959, 0.6576269959468419, 0.2736283253942965, -0.19036071411860622, 0.5392205484533362, 0.0974416742906544},
    {0.611277397999644, -0.17081098731500172, -0.0077356711811660765, 0.028317974306442027, 0.03716175917270238, -0.2177370482142338, -0.27403573488037425, 0.026542290791201396, -0.4407008339218237, -0.08671475683550435, 0.4679021024518955, 0.12405241398736142, 0.5862434583078279, 0.1739065371623606, -0.2705507122925967, 0.11216885387478903, 0.35857391714044884, -0.1254452345166326, 0.18728560070454564, 0.00863774589970121, 0.45790231136787435, 0.10417836410324707, 0.3718018217567522, 0.32800067816232964, 0.3332581047090532, 0.2066450210685709, -0.41557025460705443, 0.023134598202589052, -0.31226680249310423, -0.23839624440748133, -0.026300163645955804, 0.19521595385931906, -0.10799154837397516, 0.24250804145344693, -0.2949360485058202, 0.19048026703672596, 0.17319463746005012, 0.19010609310598361, -0.042586668794824395, 0.2112057469366128, 0.5249443642198172, 0.3449317469141845, 0.0702981747468686, 0.4028544018796187, -0.6282050734136188, -0.109642530793414, -0.543574622233875, 0.23213800316423122, -0.2121465473375361, -0.002438859796416312, 0.10377778653471735, -0.21242021629032787, 0.16535985556398666, 0.4579869055772398, 0.21524769125781867, 0.5602431894190718, -0.3350104778911001, 0.33257435673941366, 0.6570793474217494, 0.13738377515138814, 0.1756519906209854, 0.24654934148805469, -0.021709450885192248, 0.40582506719326256},
    {-0.07402358531454784, -0.23655089716160518, -0.10645133372139211, -0.32033760715256465, -0.3348642482946939, 0.16976407429432935, -0.3687402692906249, -0.23575105189433823, -0.20194293897525226, -0.3876143931571248, -0.3143887428719953, 0.1794091377333357, 0.15947582307380725, -0.3795556525814038, -0.18391004020743387, -0.30022093046544096, 0.272474126502344, 0.23320753532944938, 0.2370721682744519, -0.37227721446104356, -0.42487948677063686, 0.07725297060257179, 0.7601768259755394, -0.5076711376735926, 0.0975737783135379, 0.07829801322028368, -0.17005948538168267, 0.24995938347768065, 0.005158967807180661, -0.224307952136911, -0.11025839981590001, 0.02093695716174051, 0.1472235098714148, 0.5629841173534351, -0.11431206400502669, -0.40793587888536303, 0.28744799999546755, -0.16586896597745857, -0.21385037144784633, 0.27655587366224355, -0.15450833611511441, 0.5484694969455286, 0.2946533860954478, 0.13931128551574282, 0.006336925906299904, 0.39308551620459553, -0.10793352225503422, 0.5773379896097565, 0.06165887287744051, -0.1328946443366542, 0.6214258043415414, 0.2639786804290857, 0.5874030378444419, 0.5041336986599502, -0.21834729525742044, -0.1406241955181415, 0.3452967863201141, 0.11342591845346649, 0.537036965551172, 0.12426587984448115, 0.37457184683958467, -0.06300261914151022, -0.08566045939025933, 0.26913968958550344},
    {-0.09418763109252257, 0.3381171861852655, 0.25417617066215, 0.002666842900361459, -0.0853746434282539, 0.25785104884380977, -0.4547140358814486, -0.43720352672403984, 0.29182949417776366, 0.10448001623920145, 0.06619146828107429, -0.4286915515127156, -0.21469092607819046, 0.1266221781754993, 0.22350859170027795, -0.08942126377986612, 0.2336984766032257, -0.4443199248686041, -0.244422388641925, 0.08613401306250658, -0.6526584346351101, 0.11120636879577597, 0.27899132425372325, -0.6989693158839849, 0.03595212543994194, 0.21524834182886862, 0.08093918594786118, 0.09737846264653864, -0.4196642631945411, 0.12629840725449715, -0.40077955952738265, -0.07009614285858908, 0.08467323503637902, -0.026968659949491883, -0.06005932311484266, -0.040321277885390146, 0.2730630524955729, -0.12279184352679678, 0.2994776135918599, -0.5217048477962556, -0.09715505297063035, 0.13038715311037985, 0.21536784825053923, 0.0464273968587506, -0.4372260920569612, 0.2382152287332937, -0.6231627229436075, 0.16697421125415238, 0.3064586674990877, -0.19483471745595857, 0.07375920183541815, 0.3026154571443847, 0.1299150674117876, 0.17397393513696513, 0.04209181841930261, -0.0783680937075969, -0.5249788678419304, 0.15801749593799305, -0.2077274901975873, -0.45895315320226043, -0.41810233714190553, 0.11556131775165256, 0.09780119505607808, -0.5894459567935344},
    {-0.3770377655309065, -0.5020143575851614, 0.09533677329207046, -0.21339971936088958, 0.20114503265707925, -0.3603099452648124, -0.039866820807131005, -0.009724811574423897, -0.2256297412112843, 0.1416537239696576, 0.3052966574827365, 0.16004883641045606, -0.20864258235455213, -0.15234163929312405, 0.1257125208298572, 0.2684974235586154, -0.04581821423842435, 0.12609605231825533, -0.036330179901816584, -0.3968897164121425, -0.04741763728632579, 0.49867265579498654, 0.036211683178592524, 0.44523925236317047, -0.23482725154483505, -0.20711539032827483, -0.08919588135906582, 0.08676474140677164, 0.0220049584929825, -0.24835303700162803, -0.027878735631084183, 0.010698793893823918, 0.030039511128082383, 0.009298632958285993, -0.29235031379736115, 0.1657079575146644, 0.4304399872170863, 0.4206967339141842, 0.6085187596593302, 0.3106481974448826, -0.2578892066167798, 0.5479054106869833, -0.18327087364225125, 0.3215589778345806, 0.28816488790757894, 0.4478189125502877, 0.07639634289559377, 0.3467268913452823, 0.04621494482358778, 0.3099809944286261, -0.43871649017115893, 0.33273721752003527, 0.362819445020441, 0.45077445628274876, -0.4316024715444486, -0.07615637664646763, -0.24905283489697216, 0.2913010730059356, -0.06019677734449625, 0.6848176194865037, -0.3487238004163275, -0.12582300163907317, 0.18099288973799288, 0.4684461173610547},
    {-0.27916405138842576, -0.5728727518116601, 0.28926997283336486, -0.3850992885204977, 0.12545255741919897, 0.07484187531845747, 0.7567813963457718, 0.28151608277266954, -0.007697049610793584, -0.036050726185720625, 0.2568916608204767, 0.04786047989890182, -0.49814865460704555, 0.3362605397933525, -0.4909747470762381, 0.0724585356649091, -0.20306610214309084, -0.09707296757267371, -0.03644438908972504, -0.0939930499652074, -0.5148569948026839, -0.3941517025719871, 0.15377407301557547, -0.3507668662789536, 0.039313873695488784, -0.034187645362233635, 0.3462529238254593, -0.32334268686663803, -0.37860808224715803, -0.07375312476385683, 0.02198709561574655, -0.47230890641924417, -0.06344748602215222, 0.566279691461082, 0.2526910371613174, -0.13920762447548135, 0.2637416488274856, -0.2175944848403196, 0.12125027789623344, 0.10002609506040983, -0.035833391893971715, 0.024085227677062893, -0.23966384153122142, 0.23728745212421562, 0.07816432517472817, -0.13064039977720907, -0.18456402812062597, -0.24241719718648888, -0.13856726973448302, 0.23935991479105215, -0.22720698703493905, -0.0753500988306407, 0.1421939775865645, 0.1558255295256765, -0.05338270233229205, 0.09928785309596579, 0.10069066157031449, -0.02381610042216774, 0.6497904797466179, -0.09906228907737398, 0.5979480274355061, -0.4509591304116892, -0.23641851590142274, 0.3489219080479463},
    {-0.20032061055051778, -0.00891792922825514, -0.29011732230980386, -0.18048536315388924, -0.12037750480284608, 0.5384875847358717, 0.23385837083008937, -0.3782680943233639, -0.020753182110435645, -0.1498231627759688, -0.8898424493794417, -0.431591696137502, 0.0476989517570851, 0.4319782005872234, 0.18559005174512663, -0.16904709999325976, 0.12751357786434392, -0.47054400433363347, -0.04638312157394388, -0.1487967650773171, -0.1430743472502608, -0.06745760816104666, 0.28747237163089606, -0.20020624330411144, -0.5805263826577114, 0.045088848124845544, -0.07342566320473684, 0.1693828853062288, -0.11581122961648416, -0.15345814957936244, -0.1775519358504504, -0.3979569927694823, -0.19043178088976342, 0.4212692895525987, 0.10370590856492669, -0.2075065553511683, -0.2762609962273922, 0.2655748949851604, -0.5834984209563823, 0.23558358330549584, -0.3103928121942625, 0.023273260805793658, 0.10388500643729869, -0.16310663389839747, 0.6775586476387608, 0.3938227005631135, -0.09114202983306675, -0.030488122258108215, -0.44373804967860064, -0.25662464649413524, 0.36772953810687975, 0.5028348260836174, 0.2945933106884031, -0.25454854193140886, 0.13767942381061077, 0.07497922800323249, -0.2521982225756797, -0.25703738118052966, 0.25840693349958593, 0.6484743408739952, 0.7851970459893715, -0.138473853869653, 0.26887731187685887, -0.2097671435671806},
    {-0.2251539188998518, -0.21238856755064436, 0.7509577025576836, -0.010891889970490683, -0.10888967932368823, 0.19069333436537103, -0.6402877664346729, -0.27661940372233734, -0.39026167961963454, -0.09051746835807667, 0.21969626515820245, -0.521027843957402, -0.32391320240845156, 0.2889312079337517, 0.3854380015916689, 0.27853753054955144, 0.5902473895095935, 0.22959357750794906, 0.14232515168379797, -0.8244696235425263, -0.20404893221069198, -0.158550731008538, -0.37249115623072165, -0.48260911578259197, -0.31216925901744763, 0.19821685398058353, -0.7624931564068934, 0.08678563633132655, -0.3380094316599282, -0.20536257914897102, -0.0665693407701566, 0.05305744735779415, 0.1751331282041982, 0.21882391365944898, -0.16636528225127395, 0.0975725725135687, 0.08384897635131944, 0.28147106620880985, 0.38658962730030605, 0.34459164334550874, 0.12116949765367042, 0.3912657198289397, 0.22237114842510972, 0.9575972816817433, 0.021949286682271668, 0.01522557362762034, -0.28398200940263474, -0.3823705220928172, -0.026487242533146316, -0.6012594582807466, -0.10592976632647208, -0.08423118479299203, 0.18803151930927758, 0.23866878891978327, 0.842649964416708, -0.11040465336492436, 0.1523692357053631, 0.09597370424847884, -0.13144561500392016, -0.44537393363617245, 0.6283015920372964, 0.12844767095224385, 0.009247488201435504, -0.08203274352594435},
    {-0.4325853492504578, 0.10850081004834271, 0.4300988613597865, 0.014883294285648269, -0.01516614118608717, 0.55046510946331, -0.29584284683220763, -0.09553759557734515, -0.2059643528991887, 0.5633305058166476, 0.005007901306469902, -0.3345439730774494, -0.23025362231570087, 0.2533737562595102, -0.21273884533601053, 0.1690875372321228, -0.057122902421111704, -0.10418410202361177, -0.032721015947202746, -0.2953771569371917, -0.22338889090819694, 0.10299076827745539, 0.09012293440966809, -0.07332352845830396, -0.058819259045307194, -0.16342364266884407, 0.19668192398171438, 0.20859725540733598, -0.12589606879594342, -0.6362861284109685, 0.5184845183115472, -0.35268733812869096, 0.33248077526979924, 0.5189033252607477, -0.1141417100148382, 0.35842843402094576, -0.6935016544351033, 0.05268671116167884, -0.06121983864769734, 0.16822785834203768, -0.005677881853591245, 0.6407392332821451, -0.027589723392366355, 0.142776325597477, 0.11147580695482756, 0.2550751257205342, 0.22920629783423047, -0.029211499843010084, 0.15750784255624953, -0.4534540489177601, -0.3512052200660983, -0.28500024179150923, 0.30609664188423197, 0.2584503822433787, 0.6621746569711275, -0.1407059275489194, 0.2764355661351412, -0.2804130812248856, 0.39479431302711665, -0.04675690343188229, -0.12023197506375449, 0.3220785252166739, 0.13666990974750115, -0.22083155530576878},
    {0.5166810784709315, 0.1761004436743695, 0.20562790607202008, 0.0596394627715935, -0.34421117763332865, 0.10248709367213196, 0.23620594419182167, 0.3012490027583342, 0.09646183591955923, 0.12407354461060412, 0.32807907135846415, 0.05467983007672157, -0.12297132043512542, -0.19851130371001868, 0.17970802247729434, -0.06300702659501707, -0.26934775972293745, 0.6142890563937057, 0.047136567758606085, 0.5500035142880636, 0.12299156888440571, 0.06624669297098669, 0.35865729078524267, -0.22817502311178267, 0.38101206855369746, -0.10977373295123392, 0.35639410971991486, 0.1687357243300992, 0.3360777018930918, -0.2570515382036273, 0.4113692698008542, 0.006749601899828798, 0.5135471232205, 0.2618729936118989, 0.13839251735951535, -0.19638582450563302, 0.2731579652242581, -0.1797188365430401, 0.16596433822725695, -0.06353399767178727, 0.21858007433600898, 0.2078833064085626, 0.05253083083473506, 0.05111560811562451, -0.05076109881859881, 0.2967065970037813, -0.09728827173965689, 0.129962158471171, 0.3535159783330507, 0.4342839399926254, 0.17522688719229498, 0.0006450576139175249, -0.017967769665507987, -0.37541273186851903, 0.11028705672847436, 0.284357271757411, -0.12876213440893672, -0.04163366272851221, -0.13068924494760417, -0.3337400932975274, -0.08626087866390734, 0.1274428287614902, 0.004618998358454884, 0.5879795780592001},
    {0.33167947138068954, -0.2992223511582233, -0.27605549848238287, -0.07901197416221385, 0.4582663180142117, -0.14740114651760342, -0.5245001760766227, 0.07668351093523684, 0.16607707602397587, -0.3474778434398939, -0.38898504480396495, 0.17037091331111348, -0.03678049071364315, -0.3528347017107424, 0.024863740998923686, -0.2111200151046878, 0.35730802626828145, -0.14242604120696734, -0.023474786007981682, 0.03207277177691699, -0.19595224079831614, 0.02266683916148128, 0.44373004234148505, -0.06064016405314243, -0.32717585150929357, 0.29806850649027516, -0.21521586201817072, 0.16997052264137774, -0.07073078413102538, -0.005456192543483454, -0.33172769835040034, 0.1432991967842665, -0.09103019119950276, 0.0007364859375565482, -0.045517141641661034, -0.045960385852395355, -0.0826170623649166, 0.35225699779108305, -0.03680886190284196, 0.0976741567893137, 0.2605459882995771, -0.11999650156409586, -0.12573521682002578, 0.24646687076412105, 0.027131474996755896, -0.36660435665747526, 0.578696337421149, 0.16096685950281833, -0.20696658786875086, -0.1648219877814108, -0.054940962932847504, 0.2868771490047611, 0.08096653573469152, -0.06589660258026755, 0.15976684167008742, -0.19224437821851828, 0.1393490335514532, 0.05520932892237374, -0.38239738500677006, 0.04875826734189554, 0.022798134651362517, 0.01961515348070958, -0.14103202006341606, 0.31588373691309213},
    {-0.35767001674647025, -0.6479057662243337, -0.20252871497588787, -0.17246343253397767, 0.2951140073896363, -0.06542226685609337, -0.48242513198393805, -0.015921804753243923, 0.340965831442724, 0.019267917065209524, -0.3174521703597946, -0.3749529443316767, 0.06396061943814627, -0.1539951724353203, 0.25778514448339473, 0.2739411580155369, 0.23547491018051503, -0.1466168112492652, 0.14304980636838044, 0.18930375265282012, 0.19778908136439555, 0.41882143138733685, -0.20809431695584316, 0.13625660315799326, -0.2387412337883763, 0.18055924960151024, 0.31981580615939686, 0.6166900479944982, 0.1146719982278625, -0.1289514403700001, -0.11589991183765312, -0.22875312708664017, 0.12847750465939856, -0.24059320075147544, 0.22127408315081593, -0.46277482133624537, -0.05162776670722614, 0.5377420189147895, 0.13848849503352997, -0.24009507807711414, 0.580170409416516, -0.12420415083621482, 0.11072576613992394, -0.47642029283988985, 0.04284747120593931, 0.16061650172532024, -0.4117727107999526, -0.365629582401695, 0.09371081861855837, -0.4526125716832234, -0.03719303222464176, 0.28456663106082386, -0.18971173764052193, -0.0891915416086828, -0.20114392209581966, -0.051638027147416256, -0.10736793844406665, 0.11787805856517423, 0.05388740585408116, -0.0807818655576559, -0.09683974351686532, 0.34071718840749476, -0.07149104812281457, -0.7153573051150677},
    {-0.17422985312319905, -0.07183286846865829, -0.15933977972612, -0.15006837527693365, 0.11277084602449595, 0.10673464711277401, -0.4450526024621817, -0.029848558239807726, -0.06522968402672569, -0.16843601907171135, -0.4037914275220403, -0.11813877709181918, -0.05243859165182054, 0.007407764064302975, -0.12508199018921992, 0.3839775076730781, 0.2474167941553641, -0.03961217494620196, -0.28304454670960055, -0.37221510357143023, 0.12593554656349729, -0.18419380194117868, -0.27416104473566477, 0.16439947995588525, 0.024385268138520128, -0.46540102443673226, -0.199806234984056, -0.10466892063138876, 0.02668189549801748, 0.07848541195900181, 0.036116457082183855, 0.12579581441587706, -0.16643474154771495, -0.33768053388689107, -0.0729554383430124, -0.6192956647677148, 0.04768032785337219, 0.1762059686767895, 0.3450923582179207, -0.11357458597696043, -0.1592569268909117, -0.3341762375900629, -0.1269228747416316, -0.3774635544040121, -0.019640480360210925, 0.34173865779606166, -0.28433055580073113, -0.4885963385794221, -0.08572056415516634, -0.11318206536201719, -0.12469337915048852, 0.00388559903813298, 0.5266069940069393, 0.2564058129893878, 0.026981556482954312, -0.021732578015984553, -0.6496470698831808, -0.36733916155127294, 0.601209111658104, -0.6025021576941583, 0.05911516047635798, -0.07785810249202285, -0.1927620040678964, -0.500328949250666},
    {-0.007368596003859867, 0.23986087157155164, 0.2439713453478754, -0.2290010172020807, -0.21850096704236732, -0.021587381054243095, -0.31351806520926845, 0.388126606679672, 0.03883171440908733, 0.0256737391550466, -0.307774932434825, 0.009061535159642836, -0.10967143787365902, 0.24127096458708455, 0.009245860454047041, 0.15722915167745985, -0.4037960604866049, 0.3231960177680564, 0.23377121028533832, -0.3399970317696256, 0.27671972794539823, -0.10190998522323129, -0.16962411646880263, -0.16312779727422994, -0.22066847180678764, -0.25405873505037196, 0.07459326114360018, -0.412731050373919, -0.35618898823947986, 0.07362029176216603, -0.25690854303898164, -0.11606693780755004, -0.47518688346701793, -0.24612490373485363, -0.21626347703952328, -0.3062611779082775, -0.09883902613917135, -0.4264773299211065, -0.22975241835378415, 0.31662387878397863, -0.16929714677643423, -0.36160297675262787, -0.33681880990877866, -0.14973864812483606, -0.21372263162738292, -0.03693433190556056, -0.1804092652178142, -0.02992694067072516, -0.274988982160335, 0.21971261199199957, -0.28062221834922185, -0.12295125104933509, 0.48538923328669276, 0.17182594135943147, -0.12817563274068672, 0.21666644543998778, -0.5711456686155189, -0.2982348552636309, 0.13974755717053, -0.4950446043531356, -0.015544614692782763, -0.2966731784794643, -0.11583140308966348, -0.25901143932036425},
    {0.2919172156243886, 0.09594540522399418, 9.845105698019104e-05, 0.18715357697253887, -0.01632767044167587, -0.18597381339688246, -0.18005598342014115, -0.24494821915275386, 0.4997336641379895, -0.13679231019034216, 0.02917824453767599, -0.10572852451292494, -0.020306404300797037, 0.2500844979450311, -0.09424306869023108, 0.005444084222156425, -0.24772538504644337, -0.17852114796068352, 0.2013502450492428, 0.05341544325068541, 0.14225979257071747, -0.013124351141332145, -0.589706253883638, -0.004129168802331965, -0.22848885727153667, 0.18432520463531815, 0.04191889527170527, -0.18882621976491457, -0.070856149584946, -0.01426350046988277, -0.23348762290975109, 0.22266789919226654, 0.015360732209397729, -0.1067895265016514, 0.23777310755277137, 0.3304029492765128, -0.017166988125810217, -0.16643026592121105, -0.0007720606289373005, 0.16383929697074878, -0.24887220167720234, 0.1443636948634879, -0.40275199877649687, 0.020876159655371186, -0.3552859505629172, -0.04391906650464347, -0.07731075862322948, 0.11383819927458527, 0.2839811591339978, 0.23930985594807294, -0.19033510529736541, 0.24473071702013574, -0.12365948949727128, 0.0792655607615031, -0.4995773570987014, -0.264694930423088, -0.33652475616425825, 0.43315898642296174, -0.12624402585812264, -0.008524339766611934, 0.26925721551986037, -0.41024418663923634, 0.21315273768490037, -0.306304664218411},
    {0.03375156008059497, 0.1720966766665162, -0.009618132472569745, 0.2571817829018252, -0.08325590604083859, -0.10533490803978444, 0.5414023294907454, 0.2542191490468429, 0.0617842594794258, -0.19909043872263416, 0.02262358234887891, -0.08426798035445283, -0.13665072919049914, 0.19208641890427886, 0.01290664916529015, 0.0578508235971472, 0.5819614749738472, 0.12626556999837277, -0.5307540367888955, 0.21659789300899218, 0.3356546746083273, 0.2700330660490666, -0.4738703875205092, 0.42881780705678413, 0.03750569832237877, -0.012028812025114946, 0.22738624215600584, 0.032282132162203644, 0.40107557452465614, -0.1126538657112122, 0.17775211034147775, 0.5352639096939952, -0.10478253329545073, 0.20971926887019662, 0.4478409782047132, 0.08498675588206125, -0.24449061624880297, -0.023085537226086066, -0.06254842019819473, -0.1348181683380237, 0.00666505036718342, 0.08314888880026533, -0.28317156518679454, 0.639323678697073, -0.23764519733464715, -0.4219903606965467, -0.46140049048356624, -0.0793757542823384, -0.009808706861462749, -0.19956773268163103, -0.3675927647781039, -0.0882870321624225, -0.4041512378074088, 0.5592292399626538, -0.1852971037639964, -0.1320202908359723, 0.23018409778824628, 0.0980875911305708, -0.6102160612702645, 0.3688446645884229, 0.06902338600120075, -0.04348408472061934, 0.38867908806238144, -0.4963188424947988},
    {-0.08063360974345343, -0.07054753301216472, 0.0029686026099802424, -0.08882936550969597, -0.3568268019870704, 0.024191435608757243, -0.05460820700140935, -0.42433822355786277, -0.27811850879284133, -0.2497258017886745, 0.28346685667542126, 0.08132747539641887, -0.35134393117693946, -0.21738449097697116, -0.5952174393012212, -0.28969530449046516, 0.3763497233888406, 0.07479027942280869, -0.366900725196992, 0.0072377009212042116, -0.11118681334802524, 0.03655120525581119, -0.08350469040894673, -0.1913549398011451, 0.0371942245697351, -0.09066111252039234, -0.3747596235389117, -0.34331160236203356, -0.04001502564621317, 0.008913557873904703, 0.33028645245583943, 0.28859183645054315, 0.06815673016812118, 0.1148565469752474, 0.2832595894588618, -0.23296818088172966, -0.13194953440126966, -0.0015790420129948044, 0.09087612106992386, -0.12435465951947322, -0.2724187190348949, -0.3269859267663987, 0.06539170262253509, 0.3596484271811056, -0.40515372030473135, -0.039261588910023446, -0.11858985735100931, -0.6289513968616736, 0.12609325924352738, -0.13852725479610226, -0.022552074636757097, -0.7075023873854444, 0.036709085648158085, 0.26115318465555476, -0.021122775893821777, -0.29677929949010545, -0.0601782638194514, -0.3478551033131263, 0.02471392960104053, 0.31428729022599133, -0.3704508501046846, -0.1087253314917411, 0.18161041460861566, 0.473632179088571},
    {0.14004359232833047, 0.0554283208150788, 0.3379343939532259, -0.5727700144171304, -0.013018123028667916, 0.3400431896939004, -0.08353555599211832, -0.14090539085549497, 0.26944326164104715, -0.048339036473507783, 0.24985222924568637, -0.17283189224101253, 0.22165303642077533, 0.3399844233173753, -0.26005157495542597, -0.053328662152566694, 0.4126230311585811, -0.2921424876197115, 0.06271629247057041, -0.04659323283084946, -0.20538535275738565, -0.012611086540784036, -0.2584419080239607, -0.04367195131910443, 0.10399430236117767, 0.19467809030037758, 0.07238223121461362, -0.3009291507986368, -0.17106083516126547, -0.10324151463450124, 0.3648800366898545, -0.29805833078260296, -0.15347080296450147, 0.3194052349866025, 0.02172089374246279, 0.21626550600169764, 0.17908515648032783, -0.2504501009207619, 0.017737108154832194, 0.13637549255264206, 0.012915760932540944, -0.048194089928016305, -0.11046432109350773, -0.023616487924322496, 0.06727257727727237, -0.0356824532893332, -0.0994808782643119, -0.35110523497210916, -0.2984376102130753, 0.10197811926278122, 0.1619092929380684, -0.1219823707387029, 0.2765892552765626, 0.1822195706552016, -0.25071231552895407, -0.043272346530506496, -0.09880593185151793, -0.008529825076365566, -0.17750352406168218, 0.029866367753526985, -0.22552889051729405, -0.0981210970140545, -0.10978966168250638, -0.25392300457138034},
    {-0.0545846680635816, -0.7042319364308183, -0.2504855955779871, -0.8079963140059647, 0.32424489702258696, -0.2987306233905019, -0.32312228509788976, -0.11948656901845628, -0.05208502223527296, 0.0016654364098585826, -0.41368889938761005, -0.4173048453473603, 0.5745419023491171, -0.12369894445522654, 0.2689468784143526, 0.3099167645245149, 0.289912127830225, -0.11256609546135751, 0.13999282043450803, -0.2734225428265914, 0.2949339644793018, 0.22041211617051945, -0.40680004141549886, -0.31867533469535575, 0.12450981725034561, 0.38665499389557495, 0.03656396727547064, -0.053418776852840036, -0.02763729379274779, 0.14410442626911985, 0.10959765690448976, -0.20105342905348067, 0.21877750068966395, -0.4590320667757566, -0.050724431451709594, 0.6039066099818384, 0.20130244204657524, -0.2456791866077984, -0.46244694170095024, -0.09524504089420133, 0.35806606530305335, -0.07932193663279732, 0.024558461557844805, -0.5344756676190909, 0.11591956315178308, -0.256615565879716, -0.4872715387687248, -0.08358076899314908, 0.13310160053186654, 0.04208675197938165, -0.09029333521508029, 0.122820799187789, 0.28547802390065075, -0.40631787334719377, -0.6742825961592592, -0.031784012822727685, -0.3230545504111883, -0.24089202399860776, -0.19721484309686652, -0.07571849732182523, 0.01979979949420215, 0.006653130408836873, -0.2800764097265805, 0.11970750857740543},
    {0.03436464253569547, -0.6645536156184563, -0.17356261917172416, -0.0015897450421568798, 0.20737688922597633, -0.025621342555886977, 0.17229754794939636, 0.08809479368219161, -0.021900247556732786, -0.1850897706131013, -0.3827495499864385, 0.0823267240990963, 0.1436907794475661, -0.4615613005582889, 0.170446904304924, 0.29563671633827376, -0.34491254524002296, -0.032469962914929845, 0.24013850120055422, -0.23500958627609395, 0.05302253580264116, 0.12926471779513315, 0.41761274767730605, -0.22048592739018644, -0.6504978071634986, 0.3002517571971757, 0.14863896593259962, -0.15225685912200584, -0.5221101581373794, 0.2427681651581044, -0.05640678344498711, 0.06630208182081722, 0.1730463212044496, -0.17793493178397563, 0.06696085544252174, -0.22232423111503669, 0.09451044915288254, -0.32739714637769, -0.5727105325002755, 0.38358333509780645, -0.26414414111471857, 0.08453496573910735, 0.1466826370413625, -0.012421033706811033, -0.10894511852735511, -0.10289016211771698, -0.3435424578982983, 0.31978193652099984, 0.212121434371434, -0.16786285716279462, -0.03451001995007451, 0.2892989484878247, 0.2570381149584032, -0.21202006725970032, -0.5620621027576277, 0.041223317113006204, 0.07894539164105877, -0.11059171191533156, -0.5056965844949092, 0.04720678804357475, 0.17066655280642617, 0.07184634586228458, 0.03231434615075363, 0.7224190989026598},
    {-0.18110477593907393, -0.11719912321588223, -0.24700389677455084, 0.6558082496257671, 0.05539127571430406, 0.2001599541539536, 0.22477285832141242, 0.14559728653165807, -0.045225604147203925, -0.14554377146452868, 0.525699975768089, 0.38092355703253555, -0.025709054582578297, -0.04934788315933166, 0.15927275021387702, 0.08711034962005432, -0.29591478789321135, -0.4050438094154372, 0.29169870127971104, 0.4374137596541793, -0.09408862182215891, 0.07925382137542081, 0.4407503335413086, 0.024931116266150254, -0.31968305453274853, 0.03160713565788199, 0.10016402384131588, -0.15865035936347022, -0.20439463985907458, 0.03481562301947202, -0.5092737305676812, 0.515186920059711, -0.13712769831478602, 0.34155484095452965, -0.10620935866670107, -0.09086104395730088, -0.28094202187113115, -0.2147958118645621, 0.3225695344508083, 0.34010495156942555, -0.05156563833613737, 0.4333592812566584, 0.4347092254810112, 0.13093387827187447, -0.13293304700511394, -0.18351528803133488, 0.24057617005730728, 0.44398496953453503, -0.16990493412786883, 0.07610645315619369, 0.04940553902380606, 0.15134297345274725, -0.41496471220641196, 0.30468343060814845, -0.03959042127399266, 0.1408045596145892, 0.24915889329160584, 0.3067682413165981, 0.1411117470807571, -0.09065638331528689, 0.1373268953299262, -0.20375544017949024, 0.14012189254045937, 0.20623572456831013},
    {0.29908908675378726, 0.1598181589052667, 0.3143166724434843, 0.17872817435599775, 0.20674242192497225, 0.013031472599771539, -0.0510572918654809, 0.1461994857490721, 0.14893644823222493, -0.1680716319821715, 0.3554127562099476, -0.44092051139894445, -0.03295430272762363, -0.1147546025701575, -0.19553135426607368, -0.021067608047389434, -0.05681243330371245, -0.09995330666692742, -0.322086676119265, -0.04871847612826936, -0.24181037786455678, -0.2613975395752361, 0.468569267138814, 0.09536142225481173, 0.027974412804423355, -0.11392507881870055, -0.08583078668889207, -0.13187030581064188, -0.06007070669654979, 0.08322562722875389, -0.008140398639229392, 0.30268786794348246, 0.26250303405126063, -0.03587573955104617, -0.13367082635197142, -0.6424009053831002, -0.16804330354566976, 0.20144549376762558, 0.14378476473293303, -0.07216258557037142, -0.24796270841946622, 0.27964204169891654, 0.05773533451357684, 0.03587255091469306, -0.2750258755664556, 0.3110437656553238, -0.02899653711182183, 0.28049643538459723, -0.162886728583187, -0.3908972030180706, 0.1362737433783897, -0.17581159477355857, 0.04317853933099499, -0.18908726978228058, 0.46884468897764936, 0.2768115457930886, 0.22874827696734745, 0.6830122984635426, 0.11729116644385816, -0.010832481220941338, 0.29377145055560555, -0.2844830344747805, -0.010635062559865488, -0.28461215387202343},
    {0.004998570134672029, 0.2055260636936459, -0.13033282866384033, -0.17338301790923555, -0.15441150400402412, 0.4489022112285374, -0.27745719182252326, 0.2043410961191388, -0.048473551475191376, 0.19329813120051248, 0.15461883972576343, -0.3075651676397805, 0.07627471398919239, 0.5094802247265975, 0.02492629099002865, -0.14320117793563555, 0.09948013476456981, 0.2914355861850605, 0.10152839704741085, -0.011131784578287346, -0.5205481101467534, 0.10661759606020155, 0.1335430848103016, -0.25416023034135016, 0.16931810935848238, 0.36687232537735, -0.32683091676214826, -0.1383123477440299, 0.4914846644510853, 0.29777266261273405, 0.5927786999041932, 0.27800073925723623, 0.256346314071896, 0.32836465752149574, 0.18519235019196523, -0.023053265843358768, 0.0009793826030996531, 0.25861916352535796, 0.4632413640981015, 0.014250158782750488, 0.17655758917522318, 0.2143498342885608, 0.32342788702053404, -0.13181541726161752, 0.20739001285980352, 0.03170858293179887, -0.13616654622583105, -0.49030980438567945, -0.19616047513038412, -0.05556010570106616, 0.21198695546309024, 0.08544920216084026, 0.6767652935791847, 0.3961998985295921, 0.06592533174834374, 0.23572807230641327, 0.4245345557570958, 0.21252001986479865, 0.08833941895714185, 0.08479241233499438, 0.06728427724226851, 0.14422188934082342, -0.24254072998890383, 0.08271281037874582},
    {0.04269688346987685, 0.37624880993421594, -0.3600789743833189, 0.3115096160939431, -0.3501967430395356, -0.39864426133332403, 0.2581031251011899, 0.254522922704755, -0.45608290799613654, 0.42215377086569267, -0.06677771576663365, -0.016304484747299404, 0.058476115717923764, -0.14263826441037877, 0.3946417853821353, -0.14775772614766416, -0.03257542169865082, 0.48842616950565987, 0.029367523508219886, 0.034865963322186104, -0.3643613735102092, 0.22646337980020456, -0.28772985398510903, -0.03276513129683719, -0.07408491232014194, 0.10391273198861509, 0.07128494640220326, 0.4915788684283999, -0.07605890551779285, -0.047002162690494925, 0.6999327411505243, 0.19391515527026937, 0.6330770648835288, -0.350291870275378, -0.04624685934390389, -0.2750400841422472, 0.2831747862372593, 0.1400305883587814, 0.09250532389476425, 0.1371511438137577, 0.5860527629165274, -0.20769080396734615, 0.15161417194640936, 0.010969452476422715, 0.011847971108075186, -0.1892062604791046, -0.1789731634304726, -0.12295340281758402, -0.20028717579356595, 0.30349140742469255, -0.09105385884842514, 0.06900786829586172, -0.11536821168262676, 0.5672897549334444, 0.20317324557777997, 0.2259039634831284, -0.1279073835527603, -0.15516769426412555, 0.3433795610384206, -0.011111106758375558, -0.3878423049544677, 0.29639064479279364, -0.24435129109952558, -0.13498736009372495},
    {-0.23287741440871637, -0.5866683435079127, -0.037950164412126314, 0.5691155147125907, -0.49233689462472724, -0.4147176228957321, 0.23410560669681238, 0.3262370307703868, 0.2106918282139075, 0.13761015005100746, -0.344210115112672, -0.15530905967477743, 0.11752531191135335, 0.16212660198055504, 0.10633790114453444, -0.026967592808696875, -0.3433653213234335, 0.014546184504730528, 0.009146417392942169, 0.28615100395000875, -0.021070037299989453, 0.08436407429134725, -0.17716176306686646, 0.6310694787859054, 0.27402090527088313, -0.12328983805916169, 0.07547281754656406, 0.14239816340316144, 0.07674158827699737, 0.10188279877879923, 0.49643831588231235, -0.16667046028585142, 0.157225753278319, -0.1554065627482405, 0.010742452413292128, 0.2270079898290499, 0.19295107515201618, -0.03662290143523637, -0.0312375480274606, 0.23730525956954265, 0.388005284661019, -0.03300927726456637, -0.037618188668247926, 0.15584494975013732, -0.04786008154292458, -0.20965226001068432, 0.43012457841919977, 0.1371540226082723, 0.257955988385845, -0.5178732450615336, 0.10077654233494662, 0.24761535229215428, -0.16121155751332708, 0.06340038275967322, 0.018109313588349087, -0.18253567660367787, -0.13757612218630508, 0.06616769602365535, -0.013502033743516136, -0.3444402184741936, -0.2545163042539461, -0.06453936145467752, -0.10870474477533394, -0.13605289781277466},
    {-0.5030198662907224, 0.14409730891547692, 0.2623214004551034, 0.2290396969922927, -0.18020940505147284, -0.048269255713325916, 0.3634745881296916, 0.04800921946572831, 0.18292611778885945, -0.008407378573791814, -0.3557957670227466, -0.11432910030662055, -0.09246894170585283, 0.29124486806050953, -0.17836501211994343, 0.019737581982158196, 0.14911152372807823, -0.37864349414858195, 0.32101116076540365, 0.4980133915554278, 0.3321711673932644, 0.26460318616598577, -0.30806662800959933, 0.3536710065883228, 0.2917053496423315, -0.3559343507590523, 0.048967309034368876, 0.0970514324583799, 0.3168568201661099, -0.25805536082795755, 0.14637825920656, -0.27112707375601336, -0.04024291809535693, 0.37392695514649876, 0.23784204008790233, -0.1971844218077018, 0.016766846713775773, -0.35715956428044043, 0.45881688883013744, 0.46679916231439195, -0.09279340704095837, 0.13556884728734278, 0.07087885141348357, -0.2654663339510094, 0.4791976357475573, 0.3767469305787121, -0.007333051654093622, -0.29917812374344244, -0.15532650529259856, -0.2593159996013646, -0.140745265141565, 0.06246030863513902, -0.563232282571086, -0.27036617684768266, 0.05085883350767115, 0.2848283410384377, -0.36455578258950333, -0.5539948496581205, 0.1046624178951348, -0.0338771342495869, -0.025165201533585032, -0.28416582630499, 0.13749737832453923, -0.1975518401703703},
    {0.050228041900665744, -0.04043938637825101, -0.01821953503716206, -0.7128052447509303, 0.014315638752182504, 0.07211510941441635, -0.19734195835928933, -0.10303101152159104, -0.16268218972362564, -0.045978090358562505, -0.46242529158189943, -0.11653768427835783, -0.04757594428730006, -0.2687578965469491, -0.12960369827096488, 0.05592549398879736, -0.11407319535106968, -0.2724941607422834, -0.033166083560522475, -0.07936252520695021, -0.4061899870418279, 0.03960636242112993, -0.6355915914280724, -0.0345732860815592, -0.002651581392850057, 0.27177244712520576, -0.4506581249783949, -0.37787403072639647, 0.4387327500185571, 0.2907474681253675, 0.220629049123095, -0.09622065364025217, -0.26159232409241023, -0.3606404716932404, 0.6337731098887214, 0.2279933299329238, -0.31344690522568885, 0.1822949031340328, 0.09946743770350881, 0.00829008292835414, -0.3728960143807611, 0.464215563330043, -0.07842475518364676, -0.1554611362036322, 0.5539551563739848, 0.10639192867607851, 0.16782018087490314, -0.3713443394936068, -0.14260444727725216, -0.09962847826716083, -0.08565711511966599, -0.6081102411110664, -0.375157994780017, 0.009060194490391218, -0.05346313873457108, -0.03949911126428493, 0.11664524627857784, -0.08353293718359346, -0.4117734259904696, 0.09190508362847921, -0.1444860168705235, 0.08096084644796642, 0.08511672079467213, -0.24094828727673753},
    {-0.525187674759794, -0.19142662284695508, -0.15655389768659006, 0.24164004563023164, 0.17171865829603047, 0.08221173798362481, 0.14879455027972385, 0.15255817812645875, 0.19417363798527065, -0.035821025439134214, -0.13122367698191068, 0.48402647083614136, -0.31966768904361553, -0.11304829554657905, 0.0625562959941888, 0.3521752705204511, -0.14657755392200575, 0.47222136836822987, 0.2542596804930541, 0.005563290655569628, 0.06117007101112833, 0.18718588556268106, 0.12440501134840751, 0.2816443134224764, 0.38812322448661485, 0.3466913063714931, 0.10021224801464634, -0.0946429229940031, 0.4651889194971974, -0.17373851998338025, -0.5270393272612593, -0.28840480190989964, -0.007380232628249785, 0.019313144702558883, 0.40859996529722775, -0.377651022730285, -0.21513766184371944, 0.27824343438214827, 0.5978652705160309, 0.5091344449975558, -0.21766142956426593, 0.3399426593186821, 0.12442872838410461, 0.002833785178231623, 0.2940400561120362, -0.00518228311235531, -0.03210205917034466, -0.02935334128143156, 0.22295692840203166, 0.24230202083786162, 0.06886811105607764, -0.5176237047259511, 0.28663808008805103, -0.5641227163101222, -0.5044182200824366, -0.2605272045799457, 0.19237454773779508, 0.17505362441500208, -0.3512686231030263, 0.06168771175754631, 0.015486667312788917, 0.33669212806359405, -0.10578675745956517, 0.6892088938079318},
    {-0.2476515343565319, 0.2593673708015294, -0.41734785025269655, -0.2495415581046486, 0.09419591874891227, 0.20777813808088566, -0.17277234392940805, -0.07454931322586485, 0.07404679052917683, -0.29447885362443815, -0.2006427057522017, -0.05390341346984261, -0.10435782714995673, 0.39866122762821915, 0.2571329221619685, -0.1716169242846952, 0.3044903214932648, 0.39677164156214967, -0.23477292313430467, 0.245476491002042, -0.18168392881662435, -0.3062430897055534, 0.4529380585178296, 0.046501570374972094, 0.1973371721909939, 0.18819812976443215, -0.09666190297877936, 0.030922607836514116, 0.4721344547164899, -0.20358947697681015, -0.0010938768818329941, -0.001122028905737516, -0.18474443417883227, 0.14295369936554952, -0.022107339056432036, -0.171655010714333, -0.1276761965781558, 0.35808409814152997, 0.07313711434854535, -0.053758930800607035, -0.4621936055207997, -0.05322956431883594, -0.2599019982767146, -0.425666224082246, 0.1268661473553173, 0.08978066465816317, -0.17226293213922195, -0.3326521603384862, 0.3501835696406623, 0.11885364657727547, -0.32306988517031204, 0.2956532850813725, 0.13136104858339698, -0.5140055938561338, -0.064708568365981, -0.024357714581886174, 0.12033245884816121, -0.3458482568871175, 0.04640406221527404, -0.03922173440431979, -0.06066299243167906, 0.016864945192498322, 0.04424796045505516, 0.10062151698360766},
    {0.2686041972502747, -0.44095190758394476, -0.16616132386237173, 0.20804963413306865, 0.14341169052189318, 0.14734834857633344, -0.09651785352325244, -0.16146374432084368, -0.4235381082921762, 0.2215452795013684, 0.3709043850537398, -0.5804229863293925, -0.17280546572977343, 0.074152529742715, -0.1922353921457901, 0.08592266497981264, -0.18559508392458465, -0.09669290398350484, -0.34572746458793957, -0.23398245119266467, -0.4498738833124004, -0.2665717965139147, 0.03283589339337848, 0.0833584406666938, -0.20403913885247288, -0.04761647448408877, -0.0019518851830472885, 0.18012707456368493, -0.010262623661225316, 0.37692435315377243, 0.2807073345009903, -0.26934113970222806, -0.18522037182621884, -0.0583614679688228, -0.13939463496456775, 0.04603984506316981, 0.4990307934695523, 0.1737037200875109, -0.14606460207677394, -0.04032421952551918, 0.16394816752313854, -0.13697212032259026, 0.16762070333707832, 0.4353924099270369, -0.7528376577431611, -0.02168981926097218, -0.5436490703149788, -0.5505660747636493, 0.2981766713159112, 0.15419259812334682, 0.2709852716358634, 0.4842832266671713, 0.44315550138246546, 0.007124709049471058, 0.22860131165300152, 0.22292974378102023, 0.34757687388706876, -0.09085837746727836, 0.008325324006312392, -0.4662917814034664, -0.09053700573494716, -0.30576916640728835, -0.24290856965909885, -0.03584340133132989},
    {-0.24651332599322445, 0.023368582820757617, -0.13557105032046948, -0.07696842387320287, -0.4471593045107022, -0.1192014196246849, 0.06631573538161506, 0.28805810413099137, -0.3680961229887195, -0.17578039553733837, -0.24820192321482246, 0.01836122039252246, 0.06003900457547884, 0.027945680039791764, -0.19467281968388797, -0.028320446774120156, 0.0206800013895716, -0.11370473364109371, 0.44566654299206293, -0.0610991951353819, -0.0046923311103432555, -0.09683110422967006, -0.14868671417950788, -0.1272192116069803, -0.23829508090958462, 0.30707867263388544, -0.01976599966929924, 0.3867946260864484, -0.13669215186785802, -0.02394696148983492, 0.0004363470667457918, -0.10944673257269288, 0.0355938820813825, -0.22756150583982324, 0.07907364093685498, 0.47305232033564226, 0.3619660047956613, -0.008235688958327894, -0.19409787827168248, 0.1118026910107854, 0.034779137755019604, -0.4639049144342364, -0.6290125828803048, -0.3415090213218712, -0.32680239275744855, 0.27887609937533814, -0.04778690916631148, -0.1440845842683642, 0.1905038800930518, 0.11842074537915573, -0.11549153850649838, 0.16813918346267895, -0.2884661377988096, 0.00846706763613486, 0.08302687461011862, 0.010916324556426426, -0.2796199754153104, -0.0848539960899532, 0.3960342531890823, -0.09794214820502956, 0.14263579234139756, -0.111264445451805, 0.10641716232335217, 0.4098560044459315},
    {0.2093630443898473, -0.006744832344760144, -0.11152957387778277, -0.09802215086507894, 0.0454398090220432, -0.10123669569799448, 0.42453139652194627, -0.04978834583098539, -0.05792683797498611, -0.28443647426078067, 0.16868663627376185, 0.07419912777197667, 0.2229577785199136, -0.305712695345946, -0.42770058385837484, 0.23089500272332716, -0.059423922473624664, -0.04036134062129344, 0.1788398687503107, -0.0987373486915663, -0.2693080890831594, 0.224335226077109, -0.24027720202564953, -0.07878566083156556, -0.027794408819846773, -0.33352236384655, 0.33187894941785984, -0.3479780029638975, 0.40185944202534335, -0.0595592428989013, -0.15970684097019613, -0.3225790067657126, -0.022636091163158376, -0.3238473936495123, -0.1863382275088687, -0.18668478115036427, -0.051075784696565915, -0.17301256085936453, -0.3393904511353573, -0.18871769591870174, -0.14464163164095983, -0.31474716761695337, -0.1529756310218782, -0.09295338419392042, -0.12372577068019044, -0.5848716285615321, 0.1426528937326407, 0.30272278750649567, 0.3038547567823905, 0.18498921461464235, -0.04147390304004895, 0.2682367158398816, -0.03761958363677519, 0.2009558034218296, 0.1780559257397452, 0.5296138612694239, 0.284277804550255, 0.2841897571900302, 0.2097770637043847, 0.07346361229184198, 0.06684867826108565, -0.5462448047509146, -0.3237149961169771, -0.18787432767245063},
    {0.4034187454206799, 0.28113546130642997, 0.47005411651501117, 0.12777275618875017, 0.3352760586990818, 0.13827546053808326, 0.24472522900001908, -0.03414979997945382, 0.1953855071524091, 0.16467643838091542, -0.3600821266581618, 0.13455521444556692, -0.027833011199825456, -0.4759352169573428, -0.10249655446242237, 0.10580760861052133, -0.0525991146218673, -0.17997188139742543, 0.041778308596758955, -0.021832755415601233, -0.2622758677813523, 0.26634805192283145, -0.5903999757449792, -0.3173036551149309, -0.18441159638029228, -0.03019601286928195, -0.12402641985114322, 0.14080980035249385, 0.05854401733474656, -0.19450301900645245, 0.08348466172257976, 0.030906427441760687, 0.29234093604713113, 0.007417055261127176, 0.09092267946776289, -0.7271904758048379, 0.16574564092717764, -0.3350532825719051, -0.3056999350558201, -0.38993537907809056, -0.34493192548994794, -0.08974559980413964, -0.01781639785289293, 0.3925067783197708, 0.37891155839837937, -0.004733858315393673, -0.021280811399649227, 0.22486307903048217, -0.3179619083135841, 0.22588607970698016, 0.30999771879078963, -0.10697145266137156, -0.3633437414596897, 0.3573227357967029, -0.12219960763123147, 0.24484063028471537, -0.2324704791216002, 0.4434590766187737, -0.16091273880520296, -0.041425129236596275, -0.17087371979003477, -0.31561206106910317, 0.5673831094235218, -0.14926099104016483},
    {-0.07097623492906374, 0.07364826033796533, 0.1643389426163225, -0.24778240449299146, -0.16116228215005327, 0.3858677674126492, -0.11066102465769251, -0.04529812020629898, 0.2129816235794141, 0.6803809771142867, -0.2629583330341233, -0.27524221909681146, -0.18037168905103715, 0.3669204216941491, -0.18746547824073925, -0.4507687547414995, -0.025872657279472317, -0.12343817699750727, 0.31972872862820334, -0.010113066936594464, -0.06005070798611895, 0.1271643143585834, -0.3531398746448793, -0.2273035128644922, -0.13572975625817593, 0.050743737422480464, 0.24561561072326812, 0.11016646516336927, 0.4258756496739262, -0.09843228327042036, -0.1695936630654465, 0.20335899806569163, -0.02328789251813702, -0.061233503723911294, 0.27488216376402097, -0.47587637358967344, 0.10167062865693723, 0.29950292662731953, 0.15135072975587288, 0.13375983243995623, 0.14210712668774989, 0.08231838146629152, -0.1575056041424407, -0.011361330889160472, 0.19040920251403304, 0.6799631713146722, 0.460245189063863, 0.2733971620238019, 0.00032471035563871707, -0.1534173491599039, 0.4273575602363346, 0.09276334478914884, 0.038868364295215306, 0.7399594246856099, -0.23633768294057764, -0.19736592312527504, -0.1436973927656788, 0.19642918648334456, -0.3117432427179307, 0.38740788699666595, -0.037742026750852524, -0.12344238817167882, -0.06339847743035602, 0.43949378602645056},
    {0.3707726553448374, -0.10751928187670587, 0.5762126013117367, 0.5088910674804037, 0.24733874751331456, -0.09592437600340434, 0.2643810480623774, -0.1412713718513812, -0.03555350755967973, 0.03847956665806077, -0.4788739777210453, 0.12332204765719307, 0.07830357004918108, -0.06884718458184057, 0.19385185842277627, 0.3338098831774876, -0.22830866099690642, -0.49201321455201696, -0.18189645793467196, -0.0708668445486809, 0.1119820751362455, -0.19722352419767875, -0.2563998685609933, -0.27878245254918976, -0.22266936490006475, 0.3499910052372954, 0.25856857533509753, 0.15160843633902796, -0.40296910637239375, 0.021477625729183436, 0.05674751738547448, 0.2410836437886182, -0.18352710124145655, -0.007560458612317978, -0.11449388215175559, 0.1851851140919004, 0.16220034961333346, -0.03477971471333685, -0.03988978598546901, -0.17626125947083682, -0.18339770009661016, 0.1324530272628552, -0.5564381916041774, 0.33763045279477116, -0.09535838884412932, 0.07893217060089827, 0.5263709188253939, 0.08266473384299483, 0.1305610645182143, -0.23082323083593537, 0.3544388674308589, -0.08177183496122635, 0.07780623756323984, 0.3589145650434229, -0.613918591758484, 0.05623440124688808, -0.5270083094492294, 0.046374536083916514, -0.15126835939452765, 0.48436528494669545, 0.11306450125575133, 0.05336936139345484, -0.0781410221802078, 0.020140660457041357},
    {-0.5640125610265327, -0.5798398218985158, 0.5309937677830816, 0.32297394416529895, -0.2816432524642946, -0.6067592034754818, -0.13149912504044356, -0.4102468576351263, -0.17742399849954033, -0.08292676545756456, -0.011525572878316907, -0.006893402341832912, -0.17277092581991013, -0.5731370416709725, -0.10237328764340384, -0.45190002568785176, 0.322265879786379, -0.19477942093588646, -0.27397330056752994, -0.2782302655822723, 0.24783435193752937, 0.3279120215913825, -0.22971857268283039, -0.2588269425565181, -0.1479355533179124, 0.23039257192119522, -0.44788197745603603, -0.41303067691308853, -0.6616225748943472, -0.15055006337862797, 0.1133342500745556, -0.20591457571865598, -0.2273680312431303, -0.0360592341747724, -0.32433104999216567, -0.036692645923189326, 0.13970302671974236, -0.566177116117488, -0.044419810553936546, 0.05500947631604001, -0.319676835058738, -0.20962545862258197, -0.2894881741399308, -0.11824925924849097, -0.04999889006237309, -0.7107616984959635, -0.39084273760901356, -0.3897027119592475, -0.18949108828702987, -0.07045379975356467, 0.1812285687665966, -0.12289665195058459, 0.1528871537043206, 0.0774072475770306, 0.28424968374080184, 0.5644178836364466, 0.07108393891168324, -0.3417894093326995, -0.11866585130254599, 0.07855697840844397, 0.5136960266832765, 0.13178086004803305, 0.4481156166101983, -0.3922419739695276},
    {-0.6869039093966163, -0.23194471516071805, 0.33688188716623796, -0.23090522109039643, -0.016507358469150895, 0.37153624282313874, 0.42892023715982813, -0.08957676689182602, -0.3596346399904567, 0.25679936730497244, -0.09356127771407048, 0.6846260739298385, 0.2159867062250253, 0.24851798670143094, 0.4924992233946195, 0.09270823343606731, -0.19698034708500226, 0.25692425472271346, 0.0719893067512465, 0.13853006974243884, -0.13451515334427658, -0.020464255567327578, 0.018550566528704383, 0.25941652660515035, 0.5427126070559022, 0.13677271741456448, 0.2519885435667656, 0.3284564440335853, -0.14021710640861787, 0.10947795255641718, 0.1866185810627388, -0.27886704440078786, -0.3162737515805674, 0.4538743599936402, 0.1627232773727299, -0.06015680618524045, 0.1690329712775553, -0.2278791855663857, 0.1190749466657337, 0.08292010563381318, 0.09338518466370259, 0.009889050215247459, 0.2932392860935831, 0.11776915545154286, 0.40697377662328177, 0.21442055220841288, -0.326798235420299, 0.2071689031526839, 0.40092860418011306, 0.1214789593138374, -0.06862021560193107, -0.1355776175682354, 0.31954351769027517, -0.07630160268321444, 0.020047091648646372, 0.2724787642263978, 0.14473259068413288, -0.23842253969436109, -0.05945959507740701, -0.04815749136157359, 0.06389925811137666, 0.04661871340803619, 0.3592818867820123, 0.47014655916661247},
    {-0.03002529760654689, 0.11690941788097348, -0.032712961790902384, -0.1740822048743329, 0.18383974691324684, 0.3349272007222, 0.07639035840140734, 0.02209965882035952, -0.0579275104072649, -0.4272233723240263, 0.3891109896767884, 0.34393898334127626, 0.34018544530011363, 0.05817332590364138, -0.02251515167738745, 0.012600685449722279, 0.05484965597681827, -0.038946127156439594, -0.21602819257383774, -0.30206098670177756, -0.1464693416243379, 0.04958511491922748, 0.27491125750382933, -0.5515889237614451, -0.27949414749643914, 0.21620123069656275, -0.0942258891008959, -0.41159958060849355, -0.3002641250909712, 0.665427752161797, -0.07461292114720407, -0.5481550116675212, 0.07330958249603592, 0.5006722210799613, 0.30698118089750354, -0.016735821286313686, -0.41529851437586646, -0.018702466282547767, 0.31763933256937765, -0.1050695816942159, 0.3069611568606398, 0.354205167309798, 0.2187362390972701, 0.34214899444183766, 0.0991821359618625, 0.09935286542449151, -0.008241658982647615, 0.06735202315357074, 0.0863926408745862, -0.08667441647502103, -0.019122651501962316, 0.030327468712311244, -0.05227093256065274, -0.056431670038798044, 0.26405494787365513, 0.0047234996112024835, 0.3735372271704534, -0.20348829028969637, 0.3938996499210933, 0.19398780438779178, -0.159381158065343, -0.316348254266994, -0.10492819644113015, 0.1349080530338121},
    {-0.5483381391241895, 0.02061143052416681, -0.2994775621301273, -0.10361805633332603, -0.22016480397686328, 0.07332989099673787, -0.1283992220748348, 0.18355229486287772, -0.08238427226444515, 0.15359828560570268, 0.5565809064693635, -0.09909791216763388, -0.22987087128958922, -0.10625260394998876, 0.19502074645394274, -0.13609282371434425, 0.29282715804776077, -0.10383331168431309, -0.039356301404260996, -0.05884391399908345, 0.3396806571168472, 0.4070853231338827, 0.27585199500752594, -0.3495316307586684, -0.28520761907633346, -0.20629658101991305, -0.1054497176953323, 0.12977936199361678, -0.04061703822265714, 0.17949246470097893, -0.3635810454058263, 0.5007404996378116, -0.091518960762381, 0.08494881023147385, -0.4035564790471934, -0.11951514795815132, 0.06037641531344136, -0.1788989895992429, 0.7950263660482889, 0.02232546587949884, -0.34984507306562307, -0.17864107394901352, 0.027292741500952546, 0.4462188236551093, 0.10785498231646264, -0.18222341271207593, -0.1805793741390606, 0.008660840907355253, -0.03818686683947537, 0.018166444847191, -0.3621359015847987, 0.3175407740940007, -0.15688337146534817, 0.07582896025244945, 0.05386048966512017, -0.25592155877670597, -0.11427817074824892, 0.06864574250101713, 0.033617930310316985, 0.019986898698518774, 0.12270004659373877, -0.08168160060750286, 0.13953039387467722, -0.052758752845554},
    {-0.920691951617692, -0.5406182529072352, -0.3917154600453769, 0.4962049041261252, 0.49989791273991674, 0.14520109071081455, -0.4475013475501803, -0.2717538352247188, -0.8304568676589764, -0.6489854426468894, 0.22452695596910394, -1.0135938950686274, -0.5755168574400333, -0.5099986249304999, -0.48589277563080097, -0.07787613282920465, 0.02728365359873221, -0.4933425719304891, -0.5713208311356109, -0.331837263119633, -0.0014129202068154303, -0.5348320550089318, -0.35823105428592555, -0.5916977035449958, -0.637812586103409, 0.37352562545737616, -0.32474358173603446, -0.7033536945243902, -0.41335937103825754, 0.6181323470945916, -0.3904728826786523, -0.31785980602194586, -0.39346983983289713, -0.2857055009899087, -0.42605073308767544, -0.11787871149486272, -0.7300183706438107, 0.16784511004797115, 0.13233489655883104, -0.44982631076156954, -0.5702903705258375, 0.06502934299771897, -0.691382508349849, -0.004632484732411807, -0.4899359386459831, -0.1977306698855575, -0.4398884004381463, -0.3741271802487885, -0.5810506105088381, -0.6038869158411514, -0.3981594162117027, -0.47330229547354286, -0.13874081142243955, 0.19259412389855396, -0.5516970012621011, 0.05750987600631469, -0.18692904678479524, -0.5807396521516933, -0.3335753587553132, -0.035676654549454755, 0.500248563706478, -0.7649648942280879, -0.6235638166850302, 0.38018351952447277},
    {-0.9349223031130182, -0.22211695780204793, -0.008247625924948038, 0.23892589056670505, 0.41413914146171543, 0.11529071246905499, -0.734746071816084, -0.7066438687787898, -0.8620517719554877, -0.38506066869008193, 0.41466232892043825, -0.7022943967477528, -0.9587794654059986, -0.5430257608470055, -0.07343646514937707, -0.4348505041753086, 0.6598096027289039, -0.06512559450044111, -0.7294149483594253, -0.5733564353453372, -0.46665544547385135, -0.5892723162101996, -0.2387069770772586, -0.6204501791488892, -0.7397022304068896, 0.3618616397523691, -0.3809962112998821, -0.56633235916113, -0.6134999309056193, 0.2782094002816968, -0.2152446684186063, -0.29799220243867, -0.47615212536470763, 0.32806709029575726, -0.5329779663483676, -0.2534355221952239, -0.38083814915974035, -0.1132133628238865, -0.013947222975041295, -0.40123238556978746, -0.37549765803000024, 0.4846943259760587, -0.4660887235998975, 0.29541596111670176, -0.3180269023407388, 0.21684556089800627, -0.37212939013914076, -0.4246663790359685, -0.1693522726133264, -0.62749244406598, -0.20758467074495573, -0.7007799746877351, 0.5103039423888741, 0.7226220581614358, -0.5218391176649129, 0.13612182898333947, -0.4396564790405726, -0.5597361954921303, -0.13094438830184935, -0.3878940449004004, 0.751361748967812, -0.756987825854475, -0.5651315267793804, 0.10768330886719606},
    {-0.3615656132081077, -0.5495220632376172, -0.5577239832533463, 0.43065240239762886, 0.2778466962505895, -0.3108433061504984, 0.32431996518669975, -0.30325081121972103, -0.5646571578593681, -0.39977553620214973, 0.045006621078667826, -0.06692951767476041, -0.36824334759533556, -0.1176098766409049, 0.06300419669880229, -0.8092345468428045, 0.44873070517730346, -0.1115571491468808, -0.5770561782450431, -0.2861151321972388, -0.6426973998994949, -0.5830078936327051, -0.34782005404795, -0.4074207241260055, -0.7532120741131284, -0.2432534135717769, -0.05481774460607485, -0.6108471150171465, 0.03339563615587677, 0.008147873497722958, -0.7427527712960664, -0.3770016022286847, -0.5900717660767488, -0.39948551317304193, -0.3844827731761856, -0.40819844567036156, -0.3196910117625678, -0.3004859140558461, -0.06782133751143564, 0.10626234843785752, -0.3755332999868279, -0.030447897532786018, -0.5521043737695414, 0.27760252598932084, -0.016881621076068127, -0.3639917310649673, -0.6799260224625155, -0.19403939475901483, -0.5225350377034584, -0.33163317593291786, -0.38168829900960544, -0.13726314467759823, -0.0004346065103670251, -0.26206347123857826, 0.29368118947179306, 0.09833736387107488, -0.22216990749049, -0.5775265432324619, -0.5391267799456595, -0.286742295406029, 0.228718110771682, -0.47046950644821617, -0.8428977990055406, 0.2204762609801168},
    {-0.029069337179011775, -0.34284582025416116, 0.0641069373962038, 0.03289657427742076, 0.4975397984000714, 0.034221712039657036, -0.3398240411809844, 0.08677038583770752, -0.3691666062463479, -0.47824157854361804, 0.7789890960483491, -0.7132318548726805, -0.3566214079883694, -0.09523553486387322, -0.46053119354794286, -0.23275049907336942, 0.19860579941131207, -0.2249915804022971, -0.35130494207908874, -0.2781083640423739, -0.10417433179542805, -0.3783567793067313, -0.35371691336409045, 0.32728703585887775, -0.3946881395716997, 0.6451428261461187, 0.06599412112233816, -0.4276819025906422, -0.41925863467478175, 0.15274712654757228, -0.059382801818776365, 0.11896750846117146, -0.4824986712944536, -0.17805014096676916, -0.37916170477184497, 0.1951385068719052, -0.07918834584544528, 0.27955129229619774, 0.005089772404636331, 0.0705774034053954, -0.2212178634178832, 0.36425902681945355, -0.3510449521113199, 0.45909861871539326, -0.20525761870926382, -0.28413659086375437, -0.345863080965724, -0.015673618200836428, -0.881044016165047, -0.9501794663918316, -0.24041279257354523, -0.03865123288126149, 0.08637372205400051, 0.34136845827489887, -0.04501653065323631, 0.504783039298423, 0.15638417013146735, -0.4129957389167531, -0.5035659872937818, 0.3544613027625654, 0.6278339648615483, -0.28439474045179824, -0.10476541501946056, 0.19438821780270424},
    {-0.011591388118957166, 0.02661060517888834, 0.18803481212481307, 0.7234318673089903, 0.7033445882984932, 0.18662186872255732, 0.39932969846114386, 0.23904042239684736, -0.0247263326641097, -0.5776711421832572, 0.6902007506460768, 0.4211789602520681, -0.19018540069948062, 0.4549576068554241, -0.6436908522502524, -0.5245578234326254, 0.1773638346529088, -0.3353639457759801, -0.47301736099012787, 0.000196124310341371, -0.3668114315309908, -0.35484836950725057, -0.25818010216095033, -0.2944772207221031, -0.3639342926884766, 0.6532194251280165, -0.22892417213915933, -0.6968361194415273, -0.7391245780288918, 0.569041821070136, -0.16607465782946612, -0.5047896766512537, -0.20704131997104624, -0.4189784167916499, -0.626905544853208, 0.26561490084054495, -0.4636528243700823, -0.2318987182373025, 0.33540455344657816, 0.20819449908478938, 0.31867483906093286, 0.41520097972958875, 0.24882789746564807, 0.1619022339678621, -0.4148573238906534, -0.217625702693498, -0.10505521343049369, -0.0805327532582708, 0.038418428555250746, -0.11130654625208507, -0.0580361627820374, -0.03922603595088901, -0.2010901593269813, 0.02448576080930987, -0.2222751489774146, 0.34779119852714757, 0.3543213483509182, -0.3289206139426611, 0.042852657665717005, 0.5962988721476977, 0.5782054772011999, -0.45429118918505584, -0.6583068241753663, 0.2043649882447667},
    {0.009333827345475991, -0.12508010264053313, 0.5787761619763286, 0.226041213321176, 0.4385779431235712, -0.3244349373048269, -0.6710269797282741, 0.09298557150091515, -0.4521845235620866, -0.7235245915771885, 0.4772419882757011, -0.75793534705707, -0.3297733438965366, -0.6051173743505992, -0.4516983703110727, -0.05603409216067339, 0.3654611465984119, -0.3842779818415411, -0.17378370080679378, -0.3404801863080985, 0.09385543328769136, 0.30462979607609236, -0.44828360623521757, 0.1811786066236998, 0.06801374929634596, 0.5321199269159984, -0.16717901600312582, -0.7201317962444327, -0.5465239062209668, -0.1598696434110338, -0.18139912980532094, 0.2366833319614837, -0.5081354913640024, 0.44861189634422144, -0.45785134183826454, 0.5186846562531968, -0.07284473653023579, 0.1554880123221262, 0.25067931952238937, 0.22233062316011698, -0.3628389301515683, 0.4792738632888349, -0.6427862336385661, 0.45467129866023515, -0.21892443228862657, -0.10844499706082485, -0.3507499724411471, -0.1475866617716531, -0.7443396048041437, -0.6235223635195845, -0.6134626386485663, 0.06150160786474329, 0.48244256359359894, 0.5148864049531501, -0.32259312242989113, 0.36515657802187945, 0.0862392013881969, -0.1815513408931952, -0.3446898450070223, -0.16551138603727575, 0.39258555984554144, -0.43920545561039204, -0.4128053886942446, 0.6372173481478026},
    {-0.3303534005445649, 0.15021232949579633, -0.2451347403727977, -0.22849111549828416, 0.16557614821788147, 0.16037614728875607, 0.3060285903314456, 0.17702628764968717, -0.1439177807740941, -0.39373123028428314, 0.4813078087020788, 0.05600519367880965, -0.42635780454664285, 0.1437168114851162, -0.07641230288089622, -0.25270371422571947, 0.06070856037107874, -0.21164490239619682, -0.30774301212942734, -0.3567715683261067, -0.3424916848111803, -0.36768780444701193, 0.3592939986785419, 0.11963502956987712, -0.4500324584240953, 0.512373268430785, 0.06990350924088594, -0.4051892027194634, -0.30037368648637625, -0.31198880534395884, 0.0030054616372148686, 0.06875944097889006, -0.7239893656853873, -0.05490162419269038, -0.018504693010504458, -0.2678741364739227, -0.434827224755818, -0.201479568749947, 0.566913112955362, 0.21855429893332437, -0.22907821805778508, 0.23668910431259355, -0.36567347911905196, 0.4675339182046791, 0.2252338020542622, 0.5559858553923803, -0.1884732655436453, 0.06763450390348423, -0.1713376843615443, -0.06731548562095524, -0.1574944957374203, -0.07663392488601681, 0.4090126835494702, 0.40070861215933806, 0.3600315860266568, 0.06398029050879386, 0.5243125307229337, -0.3739397452183221, -0.24413733785007566, -0.029916104352245787, 0.04192183901607593, 0.15489051844257357, -0.5281420616864198, -0.2825970799363878},
    {-0.5149170858054103, 0.04718210645847569, -0.19714246513918543, 0.4754004452366669, 0.6286308080497636, 0.011593955280268669, 0.3364854713192718, -0.08847708456228076, -0.33208206496851883, 0.22861386212681764, -0.1583354817289047, -0.7091434509789813, -0.45500698577144555, -0.07665485256476996, -0.4673674291173684, 0.014443816540292137, 0.09993936924900937, -0.1180542259630024, -0.5034795020736343, -0.44725343357453834, -0.6126811701363957, -0.48691475022330905, -0.1442512927321022, -0.5695579653373565, -0.19503884402408014, 0.38723209008947457, -0.13677203269225255, -0.49455664183547243, 0.4759962269841936, -0.09953492317346968, -0.07121278350267032, 0.46728426236199394, -0.17211939292033301, -0.2644228375753195, -0.3355493991442034, -0.572115125203185, -0.6474067082298405, -0.2841337437616268, -0.6153830308683534, -0.6245909457205596, -0.08490734663362479, 0.6481561076157116, -0.30039890094087845, 0.012463168103317913, -0.413545974368055, -0.07054012758515178, 0.04286284790813029, -0.28843861305318835, -0.06672276390815515, -0.119788561975294, -0.6634597738597479, -0.09031059199646879, 0.23617116234635613, 0.09039644814926985, -0.2356453860509352, 0.13273363650459802, -0.3924059415865466, -0.12379123093731459, -0.3061997848266201, -0.38129267475933926, -0.28546393208544296, 0.10722403711151253, -0.12942859243131405, 0.4921199980357182},
    {-0.31114959133132747, -0.6844877306845791, -0.16587801717966813, 0.23658327540631194, 0.3625019927179331, 0.11319224258510334, 0.05833725180998191, -0.19457682409484764, -0.07661963485537958, -0.32417661501992767, 0.2478926107782175, -0.7002571449719704, -0.7521914953894541, -0.32534326108725303, 0.6002884415404568, -0.056550030280788366, 0.14968996503256765, -0.25299424584847685, -0.6680947695820096, -0.3929140731111596, -0.5199185131345312, 0.07834172645034919, 0.19840648151076634, -0.4014772462611615, -0.23399325169862648, 0.4842859956024913, -0.27629070917806203, -0.3124087708352851, -0.05254559879336049, -0.13797256030961735, -0.0802951234623689, 0.3839895712388962, 0.12718560729244788, 0.08375394416320203, 0.004457359435949807, 0.026101643666786814, -0.3243104997269051, 0.2070795133626216, -0.1722435225763736, -0.12033669428975852, 0.3049620647854516, 0.44631680473500923, -0.5842166783285568, 0.35786191452734456, 0.0985978478052053, 0.003368850548369586, -0.03793748323814119, 0.23162695779549755, -0.031726414017636095, -0.5485510264277773, -0.22446439827970513, -0.19213890035771727, 0.4919725532934904, 0.1922662968909393, 0.2172172777080411, -0.22087140841678485, -0.6763035901185546, 0.051985287070882916, -0.1344239748692187, -0.9123370270096978, 0.32790429169868685, -0.5504558078802859, 0.14119247864093204, -0.5200114658116867},
    {-0.279348896060941, -0.23099753244417562, 0.006973390549006763, -0.31052420873609043, 0.1329369020101863, 0.09992251391883039, 0.35431793613333923, 0.2694839890071476, -0.4993547477419355, -0.11816384489286116, -0.3423972535828228, 0.009391891506462467, -0.3883745605415736, -0.2126437834513034, 0.5200936356433133, -0.46577857755997354, 0.18029028018941518, 0.4970332447374868, -0.40028960534616276, -0.014287061320840231, -0.5381230885394862, 0.10451516594412003, 0.21874838445420852, -0.09467292136228263, -0.34224132952330405, 0.31878213971416103, -0.020557386807262212, -0.5536996141456055, -0.2517474344236993, -0.6147608582598413, 0.06198270756825856, 0.4043158508341934, -0.25676033911670304, -0.26255230723859274, -0.35672814317796897, 0.04979800387022259, 0.3856938781064713, -0.2628646956484848, -0.17613749198361506, -0.2756116653655554, -0.06863002826740977, 0.11556380658371361, -0.39693257285796524, -0.0897596950919757, -0.35666472910829794, 0.3540948085705107, -0.23776539867476554, -0.4430666992116841, 0.0447176211589014, -0.3253174286753145, 0.11960956114128488, 0.15547032437006836, -0.20097520813206313, 0.4207746028854071, -0.05099992052856824, -0.039142453285566974, 0.39821185680404164, -0.07686995745504295, 0.19664424256674998, -0.16212969040975855, 0.22680311936919642, -0.3511280931676886, -0.24869875171143688, -0.28616398229954065},
    {0.044040583683032916, -0.12132942689466047, -0.07838181442177916, 0.23882373981777938, 0.2185486814643558, 0.3147853566425761, 0.3805581036182328, -0.08990655831232203, 0.3314449149571682, -0.14077617268304005, 0.39417148100109795, 0.4964468117310672, -0.07522123766860796, 0.18879080529420772, 0.3789408272534228, -0.40085397774550635, 0.4406131478288105, -0.3669082204124802, 0.0778625975710564, 0.5971653455146854, 0.48568096763652147, -0.07704007716426582, -0.5748798473851059, -0.40322236173881104, 0.113003669630363, 0.4170708530658008, -0.241151762528525, 0.1205783602864456, 0.1318803084831319, 0.425983005321148, -0.42142180176081284, 0.15052452131755667, -0.018171579238555582, 0.38805365120255647, -0.4055476702721437, 0.28005932159486346, 0.17342881617755468, -0.3959000163071352, 0.2722748366948292, 0.6357172713022791, -0.2869464760479791, 0.6748400430532512, -0.3800924813942569, -0.37707288494399405, 0.290733010358162, 0.6880180301051039, -0.17314083935274072, 0.01687427393882298, -0.3110182348906741, 0.024079061787362882, 0.2695827200184022, -0.17844316211544323, -0.1773585356395634, -0.1286266921108458, -0.2714311546591509, 0.34364954629636923, -0.18174254882865176, -0.17355003899921345, 0.2438151484972326, 0.5483165202666558, 0.22241819808551044, -0.6173575251865138, -0.001184785401516167, 0.05188569438370769},
    {0.16240602486638409, -0.3988410138342629, -0.48151334975593624, 0.1161837551074966, 0.2197950632815521, -0.19172432850622284, -0.07699689834743646, 0.08948102446327691, -0.3439933586990705, -0.3262338547380711, -0.5020767506856735, -0.215819744366316, 0.10847975101340825, -0.19641356308850574, 0.1947637224603097, 0.048038406645236724, 0.04491161331916562, -0.39439923206799066, -0.18393641562663038, -0.17909207767510524, -0.12406614600526093, 0.23674441624860762, 0.06976535443124157, 0.15123210860842667, 0.0326593942275186, 0.07174887640793007, -0.026769118146546235, -0.5148784185706494, -0.11571659710678493, 0.0591003049374942, -0.151113613815919, 0.5131008408363537, -0.4002073939345888, -0.22997209590240075, -0.5215753682819221, 0.1489052745697734, 0.2730421356668399, 0.45756523787979847, 0.3439970184229638, 0.20122655597920294, -0.19246173345163678, 0.21087400502254464, -0.1131055499133145, 0.29904287561769943, 0.4376402429393024, -0.17791391951253285, 0.0755521139412256, -0.39859139525336557, -1.0265806926212933, -0.304459944303379, 0.08934831330101498, 0.018614704080893763, -0.09471643812601008, -0.27435293823264867, 0.25377830741254087, 0.42249937037930774, 0.31398089175856747, -0.3349844158255329, 0.6066400007645365, -0.1762455072137621, 0.13296280914577732, -0.18030169892542317, -0.280229657223748, -0.002116497258766758},
    {-0.12371024978692728, -0.5292487647334656, -0.05325608577558809, 0.24031193804059187, 0.24971178184091938, 0.24515703856737991, -0.18592295524420618, -0.2547069983384318, 0.15372173708857428, 0.06427474185914414, 0.26522461303854156, -0.413406227583311, -0.3635705485976489, 0.17392606773378833, -0.2696898693279612, -0.09951059047381469, 0.2668471586319783, -0.38493378375525084, -0.4883240569047181, -0.22735509203427492, -0.0739214191221573, -0.230501440567709, -0.7844366895544334, -0.27069930130638753, -0.10646516470969586, 0.6421242295720695, 0.06359246178551829, -0.2685343679960617, -0.2502920189777628, -0.2086038160691372, -0.05419562705062488, 0.16726480294986731, 0.0700987289350463, 0.0174090727673354, 0.3334842591141293, -0.31082472332675926, 0.10471954317034965, -0.3008645772522705, 0.07746080872240159, 0.2235388116351304, -0.3692573712083541, 0.04121952547450211, -0.17291202146886506, 0.31243158319524056, 0.23660478877334826, 0.0612820504075488, -0.3807119224473826, -0.3869850252010885, -0.09983073250932442, 0.08385452048785227, -0.18338980477315142, -0.4705772012660351, -0.2646163315909045, 0.07113258953050365, -0.08872934722178466, 0.42620804003227786, -0.17121088190197245, -0.24295452008717094, 0.08288921789471095, -0.409298504163922, -0.30916270236157145, -0.34576463673546803, -0.5460585575292762, -0.014444361403316366},
    {-0.41883999215880874, -0.5440390027562992, -0.4939656227853483, 0.33906256198553, -0.17135708234475014, 0.015167286901617394, -0.31901737707679834, -0.6312940678398681, 0.0076077830253174425, -0.473598260154207, 0.44259038680709434, 0.437813412485406, -0.6727899654861972, -0.188448828290377, 0.0643444061874847, -0.05193440590060105, -0.39234436955631885, 0.4603471559335933, -0.09752603386054648, -0.05880181109958794, -0.06815817256826463, -0.4033356720312734, -0.33596699502796845, -0.1758510768657723, -0.08028703879363724, 0.04277484227751952, 0.16214780478838378, -0.2574256793897049, -0.43735561204487877, -0.0648039250949379, -0.5169862589790392, -0.2218848032061691, -0.6666183475901307, 0.09903070737172369, -0.3864619084849877, -0.4324848808157721, -0.1482126542759768, -0.39477601152465386, 0.3132280095046256, -0.2089828581653999, -0.032375432517209125, -0.3495679439257384, 0.06409541387565498, -0.09663042353212284, 0.020452711798337443, -0.1413709106158661, -0.7366748289724083, 0.008856612688621642, -0.19562631067837596, -0.2723754718884929, -0.2749868235354702, -0.9057407958967458, 0.1744571082257194, 0.2846849023367426, 0.0995263322285685, -0.3474297703147634, -0.2738593555218222, -0.4650136525325765, -0.055092237472297356, -0.11400620445806965, 0.18996958812751616, -0.11371574781578943, -0.15777179004441777, 0.2774392610623927},
    {-0.10353328438765177, -0.22947255004824663, 0.40948085431076997, 0.06847754856849526, -0.08903202497171733, -0.3565639269438668, 0.1436643475642232, 0.3505874359571223, 0.29634940171553364, 0.2699606245205721, 0.3495059526576366, 0.1229857618986556, 0.15916835310305202, -0.283971384465663, 0.27526681577175643, 0.06934978710712106, -0.21620713743459127, 0.21708007819696634, 0.17691819834467565, -0.12249118203251845, -0.17597268541611963, -0.1498752990176588, -0.10669741564403812, -0.7665046082895098, -0.0788332194174959, 0.013868570366982913, -0.4524119337269021, -0.37772281397136476, 0.23356554047164, -0.7931229724497391, 0.09421319886263377, -0.10476466740924457, 0.2757489933407322, -0.31173923929122055, -0.22940711279284726, 0.14483537396225005, 0.09667179816975197, -0.45092740543985954, -0.26512557491717764, 0.1190336338147781, -0.2910120835175992, 0.5270377055850323, -0.23071769700068417, -0.028875788949196186, 0.43272214983737944, -0.2900622738107359, 0.060065325997219386, -0.1441011806569017, -0.26311755115200286, -0.12217311004030945, -0.3299281993709387, -0.2392734516227987, -0.28948193799383576, 0.47413521037105627, 0.39537516845365256, 0.06702771314183115, 0.474482401238706, -0.4494941543721141, 0.3966553513635833, -0.2817752991694869, 0.20189873154058402, -0.21725702161180985, 0.06950124311990989, -0.45831164658041224},
    {-0.4741187875123295, -0.018458767001959867, -0.2908296775200553, 0.35131858712388314, -0.3279384229120806, -0.34937312127477177, -0.3556705989198828, -0.24355266371350764, -0.4167731865054964, -0.31792298104711303, -0.26271558509256165, -0.3081931125932451, -0.2710427900602991, -0.04140810161339414, 0.25804671853554456, 0.28626366084299365, -0.09161566562491998, 0.18431470270303305, -0.7087630208618606, -0.4020423399088178, -0.2607008580350873, 0.4420984852684622, -0.17054652030060072, 0.06823358164388177, 0.04280464040410222, 0.06270481716461415, -0.45588773546463746, -0.14794274944073416, -0.12846704385327104, -0.029998312753732933, -0.026357786851423055, -0.23923938833722053, -0.26339776476760257, -0.169999595396114, 0.12001314575229519, 0.10714151994758571, -0.08480267133225178, -0.0005833490715985109, 0.30284650027636767, 0.10303142962750178, -0.20475026126248366, -0.10316462111453312, 0.027092276867388763, 0.05703180797725578, 0.3695318863758077, -0.14558875767093804, 0.05572779473700981, 0.3469729648255558, -0.1690499855443497, -0.3639296447132063, 0.1352403207592056, -0.19219022055136525, 0.08442983070056752, 0.16877114278005229, 0.560728046252287, 0.06046833665651952, -0.27434400413435467, -0.0038377928631908266, -0.11661211256659275, -0.24957755374534774, -0.44330759895866145, -0.4460778593165587, -0.46050281291803286, -0.6274431215894455},
    {-0.22625420375522418, -0.19477068316020751, 0.1872737892250997, 0.037469376674201485, 0.1992351737050978, -0.05066925518552267, -0.4072894417174219, 0.12711421424165953, -0.35310750342237074, 0.0825386228889833, 0.7430376648788658, -0.03870250131483892, -0.3990843406130997, 0.19705480455500882, 0.06295271791734997, -0.07864595148129393, -0.1410405977659401, 0.12144794797156647, -0.2679536644638252, -0.22547891889241709, -0.20311243242319427, -0.12768153089902443, 0.17545280024476198, 0.07298361438533933, -0.18314207403309454, -0.19090275198799184, 0.15008397387998898, -0.11568019928184889, -0.5247652343224841, -0.547249889445588, 0.061694820066094384, -0.08287675031579468, -0.7347233867456304, -0.04810182111050369, -0.22846111162033128, -0.00646315304459238, -0.17126750683185177, 0.7354396318077578, -0.0039682453862242084, -0.08686773167481908, -0.39201154129000865, -0.11357191174540208, -0.2829298022937982, 0.43165532146319646, 0.07955475558840407, -0.5531781783044979, 0.12872123167903238, -0.17808714205465087, 0.14671927848426708, -0.17563411447883032, -0.2005080030220322, -0.5102217237547314, 0.11607413618346188, 0.1860656769585568, 0.09954864748196418, 0.4328813997991861, -0.6194111459677317, -0.6026865535804791, -0.08082835840368223, 0.39389170689514424, 0.06485985591580475, -0.5062975550425166, -0.377852924114043, -0.07131193348870915},
    {0.2878016491801323, 0.43494140981179885, 0.5467043639834049, -0.3404220378909704, 0.1280286486018996, -0.30881654725409036, -0.21148509986569444, 0.20489692258780165, -0.3354458459054199, -0.16347823255466828, -0.2338866848915263, 0.054095269864556775, -0.2028293429093236, 0.7353150007607573, 0.22148968102596106, -0.25975189746935184, 0.12155378061244163, -0.2849401738383614, -0.3377181607591175, -0.30144201729639536, -0.3586434180391137, -0.2063629272431056, -0.25675352219126524, -0.20073648666294297, -0.054093364966433105, -0.2792670877638548, -0.5907644501463858, 0.09760164037732078, -0.2348275393358604, 0.09567220752239353, -0.09887968562784344, 0.09345626022261783, -0.2369873964241864, 0.2845037146355831, 0.07609856716823361, -0.03897106042371626, 0.22346766902963172, 0.5803974613185827, 0.13051940007529025, 0.24306452047697658, -0.12275994387505167, 0.3021085737193421, -0.3224042282412585, -0.3353820583781548, 0.1876072387000555, -0.03279433439031928, 0.13927122442417153, -0.2162812068271054, -0.3871074579536735, 0.2954330290436945, -0.2710776483796147, -0.15074068361708803, -0.1143864022611653, -0.4074673108108251, -0.04389472527662623, -0.11082963271131145, -0.3292034627212325, -0.06752771731957018, 0.21830699233316758, 0.19673595371673244, -0.23141268651884214, -0.3305884171339121, -0.4229288781806549, -0.22232304187501573},
    {-0.004282918239342866, 0.13510872523316353, 0.16349554007738995, -0.011608410764645841, -0.05932272425294563, -0.36305448451435113, -0.2100622137924888, 0.22667437682191577, -0.19686294199553153, 0.09923110286230984, 0.17724020544141186, 0.10176919257514296, -0.0833436141705823, -0.07290578601233033, -0.05867128901189168, -0.23870518049937856, -0.01290924168516239, 0.21822044005163993, -0.47415640704126183, -0.1021336152865737, 0.030747932399550995, 0.3764385055289656, -0.08759304430835965, 0.14949212962689212, -0.29890905305890925, 0.5896508134757951, 0.07323562740460261, 0.06191446555358363, -0.04417860864707235, 0.09997140721438534, 0.30369094643388295, -0.331367539175329, 0.0934183465131204, 0.12026568162251972, -0.008737148508917904, 0.2026902538575098, -0.30309312933091687, 0.6167616008375373, 0.35927242437749196, 0.26805589622722337, 0.12443261789436989, 0.3073081324413912, -0.07751226563566811, -0.2177761544024764, -0.3031827547492689, -0.1022069454533893, -0.3827902889405851, 0.08359196400329764, -0.3567670498688444, 0.014611996730530812, -0.007217387418685826, 0.34275595363407063, -0.8386472125455745, 0.47660051977726753, 0.1369801915066251, 0.25691545191525034, -0.3723581334711887, -0.08975353325581588, 0.1300975410528247, 0.5287733753165991, 0.5209365605078529, -0.4597630865837456, 0.3644752917353763, -0.014473297985906046},
    {0.2906235635731899, -0.09751812342750514, 0.5287127665197013, 0.5533343900545128, 0.2881213695694513, 0.14923634980341696, 0.2438222382633535, 0.6259553011948289, -0.4549482924549576, -0.24840400404522664, 0.012159811259445394, -0.05983192882309807, -0.312756306466926, -0.02400683106387978, -0.11577743724822903, -0.04492388610774399, 0.11255805563868797, -0.14211907562016354, -0.1910164141532316, -0.5512890122718541, -0.04399090412228659, -0.1279352737526964, -0.03370988654893853, -0.21210551681047374, -0.5292116311734683, 0.38146918434729266, 0.14346201302277856, -0.5533937104127877, -0.30112451723025163, 0.6861151145848258, -0.06650204648820461, 0.05442891011121423, 0.11437251708561515, 0.23899922221726325, -0.25436755701092023, 0.7566177308296396, -0.4230413227215569, 0.32211784588847087, -0.21591059948921204, 0.19727191510988645, 0.04933686567003919, 0.27879084468669146, 0.2664107511841108, -0.24169440066185252, 0.32196837088629626, -0.18452085259955875, 0.2546096309289151, -0.1972127846688107, -0.6326543808576907, -0.7843373341749201, -0.41864707040819016, 0.4275456696634537, -0.09447804942604641, 0.32757096471490865, -0.5826310195943663, 0.2655524938161529, -0.3651974291082647, 0.1665451926504636, 0.12197081658254061, 0.2643939644198267, 0.10775378761139928, -0.43634635698129176, 0.12719469636356656, 0.46800228820401146},
    {-8.130469014522555e-05, 0.3392080602673029, 0.0040893695815367, 0.3583512375933403, 0.4653801800215085, -0.4677116435352296, 0.2034307812481223, 0.1015907440002239, 0.03333533703485613, -0.2629986236182265, 0.5598741654047247, 0.07700598659623538, -0.23759160762193815, -0.253451222380496, 0.5837191124235817, -0.33638197503181055, 0.3184365753599136, -0.0046739885704192305, -0.1426484886035754, -0.4740982831853345, 0.2300434776526886, -0.18838506105928515, -0.46760992352125114, -0.22023078699093598, 0.05881816485939905, -0.03239193640196814, -0.04589479920167633, 0.014725886646050021, -0.5816262984664325, 0.04498608526405793, -0.40609794754065237, 0.12272873853785111, 0.1528698883190234, 0.3246029207534758, 0.4144731038447591, -0.06200952032656721, -0.18399843198322324, 0.045883865680062044, 0.1658742000395403, 0.5005778521383436, -0.41537681106761515, -0.15273985258200198, 0.3267179839470634, 0.11767793969558464, 0.2750800994111221, -0.3168254331262263, 0.10818067981425662, -0.3284356268142931, -0.11831697097490622, -0.39191440049561377, -0.166568894375927, -0.14759574347219648, -0.3555689819835166, 0.2768286484189467, 0.1633493862429582, 0.21420755561112229, 0.17012733202010805, -0.37373980577464594, -0.16591304252632813, 0.43016414400103914, -0.5336938415797312, -0.4531965224704264, -0.1275100977913995, 0.10949431272094587},
    {0.21771384603635235, 0.24596332324082598, 0.42625000437854643, 0.10442614851218336, 0.397857468860404, -0.07104738440491748, -0.38552648202200657, 0.0822925125901767, -0.8261327347577734, -0.2773218082974088, 0.33697592425220096, -0.14439715932861866, 0.3225638675463136, 0.1553927846451923, 0.12055584093617294, -0.6618474096496698, 0.3023105226478648, 0.2509304657851026, -0.08571889354939868, 0.1544303463139625, 0.6520330792470108, 0.44004777201491346, -0.1910505748940635, 0.0006974067964464059, -0.38668254836622984, 0.5897994299888462, -0.25224118852426297, 0.3992171885708609, -0.7364972464965142, 0.13078871590993169, 0.24520478946996851, -0.09799118207906803, 0.3042558612091268, 0.09041685300253506, 0.5016093494136008, 0.5722299012774071, 0.19829154437737753, 0.295693748403857, 0.2690330799460797, 0.2525146115468009, 0.07482318969964741, -0.06609609658895833, 0.072383154011451, 0.3015324679484903, 0.6636696500634645, 0.016715308324066237, -0.11392931727121264, 0.20296904109172242, -0.015578725877230495, 0.29239333469898654, 0.09964014238810603, 0.2894744095265292, 0.1610400700486454, 0.3720351575223485, 0.5320189818738512, 0.7658660496467764, -0.7709217379186124, 0.6167700027837967, 0.27572201199597757, 0.8362028973608691, 0.3713411500382915, -0.32658490265776885, 0.23028905408978767, 0.3662169444459289},
    {0.4726334708938434, -0.3004447845754797, -0.0009433404800687974, -0.10506824807880184, 0.19443677769317153, -0.38689507620007024, -0.49540225779875596, -0.6126911302003967, -0.6606031449437181, -0.3504465787293886, 0.08219444526739607, 0.5019627279066508, -0.027091595848068202, -0.23429950882341954, 0.30144908929909525, -0.388204420373007, 0.19467696565221396, -0.37361202987149505, -0.20499595476207738, -0.017041558319340674, 0.33134576730055837, 0.08373713413083284, 0.18450851406247717, 0.12273127339952412, -0.24825819676348482, -0.03716927940896121, 0.012389418648154469, -0.13856962800036968, -0.6874842626723754, -0.016995891630432785, 0.0047672229814596356, 0.1220335430011282, -0.22591985836682388, 0.4043922185286135, -0.4540504284495121, -0.029745380727583575, 0.16764686939172593, 0.39788612613786106, 0.06875143691361967, 0.13314188521115375, 0.11651997273716047, 0.18747686062017493, 0.16009706585801067, 0.1455600335757079, -0.17510184998826067, 0.3078408956769189, -0.3808281824495371, 0.05670756882611563, -0.5454557705896861, 0.31095608491893206, -0.029837718907856477, -0.2804731402554001, 0.18328796111933227, -0.13166460785297526, 0.1711277462312129, 0.3305308256235763, -0.3570396839776587, 0.4624824877697164, 0.44459803603167625, -0.011852949996277853, 0.3023188498062101, -0.00032591011413282065, -0.03595440690944654, 0.47379751158416705},
    {0.025387331000176264, -0.5602371228202832, -0.07205739599222213, -0.3170875186420476, -0.030018022156261568, -0.4810220654486256, -0.3929757540623329, -0.09891415043093604, -0.3785799482205775, -0.38574140644171284, -0.4963885593932122, 0.20494825867772362, -0.10949343653922292, -0.5800813318466185, 0.13386305455676084, -0.12001455339206606, 0.12181050837257969, 0.14659500020205882, 0.2957913793599553, 0.0997618412414824, -0.7978863072075071, 0.481645429780993, 0.433512375898387, -0.38673171968354514, 0.22612835216869803, 0.08706094995852812, -0.25902412890007104, 0.25662630805712133, -0.23750580929575024, -0.27455630621678395, -0.14508795152402928, -0.006041159677644856, -0.10866744619251933, 0.2458982035578421, -0.09609432461035512, -0.41348211874807783, 0.2908064166877017, 0.07168337525638908, -0.20063350575987018, 0.546248392206658, -0.38494831714896366, 0.38171256164567957, 0.156810534697216, 0.01912194836770539, -0.21069703879220342, 0.09542937035357132, 0.1096884369545823, 0.1606867876330482, -0.2463849279748851, -0.25978102566911093, 0.6240025819134037, -0.22797756097385402, 0.4819308126286587, 0.34626871666347, 0.03340061902748071, -0.0008052268975383141, 0.05119666189786317, 0.3336306186836772, 0.21267310281237745, 0.0723161199727323, 0.07510698910206116, -0.195634872995807, 0.10146676493419944, 0.47634776341614066},
    {-0.34851230809873657, 0.16980290096630446, 0.31876147671670374, -0.15590988566312936, -0.05130240223298692, 0.03232095891230297, -0.6821378285207265, -0.39241447595711465, 0.024489156022391725, -0.4526378971678084, -0.13599576749447795, 0.21775319584253638, 0.28057645194807784, -0.16667275046772076, 0.306061345394479, -0.007158288496730987, 0.055384197610498884, -0.17627314628067522, -0.07887993951169411, 0.4254391003894136, -0.5199315547109195, 0.18838583056317026, -0.01278173101083632, -0.4089328053743395, 0.03851866289854805, 0.3328345896373414, -0.10606215637893006, -0.34382959303649513, -0.5290668434352616, 0.41324963099170325, -0.5527143632530856, -0.5508943567238591, 0.08869070819058816, 0.02712938256914315, -0.012146603034978418, -0.39823336820528943, 0.25580104169057366, 0.07523933355828823, 0.4195139630964835, -0.1691458572137946, 0.25439081993308876, 0.2152956433129374, 0.18301896331213127, -0.03936793113659971, -0.2545645554834777, 0.4012437473264456, -0.456158185869338, 0.11174057928725684, 0.27289949607094577, -0.2824672955338267, -0.012427474626080811, 0.08551357852377274, -0.09348763262591928, -0.06457104700624204, 0.3471074347732301, 0.16471584234495149, -0.05251620583813965, -0.014018184700327571, -0.27631107159872254, -0.6301588163783423, -0.5923255966028719, -0.6284024882917463, 0.016806034007108343, -0.3299232442944834},
    {0.02526099828464717, -0.3168915841022183, 0.09088688291866429, -0.3672008986939126, -0.08714967708107013, -0.8229226148075884, -0.04556077408541356, -0.3713645292394976, -0.30858696985224965, 0.28478406113114957, -0.25354495325500215, -0.48936341797015337, -0.3041797762086236, -0.07460388790349927, 0.009717312326025773, 0.210098095487214, -0.3817440709651164, -0.09183260334307551, 0.09732314863263722, -0.28227759973399624, 0.1438489420830143, 0.24737800651580932, -0.19680466468962907, 0.15854392327268765, 0.09270626025502732, -0.26218545975354074, -0.1962038559091957, 0.03234008112182504, -0.22448650391841937, -0.01558147525948401, -0.0501517439220624, -0.05684122931282365, -0.6142997554687571, 0.20602256609516673, 0.020882616577267876, -0.1681732056190875, 0.18688335093582872, 0.570407048570401, 0.8903255359626181, 0.24973792864623642, -0.31393458856455136, 0.5398133275367197, 0.02966101214547325, -0.05469363550845839, 0.08878077623662961, 0.5543948182727374, -0.3080224549288026, 0.01917705599484433, 0.3884177942601751, 0.2146897544665339, -0.2538503843784525, 0.14775103554164598, 0.18542015388935792, 0.2726681391635256, -0.24580567693047645, -0.23019999001368815, -0.23561474692774467, -0.10037140385149274, -0.24666807858638462, 0.153456605019846, -0.12151699451223724, -0.20230283318716064, 0.17768315867113474, 0.16607796588472018},
    {-0.2526076915356479, -0.6223416240866728, 0.4748787807251447, -0.29341243092435376, 0.2735498591811441, -0.06850831945069616, 0.3753647294753518, 0.19486700716787017, -0.06028091601886578, -0.17948775472136663, 0.22547035767377946, 0.022765808029047176, -0.3972240172713177, 0.13120771187379018, -0.36007506684183055, 0.12573809288601998, 0.1860998913269615, -0.19065396265734932, 0.16770311521625028, 0.02825032053081569, -0.4769053908872226, -0.1311423086354026, 0.23930129685173918, -0.2997639066073623, -0.19594718727633625, -0.022737621670637795, -0.15314886673238526, -0.4232004388488466, -0.22721028569359242, -0.11757582240100663, 0.05028634996110384, 0.04340865694232396, 0.0038354501844209757, 0.8417681914336755, 0.155653621923694, -0.1638240614506515, -0.25223923165181317, -0.25833938952984664, 0.2792525243150308, -0.042822676271102374, -0.2659371929460188, -0.05461534391992539, 0.1640571839584597, -0.003734662558916221, -0.19874743702840328, -0.033155445310923654, -0.43441552322883975, -0.32950573570541236, -0.2617876377149357, -0.04007530194775708, -0.2737478338251668, -0.3737884951806847, 0.36974979091622373, 0.27996154474634544, -0.3738870441233345, 0.27763060088203245, 0.017000671647021695, 0.060277734847212744, 0.2910234317847443, -0.23224428983886863, 0.3658074498774561, -0.343022240724956, -0.6511337893800462, 0.6149669824090122},
    {-0.37858502863062116, -0.35485584164090495, -0.13583870317322536, 0.055480993981854375, -0.20158768440269784, 0.0637566476925665, 0.47587221140213476, -0.42208150189019783, -0.0925767525604142, -0.24300928764375732, -0.10036388853348611, -0.24401077291089418, -0.30833023752862354, -0.0016428333400958697, 0.08259224531155006, -0.578201611925525, 0.4795647899047125, -0.12067071911454029, -0.4110302662990848, -0.3766748543840285, 0.06076841980899132, 0.05569863195561194, 0.5276180053180413, -0.5321102472397536, -0.5037456790590779, 0.17378119473266684, -0.1208775831354764, -0.1478853904767184, -0.12521964865456855, -0.24838720929090455, -0.6824586414892427, -0.4122827955332108, -0.06523482854981796, 0.43905010446733844, 0.11545759731571172, 0.2956302226633689, -0.2963512819217962, 0.229516105655106, -0.2876156054917631, 0.1428552186616857, -0.6168562078820653, 0.46803015172357565, 0.22711885599391377, -0.43357449453949953, 0.7089578866238077, 0.44156335545601294, 0.036807259874941003, -0.5739480976007139, -0.4340350792833503, -0.20840216046628593, -0.2016482928640785, 0.3038006096582235, -0.02009395868407566, -0.11256376786915494, -0.10661235168304832, -0.00479303463033047, -0.2961371837667115, -0.7244169907586187, 0.3191715992555754, 0.5336706876665773, 0.6815885718830533, -0.3629916704969837, -0.23697531267834746, -0.4130782931569051},
    {0.20642150588732802, -0.3011495188748821, 0.6253754988660729, -0.4605837526910088, 0.04442098083653603, -0.10899243762337371, -0.5102006411225182, 0.03615849119561002, 0.09285455242006702, -0.13969442378927577, 0.17520504192393976, -0.21744223358523462, -0.3465424886426989, 0.33203227961772896, 0.1823556793745287, 0.13897007407338063, 0.02836214389134186, 0.03604025834136234, 0.08206694958864869, -0.7950163180850525, -0.09117174283524157, 0.11059502031819579, -0.12976804432268968, -0.5467100523550095, -0.10189104224173709, 0.6048541744988688, -0.5272304995323973, -0.28204892915915336, -0.28654462988902946, -0.1495172541562983, -0.38373908860690026, -0.13608043065352549, 0.045249440765614136, 0.03644450933495667, -0.04042230399879301, 0.13605728387328142, -0.061191722664477, 0.060690930864649884, 0.2686067293758293, 0.45753985541425296, -0.1540899910375331, 0.18361798741220708, -0.28129254508220297, 0.4825130866966771, 0.26057567473711696, -0.01036537806244087, -0.39959512718227524, -0.7082491136489548, -0.14211005190990358, -0.2756270348103347, -0.0023087764471066505, -0.20411148057883827, 0.4944887913001843, 0.16800909556253876, 0.6279630409114957, -0.11021106862243776, 0.5179661020353827, 0.17881790861202315, -0.16375632941291815, -0.40868174660235496, 0.38988780195977174, 0.11771974029495284, 0.1707819037396176, -0.3830244200312243},
    {-0.28408923783295414, 0.12455942159231509, 0.2313747412763253, -0.16784083448921275, -0.08810168409643497, 0.5069568727651534, -0.5320976961165126, -0.07717399192746797, -0.07444779089139013, 0.405464834159015, -0.3437702769698321, -0.48042625555592333, -0.05756544731629463, -0.33962009142746646, -0.042596269345713623, 0.10572411146041773, -0.023985793016449902, -0.17695424400035473, -0.3776222342258378, -0.1963888534211582, -0.3377999915969171, 0.2536656198369297, 0.14010749483857876, 0.09213718132009686, -0.14188191680806764, -0.27693894276633213, -0.3342973569862872, 0.465796957316896, -0.2869744808385834, -0.3329232841951498, 0.2564259280656745, -0.13641189435458462, 0.5213011187171315, 0.1516184913390957, -0.24649649584370614, 0.3376948131197074, -0.27209117530996735, 0.11578551531392203, -0.4482548116573772, 0.2898364335359766, 0.1933515693366588, 0.8396678127299086, -0.035317340684161556, -0.0493236228504691, 0.14752097046150406, 0.3264049712738519, 0.0773851379890127, -0.16475807395059958, -0.10286874223242833, -0.2884104468685601, -0.09592266233030258, -0.20222875806068152, 0.25982980230034697, 0.2275768028005869, 0.4991954521539996, -0.21549924300077777, -0.01100593833703945, 0.044789509377388195, 0.3273959728967022, -0.28131772057203014, 0.1826390545646691, 0.3498903275686443, 0.08109356761748611, -0.17900041649583753}
};

static const float b1[64] = {0.9541972205220907, 0.9750792486677283, 0.9412644048151207, 0.9284734439679815, 0.9272234205104211, 0.976335828426802, 0.925229435970007, 0.9244696075620821, 0.9702041102216449, 0.9858451085402348, 0.9406010861312164, 0.9736579839545194, 0.9144326184937052, 0.9674136833402329, 0.9129634569553615, 0.8399715262963454, 1.0102319274386762, 0.9013807815322205, 0.9586742568335725, 0.959412437490858, 0.8348525859619191, 0.8119980883068896, 0.9437632635123722, 0.8729314141968402, 0.8268509341723408, 0.9364443230721843, 0.8135874353597518, 0.9697591737079475, 0.9545234749116369, 0.848201396389, 0.8212033426774068, 0.8722351097893546, 0.8747164692903197, 0.9099074745487841, 0.8354742041909627, 0.8741872186387545, 0.9399371675284405, 0.8498398240507141, 0.9915818418507246, 0.8197801499480372, 0.9084569994116737, 0.8729947358570038, 0.9283677992028402, 0.9552790209871441, 0.9551393110368179, 0.9115719251644897, 0.954810761826, 0.9570735959060617, 0.933368303982406, 0.9304331580472377, 0.911817782190526, 0.9507709046421255, 0.9944550094474677, 0.9485925732415463, 0.9806391147241559, 0.9798914994439554, 0.9787844383619564, 0.9568813559833679, 0.9766261572598297, 0.943982460149434, 0.9664483747830355, 0.9468656716351046, 0.9443408824457729, 0.9342770267041485};

static const float w2[64][32] = {
    {0.9225706019518664, 0.7221842517670807, 0.6633882711266134, 1.0014596150356292, 0.09167526926937292, 0.9316156650425598, 0.9696174111929957, 0.32749396537162684, 0.7603511389268344, 0.8913405129139789, 0.9162742848073915, 0.7839799415919503, -0.004801695447317671, 0.9736368569318194, 0.8334794860401258, 0.5319353847745896, 0.6967191114669271, 0.9169702590437006, 0.7047395730782154, 0.9381938350703628, 1.0944968098026404, 0.8217031000867523, 1.0139004929155349, -0.39229746496188667, -0.00650747583935827, -0.1430966605033721, 0.2755163083499055, -0.07241440480836576, 0.41377666487883363, 1.0854367482424352, 1.1285623280035804, 0.8206750839085591},
    {0.9241087494008248, 0.6116984381726627, 1.0867164971669667, 0.9980050191761369, 0.07997935891420817, 0.9789497959835743, 0.8809839553851428, 0.5024155370698997, 0.849153539955388, 0.7958755832868791, 0.9755417322250165, 0.839997059758661, 0.06872125160271327, 0.873768737801019, 1.0200651263881535, 0.43909152768403825, 0.8437914679170355, 0.660099229010724, 0.4502601305302903, 1.1930973357168009, 0.8610261315878892, 0.8577070288022467, 0.5896770264091917, 0.24791549308187616, -0.03498113115714731, -0.06340430158892595, 0.3042130375096197, -0.06539106350506768, 0.7451416904614891, 0.9637108692179439, 0.6433772706060907, 0.8826929309756626},
    {0.7933161324121807, 0.2672224837934859, 0.9506463747493182, 1.1362102267271226, 0.27247796165479216, 0.6527305874323626, 1.1897375314913718, 0.6883623326735671, 0.9055264777752031, 0.7179278002572922, 0.6066519118612086, 0.7819983534676657, -0.1131725099086385, 0.5261714803631881, 0.9422561667005076, 0.6769531188808572, 0.8990180116228145, 0.7596082275444104, 0.6995009486362737, 0.9303089580427548, 1.0845505026850624, 0.9098437715809725, 0.8148908125893163, -0.2825736544849962, 0.06008657259750006, 0.050309150099082794, 0.22423797784833863, 0.17962730788464815, 0.26667197376329604, 0.8238099959135465, 0.9529415116865325, 0.8675232175045874},
    {0.8557296932555348, 0.6334489144772454, 1.046846809896708, 0.9986896112801767, -0.08427249415677113, 0.7258529641809909, 0.6986314736331315, 0.3737483249365924, 0.8994701472452652, 0.8021163005764121, 0.43234987143401105, 0.8318092606801814, -0.10883190068757384, 1.1176040765436146, 0.5344987379915372, 0.5645118919141153, 0.6742424383733882, 1.1387732712989362, 0.7303240148235614, 0.8252883327661958, 0.9815613205478089, 0.8455647727815472, 0.7954819390639998, -0.26982906461374706, 0.09489634655079805, 0.03698293323830033, 0.3771496782101411, -0.6459380493285597, 0.6692827863013705, 1.0568104078265936, 0.6494515954302623, 0.7515618700808449},
    {0.8811246865367742, 0.5962687815020903, 0.9338934823328262, 1.0522602227775502, 0.41409965507669233, 0.6550611258299431, 0.904451363734172, 0.4505596291058398, 0.6865108640329228, 0.8911638002030647, 0.8539409150473172, 0.4235836014857065, 0.057957148975188166, 0.8780054395661167, 1.1946771440871207, 0.7496100367291959, 0.7491038885174405, 0.8091996927764008, 0.6274069209764458, 0.8101284343873464, 0.813748599134887, 0.6890985477021999, 0.7970317352693617, -0.38621845810519423, -0.12577512356205123, 0.205523979606502, 0.20830652172037725, 0.2780263135832567, 0.5061067228698348, 1.2872301752947721, 0.7786806369435658, 0.7057750379155164},
    {1.2821029284719159, 0.14358919868937886, 1.0640950796572288, 0.9241260524396444, -0.04713869206883879, 0.6285454086935098, 1.012485183270916, 0.6744398467530092, 0.9730692419340191, 0.7270147318272412, 0.6000739086194348, 0.9784751673278366, -0.07886347609929392, 0.6708517304111651, 0.9323952518918323, 0.49959795964433795, 0.74568150395825, 1.0197505412682697, 0.6412038217766205, 0.9620993442581507, 0.8311082268056926, 0.8572543428278676, 1.1882080426187436, 0.16595170504566323, -0.15025542369711709, -0.2487644212235346, 0.3774761153597851, -0.1955130481368072, 0.4227122674054926, 1.1609532877000488, 0.983606187292141, 0.48519709705561836},
    {0.9932629648918099, 0.6827170010245651, 0.7950469635752944, 0.7049105359697961, -0.11946545336449446, 0.9437400167777228, 0.6752648241773209, 0.7306376168148782, 0.6502440591636345, 0.7551855430942511, 1.0634164418609782, 1.0178669527963433, 0.12477547072559439, 0.9236378619562122, 0.8219232909441005, 0.7197580313697881, 1.004099359931584, 0.802642175102443, 0.6453714234996168, 0.581234234338496, 0.9522476166630554, 0.9244406519481458, 1.2776639972333945, -0.040453527287219966, 0.16500378736428994, -0.05706459750920233, 0.3343988655548492, 0.20240535210038915, 0.4765686191670954, 0.9681839215818567, 0.9726339875853733, 0.9058714638525197},
    {0.9456807858756348, 0.3831599039831259, 0.7758892572942414, 0.9422776381383453, 0.12849125618792134, 0.5414773683344496, 1.2473210650788844, 0.5760960671979809, 1.147933588238861, 0.6859573682997299, 0.9378678083788412, 0.6839109953756359, -0.2583426263111603, 0.7570364503811413, 0.9651345181129996, 0.403482841169448, 0.7722897656743952, 1.027966336528897, 0.7300068451757377, 0.8276469612482925, 1.024311193432626, 0.608628051235662, 0.8931904876684074, 0.0825856216412994, -0.43865396481370467, 0.06334740132728556, -0.06302803857386031, -0.36100035583126583, 0.21693592752111795, 0.8741978406565626, 0.9477635345327631, 0.7012106591937931},
    {0.7714761786535337, 0.09640776343932028, 0.7531462581203592, 0.7124845801272525, 0.09528376259772017, 0.7661441079903686, 0.5865174000429675, 0.6056231365227057, 0.9485828002392577, 0.7641541742858298, 0.8131274032104895, 0.9459587528578778, -0.13484987277203558, 0.7983566336167774, 0.8210877131909878, 0.5673667788487877, 1.1320671223711434, 0.6704597474248848, 0.4410660587148071, 0.9064833690676223, 0.6915566210868515, 1.0910774264390037, 1.0989710803890484, 0.26507891464710537, -0.1821283669976244, -0.08498870664115182, 0.10166559549642316, -0.14087889694592007, 0.2132928283943864, 1.1784993909322996, 0.8957458304584552, 0.9675742354982015},
    {1.2470333364829922, 0.6575246535090555, 1.092230305976562, 1.0435112848039976, -0.14228188917214551, 0.6180302244007804, 0.6992249467029487, 0.6342284950360508, 0.9808509479247093, 0.8345074078044156, 0.6302667735633612, 0.5523711925062927, -0.13522575143892704, 0.974552654024009, 1.1043058009636566, 0.5320350074799137, 0.8740355789967601, 0.5015173295305364, 0.7370313034257366, 1.1213230506859513, 0.6167555878676527, 0.876100033257167, 0.9231345608189431, 0.04551373225028949, -0.1625783173015945, 0.031172086180405352, 0.33285943826356246, 0.07278448914063035, 0.23868491473089934, 0.8913554920879432, 0.8283331435341563, 0.7074412952621216},
    {0.7811243797428108, 0.4514221562246034, 1.177288173663817, 0.5485707706479822, 0.06515231907114845, 0.6289143019787845, 0.6406698164074838, 0.4106723462076754, 1.0819903958079007, 0.7694675261844679, 0.7898427782175719, 0.9167819312259204, 0.10072868455583496, 0.5823545006303703, 0.679594539119575, 0.542637743446834, 0.5572118697381861, 0.7877368732737242, 1.0285227255987015, 0.821579949416143, 0.9435107535478628, 0.8341185363097311, 0.6954320509369881, 0.023308973733757274, -0.23700499782544884, -0.17288400219290026, 0.6336296386653384, -0.3368780163361577, 0.6502548457279489, 1.026472475403393, 0.8038713476920245, 1.0240494552100465},
    {0.7108471123026282, 0.6749315552750764, 0.8064406149379197, 1.0706411776097944, 0.13702761236753375, 0.48837989728809666, 0.914925204255079, 0.2350055354535084, 0.9527718846846442, 0.4361415536420884, 0.8342104806424008, 0.9619301697926398, -0.30911699200810056, 0.8402111928165016, 1.033145631851192, 0.628536291441236, 0.8286780265697304, 0.6182618219745776, 0.3240683999563006, 0.8787268498331, 0.9118856643797862, 0.7031457718992997, 1.1665885007486898, -0.08973421054657651, -0.22713245690138628, -0.19501101459610948, 0.4050259842751728, 0.051216927609670414, 0.44648591246089087, 0.8219057770305037, 0.8179073966185849, 0.7664545872387929},
    {0.7395496861338902, 0.5298211686593112, 0.9290718901092602, 1.1395683298781387, -0.3480780638617436, 0.9298271664218886, 0.8391088583183695, 0.6249661291690677, 0.594189473309051, 0.8283552822270163, 0.988547624327854, 0.8704025987821907, -0.21853375209228051, 1.0993920385028144, 1.253917271429997, 0.5291018019704334, 0.7201955309624647, 1.215788782694605, 0.7422079173259925, 0.8292127647577655, 1.0772576340818223, 0.9373548987891909, 0.9088849264219808, 0.13102423626953624, -0.08456524121013442, -0.015491973033417204, 0.48864312498807705, -0.03134326492465748, 0.4018250313095356, 1.0316842133121178, 0.6368532546624278, 0.9570108917457705},
    {0.8005918560765702, 0.6824845751900517, 0.9292715402023113, 0.9480168452384757, 0.011126392651867427, 0.6482763154970494, 0.9776019572673169, 0.43415055998796426, 1.2401677956989676, 0.7297876791600453, 0.7007808605453675, 0.8927958688773922, -0.3094328789139571, 1.1062494198628103, 1.0308751883792953, 0.7209398267135968, 1.1181427150501175, 0.9118489629721516, 0.9749755792756812, 0.9427871808609987, 1.0203228759629037, 0.6527463244717394, 0.9287880305012761, -0.327184441543816, -0.031422593379097204, -0.1653820102484609, 0.48743619100619284, -0.08717131154811467, 0.19860945015862702, 1.0875887539126374, 1.102827209228668, 1.0559039302357063},
    {1.349872426892411, 0.24087362614012875, 0.6454363563394101, 0.937584336066238, 0.24611244329549609, 0.8447605425578869, 0.7431726457067899, 0.4053820950919833, 0.9192480418525156, 0.9910104319234239, 0.9110644856865039, 0.9222280243566374, -0.061632710847564054, 0.5189106300990172, 0.8256817341742856, 0.6734845036671585, 0.785555690527347, 0.6925761554737441, 0.6653316657930854, 0.4972488686431157, 0.7577643563428519, 1.0679919348734523, 0.7657661254917062, 0.04246994364206644, 0.11786976210588498, -0.13370857317189697, 0.36218217109284834, -0.17611029348415214, 0.46469291061645457, 0.9731423434851882, 0.9452647501495073, 0.9217611355722276},
    {0.9064200291838369, 0.546246145786615, 0.9199771585310642, 0.962236031416172, 0.34872848487180813, 0.9376806991192281, 0.754880283935997, 0.7402209845389387, 0.8463640091072224, 0.8618807465207391, 0.5652585520881013, 0.7857987045956556, -0.10449722728064678, 0.82723399621771, 0.5775849815467856, 0.6988519836579218, 0.7205284228432111, 0.6164951459284868, 0.7657540468862826, 0.9695763286481424, 0.5836055059032232, 0.839656896133044, 0.7387399741138257, 0.08786305785988294, 0.11546883122122024, 0.04573071500078884, 0.3441529496518974, -0.2893951936333755, 0.6034429082710421, 0.7806240959765621, 0.8435040912020463, 0.8540751760309536},
    {0.9645733085779609, 0.6921996983025273, 0.5579848937592619, 1.2151601553756184, 0.23935608268393316, 0.803629465941988, 0.7829534318554464, 0.4756933769239712, 0.9957534081732015, 1.026942369143736, 0.9436313465330953, 0.8136648765872695, -0.3009274165236769, 0.767091399030188, 1.064311765413822, 0.8716660624424998, 0.731481998150125, 0.9055331007436879, 0.8276661064958514, 1.1731483454660872, 0.7317158138533935, 1.2688348809356444, 0.9954814501425671, -0.012860891172231164, -0.038576363325772405, -0.18662638702850468, 0.8357928180865559, -0.11054612808443799, 0.854048378439142, 0.78325339909047, 0.9470275504326922, 0.832570533418101},
    {0.7300951417278493, 0.7153060810918512, 0.7616920922152486, 0.7687844451356005, 0.3181832566369091, 0.6004496886277441, 0.583522035583653, 0.6738009598988924, 0.6241104654629073, 0.6624410273613589, 0.9586935029691177, 0.9174807913799231, 0.28430872500133847, 0.5398480154821154, 1.135281288874435, 0.49738767016490093, 0.8531721056110566, 1.0259740892651794, 0.7410870788875707, 0.9064452169014081, 0.940648324781175, 0.969284416518945, 0.7497035027680482, -0.06791833887809909, 0.026463714338659305, -0.12138979521431441, 0.4124898556270254, -0.022224387145393067, 0.7478751836043608, 0.9560327175971326, 0.933077462459683, 0.8467078367307385},
    {0.6039646588215171, 0.5677219729953712, 1.057965649201421, 0.8908677808919508, -0.05539320405816478, 0.7898997068667846, 0.8899593735547761, 0.5517681716193064, 0.843995576356632, 0.7563057036625572, 0.8504875658873432, 0.5800207213813294, -0.3842375990319107, 0.8953783526363276, 1.0169246614508276, 0.45993989541552405, 0.6947774178323601, 0.9340022607663269, 0.5832150628301164, 0.650498454722023, 0.7530239843136721, 0.8300037190022903, 0.7796452820842645, -0.21248202916132025, 0.16932084791079743, -0.07081297067856583, 0.5110741787743011, -0.19121707159997559, 0.28690913122133344, 0.903698150340472, 0.9215625051703114, 0.9819549436344774},
    {0.9193224080641637, 0.0688040884446837, 0.8739462249425459, 1.0235423864556101, 0.073441610659111, 0.6334164203499577, 0.9341299190051391, 0.5833990936948016, 0.5903830823987333, 0.6593623690680308, 0.5656329239375003, 0.8711456704435341, 0.1034370189532463, 0.8093625756315931, 0.9331230015994928, 0.6910160345806431, 1.4010990916661707, 0.5891604832282223, 0.7468636687783653, 0.9531154892750159, 0.9751286078776858, 1.0222493627286167, 0.790205131007205, -0.2118345619044296, 0.3014876547461322, -0.26085319234409843, 0.2683090334639896, -0.12540122372240123, 0.1324417669496683, 0.8875514556183624, 0.6943826778046992, 0.48988508389779},
    {0.7202904556260785, 0.6395070626600238, 0.9687216165599015, 0.5620479867704604, 0.09986194984589669, 0.6303239782341344, 1.017428604577792, 0.6022262388284788, 0.8361336410966084, 0.6740651079119439, 0.7371134876283851, 0.7840258263002091, -0.09759334573034355, 1.118627325077266, 0.5352283997265671, 0.6577810879141719, 0.9886887321729684, 0.7629272551734794, 0.6112515681804209, 1.242713098839635, 0.734670096767839, 0.828484825460335, 0.7305565493200701, 0.36909666047529743, -0.06288247499413974, -0.019871649359839712, 0.25873862470161185, 0.17437664625686194, 0.06119510169914244, 0.8289713206383034, 1.0009614577030659, 0.7875570370953173},
    {0.6871985150532559, 0.7715387844199014, 0.8171635649507452, 0.7824008961597052, 0.12485111533985778, 0.9298229033478246, 1.1603947298714559, 0.6433667990469194, 0.8093444629973404, 0.7360167216299925, 0.9454476348946346, 0.6126361499887458, -0.17888840436075795, 0.8752264141333171, 0.5263176998124989, 0.8170863248101641, 0.7015937662600523, 0.8700932941845809, 0.7761821051571524, 0.7460389831658745, 0.9041075262743107, 1.1590707963926121, 0.6834447878342189, 0.09861371123280947, -0.10220300918782838, 0.020376758687047518, 0.26056892338680654, -0.09257468766897121, 0.5398828177983305, 0.7247880276166186, 0.7896109849567602, 0.5814215821066802},
    {0.9573384272156057, 0.4871215012558493, 1.0696733298830283, 0.6707113716110152, -0.1376349656761139, 0.7095694751146036, 1.1258657791406224, 0.5754089761855723, 0.9992315718542603, 0.8274216043441031, 0.9286754387507885, 0.7414676557714293, -0.3003940783670562, 0.8612961016159636, 0.9993451426970869, 0.6290779114062273, 0.8304185495612834, 0.8295542765875095, 0.7893681499434112, 0.8461018195409168, 0.8603639014346418, 1.004486272631983, 1.034452112604212, 0.17712214251457645, -0.18847553108958273, 0.11197576877637248, 0.42441791550337693, -0.006496515347479888, 0.5464427157328221, 0.7050564718049508, 0.8463428004428545, 0.791129543628283},
    {0.6049878857995352, 0.30846697210865526, 0.8119181059930314, 0.6297297568243923, 0.05643717202465818, 0.9946547539297865, 0.7982577783581812, 0.34169572771090845, 0.9239399874400328, 0.8643282025627577, 0.6765224037232084, 1.0185323593743751, 0.029002176006773107, 0.7725230458107505, 0.7664522029039276, 0.7108691204240999, 0.9314851062294426, 0.6278892658851964, 0.5944060274478553, 0.773438394213703, 1.3478969839094408, 0.775446346608427, 0.7652820864615758, 0.16266440537593949, 0.07590289884197202, -0.20125165210934273, 0.33487976632013733, -0.0012935970127753555, 0.41185729160635026, 1.187197147173871, 0.6625495496181844, 0.8291448034264173},
    {0.9577649705083046, 0.21865546305486, 0.9011951129707457, 0.49180395943012434, -0.24657285351246183, 0.738943967789421, 1.228747657245685, 0.8360578516025964, 0.7409738973713581, 0.8320619399972322, 0.8238655059983365, 0.9541430002087551, -0.33639826796495836, 0.9756712259084808, 0.5357194923878925, 0.535294890856549, 0.8066488606492966, 0.7011136957100798, 0.5487114868071976, 0.7514847088443455, 0.6264574362689863, 0.9973112427570179, 0.9099663163038092, -0.15630008312764315, 0.0044524455419362105, -0.08736712771708383, 0.16363688202439422, 0.24656165694235624, 0.22652319602463747, 0.6800578504709072, 0.9938145573541435, 0.8684516932141833},
    {0.8468433680267554, 0.5898804061579659, 0.9542879646657872, 0.8233185525823026, -0.09195229353099378, 0.8549986142849398, 0.41734156083509016, 0.7820089579548194, 0.8383098271853282, 0.6468151858394403, 0.7571754195977208, 0.9532908150652027, -0.0533258797283522, 0.6739555130883911, 0.785199248950221, 0.5811690844939278, 0.9099734419427088, 0.6459572174468822, 0.6471096479073573, 1.0956995618023024, 1.0118096463119481, 0.8755618428923176, 0.9131991642365146, -0.11006052290838145, -0.0536454191270242, -0.1897821780284472, 0.2802717436781058, -0.025170859169211787, 0.6607393081480393, 0.44161809921145956, 0.6348807129136911, 0.9098470849256918},
    {0.6216955029830439, 0.5642920828001174, 0.5631973127760548, 0.8470648096372384, 0.1686094246233396, 0.7956970471131377, 0.7162323378254247, 0.8063844976651802, 1.0371577167759776, 1.1136320011369012, 0.8076373437834081, 0.7119875391064625, -0.06879078631267523, 0.9118089496153302, 0.5874898075192753, 0.6583292312501839, 1.2913046744706362, 0.6122188333984417, 0.8198902531062597, 0.9169943215928594, 1.1567892304451228, 0.8340808681858353, 0.6586589901993921, -0.20713171419583973, -0.10879779287786032, -0.17043141846744697, 0.5095704783451935, 0.23616800551244452, 0.3895430199830371, 0.8688944812362857, 0.9000817419039868, 0.9273408182298881},
    {0.8500591754727667, 0.2726224731362396, 1.0471847100414728, 0.6012714034519272, -0.20480764373913146, 0.8105973386426727, 0.8892495954078341, 0.7852536707859796, 0.8818434628980477, 0.7300426715102843, 0.5558777765188291, 0.8149574849647774, -0.17121623752923193, 0.8014330005331964, 0.869574405609428, 0.3435553921090865, 0.7780249233122246, 0.8162192534961272, 0.7115249844126255, 1.073184708469134, 1.1583194018252503, 0.8558061887696989, 1.0246607741691847, -0.047928544364986676, -0.11591221804306429, -0.034790867071540006, 0.31783254022679397, -0.035234612682131426, 0.5885380336223456, 0.8397403524839129, 0.7798012799218547, 0.6539458231050925},
    {0.8350707583290714, 0.8620501573528915, 1.1075776096237455, 0.9841473021132157, 0.08640141078928994, 0.8457589828880653, 0.6181002819966879, 0.5081348178637415, 0.9121552054525288, 0.9998300708986607, 0.3935077737389355, 1.119282062013288, -0.1527883195313319, 1.1880570523939114, 0.7843838734729919, 0.6333325938130215, 1.0044099646819296, 0.9426722052773214, 0.8797213812282599, 0.6943386112381683, 0.6624622751259263, 0.8829011036914114, 0.9803777410827564, -0.30398109486014724, -0.05109406680422625, 0.15642071016571923, 0.03657890140270131, 0.03539045039043836, 0.4210624917770946, 0.7778855563449096, 0.8345987844734802, 0.5937990980337168},
    {0.8177752419881711, 0.4675040531844694, 0.9364222747826056, 0.8776585096816195, 0.26089456609218425, 0.7474555639305919, 1.0929397782253705, 0.5593410057312231, 0.6017299003741643, 0.9037025084740203, 0.9801109680097255, 0.7791662589723296, 0.02864162862328471, 0.611483965400458, 0.8342053506917447, 0.6101250024031494, 0.4525007194463138, 0.36210316816361576, 1.0598616018415588, 0.9562000765015642, 0.6308671606395051, 0.6317207738848819, 0.9479648247606425, -0.035717673136286855, -0.0784709256105756, -0.1934791930021245, 0.04539309817601394, -0.09299746871827413, 0.367851621107919, 0.8387664365121135, 0.7758089594585912, 0.450880679735105},
    {0.8275523286463682, 0.5016139062812758, 0.8134252210968247, 0.7821165351328019, -0.1136697218464164, 0.5201658537777158, 1.1338062764654095, 0.9930521740644956, 0.761966260479984, 0.8023262074311462, 1.1119322052477847, 1.0901842467682776, -0.057289220330867675, 0.8891458914069814, 0.8780924000983453, 0.8643527059766505, 0.8008388954700859, 0.7489128049851151, 0.540535297674845, 0.6633451625529253, 0.5844417248398105, 1.1460775503561131, 0.7313737312909078, 0.08609861559617174, -0.21622462906746492, 0.09449344739708171, 0.28780371555586676, -0.07550943102210522, 0.3667544493881697, 0.45884063834271005, 0.8586769023052703, 0.5800901700421535},
    {0.9735799650867081, 0.6337869065126202, 0.7247985902106828, 1.015140632771261, -0.06706532650781329, 0.7420898209573519, 0.9039085302790087, 0.6859876261018752, 0.6249808297929617, 0.642479201619996, 0.7523726511554428, 0.7670079093945352, -0.07167040588605139, 0.9863000377624275, 0.6978666192559806, 0.5226444045870029, 0.8164871312056525, 0.938522625989902, 0.6491417397880532, 0.7864820537321405, 0.8371428791613947, 0.6029279011260923, 0.8435802875926752, -0.053334337321908495, 0.13828312039862178, -0.004623646598559827, 0.13408012697338886, -0.1897362211961378, 0.47639519581597367, 0.7379876408760272, 1.1863300692558139, 0.7024996595880995},
    {0.7571722391049278, 0.5119238903510054, 0.8396852924250343, 0.8335477933858504, 0.35085953534901276, 0.4768850376678623, 1.1482945011856205, 0.2550208165396553, 1.0918428649095042, 0.7427542951721147, 0.4465394167717275, 0.7773083038958137, 0.041226446835626075, 0.6736028171912689, 0.46862004385786044, 0.5583599828111524, 0.6132267859422965, 0.9035494839550231, 0.55167009456738, 1.0097040171989542, 0.8446220490328891, 0.9093467754180097, 0.7323597591585449, -0.07989646579971797, -0.11779881380908523, 0.04324728818299171, 0.6787531940400918, -0.11347863369021355, 0.49362024377464103, 0.7236385800677606, 0.8406087056670788, 0.9295137390789879},
    {0.6822051972709255, 0.4826527015018705, 0.7935581371612246, 0.5849689967049578, -0.007722795407282894, 0.7579812090321173, 1.0306920269452047, 0.4415464639212085, 0.9069845708771996, 0.8360832399868571, 0.938627705937293, 0.761969788341221, 0.0016763315600875387, 0.5832976007047773, 1.1318346082598985, 0.5822093819192684, 0.618714212263435, 0.7690136119487738, 0.7124378930734746, 0.6435298497108144, 0.782038827536406, 1.1515162824369038, 0.585842500409305, 0.027600848462490852, -0.4331377516747383, 0.011459466194452803, 0.4678686522933113, -0.040776929915807884, 0.3695144376133001, 0.7233799537528901, 0.9370784213219088, 0.8624744233043966},
    {0.8195938457940058, 0.6182113051202005, 0.9926743456333835, 0.7548065833627136, 0.021223082972003326, 0.5375680398128808, 0.8319665511758358, 0.4685721977574265, 0.7508247173271876, 0.529699052426624, 0.7294271262620222, 0.5712680258498781, 0.01224556825399617, 0.7082903349895974, 0.8609730061307592, 0.5497745915885764, 0.7768972204714827, 0.7051244449367323, 0.7301395811645603, 0.6837000876801005, 1.0731856720257744, 0.685870967595581, 0.8322556909431372, -0.1597435031684505, -0.3850316613256336, -0.08880569945859039, 0.6476330470683134, 0.21222119844768692, 0.023961010752856605, 0.8336564624356063, 0.5877329034208345, 0.8246675079263633},
    {0.7463887298563889, 0.6608458285555033, 0.6728371125089572, 0.7626701730868778, -0.11284795801938606, 0.46029041846810687, 0.9203032420164062, 0.4483080921952894, 0.8496680051248492, 0.6409560688645988, 0.964451747669061, 0.974150905977989, 0.07218682214541002, 1.3148139554050404, 0.9799291011898945, 0.6242538749972534, 0.8624477160567074, 0.8071739466402301, 0.6050479362685544, 0.9241920679345899, 0.8944931302523133, 0.6505913787619996, 0.874688232216243, -0.25442854888851657, 0.28715260635008744, 0.19256693651868287, 0.3075014923159517, -0.013789390203092021, 0.3855841017342937, 0.5250609977528577, 1.1413602632528845, 0.8044644418458426},
    {0.8054773951701558, 0.4186749767691647, 0.5684063882868342, 0.5854593422714218, -0.14866904919282722, 0.8935725592097679, 0.6056374886980431, 0.3272422609703256, 0.8220749230917272, 0.6347356877425551, 0.965160817336974, 1.1523805924205446, -0.027431822963072044, 0.7953741996058703, 0.8220905953621397, 0.5124596045779817, 0.463303356913279, 0.8289483675621262, 0.5285065720400225, 0.9771162953484814, 0.9625921846761659, 0.9478273366312528, 0.9946509382094985, -0.2287039895848481, -0.3920705181504938, -0.07424270235502631, 0.3780843955420889, -0.04103836772989004, 0.5180994205464586, 0.9459897972441477, 0.8644283507610154, 0.8568998368698645},
    {0.7553438933725659, 0.469649628818311, 0.8325880282198971, 0.8049674635975812, 0.0744335353615309, 0.823141857258736, 0.8504798724683967, 0.5371003420058382, 0.4053767017536691, 0.7269356792134384, 0.5672465276736, 0.8301000503587567, -0.01750181320693522, 0.6394590942346151, 0.7388879068516911, 0.703027705575552, 0.9152709955300266, 0.6858170330984101, 0.5854211052497428, 1.315155197985609, 0.6518757952463823, 0.8380743015187027, 0.7468042755404747, -0.2748443614727966, -0.0226586823631424, 0.0019192321553402015, 0.1730835892019982, -0.3810958927538519, 0.24858596768683622, 0.7309565037319311, 0.7916014469056402, 0.6042367748984802},
    {0.9570100262993385, 0.5848810303371043, 0.8312208705604901, 1.0153168104910495, -0.16536302125214386, 0.8379310390809623, 0.9302284351229443, 0.7383181810250306, 1.105394780207489, 0.8883538594998786, 0.7315423342337345, 0.8507890438515635, -0.06578822731063987, 0.8996558015277696, 1.1667527868923284, 0.7609036158263189, 0.8608384867929394, 0.6047056763109705, 0.46644960983404543, 0.8114546151267069, 1.1149353008848109, 0.7590148856333376, 0.7164258467834839, -0.10172997191958655, -0.07124899456018345, -0.07018811493920593, 0.3445337436409354, -0.03791561676041317, 0.6674072688317808, 0.8070173413673534, 0.8088239670407678, 0.8577709915862689},
    {0.8346225160581704, 0.18979054463271208, 0.8726481954016438, 0.778137968782766, 0.0013485369941772058, 0.8518567197350093, 0.7054977019148923, 0.4651415405993669, 1.0691337187118137, 0.8434195621634721, 0.8562165740563236, 0.946314083291268, -0.054679973715566106, 0.8205603150683844, 0.7029292741612554, 1.2103422440236897, 0.7786249642480646, 0.7314896347275073, 0.9723132643371646, 1.0663797527158823, 0.9565556355211622, 0.6629926702797652, 0.7319657436231174, -0.21660161687694007, 0.028243794763238485, 0.16773665116148667, 0.5222775591480583, 0.014979717120784572, 0.3889066839284566, 0.6966382845199012, 0.8863637398579682, 0.8936227193543494},
    {0.7627043318167523, 0.46535709386646806, 0.9634359747537468, 1.092529945840668, -0.04363378895682108, 0.8829579982451754, 0.7814568891426077, 0.565281638024872, 1.2746914187134317, 1.0326322844393605, 0.9879079033588892, 1.0148066433898597, -0.021971638925185267, 0.6986943687820483, 0.5680410372664901, 0.44500957056587004, 0.9261696250305034, 1.0758698017284594, 0.630990071673042, 0.6574248165875288, 0.7471486480564098, 0.8653852481393584, 0.540154235727797, -0.18229034543198408, 0.15159727103485984, 0.09399786325061156, 0.340092160048133, -0.08202676741927212, 0.3453053092824159, 0.8441955093127037, 1.2131738362996378, 1.157279234045789},
    {0.9252005386737249, 0.6989198960461318, 0.727937035792334, 0.7147686160091566, 0.15310741036084208, 0.5002170848316404, 1.213247455131785, 0.5505493369342431, 0.9248969775547915, 0.8220881019244272, 1.1116630803544885, 0.6620897278343433, -0.28244548408225245, 0.9628161315765601, 0.8100520122938328, 0.8217060116644931, 0.7968280902430521, 0.8167624453476487, 0.7312563884412937, 0.951801384432693, 0.9313546454684974, 1.0501887175471398, 0.7203415052686952, 0.23321435302167343, -0.09244375896311781, -0.14183046635945, 0.551057757559296, 0.06093408472725906, 0.5493611624977288, 0.9296336215953708, 0.7945476683647987, 0.839761133804185},
    {1.0527518797658388, 0.601155090729701, 0.8878590361202903, 1.0795319475411393, 0.24391855728032957, 0.7041156864871421, 0.8439548363855466, 0.10057454614407431, 0.9937043407817686, 0.8064745063330055, 0.7290701673591097, 0.5661122275681256, 0.15263606189613552, 1.0200080965384184, 1.2035736156295573, 0.6085436882895543, 0.6838698301341948, 1.2111876573271998, 1.0035197305723667, 0.791347407563539, 0.9509834342956952, 1.1121461503359573, 1.1500333975220214, -0.22798197559809963, -0.20910851102657013, 0.19318840982903232, 0.16730807101232198, -0.029933167301125954, 0.37652461385776764, 0.8981232089850542, 0.8900244870102539, 0.7623185176145003},
    {0.7669637687513475, 0.10990798457473624, 1.0129032720550775, 1.0926577409041256, 0.030753269011703454, 0.7108535851168184, 1.0124379982930976, 0.6108211031097678, 0.8463960070629658, 0.8219769469859142, 0.6693460697945463, 0.6101738669807433, -0.13687146793974136, 0.664877375553156, 1.0663150577148022, 0.6451267935518374, 1.2175965823237198, 0.7085017735332169, 0.7386633368760273, 1.095965341377248, 0.7190616349944059, 0.8836247616182911, 0.8327813921317349, -0.4740990087391253, 0.10606619923228233, -0.11729061737662962, 0.14755889971839936, 0.061897142471698294, 0.4377191601046384, 1.1441838969571971, 0.7108553241552933, 1.1451716631280686},
    {0.6819958657302023, 0.5900781504979051, 0.8225198190354343, 0.7381540546943488, -0.06428127632575857, 0.3973056454033647, 0.9325911223218822, 0.5665138686939944, 0.7632313831130878, 1.1355030991896145, 0.8849866488008004, 1.03696220912007, -0.05437019178583668, 1.1828748781180898, 1.1861661941929273, 0.5493141971260637, 0.5067662466556754, 0.4517750615613118, 0.8987453500012825, 0.5043273083767861, 1.0541568931339762, 0.9151490858135592, 1.0333994094540244, 0.011399709713244981, 0.04468780293020243, -0.2568909256265343, 0.38586604610568204, -0.2680784515101787, 0.17716602065054973, 1.301420799519261, 0.9112974614989601, 0.5917062144964331},
    {0.8426247123015776, 0.3553815748284655, 0.6828987583183352, 0.900952214123788, 0.09836912874026947, 0.4195651479674155, 0.9664300640197848, 0.525538322427577, 0.9556711852284302, 0.8690214383988909, 0.9531187326479502, 0.8304493861552047, -0.12453882872190042, 0.8010889813146499, 0.8705902351545044, 0.9731494367277297, 0.8941160817119993, 0.6524078173519215, 0.5973901037181358, 0.6669552567285167, 0.9247847950670247, 1.2269451215621137, 0.6677465951907736, -0.1867617448775304, 0.06549184836575943, 0.052390624695379764, 0.4824494631073353, 0.1052659427090709, 0.41613035382356756, 0.8873447067532821, 1.0734827967125344, 1.0736023660463534},
    {0.7669226640013922, 0.5720692993992968, 0.5828230849160686, 0.8574903146456286, 0.1638316692726457, 0.7876269184742766, 0.7150599798010217, 0.4158741264140185, 1.3081075356921166, 0.8281734446747224, 0.906723918578904, 1.1275541671113356, 0.0997143417160932, 1.0428537087333392, 0.9572674006037527, 0.6617413070263439, 1.2844024813779562, 0.7524220890876381, 1.0650955760469791, 0.8744373823058108, 0.9917342271680488, 0.8210559318791057, 0.9968995853652833, -0.02617382024193732, -0.04517127025122504, -0.22950757511029268, 0.30399105564400003, -0.09560993597624282, 0.4595898979805015, 1.0360125045665707, 1.0528276155211251, 0.9181513136993125},
    {0.8376669179300735, 0.7748846613041727, 1.056316426847206, 0.8954988088662352, -0.24802349009739116, 0.8159948632562549, 0.5976209503286833, 0.4155744582436337, 0.883154625990289, 0.6606654138681565, 0.4315024668082298, 0.7897318243809347, -0.019070442209772585, 1.164106783767236, 0.9060492724698931, 0.47374762338450765, 0.9227666045399068, 0.7100584793546351, 0.4943168029870853, 1.127250214607745, 0.7492723543035636, 0.8538806611814127, 0.9545197901877305, 0.07110936983967953, -0.2570055740881343, 0.27253789809990275, 0.34906138250864327, -0.35778772628415456, 0.4268043623112047, 0.9887661567528434, 0.6742076920177593, 0.9670348045627383},
    {0.8787781187538938, 0.4414141820590953, 0.6170782212539955, 0.7920018828863353, -0.06637324512774712, 0.9069352262871969, 0.9275002115658406, 0.3420582300608281, 0.7356262050138456, 0.8711165585246311, 0.8236941134585887, 0.7266228561025435, -0.15088726659424356, 0.6863684166466715, 0.8839563247401417, 0.6726396452315295, 0.6552804946203946, 0.9583318712871007, 0.8256085051497485, 0.8624442677853068, 1.0156086715909427, 0.8945831656138208, 1.0424877481091277, -0.2581155458555592, 0.0037584482889548073, -0.11350495388714783, 0.47992164636730894, -0.28988439691886275, 0.10952751783171755, 0.8986002580758797, 0.6600282702077596, 0.42071636686995084},
    {0.9027169032292476, 0.45876459038157374, 0.6582855737474327, 0.6051972961338183, 0.16794978036104455, 0.6752892613333141, 0.8457813760354235, 0.42120950666177676, 0.6711301039012197, 1.0702340634219125, 0.5231389394525608, 0.7710529087961717, 0.2153165075540949, 0.7196426950904851, 0.8819586310009364, 0.7288024555599819, 1.2528900988674216, 0.5518782874604368, 0.595482756425817, 0.9837764411233915, 0.9705695663397471, 0.7910203686687625, 0.9504349951049759, 0.1527824285673417, -0.0170010075967365, -0.18502483324957875, 0.20048550126316234, -0.20229891296840646, 0.3054101174237798, 1.130008267570661, 0.6949822355327583, 0.8334845623070507},
    {0.7951824930738971, 0.7627847976351505, 0.9853413405541261, 1.0708336598398855, 0.04945252321330259, 0.7895354599664299, 0.7338083707167036, 0.7698885083037759, 0.9573820294509889, 1.0823709573551643, 0.849206572963396, 0.746839525763575, 0.05616119983354105, 0.717072078120078, 0.6053764294127466, 0.554664162622144, 0.7459322527923795, 0.7791264160763626, 0.8031626953612039, 0.8877274419421888, 0.6905704724574031, 0.5826115179667084, 0.7483727532948817, -0.35094323698668656, 0.052327388504104906, 0.0077114295981146426, 0.5165356617543122, -0.1043415825036499, 0.43827232470775945, 0.6893031028838387, 1.0455572892139768, 0.9074680480129608},
    {0.8433652093756843, 0.48108024711062974, 0.8871065230856731, 0.9049313385886217, 0.06977757519931055, 0.8712473742388747, 0.7269422026078668, 0.31746487395687023, 0.8965494594868997, 0.9239984401978735, 0.7758834070185542, 0.803092862032376, 0.13248326486925044, 0.6967707381744227, 1.0729246928447362, 0.918686943487368, 0.6964891327423012, 0.6829674374726161, 0.550916562736493, 1.08222622885787, 0.7199009763094415, 1.0777127286505568, 0.818531869433959, 0.03157702959365869, -0.2514781755587684, -0.24734226699081394, 0.4271792321696065, 0.3910643891810581, 0.7912105779564039, 0.968912158308312, 0.7595871855242545, 0.574781950645144},
    {1.034832376170648, 0.41297189005085444, 0.744120800793248, 1.1739201887565096, -0.2508273417139352, 0.5847219792776754, 0.5114854967834199, 0.6393050416532201, 0.821561675507279, 0.6169744348487753, 0.8228208822691109, 0.4937788053553568, -0.23301000008822725, 0.828544164984783, 1.0640701224900937, 0.8746625451529265, 0.8490435182025701, 0.8345821967671089, 0.7634958946249679, 0.8439097757626183, 1.003987601601566, 1.0626347423678892, 1.0924907712196732, -0.1242685906094171, -0.17780938535434607, -0.0597085612878269, 0.18620191975723854, -0.1334870981718889, 0.334743223562023, 0.7304080001207206, 1.0316498399610796, 0.8908585408509683},
    {0.64160276960766, 0.45500386482274213, 0.9220155565643627, 0.9123249104149848, 0.15872882117919154, 0.7867403781829482, 0.6432563009771407, 0.5974398031029098, 0.9087550391617722, 0.8311811199425461, 0.8054311968801491, 0.6778422249516273, -0.07093085907239927, 0.5094402582206254, 0.8610056808610431, 0.5773727553103842, 0.7314201716130581, 0.9527930395432128, 0.5265943630729218, 1.011652136923363, 0.6496686264313235, 0.8835507542123532, 1.1677660144701638, 0.004196396514229629, 0.21307405568173815, 0.009104728033645553, 0.3378208034734892, -0.14296240546721511, 0.3619301884517249, 0.7504507700417246, 0.8957785995475415, 0.6654098791641947},
    {0.7268633944380819, 0.4929443739851818, 0.9243053288371841, 0.8425328080815871, -0.12969992637415564, 0.9380013379774517, 0.9146339375388033, 0.5327510878170487, 1.1981909284576828, 0.9914635084277607, 0.8743791752569976, 0.7918602211677332, -0.004810850922567596, 0.9133972402599821, 0.850272780999904, 0.7343729137232227, 0.8883271470224744, 0.8734669941583687, 0.905404796344606, 0.8022764811287779, 0.7322085566448724, 0.9430102261226931, 0.9237187214382316, -0.26821402668005634, -0.1850913530009159, -0.2358842039597145, 0.6436894971130138, -0.25297159700362437, 0.22819872322575993, 1.3738758336434231, 0.549073939995816, 0.8893590749773856},
    {1.0611124697226562, 0.39626073743593065, 0.9102088979681108, 0.8840248702594893, -0.17271345809882055, 0.47942484661804435, 0.9890176524347053, 0.8017511773378393, 0.9563553464304371, 0.31467558770496923, 0.6643374637315216, 0.6507813602172987, 0.0938429915534808, 0.8470092318192776, 0.6791580037771768, 0.6234147990265051, 0.9106423764018234, 0.5567215980780376, 0.5862958957064318, 0.6606094204752575, 0.671511070701822, 0.7113963682754977, 1.0186968581007554, 0.11558727619480709, -0.2076922782931478, -0.057141175457783175, 0.3087281324762279, -0.3080772643348683, 0.7657483553634942, 0.9911894565808179, 0.8297501608802712, 1.0184171966459346},
    {0.6756113540836225, 0.505009832159025, 0.9632256062768019, 1.0975514227638428, 0.026031833215713156, 0.40681888179128506, 0.7405413448252419, 0.302981577364039, 0.9335646753266259, 0.8633833446813826, 0.7266930570152661, 0.5993969766354269, -0.33571809938216335, 0.636900599575186, 0.7838611960390731, 0.5630831957545189, 0.9929417830233678, 0.6621429416304067, 0.470771478242439, 0.9400841260915759, 1.0550627715723269, 0.9694294729296837, 1.2900309169967448, -0.14881749077098974, -0.04744664062967149, -0.07543961827793406, 0.641949399665465, -0.036240190600276646, 0.38834274643625494, 0.7170283351270424, 0.7671208701063764, 0.8950378828544925},
    {1.142277102433073, 0.5433397132565562, 0.9423266614056922, 1.1475182384625884, 0.05604982679159072, 0.8189192477950556, 0.7668486219091993, 0.5615616139597875, 0.9627499252408495, 0.6174715806696294, 0.962894497586297, 1.0908856869209986, -0.015470983990113528, 1.1156014279035815, 1.0738320745709338, 0.41805893443896724, 0.7963141011528055, 0.9287218660903692, 0.4322503395347904, 1.0417260025388526, 0.7431005821622169, 0.9490470254239898, 0.8691311388696851, -0.11648951156427984, -0.021269897839352587, 0.04986651868466291, 0.20439180971031354, -0.34518439161704617, 0.6091638524914271, 0.40424280671718077, 0.7883642463240795, 0.6641429587822142},
    {0.9159835421390143, 0.4254804725507582, 0.8953834413022771, 1.0713625039939751, 0.03579087747109301, 0.8367064367334144, 0.8921818703075336, 0.3589059224578869, 0.9219838358170841, 0.7610317960140548, 0.704481432837879, 0.8834812899798237, -0.04424228657696657, 0.6726458425472548, 0.8088743522858547, 0.48088448885304136, 0.7660681075496015, 0.823627410659494, 0.5739363915815123, 1.0470136271173713, 0.9270625576251744, 0.8515223025603293, 0.9365346369861938, -0.020412562279471566, -0.16175007048042275, 0.00024983275152970697, 0.5442813724759022, -0.23196974176437893, 0.3616211126156352, 0.8945680643150229, 0.741265475561923, 0.8396016093395936},
    {0.9538291623976246, 0.1889043915183496, 0.9323036655638899, 0.8633872970570172, -0.037543137444516324, 0.6905770199993445, 0.7079915253990782, 0.4489765917637817, 0.9619723632352832, 0.7853303283528041, 0.6511906673003564, 0.872289859098976, -0.13305012256574617, 0.768107880446504, 0.5632703334400683, 0.9767064483937316, 0.7481158795947257, 0.9435687857877897, 0.8254806753480912, 0.6491685621759398, 1.213564625565148, 0.9987156341906549, 0.9229521397450822, -0.04665739744636717, 0.019190080888621498, 0.11791984807373737, -0.14698353291686786, -0.38504225139412557, 0.5457211853570356, 0.6406290396511726, 1.0818265075759057, 0.8259129222941728},
    {1.1767940211931263, 0.6467706329567257, 0.8809999889782982, 0.8211373811503424, 0.15198363429710363, 0.3324998896384401, 1.2088541682994913, 0.4717629804978436, 0.6240252106097733, 0.9170331445068716, 0.7579850706618523, 0.9329689762168342, -0.05496954387233451, 0.8975713113160081, 0.7674041808397742, 0.6006476641683208, 1.138449819170151, 0.9818326889345534, 0.7239750605094795, 0.7197284615177231, 0.835896525164609, 1.3169356694646623, 0.9127378214892675, 0.04157992456332559, -0.09082320344331343, -0.12333354970954782, 0.494438090155905, -0.17403064745282765, 0.4021688788143559, 1.0467600218855329, 0.5362335285434654, 0.9355801115086813},
    {0.8113301153911481, 0.7500044910526101, 0.8525277992071922, 0.8641194938144833, -0.08883665469436641, 1.1038230548913355, 1.0256870778625349, 0.44063662350582516, 0.9204641947536366, 0.4226498271235441, 0.9225153165846174, 0.9586861065994385, -0.08983057639694637, 0.6968894532792766, 0.798870968785249, 0.5562284644887904, 0.6103582669120065, 0.9569174988514095, 0.9133818862454187, 0.9456408956905918, 0.7943266796388027, 0.5382873412131416, 1.1797304988492343, -0.17631987006767813, -0.22646251666569056, -0.2608845121803803, 0.2321322335015345, 0.030427956468412187, 0.6875723065708614, 0.6547792290196913, 0.9144619786448436, 1.0184303124520182},
    {0.7491509413617312, 0.4793516425124233, 0.7955277042676108, 0.740927882583094, -0.13002690236555264, 0.9169608091554048, 0.5350349422584332, 0.583713975073763, 1.207660533952468, 0.7641527709236898, 0.7263178755901968, 0.8927734588379561, -0.11029919805425793, 0.8132285747816936, 1.0405873837160022, 0.5568173570408795, 0.8115104576892433, 0.8774789646373491, 0.9783008847348332, 0.9564419344346933, 1.0101377869265984, 1.163756796850983, 1.1264319644043734, -0.36471910599748575, -0.169496896002824, -0.027584168468695436, 0.2851937558206166, -0.010274762410903531, 0.5380242425844739, 0.8877751385498294, 1.2724893479807984, 0.9559935873796899},
    {0.6139947621477535, 0.17590850985930725, 0.9972924218808328, 1.030443307937327, -0.004098878539198988, 0.6250675903517207, 1.1338556424703015, 0.4454736003029871, 1.009180646237164, 0.7993434877904407, 0.7626746504527474, 0.7968849530060503, -0.07495964974225142, 0.8196823252432135, 0.7327780262260767, 0.7933890383943757, 1.0713401336965058, 0.7962896634552523, 0.811846906415581, 1.2216208123291217, 1.0603125237442852, 0.42242726870497066, 0.7491802525947253, 0.012116294541353469, -0.12009870366658582, 0.025210096707126525, 0.46467942064122875, -0.07661656638051988, 0.8192554721172735, 0.7350152139160142, 0.6785289254825333, 0.6828832964424367}
};

static const float b2[32] = {0.8320928446226653, 0.5148779428625908, 0.8204871446590463, 0.8262493394121403, 0.0992800415724455, 0.7448989240610275, 0.8138830933486205, 0.5492568823896636, 0.8644552507937677, 0.8006149064266513, 0.7344690708219215, 0.8098640166428029, -0.10698949991261744, 0.8162119648010161, 0.8177698149392246, 0.6603653063311334, 0.8434760226036336, 0.7842070216399796, 0.689138644643079, 0.8454500171823564, 0.8180075175635549, 0.8398892540932072, 0.8080220128378199, -0.11079843192462445, -0.10891741655542893, -0.09145443631856291, 0.4444046004386205, -0.10381785170425559, 0.466849105606921, 0.8503635560390601, 0.7923489803326204, 0.879742844035586};

static const float w3[32][16] = {
    {-0.30704107007599757, 0.013313425106993236, 1.1186428821334786, 0.6010836462206626, 0.9965026857195285, 0.5467779663516834, 0.5821735142600588, 0.7952726675232962, 0.9674553067502695, 0.8985501846392256, 0.7692064303043714, 0.14092595743255315, 0.724742904051488, 1.026925461655408, -0.23665691041737968, 0.037812079535217286},
    {0.15584006201119258, -0.2716011917077438, 0.787504784382159, 0.8006584754246027, 0.7640941675867768, 0.2681050307517964, 0.4741053370890419, 0.9219690133249405, 0.7359315466871466, 0.30877249687242403, 0.36719219462200414, 0.1153211551366347, 0.23188263903021605, 0.8555911554146004, -0.22434282218880391, 0.27160017751515647},
    {0.1605708670338074, -0.19089232393920255, 0.5515001389651218, 0.9859880893222948, 0.9974756391519656, 1.3827476157571297, 0.7790886486331609, 0.7028353672115154, 1.4507465135250839, 1.1639501318409773, 1.1568501976641643, -0.27703813819533146, 0.49476621010474614, 1.2771055732516272, -0.25804298139685816, -0.016848710405658544},
    {-0.41055325777619056, 0.07834043632113574, 0.8662050479468659, 0.7427720955198327, 0.7044828982527688, 1.4374796996682961, 0.7666697907190855, 1.0366482185569939, 1.0377015225627066, 1.3632447036661761, 0.9247944158864129, -0.12375484381977109, 1.3317633448951225, 1.1239635640717556, 0.0405331521133603, 0.13221282339968574},
    {-0.43412096393240307, 0.21029990172858898, 0.44536585011112706, -0.024957751130766776, 0.36394541119114776, 0.14080826264987759, -0.10264193956336115, 0.6831095415768095, -0.2221159009106983, 0.12207389350246783, 0.16227053360153598, -0.023672071292136714, 0.25018871163042644, 0.5966208760651935, 0.3206686000191539, -0.29096718196358085},
    {-0.14232027876999975, 0.16834824813842808, 0.6989350143016779, 1.0266135445019875, 1.287690448677924, 0.6277710965188273, 0.6988192663164811, 0.6734335843062166, 1.176632106471626, 0.4955730834619908, 0.7099220047786367, 0.21685659735326962, 0.5824807084841155, 0.8697686671982927, -0.20564715833828293, 0.24895766913110645},
    {-0.07155614494920902, -0.09805709205215758, 0.593868886651929, 1.3147849948469579, 1.2599727871315312, 0.6367688637843416, 1.0993818186182664, 1.213045326013678, 0.903503533111639, 0.8527909137065194, 0.8044944372983411, 0.19269912152625304, 0.9847787805532171, 0.9408089963586006, 0.37086928717857154, -0.012706824378259806},
    {0.1945613331045172, 0.2748720682634033, 0.7437029431745589, 0.9971293585678529, 0.8704908200452357, 0.5025544443424039, 0.131331566472752, 0.9413345297156177, 0.7801964191950556, 0.2573813158471036, 0.761696698871182, 0.09710053910882079, 0.3756000609419722, 0.7288899539424522, -0.42530307919843385, -0.05628585563536828},
    {-0.1458685189150481, -0.24479989680451616, 0.6643494304279324, 1.1199111886540953, 1.13442255399091, 0.18201362424065504, 1.1414032495586957, 0.9805910201893504, 0.9779742013174698, 0.6078430567497296, 0.7783368035644034, 0.21069524214497437, 1.0677923185224354, 1.1041157160660369, -0.1015473508472143, -0.41581343524573766},
    {0.05940312839452797, -0.018302401643293366, 0.7781703978496816, 1.2180281530350123, 0.8123156967639305, 0.5449889631425536, 0.8778964551689497, 0.8429053922946549, 1.2919023019697065, 0.9836666086436352, 0.8951416199728507, 0.582671814640317, 0.9452832675496264, 0.6698750155334824, -0.43778111172941936, 0.22591837463203734},
    {0.20755623138768173, 0.27125460869074575, 0.7401666749359205, 0.9297875020053051, 0.7386452422665072, 0.6693899479502221, 1.199943435296799, 0.6347280351398641, 1.3940755247934005, 0.2680480713476156, 0.7612902055761326, 0.06729304115414547, 0.8008118237848405, 0.834332569643074, -0.29906207743105756, -0.006364010476625447},
    {-0.04996788177595318, -0.42821121162218423, 0.45675479207391234, 1.0190337338063464, 0.7121247161083805, 0.928831833784988, 0.5198700799286335, 1.0080877503890524, 0.9498280636425744, 1.0195864257700207, 0.589046685852161, -0.7885194479340367, 0.5719282485702752, 0.8397016837466743, -0.01739793690188939, 0.21230087147897178},
    {0.21387976487962476, 0.06784258233099211, -0.030843299621748477, -0.20771150627917098, -0.022349792990557612, -0.49732038924212635, 0.034196476393693526, 0.46366847835533787, -0.11138842340453128, -0.188570919088143, -0.3420207300796371, -0.0806748377863715, 0.12678684340335622, -0.12678023770287614, -0.07555860420069484, -0.3393069858923884},
    {-0.02065540512977305, -0.004202100667353744, 1.1734018273468576, 0.6772146899112265, 0.7445249572554857, 0.6662433699574539, 1.2435720993858321, 1.1129839804720283, 0.7000502730795062, 0.8515973829542726, 0.9994841523731246, -0.0365106828589407, 0.9934788183290563, 1.1435629581367313, -0.2749378130385485, 0.04027662476034583},
    {0.5068112650486796, -0.38465138004581034, 1.022845533034161, 1.270826500349651, 0.8323889132502237, 0.9910419179547593, 0.5797146425204823, 1.016209228530057, 0.9107109319903535, 1.3346825568035723, 0.8644627888843026, 0.009584901663579365, 1.314627856715213, 1.1178586004439683, -0.26440459217314066, -0.355255151264439},
    {0.32328664915739863, -0.20253789555077997, 0.8193314293996823, 1.0769910683088941, 0.8995038798807065, 1.4489849191663915, 0.6790382233597674, 0.7005651599692794, 0.3776049197103501, 0.6668661872212465, 0.6150074492440252, -0.1493532178608677, 0.7787733685005995, 0.5124933387507304, 0.043086352682497706, 0.12406291475044953},
    {-0.19971203443285238, 0.27666774532118005, 1.140304233141528, 1.429701934952432, 0.7810104825003747, 0.7221593326805061, 0.6002454487019662, 0.8439363901318142, 1.0554315112612067, 1.0666217362463921, 0.6724888090325266, 0.6337645689385638, 1.1280838402158928, 0.6589698322674931, -0.04431798773171908, -0.09987482311322314},
    {-0.11292305453969288, -0.07674286766616097, 0.7660007631963438, 0.8960611681603363, 1.3165691575823613, 0.7990300068688738, 0.705507819538889, 1.2310254207442148, 0.7401654612677364, 0.8082930451241679, 1.2722895844676605, -0.08863827349155061, 1.076277034420185, 1.257306145453614, -0.015916025205689154, -0.4132882490834836},
    {0.13030346036178198, 0.2776765778868328, 0.6768105323555007, 0.6054124944751563, 0.8989457364060232, 0.4720825574511602, 0.9636151393904482, 0.8544543752785811, 0.913595091874842, 1.1159181245828873, 0.9144014390151577, -0.024683206308421888, 0.6930741985731899, 0.7889489667531867, 0.2929668749622503, -0.07258555698558772},
    {-0.3047650030867764, -0.3809684231140595, 0.9425680391880161, 1.2158877262292276, 0.8822104096562559, 0.8848762128866027, 0.8467467884301667, 1.3864584530728212, 1.1920870818386666, 0.9185372589363524, 0.8294929821531717, 0.11972951079482043, 0.5844580902715382, 0.758303265950266, -0.18508423375615626, 0.011596702096795575},
    {-0.2519716143519553, -0.08155087450209406, 0.7554112466520465, 0.49805028762383635, 0.9084393438620155, 0.9591840917730573, 0.657022731621256, 0.947205505453397, 1.1261358135458284, 0.6495327076649137, 1.0306460525178647, -0.47251142606588825, 0.9603886864901514, 1.3277766910234527, -0.027315458435155406, -0.058333808807884385},
    {-0.2800606765894667, 0.07753137136776647, 0.8073087609290864, 0.9141431244411441, 0.6909976258307807, 0.7777993814777987, 0.9721445849932893, 1.0967265461406075, 1.2301455811828024, 1.1666909072903804, 0.7006252394211754, -0.18280395406079158, 1.2257117002200681, 0.8578494382480849, 0.07991632886659603, -0.2919736243177444},
    {0.02912661609224773, 0.12317688596103524, 1.1324116489632408, 1.4508812556102089, 1.2159357800251007, 0.505470582248157, 1.0203604414087262, 0.9566879150864342, 1.0588612297502018, 0.8650294088402551, 0.8909263772218827, -0.24398481348442833, 1.0035640624929303, 1.112288306418173, 0.1963301266272485, -0.3834517023901643},
    {0.014977953047012825, -0.1821324204737041, -0.2593172757055343, -0.33839611837863703, -0.36873690856616187, 0.05727997132322077, -0.19653468142720135, 0.023115664313747036, -0.04329499178868686, -0.05574114999259795, 0.33903461439641064, -0.4041116008935439, -0.43653969813449495, -0.10311850951029736, -0.13271061974813614, -0.0011344971172696813},
    {-0.3743616848897057, 0.36013449741174336, 0.06829940442648408, -0.20418882566219732, 0.013689454548814428, -0.08145237609900612, -0.20612418330066945, -0.2805145343229555, -0.005519693818268352, 0.3398376057696736, 0.0713351044665106, 0.08811524121805352, -0.3812065227814118, -0.2808461096921777, -0.266112158016567, -0.27664117490832857},
    {0.14157025154032324, 0.00807737772202423, -0.36183712119275807, -0.4287076848859331, 0.04281351934224059, -0.08703706500683688, 0.18987352265538537, 0.22702910807433357, 0.0008777980703103447, 0.5518618651512713, -0.1993060339814967, 0.04485789237204626, -0.23231284762275992, -0.4638477377195381, -0.03876399094258152, -0.27842798302971317},
    {0.4391148762592441, -0.16157665151528067, 0.3674275769499297, 0.4557576433544116, 0.8227776934413298, 0.37592657328317053, 0.20647124858785054, 0.9053478011934308, 0.6990289138184029, 0.2440381520377058, 0.527856170213129, -0.1272834284851646, 0.6176916986276665, 0.3913887760088752, -0.0070987637279284616, -0.003446711578947676},
    {0.0721882027381952, 0.0825524873811048, 0.022166152736037077, -0.18116048440538185, 0.040622434971311044, 0.13185332703718297, -0.25398111866469636, 0.06747617762934105, -0.4626766288756687, -0.14565829925757173, -0.3303753709265677, -0.05427222861203107, -0.15266953466324146, 0.06292327034557864, 0.13289873103802138, 0.4110935409642294},
    {-0.1666442765676368, -0.04446520515126269, 0.3700862355614722, 1.0168601582174486, 0.8746417120421407, 0.7551005130966031, 0.5137095667884188, 0.5542637475774912, 0.5650213622384795, 0.6423676158732033, 0.6048310428994818, -0.16822443437077514, 0.37517928160218705, 0.4719710096404567, 0.07581390337697379, 0.26199259185996354},
    {0.03859315227438578, 0.2611707520158806, 0.9157367464063011, 1.2269989680145164, 0.9309984452038239, 0.8614789982201316, 0.6158075569043852, 0.8075315925547978, 1.3221668766887782, 0.7037315231992813, 0.5153324168726284, -0.7621408124846238, 0.8436580145373734, 1.1775495725805123, 0.1451479955709651, -0.015704924292752432},
    {0.2807860181033992, 0.2061879828507069, 0.9264438770346218, 1.2746255419436365, 1.5237688988853175, 1.1489340297477455, 1.0978413615506735, 0.836391658154789, 1.1868838290478487, 0.6878611404655901, 0.9846693033962031, -0.2666001636683909, 0.9353609611431151, 1.032674814987444, 0.052309411878986245, 0.09780755525825159},
    {-0.41418623145903355, 0.041419915012232786, 0.939034596742561, 1.035228465683598, 1.204810958041041, 0.4705876642112403, 0.8189722678187664, 1.3419564897478378, 0.4997889273853256, 1.4880806997780711, 0.583850338030825, 0.2228279884865513, 0.6623735969768412, 1.1015388963051134, 0.07018663204198627, 0.006335366320423763}
};

static const float b3[16] = {-0.04404506663026351, 0.004642725251074792, 0.669335007920312, 0.6314327306917819, 0.5987409558792349, 0.5400815317841287, 0.623112938916034, 0.5971784637303936, 0.5679672806609495, 0.6058932288650289, 0.6273896622330171, -0.020143534839028497, 0.6597535683108449, 0.5965860052051422, -0.065962503439858, 0.007466941823870569};

static const float w4[16][12] = {
    {0.27890168587737857, 0.14955205767130003, 1.011916507011403, 0.6962522492131453, -0.7917185386695788, -0.05089859350407461, -0.04933385497329139, 0.043991739279977654, 0.8131620909350065, 0.3975431335514848, -0.5472882473455906, -0.17290766766034546},
    {0.3977959268176557, 0.19809639516377295, -0.058523990841237175, 0.12858017717815082, -0.11827894535029032, -0.7904683299790065, 0.11424822972982537, -0.2489474828936741, -0.17863865804616322, -0.19547960473028922, -0.10444266043471347, -0.2838155817642381},
    {-0.959054197105795, -0.8491484155952032, -0.20547501785331057, -0.8854035442992277, -1.0066981870046592, -1.2500735161067236, -0.5928860743084072, -1.1827310433618727, -0.7955713215837357, -0.844602477948482, -0.658283065988089, -0.5086183258863428},
    {-1.2519370056753805, -1.0008858557534206, -0.6238864672537677, -0.9222738717782176, -0.13999192205030636, -0.9805919896577202, -0.9710204178977048, -0.05525761738382507, -1.0035258015885349, -0.4193631951579636, -1.3380485996176052, -0.8856456085812418},
    {-1.1335292768019876, -0.9933403241636253, -1.0535014486606922, -1.2181233172141224, -0.6380439282742016, -0.8077953695091218, 0.023004661552733043, -1.141774964075073, -0.8286178505863085, -0.003696757406341286, -0.8888840298058448, -0.574176770984802},
    {-0.15728720224301979, -0.5868114141217575, -1.3509104543629016, -0.7491695388011804, -0.8991442657306788, -0.9297634858969419, -0.844055088661001, -0.7818343912093856, -0.38982341576871266, -0.5810560668513386, -0.8850817437216342, -0.5679447064996241},
    {-0.510457070808009, -1.1877038074667183, -0.15130853014600298, -1.1884496945903016, -1.3790035359748225, -0.5223192599242648, -1.2360765514579832, -0.020692710865844663, -0.5497768263053109, -0.6601335593241263, -0.617522027296882, -0.7702432538075646},
    {-0.9762270426505881, -0.6112209448956928, -0.532569649901963, 0.0271008424899175, -0.8350565193064682, -0.748042015478719, -0.8650493308303727, -1.1914210997844599, -1.2872056858739562, -1.1204754161263748, -0.08838949846114454, -0.9028336920913732},
    {0.009549493978513892, -0.515179168599863, -1.3216889602665836, -1.0982540954931654, -1.1751143078490434, -0.8971261419857958, -0.724026971269422, -0.4863392448048135, -0.29923670931816154, -0.9664023960595648, -0.581027170281827, -1.2057538235387188},
    {-1.1938469632498534, -0.1772016458775225, -0.3211953310661059, -1.712421500697961, -0.5329628933848739, -1.1676163628888676, -1.0444332366577784, -0.898616932151901, -0.579838199860674, -0.9181424831371909, -0.9085736092732841, -0.7449768792127166},
    {-0.8509349014264624, -0.7676940504880828, -0.9362554290044842, -0.46509358907302706, -0.1801278631074027, -0.2355018851299636, -0.8398217269654024, -0.9294240673476485, -1.3354916682736317, -0.7974209277052877, -0.6344205352547923, -0.944279505468726},
    {0.2850817704335913, 0.4175649064999125, 0.32600543771170865, 0.6229582457460344, 0.12473219137185752, -0.3456495941728731, 0.24491716587077475, -0.3418058600944946, -0.3603161858046577, 0.42094179466400494, 0.2166539899267309, 0.10902176993390954},
    {-0.6089400799583505, -1.0527258434475355, -1.039839952443569, -0.35702130624566625, -0.7446208893026288, -0.6250583401724227, -0.8025589408887633, -0.7981330704220637, -0.18884235552098808, -1.49363918998288, -1.0953326423842895, -0.8218193571489898},
    {-0.8939196150674897, -0.797820176200738, -1.0103480864983223, -0.07210372739821042, -1.1278246273733674, -0.4183513386049437, -0.7857903094982583, -1.1316757474198709, -1.2345175904369738, -0.8503372531948109, -0.8987515077509652, -0.5991751859553144},
    {0.19330743591997848, 0.3077085801913467, -0.26772964996025056, -0.1793525879776454, 0.19200840357616056, 0.3856603962353069, 0.447428422633502, 0.2004777896899077, -0.3346800476625901, 0.15270711116251412, -0.051201440174393535, 0.8757367989766008},
    {-0.22460780552428516, 0.5465333209242554, -0.17630076719501167, -0.3025739637569956, 0.28188069195171866, -0.18205611187041068, -0.08008239124633094, 0.0646183436534695, 0.125636563152047, -0.4785039139841564, -0.3815764124095987, 0.14514032618120082}
};

static const float b4[12] = {-0.2713870944281864, -0.2230077913835785, -0.3799576839854662, -0.29771678204252117, -0.3582183595343811, -0.25988140320400976, -0.22707796075061237, -0.2617919162237332, -0.2875325645281818, -0.31370391496433325, -0.21812358589323214, -0.388259589093462};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
