#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.7031349877140505, -0.44576651427683056, -0.2737275726204029, -0.784975862126413, 1.110957296994532, 0.9311664861485982, 0.5954788428309754, -1.2039784211532965, 0.8195029645699251, 1.5774760070085143, 1.5867153767759856, 1.8530397196359327, 1.293463322582463, 0.8288132205954006, -1.0138308218780727, 1.4477622387214475},
    {0.7815586796222118, -0.9880416007524374, -0.06078232188730884, 1.21411657750757, -0.6128473805586634, -1.5674464433497113, -0.005972237222023952, 0.39208169931466463, -0.20370199748315374, -0.08390359310372567, -1.4536662996614738, -0.5443650813423381, -1.5639651226980151, -0.7473009974317106, 0.8332210298517562, -1.3943807490805298},
    {-1.0559664724016344, 0.14043952676312185, 0.8843763163232153, 0.8096328762056372, -0.7191660908171951, 0.7680913565715243, -1.0549491988012232, 0.2574237072083278, -1.1592345583387844, 0.3062505613863534, -0.3610954760000656, 0.017226697651382634, -1.0694450281504155, -0.25986080102890324, 2.0648694031356314, -0.88453213741622},
    {-0.9340460567512494, -1.2275418562393186, -0.6443003427673877, -0.038705123310213446, -0.8710406498965476, 0.4317936217807824, -2.2449072938885277, -0.8246265019320822, -1.6222466788798537, -0.7055761709294588, -0.31535440368011014, -0.4353387661922421, -1.0312933181172756, -1.3132114890844269, -0.7356629444906547, -1.3315755908983427},
    {0.8817651660111802, -0.16278408804330927, -0.36919185269668015, -0.7256932101977656, -1.6990495264176406, 1.3929432100814754, -0.28743575203623617, -0.7662972760331817, -1.2189351786477927, -1.1505288913480527, -0.19131849255883346, -1.1334883240440228, -0.2775740451108036, 0.4516565010964265, 0.5173577641694473, -1.3291623976425937},
    {1.2817206891505215, 0.982795519717543, 1.1560610474421604, 1.5867739124357954, -1.2694715896209827, 0.6559736931510175, -0.018727938158320964, -0.12088132520567009, -0.8743793625774448, -0.38751260190111486, 0.1358652444372873, -0.13438846835027696, 1.1767596268255627, 0.5385502762064107, 0.884246458750821, -0.10907847059330612},
    {0.051076733801571475, -1.032564628732048, 1.5169405751731322, 0.7777646050869002, -1.5999679685869461, 0.9529515598475921, -0.21035860025347922, -0.022584534534461843, -0.9914514666360978, -0.6484814984127394, -0.8419020594891462, -0.09845679523699737, 0.9367641956449606, -0.21877513405043036, -0.2034015763937745, -0.7607324035663311},
    {0.8380473529400148, -0.7666372527701245, -0.460739968076291, 0.2523518719964202, -1.0144515754340278, 0.6629276164028842, -0.017425330639303287, -0.3020218275290925, -0.43593388209088835, -0.9345261128810943, -0.16903631351069745, -0.08195053969101912, -0.7536663983721865, 0.6184792664639022, 0.45671997471252157, -1.1379909164610533},
    {0.8128474398933719, -1.7438307422938388, 0.13000774788680414, 0.42248535673131143, -1.0086602862707916, 0.9337526406367449, -0.8569777152556014, 0.7603302922597769, -1.0036726114044847, -0.9558624088095996, -1.0297032480323345, -0.35259970575271254, -1.7249139857393496, 0.9760622373083089, -0.037667888876124184, -0.5148921089012304},
    {0.8011312499630981, -0.7579248076003152, 0.23572569196151472, 1.0368623115710385, -0.1814943904736239, -0.6571599838430833, 1.5430201114790072, 1.63878617532322, 0.919903088939664, 0.8831015420550724, -0.6382672605082473, -0.014937471340480433, 0.18854105003286611, -0.08421282381470734, -0.4241530672589113, -0.20082100637421255},
    {0.26835817996715644, -0.0859806471531158, -0.42601468628090533, -0.3421753883217338, -0.8064654168281956, -0.0279417032893196, 1.185696118047798, 0.6472448386347704, -0.0683345510218097, -0.6853027015345087, 0.15459743212563246, 0.26663848783660776, 0.6241333303066569, 0.4312386046681685, -0.7503807254305321, -0.4772887743134817},
    {-0.1828527151517746, -1.5831050177626722, 0.325460587386821, 0.05548854151985126, -0.35063676162568647, 0.031214367216381225, -1.2234424014436385, 0.20567002464387507, -1.2220501822904895, 0.8233338533413558, -1.690508527414243, -0.4999444119103358, -0.5761396181300914, -1.2645329547989068, 0.2776960378452906, -0.38365390551865597},
    {-0.6206590721568054, -0.018222166589614685, 1.190339907439106, 0.18901892859033784, -0.05477929653858326, -0.2359926346538224, 1.1596088247761636, 1.2562872688670301, 0.7977624691550439, -0.004038690009270316, -1.262955532759958, -0.31706221798063555, 0.363163661957093, 1.199368870756114, 0.7848001577549392, 0.44473285295727116},
    {-0.262108736399874, -0.014215985387262825, -0.23893461423723114, 0.9872955705815741, 0.8518216508332215, 0.050784880773078536, -0.0369705075803913, 0.2938716658391986, -1.021040545727531, -0.455726416640709, 0.022569349796229796, 0.7900633356662123, 1.2360412499587976, -0.5846792385963694, -0.6637680024913369, -0.568754502767615},
    {0.05086721668506958, 1.291038740090689, 1.4177807935864206, -0.19737114808283607, 1.3687881395917088, 0.677870617647063, -1.3019176732847666, -0.7753290308408225, -0.2794540981566568, -0.9001336111966733, 0.634504597491761, 1.6456799333840966, 1.839709028890737, 0.9628874334591173, -0.35655064319609764, 1.3128147666390129},
    {0.10716701162107435, -0.11739109986776262, 0.7856573435090073, 1.018379412546167, 1.566418091004504, -0.34735737077208667, -0.14834035050682853, 0.839303685847606, 0.3579073389447431, -1.377955560196863, -1.1199355045209687, 0.3785740804813688, 0.5985646560435313, 0.5548573215588574, 0.13492182815560483, 1.0618364083257859},
    {0.5126087212670674, 0.891472758741895, 0.014130800485537576, 0.9962755765229102, 0.6257708805062593, 0.0788770279668974, -0.09170871891466051, 0.1155878077119311, -0.19429515114111504, -0.8182477747319827, 0.5259313576892567, 1.3818078654682966, 1.1180740614377056, 0.15680903732649154, -0.9035932567715449, 0.49540370086934277},
    {-0.012904840103059912, -0.047228106751710325, 0.35356980025497897, 0.5197221756621764, 0.30959376204869116, 0.13817506780816538, -0.11330053227254253, 0.2349718384233497, -0.4335725474477366, -0.009980357219175834, 0.014104505592887595, 0.5411855385047567, 0.5554949948952305, -0.5193985665721897, -0.6011203152272101, 0.4448952829634133},
    {-0.5046288052531365, -0.06500395733437803, 0.006223920094860783, -0.08151686077063963, 0.16900198349740367, -0.06914074270186782, -0.014259300749960273, -0.6024502043681949, -1.0083617470511261, -0.573204039933903, -0.44057605543911926, -0.03367388051799678, -0.9143289894398908, -8.114183411743893e-05, 0.16634492197832523, -0.15956405325026787},
    {-0.008470060837147911, 0.3784109340739286, 0.06847625804791314, -0.22476243832695203, 0.7242369600188034, 0.10624490552036507, 0.22487978319483573, -0.6545079382747165, 0.38996953530478884, 1.0343034235398045, 0.5254946665511103, 1.3443287558193486, -0.28031024528156684, -0.4390923147684994, -0.6536964586476882, -0.21619038782430613},
    {-0.20369582537802589, 0.054095665861515235, -0.6493875587778007, -0.4574641911084403, 0.11076302546055812, 0.16964137802338825, -1.4703006515306547, -0.8244314130081769, -0.16347826305916524, -0.7888109517842176, 0.4955147698587281, 0.8926221713293104, -0.12847511445407883, -0.695395167063936, -0.4178806295336353, -0.5492642132049839},
    {0.474501449329264, 0.7400771045797943, -0.5820215865279686, -0.48957152583646407, 0.8577605771424311, 0.07479094866481371, 0.532593635177329, -0.96056188903785, 0.17478079745678773, -1.0039062535196257, 0.7635713001139722, 0.5978391559913623, 1.2017519875387999, -1.0479300013132795, -1.532008576933633, -0.6551554625779473},
    {-1.0069617680035907, 1.1978799743282942, -0.26599081505407474, 0.2859775873302569, 1.1416141436705474, 0.02504661036796449, -0.9729503233813321, -0.24020333253062848, -0.014661695417777905, -0.8059191528032349, 0.1870783356962599, 0.7577059396501554, 0.4873861115089275, -1.087193735819074, 0.35473918796392406, -0.836997159288769},
    {0.5272305961602817, 1.4270628347134933, -0.7583071470665594, -1.0854585746774434, 0.23021054691443893, -0.5813337982612934, 0.7380905695950932, -1.062114673603749, 0.9068659064616412, -0.3863113625544163, 0.547514034860811, 0.27490652023156986, -0.17960186624002752, -1.6800304063235032, -0.28159931870258853, -1.1486617037227376},
    {-0.19564178142083874, 0.7715518672225705, -0.5878901537833051, -0.21206317371190841, 0.6575287033156211, 0.2193705406443406, 0.6736354890445101, -0.9213463100090208, 0.5017054609304594, 1.121811670611796, 1.2178079105016137, 1.0567331842823577, 1.0373377208594512, -0.7187306362279187, -0.1833763503348363, -0.20259167033288025},
    {-0.7053818138205104, 0.4551970379434318, -0.7863065099742701, -0.3993288278614616, 0.9485956491816038, -0.11681209018319999, 0.32509279723741935, -0.997299672688086, 1.1144105376067774, 1.499759517582924, 1.2507081490420249, 1.0731814893871636, -0.7102613918469091, -0.5520453023085691, -0.218228625909013, -0.08245130334584558},
    {-0.3013249774450207, 0.3630774874945616, -0.3450291484650059, -1.493946262129924, 0.7617740856581418, -0.5949813134963975, 0.08987791323212142, -0.33955132172325264, 0.7993014310671239, 0.4974640640880493, 0.8150360230158122, 0.4845228440802872, 0.2442038788027623, -1.596708343482118, -1.3421795252148616, 0.14690544222743565},
    {-0.6365338971427839, 0.507189365666925, 0.39144104291908166, -0.8605185248259927, -0.08336226734856349, -0.4585581918498128, 0.2521947387388326, -0.8229313157045911, 0.7543064129559008, -0.3312294135733308, 0.067620383824791, -0.6500948369541882, -0.6851731437326866, -0.8569512588163778, 0.24975439774026478, -1.0023436356401356},
    {-0.2912482533483188, 0.6999218730174326, -0.8547595273718996, -0.30440706157897646, -0.23792679680063208, -0.7183854263187975, -0.45099525029780185, -0.8906803789428976, -0.34736776638475153, 0.21907497419063168, 0.6497830353709902, 0.16087679205625344, 0.10361966034460497, -1.6705329666537165, -0.5502872056917628, -0.8066720240047226},
    {-0.5605479791753464, 0.14714357582770826, -0.41777834183711243, -0.758021859230181, -0.3484374163798678, 0.02423129113226739, -0.2728876235543471, -0.6081952377230327, -0.9938288165495525, -0.8973552833975111, -0.16914172210047318, -0.755130614265436, 0.11411660280920331, -0.35448038378305724, 0.12660074157472176, -0.748575603955453},
    {-0.45254881504729555, 1.4933479258522508, 0.1068612477120364, 0.24672303919033142, 1.504641721386961, -0.5076608031739687, 1.2691650846978817, -1.3198640505517623, 1.3659634746496037, 1.3975369626831693, 1.4080344286245243, 1.6419528158467678, 1.4968560657625998, 1.0442190565951575, -0.9955195106151286, 1.3602573794505277},
    {-1.08115238690128, 0.8224052044787001, -0.0493112674552916, 0.19093746052057095, 1.5528963087898826, 0.15047987458372622, 1.3393323196018627, -0.2560381222988179, 1.7101823087282402, 1.4375306984353624, 1.5808721715263043, 1.8724328715737486, 0.7246362679112245, 1.1943916340294438, -0.38714212983276264, 1.6446147508651332},
    {-0.6998394959555976, 1.2990273644922163, 0.030268463113711726, 0.662666255730611, 1.252369442292209, 0.4080066949731447, 1.3840347429721, 0.527332093426202, 2.022305574437147, 1.8889577662034238, 1.7363230595139325, 1.7587787366551582, 1.1402355245874813, 0.9026537113648994, 0.3884831677764644, 1.2857253854178812},
    {-0.7110472590149742, 1.283034149007286, 0.45797263349113104, 0.49097044791215116, 1.4652707624354577, -0.11442611990071427, 1.0138277362055415, -0.0013107942671963942, 1.654425920504817, 1.3575079020668679, 1.8083493563962463, 1.657439845331558, 0.8578411324301843, 0.732183730808583, 0.42837480474712636, 1.4523511542968328},
    {-0.11521838187531319, 0.9461697635087919, 0.1611063367986355, 0.6221702663432418, 1.4508700350057309, -0.03979681611760052, 0.8867224887423063, -0.6700729530926772, 1.7681792203821076, 1.1136311700737462, 1.3047472077403832, 1.6416650677430273, 0.6889765734231346, 0.8854203856108515, -0.034627590519281985, 1.6997568658716995},
    {-0.4613796487613304, 0.4650801632110233, -0.041702920633693526, 0.2903055261572613, 0.4709660003402602, 0.0428875475182768, 0.6112465119772393, 0.03365570551764098, 0.838372494534948, 0.745714413433595, 0.8762075885802971, 0.6276213049429901, 0.7098292064404652, 0.7084836745665681, -0.017126202951004175, 0.502422729357383},
    {-0.5491059875338339, 0.3152457422845752, 0.20738776739149073, 0.034915907313080224, 0.3486525839573779, 0.04276091988972035, 0.37666219773860793, 0.16308834198592906, 0.28720986995756137, 0.6941433742755999, 0.5126410490157794, 0.5293199745706832, 0.271774709769329, -0.11937579204245678, -0.11294119945861132, 0.7887249696903621},
    {-0.4835603178205359, 0.2545442611944206, 0.33697493944458035, -0.1389416151916546, 0.18971998469506432, 0.12624174023489484, 0.07347703423503017, -0.1665566178574386, 0.6056398784710937, 0.019669232078661256, 0.6603879223410711, -0.27089007784696295, 0.7585727378919288, -0.3195097608185238, 0.3232761517125884, 0.4471414035987793},
    {-0.5771919031096914, 0.7354950844476731, 0.03935804996394364, 0.12665221576465355, 0.9180183524913325, 0.06230326174743277, 0.5535636459545153, -0.26691961243390666, 1.1527599464889977, 0.35228296490029015, 0.49740013001282046, 1.0375598941491586, 0.3932099642278219, 0.5201757369366199, -0.1154924250662282, 1.0196367181173993},
    {-0.09168500454124484, -0.3695509549675664, -0.1128977766794134, -0.048594554869397344, -0.47069321673381476, -0.5113613986875345, -0.3924719754692764, -0.5629457876419759, -0.5266358850784977, -0.2073919780447957, -0.011432353032399728, -0.14206177363831357, -0.48453771465651585, -0.30911428923387246, 0.23123361956603397, -0.4215168569984428},
    {0.03203285347564045, -0.3198810504884851, 0.05299354838901977, -0.03770364369489622, -0.00803750622260924, -0.356982177827036, -0.086328777769935, -0.1232996859677194, 0.004662530436895629, 0.5924889025139084, -0.12749260264909779, -0.05186105306494761, 0.004502683975153982, -0.6486120086988146, -0.016671899930882132, 0.5972308317313747},
    {-0.43932105450029135, 0.37527489845561646, 0.03319824696828211, -0.008659356182099332, 0.15999538537355174, -0.1397595719688704, 0.13540946495507702, -0.6493154851075729, 0.6801876579296283, -0.0015978258456869137, 0.39920386672559666, 0.31051585270833904, 0.19105347708906306, -0.07725308199103337, -0.1908413491868942, -0.29429479178175943},
    {-0.020397882322370317, 0.1732976131340759, -0.25421288582181184, -0.07216138361063364, 0.35909114648179313, -0.08808453754234973, 0.061554379411411876, 0.1625964235064381, -0.03526445557469641, -0.20459043107627015, 0.3931872954712828, 0.3040893994977287, 0.1340217877739295, 0.2895625648994855, 0.08580716141022371, 0.05400959533378096},
    {-0.3222521533034272, -0.3461374375039053, 0.1715796951083572, -0.42896713532296465, -0.2956205240941309, -0.16484859874591712, -0.17998063969114078, -0.3792224845955236, -0.33024350022270504, -0.8132636281646992, 0.07258297560770607, -0.7860466891157474, -0.494472503017159, -0.8177805180033739, -0.1000878392904371, -0.29999921812064845},
    {-0.10992442789023503, -0.0870198477554683, 0.05457853721835954, 0.12330473815524924, -0.3547624790832465, 0.2689744962913041, -0.0566614918783886, -0.45099569031466274, -0.3576211430755103, 0.09564424167420857, 0.1398495123938387, 0.1257529066511101, -0.24264451285199912, 0.07833132320664446, 0.09665650248802526, -0.9872242312085766},
    {0.2376464033391113, 0.24560444094809253, 0.051357779918692836, 0.034022983395175, 0.2472772261599066, 0.022164860885929533, 0.10084356731284493, -0.05820061405775904, 0.4352346657039197, 0.17817929191001403, 0.28377232703048283, 0.5726615040319988, -0.09606684597634214, -0.6016903235780008, 0.1530847261678497, -0.2871823848703823},
    {0.04195293283087391, -0.019016031303910302, -0.11841405663538107, 0.2543846473155971, 0.12731421909259696, 0.01137812662412711, -0.1430825751921354, -0.0890980673928129, -0.025937724900629802, -0.01484024001863351, 0.0736864363517676, 0.03844449129274452, -0.19724143356512552, -0.360748107207631, 0.37559386524283933, -0.14956424394980983},
    {-0.039959756286193096, -0.07858236358631475, -0.46736858419371125, 0.09243903671326821, -0.6393582656562945, -0.17281474175934045, 0.034154686644457, -0.026141620736726073, -0.1549273837774321, 0.09487195447351503, -0.23869413637273285, -0.332466495038178, -0.22040283454771156, -0.48200771115778346, 0.35676872559403766, -0.34907493097115116},
    {-0.22366633526533436, 0.1563657469534178, 0.3054303394635054, 0.01119026407211208, -0.17320185594104678, -0.043763606502040205, 0.09513931624349772, 0.14209485804468167, 0.10619695214962276, 0.7345143779838736, -0.3339266594678729, 0.3486188602576512, -0.3900391034697623, -0.17239356284408217, 0.15450980557339458, 0.2119216176689947},
    {0.11839129070033516, -0.4284179292712483, -0.06829648880622323, 0.09251002713721365, -0.6777177501716497, 0.41271702809528904, -0.8683976297057872, 0.05402903052011713, -0.9235819418557605, -0.2987968336467064, -0.8417054599066847, -0.45167453748560094, -0.11087684161106195, -0.5676090804397186, 0.5602695213628177, -0.9620328180025016},
    {-0.0118657872052605, 0.07323281193319091, 0.06556044773577555, 0.2903796632822045, 0.10169507466252402, 0.620589107655586, -0.3695769689167118, 0.6427345865284784, -0.5109666012950721, 0.458450807349356, -0.32316687758548496, -0.14777113255454405, -0.22755956322552068, 0.08331617038253196, 0.3374875624713643, -0.8851365204710044},
    {0.14147162145838119, -0.4871027370490052, -0.29259507872473106, 0.3958145717804952, -0.07569958432915636, 0.3191498718341174, -0.33276332803326414, 0.39458185112804167, -0.5367885769344752, 0.13265778041608958, -0.20163699609439856, -0.7286880818119255, 0.0928418864174385, 0.40963367211047375, 0.4291233595479872, -0.2780380974593201},
    {0.10825975992781572, 0.19063249274714616, -0.09645157344430316, 0.2795278033219056, 0.2708227265585779, 0.3159096599439608, -0.008192273468327535, 0.7559666457412272, 0.11546241978565885, 0.3845968411174228, 0.5492656239586795, 0.14224223033611677, 0.14668919153047216, 0.7814427910361053, 0.32461537102960025, 0.35333534530640315},
    {0.33237920594355586, -0.06671769819633606, 0.11516195096689431, 0.42836546907818424, 0.08809642313174385, 0.2572092206683708, -0.4945402666043165, 0.6914273026080991, 0.1186990435739792, 0.32220285283802014, -0.009997847474440961, 0.08250371826030614, -0.1762624635663888, -0.21623346289147094, -0.052181053753326205, 0.16751664549364076},
    {-0.38073903218486255, 0.19735217406242786, -0.008120811986532526, 0.01886273959229897, 0.49233977589577965, 0.1377020976965617, -0.015827941771260658, 0.02201303375259234, -0.19252671689488515, -0.1678776441277299, 0.015534192119452199, -0.12747105205563894, 0.04009759375423342, 0.5178325539534968, 0.34504805628923485, 0.35047004464567144},
    {0.4074118497847634, -0.11759749089586573, -0.17551464890853594, 0.2426136511855934, -0.25375863567772283, 0.3711635209603025, -0.012757069291538276, 0.2859560209658919, -0.40433566552924777, 0.10294040089780997, 0.11823987836403788, -0.5273581665194721, -0.36624281354694244, 0.029776471900558415, 0.1886049439746941, -0.5448816320886835},
    {-0.32179029479692495, 0.11551817274933937, 0.22867994930936816, 0.15533891937706754, 0.5095770703964628, 0.15312675863785158, 0.055430749061637134, 0.2560570984501801, 0.19549614374800223, 0.11516542234298945, 0.39414181027386025, 0.3264761901347922, 0.0440519416443347, -0.16644702668641687, 0.2085154955467419, 0.5560986583652651},
    {-0.19142121323686415, 0.06482623943057876, 0.07144268417597398, -0.4552833613776543, -0.10879386493732503, -0.11554014195570537, -0.32326017161769205, -0.1400971139314256, -0.9691841845025888, 0.4740664455016603, -0.8690055308927999, -0.34734590066024157, -0.37766420230536285, -0.8195125168937484, 0.09136353077178273, -0.3362977250159141},
    {0.27959543983458157, 0.15526478771235389, 0.06433806543150655, 0.5715736086888216, 0.3337760670497363, 0.09176336960908527, 0.11160570779156358, -0.13525028432952063, -0.44063531086118746, 1.0910999412875193, 0.049721986978979005, 0.15349801598032034, -0.06437462262381648, 0.08869970594850982, -0.08435983294969798, -0.04563638579639657},
    {0.2180238889330298, -0.264450668850745, -0.19913847938200957, 0.010597625669567987, -0.2690572227413619, 0.26293365312462735, -0.5275215060454835, -0.15175089936202701, -0.7129491385105887, -0.5144688770263969, -0.26562355421983963, 0.13192655536461634, -0.3164329815423624, -0.1375254083078677, 0.014674086373648065, -0.3035727547633526},
    {0.11712069172155534, -1.063609861207094, -0.34511888751068015, -0.33247077271646297, -1.3564187441758373, -0.011524236940716212, -0.9391519990714204, -0.04282270171463172, -1.223688956091895, -1.1797915452940777, -1.1073323271627629, -1.2152738113662918, -0.6810436121605559, -0.530318385287654, -0.02324857554928509, -1.3637822877479735},
    {-0.31041702093216084, 0.5020518478938568, 0.3769079413720663, 0.37645503994749074, 0.15870490981719065, 0.22755096249118076, 0.4874095959467154, 0.35635642464101036, 0.33432580488742714, 0.5071465962032725, 0.25283093418066865, 0.14906619074106553, 0.1520366468951056, 0.9993082834845453, -0.17229519908519722, 0.28603019473882085},
    {-0.16404480138674601, 0.8868001555126616, 0.4650107207009253, 0.32747704799533234, 1.435641456939888, 0.19803561196078515, 0.6215373475245172, 0.05829337329881157, 1.2615334013474382, 0.9351932535978386, 1.0932773289351503, 0.8594936858984542, 0.6096783474409515, 0.7117210451277369, 0.1200685293295378, 0.6608782769516898},
    {-0.6440994860621012, 0.4181301996907705, 0.2874149237495485, 0.29570470511942215, 0.7376299321741849, -0.08228069356938282, 0.5886615350779543, -0.0019284753828053953, 0.24688572275736884, 0.6996335503477193, 0.7623261033421764, 0.6829222125470072, 0.37827465884624945, 0.6540395330113846, 0.26242939640075436, 0.29759705473550624},
    {0.13180030849462668, 1.0138996168184966, 0.07525097888721634, 0.12812155002181624, 0.4143486140139826, -0.2708662156740349, 0.239434381827102, -0.4029633728992765, 1.1893269320654543, 0.5239027340313651, 0.19739412181513727, 1.262399807795028, 0.4546824204314717, 0.22527749932640115, 0.2031156456432269, 1.2363079548765687},
    {-0.008695017646617306, 0.4943798465259972, -0.05361954678548847, -0.27896204579968614, 0.06717715875742675, -0.2271153652682167, 0.1201594278846207, -0.2073538517887791, 0.6489706207273608, -0.08278392699456562, 0.3883082898097247, 0.827476558329884, 0.15339168791919364, 0.14381240737914938, 0.062053426976160515, 0.5226013766695078},
    {-0.3383960972746442, 0.5299425485555106, 0.35007096149666284, 0.5611390614888422, 0.4865250332739438, 0.13125481602617087, 0.6436588620377829, 0.19468394639390743, 0.9663632222027353, 0.4210247810651189, 0.8317230918876211, 0.924439827198795, 0.5988965234872939, 0.7055332440019761, 0.175404441356827, 0.8658132199996499},
    {0.05747099728933706, 0.2132721134352329, -0.0711319122500341, -0.3180524095419367, 0.36809398530489446, -0.46568745275808954, 0.13744805253291498, -0.04085469629860617, 0.6985984830432139, 0.19600154823886065, 0.28210618327062054, 0.4849300614884189, 0.2488787007086354, 0.14572332963607074, -0.09686051298144631, 0.6518755025760268},
    {-0.18327786086062156, 0.6673770546501665, 0.22654089700676838, 0.0676111542084319, 0.6714745216077994, -0.204672416661369, 0.3400019226437291, -0.32920595689495497, 0.6107985043542462, 0.04454726676962429, 0.37106284393753536, 0.7320994177899007, -0.08240939215313164, 0.226940426557668, -0.11525806635974953, 0.7041858285430515},
    {0.2979226101825674, 0.22844069271679543, 0.1942550481032714, -0.09820301259928804, 0.6117033930460658, 0.24474045258181912, 0.39495830684801875, 0.13936211251723676, 0.29824209545501706, 0.2753840489806596, 0.3630519063386772, 0.4101605282801142, 0.3154007549896265, 0.10403845092925855, 0.008962076426410004, 0.5437495586010646},
    {0.5533008498462055, 0.5019322078738513, 0.0039300157650079826, -0.10368840597612455, -0.12926596757613984, -0.176082275868543, -0.1749646114762213, 0.15116505776706024, 0.20811048268003934, 0.2910537859777986, -0.12596776742522298, 0.5352783186322251, 0.16752407380800566, 0.10949234829529274, 0.006478710174305687, 0.7665591537433541},
    {-0.29876001212003633, 0.454146860249551, 0.22447052265240525, 0.17229202990095668, 0.42371821073339855, 0.29174640798702195, 0.2944143723757722, 0.12955427625311947, 0.41750027520542904, 0.6169880546990746, 0.6591587466340999, 0.6185721093616002, 0.28891016353325477, 0.5988509663807736, -0.04935648975616032, 0.3264416663504297},
    {0.41349553609691553, 0.10144391066799734, -0.006084847084205589, 0.18408430329928338, 0.03630331910015973, 0.1705199336943915, 0.21426822323976485, -0.19076368519874384, 0.1035041845648572, 0.08113091569064806, 0.19635435987181113, 0.20667986430324597, 0.34557679988683576, 0.6327274188449095, 0.3416589794884638, 0.26543838546418774},
    {0.27466237515181013, -0.2773913268607597, 0.023067572835015506, -0.14391666309834605, -0.05852017100080962, 0.03125307555468623, 0.011219856098301574, -0.19721712650607368, 0.2569488207198868, 0.009438205698639079, 0.3888324656310413, -0.4274715022668315, -0.08210457979171304, -0.6040062792250397, -0.157581927144129, -0.09183861071434574},
    {0.08977662241414407, 0.05656665862888099, 0.270642803302716, 0.2240646491951899, 0.16574994177766603, 0.2770102373975869, -0.17770684898514788, 0.4066422029865196, -0.2324408955845951, 0.19007770955257347, 0.1878180430105624, 0.03182156399990832, 0.25160046893438176, -0.14319647734804744, -0.1232325845135648, -0.32638095953013163},
    {-0.27473289467734885, -0.05576535363297464, 0.08899845561510818, 0.2086625162118983, 0.4852197831537751, 0.011826580622549134, 0.1413421413131592, 0.009180501451428506, 0.34290100345262803, -0.03159609092876173, 0.5416386730789431, 0.4840317964618731, 0.30841900155869045, 0.26066906278454044, 0.09733568482588666, 0.7568239121243485},
    {-0.33470246999928166, 0.2444790791440456, 0.2941153685349883, -0.15667956482242287, -0.18177181123973793, -0.16100466608858713, 0.16222693208012803, -0.40818232460919934, 0.010170453928182447, 0.015873717565429355, 0.1183571045298956, -0.19794279633811193, -0.09235925453056391, -0.25758999383759656, -0.08512068342380844, 0.006589735105975681},
    {0.13079688524242689, 0.14452937045710904, -0.07489668264553542, 0.04577013490338325, 0.34837553665532334, -0.010754556251249605, 0.594695445708879, 0.16821631258200045, 0.007269090545700419, 0.5664484161692249, 0.4250197350747413, 0.36288654493160527, 0.1651949683270637, 0.5269870124717666, -0.03882658378295984, 0.7577273328937096},
    {0.27581338415350065, 0.16715921421347552, -0.07560497330718335, -0.07546877707075562, 0.33682198881665776, -0.30705281172608073, 0.13766648025082526, -0.0038373445939035122, -0.18747045431206474, -0.05852179067524416, 0.38864015108752287, 0.06718684675569707, 0.018892293394113635, -0.1331521522647885, 0.09676174889661882, 0.5139937147033474},
    {0.03676364607818375, 0.42087724311009705, -0.050007934308061115, 0.3047687923979585, 0.6905067943517312, 0.39160712861964686, -0.02854109020332562, 0.3639946731967132, 0.447617377974378, 0.20058614290215598, 0.6454218503771968, 0.06174645765289172, 0.10488593238273522, 0.2851923151950579, 0.12380586075465069, 0.42568555922008894},
    {-0.3881071969042071, 0.0845573614171334, 0.12399461119371792, -0.12180569748774649, 0.11949257261021023, -0.035402528651740824, -0.031207607942363973, -0.04458157233116128, 0.30953455269121516, -0.038065737570133866, 0.03562756604501923, -0.26840499908188736, 0.21024669124938347, 0.07215947645766747, 0.0876656050734716, 0.04349970338011099},
    {0.18245382879358257, -0.435949611908643, -0.1566834091831335, -0.06223609007493554, -0.33497846807511267, -0.17329574982139295, -0.32834355496629525, -0.15973964518431702, -0.22330516787863158, -0.3885604475861438, 0.0032239042698355125, -0.35572548773519824, -0.267631398472441, -0.5089693226268326, -0.06545363245187759, -0.4638698168924079},
    {0.11901111915198187, 0.058814187514666494, 0.13813475328512478, 0.16530804352064718, -0.004364266687691526, -0.26125857803917063, -0.13363405303715736, 0.09467945995583589, 0.33298597599371715, 0.09971467503478337, 0.02005671422788234, 0.4047157660847357, 0.08795924787198584, 0.10007129469957463, 0.19635546076999957, -0.4027971161676593},
    {-0.4238659367838404, 0.0661231356546066, 0.22559142663269297, -0.13901433111771558, -0.09516440318714017, 0.23596765062740166, 0.4452873998818758, -0.006695227324566536, -0.3328869779531289, 0.1823097477495108, 0.32843831720184236, -0.26279452980572665, -0.07148665727031427, 0.16153872919907905, -0.1593496134864244, -0.32608794883605574},
    {0.04159514847896985, 0.5376229031432599, 0.10476387921817663, 0.02084976649740859, -0.1307870191431563, -0.06439966557410728, 0.1255991191405253, 0.12955292027963916, 0.1270851787797127, 0.18650359104977768, 0.03640751292742432, 0.571344805436764, 0.3332336459274862, 0.029705591005747156, 0.11427000543711993, 0.22252806915225806},
    {-0.3179294541799906, -0.004058761998964464, -0.257148291968442, -0.22424254066890936, -0.065052241247752, -0.3443047577014589, -0.08637799844138114, -0.5152432945025311, 0.5414846806953534, -0.7236420479899794, -0.04352533961958781, 0.12084488217990749, -0.07864129881645038, 0.050929578530662545, -0.09455160380655453, 0.34765369334741975},
    {-0.022662297525050966, -0.27094400516563866, -0.23964448467530355, -0.29621840305289465, -0.0006624692644254694, -0.40008222064365045, -0.23989397245039965, -0.046372075965050184, -0.09097709492044093, -0.6895010511727301, 0.08577101338466257, -0.4748231420793441, 0.05813164743401612, -0.26685242657538993, -0.12941784904616033, 0.0676636803095769},
    {-0.3719218202675275, -0.24871763812279948, -0.3006584543500179, -0.02135648509054653, -0.4394947622409023, 0.07543573768778093, -0.22423004672332492, -0.08562579682023487, -0.4284752036031405, -0.3356493205646058, -0.5396100973438529, -0.30780634573632176, -0.20806727852320295, -0.32758862103344716, -0.056058041168990005, -0.7405518199676716},
    {-0.032134532685706575, -0.2082932602127228, -0.2728913756934992, -0.1208399048972646, 0.051998835793743155, 0.5692335987968122, -0.4569401800792351, 0.3912885364652911, -1.093615312597658, -0.49470143907721187, -1.066883327782482, -0.4950758215346293, -0.3508664179532841, -0.1371659788437158, -0.28595097262763247, -0.490638020085611},
    {0.1383100809838484, -0.21872487399389046, 0.21737240855558795, -0.0996492155808075, -0.19458758093701797, 0.10841050766359037, -0.2233031370267884, -0.07445663745849189, -0.22111631194851822, -0.10863253097886534, -0.18660046248103584, -0.2145856996009636, 0.319259340181237, -0.4781252162073589, -0.01603606165616574, -0.22289047379488697},
    {0.396667376229791, 1.0803379313919899, 1.015124067583657, 0.7787838337130818, 1.648010959647846, -1.304864087281813, 1.3993260873810256, -1.480814881758441, 1.6083317357530846, 1.5261598133366072, 1.430732680867502, 1.728322795038226, 1.0866392876962672, 1.5511776585241153, -1.8384451408521654, 1.28446394168009},
    {-0.19769882694630014, 0.4965068308982782, 0.7121909940926103, 0.23374499421533082, 1.7612626595872485, -1.249001709934556, 0.7144697500480478, -1.3510520238170083, 1.0818735926036174, 1.562864758769322, 1.7243794547855706, 1.890204039730459, 0.1633730583568433, 1.0698926367793418, -1.6829371181348545, 1.4642195718748645},
    {-0.5207236348606128, 1.2257995446502734, 0.3716837978463558, 0.21357001075486984, 1.3263817662009227, 0.1241586510668325, 1.1854191290974239, 0.33352595171118304, 1.767627432831216, 0.9170340574249566, 1.246320091736765, 1.9496483663592084, 0.7216394514444696, 0.7840499773674819, -0.12845333091054156, 1.4842843139008035},
    {-0.22233047961936622, 0.6934693867926213, 0.0817568373665148, 0.14177547792349193, 0.9754816053590145, -0.1443505356041607, 1.0917269608494768, -0.3924369415397686, 1.4994048579538566, 0.826486428090289, 1.1719519719074187, 1.5449265163874488, 0.6284432168033328, 0.4097163106719829, 0.02352714381676899, 1.515104116678915},
    {0.12419458388149007, 0.8907142262380999, 0.4539200105052504, 0.23729998682079814, 1.2667928904889048, -0.11675813947517093, 0.9857676134750601, 0.08765891266424171, 1.2361526954099673, 1.0809555848512151, 0.9776189533595168, 1.1844899406587315, 0.6704411079488232, 0.48648594718617266, 0.026762085192866814, 1.5171664834102323},
    {-0.26805079703841883, 0.35590594746948223, 0.1033621733427674, -0.018307706267572957, 0.889006503832009, -0.19508298959544626, 0.8149792200648183, -0.1557602026423828, 0.5858481753461395, 0.5821950538441515, 0.6216368017562134, 1.277658480405277, 0.3638981442329145, 0.36239108421586563, -0.33955739870173085, 1.0772314448082898},
    {-0.6628118390808316, 0.32354131140913495, 0.2994584675079346, 0.060332858995472416, 0.5662923439305994, -0.29469779610571517, 0.6342985074294333, -0.2006528477707763, 0.07248954999719667, 0.1337739538902251, 0.06456672569350617, 0.8415030282716502, 0.21168220980583674, 0.10827267500013953, -0.33223866178634004, 0.5248136921547334},
    {0.028310262537235686, 0.23080706983716204, 0.08187851203283734, -0.06767324896714176, 0.5427634175847309, -0.15083673069514447, 0.3995979994200244, -0.2579078827313517, 0.8213635294577986, -0.23986408923005337, 0.68407955933576, 0.816198766642187, 0.28045471931682997, 0.5919682494672766, 0.13881871986577557, 0.5621887547096548},
    {-0.24513601897145534, 0.1134594029750657, 0.05561294461960232, 0.28793530850259796, 0.8111341146221046, -0.18553612896866897, 0.3339207137315737, -0.24397626221471788, 0.598192154813108, 0.29781030510878387, 0.28397476927197135, 0.803737820157536, 0.2892644517159736, 0.5144130142849213, -0.1727143804870715, 0.7421139714669304},
    {0.35264432039449245, -0.09381052415351296, 0.19080178259077132, -0.08643443936611234, 0.328557316230394, -0.3685801110419569, 0.18167469526389274, -0.1430514363003936, 0.02362765760658102, -0.3922785911200922, 0.31077131737276364, 0.22604118628288297, 0.2069340659722161, 0.06278697855616297, -0.12202758408345311, 0.23814727830906238},
    {-0.05543691756660621, 0.036577091215808516, -0.14575209183107954, -0.2532200828272091, 0.09341682746914497, -0.2531687398042559, 0.17809763418893435, -0.6328741599349659, 0.3453962581503509, 0.576589928004578, 0.4428612625760647, 0.11673046235644781, -0.01624805957990143, -0.5533583082002235, -0.4060208913314457, 0.774171603429657},
    {-0.11151497367165092, 0.48569647186572856, 0.07424578417481933, 0.21363597782262816, 0.2774365481210391, -0.04698832501929903, 0.3430310577672604, -0.3861954989346664, 0.5031894932154528, 0.6408588237059212, 0.8729493924465241, 0.41389228820667157, 0.2910910115528105, 0.5442294993175153, -0.04006710899369156, 0.32382509874514037},
    {0.4300981564305819, -0.22281630041104877, 0.21882849267736768, -0.17473508261395307, 0.3059990354302018, -0.132067571407113, 0.5468530716110461, -0.035201324865944274, -0.28240228796794303, 0.01449994563980543, 0.05413265262449811, 0.10584464186655264, 0.035322480143166905, 0.19266520164463158, -0.13574876984525333, 0.4843286439130945},
    {-0.08219565663192872, -0.26868727194974495, -0.16166030181418567, -0.10924567289342657, -0.15071609609112727, -0.2362741033403952, 0.06341171869029534, -0.36274751100589947, -0.06410265439175017, -0.1293902083618298, 0.3611238737583569, -0.4477069994824626, 0.04217614812905191, -0.5983309838005035, -0.131833113840582, -0.16088389376187792},
    {-0.4892217952853726, 0.28751300727032264, 0.15193468612090183, 0.09214953177679355, -0.0044791425882573874, -0.09361728396835534, -0.14142014111948098, -0.37054204182141565, -0.0644817386186823, -0.10555059503979057, 0.2578697689058868, -0.1972730307929124, 0.10580979715346135, -0.13615072356714328, -0.21928681703461786, -0.6692504797876457},
    {0.4757388911949403, -0.282546719907689, -0.23369763144509925, 0.06044254898141276, 0.3499912003186605, -0.22981731422689658, 0.17265393572345594, -0.2232674693210711, 0.20459048228723128, -0.18186848086474164, -0.049429648739579495, 0.20189416338629299, -0.10350998746876705, -0.5241478436631667, -0.08813489186766353, -0.26511291676603926},
    {-0.08387560093030337, -0.2557061274197363, 0.06729760788677504, 0.14244114460889928, 0.4405611191799947, 0.012904817983637698, -0.055898743254197615, -0.2532437496732668, -0.13234399951689454, 0.14903317471270344, 0.2996107078590853, -0.3826874535367025, -0.1448217121508033, -0.3562990336875974, -0.5004123750205887, -0.36126367147514543},
    {-0.021126477137609612, -0.1565831563867831, -0.0010369225905329834, -0.30309385994314425, -0.2276990609483359, -0.42162315565470276, -0.5307605062076334, -0.30397067121920307, -0.19317533258311406, 0.2625708020441366, 0.007841882585586766, -0.5037571614134584, -0.09443071638420221, -0.12888170131655682, -0.58735933742483, 0.26200506948907876},
    {0.3040703556049437, 0.4039550319582483, 0.06756585242339698, -0.06357058434752717, 0.2465381336808841, 0.04959241539980709, 0.10926422869438934, 0.0754490318532499, 0.19046580140544628, 0.5549602143284105, 0.26601978028099627, 0.4412990894758654, 0.30351027158879146, 0.3757193578190658, -0.296739865837496, 0.19781074682084301},
    {-0.0951998306210798, 0.27529367328827536, -0.1790940913775404, -0.15136974568020142, -0.18222537431079852, -0.389715437820368, -0.012505995163106663, -0.19941837252959876, -0.5345542287660899, -0.009839581739160597, -0.31211566589726625, 0.10100641153608134, -0.2139156449617683, -0.10395941443297192, -0.15807393876471593, -0.4978758813718322},
    {-0.0956129304745061, 0.2792362794070584, 0.030998610420493466, 0.1093380967724846, 0.03984756422651073, 0.3761259470038414, 0.35271888286709396, 0.4023254686544297, 0.0891045901866787, 0.5035890360287626, -0.48846222952867874, 0.3955436836345191, 0.11833083170365183, 0.4156932363516059, -0.08762073458975747, -0.6622387164220684},
    {0.06085364543397556, 0.20703866591456055, 0.4583533924595981, 0.12722174388468846, 0.6742033945026833, 0.24621589968119167, 0.26221598933740714, 0.0966763599180493, 0.6107540278301665, 0.7082142258714688, 0.7199683252618083, 0.07325311925853001, 0.6103016740029951, 0.6382514131037108, -0.01624487560407839, 0.24711180961632925},
    {-0.03050906018539755, 0.11840643127505397, 0.310392425204352, 0.01837122345797182, 0.15557689521925064, -0.0011697925991203642, 0.01640503382977502, 0.3278393442233676, 0.5817149366598663, 0.6959377474038743, 0.2121203627113433, 0.5282008909142014, 0.3097298040143705, 0.911491314669204, 0.22741622487817093, 0.39545992597312885},
    {0.6319507478873313, 0.38827623295731994, 0.046503953608491355, -0.1640645572562638, 0.4284052695830185, 0.38278047698754486, 0.16143966937896828, 0.629879514861852, 0.2671181799326842, 0.853608972612073, 0.10080820496466411, 0.4011902158074455, 0.058162148107108756, 0.2704683552386513, -0.1777230950868862, 0.6187576385867161},
    {-0.11854105491822611, 0.17722621229109148, -0.4520273616685474, -0.0955538897953921, -0.008528953586864018, -0.2790784432936353, 0.1438293818196192, -0.28954481663994147, -0.24416524866062173, -0.26936189279063755, -0.054936547145298054, -0.004316849260056615, -0.13426108615292978, -0.43974871162824564, -0.48583373787632156, 0.0849693919852739},
    {-0.0325585691281623, -0.5888168215899636, 0.024951393144124846, -0.12420256787823428, -0.09070324135405368, 0.19077137981869363, 0.23956477084816247, 0.16961952536598407, -0.6894215273391525, 0.6667447255680443, 0.17083433940055265, -0.7787765052705017, 0.05635328139823459, 0.03534375805556759, -0.1631016577851101, -0.6411197699830632},
    {-0.011821457510327113, 0.239515251269177, 0.15074363935895774, -0.2630289052299201, 0.6846220717927182, -0.10317199014910577, 0.16141320300290535, -0.35088002962326337, 0.27652259894910797, 0.3639535989335366, 0.06142026524660404, 0.665939550784684, -0.03683802666295324, 0.19169870823926344, -0.4551329391736705, 0.9552425197570911},
    {-0.32340714273291676, -0.061522393291933264, -0.36401073660067695, -0.28167263925893377, -0.4933447417674946, -0.010266954718252891, -0.4518644851809531, -0.5465418822860477, -0.9349864479996662, -0.10112997311954472, -0.6048818474614731, -0.628255569785115, -0.44704042536421174, -0.6810824731301746, -0.23505392382748116, -0.3624816336331769},
    {-0.07002596957894341, 0.20888555321856717, -0.18782525966598226, -0.4816296457050955, 0.09877564893720567, -0.12616451564289666, -0.29047551833469387, -0.3619075700613785, -0.4206119244727018, 0.32899317426865465, -0.25600226570269435, -0.13480781976547634, -0.2491147646280622, -0.3796116209235766, -0.3512282906166139, 0.1232947842869003},
    {0.2052020563394095, -0.33082432740624457, 0.03518063388576381, 0.26262952679634527, -0.22621285026593596, -0.2884018595851268, -0.26141977709465275, 0.15942069987254243, -0.33280858496860155, -0.0820420240901569, -0.7586198562520982, -0.24139145466457484, -0.3369869621280634, -0.25515599166156455, -0.21530399490568033, -0.21152134554375976}
};

static const float b1[16] = {1.6877329132083962, 2.3041249002957, 1.4126834757049622, 2.2386019036487084, 1.928293838647952, 1.8543682349749966, 2.543999083133499, 1.6112916920704654, 2.10564777792287, 2.8943475676159705, 2.095347520963793, 2.402792114612491, 2.074837325078584, 2.3415672637485967, 1.947928321661006, 2.0892970950253336};

static const float w2[16][12] = {
    {-1.0930996561036201, -0.05611311915454355, -0.7341639782279102, -0.6530118799108188, -0.8290321286805887, -0.5355555397690185, -0.8902392796314434, -1.2566800654974872, -1.0908059304212767, -1.9144290379425057, -0.04207482128726883, -1.508709085488818},
    {-1.1287983697679633, -1.7894729027054888, -0.41681407116480945, -1.6094025226828181, 0.12377540856446652, -1.799771396841385, -2.037204117338874, -1.6669609933530514, -1.0782370572117341, -1.1191510239895888, -1.027543637771073, -1.7530469308043473},
    {-0.9536437446266036, -1.0897441225209261, -1.3284382885684707, -1.0055038710931654, -0.6997882332883214, 0.19110359510201255, -1.4435567333472952, -0.7320716891157296, -0.5481210977766405, 0.35074557176019144, -1.2771071627248118, -1.8272261239078678},
    {0.22205191066707375, -1.0851041642479704, -1.8083388655381953, -2.394893643982494, -0.6011466626573894, 0.00993690538872447, -1.397819460852347, -2.127467691844903, -1.498446441770931, -1.9117211629859419, -1.560958243491547, -0.4321822524882311},
    {-1.4635375187085524, -1.4380593488976023, -1.41533904792774, -1.4711156337582938, -0.9822005618767435, -1.1874494745949278, -2.1742544170969156, -0.5246959840205329, -0.624797456849276, -1.4141995281437632, -2.265484729057692, -1.4247328895160698},
    {-2.2951858449496854, -1.0507700047329744, -0.2090760925913669, -1.8007855781438016, -1.35749863091794, -1.4611112696698947, 0.3831246301499031, -1.9935961685945236, -1.9298990788528323, -0.3205266210077512, -0.9214858069842192, -0.9647491435393442},
    {-0.7135133939877337, -0.7114944972943169, -1.6799139177157434, 0.18705537532072497, -1.182007110200297, -1.9640139484522254, -1.9621403592516273, -1.682137935045685, -2.281943411051528, -1.3333558746642393, -0.33933671569754836, -1.3104736662396304},
    {-0.004462786311359208, -1.308263223488254, -1.4393927922186227, -0.5351905613514957, -1.1255603522476767, -1.411750096381123, -1.629240485262966, -0.4315332201419515, -1.567335896395887, -1.2976884582885022, -1.392751142454806, -0.907998095510359},
    {-1.4010285587962688, -1.8217628756010513, -1.8527909278642498, -0.4777156994193727, -1.2585245220890116, -1.318843810318721, -0.9683094399632185, -0.9803059519325398, -1.3381183437668234, -1.6009997213779785, -0.7626428940595915, -1.41508905199046},
    {-2.1852665996711167, -1.5677365761064397, -1.571404362674977, -1.482811561522946, -1.903849411482154, -1.3186629171573403, -1.8167193711664014, -1.4744500906457643, -1.1755531427270898, -1.3950070216488657, -0.7101925309458079, -0.5568671496460291},
    {-1.544525001751083, -1.3068299861517025, -0.6631485055038828, -2.5103028827886535, -1.5630600579269622, -1.1967819740833339, -0.7712948917304214, -1.7323411671554905, -1.088610771894539, -1.6984317914986324, -1.303462066012297, -1.4212944246694224},
    {-1.7585295658026816, -0.9978636556311975, -1.5439191814481588, -1.2270685367583762, -2.058662068772847, -1.2272812044817267, -0.6433687192781519, -1.9107828947151078, -0.8301094943413434, -1.8461567076526777, -1.996057854020449, -1.013373141020995},
    {-0.45843249439448897, -0.024432770610619815, -0.6930229010236458, -1.6525770033847516, -1.6537683844211706, -1.8501884398959452, -1.746581337152989, -1.7342075078180947, -1.6600935751914139, -0.19731415432469543, -2.123621034449621, -1.4411358354875112},
    {-1.9218676398616596, -1.288125789506833, -1.8019679555254042, -1.140092332257289, -1.1201129213833545, -0.8871952055112453, -0.6683803759270317, -0.24151902024068386, -1.18147793518375, -1.3035934403629503, -0.9440206707479241, -1.6149039136895593},
    {-1.6673078473719913, -2.258859213979206, -1.8762747193064866, -0.41882671428182483, -0.15061424866119655, -1.458306012221632, -1.0212278073049152, -0.6547226752003054, -0.7229776755176566, -0.7707991287407415, -2.177926233003622, -0.3032321164141797},
    {-1.52980693893329, -1.6712879740809858, -1.3136619515329253, -2.1223688305077353, -1.3184961403415156, -1.155884268362413, -0.8736719510267675, -1.1207788027990546, -2.1549746851189333, -0.9882683848022644, -1.41678850621835, -1.5879716488066524}
};

static const float b2[12] = {-1.1285132528851864, -0.7662407479881973, -0.6287421941593994, -0.894494326410137, -1.0299330014081944, -0.6383027332941125, -0.9457443274624794, -0.7239800745000307, -0.41552430288218023, -0.7282942055607478, -0.22866750422260582, -0.6313394286662175};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
