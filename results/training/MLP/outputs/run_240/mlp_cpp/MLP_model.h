#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {2.209682126084889, 1.9306332340220673, 2.56800295756292, 1.8844067225405081, 5.2353069908493355, -0.12824487436708518, 3.7057826651391195, 0.19295885024873322, -0.5070246217650635, 5.788552591282224, 4.081495747478767, 4.3676406698590595, 0.4534756975426026, 1.938867933670869, 2.5776129644065815, 4.108521620566622},
    {0.15159406424688152, -1.2974150265711366, -2.002885605423167, -2.626570602202867, 4.368934839622437, -0.6683001275506548, 1.6609893263630844, -3.772418967279941, -2.7413536734256505, 3.428723357369085, 2.2645979409522083, 1.7694244744187524, -2.72499477930417, -0.84688975227126, -1.5760020809823052, 3.81865176811576},
    {-1.937937146632758, -5.074105260060814, -4.189092425365659, -5.196143873318658, 3.9506863472816653, -4.26942395738585, -2.607851420247658, -6.039427267181837, -4.891211506227766, 2.865505353875298, 2.9642268540888015, 3.0492174502200466, -4.534491509757924, -4.58733287602014, -5.21805678206936, 2.513454031652669},
    {0.35534755869064755, -4.661333297972251, -3.606828452884652, -4.956088548022449, 4.765046801121652, -4.699898036739265, -1.4154685094286525, -5.5287282755870795, -5.549521815660946, 4.4348979448380685, 4.023934282053783, 3.398207539177273, -5.757139526935943, -4.67222393573923, -4.7454383028458285, 4.778766223138067},
    {-1.0119911985124104, -4.9981694166562445, -5.311608376802047, -5.516571506951144, 3.7808815059160246, -5.5881674041587335, -2.592987061610095, -5.433911426951966, -5.1491120275868365, 2.798020711658594, 3.1814757642571134, 2.6216553508790503, -5.358157230741959, -5.174001721352446, -5.32423701243172, 3.133283792379061},
    {-1.7204775840953055, -4.818984143961322, -5.4481091921580305, -4.9399148152538475, 2.4796287815674525, -5.420999461894939, -2.8055693453239248, -5.208869836262832, -4.481049010930562, 1.4470949753985642, 2.32523296181799, 1.5648116859947985, -4.324511860365315, -4.904838851786058, -5.120221473032726, 1.841511313079311},
    {-2.059495298464004, -4.4101595689473205, -5.586401421054353, -4.761384911653413, 2.02546995106458, -5.116611657497804, -2.4111264853662093, -4.669593226924029, -4.478670288765554, 0.8101239992881413, 2.1584832684981334, 1.060159613714895, -4.068221832376364, -3.9395788738255586, -4.850008409722075, 1.4503735428086237},
    {-0.08331370293618752, -4.4875261515079305, -5.369222580765754, -4.226685483115759, 2.8844329536405984, -5.431376571612193, -1.791188844387897, -4.740306131684778, -4.917264192473506, 2.334331826596, 3.494412280320848, 1.7908294311032058, -4.1232788538552, -4.493880969636886, -4.8878883593795805, 2.3467771624253606},
    {0.9990853331772738, -3.349497770810623, -4.334665054556652, -3.7762089764698157, 3.8941569448191387, -5.368265793169246, -0.40483280272100164, -4.871889532804886, -4.185216867243123, 4.031148333323226, 4.150725858473323, 2.359914822470971, -3.613626983293743, -3.9988252990534723, -4.976961160298983, 3.858445340977862},
    {1.039621001272456, -3.502536940117364, -5.073388958384715, -4.127829786818511, 4.736203219836735, -4.6967592112101135, 0.1539472263376157, -5.496993577356355, -4.462435449348651, 4.683131673136396, 4.125846435475663, 3.3204605004554684, -3.7665472366471056, -4.0143452969355655, -4.844646439911427, 4.893834828356555},
    {0.4646086526892743, -3.0576523876100383, -4.362857931471879, -4.273543143851294, 4.91262324739604, -4.14507790805267, 0.03328524332474058, -5.121061705551, -4.438751627655207, 4.444946202378348, 3.3579403041346243, 2.1340809050698155, -4.075705071329628, -3.931393505070221, -4.942363924327089, 4.345588936789406},
    {1.0878779743114932, -3.487791965495466, -4.047793740826393, -4.0825170978109355, 4.2127213559526755, -4.49583900366125, -1.6559545508184506, -4.648159710319625, -4.86513406914086, 4.600855279401234, 3.573316358014113, 2.6022746073769323, -3.9516996600029315, -4.9109174707007295, -4.5359736478228525, 4.061106229231196},
    {1.4613420145773088, -4.244673336805397, -4.301612614193118, -4.6156529128773665, 4.206674155467265, -4.439280850254771, -2.189397042813395, -5.32213441679939, -5.351214201160462, 4.176785793546911, 3.7088824088385937, 2.867625137070844, -4.456466181652651, -4.958051925648533, -5.2849123487982, 3.956028911875417},
    {1.6243567735455067, -4.584914974976226, -4.806844861407659, -4.963423147630926, 3.9713842350931867, -4.962709209226583, -2.770260217850845, -5.6693812577024, -5.612237821212034, 3.9582015522994936, 3.8752162263848087, 2.931052063674196, -4.717229053984304, -5.016317289836735, -5.191783811059804, 3.583617090637103},
    {1.5980887388823775, -4.197596236104252, -4.776100391906333, -4.530166307406215, 4.094920537045376, -5.014200199172854, -2.3392971641034106, -5.483223588819025, -5.019253934698679, 3.571322076289406, 4.2886728079012055, 2.9725513050858847, -3.8951465158641736, -4.255587125840648, -5.184848805448423, 3.4214193727094453},
    {0.913216789394421, -4.940479659527041, -5.593675567953823, -5.24306674810693, 3.538238103118927, -4.83511561974155, -1.89167539292086, -6.092541485474846, -5.227566990740202, 3.422768335475279, 4.102732839756336, 3.078015632315641, -4.764511339006205, -4.638285522218145, -5.56505361989305, 3.559843733139765},
    {1.6441745160209025, -4.809006275064313, -4.787971823101855, -5.180003511338207, 4.113649158236129, -4.861224549180601, -2.2456136556872686, -5.863685473823456, -5.461585350039765, 3.6709757698528658, 4.542026091894648, 3.940499647488633, -5.01848161032107, -4.7736228518022115, -5.884768539456725, 4.012188403144272},
    {1.2241380999220113, -4.801782011922603, -4.037363746681081, -4.7881747170243365, 4.371327541034654, -4.958049910868904, -2.378026727659673, -5.335019448643533, -4.97923806442421, 4.378005772992457, 4.299113367902688, 4.5349152799697, -3.844757876102568, -4.654429516648403, -5.284190830977215, 3.84257464655619},
    {0.5205226582136893, -4.809446825331913, -4.100920358665755, -4.468995048949933, 4.3044161598997395, -5.426378504350861, -3.3478768504612613, -5.3934737312400545, -4.683918505458651, 4.493020480884127, 4.831818438437791, 4.507983614462352, -4.079981941441407, -5.154810811068667, -5.291701426162772, 3.385769889159077},
    {0.3221194011459178, -5.033508685734757, -4.835968458542902, -5.387459624140022, 4.8388286999936305, -5.555255479195705, -2.685715303387941, -5.394093096779343, -5.570727343056862, 4.860568735151487, 4.150318508423074, 4.478650180583082, -4.461671236111637, -5.484090946349603, -4.970579838177744, 3.9566266950991764},
    {1.2616783347428084, -4.691612141661538, -4.194344270040351, -5.00526737783951, 5.42538656962747, -4.588773842014421, -1.656275194300104, -5.439599963374332, -5.444185890763464, 4.9905273687097065, 4.620223359256526, 4.4780098518803175, -4.775959994923665, -5.21770732767487, -4.802357471603408, 4.88818332374656},
    {1.9749551993832701, -3.792712271947977, -3.5946651117638435, -4.488972728112686, 5.361036641975532, -4.446952154166999, -1.1735508538206028, -5.001713086929984, -4.711050868593314, 5.498857255467547, 5.277273801887401, 5.207839048505522, -4.434736839276676, -4.449672183273305, -4.428379249636459, 4.823668390675638},
    {2.2532231179956237, -3.330290330937076, -2.43848806446038, -3.4265953462225576, 5.527003629353169, -4.1200739880190005, -0.5781412571268458, -4.575988123729853, -4.482984108413299, 5.889942943925768, 5.122984568507829, 5.16801221948656, -3.591492077321553, -3.746174675009648, -3.7361510770317023, 5.17005197495308},
    {2.101062472701292, -4.0803504806458015, -3.361657833232723, -4.634479921672351, 5.027672970886051, -4.480104009399891, -1.3623076360253306, -5.329467289953708, -4.860032933845009, 5.35652044926976, 4.899708115291695, 4.88930939298096, -4.010614839392155, -4.509181664315297, -4.472236265215093, 4.8657465532660575},
    {1.4371197997250214, -4.100128662975924, -3.260789889317411, -4.833445394703058, 5.126415591698292, -3.8706629651160216, -1.3116216964659366, -4.614264059567918, -4.85559608005838, 5.130334344833699, 4.175664052534357, 4.70959133811143, -4.991030191089832, -4.808362767246879, -4.471588381708965, 4.947653872714924},
    {2.0121201285463863, -3.3957158636497966, -2.6148956466079243, -4.465369073640956, 5.017002531367909, -3.415425959544678, -1.6146521811499066, -4.059330165183926, -4.334866191886908, 5.4599952548657855, 4.882036763387377, 5.095291060392454, -4.081929346015388, -4.392386157236784, -4.1986626643235905, 4.944637846893904},
    {1.5399302835905124, -3.770521252063907, -3.7136987295513655, -4.961262435608877, 5.488044353184608, -3.927729995503617, -1.83903502819458, -4.585612839123231, -4.830781790754625, 4.873141268841185, 4.609842279499923, 5.019472590646983, -4.435199242448145, -4.362182654351446, -4.613651968435163, 4.503415675288645},
    {0.8522599583774632, -4.606831257709935, -3.682702946868184, -5.394047437284339, 4.966973714411711, -4.375801218883458, -1.9042921525211696, -5.074369312046788, -5.185372051256289, 4.633239924000692, 4.33873236195702, 4.750970166081606, -5.003576024511899, -4.7073658747739895, -4.681985937618344, 4.306353687019013},
    {0.7208861213319894, -4.341409532602129, -4.30508757698286, -5.7918402717566355, 4.626373315620209, -4.070110929545483, -2.1509140324014333, -5.031654140117372, -5.035516933207201, 4.647052128464754, 4.035636883980283, 3.9841557699451933, -4.837209394363879, -4.981191530188374, -4.87105894066698, 4.1428757037801285},
    {1.034719436085709, -3.585692064819795, -3.517735054833186, -5.407260939131485, 4.357006635201692, -3.03236908796177, -1.537612595222701, -5.062968561096341, -4.409329020771843, 5.166688235778504, 3.4974393913456483, 4.789208895702928, -4.845385165975007, -4.53455583045712, -3.9641276592906416, 4.352664146321848},
    {-1.7148397821018966, -1.100217552017629, -0.7488089775896396, -1.5015411184975829, -0.23973587571793412, 0.7150693094288807, -1.3307456295669198, -0.6763032371733882, 0.022953635144420996, 0.15594518111310257, -1.4344927038486854, 2.0190773778334004, -1.8572590582061665, -2.4370350527333415, -1.4609183525180898, 0.5018323216431855},
    {-1.647875475262727, -1.2233988756490402, -0.3347745703007897, -1.81367105313759, 2.013363849779132, -1.5858116751222544, -0.3371998663275806, -1.7161753240248327, -1.9192242712192389, 1.5927595753842625, 0.8051897305139407, 1.187482892297174, -1.0662621777574754, -0.6051547950624577, -0.9473920819815712, 1.2135639609898103},
    {-2.0322768014929404, -3.5480439903189755, -2.3135920930720153, -3.5620678763580207, -2.227053236094235, -2.6321461044596903, -4.381953007703576, -2.955796800026392, -3.8391193224810505, -1.9249599328276252, -1.6177900436740211, -1.0514331537534618, -3.0431536377444233, -4.088194147034274, -2.465153108394138, -2.7212746791445057},
    {-0.4853409209829878, -0.7726571915425782, -0.7834158711876676, -0.4381878535556544, 0.6375181487561066, -0.3805604511253991, -1.0599794277713142, -0.3926065569408769, -1.3265861570646877, 1.2406500567474779, 0.7338256889990699, -0.7700430923718118, -1.1489588643835886, -1.3030326436872863, -0.5457666760966602, -0.08696302102011348},
    {-2.5720419099403364, -2.036345543072471, -1.6032102828937433, -2.4945080128757997, 0.5410039973836881, -1.6612058406210837, -1.2149274546010258, -3.0212116115977197, -2.2808927842745716, 0.5365057398920565, 0.19580770527651412, -0.8552696248311189, -2.1202219805090374, -2.6361093471837695, -2.6166814836763868, -0.1350037788194082},
    {-1.8372165724945237, -1.376204392343622, -0.637363025048624, -1.5385657781359139, -0.42123131231455385, -0.6066044912336414, -0.9094064086786635, -1.4393199774942969, -1.6697869698786132, 0.10443872185263134, -0.6356348025045835, -0.8229902820386582, -1.1257633610332434, -1.2571912983380418, -0.7122629425014092, -0.4584572962193508},
    {-1.904288332448643, -1.426610855317564, -0.8678295606399777, -1.718345985372775, -0.17286498900733105, -0.8260396384278025, -0.8420658109737791, -1.4063881318482636, -1.738361616803212, 0.14634442351584642, -0.7594396218895837, -0.5338090887348574, -1.5763596523153074, -1.576461909384537, -1.0589195009967496, -0.7857727724973864},
    {-2.008881137444904, -2.389636567014578, -1.7031155705809171, -2.277194558216108, -0.7121459367977707, -1.9997706196645262, -1.2744944159353517, -2.68479577861769, -2.7342486078594215, -0.012480050648277376, -0.304781354734591, -1.6113698592409784, -2.008924540296828, -2.4872035197906754, -2.527835701774285, -0.9144860912763517},
    {-2.2957568496989507, -1.003816150533596, -1.6978017110438486, -1.5826729786231015, -0.18828871765208766, -1.853966547225987, -1.4540513310201664, -1.9684330725731267, -1.9225175376668258, 0.23944418284528982, 0.09580282843049795, -1.8764121789639232, -1.1787092702008397, -1.3993634440992644, -1.8675919617129222, -0.6316498116383105},
    {-2.014233691302427, -2.5034311466483596, -1.5920480873190104, -2.7788841247010847, -0.43852056269424927, -1.4548931749049523, -2.2390774685011126, -3.0488776231623524, -2.721243520668097, -0.338404599518238, -0.03808134001242765, 0.18496287935575242, -2.8514204950627278, -2.8307604848416883, -1.6695152313821116, -0.9068180731572002},
    {-3.146299314605275, -2.8542979386292826, -1.5309507399234457, -3.2181813716065144, -0.6961266162173596, -1.5143391194401379, -2.4421219645326993, -2.8215157477827675, -3.3714426051958513, -1.0266323270894921, -2.086055623815326, -1.5439940971617947, -3.308914927398653, -3.230660272300645, -1.8142867721815876, -1.2898051694459793},
    {-1.4123623072256426, -2.686791421659781, -1.3305054452241607, -3.201561025680541, 0.15794972130135318, -1.4038877923269986, -2.312881848142595, -2.9958788835937034, -3.2013106161864977, 0.4502865229713599, -0.9598007238011762, -0.1168022069901507, -2.6125897655035244, -2.852963611975603, -1.424644916425316, 0.12185808840329881},
    {-2.7361687091399123, -2.858313216296074, -1.6217495820458758, -3.0625082740709852, -0.6673801018367899, -1.8765549841060967, -1.9449194457890107, -2.740016265365983, -3.3380666560104455, -0.39654568268520096, -1.0099312668432208, -1.4948046168252536, -3.3615119185020066, -3.047173651552306, -2.1357107629156995, -1.6049683237035235},
    {-3.5186262854723163, -3.3857083763562112, -2.0189909241795667, -3.096937025868147, -1.8778391906879803, -2.260733844987514, -2.634427935537557, -2.76734565641476, -3.023313702116227, -1.3412585365588223, -1.898769274577465, -1.4228684864992598, -2.9718331537879106, -3.2590882663489458, -2.4600196550221436, -2.1443658360212567},
    {-3.5418934126027186, -2.5651623073653345, -2.013511760364063, -2.6586236611907283, -1.496126956363141, -2.2618879827511305, -2.3291786884527905, -2.373983767195755, -2.7045353199177335, -1.3358036742101178, -0.5023124672365209, -0.7523987741955668, -2.606140817312335, -2.525945341909506, -2.3809196315103205, -2.1792650473465383},
    {-3.4700030331845433, -2.5623155310360515, -2.288022323594628, -2.6047523339824403, -1.8453424878314255, -2.2705355310239557, -2.6839020701339846, -2.6524895185111164, -2.6317500731242656, -1.0419533051195304, -0.4658764992192364, -0.6466129020269027, -2.689782015281033, -2.4031314575530853, -2.256430597797553, -2.0306587186759577},
    {-2.8047270878063593, -3.1347806134633918, -2.6661268763332298, -2.8154436422930904, -1.6119776121967533, -2.7264678737269943, -3.7418075431466895, -2.778410363926686, -3.11411199411909, -1.3228069671584322, -0.08992849236689106, -1.276761921833957, -3.200606813576825, -2.8259133997611725, -2.770141047961267, -2.410557931581937},
    {-3.269578023936611, -3.298654901692242, -2.1710496510924795, -2.9469176670480355, -1.7048718282913708, -2.9347868055334283, -3.821383463586197, -3.5064055965189516, -3.2979632156017957, -1.4666870147252555, -0.6219354322392939, -1.0351464912092827, -2.9166030627905255, -2.735503360169835, -2.6094733227154494, -2.815308249574863},
    {-3.7944654954461146, -2.6617292657588014, -2.147420855005802, -2.2646618987068017, -2.4582270671690147, -2.1138726641029155, -4.095993417370741, -1.4519026680833704, -1.980725443034575, -2.7954997339451473, -1.25592778990814, -2.526065222036047, -2.5785475744776534, -2.336527493524066, -2.526205335295758, -3.5271568087894942},
    {-2.9021074632033983, -2.391235300566394, -1.7673605763091995, -2.474752815637197, -1.380025849566728, -1.3282345802695843, -2.998429524888723, -1.4410976456673141, -2.2560814413227326, -0.6640767336025791, -0.7663842712493739, -1.0744296754633884, -2.2748076486216804, -2.147027742045123, -1.4479511454070872, -1.7633340039607495},
    {-3.1991798703820273, -3.6570045860251823, -3.1623443096248067, -3.657090133280748, -1.6729589286610205, -2.581603034629248, -4.014524507575237, -2.7573873196145766, -3.4364701559706647, -1.9123104315842707, -1.963974739934259, -1.8327767942928825, -4.05768812920656, -3.645298754190715, -3.3894114044781087, -1.829063562652612},
    {-4.100460497482722, -3.694245896894556, -3.212625551726206, -4.139041100529637, -0.4477697579493176, -3.2952660090735364, -3.9600981345948156, -2.1542410686017366, -3.486609005638757, -0.9271542749986643, 0.12216188754745488, -0.08631372647371575, -4.187901971898823, -3.8137327522758935, -2.9877250431147444, -1.8951992061912135},
    {-4.131830317611873, -1.8766146000992163, -1.7881941139093243, -2.347971569298598, -1.7845736148503049, -2.4210097175712777, -4.117557248499681, -0.3690811739814087, -1.8252541711043304, -2.205535310861244, -0.07132059882859053, -0.3528871576865001, -2.6047812255828786, -1.7221195063071015, -1.974817140802961, -4.063202601002321},
    {-3.1603526157793613, -3.4661954628517115, -1.954459039664036, -3.4299952647681717, -1.9189578098798161, -2.0785119691388223, -4.670139676121821, -1.7544167373927566, -2.8208651056220444, -3.2889440262801632, -0.9778062422722501, -0.8069716898241593, -3.7363964823069855, -3.2830645292745073, -2.1405712674106225, -3.281946867327701},
    {-3.345084779086602, -4.117464260430685, -2.06683561308709, -3.770511749026237, -2.144098341840927, -2.2152504375850834, -4.703545423566422, -2.5284148869986813, -3.6971805055866627, -2.1539967230445156, -1.9528054118119484, -1.5526416941559942, -3.886480162380849, -3.586804856942864, -2.760633349095928, -2.931844195399726},
    {-2.746178635513751, -1.3304924484260097, -1.1528018664996327, -1.8872965220870423, -1.4104706384486172, -1.4782315859667774, -4.283813710073901, -0.011839635006514262, -1.101499620540756, -1.947623203650871, -0.9696794636805538, -0.20809013698526152, -1.9762415596525753, -1.7639320138578203, -1.5805723232929048, -3.2284454913774296},
    {-4.347724814367265, -2.942907724010593, -2.9709520421045785, -3.704002455705404, -1.286663765052424, -2.8389323751956073, -4.130056860491763, -1.4690480949683529, -2.715370789334229, -2.1439480542278315, -1.118129755734861, -0.029883714214014218, -3.641358136157179, -2.9831947058438972, -3.2136813590918356, -3.506584856014678},
    {-3.4892748627674695, -3.389084958130142, -2.162881641117089, -4.1632964138299755, -2.5453764893657684, -2.6437980552157465, -5.375518602418341, -1.221335493866587, -2.771671120993233, -2.352915757596618, -1.2607013433614351, -0.4237481191312498, -4.5730208027361146, -3.813579332989737, -2.3861012156140333, -3.4507446144118417},
    {-4.167623583832646, -3.2928844130230313, -2.7869848940339135, -3.473567606534482, -2.742815499403762, -3.1227625959244696, -4.797386434998376, -1.474411857919649, -2.6594655178058955, -3.0582060225416097, -1.2593016894527, -0.48356840891045677, -3.520181196611794, -2.984753459807037, -3.112593109280328, -4.308375122354197},
    {-3.236049017721571, -3.1857546915772947, -1.8178296265418088, -2.876867846108788, -1.9547537525603635, -1.4794021846579946, -4.482674176051815, -1.6629174217223301, -2.6560398424475204, -0.9747927119829898, -0.4696890709068402, 1.2927925049725784, -4.494230233497871, -2.8224209116904233, -1.310163346922036, -3.182862249786378},
    {-3.2086620171148623, 2.4749834479943464, -1.8912841018175255, 1.831301086142614, -1.1133912111203748, -1.9724117359100426, 2.1417675468308084, 1.3664359955104746, 2.152621563622385, 0.13186244250112233, 2.3578509015977605, -1.8999580900529054, 2.051258455781674, 2.2634271278753437, -2.0299219516669726, -1.186693827810039},
    {-2.7001620790046266, 3.4304132723228835, -1.9928955178765806, 2.327589878793506, -0.23075949896538325, -1.8414012196972478, 2.6211582578108175, 1.1829062054511859, 2.0831493404945083, 0.6359633355690214, 2.991089889092406, -1.5852529354442406, 2.396624455548144, 2.7796055126618913, -2.1039600759141073, -0.3046764559759442},
    {-3.4518521770439574, 3.321349820102533, -1.9059800848942838, 2.2425028308886508, -0.4315646039941927, -1.9796223071324794, 2.5835058340985446, 1.6505493056284668, 2.2488779323915837, 0.36484226032679534, 2.9601598090202352, -1.482357608854677, 2.317095920754337, 2.6563299551963073, -2.119929201489139, -0.8643206067329801},
    {-2.6946915775217324, 2.7323539204493263, -1.5403481129389522, 2.469819281321644, -0.25369469856169524, -1.5927797980368852, 2.638560518070269, 1.6148033868571452, 2.3551376996047213, 0.5408879131361863, 3.0900622308721744, -1.8349774955643103, 2.0892491388008576, 2.6345117619025507, -1.4136490360303666, -0.2429275242088707},
    {-2.4141985807653414, 2.519724028836538, -1.5753137570453812, 1.6825372553166889, -0.004134371879070262, -2.0391885115824993, 2.468361574632201, 0.9304381065988754, 1.7938343041083407, 0.7001498516502801, 2.452537318842691, -1.5136479172124955, 1.5960060225653112, 1.9165777159189592, -1.8495666855013453, -0.3921279128255852},
    {-2.317657151912768, 2.7325116862431575, -2.024311889992676, 1.592123764486969, -0.050796659806550834, -2.284613485986298, 2.5677047680960694, 1.1037585334122861, 1.4276714427335162, 0.865771678655862, 2.944165790836928, -1.27054331118957, 1.7066576347615758, 1.95144925485661, -2.1249899399938283, -0.26562081206634386},
    {-3.0061596205908505, 2.3310556980774657, -1.9712798779439855, 2.037400954564704, -0.15599660512949232, -1.9919274344648552, 2.186090059378793, 1.2312905230671432, 1.7444580695422085, 0.5491272357973661, 2.205765890837557, -1.6077497793882396, 2.0855921269225646, 2.2936061048290375, -2.080530929368298, -0.45778005757720036},
    {-3.0901721476371162, 2.4991304480689545, -2.4813986063299396, 2.2240110399158, -0.5981261816516024, -2.54831972404024, 2.354929311769821, 1.270757799662996, 1.9977125719079618, 0.1852680122214094, 2.494917407979628, -2.073026260130407, 2.2034925261079277, 2.566300940617946, -2.5255901004352834, -1.0143664335110725},
    {-3.1296190540567905, 3.0255247585616765, -2.6959182498830514, 2.987731251327643, -0.6077481431243621, -2.405723437320165, 2.6757438108629144, 2.243239456485056, 2.84786342743111, 0.2829887501171205, 2.904657397354816, -2.0260047295285637, 2.423617092716248, 2.9649782988330817, -2.9581324162350113, -1.0756454304302956},
    {-2.226691480212375, 3.400877375423103, -2.0174638425217855, 2.964328949893831, -0.2969166228462407, -2.253493831073046, 2.550826831950194, 2.5163790820177807, 3.2597974436755943, 0.821226502451411, 3.102664394926907, -0.9902763063312204, 2.638006570484728, 3.102885000072284, -2.382675896877973, -0.19239552482704628},
    {-2.470500898821783, 3.4789714304546884, -2.2425747768537843, 2.9720284149053513, 0.4119226962997832, -2.240733274256479, 2.90902188162569, 2.241114443847144, 3.0542882908096747, 1.069572283679683, 3.543579296185816, -1.2046589911084622, 3.1202528844495814, 2.9953186827928264, -2.4474173366077694, 0.06234915596172425},
    {-1.710068712676181, 3.6394997774934583, -2.100324309495359, 3.0479573829383515, 1.1759502409280982, -2.2158405239993586, 3.10123332856778, 2.435821779818798, 3.3890018803428634, 2.235213158965544, 4.112861780083243, -0.66104387091908, 3.0691057387625134, 3.4826118815288956, -2.358726976135935, 0.6814260513305909},
    {-2.2326112576696264, 3.090914229539444, -2.1873138552484983, 2.872036728190004, 0.3433982915180164, -2.4839436426471777, 2.6540536971739677, 2.356018436822629, 3.094016752956025, 1.2385168192356157, 3.5356041043651683, -1.2398586758032264, 2.5699374767660736, 2.9120351050623747, -2.7858513440273858, 0.3199084482029375},
    {-2.7592299895665113, 2.504624134236556, -2.3750492710441065, 2.3329855990952306, -0.3854645666658407, -2.410664175924358, 1.946374221790234, 1.840900618616571, 2.2295091599823063, 0.5481713692375522, 2.867094137849041, -1.9186063019557302, 1.9129511228906866, 2.5117042749532645, -2.6573571651953443, -0.49880300473529365},
    {-3.4002854238819484, 1.9126408353807933, -3.0964196416892324, 1.5185894474221562, -0.6872052120430495, -2.853751759280301, 1.2333367161682174, 1.4473661252507082, 1.7830269630975428, 0.2947555752211067, 2.8289432791795828, -2.157301448661117, 1.176536516829777, 1.683814874802083, -3.332276754491823, -1.2788155298705228},
    {-2.920968751307669, 2.478996920979274, -2.7080734054707842, 1.788448321914053, -0.37553907953650273, -3.0469930249510973, 2.08536255294905, 1.2068713620753875, 1.7830167068419178, 0.4150344945927322, 2.705368145482495, -1.6778901673385918, 2.151402803183451, 2.047805913777288, -3.261750011323539, -0.6143287348368697},
    {-2.424988916947515, 4.200172305676471, -2.6189720946276536, 3.3286819920075295, 0.04106547540681645, -2.855972037053779, 3.2237012956453457, 2.7500455968774795, 3.3573060098604284, 0.99295513733315, 3.462771557479593, -1.039800468943291, 3.3456748794072646, 3.5422046017615494, -3.2355916295338343, -0.10993350228262252},
    {-3.204009963536539, 3.72057414611838, -3.5416230514219236, 3.019570238417618, -0.4911010483630308, -3.476890334239228, 3.073469177479412, 2.121475685851746, 2.777452972724229, 0.49471626083443443, 3.6684234512800336, -1.8746512947024276, 2.5756875954538945, 3.502249700746724, -3.512945075299628, -1.1230992901743424},
    {-4.028218369357531, 2.8480495216505117, -3.69344384482502, 1.5060793202382723, -0.8361709230506246, -3.834190157590373, 2.152987386671296, 0.8075724161349741, 1.5787613249978207, -0.048490128360415274, 3.2777680381212475, -1.9908227220206285, 1.6441898557545245, 2.320204093351382, -4.19895730816592, -1.1003395820495725},
    {-3.505306538159879, 3.608598427467455, -2.5216958530879836, 2.6252278781756027, -0.7644050856320802, -2.608507448371358, 2.8063673680196906, 2.7945716723629785, 3.0378916087426573, 0.44938151671084575, 3.67364070936475, -1.9537347084713743, 2.7937858578658554, 3.180272960000294, -2.976576075620103, -0.8212713233288655},
    {-3.3781158427498146, 3.1276250868350877, -3.0115182121939625, 2.4137060556658394, -0.8218317148149202, -3.09350798990813, 2.637824924173962, 2.161888664350452, 2.4987632010850236, 0.44100442782047816, 3.146297923205086, -1.9242127993324991, 2.0997633840922187, 2.6161201756059946, -3.4116162933408516, -0.9278463700644326},
    {-4.038836932754903, 3.0562394379000555, -3.30987836960616, 2.1819585927732903, -0.848189186653908, -3.3918656716382145, 2.6123839931583803, 1.732143666214491, 2.4364269304738566, -0.02718218526181179, 2.8165013300688737, -2.1294578867430065, 2.2205405015095874, 2.378883579425852, -3.473186325784701, -1.3652551579267735},
    {-4.183835277644101, 3.4221312216063327, -3.4854575492981006, 2.665080791224717, -0.8129599977183285, -3.584919248127099, 2.5364622628721856, 1.9052380585592532, 2.507625945111701, 0.026061908679666936, 2.962265917522829, -2.1537147729323673, 2.650133603538092, 2.866869160693421, -3.9045229494590794, -1.0561890738466135},
    {-4.071683950354953, 3.7382890619010403, -3.622569061063654, 2.4963667604810573, -0.5601229983141051, -3.708486012996301, 2.934027987397345, 1.6009814000888194, 2.7865916815753473, 0.4416320047916464, 3.302004166868608, -1.9306528851513078, 2.36444096534981, 3.195165813708564, -3.922117229807538, -1.0706435789475097},
    {-3.374742871378186, 3.8123485382590103, -2.9448802859162377, 3.0841134823462193, 0.20088393585749154, -3.1064350814163544, 3.3777149825619937, 2.331051493374828, 3.404220745207058, 1.3836750668180167, 4.052053531550658, -1.9312027502181905, 3.246214284918763, 3.713694908739789, -3.3337884710322, -0.6579749633415508},
    {-4.231649876194695, 3.62018592693295, -4.013793301902684, 2.559137391820641, -1.312681539925247, -4.13596362946497, 2.621141228815345, 1.8296011313219858, 2.9060151022704934, 0.03748200409909417, 3.5650769643130746, -2.91860973050772, 2.742995967847354, 3.2264295469461666, -4.335599135710927, -1.664285049620911},
    {-4.08557539086522, 3.5716072165333586, -3.8178349361390924, 2.776350036176555, -0.6596922595490674, -4.02463244856543, 3.1565535823736868, 1.7404982645887908, 2.6327030197593366, 0.7635369695630277, 3.6918327368920907, -2.2137350297490173, 2.887988263474829, 3.005221700877979, -4.377796184425242, -0.9519926116997166},
    {-3.814318305420816, 3.9509632885481305, -3.362411024695742, 2.789103138274286, -1.0325224880673072, -3.735870544907737, 2.7872950043631817, 2.30035134193663, 3.1864523748772866, 0.4342283534311771, 3.7828921079992157, -1.8725106867444465, 3.2393842078075363, 3.482711743668722, -3.7726016063180476, -1.1844701455277475},
    {-4.267915240718959, 3.9134959841701833, -3.4948795118670595, 2.7359002785093653, -0.808730338903008, -3.844518105964575, 3.0654550688114615, 2.2914320060595603, 2.8544777931233423, 0.7437672102471933, 3.9623460750039325, -1.9367049621274839, 2.7278039286119227, 3.253018820802289, -4.061971089524708, -1.335505622943507},
    {-3.768219906964175, 3.895621760977399, -3.542590690458563, 3.2378887403115475, -0.6052413228762343, -3.9007994412992466, 3.522064553073872, 2.4032671569411, 3.1555747542664956, 0.7367643851457738, 3.5917372247953305, -1.7639002533375967, 3.0886804520777864, 3.7378055026536487, -3.9193162643556643, -0.9706306450201173},
    {1.0028660679083954, 0.4675567788815107, 1.5539884613075172, 2.164370297928408, -0.16927839932979047, 1.7429163333192483, -0.9035422934232953, 1.8043364492297356, 1.3789025347154087, -0.540032957468138, -0.39714394925881613, 1.7988972043836529, -0.5114266234630571, -0.14613506675652435, 1.0727522922724286, 0.6584983452722407},
    {-0.8753915194046076, -1.4244015315855973, -1.2451339871852194, -1.843260582165683, 0.016865720076709473, -1.1839168707098973, -3.4761028337471984, -0.8726570005680898, -1.4924771587122083, -1.7667230049915497, -0.47111234070534325, -0.7133883258787147, -0.4271141143122524, -1.5043548424509599, -1.2510007994640282, -1.75866561115269},
    {0.6801696274628246, -1.4363913905817662, 0.4225173312571922, -1.378919574398266, -1.064846683839304, 0.7046305120869966, -2.1022727239191163, -0.44074700067490535, -1.4253957206477523, -0.30037306951664394, -0.7675435797389774, 1.28463677392881, -1.6313248930161488, -1.6010409397953056, 0.5360382776509265, -0.43668638850156966},
    {0.5874086106243971, -0.5595159488970609, 0.7207738203641233, 0.04913469883287459, -0.47808514428648397, 0.4306726243023513, -0.8187507740063478, 0.9045517990582447, -0.15891434008034772, -0.03766990583868044, 0.057058402265392896, -0.10124850848062679, -0.6212772390384619, -0.6273574145731805, 0.8570644802305943, -0.5508513039782471},
    {-2.4644169964904075, -1.3029689330106804, -1.1364391999043717, -1.8558122276082665, -0.7526587199227014, -0.8948360548302364, -1.5733250105032102, -0.9825764293343812, -1.1838660057041992, -0.37246123206979903, 0.12088916154712682, -0.11605064165208419, -1.5576236428202084, -1.3691072285471226, -1.5020998245342931, -0.9934693069673397},
    {-1.3885787183711897, -1.4684638089342859, -0.5268222195898816, -1.4306221546387317, -0.5318140593866773, -0.9234324563454775, -1.052212973340102, -1.452603750543935, -1.5185619141790156, -0.38364995908440047, -0.6480217011897642, -0.9278761424916343, -1.045566739509139, -1.6140190014823126, -0.6936739360555279, -0.8047505353842404},
    {-0.9880527923782062, -0.41354681583172287, -0.16809006328688422, -0.6860545279040362, 0.28586312921570844, 0.2685273528566272, -0.3816965320398599, 0.03303253929964382, -0.7850621520138747, -0.0026066393714883267, -0.5527392314117533, -0.1565352712922598, -0.6782886468068544, -0.920494070418342, -0.45410747353592723, 0.005334737161975103},
    {-1.0539788421542955, -1.5217519474602004, -1.3763303967423282, -1.6540891525172838, -0.39256376651065406, -1.1490958905797615, -1.5019626881349706, -1.810591840204963, -1.9608719897091087, -0.44718894879365445, -0.7100895550282244, -0.7678525515628898, -1.6585112205761607, -1.8330262872776693, -1.437339443405085, -0.8747845421675653},
    {-2.420054978665311, -1.378841842826597, -1.0938953048348714, -2.045513894874445, -1.3814838373208418, -1.1269217147326254, -2.2031163400304634, -1.715153745134169, -2.1389807102681773, -1.498696720154756, -1.3409739416908786, -2.0810698463046973, -1.7452484245618878, -1.6486093552802183, -1.5499288040145078, -1.7133328228628104},
    {-0.8793023382690619, -2.335862177121287, -0.24229781273189638, -2.5362560711811803, -1.3525352969971378, -0.4212394944358165, -2.3535816314392983, -2.082325267701034, -2.233021944874516, -1.3440080926697757, -1.1364147438845085, 0.31602657332471507, -2.1540506351111306, -2.5767378551723277, -0.4102411642546636, -1.2600809460792068},
    {-2.3941842113275364, -1.6888876597543032, -1.5585077586998743, -2.28772093144649, -1.144428072633004, -1.4713922342602623, -2.194968603139836, -1.2740901270862195, -2.1121158218631884, -1.2690866231091844, -1.590181425723772, -0.9999756761043729, -2.1941966718123833, -2.3653087834800552, -1.493754363423208, -1.6433938743334666},
    {-1.3119917855621603, -2.468736727728419, -1.215629439098439, -2.0780434488006616, -0.37379280172225576, -1.0465530467002224, -2.227018929368639, -1.9127243469969488, -2.4523720542497793, -0.6059158406552582, -1.0192142573872356, 0.26540256635580634, -2.4711274750618126, -2.640769472665306, -1.0576647082574697, -0.3001042792465662},
    {-1.7907671462566375, -1.810173939335317, -1.0469536050983292, -2.12700565027934, -0.792808110744564, -0.6714939052635258, -1.6878501229437315, -1.6105032148590972, -1.9822711140961398, -1.0317479281818054, -1.066972867567837, -0.756028013538379, -2.629507538604736, -2.041873993674514, -0.7551968843577842, -1.3748646151440533},
    {-2.4075797981187685, -2.472301198907049, -0.7997975295133707, -1.9356209245273082, -2.4335899832546555, -0.634974291301664, -2.6801578773911734, -0.9695814980849777, -1.6679574120697624, -2.152324701573126, -1.8222513665403615, -1.3690440401340214, -1.9250317449219039, -2.0507308879073594, -0.8574209446346719, -2.662113761255941},
    {-2.0088229927098826, -1.58526022429468, -1.0133517841890125, -1.5031429205501887, -1.2160586294047087, -1.0336751417837182, -2.0724966007917316, -0.8720356847265447, -1.2404330706417184, -1.141060433712701, -0.2681138279340755, 0.37115190654090535, -1.7174879898104807, -1.5142591219116341, -1.0347295578144726, -1.7972622527755877},
    {-1.9068536854853364, -0.9430684928357064, -0.8391908273983606, -1.2312899293071258, -1.7475462335661818, -0.7313310760363467, -1.6507704578497948, -0.48848125203233844, -1.1037721229657613, -1.478272812271585, 0.0688152512448941, -0.2747783952801609, -1.2428345801189826, -1.2561526217195913, -0.5896747691797307, -2.0725728592380626},
    {-1.8517421566141983, -1.5904644161642822, -1.3092424948623942, -1.4136930376630017, -1.5241588720715578, -0.7694428208482165, -2.353253690732966, -0.9275240500833406, -1.3507332240631225, -1.565772288208872, -0.5600993369043169, -1.1868933608743109, -2.2055374755580197, -1.3586561997477218, -0.4460563582072454, -2.2486015460955286},
    {-2.6727278714740668, -2.3765119648125577, -1.2378262608812654, -2.3813155400951493, -2.382443043719989, -1.090879510662859, -3.7273700523374695, -1.6706938728152394, -2.0788130500190483, -1.819325404887352, -0.7561622429546615, -0.725680862332934, -2.8527522517289055, -2.0597122549275153, -1.054687235309188, -2.8264787900719477},
    {-2.2066146000829407, -1.4564405245124497, -1.1371495024097504, -1.375908031760306, -3.0497619458044527, -0.9015530997973511, -3.759371712328014, -0.12099825951142476, -0.8606460727302409, -2.583525004201481, -0.8067196349593275, -1.2822315222817404, -1.2928256599389798, -1.2395549789091316, -1.1332501030087672, -3.3385111663079674},
    {-1.6652901455483313, -0.8749477394727405, 0.2221848052224672, -0.9529478205873556, -1.9384128324187433, 0.2524944796782706, -2.45928921849806, 0.1451237535810277, -0.3039801764525871, -1.8188357185524162, -1.2798342497849995, -0.6717953133734771, -1.3771734188679328, -0.5742022843686928, 0.23306414663127814, -2.15715058224516},
    {-2.499707923452352, -2.715233395431693, -1.482602822248292, -2.023472712893777, -2.707695371058693, -1.008270513553223, -3.7626729105248904, -0.6589491713458409, -1.4419114465203786, -2.6152614459237613, -1.4584544717702075, -1.75518224995998, -2.777239371225475, -2.306149648602779, -1.562586554325621, -2.880483452991154},
    {-3.2249616276533533, -2.624549656220899, -1.64290770701466, -1.9981753351772804, -4.428401481587501, -1.1366691327122302, -4.696625977959242, -0.05742170253179786, -1.2589189772835836, -3.8606184225297517, -0.3378155173325259, -0.7090253255135046, -2.768884453276767, -1.9396691911955664, -0.6490111847807147, -4.613286939187359},
    {-1.86346656215846, 0.06224393512258978, -0.01630131459451283, 0.38021154510300853, -3.9008390697737165, 0.5249002615002696, -2.943717402283276, 2.5148512185690595, 1.0447272606657485, -3.323148356671839, 0.06378312348088776, 0.45176716060587635, -1.0585887310092943, 0.4845512980735723, 0.9493173829697837, -4.2732727319639645},
    {-2.21385785920494, -1.7523565711710956, -0.8616195799907416, -1.6698567722948654, -3.2518561028622517, 0.03497783954950744, -3.8063956743898824, 0.5573913062475638, -0.7864355210456673, -3.65323613186849, -1.1902859971582944, -0.2725906714759154, -2.573139589045983, -1.767548305447394, -0.29673718080326467, -3.767554864128844},
    {-3.2802333360210443, -2.5114802199196955, -0.8338200640365317, -2.2200485796924205, -3.5416667855985993, -0.6855487111671625, -4.232120036247555, -0.3152480037762266, -1.5274578794278726, -3.1551949248145355, -1.775916214444954, -0.587763227745803, -2.4983525994440843, -2.402491705991739, -0.9132398184836489, -3.662089641859174},
    {-1.957588418084531, 0.07174225876410924, -0.7101673181948992, -0.5949460075977908, -2.7308170658825386, -0.20859861285806822, -3.5183006364806353, 1.4977238709206488, 0.2216469232451938, -2.4812003424381546, -0.3007338987954219, 0.8172910739201722, -1.007956025402812, -0.4189883750405934, -0.3415569103797808, -3.5270919706912847},
    {-2.7257206163357535, -1.493879015753675, -1.658370545274485, -1.705793265962508, -3.6929650384237647, -0.6637893551695512, -4.697514656472858, 0.7677131693082815, -0.4682004153072173, -3.8742924670708403, -1.393353793827806, 0.6222871743849178, -1.901589413596373, -1.3846236415187796, -1.1468996802629208, -4.674306671619887},
    {-3.503700989572645, -2.529156146458207, -1.8078232901788058, -2.455071949201501, -4.351277864445486, -1.558013184457468, -5.329429803018805, 0.40043870311088575, -1.1435472241269307, -4.00633826188111, -1.539406392803763, -0.19596348693123736, -3.207644764018999, -2.5543829269410305, -1.7392019958789278, -4.780622499221334},
    {-3.3676089934612587, -2.0729479948870835, -1.744973153613184, -2.132389166040968, -4.156425768522411, -1.473189976658411, -4.810887482316024, 0.5128610979918619, -0.6933871345656816, -4.0100703543352205, -1.485592633353547, -0.6920361932154891, -2.6045157274471857, -1.8953043963713998, -1.4467489550045292, -4.870184387427493},
    {-2.2846114523782584, -2.4896359096361325, -1.0838278630158853, -0.5611678345049532, -4.0023993605968595, 0.1690751420713166, -4.699615793896896, 0.9260483825664331, -0.20877636008802636, -3.672402378033826, -1.792149641724454, 0.9298086129953236, -3.433833700244127, -0.8432648674910823, 0.3616683578540245, -4.595135473799756}
};

static const float b1[16] = {6.835623879103809, 6.18669306920122, 6.326148398732362, 6.2023293333523535, 6.2778630748878905, 6.269398908661894, 6.701863602797469, 6.5574823400535145, 6.319786116691869, 5.986653401944915, 6.362858656750746, 6.834100005543739, 6.37291143070025, 6.305779962940479, 6.549766634762211, 6.338658384407142};

static const float w2[16][12] = {
    {-2.943047028940731, -3.1194633220377983, -2.575534922157293, -2.7983180532864798, -2.8608544204755746, -2.8662917748548815, -3.1172778878039575, -2.8777013819077495, -3.1669545852809597, -3.065694420369737, -3.0767942823471577, -3.351621627598413},
    {-2.828631319900734, -2.4337546712543134, -3.0511260645615246, -2.826421507682224, -2.5984500947890345, -2.8626655785370883, -3.3473677351892266, -3.374835069651874, -3.2132331958474993, -2.2716344043943146, -2.545484281389849, -3.2264906814437566},
    {-2.666553455650873, -3.0343166203950704, -1.8592523662374476, -3.989104920736463, -2.834429042294299, -3.663324019341118, -2.6513488831172656, -2.890567594263017, -2.9867323257783958, -2.933585398649421, -3.465322094825623, -2.6270819269142063},
    {-2.6012811973732646, -2.741396948445305, -2.514224428276196, -3.7005517745480425, -2.99167520384697, -2.3630275309188375, -2.5944952306717033, -3.2059619000603043, -3.126273655765721, -3.105127822648372, -2.5969483538907827, -2.593439026951606},
    {-3.671709022221069, -3.0700687047133774, -2.6406397732852662, -3.4450787521387283, -3.57164031923677, -3.289324720759639, -3.336696046954885, -2.9734775417459507, -4.010587896162487, -3.2881097576052727, -4.281211471163336, -2.0004567443145413},
    {-3.397802393097644, -2.9802354916314844, -3.01169098275541, -2.1757801825252394, -2.4582272556416394, -2.685112993916872, -2.8681991884858267, -2.606312233727917, -3.343749140889417, -2.3814630853003522, -2.113098385264411, -3.325314353672409},
    {-2.921246085053686, -3.214139369453431, -3.1676365564595543, -2.933843093189023, -2.811578603426903, -2.9268703763369652, -2.5896178840634536, -2.8037133497871345, -3.1711690231109717, -2.6192832268427955, -3.065406026437595, -2.6120777325536433},
    {-2.5111267310890777, -2.4752857105178028, -3.386079448778076, -2.717751876148849, -2.609743120830763, -2.792812981713165, -3.3914808569489603, -2.848612998272149, -2.874534346749909, -3.0210958836810824, -2.9195561844159723, -3.206578738601744},
    {-3.1945580753465084, -3.4850966193526642, -2.724079358356495, -2.774472905143603, -3.1166705918297524, -3.1312775649372937, -3.257909349929148, -2.976341166197532, -2.1026585140991454, -2.864688695362227, -2.2348532118374416, -3.2308463512700505},
    {-3.1008318585107437, -2.954782308378292, -3.5162280548175593, -3.2420393811797936, -3.3271936703109533, -3.040224655531553, -2.5536623814511348, -3.7311762204722148, -3.087175007219815, -2.6073786183943057, -2.639772623039568, -3.9691164380932094},
    {-3.4664350620004294, -3.3195593228413394, -3.117398152112941, -3.4210878107452505, -3.371115111008504, -3.326376385251688, -3.539801563392689, -3.0092062100322368, -2.9491689991246646, -3.7074399274450305, -3.250573513809051, -3.3692185906671415},
    {-3.2728720220039347, -2.693801124370867, -3.4491217173085387, -3.56381599694068, -3.6901405467559822, -2.901812423450189, -2.7484830320754896, -3.104216263096928, -2.1678048838317134, -3.124006709989522, -2.530344249167526, -3.0178774194165428},
    {-2.4033291091682965, -2.868074734358279, -2.3625259355916794, -2.205034313664244, -2.7896580193293143, -3.556964858263321, -3.229931183469676, -2.8784220884971994, -3.0018469766700755, -3.2160077988502485, -3.2591995309569137, -3.159388565458379},
    {-3.437379557516602, -2.8593966626781584, -2.9453617602131996, -2.7823045903595185, -3.0059206275719488, -2.394587203414106, -1.8782809186852982, -2.294210371311703, -2.9321390530432927, -2.9299533593968925, -3.5342890127857656, -2.0551324736908314},
    {-2.7167772648728814, -2.7022465142239236, -3.996964464021199, -2.6868021248440086, -3.39662184387191, -2.449688955105611, -3.104088056176537, -3.396212142950639, -2.5244577866031355, -3.2635468775852132, -3.1387606212769117, -2.6837810357860348},
    {-2.6492398281483625, -3.5323411059958576, -3.3769431026276058, -2.6265935970048884, -2.6847335867869067, -3.325804002432183, -3.4404918607977653, -2.886221632165021, -3.2947416600712045, -3.1193634505858685, -2.883116208146469, -3.286308071351934}
};

static const float b2[12] = {-3.063422352505744, -3.29309969904508, -2.0218933125876664, -2.3458593761988715, -2.7123201569840107, -2.0277750321966805, -2.5177997131995307, -3.4958977632619153, -1.7075461707290565, -3.1556083276665388, -2.95116650505557, -2.1534733306399674};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
