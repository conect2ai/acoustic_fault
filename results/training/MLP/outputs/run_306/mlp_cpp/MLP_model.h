#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.4517747713878657, 3.9822358163060736, 4.206467491552367, 3.657751169700305, 4.256358512690014, 6.647896317840793, 2.609112065664687, 6.46668476897966, 4.256106359016868, 5.983346189221786, 4.050041484210641, 7.062732079842512, 4.643820364187464, 4.824311370141712, -0.41927454420039484, 4.090549907011889},
    {-2.837525497315264, -2.78908733913778, -0.17885433134967693, -1.261820038433958, -1.019370336787616, 2.6451436366194336, -0.4920158512036936, 4.134285840185142, -2.693093256098818, 5.503309909434149, 0.0969838476944678, 5.1133446536692615, 0.6490928173750686, 1.9515666579510322, -2.662392079109665, -0.19832886804779126},
    {-3.239983005308385, -5.424192749163227, -3.5212057255669227, -4.631918034492362, -4.758340677712627, 2.1406971428750357, -5.311898590886089, 5.402074139714466, -4.685112753754014, 5.176335713249315, -3.6558625495010717, 4.914315172134614, -3.234792258104866, -1.4838465685530533, -6.040322513120875, -2.8588428270724746},
    {-5.236141289870667, -4.014609409815562, -2.001620114896778, -5.175236058827521, -5.429873497058612, 3.043452859217228, -4.154451951203034, 6.234098016331157, -4.468323028314342, 5.155645160112588, -3.0675003740651716, 4.55442583982481, -1.4480683882650884, -0.5846757816493354, -6.7581543801210024, -4.567118079540329},
    {-6.779827252558667, -6.667227871700399, -3.9366331033584907, -5.282953345221122, -7.028441111039909, 2.2098254669969553, -5.671905010360119, 3.619700337636871, -6.274409312385877, 4.192038948822576, -5.857882895997114, 4.546082041753496, -4.702316723179819, -2.79432722102481, -7.475262101421467, -4.86762726717552},
    {-5.6120197636562725, -6.524843479128882, -5.269190690261462, -6.000186298291589, -6.555152710854269, 1.7217887957986378, -6.7220346802294975, 3.548821546624739, -5.848177137440373, 4.236560447126121, -6.291171981972536, 3.297901264252902, -4.858275496253345, -2.507661664513065, -6.192467988985985, -5.188536699685821},
    {-5.318738703425754, -5.95164814405778, -5.858267646216849, -4.477604155420535, -6.031084647365002, 1.8955111510160345, -4.9047480823196885, 2.7129093368877624, -5.374026227878974, 4.791222802659111, -5.968997255422126, 3.6124499627706985, -4.363116051171936, -2.66341699091959, -4.832715585698702, -4.814304558524934},
    {-6.404890880930729, -4.386589438908208, -3.6666110334395037, -4.864879934663256, -4.796040706371067, 2.5512547370899936, -4.944850729749983, 4.883219433660642, -6.174967532593877, 4.671123680931438, -4.757625651737216, 4.1840743911117855, -2.7574229286981384, 0.18050664243938358, -5.9111718173419, -3.2191918589837973},
    {-4.905956146873336, -4.1952940123728295, -2.0619616036922683, -5.454077886266847, -5.025052500369697, 3.9626932649088515, -5.961601959471751, 5.340028740495265, -5.839281333515214, 4.68231835364724, -4.673362336734166, 3.5205649238339514, -1.7226597382862985, 0.8323089288869651, -6.720188386461811, -3.2985125324177678},
    {-5.10301119745095, -5.945527135218612, -3.2671077559755464, -5.69201932021493, -6.260431035661353, 2.5029254446113547, -5.448975683870389, 4.188270533116923, -6.088780352830721, 5.526264117961963, -4.181493856868821, 5.584272994702192, -2.647480310336996, 0.15431482193372234, -5.363592876676072, -3.602987092552992},
    {-5.432278135801578, -4.383859462436317, -3.1794756286038584, -4.018046061292287, -5.707494055527441, 2.3794289799712516, -4.367497164348596, 5.215754505841573, -5.602294879698518, 4.89541285123528, -3.161488689225735, 4.624546946620858, -0.5453274375555456, -0.28269062022575014, -4.050813048235431, -3.0838461535442},
    {-5.47878650941558, -4.244021202523483, -2.992577407879967, -5.230906301587097, -4.82966819386264, 4.171563291350979, -4.683820868400334, 5.068973706212788, -3.360282526972345, 5.000736896282141, -1.626296780258403, 4.193723477221774, -1.0743355698353036, 1.431372043137943, -4.01448635107621, -2.1925354724248067},
    {-4.069611945896825, -4.178849782755352, -2.0584030904651427, -4.897762281476465, -5.728533433771837, 2.3746336240674975, -3.8137300886978647, 4.472245179826175, -5.068144855102946, 5.31900151738189, -1.932208854107745, 3.5289277089593387, -0.25092675603711867, 1.0918207489475724, -4.055466431939961, -1.1171148915770874},
    {-5.606841207061319, -5.54675798994882, -3.3118771130207953, -4.53178166884314, -5.042259943445492, 3.098224726681889, -5.933629186089031, 4.268579811043036, -5.426852056941352, 3.67767488623195, -3.3759805445687943, 3.940102500323789, -2.3179978994429713, -0.24784013810775155, -5.7641730516217375, -2.4652428981204952},
    {-4.628900150700782, -4.902803163769349, -3.9928007863973067, -3.413686054247534, -5.776995823161254, 4.098451950410527, -4.952680848660536, 4.317624737483304, -4.345164104399226, 4.478743459381328, -2.9710244322464248, 5.030764736683934, -1.316189880354442, 1.6455492409181542, -5.000700246749661, -1.4471123226286238},
    {-4.652940636507709, -5.312800521548542, -3.503160055472852, -5.649191309739888, -6.4415097215815145, 3.2370337834564915, -5.930847210529485, 4.6455143147849265, -6.972917003829705, 4.690197640826191, -3.4611202813163473, 4.192459429020062, -3.3779929419637518, 0.1474657690765888, -6.389833750495935, -3.1604017255349115},
    {-4.527644443596764, -5.290460091764643, -4.382613575115275, -5.121602698413582, -5.603873483036597, 2.512022018602638, -4.03312637891451, 4.180755528901464, -6.349056319102332, 5.5627289757433696, -4.996952206862771, 4.795193562751356, -3.8617526196319405, -1.7333456148634352, -7.164046111910836, -3.3515497561053436},
    {-4.632537788918818, -5.169663174007995, -3.5559778614598145, -3.6658168307209578, -4.85783449082182, 4.103273074648887, -3.6479226985215316, 5.2039059288455265, -5.158242193909309, 6.236956892799111, -3.2121570676041986, 4.616281625057243, -2.819361086872211, 1.589790343438835, -6.146121974976344, -2.455456135855507},
    {-4.5136243682439305, -4.692928867466478, -4.4573716961356356, -5.324330689901558, -5.502856174818423, 4.370698365577034, -5.557885328078941, 4.966723215850873, -4.532370668233967, 5.135528717172972, -3.906343164800855, 4.7970946807665396, -1.9544267680035923, 0.706035207039575, -5.130010199153554, -2.2560087530030892},
    {-4.873405862017882, -4.6288755236210966, -4.3380398137656355, -5.509485086256982, -5.866477210289006, 3.550535061318367, -6.224587495521974, 4.441115946139894, -5.333165534414016, 4.786367736548352, -3.434820198780943, 5.39204064781114, -1.8145715652932342, -0.15430404191707087, -6.834282574220273, -2.489672169123818},
    {-6.492803435778874, -4.29598021883131, -3.5844231888007427, -5.301429671037781, -5.954198992217307, 3.465661668794018, -6.048271741069665, 5.847853419083175, -5.316092538927833, 3.937100777804769, -3.873512739662757, 5.528196708521309, -2.6518489876819347, -2.147721440710958, -6.168030966709451, -3.7328223884559013},
    {-3.76377688226002, -3.3385585660845756, -2.1359773723866953, -4.937198068728366, -3.8368027506956928, 3.5209284217615093, -4.762092220852861, 5.471964614220018, -3.0450477072799966, 5.004847299650992, -0.598503571414539, 4.936212829299215, -1.5180849506982126, 1.2968143731198014, -6.489359081550332, -0.7804240727720264},
    {-3.075303943615659, -1.6959342762456304, -1.5565689599436143, -1.596316847905226, -3.6049286265697313, 4.028469010315801, -1.3508783122519386, 5.369980997313433, -3.0606707489574942, 5.976509797804121, 0.719602258633914, 6.642684691469939, 1.2752430120473432, 2.212753461989692, -3.941291876284422, -0.4949752919955975},
    {-4.0706131454385215, -3.633209119601857, -2.3829864340037368, -3.3054194071476206, -5.047721756899935, 4.069187174991857, -4.476466216196129, 6.122403864502768, -4.680584014980126, 5.553499795635369, -1.164427261267295, 5.581402741346513, -1.9906541746483308, 1.112696349829533, -5.015845155953407, -1.5886376496347383},
    {-5.7851176473616075, -5.429731105767078, -2.7084143777594263, -6.204968974853894, -5.521419764415171, 2.664523912625027, -5.210428867066309, 5.23734388868527, -5.636976462213114, 5.59076557033074, -2.8939927485944046, 5.804719633692624, -2.770435944551323, -1.3604256001175683, -5.257385270529806, -2.583296747359322},
    {-4.96940334107682, -5.33038163976974, -2.9190362270418957, -5.474367975090606, -5.468413273202796, 3.82806152760742, -3.921021530267321, 5.167268372053862, -4.117021990359022, 5.543822439359472, -2.0127718684503773, 5.477573787182702, -1.361938373166531, 0.35603450865812203, -5.048520787145206, -2.8046624900810455},
    {-4.266955903322068, -5.365993867157741, -2.755438182428626, -5.207757604818256, -5.238673377709306, 2.9171915970907962, -4.677762813735463, 5.36084932304704, -5.391496289569614, 6.029701638806483, -2.1442842598571015, 5.532270187435436, -3.026707350354096, 0.08370053598660611, -4.931801394724414, -2.991103302866284},
    {-3.997007085673813, -4.7705792907061815, -4.018274145505832, -5.736556196700916, -5.16192357109933, 2.9839217722601474, -4.369124389886786, 5.041450947469334, -3.963506828382297, 5.2798750383003, -3.3464377323562, 5.369222437739273, -3.0150910632402654, -0.9275633364843777, -5.113712819815535, -3.66126219322394},
    {-4.861415548463178, -4.937417320694048, -3.253261920295253, -4.8963309100903425, -5.404261967818442, 3.303075842219409, -4.175391744102294, 5.886514164116475, -4.240047196382286, 5.3385054863132435, -2.9842075154730856, 4.983351780522286, -1.3865645792737982, -1.2712057925610263, -5.007753273543783, -2.24545266926996},
    {-3.706473144048797, -4.2372111368114735, -3.7797679737720906, -5.28643252721929, -5.7957205644674366, 3.594317772894232, -3.094279316643266, 5.075933970127085, -5.185326073620656, 5.179923022319374, -1.7359868084076562, 4.6433292717141805, -2.575262808375374, -1.6428556117600441, -5.333659357549641, -2.5225503636965785},
    {-3.465579479534381, -3.5329253135356606, -1.6319649782070524, -2.6126825440554295, -3.551947749925501, 0.7368785071586149, -2.8338747657363648, -1.8120908943070562, -2.9455778959278267, -1.0869820276157127, -0.9803193009085174, 1.0265009201933688, -1.9765112899547088, -3.1530260892986983, 0.5763418635496662, -1.4831914059857978},
    {-0.8423499385294105, -0.8726120446651888, -0.0026154650746714786, -0.3517091078885718, 1.0336387253441197, 1.2064179922267173, -0.03313233976862753, 2.9346443637226036, -0.6988789085776876, 3.8428821720497996, -0.660142603497919, 4.294159610024412, 0.36801053246370813, -0.024005874847681474, -2.6129448138984954, -1.1471553924509321},
    {-3.256825226293341, -2.3908270114089465, -2.284809717181057, -2.4352998224647027, -3.4268213907251592, 1.8883486088358812, -3.578564685581902, 0.1765853676766022, -2.1946462131028652, 0.16517460673259685, -3.412476571884181, 0.25576088654198414, -3.284950784858071, -3.0800117174631825, -0.6503612141678766, -2.2597125784142773},
    {-0.7060575796544337, -0.7958807187560554, 0.6445754806254803, -1.3090707115808387, -0.1091334466111906, 1.2547616171329958, -1.1748764113730858, 0.5635147392002787, -0.38608277753700393, 0.6065852501154076, -0.9561735756087177, 0.3723356766678007, -1.3585066443436011, -2.756745485135818, 0.7901339479288654, 0.47346517683867034},
    {-4.643186707558464, -4.1434042993095455, -2.914729772136438, -3.202348893060256, -4.605355506534582, 1.5762008147347844, -4.167629875849044, 0.3865557286720026, -2.9942853728681142, 1.5180465802064405, -4.052754136971763, 0.480934642981035, -3.7453571354888524, -3.1524732554149453, -2.608321951884603, -3.852394055807683},
    {-2.637747948841111, -1.693037906475004, -2.280406553915019, -1.592745919447596, -2.3872635468632315, 2.5458752325921354, -1.9668495335045904, 1.4310518294356986, -3.257696147728936, 1.9020664424898146, -2.6181238632477197, 1.7757571832087815, -2.830808838077023, -2.1517499207814126, -1.9968106900825722, -2.153358603555367},
    {-2.3091022245331487, -2.615593298941999, -1.6767681108264385, -1.3865941041847125, -3.3670575816623094, 1.9019949424476164, -0.9968627605716601, 0.42849528661722486, -1.909902208540884, 2.116030694562734, -2.653436887025687, 1.4543227617631675, -2.7650301477634422, -2.8663240164599593, -1.3197088037925035, -1.6660133412518168},
    {-2.2180438468311614, -1.4829608027259287, -2.0144518842929395, -1.4428094902655444, -3.1133314685441937, 2.2928449700749503, -2.1967569507302107, 1.5429176453154905, -2.247943724260826, 1.8720122552174443, -2.6186169420921996, 1.7239830667465827, -1.3937707371171653, -1.8972509736417535, -2.3031410203357505, -2.1167980962937007},
    {-3.628536183450466, -3.5712762627425017, -1.69059806683227, -4.333522819552532, -2.9269521852106295, 2.704872554366095, -3.240208958741959, 1.639303908402852, -2.8505030933500928, 1.3901075238916694, -3.1693983331001347, 1.1758414050741315, -1.6669641689184573, -2.489813691446042, -4.464619915936481, -2.5107244770679427},
    {-4.561201596145571, -3.710548703020271, -1.93215860768153, -3.411364634877906, -3.600245837755069, 1.0151859100621452, -4.239548139150576, -0.02761107723378111, -3.2980926881387447, 2.26617926545371, -4.90784447181682, 1.780332231438495, -2.6989951826083427, -4.458183250443076, -4.320528539352951, -3.837375396636886},
    {-1.6576382187893832, -1.2999997421815739, -1.185300363377237, -1.935440329647125, -2.4200025161401686, 1.414961535063563, -1.4206307109333192, 0.12906552481213152, -1.8175442665704293, 1.577958504451571, -3.099847701649468, 0.3239165946132758, -1.134811659169158, -4.027719849311723, -1.7851455862077066, -1.7550076026682977},
    {-3.3349550622960757, -2.7282916735732003, -2.1380855882494445, -2.955667218794041, -2.2135709922976083, 1.2357119111273462, -2.881071417716535, 0.984573397725568, -2.9055410076074177, 1.4299117951272702, -2.6318818701613713, 0.5236258555295749, -3.025761094950181, -3.5596981632484637, -1.8687140428012572, -1.9539445052930642},
    {-2.387051233508751, -2.832844749668231, -3.1909195946888302, -2.5952147286601757, -2.1999052249552746, 1.8493577785591069, -2.418240345038566, 1.203395907757204, -2.86943431671744, 0.5149514894128819, -3.8917138797722344, 1.2905239146966512, -3.3924075928790938, -4.732690686488449, -3.0628409354527877, -3.8338653681702626},
    {-2.4812323159507725, -2.9308673528277596, -2.8501993012843285, -4.129077545696856, -3.794763869996915, 0.6158858629916196, -3.603388718618437, 0.2397483238039636, -2.745466095982852, 0.9212430244980507, -4.057906553777184, 0.41526226929403826, -3.1935077504707814, -3.8462816254073293, -2.467108296741905, -3.4909966339120575},
    {-4.938918301477777, -3.485115733387875, -1.9806359852867246, -3.5846405970902384, -4.7422916225533625, 1.9472859881048534, -4.807266680651956, -0.2712183175599446, -4.532490435434618, 0.7726333158495141, -3.673367191170409, 1.1128575264238452, -2.6007523580521967, -3.9219095703964757, -3.9667317707263154, -3.1984497478487675},
    {-3.1881746746294883, -3.0343336652564474, -2.8879143428223113, -4.13532490422529, -4.684891952722234, 1.8326418574184713, -4.289822245187031, -0.20980902113209154, -4.301173384810509, 1.3591260050677236, -3.9878582122358495, 1.2331338811230403, -2.6675006643195442, -2.768585693828301, -4.178493877526934, -3.359039089494302},
    {-0.4075381721232706, -0.9313762097206846, 0.16863393918882197, -0.48153535621701515, -0.8866509381398013, 1.9031406746612827, -1.732719959008737, 2.1236313592689595, -1.2965972424739147, 1.7543633603413549, -0.8133465746014564, 1.4198208413437563, -0.4545803220578892, -1.7234251528150777, -1.8405553229785696, -0.9077349957325912},
    {-1.594370327932265, -1.6461614729148009, -1.2273222023084376, -1.7498228627128494, -2.460807346538761, 1.4015708137269125, -2.728330851204095, 1.1660325679165766, -2.300843525450887, 1.8355532514366495, -1.5832851770389473, 2.5807960447286664, -1.8859518206945034, -0.0468035391509846, -2.3844837886268997, -1.0854720830548874},
    {-2.855213130418528, -2.210362100737032, -1.2355154758306264, -1.4372409620065398, -2.7270521735839166, 1.7317918623373736, -2.5572952956119024, -0.07349200034732971, -2.34918456683955, 0.5362938317872785, -4.14383570476352, -0.44846849586107285, -2.898125907937308, -3.175745667134222, -1.8433356513727093, -3.244954096708577},
    {-4.616407696908228, -4.687223740875092, -2.0916583810773792, -4.522704471862458, -3.895989714523873, 2.476295571274951, -4.536499042067803, 0.5422014551029567, -4.403663064867555, 1.0407417420016252, -4.291694260087624, 1.7643431707689323, -2.5786761853550506, -3.676999425045977, -2.2541038022897673, -3.0973671004582046},
    {-4.772570806238152, -4.2705115173772, -3.7444837353319436, -5.231229422073674, -3.385658557529266, 1.4103320463430238, -4.400641463162777, -0.1435606824834174, -4.148753507618834, 0.3566034649406512, -3.8803299433363954, 0.08069652769804593, -4.588349148391653, -3.9809060612909652, -3.372843049395483, -4.581254829426609},
    {-3.900681838386152, -3.257064899841103, -2.2180379063555082, -3.702383772300742, -2.0658269978555626, 3.0101729473629546, -2.7338025772707693, 2.6984533709307406, -2.584609702154244, 2.9210236121173647, -3.8591225899805224, 1.6372256037716288, -2.3578694663376023, -2.9117446013531176, -2.8526485623990334, -2.3563265201632566},
    {-1.365977810714283, -0.9239895773518568, 0.7662715414878719, -0.05432577261958105, -0.5085585622912211, 3.1469005011487163, -0.7034466111180795, 1.309087585529426, -0.9681743230465276, 2.839425610560672, -2.2372444763701327, 0.723647626304224, -0.8100012788718941, -0.45904787989644563, 0.5194412316058169, -2.015283316628652},
    {-3.2935904056993213, -2.465595108661344, -1.2917936996302377, -2.2306992451798227, -2.4036165411593355, 2.562335633736723, -2.180776003197025, 0.727640687352973, -3.190378439300263, 1.1916682243891603, -4.1140101176640576, 0.3948560831667017, -3.104468864687786, -2.6205427637954033, -1.7935195585493686, -2.217539398967717},
    {-4.124474314650353, -4.155240464039148, -3.5288428447828513, -4.151377247512322, -3.590659392307085, 2.683497042177747, -4.640947022865467, 0.8319510424130874, -2.521590889864477, 1.76517878621668, -5.094803287134527, 1.6731787628649737, -4.625185441536324, -4.3355328278256415, -3.0568846144492254, -3.2175314154291454},
    {-1.294977921490725, -1.749075472155291, -1.021399666667775, -0.9434564725890464, 0.24622640620744182, 3.589856668801259, -1.1530942264405972, -0.05865184589877656, 0.6332378664125773, 0.16813501578776852, -3.166550207082836, 1.1857378484336625, -1.2304365497567595, -2.868845506241032, 0.923250321284317, -1.0493894159232209},
    {-3.9997311680865235, -3.0270686737235395, -2.282483693380452, -2.8140268460563083, -3.4913877859791573, 3.225310783391428, -3.664257742651404, -0.11199125282512686, -4.03770916467258, 2.648152037651775, -2.4298706422810565, 0.5114450633203769, -2.973331112620559, -2.20873755858397, -1.2830980988915812, -1.5305686177962825},
    {-3.2220772637677944, -3.005757888139461, -3.1870420135602457, -3.2374551574498915, -4.4559692299812435, 2.3058881511512572, -3.464402857614338, 0.7038630200613185, -3.4323405966178364, 0.7868173889254323, -3.5157794225029453, 1.9738009213429604, -2.322219880575714, -3.774124034113481, -1.83193346674626, -3.139598795724592},
    {-2.9173017095473863, -3.0277204900882926, -2.9366501088023753, -3.9957288670928865, -3.830150594025887, 1.5176403971128127, -3.069832849283301, 0.1379692703398998, -3.309858766885401, 1.9836174748531687, -4.634079467652215, 1.6045911590803337, -2.42787657583666, -2.9669880940761506, -1.6742714033241979, -2.302510789008346},
    {-2.477918969008842, -1.137587256479098, -2.2154810429072724, -2.8281831248692044, -2.950447361746617, 1.5735262464024795, -2.909155399241299, 0.6264019964227054, -2.930941247671637, 0.24168538382543822, -2.702960207024305, 1.9459121012502447, -1.4734285638276536, -1.7365341137996224, -2.8991535343029224, -2.8148821556331534},
    {0.6986698902268726, 0.38354705785101056, 2.056873121466623, -0.5418284093203943, -1.157034601181004, -0.5386066942474631, -0.278257328944159, 1.5505875339128043, -2.0656470395125375, 1.6394324986749251, 1.3816848963353119, 0.5821552195780957, 3.294618459201497, 3.002829623015621, 0.09759877908521467, 1.5838770828684594},
    {-0.976023646234404, -1.8720310302206842, 2.564324850933542, -1.6465415323671222, -0.3619355294576552, -1.8996927232554617, -1.0030687899003015, 2.663657119301608, -2.085699863558995, 1.1383388576357665, 1.798949987282192, 1.5754195812745486, 1.8901019301349398, 3.4876576317409755, -0.3208418416288149, 3.0754851917830397},
    {-2.251481199146525, -2.7310628461557935, 2.5972254851867986, -1.2241715069389942, -2.1850593372931386, -2.4816597881144173, -3.121433241807434, 2.0737780715786367, -3.0534977128542993, 1.068542366106158, 2.437719574503926, 0.7611765932501228, 3.2697174835510965, 3.79611780563705, -0.22139433899570135, 3.530361970488335},
    {-2.1262104141703535, -1.561069002300679, 2.7476535548176213, 0.3558445952748403, -1.2609527439107693, -1.5177139832684907, -1.3677256819936445, 1.7699719095752875, -3.086353557270395, 0.8400199422442494, 3.66088535342275, 2.483073367284213, 2.4969987964366207, 3.799813996437446, 0.49921965207648855, 3.9467521144604674},
    {-2.370809406517881, -1.2227832914172712, 2.268516232412367, -0.8016496718692435, -2.5591952950783945, -1.6730776353180135, -1.9229837638341352, 3.566338606651825, -2.136285154417708, 2.175183230955938, 3.541830317433041, 1.7626806793295056, 1.8832640776992562, 4.710691712548649, 0.8178385830024425, 4.01672001333825},
    {-1.7229505890508408, -1.6003869629262006, 2.870571322957916, -1.2027351225620404, -2.036350787952422, -3.5061343956479787, -1.8486407278027197, 2.6378999842950184, -2.704522916064179, 1.3236502875765968, 1.1956075905859818, 1.578907256251815, 2.235009549095498, 3.671508862684472, 0.5980094107632105, 1.9515110248920144},
    {-1.7508178496988174, -2.0430162568207257, 2.585987628215554, -1.9164219278896772, -3.6231835988120658, -3.7454799390709455, -3.6206814183582816, 2.8985015534679883, -4.5902011038953585, 2.3429553928438738, 1.8241767203650832, 3.0207822618729234, 2.7511796793190264, 4.525413932661494, 1.5004280681164228, 2.421711128623038},
    {-2.1725002639237614, -1.2167143294295997, 4.061010779739358, -0.41718819735508494, -1.6241477168909035, -2.340879955547015, -1.6674044247588917, 1.780015437266334, -2.4732521499422138, 2.4306059324433558, 3.290617468585353, 1.1020353194860881, 3.0310067497496664, 4.363805038952095, 1.0799592598848744, 4.280731543469673},
    {-2.034161087664043, -2.2427380114299704, 3.024750972410909, -0.3039433673027066, -2.358596408746166, -2.801628484593727, -1.8737545625500642, 1.9508539948306411, -1.921642686274897, 0.6150287397068743, 1.4840328713224489, 1.567215382656264, 2.273994933285184, 2.528991337228578, 2.488896653903194, 2.4783478321365644},
    {-2.3787911559141395, -1.2883276287051328, 3.6586182460094463, -0.682270662434187, -1.3680063544339178, -1.0532000717257464, -2.568738057026028, 1.3383921995508319, -3.1961005168444903, 1.2698051653664697, 2.9799366805192875, 1.4805276333410573, 2.2616992921949977, 2.500714679754036, 0.34743830116206587, 4.000535587813439},
    {-1.1765645088836159, -0.7774834143257452, 2.547971585454614, -0.9130130118731948, -1.8344072853254976, -2.731485807984292, -1.099075672216855, 2.883099089219687, -2.3832845353689946, 2.459572347618387, 2.0450064779634096, 2.713058389585284, 1.7571483613229038, 4.094914442821982, 0.24376011988303697, 3.017306908077308},
    {-1.0762822978164317, -1.9706568793288768, 4.4716846615606425, 0.27950166140687815, -0.49124349273522916, -2.5505442895432964, -1.5427328011452202, 3.8391431592206557, -1.981625531559895, 1.7804054130849063, 2.5348934535676206, 3.3732503901769664, 4.110887062958748, 4.715138486494368, 1.8032585772171488, 4.172330629035569},
    {-1.0370240484482947, -1.1240846731853504, 3.0491182938802797, -1.241368773321674, -2.701031614604567, -3.3997450394507007, -1.8793035540208012, 2.3426516036567464, -2.2907349751797272, 1.3394191771812414, 3.0500221645914376, 1.972118402972614, 3.7079482481700285, 4.530156923347024, 0.8858786650989758, 2.877828078963772},
    {-1.3801197437794244, -2.472729951352616, 3.1353685485143505, -0.19377452641581755, -2.419076640278181, -2.035343490137767, -2.3268022861005386, 2.2259257174883986, -3.4115019789954415, 0.45549457486486894, 2.849423295059347, 1.2687640500317199, 3.8205805020417873, 3.835499166613955, 1.374137220461082, 3.376078532965129},
    {-1.9657664014733511, -2.0932870488273214, 3.614637824261793, -1.7974808271862226, -2.262174231213639, -2.1390513257162143, -2.7838406689552264, 2.114022675252753, -3.333811147998564, 1.4899072595664202, 2.9455410587251394, 1.569337002517318, 3.214325863790751, 3.319914729046212, -0.37924521647601783, 3.747950929574595},
    {-2.211350202350509, -1.4791921724242203, 3.290612018978881, -1.5273532622704649, -2.2224726346265715, -1.0494442244789248, -1.8185217997667247, 2.8495224877625636, -2.8390029830789887, 2.7787836913939556, 1.96196886077667, 2.276569985802511, 2.4519858992145567, 4.064710026295911, 0.303990236756587, 3.0998510102125323},
    {-1.5150396279144256, -1.1875670637723004, 4.117639567621569, -1.0733058519303424, -1.792818180263032, -1.7977151031802168, -1.8849889046910209, 3.967370976411699, -2.8032060685581826, 2.1381715891251836, 3.427995802668263, 2.8706104734839735, 3.470519899706323, 4.649122802567107, 0.22258039230104626, 4.8635615953878295},
    {-1.1156876540306129, -2.5927251002701954, 3.196603988781099, -1.4837796271235046, -2.202770599917104, -1.7333429575196921, -2.759123293280654, 2.52904789488453, -3.241021272042687, 2.591631749128234, 2.2819874877967994, 3.2367842595810017, 3.9397040086334454, 4.311939147997691, 0.4187196431386772, 3.212880534219861},
    {-1.6990552727510961, -2.5015388961197154, 2.804751035760353, -2.074811597265963, -1.5078207052769124, 0.2394562090248488, -2.2914957399450597, 3.529174618944009, -3.45693537245735, 2.4726624711043548, 3.0550182271378796, 1.9790220213821619, 3.031830869283299, 3.7359504502581964, -0.2534081051426225, 3.6534606767603455},
    {-1.480243161327131, -2.784040883451006, 2.106211990628064, -2.2322793538343624, -1.6687619265093716, -0.8116573383359672, -2.7304958919551474, 2.105230595182089, -2.119081309709335, 1.3432051034575971, 2.9770573058551237, 1.6677561359810773, 2.876083223245955, 5.09447068680043, 0.32829500461662287, 3.040522185502053},
    {-0.9835672352781638, -1.8071042548531213, 3.735631918624414, -1.5177243534770763, -2.4875050458296317, -2.2427777361539585, -2.164429986274069, 4.2661286179392945, -3.3902254455644476, 2.2948394577043842, 3.0561806773718323, 2.5756747190191183, 3.6956010562830106, 5.690840991438533, 0.5190900748545085, 3.2959981840576584},
    {-1.891065678945821, -1.6053141967736912, 3.491488314235432, -1.2455394813444554, -1.3791309779853775, -1.0494315826994491, -2.236064301533185, 2.5485348653023574, -2.3716429237326433, 3.004298567187565, 2.058571686800042, 2.9050138423875964, 4.084890536208588, 5.337546399388788, -0.1224541591623846, 3.632242213016812},
    {-1.3707069794498297, -2.1441411574365734, 3.5196122874453906, -0.8468982934463647, -1.5959769596770768, -0.39411205409314637, -1.8762685844272113, 3.726736198818577, -2.8588352484956556, 2.3911336443653504, 3.0904787413157617, 2.73682132006101, 3.5619291271515183, 5.67350948580128, 0.5162654711469544, 4.619443418398197},
    {-3.0441036069032714, -2.8038912605929722, 2.9627683537058056, -1.4146581859595049, -3.494963984938797, -3.4200103185453608, -3.268942038889857, 3.1817634659749827, -2.7436808201352374, 1.9488627997264756, 3.488588337701208, 3.024931253098378, 2.9235278819177632, 5.788187538384804, 1.605688362676129, 4.161835640217471},
    {-2.461730630059195, -3.090471199078237, 3.632173612860882, -1.5731702673553225, -2.8033155849583173, -1.6308053316311386, -2.7255625064391165, 2.885627345994217, -2.462060925347366, 1.4365654142987963, 2.292722412141627, 2.6212756217102404, 4.283336482634156, 4.350283102558687, -0.34153118952139566, 4.458558869411023},
    {-2.3064341421247776, -3.002763737897299, 3.818410007527148, -2.157613568807141, -2.310785661627671, -1.91170797397853, -3.4440474576129922, 3.6670378644283455, -3.6741154747664804, 2.4767869858449036, 2.585216463454983, 3.428975470664559, 3.255566998399897, 4.743828366390274, -0.9847046141782778, 4.255356307316094},
    {-0.8521832832829948, -0.47619942496827267, 3.786716669881176, -0.7977661028785481, -1.6879559534999844, -0.2050104400172414, -0.6569742919771013, 2.567332596952201, -2.666173062146365, 2.885245550166521, 3.542996335053811, 3.075406327677987, 4.337349266094087, 5.875354770982459, 0.15924202170460797, 4.438057718291443},
    {-2.7082366335816523, -2.6647817471087447, 3.696786259922061, -0.6919080596758294, -1.5914004675111508, -0.3572919035448302, -2.6180529665157004, 2.613564738959387, -2.9390106674392413, 2.10869891809958, 3.2239464210852633, 3.0773022608373513, 2.9102168823333776, 5.526915884372458, 1.3944715555268878, 3.677913465151629},
    {-2.60897778608085, -1.8167203661243334, 3.884197590405209, -0.6339098441093002, -1.9874923592144251, -2.6841524557573315, -1.6234286721758935, 2.8647430902659714, -3.3416003953164037, 1.8050601595387488, 2.7982787258236757, 1.720511617021318, 3.6581839254005617, 4.443899776781701, 0.7237823793121255, 4.6336674952549615},
    {-2.3939540977796043, -2.666843241226748, 4.325326162394189, -2.8607367476673, -3.2312195659738845, -0.6438015141232802, -3.0328137002111735, 4.2886347008108405, -4.373234865912648, 3.93797330743907, 3.4527772728346724, 3.680036668425115, 4.114594042131887, 5.202342031952437, 0.013192048044013015, 3.8772414530226813},
    {-1.4539616787195093, -1.0056272669603006, 0.6136589434556969, -1.1512008213767408, -2.214885674481202, 1.3642999333230101, -1.1606075724696294, -2.3237116151872184, -0.04033323501889932, -0.9962231489508173, 0.1739501302044939, -2.7635532030935166, 0.2364658039185309, -1.7029909750307026, 0.8284929894567413, -0.3294772588934178},
    {-0.5269898047054685, -2.619517140728046, -0.9137558479974177, -0.7831488399395984, 0.7855063806575087, 3.0233623398016616, -2.1537128083252868, 0.2648164293436908, -0.8606247893178581, 1.1473084114791399, -1.0672232796119352, -0.4887124054985958, -0.4752150104902899, 1.6466655502469276, -0.291216487973561, 0.807333498830324},
    {-1.0250986926697647, -1.9199356309438294, -0.04424358819944183, -2.2750821864727215, -0.057948124308531794, 3.0165568809757586, -1.0462157212198981, 0.13369534175618042, 0.15113655461726647, -0.11129665182451705, -2.529010346249247, 0.3432390640477747, -1.6951557200373475, -1.983687512216851, 0.18898286097491726, -0.7376410943664684},
    {0.06732322459785581, 0.07268339204109357, 1.0576559455467371, -1.2937479724580354, 0.11515402801421716, 2.2974762756668046, 0.3578833334845287, 0.1630632818036969, -0.2911234313663701, -0.20962408574955008, -1.4077157225053074, 0.6772323777131195, 0.2897756014905325, -2.2398240692388316, 0.4598237246708912, 0.39988937314841994},
    {-2.392173449787993, -2.90258882267094, -1.0873575575073977, -3.08472087307116, -2.685742198259597, 0.3756939940454205, -3.1331307097161014, 1.025106381899832, -1.8777802748226826, 1.0990123764682564, -3.0713594008442455, 0.7612350840298687, -2.155295338826094, -1.2573592800237445, -2.5944440959681763, -2.217033839578581},
    {-1.3389104484003054, -1.3500663945550038, -2.2055990848549896, -0.8072309893977236, -1.793493997706988, -0.06689300525941852, -1.4850245433634097, 0.9763519133792378, -1.6573117222391576, 0.9154168533371578, -3.299280067159016, 0.7708511247113585, -2.2571976696055884, -2.720429917268947, -1.3460361549715383, -2.1977551269327527},
    {-3.189178513201401, -2.7038801990621164, -2.176567140478789, -1.352951385678758, -1.8512836906611476, -0.22891581725829352, -2.6632119820187237, 1.2883103864631582, -2.962098469394478, 1.2902301617778233, -1.5501457763359827, 1.3334947879019599, -2.2066292395496117, -2.4102625670865305, -0.43081208536950655, -2.8217589144275648},
    {-1.238488010365114, -0.9859758418654856, -0.19469759898867062, -0.5923780159930735, -1.3933029537321577, 1.3732597580578136, -0.5769750998410067, 0.11586069355783117, -1.5956223511235883, -0.055516578616164006, -0.8411531130853818, 0.04421109361377339, -1.6139624657994456, -2.45520498954053, -0.13692497016333952, 0.031094901725085188},
    {-2.0830204664270413, -2.0339228540464847, -0.09270939103953116, -3.0911983164553813, -1.030754091122454, 1.7378055010782667, -1.9331579516519153, -0.43174979557983356, -1.439353712744943, 1.2314882122410478, -2.777492309209808, -0.20173433290951512, -1.7397588569664177, -0.9401395646348478, -1.566582129313304, -0.4936429864080025},
    {-3.156710898407576, -2.7459382968711012, -2.110499788392315, -3.1682057290687426, -2.301512096035235, 2.8385583861314903, -2.814464954707974, -0.5440911932701126, -3.2767646424320733, 0.3828605265563874, -2.4774630436995855, 0.9937437531568334, -1.7618584978298226, -1.5468207448044555, -3.7241878665590202, -1.8806165732863347},
    {-1.4940920305629046, -2.097445658896923, -1.6817980852721106, -2.127341060764228, -0.6100759198975815, -0.02188167203322856, -1.5214858439608525, -1.847712377462623, -0.5379131442077656, -0.635472710403358, -2.2825503613824445, -0.6013698389709973, -1.7115818860929541, -3.7852338010373128, -1.3362835272149876, -2.155150545784256},
    {-2.4139496286055944, -2.4359723423819934, -0.6462936644614095, -1.0715669718724157, -2.204423012869599, 0.5885746478816343, -2.7318687383829903, -0.6023743952244922, -1.8031481923405759, -0.3330905094237223, -1.4748551862749935, 1.2982542624857305, -0.9235987023080829, -2.9027629792081147, 0.21230031966280138, -1.6280212045103772},
    {-0.8067911883588431, -1.6449959808103036, -1.230037040788536, -1.1620595510066005, 0.03971255958315222, 2.3951639582163717, -0.31075342458882466, 0.685979986283215, 0.566614885615762, 1.3500044640843376, -2.3397965628661375, 1.5841533465243574, -1.2957665652453232, -2.8155582831520585, -0.9764718191676252, -2.47167578225488},
    {-1.2101836392959158, -1.2115906748916698, -1.259770534467694, -2.69907506264085, -0.4189796701263237, 1.2687926958818492, -2.144165780804288, 0.24254615864608567, -1.5408859674711552, 1.0503394138760886, -3.608290242664307, -0.37458851937614734, -3.0891324228224297, -2.6228482368477937, -0.09073198072329891, -3.247470690893472},
    {-1.9170215164335906, -3.0132174444236877, -1.0198824810516447, -2.6506693058207005, -1.6700030034438218, 2.4082326757044115, -2.795834939324442, -0.34852019698419695, -2.6033987473623017, 0.7607093230542553, -3.7452739919164584, 0.6211824406319908, -1.5931596297802, -1.9949110805842774, -2.068914508271016, -2.087673978190304},
    {-1.9315175576778942, -2.2314131211489414, -1.724954023087543, -1.8411767427723935, -2.1410889165146676, 2.9642339464567358, -1.6026019372406932, 1.8461982568225428, -2.639661740848367, 1.2517332609955965, -1.021812973311215, 1.3821929602200058, -1.2214593305513528, -1.3530874780654172, -1.9660183741622719, -0.500256576069022},
    {-1.4265936430998651, 0.37305652848643, 0.18678475152973067, -0.2243833104879201, -0.2091809438547359, 1.7816259342877667, -0.2550060168127547, -0.40014331279424203, -0.45615264173708847, -0.095910193956873, -0.7039434264477945, 0.24680871620150793, -1.2454580988317154, -1.3109942028612378, 0.09255250907141374, -0.453207950070894},
    {-0.5446113446813814, -0.06645210743160582, -0.28713241884575275, 0.39227186609913317, -0.9203324504418952, 3.5980361106572714, 0.057702202098428614, -0.013288630481630854, -1.1600061470889507, 1.0936979169887049, -0.46027953693715773, 0.2916225467135394, 0.16602961417400044, 0.05822484759209624, -0.1189251826129273, -0.5495875781052391},
    {-2.0437571353498156, -1.4559087443271104, -1.0373715135518031, -0.14364713111940025, -2.019715042774507, 2.574183635615828, -0.9865087435023628, 0.026066353575531904, -0.9594510372325202, 0.7984466407966462, -1.6404811223333666, -0.780827662995583, -0.7564756427497967, -0.09146149095567672, -1.3496456659007883, -0.7343356586655102},
    {-3.0398712745416447, -2.4555537154386973, 0.4512671769469221, -2.5822591774213666, -1.4226984352253893, 1.5761160874225826, -2.7646227552877654, -0.0675344878529375, -2.2594597858279615, 1.2922598962478313, -1.467733714895159, -0.36574875893850683, -2.4481564945538383, -0.6965521206425552, 0.2223099320536406, -0.8916885375715943},
    {-1.4000920869215496, -1.763921829650025, -1.0561463439508838, -1.6281178785052166, -0.5120664690850927, 1.7394675856078272, -1.9216782752390988, -0.517528570369435, -1.0051821431755814, -0.25673411187221695, -3.3006577891508435, -0.7745907582025924, -2.767993664021904, -2.859823884749443, 0.7914708794017916, -2.870018009182318},
    {0.1250206177452053, -0.54597496882828, -0.44178067495140577, -0.23394496788549357, 0.14001192410128208, 1.9694440601887622, -1.2061510036978742, -0.8134397324686753, 0.002690658150560359, -1.6243977208799714, -2.4696710031217206, -0.8061296930644436, -1.3714240807287457, -1.7512549451600785, 0.681791442210907, -2.0687211575912667},
    {0.4468808201109164, 1.6519756890860435, 1.7821460762953931, 2.3439799195459248, 1.9021463250056463, 2.824699924648545, 0.8270289033385437, -1.7628911585469493, 2.251530198233978, -0.8857992321018041, 0.3768972437624706, -0.43960778082108615, -0.06020100909413655, 0.5668795235167666, 3.162757592613473, -0.168840294921696},
    {-0.16019815946969662, 0.2715465110057689, -0.38299709608563537, 1.1190168159117082, -1.725533494436993, 2.114086191912603, -0.8356226010431295, -0.9738441804557311, -0.14069090059074033, -1.9144659837393059, -1.4574777933357674, -1.647105694089502, -1.497457923539331, -1.0269584380141155, 1.7145084257802066, -1.4141628359612974},
    {-1.086582002903287, -2.256774762894905, -2.4738582700959157, -2.5963235085411873, -1.4310817763326589, 1.510811610408774, -1.4213236056629583, -1.0773216660628384, -0.7761277282549337, -0.025806590936393734, -2.78882042108868, -0.9504677129663901, -2.1667864883664696, -3.2258739136449615, -1.4535748847254608, -2.0677137427224936},
    {0.3082209477585074, -0.2669807866574952, 1.2186546144461647, 0.832970274206002, 0.21027311497972032, 2.7083729321709447, 0.7940862635399404, -0.691617844953136, 2.5106317721133076, -1.4568083256313937, -0.7196909463592388, -1.5977680786366308, -1.0608186059464175, -1.3824434922908186, 2.2075677723302913, -0.10644033751067705},
    {-0.14065911015661214, -0.48428724416024793, -0.20183277378061396, -1.4355349127839339, -1.225269650491058, 2.3664461867228495, -0.6307900623853961, -1.4184595630271926, -0.7622266436717636, -0.2774747342786083, -1.3468032640212786, -1.532869377767356, -0.43488018497825637, -1.150208109459147, 0.6846691885436696, -0.822191196810636},
    {-2.245584066297229, -2.02894110219607, 0.06833557382511925, -1.1184489654177543, -1.517889224312294, 2.2590468330615665, -1.943480223975997, -1.5515089550398864, -0.3828520371959628, -0.7879344662894029, -2.6131554114236883, -0.38194711930910713, -1.3454014365701232, -2.8136649322537037, 0.9405077483384393, -1.5437361721132838},
    {-0.41419028193261564, -1.0391991959424252, 0.6225602823492887, -0.4578298809666436, -1.2069879608401544, 3.2504098998524933, -1.9227949747033137, -1.401678579369166, -0.6883890284208097, -0.27266332126255766, -1.790407006624709, -1.0897141714779204, -0.9962438557223899, -1.265749854945131, 0.6789533832993008, 0.05949104958641686},
    {-0.6267014459089563, -0.2642318884572419, -0.11095695493764282, 1.1386745068354243, -1.2368259661769645, 3.019730170490663, -0.3595441554898555, -2.4922827810980173, -0.002257368325293038, -2.7059832116464895, -0.03362646488995179, -1.7775296246125658, -0.8584119135634095, -0.6841633996497162, 1.7971359833860938, -0.9561217179753605}
};

static const float b1[16] = {7.0384910161048895, 7.4091770182864325, 6.976160045144401, 7.414941795391677, 7.235197342495635, 7.522642311800976, 7.123108645583406, 7.489236881806602, 7.399022512092594, 6.927376803717028, 7.169594214742438, 7.20873746402103, 6.8989553658206395, 7.648294437570926, 7.174324207460458, 7.088348421687653};

static const float w2[16][12] = {
    {-4.337399077953574, -3.5735482393041957, -2.330216125739057, -2.9269607394571775, -3.1350429649138314, -4.374796826949272, -3.437032434811931, -4.066258254382229, -2.8831192756938, -4.389994265448434, -3.910870941000575, -4.527634501910882},
    {-2.7095444578583026, -4.4493579933488325, -4.22436902360159, -4.416325515940593, -4.57338854069757, -2.9822773518602848, -3.294816583540835, -4.275194799130263, -3.526682329242843, -3.4002326868307753, -4.344479871507062, -4.577440554497742},
    {-4.4677871728276815, -3.704250058728842, -3.3820755120770896, -3.905547688166043, -2.6144733870616834, -2.712486213329656, -4.257635348523984, -3.632308099439592, -2.517031009265725, -3.592459640633175, -4.378148161489915, -3.63592432499398},
    {-4.414748824520277, -3.9217983482598178, -2.8437710188165752, -3.551358527078975, -4.022984777164794, -3.662605778871529, -3.735615916952411, -2.866393875044563, -3.409896964396904, -4.614579374711288, -4.327953808505541, -2.7220857126987776},
    {-3.074086180707071, -3.574876603065633, -4.378661405473147, -3.6593843622903885, -4.20852918225731, -3.9364488369688613, -4.485997416595583, -3.408991624664632, -4.453403697782462, -3.8208164362496873, -4.56159923526157, -2.4991020941880415},
    {-4.305163749861527, -3.645944325122048, -3.929190425019171, -4.0692066048242905, -4.107148896853347, -3.6648305355469826, -3.9380335642295914, -4.110213305897524, -3.5557926317879875, -4.054242285671998, -4.055601153737659, -4.1266168038139766},
    {-4.069999025245403, -2.822882307409617, -4.7200046471921056, -3.1237194894575913, -2.650621630115474, -3.5131243718639826, -3.2569185991944964, -3.1675952359695385, -4.66587715435919, -2.9550999131616336, -3.17575365623243, -3.8048329817595956},
    {-5.003165435813976, -3.7499571015357445, -4.512397615824027, -4.931387545790686, -5.21205437926202, -4.032594883932007, -4.900723126266148, -3.4722351280054156, -4.414668097271449, -3.5859404588732104, -5.074284892378935, -5.231675185020953},
    {-4.208636816377486, -4.197115170245301, -3.3494038477506898, -4.628697817911253, -3.920754022398788, -3.925742385824262, -3.93394410685465, -4.47821589870357, -3.4587526707069682, -3.422514783675331, -3.117216111108667, -3.8474979483086282},
    {-3.648459692641534, -4.598031689888967, -3.6869005278744957, -4.125518816770607, -3.545857409679264, -4.985861654681903, -4.408672716414002, -3.9149521215144905, -4.6890324194717525, -4.689735728718359, -3.4201539173813362, -3.1494353624769875},
    {-3.6273576377025596, -4.361965326496317, -3.3704373079060903, -3.933522079236075, -2.9869572599759744, -3.5258668554707326, -3.73227087927863, -3.826266761325832, -3.8472454556699787, -3.2422080663009796, -3.4775157730941175, -3.7471741645800063},
    {-3.956202144970107, -4.7239771232126, -4.592494633969374, -3.6524247286921208, -3.9482507121404313, -3.971130976150835, -3.3773836496671064, -5.204929154519156, -4.02386800112687, -4.334558190210812, -4.178534361250954, -4.242600951318916},
    {-2.8046462532702296, -3.0782049560023794, -4.300723253092056, -3.7531439477313264, -4.258896857229779, -3.74860671118537, -3.249371817948311, -3.478377405087125, -4.281051991765954, -2.8647467016490897, -2.845348394932075, -2.979806943855656},
    {-3.86005973712783, -3.661158570016851, -3.657498660205476, -3.5337065545193207, -3.6123937646707915, -3.6158331099689742, -3.8243207144047933, -3.858909522264144, -3.1165217537334193, -4.252227013462961, -3.818932403103536, -3.675426084925041},
    {-2.980042017196882, -3.280508291801994, -4.430713147747818, -3.380151302507834, -3.6691259368002616, -3.7008091341066236, -4.390735544858348, -3.5621549932165992, -3.96968349751537, -3.787740793732339, -2.493296594550651, -4.312089031318009},
    {-2.9948396932388754, -2.8642090183004085, -2.579830676277512, -2.7093936724182566, -3.834161784117302, -3.7991115654291194, -2.386082679417022, -3.1311675628455093, -3.6165703601343853, -3.435127757062397, -3.2873659735250067, -3.306970557997477}
};

static const float b2[12] = {-4.125834084265124, -4.423152819173022, -3.1828921584492047, -3.6227553879003134, -4.189418533839807, -4.410467090801341, -3.6788687754646787, -3.409462472435958, -3.5689629374981737, -3.423080161851321, -4.324236284456255, -3.1748876615713035};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
