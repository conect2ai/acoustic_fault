#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.7766512997314323, 0.3258631244830677, 1.8098487436183732, 1.6390251553019568, -0.6883287054705732, 1.3949551748534064, -0.9196560983225687, -1.094478752867812, -1.484259363535958, -0.20210047419498847, 1.0163861882935474, 0.3146918510798921, 1.2326288986946274, 1.0370498039501599, -0.38133696388608845, 1.9406693622266313},
    {-1.2565201445100855, -1.27554908037139, -1.9709135633431145, -1.4830290882939583, -0.24636373814571702, -0.9210401344127243, -0.7670597127743628, -0.4190123383768708, -0.710435953182939, 0.05025636864370408, -0.9665970550650232, 0.7939907510189115, -1.8188390523286224, 0.0330039135117187, 0.5643158352761023, -1.0174170381309364},
    {-0.5896655768515208, 0.7415786942318331, -0.47678286898884714, -0.5045440397983529, -0.5556075942269327, 0.9184033596259028, -0.9759821010182914, 0.7010094923423893, 0.9118783224193783, 0.5023700845343276, -0.5339817811721423, -1.0044081312751383, -0.9740318511004225, 0.9122451794742226, -0.6690732937502728, -0.557551243803293},
    {-0.37534974880571786, 0.12707541682118945, 0.660336522178415, -0.3077180590949076, 0.6964144879942779, 0.6109589555929996, 0.24617956802389424, 0.4901925261884516, -1.206834972034539, 0.8790680593690775, -0.7270218599044312, -0.9816962410832314, -0.6103764967177872, -0.543185340323833, -1.0722941389084866, 0.5812995585928956},
    {-0.2605322333087825, 0.09950750567858486, 0.6418520382209507, 0.7626219631344979, 0.11624625731037388, 0.18322140424824154, -0.32505117729692606, 0.7230290839573111, 1.1348282119686635, -0.3617595078823151, -1.283383311475324, -0.4295078320682863, 0.019402628502595182, -0.863603271062153, 0.2532648603735221, 0.813342154014266},
    {0.4508571747656944, 0.8751222493613207, 0.23302437755483574, 1.7680902615770138, 1.2269089775513544, -0.10080558807506776, 1.4336112438246855, 1.2693062816701475, 1.69126559905973, 1.451209861725419, -0.323602017880636, 0.30083831618761325, 0.26333281047544493, 0.18178196860033424, -1.123814110149719, 0.9078846543100283},
    {0.006017214209539395, 0.41156812385051966, 0.55948266198039, 0.8386671724212361, 1.440102201795474, -0.22227752471908216, 1.650394231792442, 0.7722794732566866, 0.8002866483114708, 1.6276211702643002, -1.7159763136524586, -0.7181312851747157, -0.7741337693015238, -0.6645117122108453, -0.9648833166818844, 0.3597548700940563},
    {-0.8180156474622667, -1.9672419864989745, -0.4925479014809227, -0.25881910907725253, 0.03724160170399934, -0.2820436481082682, -1.0163950550057619, -0.2089952028576711, -0.07356735419993979, -0.21897098156856068, -1.4373765937648557, -0.08807628938752732, -1.418794827116142, -0.9296296311268756, -0.29731091920894964, -0.5573103719828048},
    {-1.5539045022104627, -1.723716053483581, 0.42314287261862193, -0.8105412943536712, 0.5116106544414829, -0.5093989463018981, -1.2874645070262698, -0.5463163273935089, -1.2455064489215335, 0.5096664270377272, -0.9030140977409569, 0.687695827371283, -2.288208031461234, -0.33664892773008387, -0.058425580242284246, -0.7251243197110693},
    {-0.7500467252367856, -1.5131225595468032, -1.3305173488524347, -0.7939323147878062, 0.47376809234033934, -1.6951224228249937, 0.09753516456591298, -1.1033607863063135, -0.4365013176836541, 0.29234515426398533, -0.6036777789609752, 0.14255238862372852, -0.8287809663797485, -0.7868387189516487, 0.5534654346105397, -1.4568741891539982},
    {0.1262337476645426, -0.5160641707829712, -0.05963949438996452, 0.4018680874685373, 0.17631551712169483, -0.213036608198751, 0.06184112968480381, -1.4771191545353832, 0.5170035269553036, -0.07877889789133159, -0.6319270758132794, 0.15113375115817937, -0.061627961896133024, -0.8483673725123412, -0.10501154331750703, -0.9941785002295047},
    {-0.06825469811158855, -0.43130186418988137, -0.19657649766574473, -1.485956389506541, -0.2901423417026299, -1.181237801027711, -0.37590103292964155, -0.2301360564940415, -1.5245837754026277, 0.7247799957247412, -0.5848876140803445, 0.036367825252460274, -1.475917901216215, 0.2685569472043732, -0.7810315463228721, -0.5137271535377661},
    {-0.14188216492377814, -0.2981882555260384, -2.086852381093029e-05, -0.4406609214196421, 0.608290589644007, -0.17165364245388973, -0.07747121746072519, -0.6266644040147497, 0.7221340619907104, 0.4497938536657869, -0.13006455641659598, 0.8204073176290143, -0.3212384388901802, 0.2781776904265459, 0.5174456715700221, -1.4702060402182215},
    {1.1541970362940979, 0.712591745849401, -0.4671425072127995, 0.7948033106102268, 1.341983772309235, 0.7353187424385227, 1.5491227699782602, 0.5164969409593665, -0.005061116811783152, 1.2653991041749002, 0.45675776619026137, -0.19492756027212355, -0.2615430772038088, -0.8667416751417946, -0.8382933987324137, 1.5286790636227252},
    {1.1179074534875344, 1.4061584173238995, 1.9499426492259533, 1.325499596705336, 0.429758642347301, 1.5755621020687813, 1.4127048039641843, 1.4617375685104819, 1.0015321247253843, 0.4111255646108525, 1.313811124966699, 0.21396867965625496, 0.5992117635114594, -0.02880273737862049, -1.5157376437981331, 1.303013804502137},
    {0.564057002610574, 0.20398791398008656, 0.7041790989863923, 0.0032926811700875816, 0.5695521574965982, 0.6596621762193984, 0.9826507235257256, 0.5290936966495273, 0.6719504159077049, 0.45471933597468384, 1.450858242609151, 0.9061374905991548, -0.6798864787578699, 0.11609112162669244, -0.7995222614107442, -0.7448901369788373},
    {0.8715469133459032, 0.15937255346180695, 0.13484755714738675, 1.1758959730746221, 1.5609493846780813, 0.9825909122327876, 1.363643777196598, 0.6233677084025321, 0.2713486201020439, 0.9745805142531112, 0.7946314029645345, 0.04160531976634027, -0.41467677946673803, -0.744042919913172, -1.2436714019647033, 1.1645889251984065},
    {0.6157924125142751, 0.6856567845355774, 0.37508243032800553, 0.7003366715858778, 0.7168919035171849, 0.2377259961956486, 1.108565603176103, 0.5571383015770187, 0.40167809231947016, 0.9472981321062378, 0.620854579279317, -0.5222579874389236, 0.08983077937147309, -0.37759106511342766, -0.7242794233001425, 0.46026215771053924},
    {-0.3498032198512418, 0.022597960971376962, -0.2152821513459739, -0.0033851583111991885, -0.30111249900984816, 0.4883543105907461, -0.28253627045243207, 0.3999968958196557, -0.545066084448955, -0.3523004987050148, 0.5558420629240343, 0.13208803443614958, -1.000003175871935, -0.23370014669405548, -0.26926633431290503, 0.4002028103156265},
    {0.4808833622195374, -0.24319561886876434, 0.1603163779996384, 0.0025791746013167282, 0.1693508055282155, 0.4451525903658307, 0.21795551393679705, 0.25868588450376007, -0.3084035844823247, 0.5237224143551767, -0.4893610782087966, -0.43604817414421304, 0.519557654602889, -0.6779135383343098, -0.13529632338223685, 0.7974719410517171},
    {-0.5937287344453455, -0.4991433035532598, 0.129447430228524, -0.6089161121123349, -0.7382602376558636, 0.2912527205327341, -0.11911820916995351, 0.08608370555802453, -0.7536251798940885, -0.6019487093923016, -0.607368941474864, -0.4677332074057748, -0.6472041699325695, -1.3765713064155773, -1.1178426867905928, 0.4870797251820067},
    {0.5266553326314193, 0.20783708521554553, 0.34848241785402223, 0.5491978144388046, 0.8871945852681639, 0.6698622943589712, 1.345648011119355, -0.02174842438855257, 0.1656730419246274, -0.4090180899838799, -0.16018608556031086, -0.14014688124378352, 0.37864790677867266, -1.6775704727237342, -0.3274617741132698, 1.130869133157177},
    {0.43352266670220063, 0.9042443466493792, -0.12941899787258335, -0.43749379268708233, 0.04880501851727611, 1.41519562239323, 0.5488011833815585, 0.14298939963195353, 0.7544081208130834, -0.0035725588059664797, 1.1148070554450078, -0.8536212063550179, 0.5726151434577639, 0.16235561410195784, -0.5775115929403704, 0.41811518257674013},
    {0.7381540304960874, 0.24639784769729944, -1.2110667865875235, 0.012914854190208293, 0.040962893602208415, 0.6734572813925251, 0.04632458772299497, 0.2609172202228197, 0.1050087222170058, -1.4336454977858606, 0.7705113025084102, -0.14607185894893923, 1.359144058204927, -0.7884656918805885, 1.0366580650499422, 0.7826364351551574},
    {1.4116895512603098, 0.8075056785384638, -0.23567134719911725, 1.1406667747423596, 0.14082939694349364, 1.3913479345067377, -0.08533493659021475, 0.2183972064253661, 0.3560989844019872, -0.032342494943316674, 0.3237557507559114, -0.7608311192985097, 1.142514632815979, 0.2356818762725894, 0.40653049522085055, 1.0698298515474305},
    {1.1004126327513049, 0.9503185558777335, -0.5606205353033378, 0.6416465999577234, -0.7931273062496559, 1.4833966771421194, -0.9681127373562397, -0.12282792503921774, -0.5464191701135221, -0.30989461075164937, 1.2805659565796055, -0.2614899348882376, 1.4104125671754872, 0.7040907251504831, 0.8578906726844318, 1.0364432501770455},
    {0.36100721313591605, 0.2604871545797769, -0.1528492094810104, -0.10253567511651993, -0.731633132442207, 0.3666095759437181, 0.23914361807770243, -0.39703088358975847, -0.38739964068604027, -1.1076358245973281, 0.5940313896882287, -0.9378128018042374, 1.5100043041617441, -1.017769011546034, 0.12354928465419776, -0.132877055620228},
    {0.7243135221562172, 0.8501406378355602, -0.5837146167656281, 0.03415899298500565, 0.07428144361626807, 0.9904738277851883, -0.6780953972593492, 0.49033447969772576, 0.35705905419512995, -0.72307823252398, 0.17855719569835615, 0.0055073844418882375, 0.8624252251186991, -0.13346293659447903, 0.8533100414768471, -0.988864394235507},
    {0.5951570067796155, 0.83662603849299, -0.6696323911619135, 0.005719301315268619, -0.38586943974057725, 0.18178052294128966, 0.7938259994199044, 0.03637103498855738, 0.20823012579409628, -0.5141837254307224, -0.1629947318433854, -0.9854139796831894, 0.4290454602125586, -0.8824355666082, -0.5873537698847358, 0.9112498530593964},
    {0.47447637388975383, 0.3959285988770276, 0.4177270370521607, 0.13510371804284524, 0.03861939851624334, -0.08743452333473861, 0.589644507887016, 0.5536644712564914, 0.3659991496471952, -0.3617537605179534, -0.4178835957285669, 0.015312828126327017, -0.11156099168969401, -0.9253885011591061, -0.6411751479069769, 0.0822587917237317},
    {1.4649474008188235, 0.832825519141312, -0.16983979305289376, 1.6110928411538576, -1.406901778684407, 0.8667669186065811, -0.20553439504683427, -0.6819452694564411, -0.9527838697250914, -1.4599034165279807, 1.1838596636244587, 0.4550286015243987, 0.8201609577308007, 0.6145821415060764, 0.7659961706169148, 1.6112771570704372},
    {1.516819442369382, 0.4835259849139236, -0.3322779551939656, 1.329803629184086, -0.9722121039610168, 1.4287657415077322, -1.2024322556122282, -1.0646904195746616, -1.1598626966382413, -0.7322447996465239, 0.7451930636830161, 0.5658008545362925, 0.5739313002373079, 1.0233495740013827, 0.8665220893817558, 0.7148920635580036},
    {1.1462391680485895, 1.1174728748015612, -0.3830851294455232, 1.351377680272528, -0.6979057113435816, 0.9716133598901193, -0.11536729773877791, -0.30220757245952656, 0.016791261738624375, -0.03567940888072981, 1.1140317974019363, -0.10936652004463901, 0.7840920796726311, 1.0988508806047925, 1.0536791604878342, 0.8622512723801816},
    {1.4458891150268753, 1.2014680400744615, -0.3235795216430754, 1.0526979769316822, -0.8311676194454549, 1.0985236893938917, -0.5530819583451341, -0.23800804202545053, -0.06826578318002606, -0.10676526135239754, 0.9942597175513465, 0.22095339980671097, 0.9485275169675574, 1.235860697816191, 0.48365533023308244, 0.6778729628396664},
    {1.3180507850639223, 1.1965114583727379, 0.022796551208069792, 1.5007218583670243, -0.0055809548585222125, 1.3102276491803637, -0.2310156818813195, 0.07707820231961558, 0.3790401679280632, 0.2680196405210658, 1.0302098715334083, -0.11242932290069375, 1.8743130864452595, 0.8704831038653587, 0.38832811107136483, 0.5322877488861301},
    {0.6933074236072089, 1.0372430709062195, 0.06603769734155297, 0.6933896044329415, 0.030543935684858192, 0.699674696385576, -0.18374941373868509, -0.1414163931035937, 0.2100132115645078, 0.35658400482861125, 1.0955114378538882, -0.21057366343154524, 0.9396382404746404, 0.583481644623949, 0.5922580746848569, 0.20795148315428263},
    {0.7564889065940456, 1.142608615284187, -0.021325891088109672, 0.7218477835000587, 0.2654299987972055, 0.7314993115660702, 0.3801236440103352, 0.2796999514677109, 0.24815594427564988, 0.2868666028871952, 1.075411242661082, -0.06075128802464178, 0.8003116685638751, 0.8129899742551953, 0.2883539762950959, 0.2507192916911632},
    {0.6956775701568157, 1.0426960526508005, 0.5041565070010595, 0.47430020200676676, 0.20818177960911824, 0.4759491339185425, 0.46549441524639007, 0.29569430110708633, 0.14174448507814277, -0.33604470407519094, 0.372694831546523, 0.043736907960944656, 0.537331964448433, 0.7061121461108151, 0.03721856236767805, 0.31956749286723285},
    {1.13051895776532, 0.9877297919902667, 0.38667646668273836, 1.0782005276888125, -0.2937452625416444, 1.173907568833491, -0.14232855521572915, 0.059230940941811236, 0.08670564847709128, 0.15510201365396176, 0.9061378579463317, -0.2666853407637277, 0.5374862586305235, 0.8029187777798625, 0.5233276229563439, 0.2830989254173359},
    {-0.1679177489729537, -0.13817873940690814, -0.07312829162015598, -0.2527318149594054, -0.0347898621941248, -0.17497978808886347, 0.03302449421853632, 0.003896836859471733, -0.25391259531836663, 0.053460421969965304, -0.10673684468140777, -0.1018154827555243, -0.010105104185919013, -0.08625003762568052, -0.4120067207345736, -0.08558412535866833},
    {0.23112252275184986, 0.146068785515666, -0.038754324978347916, -0.09370887266221091, -0.31703029801117333, -0.29314074288381176, -0.12986154658635918, -0.2405434324534712, -0.1488557902807799, 0.4974509036941017, 0.16571053800379826, 0.13837019770056344, -0.11750552785953325, -0.19996383351941607, -0.23737245706050786, -0.43930043602063196},
    {0.41277898876420327, 0.33251277526025164, 0.09917213157797844, 0.0894339268188252, -0.3987781964435963, 0.15222985020034643, -0.5312367113534736, -0.29910338607811054, 0.3399336795232056, -0.25320915932639587, 0.47716478093376186, 0.2704867929933266, 0.2074608251226629, 0.1783984660980422, -0.06542520409759477, -0.03945504062746083},
    {0.43122661985484617, 0.26890479271483336, -0.008701460789801748, -0.0977229566525623, 0.6922755621633319, 0.20131137576038624, 0.13955919910446338, 0.31739828496802425, -0.0640031104443898, 0.03407727793085498, 0.2810837320511569, -0.055276449540762884, -0.09934751312538696, -0.10486105738235658, -0.38801760843864846, 0.3904176696917163},
    {0.2264943670182985, 0.6265580168406093, 0.25683774155355593, 0.11404150493335635, 0.2057660866462402, 0.42725137271190683, -0.18949411597538915, -0.07092968979340365, -0.08337293005215224, -0.5404308433391993, 0.1737526638062045, 0.29446820755402453, 0.4830910173916467, 0.23340286370809699, 0.08652670140199382, -0.006763427616854485},
    {-0.3617427944930028, -0.09155970195799779, 0.1406897552914166, 0.08699267008046985, -0.12470705650220361, -0.006988600913360489, -0.03569423397153888, 0.31759253307322044, 0.1583150137599032, 0.2927495699830313, -0.19152669872986902, -0.03450225512157317, -0.33304746428368937, 0.02174962626246425, 0.06717106777562806, 0.28960589216227306},
    {0.5703146042676162, 0.11988741549060299, 0.06855148458744954, -0.21024535397653138, 0.06781875627916753, 0.24934503765274263, -0.26579224160926185, -0.006905909853189957, -0.025233823626420973, 0.07815108387169187, 0.3899762801148543, -0.331397049582963, 0.3235849115740074, 0.42422860600973805, 0.41533049322141025, 0.39936564355962695},
    {-0.14740609973578658, -0.3873918891741276, -0.12895741017573384, -0.569312810309071, -0.315515222794361, -0.18526949658818231, -0.6369273613843323, -0.0811360006122208, -0.4002807455613916, -0.2943128166074769, 0.018704722156862422, -0.3757415831715187, -0.7288202023467869, -0.1556097516676089, -0.2866132834012386, -0.14279827338727383},
    {-0.15182030209042216, -0.08732371552601839, -0.41625581995488825, 0.17622100084760978, -0.628127998145647, 0.028404653100200527, -0.5808478770380657, -0.6750800399692647, -0.0028187813417740893, -0.11525171729637243, -0.30811871147386405, -0.4913780347010466, -0.08856838943362876, 0.2244754713720287, 0.01937388290922109, -0.4229051607703362},
    {0.22261773270941218, 0.18804983280134072, -0.06673521551643401, 0.22640379222734044, 0.5030011375378974, 0.028461200886643227, -0.01891446793261117, 0.23554141549883154, -0.13206652669668992, 0.10443479291904707, -0.2561923658417448, 0.08937199184985174, -0.22134071313528345, 0.6642025157388741, 0.5259072070515124, 0.20192763100170583},
    {0.15257426833872148, -0.1676467177759097, -0.030895741174873707, -0.19570661632684144, 0.2604170721071842, -0.17551305674133386, -0.21787613352591698, 0.1485304570170295, 0.2669358115066834, 0.060909152173318395, -0.32842466277233334, -0.22933448861430122, -0.410584868382901, 0.5494163829040364, -0.11992702601071747, -0.01827255105848698},
    {0.18206179919475252, -0.2271291458908487, -0.1744498439161289, -0.2633379281166891, -0.4212110991858302, 0.04179061787756743, -0.27916084167773153, -0.36514638612585426, 0.3486512637517498, 0.4462620617655687, 0.1842622560830238, -0.37826109951477543, -0.6101362218912018, 0.029759241208389953, 0.01952111898795114, -0.3033390803423762},
    {0.09399917306165703, -0.41982385712887893, 0.11030290922173239, 0.24510828621309763, 0.3019269083705289, 0.055509951439460116, 0.09187284678544395, 0.30040852020096376, 0.33872951866798456, 0.8565621645737823, 0.24201669278265273, -0.317486534957872, -0.07580906938954034, 0.554415559664035, -0.2026859932171145, -0.09967515487960144},
    {0.02092567912883921, 0.12210011773397896, 0.16603505655912063, 0.22365333677185625, 0.04636292169516758, 0.402532190174917, 0.08358644801837686, 0.14169261033801714, 0.4603566094710422, 0.8299888879612404, 0.7221943402069867, -0.39285418321551857, 0.09753094633770858, 0.06689330062378826, 0.26866078949544625, 0.43808976921172854},
    {0.2798250347249706, 0.4874286328790351, 0.05093794372761398, 0.3758705041268576, 0.08206501520044732, 0.672711662469672, 0.27992791155949576, 0.2683153924526009, 0.12023051694910236, 0.7644060586164114, 0.838607596302772, 0.1317763035697218, 0.7783145202224249, 0.1379568523540785, 0.213885118778423, 0.20593518382532622},
    {-0.4794840815736876, -0.059741842567782144, -0.10423085882231352, -0.11929910586008292, -0.35051456230193917, 0.16851195703267452, -0.078765786151692, -0.04734351618356687, -0.06281305970703484, -0.3490305444647056, -0.3802553106609468, -0.41229429181686406, -0.40235986000531054, -0.012827472708819202, -0.49315951338455466, -0.18544578769047157},
    {-0.00686677773619842, -0.006767034784512336, 0.04998407240156385, 0.10420984144556841, -0.056388439100479706, 0.1401507071841212, -0.3561144580020948, 0.024119112450887617, 0.18118646783795694, 0.37743395370758587, 0.27907772270733044, 0.09292115497913117, 0.34070231018382063, 0.017229330926547787, 0.0114564934939024, -0.01841782836875276},
    {-0.0121346818995769, 0.32840157518417934, -0.14764870715308923, 0.22203870492216207, 0.025667154502865757, 0.04028647670194223, 0.10848374057235435, 0.24659882943152503, 0.16460150452599293, 0.29794057752428166, -0.06419125777088186, -0.07417754980234385, -0.046584752848115585, 0.14393182457468204, -0.300593173345797, -0.21298874742625132},
    {-0.09111419562029395, 0.37297823628400784, -0.07289605786378561, 0.12216311645120521, 0.052568259011839355, 0.2013692659454572, 0.3320013560892792, 0.20818075781238768, 0.292515605183578, 0.8793739704797022, -0.011185534274396558, 0.07101657679154577, 0.541426608728409, 0.023185467332832638, -0.2638378545810654, -0.16890696783319087},
    {-0.36944715132707917, 0.07540459157020568, -0.13850997276975466, -0.20514432711763803, 0.0190670686527127, 0.07181047150880077, 0.2056462458466125, 0.23119254440899006, 0.09134852929963216, 0.49729418748024906, -0.3860841256763889, -0.22160805766174685, 0.2298974663600011, -0.422782912956544, -0.3449086715762354, 0.19050475540061848},
    {0.5669032097690193, 0.6189862634483003, 0.14776044972297644, 0.5543973560387423, 0.7270817620551489, 0.28239550713480854, 0.3558818773889689, 0.5342760525145881, 0.19978113975510567, 0.22268616654614692, 0.6795359200407738, 0.026827397092463692, 0.25065158505328133, 0.6309782771695792, -0.10532456459407107, 0.5353155249034731},
    {-0.3253114263239978, -0.9169862886662714, -0.229085108378734, -0.2811418883439293, 0.35485866917945913, -0.8334682080866068, 0.09848102048662678, 0.16653153646957686, -0.17878881733394153, 0.01597683668574714, -0.3157650609436102, -0.04589779729519309, 0.01435329641237776, -0.28856309630554067, -0.501009959132271, -0.47569059027863597},
    {-0.09076576038013306, 0.13494243626922506, 0.28055362685164537, 0.373305120653829, -0.1879126982653368, 0.27553039179872807, 0.3338490033953443, 0.16152705979886206, -0.0956834035517588, 0.5493227964316694, -0.13387310556334342, 0.02108480200777745, 0.17785049914047676, -0.15948341336749183, 0.1731854402261578, -0.2855579187280649},
    {0.6020619990852372, 0.798919824006243, 0.08872104723803388, 0.6810602764451318, 0.010063432884849908, 0.6370053990830773, 0.3629214799303153, 0.11586669812654653, 0.12969465839065472, 0.17453141613156145, 0.6511049773792789, 0.00046999292651918865, -0.04072370553617022, 0.34381416879751353, 0.49259718343669284, 0.3095029318282995},
    {0.562767950895327, 0.7701919915059453, 0.23321411582548998, 0.2916344883209008, -0.0642348126060793, 0.6510562380301647, 0.0007080496493974821, -0.1476547528292911, 0.14543862950738187, -0.08566312344446049, 0.6146966447671518, 0.4195686458078152, 0.14292972306124574, 0.2943127174420788, 0.3677650204425429, 0.28372471373758446},
    {0.11280215906069288, 0.433879982440918, 0.2123902887345496, 0.08356099572565603, 0.4883574781809783, 0.08752132081643328, -0.02022697596161752, 0.16752249901481903, 0.03351153233830849, -0.2165613880148556, 0.3612775335103996, 0.08073333529952094, -0.2484125492846298, -0.2788189405420773, 0.1363402681170796, 0.331328032057682},
    {0.043189717679406554, 0.46006252616512955, 0.027440966566138505, 0.2711853073179073, -0.23629612300391908, 0.5038824837120447, 0.08899901251608623, -0.1258827119467971, 0.6348188385270312, 0.3044003639261299, -0.2734104741368237, 0.3739689830863164, 0.06899342703926299, -0.12674200946116096, 0.4290519469753255, 0.09551152033811076},
    {0.2714729431478453, 0.36882125004245186, 0.11093282520826991, 0.29331725969531314, -0.3852518571466839, 0.38657340345383273, 0.37872990828910075, -0.09031241671950704, 0.18380442460384955, 0.04387030912861035, 0.4268394223033295, 0.07557023677868699, -0.14675126180468515, 0.2521728376526205, 0.33014342908102207, 0.29176871267820437},
    {-0.37557598232996187, -0.11044356525118662, -0.13396135311978435, -0.2705248889121875, -0.1483400109777142, -0.24994342040364287, -0.4202676854120646, -0.20461610435828692, -0.8020607789083939, -0.6649267308285229, -0.46692356716880795, -0.014564327066988186, -0.13781473431316862, -0.06903748715718026, -0.26122708753933266, -0.1967543015218317},
    {-0.48270209604316483, 0.04531145053448661, -0.07639181484996622, -0.1303040901264523, 0.38150353113965707, -0.11822105645129899, -0.26670451155711794, -0.07073364152936647, -0.36382944121483646, -0.39582738462176575, -0.3133862564894063, -0.07870807874404037, -0.36562772028217244, -0.010343362046940545, 0.1232028915988375, -0.4481000742090701},
    {0.408366307757437, -0.10559742122317355, 0.0877236690611307, 0.05484647045782191, 0.6136881710469394, 0.23931140167551157, 0.17202700053775413, 0.17521874604568458, 0.34238979233455863, -0.023898786916056597, 0.07110790272213863, -0.2002159611604077, 0.7801729311699283, 0.19342570732282455, 0.20286381902330708, 0.3477978191578395},
    {0.042577608546834705, 0.3337458650400284, 0.17809105733023423, -0.15071094723486989, 0.30145900171846146, 0.2609468513427197, 0.00496626507335004, 0.020725890578464853, -0.06563727837273889, -0.23999939057409558, -0.03280523016496192, 0.23337043717850067, 0.6386925065924965, 0.08209838344899231, -0.07887865905732741, 0.2947332145589948},
    {-0.5868049912437294, -0.3243470226454596, -0.0826955385836114, -0.7296850989561355, -0.34154775900251083, -0.4479728788240892, -0.23229940038821964, -0.21281232104119074, -0.36483497296073564, -0.22855672981429523, -0.7281343503743252, 0.02508363442625379, -0.5467541312744475, -0.24142373402326706, -0.21164337350297655, -0.17095131295911914},
    {0.37460309984835055, 0.027739798789314082, 0.4005825129743624, 0.301908877177997, -0.13499226120554375, 0.11320797971021673, -0.3072357816624587, -0.14677764769614868, 0.1832359146672267, -0.00598983356955767, 0.20473886754024936, 0.2592463833060753, 0.15180635856577201, 0.09348138820082338, 0.29122204580013866, 0.13409715413871148},
    {-0.582418447735274, -0.34156838161224257, -0.016947753222137794, -0.06856645984395368, -0.13745713570350734, -0.8338955177279416, 0.23435703230589183, 0.09328959953908361, 0.01231725301950179, 0.21482444225745573, -0.13165415427789856, -0.48440233664394394, -0.16959932218886292, -0.3027821966673, -0.4652744532376425, -0.10117716882964371},
    {-0.7649657675927751, -0.5161432533383049, -0.2641803144819342, -0.517522618737169, -0.5052590268168444, -0.1994217402935563, -0.21674139450366184, -0.30887607557578534, -0.6182396672678958, -0.3218420180978364, -0.21398340919784375, -0.13488403365197293, -0.22165555075838014, -0.8874137674155346, -0.5266756429534475, -0.47020547145525216},
    {0.38851712802956667, 0.45782341644200425, 0.1757901994348223, 0.36526182142095914, 0.25025155187845505, 0.42237084902942973, -0.24262216449663537, -0.2677514876038812, 0.0907415846494902, 0.4715568163635164, 0.3117222209808309, -0.12442694673003936, 0.31355764062077973, 0.12531843615450264, -0.04742539048286133, 0.22754286054122794},
    {-0.12691823425182686, 0.5115869907845647, -0.1694931795974543, 0.11145593094095262, -0.39356876042502803, 0.08431012889617015, -0.359489530876292, -0.3359608043147362, -0.012280235903551498, -0.2608490992884588, -0.009918257502798474, 0.1425511795098575, -0.5359860567544021, 0.041728616628766965, -0.03611637236617635, 0.21482087513601533},
    {0.6310448974910217, 0.13563252087053598, -0.3054374842997791, 0.37296142638063856, 0.057290905514785224, 0.14239317232558757, -0.3140422850285979, -0.05416300234736541, -0.12300446700352846, -0.14050372220060636, 0.42530824716494203, 0.11614724107504129, 0.24330793378770413, -0.1243941222998817, -0.014955411689520484, -0.06707283359026443},
    {-0.3514505276853815, 0.2782415748486841, -0.014906418583858643, -0.11805194769106528, 0.31038738827533074, -0.23845853081242271, -0.3228681457381131, -0.031739157560879, -0.1680139477295358, -0.3692418841165227, -0.29102560888424556, -0.20694191464777117, -0.1385955152647248, -0.22164347493991177, -0.5592264833775684, 0.22634566085637356},
    {-0.10744588610745659, 0.19218808142371613, -0.012631106997351024, -0.00018348096291637432, -0.4150397956157616, 0.16555989746530017, -0.40627735300955076, -0.04951244963460077, -0.1784933672065419, -0.4019934897941686, 0.24606175802166952, 0.04355885257498615, -0.0717679693635422, 0.1024661017573008, -0.19260776755728024, -0.15820729620758717},
    {-0.550672612173216, -0.26995210793221897, -0.09734466509854185, -0.3634827452058953, -0.31569778939618764, -0.3758704097612051, -0.3653554569300889, -0.20102922070182422, -0.24175515900153163, -0.052961679059079336, -0.5273058626828322, -0.0727832661286839, -0.42525044498664116, -0.2135875423326937, 0.14957135388089676, -0.38313796884019896},
    {-0.10421852278986712, 0.2111921386866694, 0.14800145888198732, 0.04252612437338517, -0.3503060071237582, -0.0727645570263226, -0.13905150266292976, 0.023620411327463862, -0.1577827332330424, -0.28702496073578737, -0.394669360553403, 0.04343362912109751, 0.03517512913660311, -0.2481550811289781, -0.720534169710116, 0.11425190317180522},
    {0.2120181941839637, -0.09087138991664724, 0.05270738295248414, 0.02582295117390413, -0.022193437410979913, 0.543188706329425, 0.34212914648352, -0.002220626602644338, 0.38014499203527036, -0.04323800335025745, 0.4898869589501396, 0.09896112208106045, 0.5869674141603859, 0.19057040387524513, 0.0982544290735248, 0.22937714114289612},
    {-0.1760140021270254, -0.35886369629317233, -0.08791608823016768, 0.07077975749909898, -0.30833525496205666, -0.22763302419559073, 0.03198573740393927, -0.08814093246975019, -0.10174663877954739, -0.2761129625089264, 0.060740805399592666, -0.14324273272533827, -0.39274267616818437, -0.4224855876038849, -0.1278115842535802, -0.282290670781125},
    {0.4828130030282561, 0.29468384826421384, -0.002712861062018061, 0.35129290880267244, -0.0056685794495654, 0.17154568713686344, -0.05874591583152444, -0.06810713408587675, 0.046048321786011925, -0.16903578794847446, 0.6673597657169905, -0.0025601318908553983, 0.3888242925831678, 0.45672654021523407, 0.22543298738265738, 0.04299813709517669},
    {-0.1737097587528072, -0.18781104319298522, -0.0012635852996701674, 0.05386078988317765, 0.049317809915413124, 0.04496256704463949, 0.029907468338492466, 0.2104553358665954, -0.08219023660835535, 0.0949038373400448, -0.1608490274096851, -0.27877041731948254, -0.0808948147595481, -0.24087852664772674, 0.0003242117827901009, -0.5278626910057909},
    {0.01551445597097665, -0.24193451378237493, -0.21971755668282644, -0.44301554158323175, 0.007058833104284475, -0.058544833577119544, -0.34734181529021574, -0.39914276985211444, -0.10695876941910555, -0.6625282191089163, -0.47445022100781303, -0.1079465707730218, 0.3963339411123305, -0.30235032293244485, -0.4204946114696061, -0.32712569513872447},
    {-0.27023896935595204, -0.24815826934460108, -0.040741856367690864, -0.556240199912866, 0.23793907977341208, -0.2624948987062252, -0.0649084818978803, -0.09705246233667311, 0.027982219845161964, -0.028540720143906007, -0.28057704790662363, 0.12821081311591392, -0.19183096701917976, 0.10194409494797188, -0.19695829382235266, -0.15099028026407968},
    {-0.015619679290023215, 0.19574328552051973, -0.04244513791827695, 0.25497898847313205, 0.11602419153301256, 0.2439133732216508, -0.2926272545327855, -0.18830021986315076, 0.10283959554641844, 0.031177213958580915, 0.6100454350151513, -0.11877598653513612, 0.12182922503778729, 0.20320233555306264, 0.17482976449516413, 0.1983331730097085},
    {-0.6736452628009447, -0.1899812249353325, -0.021605984249338916, -0.3616568951968664, -0.37234527652960936, -0.3939357115786617, -0.2515409364086968, -0.16366621557158884, -0.38972997502868956, -0.4560535682773215, -0.6976350051815138, 0.09612537764487651, 0.040295811045998026, -0.2532832596997777, -0.3137004345095802, -0.19367331680862973},
    {1.3702521374789063, 0.5210098179910053, -0.11678319889905873, 1.554918333435716, -1.3221889151128496, 0.9531146284414109, 0.03521943258184181, 0.14616574191620205, -0.9546737562175667, -0.7687161806171161, 1.1006353857959004, 0.8240652250333371, 1.3208200418163845, 0.6029091191989462, 0.7974472866646246, 0.6190506678782547},
    {1.1677935490451756, -0.5428408185576603, -0.8238718145449843, 0.760060631002998, -1.220934635249727, 0.8397281986789752, -0.3438672546417529, -0.35324136119121735, -2.1633760284107835, -0.7387132001624115, 0.8935406398089941, 0.7480233651486714, 0.985660649396955, -0.13710022881562015, 0.281810968206857, -0.7471239638801803},
    {1.483065294593362, 0.7420620596484587, -0.48076656126407313, 1.167291114665245, -0.3106157612533118, 1.1007670687584887, -0.26686455476146326, -0.37808179691597404, -0.23350293525942487, -0.30443390109014357, 1.1812271909906153, 0.1704291545288732, 0.8695694956129272, 1.0520843427235047, 0.5274513346684686, 0.2126038670269189},
    {1.2141214271136367, 0.857648177247097, 0.0967945055201129, 1.069166648192013, -0.0001230922014577778, 0.9694993512551666, -0.15469573235332912, -0.18949938425147447, 0.3465812492425781, 0.12456559555520581, 1.1183338196749046, 0.29924741703776775, 0.7732783748564552, 0.9028415069268652, 0.6168682773909356, 0.5412644505733586},
    {1.1673995932676071, 0.9684815417035283, -0.18683919036551633, 1.1308241411718993, 0.3628628447379288, 1.3954157674490637, 0.04198118786139919, 0.11565565500799824, -0.0042600692986282645, 0.234941918620085, 1.2429353511117753, 0.3000444629423203, 1.45706322620164, 1.0854517559578227, 0.652324673665473, 0.44013590953780496},
    {1.143702360813449, 0.70329711036923, -0.24415494697751886, 1.087762515314852, 0.17097160461092187, 1.0215186671940624, 0.27333408382307106, 0.0683875186780913, 0.0721511560859316, -0.09119500796008842, 0.8236120335387017, 0.023469470917659063, 0.9780406367814303, 0.8966995420089586, 0.45946030210480865, 0.18064165546390873},
    {1.040746397747777, 0.7019109684905344, -0.03184316813863671, 0.9089607794132575, 0.5140168384673125, 0.8943736790116658, 0.40158500656161494, 0.45472897390591116, -0.16067978237642383, -0.18649471210984564, 1.1604665858007432, 0.08283298572928452, 0.40891269677349534, 0.41974022910001424, 0.23694653670325147, 0.2829805329071476},
    {0.10650573125924691, 0.011762609429992773, -0.07912671789225463, 0.13038828944815634, 0.22717372269717506, 0.2768383207973628, 0.06355967350209361, 0.10231535860896426, 0.06326473073662829, -0.4219781811864628, 0.0784746334503173, 0.059189967045473274, 0.0514728505480958, 0.09474574161103587, -0.22624683472568907, 0.4112519239002193},
    {0.3647702066878971, 0.35778527286092415, -0.2530897539567006, 0.6394520325506637, -0.4336599889948781, 0.6798205776759265, -0.1820487290402789, -0.021402627343625774, -0.26794357801584373, -0.0941657354588617, 0.2911880304988684, 0.1509638884413424, 0.31112409117322826, 0.06040080702381908, -0.07653677528845367, -0.31509343074571816},
    {0.3216396268365951, -0.21092838048767426, 0.3895084313525495, 0.144611107586206, 0.5286237783950568, 0.322971854949295, 0.1697953265490784, 0.17117350960678415, 0.31142370785738904, 0.4294386484244538, 0.43632607720360705, 0.1618795263390975, 0.46992051062455686, -0.020615246117306318, 0.04229657553023694, 0.15706763830466874},
    {-0.3302178218763948, -0.11070419070704034, -0.41485865415153755, 0.2511308495642344, -0.9978717842273866, -0.12549671151422095, -0.7224572861122187, -0.5106791932097694, -0.4840254176683646, -0.4664558314168404, -0.47062872742733786, -0.47608102139806574, 0.17881956214978217, -0.6079903124048165, -0.4483513940241391, -0.49476089246390764},
    {0.6565660607867218, 0.4889846429858877, -0.030598672080494587, 0.5554062956759711, -0.31464653454461255, 0.481355540773444, -0.3603477430294707, -0.14147051569521527, 0.01628772732116937, -0.24344247121260418, 1.0497907819976697, -0.215299926046322, 0.745841702824061, 0.3475390574152753, 0.07516408615393946, -0.1725279551209518},
    {0.7169815575499484, 0.25446853742152914, 0.259974250313826, 0.2809766220887547, 0.8174706768621801, 0.0025650467270189373, 0.4735916363099648, 0.5216803138790954, 0.17748348587733787, 0.21256275629289784, 0.32216525546139935, -0.06501585207386493, 0.6366807212734931, 0.20431178784244922, 0.2555445658997053, 0.4967398882575488},
    {-0.047716467130861966, 0.42942975207112244, 0.013576436099018936, -0.23425703132607395, 0.30422902027350257, -0.10714497805813034, -0.1784523436715317, -0.040066601979033147, -0.2442701400939346, -0.2405142158819044, 0.05796863410617176, 0.0874871605018216, 0.5835651818528016, 0.0025453259023772126, 0.11147569425855612, 0.24754533219520378},
    {-0.5781591228123989, -0.07317838941629833, -0.2031610860424866, -0.42127448966570635, 0.23545498180244911, -0.29104923736491445, 0.2996084343649001, 0.3930197980832729, -0.33816838044973513, 0.02704300831539878, -0.5345076776158768, -0.027426093818899183, -0.190215923789449, -0.3835903598841625, -0.3752940675527204, -0.15827916577195209},
    {0.6488474262831653, -0.21100379652031964, -0.3578361999633699, -0.11377791665941231, 0.02178248050922972, 0.2576202088397224, 0.08794289880811315, -0.29372501391316985, -0.15163429280535887, -0.6411008394680808, 0.4638810356487574, 0.3376203035394884, 0.22526556982437831, 0.20045137269403418, -0.25848537514093534, 0.00463746440767073},
    {-0.09823188575385865, -0.6032315439590452, -0.005045317924589804, -0.31753123768450037, 0.01472005491853039, -0.387728479632959, -0.2602717606330743, -0.20902043031103257, -0.35680863538175145, -0.05520107269251919, 0.032670162910578324, -0.011606720463347263, 0.14271871805813297, -0.6661508318982451, -0.1649657917616419, -0.7748848204255978},
    {-0.6374799621999805, -0.21068229038083244, -0.09965703625773821, -0.1300484566741825, -0.3505883587287769, -0.35904199493315636, -0.2809156873884049, -0.06463026864399819, -0.5487051483924343, -0.041781938135319156, -0.3723768694832883, -0.0976412843393576, 0.05315296134711675, -0.3180431564216787, -0.32338781165438757, -0.6205524369963854},
    {0.4622462349491839, 0.10539549497635847, -0.0776211446165286, 0.5059013996529493, -0.1653086682008902, 0.6063035713335883, -0.059744328873064176, -0.09608755776292009, -0.10729026317416711, -0.21756722950698412, 0.22410727376926992, 0.15402932120309665, 0.37433829123347667, 0.42064271696730077, -0.024596485605252082, 0.010685023166722946},
    {0.339568093426105, 0.3185764601427381, -0.3171262425469161, 0.292611265536023, 0.09388957508870509, 0.4885015869170816, -0.24070383076534338, 0.09462218248836635, 0.061251860379028654, -0.17433290326266054, 0.5698608909905765, -0.16911393735578523, 0.6352353031141003, 0.13743188865198977, 0.14269197650916288, -0.19136325769248},
    {0.4551012549280384, 0.1930230008301852, -0.15274478629291588, 0.24475155347785532, -0.12061788007050327, -0.029171925275460732, -0.2962390220467028, -0.19393475968010004, -0.05806807696066111, 0.2284504055931734, 0.18887789691852613, -0.09039565977992735, 0.120926462434475, 0.24267831513683147, 0.4900193379198405, -0.35104545370807677},
    {-0.30683830710458, -0.17807025414019198, -0.039737342158914814, 0.17735260682265233, -0.3767164811356035, -0.2076110822872804, -0.19990764176652456, -0.360397017569081, -0.23023604591558877, -0.21534863779764116, -0.026807400821533937, 0.043329119296654554, 0.7288744273367496, -0.15101962825015458, 0.036829567970885595, 0.06871301987162204},
    {0.20846258736333279, 0.0559211592267969, 0.01354631538678891, 0.30940750472824496, -0.29153172308110104, 0.21104092312848252, 0.021234439574078928, 0.009134653253087153, 0.1457124523308922, 0.17119615209763692, 0.39524277474135, -0.05354539632246691, 0.33153619181196603, 0.1550565107803203, 0.14789836870301645, 0.001330663397105638},
    {-0.04276416239841816, -0.4292578179477023, -0.0835777833509342, 0.12537369694980727, -0.005446279087480476, 0.11499897143398674, -0.27907478320793616, -0.09381360449034465, 0.008557878467603024, 0.026656923078858884, 0.460144886774484, -0.33168833385968016, -0.007198562881190456, -0.284330290454058, 0.3630136908718304, -0.1090048497732699},
    {-0.023332306155129934, -0.26419492534776134, -0.4006516165224344, -0.1887590260862232, 0.3873823775304169, -0.1032055084116092, -0.19388125356463573, -0.17591936029736271, -0.5961407416972672, -0.7507188582385161, -0.06625212360674167, -0.40846647606784686, -0.17531410345875714, -0.24446460409666115, -0.23450544057457526, -0.5431156600720218},
    {0.06868674610240484, -0.22371747320176003, 0.007680440428335055, -0.2658843033398209, 0.18642754273380405, -0.1060545223126892, -0.13334837444524952, -0.16540359086563783, 0.042821117269481276, 0.04826975331425358, -0.024877281532740925, -0.23722849869978424, 0.5050495189103923, -0.20553941042801885, -0.17810692666133188, -0.20103744989919123},
    {0.3614044548788212, 0.3095723677686746, 0.16377629749536204, 0.3246566129461297, 0.016162445846957783, 0.08107996485492601, -0.2184006901489769, -0.189388409201563, -0.25600484648385413, -0.43700702090643617, 0.12409574149384939, 0.2838436116128144, 0.36629951206926176, 0.3261333302660672, 0.2989989541605511, 0.1490494144316678},
    {-0.8827045096794602, -0.4732550614318808, -0.18596880614613956, -0.6152017877839171, -0.5064496632736217, -0.44926560978547136, -0.2736297270794281, -0.22855874897383807, -0.22956278626681498, -0.14334627952158197, -0.7430074478708332, -0.29497555105406836, -0.2903348811226887, -0.49796129400156475, -0.27650096822474873, -0.22604866197004378},
    {-0.19875056489791593, -0.26785153586556354, 0.19928095052742395, -0.5276263718817765, -0.2846351999641209, -0.19661255532153657, 0.14021330387607062, -0.010013221273662717, -0.12542066547524655, -0.20166231029308393, -0.6543616327884065, -0.01585257478130733, 0.1452937200933866, -0.5129276589659097, -0.5148876808709621, -0.38808945161050673},
    {0.5202709444337184, 0.1701053937531569, -0.11582473024046473, 0.3369605247249307, 0.13688137675823536, 0.23973836718650693, -0.12451794757423336, 0.00979908405439058, 0.33106905763467587, 0.06614264855691636, 0.7422986320776899, 0.09097026250282934, -0.08419040298973819, 0.3803036358166229, 0.3549090325260088, -0.09999391680957698}
};

static const float b1[16] = {2.3077872484391024, 2.1638029019734093, 1.8645100617852501, 2.2743878152149013, 1.605583863495852, 2.088787997525559, 1.774475539184916, 1.6514599456055725, 1.9142883553667924, 1.8507465535115084, 2.136351696946861, 1.7252496467816736, 2.303286111400106, 2.7566889632093203, 1.4002746636718653, 2.151903688396986};

static const float w2[16][12] = {
    {-2.0078903760001556, -1.0426437512016173, -1.4261139875397009, -0.8954255140529946, -1.858196062056696, -1.5377160686928095, -2.1426798972921284, -1.9163707939286596, -1.2851155996052976, -1.5073030983106317, -1.4521482571526585, -1.2537838101388914},
    {-1.0665930560651942, -2.178572118759844, -1.1034454447664155, -1.2219082042422043, -1.221170190790022, -1.5722322779698055, -2.192052327860595, -1.482717434436037, -2.0556578455956105, -0.6801699415581762, -1.140181927957567, -0.8531241948582435},
    {-2.0465384892083827, -0.7314368674648722, -0.5322003351339378, -1.6998928533411959, -2.450149085055403, -1.2231638173197519, 0.214664893765299, -0.03457240625023538, -1.5660141913652155, 0.04774805572921244, -1.1618153318701805, -2.117357941487131},
    {-1.5778899922640774, -0.7472089177857395, -1.3671185542372781, -2.0773356119956543, -1.9961379445226828, -1.2455213772061078, -0.8685035406370571, -1.946542601477101, -2.1502016493433755, -1.5385323402134703, -1.17274446797063, -2.698945752737309},
    {-0.37793472821317037, -0.6350595829930058, -1.301246289232117, -0.6933130388266878, -1.2645808319552418, -0.9579470432458224, -0.5395022622055481, -1.8467433777486881, -1.2947447282691524, -1.2529762445594812, -1.3260330144081516, -1.7288295971592307},
    {-0.9589389270162758, -1.5574792263833557, -1.4486791378007038, -1.8879570155549197, -1.0805059346737729, -0.9730675668560728, -0.4894485616760146, -2.069934808996023, 0.0710233295845096, -1.4743776240412723, -2.630157231674781, -1.8797541413333767},
    {-0.3118756569315122, -0.480582248915314, -0.7506115606357662, -1.5189368529370721, -1.535277414237103, -1.2238449211533151, -2.2202703841081437, -1.3818367438117212, -0.85608638347622, -1.0109649911709924, -0.7170941049199405, -1.7340840864518505},
    {-2.3113502162804123, -2.0846257492209666, -1.0969166942757007, -1.6127196146130587, -0.015277249019433232, -0.23721005593472938, -1.3350528508370472, -1.1533948377737946, -1.507185720132611, -1.0183496488152584, -1.3527408252902426, -0.8334002470032559},
    {-0.8570727739831743, -1.2161312571401715, -1.3322816894978946, -0.43241946324288827, 0.09499147444198884, -1.8208391078886967, -1.1302112714124402, -1.2970630950274604, -1.818876371934577, -0.935912204647218, -0.8217274524020969, -1.5007260895547658},
    {-0.8894375198728636, -1.2292870464185413, -1.8746001453879595, -1.885791786583932, -1.2396689678874917, -0.7705060748711721, -1.1564094553108086, -1.641115529550498, -1.1528569711777266, -1.2652873695243676, -1.633804352380184, -0.08008154775004686},
    {-0.7385770116405292, -1.3323548905064075, -1.1760566096974052, -1.849230553514116, -1.0806517246428504, -0.8700271383873474, -1.4686153711073098, -0.6369723706411028, -0.9239129603432569, -1.6253805477015153, -1.634355081883145, -1.4850442380363713},
    {-1.0998577144258344, -0.8085781520051998, -2.559488083088783, -0.4092556618473379, -0.2569645771678225, 0.2216282163941745, -1.729714017251838, -0.045928839809715336, -1.923540185117918, -1.6984266823059224, -1.9745565900698774, -1.9689791648167996},
    {-1.651838263151509, -1.1456452727970428, -1.189697794774801, -1.9348415632605245, -1.6916837630014374, -1.9727775740942886, -1.90346159128073, -1.5540061577451438, -1.3491291150493694, -1.4325534207868984, -0.5082721668225226, -1.8902231037323274},
    {-1.828970457046734, -2.359031323660386, -2.3762479767941085, -1.4168438382985133, -0.6085706574888771, -1.2136125303771679, -1.2020912302334354, -0.8060437610022906, -2.270845470417969, -0.7235945159240907, -1.7265801160477954, 0.01562078617009687},
    {-0.7953372191076808, -1.495932866704245, -1.2137939050297986, 0.5175834442775553, -1.1367173859330084, -2.2738830951625375, -1.0820129187645962, -0.7750358842105581, -1.1529559104335703, -1.6326155489874004, 0.32224437422473484, -0.5113653008717789},
    {-1.9960369319299158, -0.9018351329943024, -0.6629941597908424, -1.48190673684052, -1.5902891458755775, -1.5730338546543634, -0.49950587813467323, -1.5563009117548514, -1.136595971916874, -1.746488967710395, -1.9297624731275074, -0.6031026505493975}
};

static const float b2[12] = {-0.9762259873750444, -0.9634384929992303, -1.3060208132217896, -0.9834336467585881, -0.9314374993813433, -0.6476384887239544, -0.8716945544516546, -1.0073239168517174, -0.3820547498513791, -1.1074067378928802, -0.45889574397071475, -0.2647791243256675};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
