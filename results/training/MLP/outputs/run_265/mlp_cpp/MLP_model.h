#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.2024405789230785, -0.4670595076418619, -0.17455245427337335, 2.110025618055174, 1.3748061793056239, -0.28322775625080265, 2.842268999575598, 0.9250822574368963, 1.9628446521213436, 4.564608466207873, -0.8383857270514663, -0.10668427404063358, 2.445060712304658, -1.0429500941123238, 2.3539359809087896, 0.8359434501054434, 3.4510757702547092, 3.8849730495975185, 1.1435387676277804, -0.027230670074127147, 1.6724944126307613, -0.19607426313002663, 3.0839782479812547, 1.5601300675059193, 1.1197529880806678, 3.6424360748723457, 1.4610121822998314, 0.988263466220232, 0.4628234916755103, 0.3272430044915804, 3.248086200191088, -0.22571145428328548},
    {2.3427754585708795, -1.046653692678252, -0.7342700458980711, 1.1384103711595996, 1.8300830758344957, -2.3920093617926854, 2.4111744627361245, 0.21054242069822401, 1.81287618746888, 4.174848118631407, -1.5821545846452698, -1.2998073695870047, 3.100923992384728, -2.0280612546592227, 2.873225769670761, -0.027162928079111373, 3.9481526676905085, 2.0488700428568674, -0.14338958379476963, -1.2055225055126442, 1.5782091412261785, -1.283522097189505, 2.8502052440047807, 1.175458079254257, -0.20534009433374262, 4.206854045485998, 2.387965222448402, -0.8014711111310995, -0.625754736633101, -1.1245578582977258, 1.9758491561776352, -1.3973287715267844},
    {1.7464991910648564, -1.9852738738850588, -1.8556694968392, 0.5847816363050351, 1.2653954666282414, -3.523553163572575, 2.1466083355067576, -0.2673233621473423, 1.138336505767029, 4.784844250798146, -2.9314848477505997, -2.484328602867215, 3.177033884690499, -3.09870092144178, 2.9694562927741437, -1.3310112250231598, 4.004038888814002, 2.067611856584926, -1.0344183554755733, -2.5290799171508676, 0.9122605979326022, -2.531007047978815, 3.1191951995094387, -0.393915587518057, -1.7443594893289451, 4.6922043575672685, 2.2264353084662503, -2.158787384839754, -2.1796794092015874, -1.7740521158299, 1.3123655569125439, -2.7244014454523824},
    {0.45459805918113494, -3.4724850279858153, -3.2983119852855025, -0.819396547598102, -0.31937401949940375, -4.3610731884490255, 0.6990543080992502, -2.032690391625493, -0.12594132526402224, 4.170693888408146, -4.063846530087426, -3.548038547187359, 1.823471831034194, -3.944395507542169, 1.2174268965291397, -2.9657697653346173, 3.0654069977192684, 1.1193661848954288, -2.796221345241147, -3.579520716951438, -0.7565626757217457, -3.5966492737078806, 1.984447243987976, -2.123497371086081, -3.3053203502080883, 3.6863392060150963, 0.397823151105723, -3.533657506691089, -3.3397850581966964, -3.4290625368822782, -0.0949221642231767, -3.5664958345473075},
    {-1.4432803680636321, -4.381973306029737, -4.075836221309748, -2.3516648882134628, -1.7996781317125772, -4.903048860088885, -0.9517248985944623, -3.492436571759617, -1.9605795506581705, 2.67479147001118, -4.753859804816993, -4.112376197854326, -0.12426517379229989, -4.751676110370547, -0.42542926771386863, -3.7835619764664634, 1.0954596556261682, 0.12112673888044614, -3.269195221696283, -4.232681480511953, -2.218367459844906, -4.298868358203573, 0.14940529403924324, -3.553105198868336, -4.2853224987827225, 1.8591549223118549, -1.1796981972660472, -4.215218553250812, -4.322276336321789, -3.965287598342077, -1.1568747931025198, -4.397963878467652},
    {-2.1086262418437047, -4.289319630414331, -4.448350778579277, -2.971060955562378, -2.2671453602462153, -4.75883585256362, -2.049030557490585, -3.2372463299501923, -2.465950008621114, 0.8151270730851834, -4.53504188527003, -4.1860740316825416, -0.8869501736880312, -4.5214408214438055, -1.108430680639711, -4.112190274786505, -0.10483765114934628, -0.03536489140993732, -3.4803181111949484, -4.516587389656497, -2.5639523659918386, -4.543136396141345, -0.5833076577943958, -3.7834466935512685, -4.457527940162923, 0.6970926073996396, -1.6665860529086944, -4.33955303496565, -4.215585808172461, -4.08721534328928, -1.3951868795392706, -4.249170320409522},
    {-2.3992880630367694, -3.931086987163399, -4.203279298482077, -3.0953963091343595, -2.502807471068714, -4.729519559902355, -2.0976955080076922, -3.1067264466000606, -2.594590927819303, 0.5521411498879845, -4.518515467287953, -3.883253292665706, -0.8395810830467118, -4.476089621600646, -1.3094666704466216, -3.6839527882983267, -0.3913572167094141, 0.234558853678956, -3.5366533345957705, -4.423477926396602, -2.6562555437136868, -4.36533406805752, -1.0669882043505425, -3.7050088732065785, -4.251079653025128, 0.2820409672819624, -1.6780923746110228, -4.061926648329777, -4.414370710233894, -4.130676116069222, -1.1002419799485834, -4.045507612408675},
    {-2.571665750375705, -4.340328995062516, -4.178575052148391, -3.2836397199534826, -2.8304038660252155, -4.85774544894068, -2.081863971638965, -3.718312487312112, -2.647555928960599, 0.5762365556416188, -4.589366048773026, -4.246759803813951, -1.0597011826985103, -4.682218343161735, -1.4551006847585537, -3.9083249163724134, -0.42512614162718143, 0.3735806210562536, -3.518131172846292, -4.309542600554933, -3.141186934634626, -4.4812593168519435, -0.8383786737131921, -3.7683718686969727, -4.4243807341755685, -0.011476770069058364, -1.950850562059697, -4.243140629121484, -4.3943062736150775, -4.013487275697071, -1.1148233252289794, -4.218952931158073},
    {-1.9798813838300997, -4.3992981977129055, -4.279560187673948, -2.767685050060549, -2.1874003006338283, -4.7915571691073655, -1.7809391249765671, -3.894316082531391, -2.3618262493164806, 1.7291627357887933, -4.604730938638109, -3.5193620505864316, -0.6923539814498335, -4.641485220930116, -0.9148092753012341, -3.6562095919493407, 0.16578518821643667, 0.43015932554075675, -3.57374478760439, -4.294067045373464, -2.8162559479369103, -4.3577902367589, -0.42021801117881336, -3.470623334847055, -3.9725816600373536, 0.9781251448301772, -1.9493761397949685, -4.389624983562376, -4.147762835651952, -4.1542206360902645, -1.6432628379314889, -4.334826757863778},
    {-0.6545284111451288, -4.004108344262909, -3.6220555736902695, -2.0504861481125136, -1.3530257797254788, -4.723892838757934, -0.7838780973483414, -3.028866360123068, -1.3839149030097626, 3.2843324919128123, -4.378993236072555, -3.2847528189477018, 0.3991418934171898, -4.281339916006095, 0.40877920995470773, -3.274191722920059, 1.7963019186830758, 0.7595527180332363, -3.3036804950258523, -4.330118614595316, -1.8178298801640491, -4.351569578914888, 0.35605846335669133, -2.7915914848589036, -3.6710473969725452, 2.2595495964326213, -0.7709648598444991, -4.214666989120517, -3.884491932837785, -4.098757354687118, -0.9195428022911796, -4.006901639154656},
    {-0.6524748010027575, -3.428112307147744, -3.207365595494846, -2.447842872777942, -1.08619674362658, -4.260816377052866, -0.7047782558288921, -3.193842478806654, -1.3863200890221123, 3.04968343795229, -3.879246284556945, -3.4794395710623607, 0.5978327003466859, -4.322848772410267, 0.5109619335791277, -2.9927606894423238, 1.7540057870585637, 0.09149055492511424, -3.2828200965697087, -4.161812887499292, -1.6077858896868116, -4.145403038700285, 0.339866593827774, -2.7426291882650413, -3.3579543327797707, 2.6176254429052843, -0.6209121588951492, -3.8330750307054244, -3.63224675471208, -3.647541815392642, -0.8928515602990795, -4.085520585884069},
    {-1.8032587559895557, -3.652005268307832, -3.544835124638415, -2.91939906387407, -2.0599845137902326, -4.187084119547862, -1.8135370334120577, -3.434405541543035, -2.222487868629058, 2.415334410763791, -4.142398550459271, -3.66117995519118, -0.9276282013100724, -3.9264068946864077, -0.7473578303116546, -3.5887242527842202, 0.22152779590977567, -0.12652724075094002, -3.535266539766589, -4.084001544296708, -2.333587269514473, -4.081057919130174, -0.8765033586191532, -3.2881819101698895, -3.682173195619925, 1.5473614014914034, -1.5415562684098192, -4.214402843113268, -4.0128390928909, -3.686023703862594, -1.452676554875325, -4.160863176374277},
    {-1.5140811738248945, -3.3310933454986706, -3.601493881007778, -2.9056261807829307, -1.741204987569623, -4.099286266674251, -1.343987280378473, -3.198471668679334, -2.042279196469953, 2.7929185058798067, -3.924061286319059, -3.768373321125268, -0.14645050144702765, -4.121713994698836, -0.5049565182395193, -3.282739542209909, 1.1286376126164936, -0.043697984881873056, -3.5096951577416027, -4.120938053617021, -2.155056445214621, -4.028907608010363, -0.41727492761957874, -3.080483516605456, -3.570500496441931, 2.247754348017178, -1.277757241506576, -4.128575222823979, -4.013774106487821, -3.6232433904236414, -1.2673679538058442, -3.936603542172059},
    {-1.5486093364871953, -3.6377923448029024, -3.578405604140086, -2.6840219114445634, -1.8980109260565543, -4.314599433342989, -1.484780977352734, -3.448671934901897, -2.0750761658974435, 2.5316790601587567, -4.009004735884724, -3.8876964692036933, -0.131034709407476, -4.0603418677959064, -0.25139569248429816, -3.5665382055847847, 0.8616348062384379, -0.6752130068920106, -3.8244601391843718, -4.00766304495968, -2.377865223568007, -3.878334837541598, -0.7667501935216137, -2.94789850834731, -3.488825960580499, 2.0863553958802092, -1.348103087765832, -4.202443403481055, -3.8459885704086005, -3.875141657186927, -1.7063875155449386, -4.318072455325646},
    {-1.0026668982753868, -3.436177692925541, -3.227289406767523, -2.1172420717027696, -1.519887725357545, -4.246003524693373, -0.9135342339562896, -3.182788080762343, -1.4429077622912423, 3.3072044982297184, -4.035184389081612, -3.8446613486617855, 0.4979348148581523, -4.186053731531579, 0.020058160438949788, -3.044475954876473, 1.5007863285792429, 0.12463048632172398, -3.389500739428999, -3.8970059611176446, -1.786653350534586, -3.766072593038716, 0.3054647730278726, -2.7748934165407984, -3.2839221713003455, 2.4312924934752305, -0.6192806845748549, -3.8006613693824205, -3.988626696381915, -3.8658417778850804, -1.034559536140748, -4.0207212424057674},
    {-1.0213776526715832, -3.795635424216385, -3.628270783878156, -2.2597874126992257, -1.2837667462350597, -4.695487836858108, -0.7995866785309419, -3.1832677901491953, -1.543346561267716, 3.123798109435679, -4.478368341430544, -3.952615694225134, 0.709638920421013, -4.354802986571529, 0.42442291162561224, -3.361311062594443, 1.8183020184521796, 0.13135671668442467, -3.290854624413987, -4.179940721364846, -1.9438397038914357, -3.9408808256291867, 0.6207429606413747, -2.73805230896274, -3.6200182084284465, 2.535615430041139, -0.3240192060859681, -3.9885773783660636, -4.138893387441996, -3.789370061506082, -1.2493395850941773, -3.95618319309304},
    {-0.043753148348135006, -3.5414490490848345, -3.2863130926400252, -1.083139976986896, -0.6889115648491447, -4.333247345708842, 0.15594376376098307, -2.5538126424065637, -0.5734917794218702, 4.067730967640779, -4.1706056470431045, -3.389745194250644, 1.6106325736507043, -4.054889310127407, 1.4268789679341527, -2.661792821486276, 2.9511134207003527, 0.8673836399328752, -3.0170802120518077, -3.7267085828515976, -1.243072933140892, -3.71979051349258, 1.6396522384734293, -2.4569052261943716, -3.0805984400638105, 3.8999980578396367, 0.37803501842056036, -3.617359085926982, -3.7951146545719627, -3.3970739466978084, -0.9924605184308893, -3.7847292576404383},
    {1.0006335561075703, -2.523188475274154, -2.5148552833098274, -0.19608802246078974, 0.11740677845505386, -3.2810296981597356, 1.117605974706201, -1.3978783565449597, 0.5082889459061747, 5.139720254188445, -3.087314521970119, -2.8689139712208216, 2.2022679659166458, -3.1304554629447985, 1.7855401691805437, -1.8295498657752234, 3.353579830370669, 1.896577418179778, -1.975512435228475, -3.0207439912185974, -0.009712456328897695, -3.050963078099527, 2.4115210906141655, -1.5286011614421011, -2.3416634814651, 4.545744735862189, 0.7999969775112722, -2.877087113245295, -2.826884144936182, -2.6934579221099377, 0.7217979110022473, -3.0063277842612246},
    {0.13070303081081577, -2.9219720545660843, -2.6530190864983556, -1.0503909094832349, -0.6472719423891901, -3.5306319995746773, 0.3980563596754925, -2.191599003942519, -0.23857766822429763, 4.5942998012761445, -3.580020979234951, -3.0194668104430566, 1.6381777493289102, -3.598537033512117, 1.1787255135644257, -2.461070268345562, 2.6899448522147615, 1.5406055583928107, -2.497901341108913, -3.3209611301573734, -0.9355131287077169, -3.250410010948049, 1.3135753594799606, -2.22134367580204, -2.663859304560551, 3.799303789821614, -0.044426689753360143, -3.0251766239949998, -3.208186927856482, -2.6974553257796203, 0.04205300790016675, -3.2277432721223005},
    {-0.06500105098827773, -3.2941603942248805, -3.3909566268121734, -1.7456808935716257, -1.098758976939615, -4.107087785826029, -0.19442812965640083, -2.3064801005476303, -0.8224201244439633, 4.233631581239388, -3.903907877780176, -3.69562115496067, 1.6987419801182024, -4.115352287348669, 1.2319530071937683, -2.8700694112233487, 2.621264938809181, 0.36842005978990067, -2.778466866117481, -3.8662869759219936, -0.9167232055838053, -3.6567844278260533, 1.370518388010563, -2.4718369324137672, -3.4988576685386015, 3.818230179815401, -0.12720488295824067, -3.7716138461233824, -3.741936785139814, -3.582584766583579, -0.7054158049561028, -3.9880744084223707},
    {0.4228779834515888, -3.1366896260490105, -2.875920455459752, -0.9658188350204803, -0.0922340072659287, -4.166059022629413, 0.35911922851441436, -2.2697289662718596, -0.2197165859372281, 4.686919426938654, -3.8318198808267363, -3.6179440996085583, 2.034793248708206, -4.018168106284897, 1.426079002446524, -2.6911176016971976, 3.311593783038721, 0.570120882011846, -2.7281975152364417, -3.4870160381481172, -0.5411147610222974, -3.6856146210588028, 1.6023571523605389, -1.9570998689422703, -2.9768528721555385, 3.9375619881462023, 0.4492071576710115, -3.652604269254766, -3.4088710578173935, -3.197865419691344, -0.46897810551080577, -3.601429705127561},
    {1.4902994839010555, -2.4759620122337025, -2.1848241858249855, 0.1648979049313392, 0.5552479912184566, -3.0325187670268705, 1.7329383368393616, -1.0267079938246746, 0.7757483459116458, 5.21151720711717, -2.8739511200642243, -2.459723247349796, 2.699795148097543, -2.945401919737917, 2.21707844421468, -1.4770290338675012, 3.9406073367265297, 2.580338251085898, -1.45060957583867, -2.4811123771748855, 0.3814811735551678, -2.6526452189832077, 2.807446849517839, -0.6336945585802534, -1.5972012776485383, 4.643526435442473, 1.283059930986615, -2.2973045711207467, -2.5378243345339797, -2.2266541072847983, 1.27270569764599, -2.8271618449571725},
    {1.7847445361946628, -1.7276971526169316, -1.264354635828917, 1.2027485821600743, 1.3268058218665508, -2.266604885757421, 2.1273730696178887, -0.13936679438651933, 1.4379382153599862, 5.35351318168424, -2.2487600038700286, -1.7401715557085278, 2.9065401940810314, -2.2312477768886736, 2.8659937989047055, -0.44583225349617395, 3.989466423206875, 3.47714547896643, -0.3431804415482653, -1.8010056825051597, 1.1532905089013814, -1.7509348453885916, 3.076486056493135, -0.02196848598169078, -0.5717885651249753, 4.962856226321205, 1.7475951899612419, -1.5688491145990329, -1.1645843372806668, -1.1618447828695446, 2.202020503327141, -2.009655928588944},
    {1.4881265540542674, -2.5331885164193912, -2.0174796668866986, 0.215548025738781, 0.8873730666088366, -3.0187227734390616, 1.900576009200854, -1.2217258355171274, 1.0650347908913067, 5.003575815354733, -2.926349582666631, -2.3747967650477335, 2.8561499941819743, -2.850316309335448, 2.5407048200398754, -1.2873531704235934, 4.098239116913918, 2.097974738211471, -1.3444760170107712, -2.5025034925671212, 0.414330352522499, -2.6287960715461356, 2.813710908013736, -0.48086037001620624, -1.8875714902038028, 4.799729584451791, 1.4624193550294877, -2.4040112527375954, -2.5309566776626635, -2.225380175831081, 1.3673092922933763, -2.693312084281265},
    {1.311572718483208, -2.719056950143448, -2.274670188044819, -0.3240623221990394, 0.7365472235994929, -3.8651673030193665, 1.383882094560753, -1.7223961954799505, 0.7935095143548374, 4.848720181148598, -3.322130744708033, -3.3395611199340736, 2.7309159378951433, -3.2642371306639184, 2.495181934832495, -2.225783834263949, 3.7217496003143733, 0.8120757793777037, -2.08170382449046, -3.13832147490992, 0.49862144255090374, -3.4022539227903588, 2.283947558655135, -0.9917945579627546, -2.5043040319866154, 4.4760053776446, 1.4081739398017978, -3.316006366736484, -2.9174443523827325, -3.01380502735364, 0.16491399828102773, -3.5750340928799904},
    {1.0114011023538187, -2.261091980596399, -2.258511439070955, -0.5373028011240012, 0.42422363021828186, -3.3251991581436102, 0.88965434187081, -1.6745669821861289, 0.5018456412229778, 4.486459279020848, -3.25686365799643, -3.0698508499071226, 2.1788914375130224, -3.2692897246026305, 1.777189711760392, -2.1216435968044487, 3.371972396795187, 1.2189297976462095, -1.9900272459424477, -3.1204750410596964, 0.2849982080340575, -3.1366637149445453, 1.7253222698093296, -1.337129199842163, -2.5035468057595627, 4.301610993418611, 0.7938625358840865, -3.083027881558087, -2.8721531642716354, -2.7203969222837863, 0.14186936601540434, -3.334177477676353},
    {1.4009220218752292, -2.5494508287026068, -2.2341141909132234, -0.22660585739065925, 0.5572748015833615, -3.50638348788449, 1.2690887762931051, -1.117830683823189, 0.8247406068509009, 4.945387383356873, -3.2091201931283724, -2.992318774940284, 3.014682743707496, -3.402560211256993, 2.3598021869774852, -1.746460709486753, 3.9006126562415315, 1.9131818260673499, -1.758039999989871, -3.1050189994054507, 0.5032163596903438, -3.0302129639880597, 2.613995629392169, -0.8674278554634418, -2.149330182574973, 4.590999015971454, 1.7039221940644678, -2.7098116176182643, -2.559114412620603, -2.439043293520223, 1.1235240935965158, -3.083387541167239},
    {1.4553460808812644, -2.6096808553953483, -2.352748554896115, -0.3531232264741717, 0.6156813548369954, -3.5661362122078124, 1.3819875675887847, -1.2947778516416104, 0.8838529344289217, 4.920970695802992, -3.4090931655300385, -3.0197069328368817, 2.7087709352591327, -3.5554804186365847, 2.2925733730608844, -2.0127772085681883, 4.0645308339435084, 1.8263902902454847, -1.8979065524112673, -2.8935986801500624, 0.43094013889060034, -3.115287835730183, 2.471570732973032, -1.1036315038830937, -2.2681660761810454, 4.451308883430815, 1.3039840161237233, -2.9926389251871583, -2.9877011546211185, -2.8792994025930967, 1.1282777591528488, -3.3913480904343083},
    {1.5025278743183306, -2.4129028175339933, -2.0625887716238482, -0.08334802278767536, 0.8118784364233148, -3.62382690285839, 1.4012857413356672, -1.4358111156534357, 1.09029103810975, 4.778263334304866, -3.044596947435403, -3.0078863581227626, 3.1052700494516428, -3.347478396452482, 2.632287944994937, -1.6701363601703025, 4.154783771689014, 1.1100139468198755, -2.10401171820905, -3.0586782196731583, 0.8312646979624213, -3.0260211792837466, 2.3445411234931144, -0.5624229238858438, -2.1283821221526162, 4.814651704445328, 1.8458067004949046, -3.0921842711707566, -2.7041159588441266, -2.6803835465858605, 0.7810527451194348, -3.3455984433492305},
    {1.7592886186127283, -2.0155665278089736, -1.6864136821908624, 0.417964216128573, 0.9959733584127345, -3.4082137706850486, 1.7087444222238508, -0.994772288084493, 1.2870566639990266, 4.869024186098362, -2.921058143104211, -2.8925754980258374, 2.7496022009009824, -3.1765502726961223, 2.405203062680336, -1.4977928854996958, 3.8013577991829863, 1.3606138714219458, -1.5951564999909429, -2.6791289057075, 0.9038367612281426, -2.5260298593326365, 2.3388050112297067, -0.28004563205518457, -1.4435414388089707, 4.52477758586285, 1.7039341548599949, -2.609428049380591, -2.248166533870959, -2.1902432840709207, 0.4503006773381664, -3.1757745860153133},
    {-1.5411829248158775, 0.07372695264017944, -0.20805903846840026, -1.7922703851315753, -1.2033321995032733, -1.6318414651317399, -1.6707805660060722, -0.8424069751574549, -0.9740062986704415, -1.6638266576383711, -0.3284804301615381, 0.03630311757812479, -0.9852379950300549, 0.3573315530703445, -1.1007530256215041, -0.9077899534414173, -1.4057616623713878, 0.22789336671977112, -0.6697988141049938, -0.9468213002769053, -0.6006759396511941, -1.0836720755339644, -1.390259975459329, -1.6307777476263567, -1.779743621683105, -1.3103778656895526, -1.071878375823432, -1.8416613787985898, -1.0505575466757524, -0.019034172437345117, -0.5151869220061741, -1.0300333322608048},
    {1.0902117976679364, -1.4642485679718915, -1.226274210368475, 0.011658606539860965, 0.08038027406411473, -2.1526363237863055, 0.7714625926360613, -0.22288903628843829, 0.5345975503639827, 2.6065252857856716, -1.7961120902300773, -1.029223331672504, 1.481555058673525, -1.8824239181021585, 1.4603008278283671, -0.39995629960229945, 1.8901261799562983, 1.6253838222969625, -0.15376482315181184, -1.8368135833821913, 0.4419925745426341, -1.7541957899457117, 1.0005962662614165, 0.022430671709452663, -0.5976882610131917, 1.862671938779151, 1.0493772561266415, -0.6719723546965272, -1.038339072366993, -1.022181581059308, 1.2425510521456546, -1.3641950302417223},
    {-3.329357643636495, -1.9635062189347856, -2.6317402232569767, -2.882685178195323, -3.2287315648268815, -1.9783473059708099, -2.6027573477122026, -2.642851647195102, -3.0469155357412574, -2.2848688364799767, -2.649032882909786, -1.8526645122023826, -3.0467688154547323, -2.385118148583755, -2.9970144517262827, -2.367400178313767, -2.738646270779473, 0.08223482962418865, -1.702005675907486, -2.259369213358585, -2.9905333296807775, -2.1863429757776953, -2.707819653210176, -2.982741628693751, -2.636519476962935, -3.030586878755047, -3.127181108120745, -2.4831873669558986, -2.5413160019498138, -2.0741599535859634, -0.0732451899055437, -2.062653573577156},
    {-2.385216887108106, -1.50375472895156, -2.143604168596078, -2.112558608805752, -2.537702953033033, -0.784650533600302, -2.305727582786434, -2.6069395823346704, -2.4681585733452516, -0.8884366964846251, -2.198942832614866, -1.3334717811584975, -2.283745584006893, -1.5359267398734469, -2.320935893473891, -1.7785972859792765, -2.078947263259359, 0.8663867685685449, -1.2784129947725271, -1.4280020737850452, -2.422340890760293, -1.4510279147044396, -2.4286634920899117, -2.4614393682621225, -2.194809552575176, -1.756499369247252, -2.4271160337342383, -1.757752198861873, -1.4115874302941853, -1.351546669042256, 0.02912068645647007, -1.6561342233081835},
    {-1.4304326408948018, -2.7735955214390295, -2.848488470663751, -2.4210365964175478, -2.127653124612231, -3.0950649361092966, -1.7674163404070138, -2.806965702472432, -1.7109089500496617, 0.9124363405399152, -2.9264596842913315, -2.9741539266478454, -0.8867286912350417, -3.3598578790452542, -0.7462616655325403, -2.4439389086046064, -0.1871406463896411, 0.43275800762356414, -2.3020464001407097, -3.05410211824462, -1.9453189264956288, -3.1097289655414126, -1.4597396869415666, -2.3737436830712633, -2.6110628153792286, 0.16582595948421383, -1.4994317321426813, -2.9761123131574454, -2.8767761240688676, -2.8783345626178565, 0.098447730439575, -3.148911076586798},
    {-1.8045950841521838, -2.172622474097984, -2.8780173397111066, -2.507438058547538, -2.2399188156882492, -2.508614984132802, -1.939714291094189, -2.5570006053250056, -1.5495396888570636, -0.026809862809407854, -2.997395158118827, -2.5419583188997015, -1.487545395520774, -2.8435924447365304, -1.4195451766919676, -2.6602611904517848, -0.6323971002215271, 0.8677494147869959, -1.9225538385888798, -2.828625214465189, -2.311531435379874, -2.492364012480105, -1.7006578265597174, -2.5590850688209863, -2.655288413912301, -0.72390450443601, -1.7789126394995731, -2.4911927355737564, -2.4782076700015754, -2.4527408807437747, 0.8528983096242259, -2.64750604661315},
    {-2.314350508514959, -2.7582503345872396, -3.2450442364106857, -2.6114399166198314, -2.4994013070749705, -2.3499974773471353, -1.9693869043327341, -2.468019065997372, -2.5443896228840672, -0.04224265636559347, -2.7321236280531735, -2.520723424626843, -1.8970965066799295, -2.4603772754419233, -2.1295495222790732, -2.750781144545567, -0.7204249146938904, 0.6577047369011186, -1.9774156778462078, -2.7379465100139067, -2.7970558643664156, -2.714750275644337, -1.7278217369077982, -2.7031016672236348, -2.8338687081985423, -0.6698701876263455, -2.2176769218634584, -2.8172450821118846, -2.746669320262052, -2.6495104297719165, 0.2743316823673542, -2.599458216862626},
    {-2.054736444508628, -2.0870967163185568, -2.5662286064625337, -2.0194598972163433, -2.236367719831443, -2.193644327550585, -1.4508204506743918, -2.341493713096282, -1.7571868904800214, -0.016405984086299473, -2.726850092018774, -2.6558240165130793, -1.7594926829047195, -2.2686933271418175, -1.6094200467494786, -2.477144130529612, -0.6692172974396542, 0.6942702012725228, -2.1583893968981815, -2.645142511763983, -2.7437287379071824, -2.40825936679963, -0.997014168372497, -2.407251763705134, -2.54679207947485, -0.24940598083089502, -2.1320504990994706, -2.7457365122156987, -2.567252529104947, -2.6042191020957386, 0.47278748277899574, -2.526426714432461},
    {-2.5406727276993046, -2.1844030607677203, -3.1761771193648025, -2.7186796794163817, -2.7174193447799766, -3.0828111440617456, -1.8550082630893265, -2.8655145825143014, -2.355080871130237, -0.03674730388616647, -3.1841995258371547, -2.3998074794784565, -1.7441227924678082, -2.9129444516446177, -2.09869585081997, -2.769020737404758, -1.0262838790267044, 1.3832261713159435, -2.1059862018349382, -2.9546229573795713, -3.2203641105136707, -2.963487711315486, -1.7184872495706927, -2.8795751281781325, -3.0199286257473132, -0.49046562157951107, -2.3975395695542963, -2.747946654975115, -2.8959515010241343, -2.567570855104136, 0.5041581611977454, -2.635150494248302},
    {-2.862551489886816, -2.3100674408084014, -3.244440154011347, -2.805917152903966, -2.770413629708965, -2.9327331113240667, -2.1942787869307874, -2.324841465543838, -2.538902717350702, 0.025751807453471366, -3.3865594806200954, -2.6613448408128897, -2.21616646566822, -2.9150608853071542, -2.1606929193550264, -2.989632675869422, -1.398804337251132, 0.43882461090197344, -2.2680309874149858, -3.129136595558957, -2.671213495759745, -3.366598466611679, -2.024148819589191, -3.069438561837791, -3.3007920864158864, -0.9636791969435776, -2.3957695116979023, -2.8179356022419086, -3.2423023826779094, -2.722049219497988, 0.8077303485396201, -2.8784004744134295},
    {-2.0975979134420175, -1.9493749014934245, -2.716086034974645, -2.396450065412677, -2.568377275965184, -2.3986163024708436, -2.4802838700036927, -2.2767207466982153, -2.2154232055532463, -1.0004084689678021, -2.3613440186879733, -2.1759757066104335, -2.2537210894839443, -2.157528871831875, -2.0101028396335594, -2.4452309476104506, -1.9196565788211837, 0.14179223726268989, -2.065187819984264, -2.2887725816505275, -2.3380811067211926, -2.467195194429933, -2.1209174113005247, -2.3643760613933393, -2.6387819093874287, -1.270640884484117, -2.2260847413355456, -2.5750217679727467, -2.5744778911264588, -2.2546329752948395, 0.3254489140714719, -2.376812427899042},
    {-2.640720907947863, -2.528521837114967, -3.1723020342715604, -2.959870993409955, -2.7956174597412566, -2.875661050259098, -2.692406763813741, -2.759382229497074, -2.484628485474354, -0.671451023066864, -2.8392285043830716, -2.278228340046977, -2.214659615316468, -2.6821135121401207, -2.198869901155682, -2.879632891749659, -1.8921197525730924, 0.9800163584906108, -2.6670675925882903, -2.85338499762812, -3.055703475863768, -2.8904405580038075, -2.3423750114581994, -2.9458162007300626, -2.9576720603740947, -1.2475786651044296, -2.447052037391807, -3.0294605810090265, -2.8317353058060597, -2.777634916475373, 0.508337976519077, -2.553337138258332},
    {-2.998681521898331, -2.4850948441558947, -3.32401244848524, -3.1802636302044385, -3.041329412254491, -3.4578768415988077, -2.611005870438172, -2.852204345253129, -2.447839505733834, -0.558776104102021, -2.8765104003443938, -3.0291187644089512, -2.1360586612242343, -3.073033348820442, -2.519515427722125, -3.1476203195558146, -1.5773595626343935, 0.28471315954467324, -2.6600613159252133, -3.288108699159209, -3.100246387844651, -3.22384282114566, -2.5196386851206634, -3.278370649349911, -3.3216919676643166, -1.3828415961989282, -2.717701539040648, -3.2178750785040053, -3.031151849615408, -2.9603928612677497, 0.8465567470507561, -3.1053521908924235},
    {-3.262854261720243, -2.8036922040335526, -3.6609807186526635, -3.479742014151288, -3.0948984290017076, -3.561168165421486, -3.3724682390721568, -3.09560054520595, -2.8977293256895544, -1.3737481975032626, -3.504267680658847, -3.44225981180551, -2.9540167726201054, -3.2981054099135947, -3.065611802361192, -3.4210797787204568, -2.0496588359770547, -0.0862032447738043, -3.0505604265448647, -3.5080529157481704, -3.1969347709573053, -3.541051266255932, -2.8152448764230975, -3.571025615507527, -3.4124733056295558, -2.0880839888805482, -3.0706418887533733, -3.2615590508210754, -3.508018175857834, -3.098418073020829, -0.017268554141182276, -2.9401391853151138},
    {-3.279368499391262, -2.8172070563876677, -3.0905625645816053, -3.33472502926962, -3.3084049972702876, -3.6186461771586833, -2.9922815679203048, -2.8971869802556407, -3.0528600704125237, -0.6849243302574778, -3.547930535888141, -3.199869360320292, -2.6887813853396767, -3.3387917410712684, -2.9124479367111844, -3.233190237348616, -2.095651955325593, 0.7830405341214665, -2.5476347996006057, -3.2966418629385905, -3.2949216667718835, -3.589069059244945, -2.1662257029876115, -3.2988851437287816, -3.255240775088161, -1.6911593718144577, -3.1196906039259265, -3.4897923524972088, -3.4744176891673075, -3.17182364650108, 0.545541904756872, -3.2693267543159275},
    {-3.9180622612986187, -2.9487425127884475, -3.2316626340849175, -3.367092168105594, -3.629610062277325, -3.2000427152667386, -3.291078136433544, -3.140293321732405, -3.485665273133032, -1.4853866427646063, -3.0123600065103306, -3.0591218168932057, -3.4492642637703663, -2.811741638749504, -3.563440586438493, -2.8541009658863774, -2.819516125741007, 0.16112582613685078, -2.7659049460952456, -3.1975521202599677, -3.532845276025463, -2.9934835643243924, -2.632857246264038, -3.3089040646452537, -3.5113686479349004, -2.6622538032078067, -3.7350290868080034, -3.2885910922184403, -3.0070308024355166, -2.6725001328752596, -0.33133522329724324, -2.929365690773944},
    {-3.0701420012908787, -2.228547977395764, -2.6064454019996437, -2.350088256126972, -3.0984354578092055, -1.8798267622750353, -2.3902934429855285, -2.1295431222245624, -2.682332428422084, -1.0446639593530542, -2.6944411877339847, -2.4914257694426976, -2.749871249283163, -2.4508280398490783, -2.803686834839341, -2.218760396723194, -2.1989639764701376, 0.6574253594638175, -1.9476700335076957, -2.199708174952847, -3.0888526502553346, -2.5157249783574693, -2.22593138852289, -2.761697546234567, -2.325769308981418, -1.629685878919813, -3.0091257891850174, -2.1096884035123185, -2.363919451266913, -2.2867930347305117, 0.671712058856905, -2.0420407062690114},
    {-2.2795673540058727, -2.0403686147857822, -2.2417730102431475, -1.6193688097000432, -2.226766629984785, -1.8644708148747982, -1.2863332813672912, -1.6371438690652873, -1.5710681403919806, 0.2917370340567557, -2.588680805956472, -1.5151376224031134, -1.7893106427169942, -2.113989609637557, -1.6479641565269847, -1.8301590167909771, -1.2231872586211048, 1.3159877109421618, -1.3564517936195963, -2.0094718776982496, -2.44130437613535, -1.9534752470149404, -1.2191651613315715, -2.1787341094884, -2.1380798906875453, -0.8401509081057232, -2.426268233556409, -1.6004778886656847, -1.7531663485553481, -1.8202607744311425, 0.8448289109563367, -1.9287285572669803},
    {-3.626054926361135, -2.436183549542619, -3.066602198996079, -3.3001646579833284, -3.2515338411668444, -2.3847952759364897, -3.1241568929428585, -2.542106871721333, -3.1847929033159708, -1.852829363647546, -3.0061357062334624, -2.5761199220972517, -3.376683516007713, -2.799789548427532, -3.1025958064826153, -2.6741321283199726, -2.8373036466537953, 0.2280839560111758, -2.01126090873281, -2.9202677870196396, -3.5373378309505537, -2.7031962183737, -3.134893762275155, -3.24562590104469, -3.037781263373984, -2.6814905661526685, -3.31008576310182, -2.7084559206167143, -2.7690286090261953, -2.7775298728340925, 0.16394280501182407, -2.2850648069539075},
    {-3.56867796349005, -2.8599899419578136, -3.5097995702623064, -3.8662308413453985, -3.670762286367849, -3.7172065157734187, -3.2899603220586298, -3.090953568583657, -3.4189301457669763, -1.5598392661205795, -3.5427382281195934, -3.433391301820915, -3.4159090516218846, -3.5324821966749607, -3.115071578650917, -3.3977833376628186, -2.791458066328954, 0.6279171517643832, -2.4694173528412584, -3.6843268743226583, -3.26407318658744, -3.844659727631698, -3.4471645043411683, -3.592966653808474, -3.6048786191427893, -2.2448160460069584, -3.265528632285614, -3.550384980582171, -3.701632835758468, -3.0489000330004656, 0.5071470692576208, -2.9473379662381096},
    {-3.3164802500716504, -3.2020682393486064, -3.7296243108954137, -3.7511720854039337, -3.6258979895394754, -3.7210520279266412, -3.2602291399137693, -3.2439078571944355, -3.516932666226279, -1.66511112146595, -3.584807826581656, -3.7358621161260586, -3.1411534067462905, -3.9039162628856885, -3.2958735978303495, -3.7132973352707563, -2.7361631856873325, 0.2652047974812715, -2.8428011930920927, -3.734917118435518, -3.690302477094443, -3.5845560393582043, -3.1568455788153673, -3.8425282677413506, -3.5463141770928432, -2.2366057701966424, -3.306385214748985, -3.776642426030834, -3.9132456040560073, -3.5504125214214564, -0.02139997521715275, -3.423684540761419},
    {-2.5871518569859964, -2.5687912484159665, -3.472380578170004, -2.424246259629241, -2.84528737565862, -3.063672995260522, -1.6564448171260302, -2.264649626274445, -2.0342072380635186, 0.9471181979057903, -3.089912399282424, -2.514011822796892, -1.6812345132078477, -2.8020586698650867, -1.9625521886289006, -2.701469868091486, -0.9263688452908934, 2.430679599772201, -1.5602795556359188, -2.8641451085751473, -2.3736608724704267, -2.657143383337141, -0.9447530183739249, -3.262736855116911, -3.0765071408418847, -0.5251546497872172, -2.4524062718833637, -2.3860541366510284, -2.5313738141584268, -2.487028935432461, 2.0252901283192752, -2.3659169076989532},
    {-3.685923082947495, -2.1334173626258486, -2.861862752211824, -2.2345189738410918, -3.4491655762748525, -2.180423932512052, -2.0377710615753153, -1.9468478807141287, -3.118971693007568, -0.8546811226582406, -2.3406230569407716, -1.4626076730867765, -3.302829843531401, -1.9552778236521704, -3.377791983716482, -1.9677711682016374, -2.7229746409940545, 3.0668702121898073, -0.6037894750100546, -2.154468695505011, -3.1341139703728063, -1.8953817565555182, -1.7294949035087892, -3.2193262200630883, -2.6136251261179106, -2.5256370205722245, -3.520325503153556, -1.6597911479728138, -1.922126859546948, -1.6512181274575266, 2.283391467338756, -1.645258198530887},
    {-4.550684102525045, -2.9225871070654845, -3.704803585392746, -3.593815809968016, -4.207116957406687, -2.9533362464359256, -3.428893702679109, -3.1094184637430007, -3.9364506967846205, -2.621790926100872, -3.362732799600319, -2.7292091090919466, -4.048835897800489, -3.0790286493697705, -4.228037731842924, -3.4157976903068787, -3.9122742538712827, 1.5538044460429417, -1.9459678514111827, -3.479295748709692, -3.7688787650627, -3.1498130511204385, -3.451947635158658, -3.953825331023673, -3.8051605098068615, -3.58798977673146, -4.2425588339429225, -3.313857765340545, -3.3371013716739197, -2.927195899454071, 1.0174245137404152, -2.619983835179983},
    {-3.800047365869485, -3.04815672605377, -3.477931321137921, -3.819754079943742, -3.6034969302992614, -3.3736499847120376, -3.6518375447470515, -2.949348296191458, -3.461552996161906, -1.7331048406720773, -3.4832015305033965, -3.535144244055036, -3.3990931410511847, -3.454700967703485, -3.812981211076404, -3.67783626368532, -3.0281661157630637, 0.5632537169621016, -2.8253324961644197, -4.117260612128401, -3.643748667277571, -3.9390164308568543, -3.385464360445555, -3.872624285151383, -3.7513483313774127, -2.883333431629072, -3.8292263702701157, -3.796781753923592, -3.8596368084708073, -3.710298312411016, 0.3237590365626829, -3.361647473678967},
    {-4.001640851292293, -2.1528581938746667, -3.006858134833375, -3.3267037872640928, -3.961428249650369, -2.371246839144625, -3.365938397317455, -2.6578089166142744, -3.4286458093035823, -2.352575564772983, -2.6810005294388572, -2.198685158192451, -3.91871630183985, -2.3248578559155453, -3.989171203759796, -2.6790484011828255, -3.7644881437908646, 1.5746210426317955, -1.7423396122581487, -2.5054894666532097, -3.2442609127632456, -2.4785847710607456, -3.028080266216519, -3.482577017021371, -3.261426921331258, -3.265491112543763, -4.118613637084006, -2.593821778640029, -2.7513493446370867, -1.9751356207537563, 0.9330125224435194, -2.0298392281975244},
    {-3.4694610592510156, -2.5076713187023465, -3.154425078061709, -3.2838074363041563, -3.73137058304393, -3.3638012390884464, -2.8766084306990067, -2.3689269580545353, -3.000852040710532, -1.0903997788830655, -3.101844935496709, -2.5319207110978255, -2.955890832921591, -2.5993663863833705, -3.3801348807972444, -2.7503157365172575, -2.3581824967575042, 1.7117189728261024, -1.6594637691901744, -3.393692370550642, -2.9023606035101635, -3.1990327567653747, -2.300106134187359, -3.5761032164133653, -3.455748948039294, -2.1237340479776963, -3.560875375309651, -2.8884164400225436, -2.9705562545947775, -2.065123150432774, 1.7049391357166506, -2.55246502828633},
    {-3.7741468969377086, -2.4239494834350523, -3.447109836092766, -3.6563939343990994, -3.724529333507249, -3.2336580825360177, -3.366134829363475, -2.6787721956519936, -2.8787356181916914, -1.644079419384638, -3.2354359803894885, -3.0647713756496815, -3.474745198010618, -3.006229260416652, -3.704510532993873, -3.273264234278064, -3.1947185575167985, 1.4144450493032052, -2.496396290696293, -3.5004227885917643, -2.918561000255732, -3.591522667724303, -3.22104910044178, -3.761649431762081, -3.6312968478042613, -2.7515496222750158, -3.8003270951317263, -3.507267301773898, -3.392268341921415, -2.8951484985689597, 0.8521855326688837, -3.195304621470913},
    {-4.010807705601846, -2.956383577401975, -3.4341013406187333, -3.365580588279645, -3.980184789776658, -2.9435083017957324, -2.991086566707536, -3.0459101792125125, -3.7365004354577955, -1.8818960177370434, -3.254709962289253, -2.6386079344666618, -3.9056488555494733, -2.916613491083298, -3.928666270544574, -3.2138623845697367, -3.582422542734525, 1.1600610695681994, -2.216695422151694, -3.303419116140067, -3.4597707002630944, -3.2653254453886276, -3.1209463437392313, -4.046533945109014, -3.5937538944183496, -2.9159396795339325, -4.34324182045753, -3.1323004175494593, -3.330095995850566, -2.7935480360430787, 0.9627085411690153, -2.738082425182379},
    {-3.667922008458164, -2.4072201084368627, -2.8864671351347875, -2.924909953086891, -3.653306882605957, -2.5645181426983084, -2.4805657733601048, -2.3294891888179694, -3.0537438788038447, -1.5334028327407543, -2.548405502635992, -2.287297027743947, -3.5814181511541756, -2.075361329949339, -3.830465538178483, -2.69320149285442, -3.464291124187864, 2.0494413160140343, -1.335283023012419, -2.5192665704104655, -2.8461697485629727, -2.368175464707852, -2.700293706023672, -3.5906988219590517, -3.3996803277925167, -2.7448935289491287, -3.9711774118797245, -2.369840438301441, -2.5651942527143827, -2.1744487891348805, 1.8316411441673162, -2.394831148291979},
    {-0.5092594859778117, -2.4900667600866018, -1.9061779759359174, 1.6652981794443202, -0.882924906308453, -0.34727298447325955, 1.786189799427339, -2.515469503895685, -1.3927652367922443, -0.31349881404254093, -1.1233346442472953, 1.7900999380795868, -0.894225937709456, 1.1313039037128225, -0.576686111499451, 1.1473458325068397, -0.7893929031921199, 2.6913202963658738, 2.0918956965870734, 1.0849067684012323, -1.732694307840787, 0.8787885752940576, 1.7389890416715632, -0.5844565092105766, -0.8265707374738331, -0.3655173315088437, -0.35149658328237365, 1.0632453048096486, 0.8733811813304039, 1.620684800411239, -2.907376862628754, 1.3640950938633265},
    {0.47183505498054834, -2.1105840836458274, -1.8967248354244663, 1.8008051209664637, -0.43968484263162977, 0.2561585055486455, 2.242490456284481, -2.0293707481583523, -1.209608341627564, 0.5738793660307651, -0.8349027054930762, 2.436356113726154, 0.44043229410563733, 1.3027503507446478, 0.13139393577907643, 1.708876024163175, -0.0796655574831752, 3.17525920194711, 2.4913365169912214, 1.2779241055153416, -1.440267676240325, 1.4323709039498609, 2.2792867686974323, -0.5889842309573441, -0.5916220767084079, 0.41903707697862225, 0.3600999600979746, 1.1872616854767446, 1.9715530217972552, 2.3386255234866686, -2.025925186823846, 1.658476507117475},
    {-0.6434029232006657, -2.977333169141433, -2.3835416540976104, 2.143369924542795, -1.329950513003345, -0.34343650237009443, 2.0373123775202435, -2.7400641710167477, -2.3650137172389325, -0.3715832828829541, -1.0807639169898466, 2.437312378837579, -0.5613462846776975, 1.0983600790006993, -0.4507818855640348, 2.3716340113910364, -1.2502945930878648, 3.6872857846219156, 2.8681741003617174, 1.1968496968578395, -2.3584002805538447, 1.421978953809212, 2.346245068937444, -1.4316809454738564, -1.6079635360169593, -0.1996783405680045, -0.4721235938204954, 1.5228734800829953, 1.9290188403255215, 2.727504763233425, -3.029275521557387, 1.9961594662197795},
    {-0.26529453449505247, -2.6401067699162146, -2.114758203844097, 2.094056824341341, -1.0891073978960062, 0.39738130851878367, 2.1169845169887767, -2.7673638030134327, -1.9150444446728603, -0.10615550541627342, -1.1804561858733909, 2.331526842167101, 0.056137840443051125, 1.1795552158855442, 0.058017713413372494, 2.0796800079360467, -0.8368940621059986, 3.336279736898709, 2.921335822565807, 1.7332369724132277, -1.9261906547411647, 1.5466775701028692, 2.226638818484276, -0.4331688373773168, -1.1966279580996333, -0.14888678286121865, -0.2515695585552704, 1.7071475695503504, 2.2679053037194956, 2.316172951928444, -2.7785152263803896, 1.6432466697238814},
    {0.006231229637020991, -2.7950162157015335, -1.9518586141802203, 2.3264324889080306, -0.6751929460654661, 0.45418513028083835, 2.368474800377949, -2.4145349480133, -1.3543018926379444, 0.08807476933951273, -1.2429169140566318, 1.9490179917642754, -0.1375191693886462, 0.7170519889792252, 0.20926338348847054, 1.8948992524897463, -0.4328871263614657, 2.804069985350392, 2.4099041769816347, 1.2794673431368455, -1.745877687699208, 0.84476230010416, 2.111152949618613, -0.08815673440654742, -1.226158569011131, 0.23493163549750562, -0.17103286872314685, 1.775251390627683, 1.9141664699117962, 2.2021074117039534, -3.012977942944606, 1.4018316521508662},
    {-0.2797043252329402, -3.038058030078649, -2.4649135235335, 2.2484096747093347, -1.1236559354708098, 0.34446487328299147, 2.2798499086657382, -2.7748756880062633, -1.7635381213197299, 0.009482804972403568, -1.2710990365965673, 2.2397972033365288, -0.180539560500073, 0.8848143514448553, -0.17943223362631086, 2.184922131268329, -0.35580237890658256, 3.0348334832282298, 2.9438973405690168, 1.223699489925202, -2.1580968844868598, 1.0097864406475257, 2.27449359421094, -0.7774030820163389, -1.1783589735896567, -0.21777834321404346, -0.33075023209115706, 1.4784388538946311, 2.0592878962728465, 2.2842622260167764, -3.3010990160021967, 1.7910725546668531},
    {-1.0253207654165544, -2.9861447785772346, -2.4478193714871375, 1.9555970354293797, -1.4143109832040661, -0.19548580095585993, 1.9483238934605842, -2.9669223547502424, -2.030298198733618, -0.41300536596193577, -1.7064998164726333, 2.490558062132568, -0.5396651023660227, 1.0516939869386221, -0.5862442645451903, 2.349767825874554, -0.7676782173400309, 2.9685305522359986, 3.049226226858405, 1.0703424554700507, -2.295607921214701, 1.1577736657585367, 2.4753093325376785, -1.073639293016444, -1.693122325043585, -0.35691769966460285, -0.6660375694714706, 1.2542147304755669, 1.833315152677218, 2.4736837615925276, -3.2005847211246023, 1.9946275475062374},
    {-0.2993777288068747, -2.955227965696111, -1.8394986083160147, 2.621830653338146, -1.1416544477490127, 0.09752414105226938, 2.3903491196811917, -2.648536711600015, -2.0242327631567387, -0.07777657747959867, -1.5693400981696723, 2.2562027966362965, -0.215256116372079, 1.2554947625349828, 0.08080494413731369, 2.3416732202241626, -0.8965492554988742, 3.015445978079336, 3.0076126479312597, 1.2912898021643981, -1.7174809954022496, 1.498172751191943, 2.440612156521243, -1.0293800747598443, -1.0574123211180513, -0.2663976426308224, -0.24558180336788854, 1.916279521456654, 2.145472913078879, 2.354394672001142, -3.283141117254346, 1.8880877952124953},
    {-0.43228055277128485, -2.9532297646071957, -2.135443779606185, 2.717280776031295, -0.8585175588004643, 0.058161535068867364, 2.5117806945904144, -2.6028745981032175, -1.8926308727084251, -0.2555869012274941, -1.0790175829215634, 2.571929601324995, -0.4864406834221563, 1.7657899762427636, -0.1086507843228272, 2.2995723813042903, -0.7776716614403952, 3.0100000670588893, 2.9355984648151137, 1.9085354691295537, -1.763276535998405, 1.6677624559831739, 2.3029419507868956, -0.7312827840522854, -0.9397804061754002, -0.1262862125421892, -0.1949948882357259, 2.2122948813078898, 2.3467750822772313, 2.707785474671136, -3.5394182164452723, 2.1386140264195808},
    {-0.5426185017330052, -3.175148776621957, -2.2427067793795805, 2.2393637532076007, -1.1640452913207888, 0.2743366444728406, 2.142977358379662, -2.8515572831568803, -2.4092912571771894, 0.02388430570790573, -1.586281859611013, 2.471918553589964, -0.6161350011375479, 1.903817678102212, -0.6675445238298188, 2.276317368355946, -0.9058561347070312, 3.2797410388312023, 3.321028523142271, 1.6072569342862815, -2.10374698451291, 1.4738884734317008, 2.005623271602205, -1.2262576983316111, -1.5692948071967818, -0.2803869372113449, -0.6437841235963959, 1.858045007815479, 1.9217045025975743, 2.719588651565737, -3.2352597574105384, 2.0291392254781675},
    {-0.47129836739880093, -2.963997489587374, -1.864233959944956, 2.2403426037786986, -1.3137297934296863, -0.18361128124637482, 2.307624092864875, -2.828318259405682, -2.3604025611184714, 0.14135109520742645, -1.1193788378739384, 2.5622170199380387, -0.793860965452587, 1.4780632458627232, -0.2670249115805855, 2.0231531955427844, -0.7471499527136539, 3.506702801919554, 3.0979807323077106, 1.6333179737267396, -1.916783088080904, 1.3423195396757264, 1.9659907724412313, -0.8113983406856292, -0.9442361488214167, -0.19516132935526592, -0.7901643810290068, 1.7835127936695598, 1.9654130743910379, 2.630110829088363, -3.372385331570118, 2.3237310528963246},
    {-0.11638696856710533, -3.337271918025781, -2.4082446571907554, 2.455000620977165, -1.0344579723704326, 0.014758534071962306, 2.523069325177535, -2.849400621998433, -1.8521503967959678, 0.2633793719661336, -1.3845976081117959, 2.4238779242430515, -0.3891388904992191, 1.6857167325613052, -0.23054710203963918, 2.4709437818556887, -0.6577117254440974, 3.4387329628264887, 3.4144623193153314, 1.6532075504122625, -1.497750897099484, 1.6893011534500482, 2.584909602120165, -1.0635031524587675, -0.9165429328090372, -0.32772059568915646, -0.16296659988674717, 2.0007341298162826, 1.9525432611148341, 2.655675950871302, -3.6832102091894763, 2.1031816285228775},
    {-0.22573473713339315, -2.986781327949646, -2.496118266724157, 2.4150379926544487, -1.0317105813495722, 0.25928388293553395, 2.2996943322315704, -3.2320580758129487, -2.1305956564900708, -0.21431821143213556, -0.8194962269045998, 2.7923228974162435, -0.47610263453599994, 1.9960610874580975, -0.1334414530405385, 2.439790091216418, -0.691860166712316, 3.5167320934596806, 3.1162307910760387, 1.784894187997038, -2.0061970478758977, 2.056790568724419, 2.3971214795977294, -0.9581028618625956, -1.1118216293931413, -0.41921545471627913, -0.30649241023714713, 2.0569848051241997, 1.8591657731950302, 2.9637130723797362, -3.4825533345959805, 2.2621675985982304},
    {-0.15654821704459917, -2.7506087632108773, -2.041981646634028, 2.5780430974216997, -0.9601047449871626, 0.6623479941351835, 2.3535222919584613, -2.5723131233000998, -1.945801749523094, -0.06439602906700455, -0.5706731399276557, 2.8129526396990845, -0.751385847040374, 2.0481547690479616, 0.18209406942715206, 2.4246282513406894, -0.6356520768075017, 3.582868886548236, 3.258629249751088, 2.0237278921403585, -1.5311853310803571, 1.97695114413809, 2.568480640312078, -0.8565705731652155, -0.9406807241180744, -0.3630873450280329, -0.17850485535052468, 2.2836754602139497, 1.8279235918433723, 2.755737128833865, -3.078378838123574, 2.69966042589541},
    {-0.2945639913657234, -2.5630306502937796, -2.0730144664703145, 2.5724788878659233, -1.2013859023485336, -0.15167288309267807, 2.334210565084367, -2.572479446830034, -1.9650779064557813, -0.37222150186370256, -1.175296388820267, 2.5072938513014544, -1.3421099991115586, 1.3533679785725279, -0.43704509383782497, 2.123430167365473, -1.0768400006382797, 3.422737882407624, 3.015720133357259, 1.2864571393613382, -1.6993546557221084, 1.753394968440392, 2.1913596726915996, -1.5524255243847376, -1.1735641956642004, -0.5522018012217904, -0.6147242623449973, 1.984188424110367, 1.7158055133873886, 2.472608571900556, -3.335489069611749, 2.5109316422838686},
    {-0.46739185667626554, -2.840132295070788, -2.392162823686212, 2.7588656697263136, -1.2380620487466623, -0.4538343668662118, 2.5494423337405028, -2.993525264371436, -2.2443146691319975, -0.1737944513946552, -1.6344558289582094, 2.7802368991602777, -1.1765376946904786, 1.1400821220747224, -0.4615400358647853, 2.3875970043467736, -0.9280354554468555, 3.807958300452134, 2.9620322208588705, 1.3678068031807658, -1.5736984636063795, 1.6711138469457127, 2.8364045148614623, -1.5748862963271473, -1.323843419631296, -0.37668023032174486, -0.48893252965795103, 2.125771084772885, 1.7121616222195726, 2.732728964452706, -3.1278884391663655, 2.264372819880489},
    {0.21101692962819077, -3.2087767959070947, -2.1845389203129444, 2.815200389092542, -0.7127221004838525, -0.33314141328280944, 2.665788176562789, -2.640760396568793, -2.050929686424437, 0.6591122294542073, -1.3920175995997834, 2.3637687662163884, -0.23213786881650517, 1.5785074254002294, 0.35044215697852693, 2.5475667919463993, -0.3448058597243561, 3.872035466769466, 2.953614677397862, 1.6646821841021202, -1.3310120870162883, 1.8211030397951318, 3.271193874804644, -1.3639740655874844, -0.8038524077436736, 0.46742614402518323, -0.06872522441670106, 2.093990929856558, 2.2404379611105574, 2.5879618560440183, -2.866168671719174, 2.381451016968896},
    {-0.6718915585925894, -3.1176223842761486, -2.326073823685127, 3.0339907312957144, -1.2675001385231823, -0.08749038890213418, 2.6734893157143147, -3.165838714469901, -2.4864642288741616, -0.1839070262528033, -0.9386045901293579, 2.603072922940491, -1.0440732482939385, 2.046551104187127, -0.04568623181992238, 2.7835489461931817, -1.0884855936385074, 3.6925219756022645, 3.1418583611175515, 1.9091174824564334, -1.8123167912822287, 1.6932469401023729, 2.704370094688841, -1.2431622679251193, -1.0036407147074924, -0.40997361559858253, -0.7162237673052666, 2.4322568246090337, 2.287065648833725, 2.956529673419233, -3.3291098401119483, 2.8921996259702634},
    {-0.7135242785219196, -3.0958824603243684, -2.3247171573615915, 2.945276951707157, -1.405408180870471, -0.18233549734147408, 2.4979064562724167, -2.894244584691638, -2.5010146254348884, -0.3440841273241263, -1.2103809598829196, 3.0047739875415105, -0.7317611415091836, 1.5243938946555664, -0.40901931393009894, 2.940229069508707, -0.6789002780195472, 3.6780834588452147, 3.4750820380529257, 1.8195267649249447, -2.0127193123652374, 1.7016814237756632, 2.928058333056737, -1.673725830176952, -1.0659814030967918, -0.5474828181219276, -0.7178362898897336, 2.0616018244794105, 2.4003609970492854, 3.1239545916839244, -3.644937201528194, 2.733218333580107},
    {-0.5133792801854966, -2.8604796324686537, -2.217120300095421, 2.999258339054409, -0.9336193039539722, 0.553352367758151, 2.8819359487222833, -2.7455286802648198, -2.37145562095517, -0.31280425253430394, -1.326416184020319, 2.838162358027835, -0.7221329912367916, 2.190656536546829, -0.11743004324452218, 2.7250076925697844, -0.6030208113135234, 3.7310242429092626, 3.3948191354322677, 1.8861887204054002, -1.7917681734062116, 2.140110334705407, 3.1326962935907208, -1.387337355792452, -0.9925623253170773, -0.03475197328239618, 0.012025894118457014, 2.241310352507898, 2.301980653832138, 3.319815463145644, -3.037863251172732, 2.717700020798799},
    {-0.22958253742517643, -2.937661620979318, -2.5262389714180635, 2.5734820636887124, -1.0846951979777772, 0.4762042446838416, 2.995246820468852, -2.9702806970967273, -2.1020403347091037, -0.09859926286040549, -1.0835397791473884, 2.7219626621528503, -0.8017584076167601, 2.3560306791727816, -0.04420093434335033, 2.687286555371917, -0.63211290496347, 3.583151037549841, 3.2817994870965115, 2.2262263336464754, -1.4800477432784878, 2.3256852733689906, 3.196218128744027, -1.3016712706657025, -0.7324310717069548, 0.07555280172347033, 0.07617816710345267, 2.142906148692153, 2.217132174650923, 2.7547625178239823, -3.126860557740369, 2.604763388840013},
    {-0.06141228552492224, -3.1608151235783213, -2.203279763191489, 3.36492895407039, -0.948920839599937, 0.0005014085511051028, 3.3402973240943687, -2.7609371939045775, -2.2911790149394733, 0.5193934631276865, -1.0169725718151859, 3.2539827255481755, -0.5394181240598973, 2.432530108417768, 0.44976129247803665, 3.103525361737065, -0.4119631402739172, 3.8036622224760324, 3.7716675309263406, 2.06007912847846, -1.4095573827430616, 2.47895677036734, 3.293169206296085, -1.4867194331984506, -0.9460954362681867, 0.24888779779986253, 0.2761945482650281, 2.3583849155740912, 2.4341566168784436, 3.1375252765833337, -3.1112079342228354, 3.027370864112192},
    {-0.2998627508611333, -3.1291070942565646, -2.649890643935687, 3.3410984870942033, -1.3424128727684652, 0.1474620724679538, 3.0764413031425137, -3.0664311164471565, -2.7122551278844993, -0.415230557451667, -0.6449752623771939, 3.4121450325719387, -0.7505281144780707, 2.2051884065870304, -0.11997121663545078, 2.955947300214782, -0.9222449107179039, 3.748510920260601, 3.626265008610781, 2.234218739632313, -2.09583983534095, 2.405817776115094, 3.285919775422244, -1.6295686367361082, -1.0878905880077885, -0.46941580267001054, -0.20726561819525602, 2.745585805178627, 2.5762845161447374, 3.1336289373508857, -3.0115337011961403, 3.0774676332207584},
    {-0.5005909642953698, -3.4234408925025916, -2.9716960666418673, 3.2055727335666755, -1.3822802440693076, -0.22577700630777614, 2.833877332622101, -3.234917003904413, -2.5712762120108192, -0.14335055225006033, -1.4163027960942434, 3.4120243777620893, -1.1025275713480096, 2.3003524936051924, 0.14433121993345763, 3.199333874603861, -0.9621724468418987, 4.068105101627616, 3.9403252134201106, 2.2864975869075277, -2.5224024970367354, 2.5377984883512092, 2.990150795153446, -1.537550834352152, -0.971645858142411, -0.405929859919363, -0.3628111596084126, 2.3476292836330237, 2.5446133022495494, 3.479185839259621, -3.496450361865332, 3.1857505119495064},
    {-0.41258671506106925, -3.304777768227316, -2.9833851404231564, 3.001538782832793, -1.3156915426378748, -0.4248508834259641, 3.379675185619666, -3.1264597062895683, -2.3303658446022775, 0.24800115253077426, -1.8094856194668112, 3.057332145011273, -0.29585374219513966, 1.8001430085920898, 0.17952467226217064, 2.926907955910986, -0.5926912921278585, 3.959142343939959, 3.5407046483719435, 1.8454536492628748, -2.2670648522572896, 2.1745882197812705, 3.338399494714685, -1.2355630795568562, -1.0008572752828038, -0.05249290568530198, -0.24835265871080411, 2.204656101278695, 2.5845649828147397, 3.079837328509972, -3.552362239111949, 2.845409964767617},
    {-0.7726737259741363, -3.356540957933503, -2.807296544959541, 2.9680528052352066, -1.813870701135066, -0.3311197840537383, 3.2126707749400034, -3.5203823495945783, -2.696125099134843, -0.40316970754146425, -1.5091547132734724, 3.3288529973195335, -1.0563081257305722, 2.322591280102648, -0.23217116642583352, 3.0431530071206168, -1.0774493216178793, 4.015436042471908, 3.661450140252253, 2.5349815565779314, -2.458184862078879, 2.246755228961559, 2.9873624281720574, -1.943807975496327, -1.4874980662143853, -0.5886174959057304, -0.5203156804952263, 2.7942278869523793, 2.9026161864588373, 3.4663517696307102, -3.39821338634757, 3.103050265285686},
    {-0.528247708571143, -3.410791545106346, -2.748724496321244, 3.028808245808389, -1.6497058105275637, -0.1911977548090171, 3.0912785601995787, -3.066748096908559, -2.681230690279401, -0.5549584566339111, -1.3447788502615659, 3.665299927495731, -0.9526259903118762, 2.1719671621088894, -0.0037611423251682446, 3.2422545708660713, -1.073395028772725, 3.985406961208638, 3.827074708721665, 2.3393871452670854, -2.1797509532695956, 2.5195525957525113, 3.2217496890613266, -1.6292669548952154, -1.0552982026745312, -0.7361040066951257, -0.45261459011645644, 2.492995380443906, 2.53503025359832, 3.398963909980222, -3.389790353863883, 3.237882002359814},
    {-0.9983947663564677, -3.260901391303448, -2.975780057268224, 2.993573269484832, -1.757855910437201, -0.4656387412413878, 3.075074047883914, -3.014049308005766, -2.8077654752439853, -0.5569808932760246, -1.4996947103329707, 3.1782754145603116, -1.3137574051769023, 1.5772357006043567, -0.32993792258034177, 2.8655972804823757, -1.430191148562961, 3.7685600072854935, 3.7619754074645555, 2.0176426717924207, -2.3591767370691703, 1.96413058395412, 3.2320190131727076, -2.247501606498203, -1.3455463614572203, -0.8870024779838476, -0.9463825016630237, 2.096142756061075, 2.31788415865063, 3.1321554801080342, -3.476725323035345, 2.755821406191724},
    {-1.0713765510065552, -3.4213291317323336, -3.159675102849711, 3.134252229013042, -2.188975303908425, -0.29473828693804033, 2.9005648768793177, -3.4463715318360926, -2.9536884110911745, -0.5312329884343169, -1.4564937253715795, 3.3654101829997733, -1.4110871828032783, 1.988980991484519, -0.3388375111533325, 3.0342138195114186, -1.239843376896929, 4.123353096781434, 3.6000991577381254, 2.1324700130143817, -2.586411757777459, 2.2271585388813535, 3.5075628935154772, -2.584514575772729, -1.3895598102766848, -0.8201875722092958, -0.8993324956458513, 2.476827581261605, 2.546900365348238, 3.30067848847081, -3.415216529380641, 3.1829785054039874},
    {-0.7056115228910892, -3.61643118621559, -2.8185971534462038, 3.179477722027046, -2.0533807219064553, -0.18088547808402636, 3.4506865313085466, -3.638018995443648, -3.0224408484715117, -0.08033368430849033, -1.5650741792559824, 3.4378960476642493, -1.1215805254667983, 2.3817503645448075, -0.3817051980313473, 3.127197804799952, -1.1222540938043097, 4.123694838707697, 4.0176689918388515, 2.3630930911562227, -2.2716022354909726, 2.2842809770583035, 3.2392191368244125, -2.1928085430352815, -1.2761397221475084, -0.4224277889395995, -0.5488492704154336, 2.537995126459345, 2.5878616855177214, 3.1612816299966227, -3.3711891059419368, 3.2394644401201367},
    {-2.3205293530783244, -0.002050617609339263, -0.3941818100354302, -2.3379299986951856, -2.4293619019953603, -0.5689501084164443, -2.198677516819966, -1.1277730059568818, -1.8829526520454085, -2.595087182720116, 0.23148829513269475, 0.44275876390121865, -2.375567014309389, 0.5660409823900191, -2.42622570267889, -1.4098736715376807, -2.462191273726161, 0.11148013457220617, -0.593380480897736, -0.8720193892674636, -1.62169479932826, -0.61323361762016, -2.0649260417686603, -2.1313582363921832, -1.9586431600709489, -2.4866894283045924, -2.7968237409599697, -1.4962696579951789, -1.3226329339391163, 0.14943271157257867, -0.15734419511270217, -0.5365267519713783},
    {-0.9635631534590968, -0.7659214672487666, -0.8670046095461493, -0.4966671060397377, -0.9212995623751647, -0.08240251305829105, -0.6167518318172751, -0.6901306873370993, -0.6978979122519189, -0.07059267871595691, -0.6430095180764805, 0.15240824194998162, -0.6212025894394292, 0.021556590050274126, -0.5425835690981319, -0.6528456999310408, -0.2617751914873347, 1.2788802105019152, 0.18532747858233622, -0.5139875339608748, -1.017933654876831, 0.026566860651947802, -0.5388299829165728, -1.2123812500142417, -0.38451066854665933, -0.5036527542550339, -0.9367276515705842, 0.21114436977491055, -0.3827567610131184, -0.1221101401483244, 0.807852788532939, -0.0038427407976253753},
    {-2.608456213124948, -0.9052018160981519, -1.7924850548819906, -2.809881611557823, -2.368294268856554, -1.801946101418253, -2.504054533947178, -1.6885944863345608, -1.9941102197434513, -2.0534887851509875, -2.0616399474505616, -2.0341539697859026, -2.99423476298968, -1.9960479878162518, -2.8419994813616984, -2.4107162373002695, -2.9335882252299474, -0.22658055930792348, -1.9049090609540384, -2.210416753490946, -2.244596475117416, -2.284619336505636, -2.8029810641594928, -2.3216679152378186, -2.0575819577294983, -2.840285475977433, -2.9223418203156366, -2.3482385721998087, -2.475914280267593, -1.7321161030650931, 0.9162361167767187, -2.091123575765749},
    {-2.2689891665320956, -1.1351972800868835, -1.9342478121130267, -2.038377291351878, -2.460398983118844, -1.3741235272484469, -1.8490603382897046, -2.1646631709647117, -1.9755983920683513, -1.4244588458253455, -1.8963844279043078, -1.4105559109794796, -2.2670132574694857, -1.745527529575442, -2.4086201624652213, -2.0823653308980736, -2.1619822773997193, 0.7512184601315782, -1.551888055536141, -1.55062101652678, -2.138852658044892, -1.5945100180403668, -2.1160620588182204, -2.5602567904758464, -2.1259382273304355, -2.2921070018387284, -2.4991909472118308, -1.7338237652443063, -1.6379642384904978, -1.7083556474226271, 0.4683755118770988, -1.8936390540733663},
    {-1.92903790116182, -2.2373203770644903, -2.900171162219956, -1.9756918708332978, -2.043809016936249, -2.62757978632685, -1.480318254379383, -2.2970760595045636, -1.6073068025973853, -0.11835660112797278, -2.904194996380209, -2.437918109085907, -1.7168711209660945, -2.387630902822625, -1.6383707038340116, -2.2087686409427207, -1.1464209357146713, 1.2693254704259125, -1.445797653393548, -2.0406863605712826, -1.8999773761440726, -2.0959987176015673, -1.137140439440761, -2.166852945093196, -2.4928711935796177, -0.9005202290373842, -1.8436132193549764, -2.0633716399168263, -2.0745745363600796, -2.264011020853715, 0.44260116613006056, -2.3500216190732015},
    {-0.9141168403899295, -1.2495258094408699, -2.07528509633188, -1.3646045784347658, -1.1324973641218632, -1.4958224527981487, -1.5360032651916196, -1.4909809387790653, -0.6337346860867026, 0.32442937749885176, -2.0158162485429933, -1.7857564433299213, -1.0558218706854245, -1.431280333786078, -0.5749011845236366, -1.939066332012411, -0.17228876354359657, 1.086392173163462, -0.7686825760679369, -1.6292991157378935, -1.569186962501428, -1.8398582928903917, -1.3411478370513765, -1.2444855372828492, -1.9162898755794786, 0.08915630382587082, -1.1052088721354478, -2.064927821657785, -1.8457375904107292, -1.4427911700477192, 0.9293293607317554, -1.7654268304357654},
    {-2.172678297872818, -2.0272487156160595, -2.39463652616828, -1.8552713109369978, -2.074016374367289, -1.8615636327004463, -1.7390239100144418, -1.9259511755934875, -1.8080221693909853, -0.2121419621268541, -2.1450568548200306, -1.4841098543129247, -1.77863049548995, -1.3167203045762221, -1.5521986228596898, -1.7922352233826233, -0.42706064650972825, 0.872818909378583, -1.1712723352208994, -1.8363910564923882, -2.271809882441625, -1.8195398079284886, -1.266342009864275, -1.9947866875194022, -2.081073502633958, -0.721490129678345, -1.8546755454906652, -1.893478571127351, -1.708679403568233, -1.576474943449585, 0.269198945274451, -1.7175079846284107},
    {-1.4524208035123751, -1.1166548692677456, -1.773364208563333, -1.194265498310961, -1.9229346546742698, -0.9791082437423967, -0.8735846058877724, -1.8130888719370468, -1.3948525311487745, 0.12482713576420358, -1.5447657467994955, -1.3613069395640278, -1.4053782540266468, -1.3649128648170201, -1.0831456381773168, -1.3151972103840035, -0.671161269761068, 0.8904587343979098, -1.0618716290837036, -1.551145425887575, -2.128330839543509, -1.5235342341347433, -0.9948732049409578, -1.8002740851293062, -1.6738902956631987, -0.3043503307231499, -1.5179398557600445, -1.6591790139916525, -1.500190504742229, -0.9930609053485886, 1.0036983624820115, -1.0278352550806107},
    {-2.2528710307207676, -1.9353265803518402, -2.1179335772005614, -1.8684661991613756, -1.9641744268632542, -1.8943531983220603, -1.3495670227339887, -1.8293628658462755, -1.6284409191577938, -0.46988060960177663, -1.9355228334015568, -1.4254845980956878, -1.4656743068472866, -2.119643661918219, -1.959930583689746, -2.077187248215357, -1.0950730660779087, 1.1464019139729897, -1.194815861495781, -2.086816273501555, -2.491482790834681, -2.1320500848354333, -1.4576425318326929, -2.136274021152216, -2.2095350861885876, -0.9128686290555103, -2.0832022805434374, -1.978044868948111, -2.134130127211716, -1.900226716075258, 0.44716644132525696, -1.9651587191739597},
    {-2.5071078682709356, -1.4116944107743081, -2.4162106389646185, -1.9272148163820682, -2.422937484614873, -2.2496947400272194, -1.8851373080273057, -1.545747215015635, -1.8470201494053125, -0.6944411625208825, -2.3229104510637564, -1.7565921637572985, -1.7274355668883898, -2.1501842251743146, -2.1249066684992854, -2.255043574644707, -1.3304028357616662, 0.5665944631205226, -1.8058966490793653, -2.411450788253305, -2.0782233138783974, -2.6966133986467797, -1.4498784216266765, -2.1890344030631117, -2.8067506889819063, -1.1699665792672955, -2.228449560829345, -2.0565469671000907, -2.284798704847108, -1.985007215233351, 1.0302085187681311, -2.305860726365568},
    {-2.0519823084595554, -0.8924686284160375, -2.0775578154962715, -2.1233171603521743, -2.1312688465371528, -1.3944533917942339, -2.122553473775881, -1.7163910968726566, -2.0041880629814863, -1.11396918481593, -1.5566394938215868, -1.092792533245659, -2.0128933078582185, -0.9054074206994863, -2.0198294276375655, -1.57364291887431, -1.8553775303316047, 0.6182898839176406, -1.5686655761483894, -1.7006620134373047, -2.1078162152003257, -1.8822237321123174, -1.7911584310424105, -2.1189791557848925, -1.9311145082898968, -1.6758550826662912, -1.8323179148321402, -1.524389027816763, -1.790062345486534, -1.1274839964288013, 0.6790213866126897, -1.4922661386495395},
    {-2.579271843480437, -1.6955396264744609, -2.4412215964263515, -2.537313869500887, -2.722723242827922, -2.2378099922697854, -2.375445266669024, -2.1033189287467167, -2.106429464399947, -1.0737903838691263, -1.9866331972401068, -1.4051593629628503, -2.0364673448300983, -1.53972666059522, -2.2568461834663105, -1.8678533917485756, -1.7804890732014893, 1.5474570618151986, -1.676955504374342, -2.0905303892720744, -2.3523265320751516, -1.9399582282844605, -1.6406847496401475, -2.563799016808183, -2.1773994358709547, -1.6313607039148568, -2.5087836912064274, -1.7446816927927393, -1.9231649863752571, -1.7174796084028081, 0.8352190590591542, -1.6260974768270806},
    {-2.7478617879477616, -1.6660572673568117, -2.7479682416508453, -2.3714757265063673, -2.794001929996392, -2.068782931254798, -2.095599224632226, -2.363429234752528, -2.403641117903184, -0.8927703957222555, -1.8964170239377398, -1.5458803133513774, -2.1087688848721236, -2.0420696836560084, -2.1368110098667557, -1.9287461312338317, -1.4559004292107771, 0.9320979856168654, -1.7444404032150589, -1.9961650420883221, -2.4645871563483976, -2.4095022830797315, -2.055095209381624, -2.4641521412512457, -2.331218341109796, -1.2710447026302127, -2.794683198001147, -1.8874428322706633, -2.1510214738899216, -1.9046888580937151, 0.8605434264174411, -1.7321019915816533},
    {-2.8597783529966327, -2.1414665976522973, -2.8086957778101045, -2.6230962523427066, -2.560549745924909, -2.3122507733591617, -2.6207970689940376, -1.6516750688103614, -2.3824627490518666, -1.4288791273246912, -2.1832569170428613, -2.0686476092798016, -2.2453920879327836, -1.8199631943781618, -2.571625209077873, -2.2741488839512503, -2.1638078209101375, 0.7282492647591251, -1.6551443639769494, -2.2335802442769306, -2.825232361369541, -1.9319723166517495, -2.113961082323039, -2.5942707032224743, -2.4162185946969092, -1.7287143033709245, -2.899635945410395, -2.1044794448517328, -2.0244488117676855, -1.7710745891812398, 0.6038827934651843, -1.4939876353251653},
    {-3.121379368577759, -2.197242815754168, -2.1781763049477836, -2.8158380615198686, -3.2523472639101776, -2.632926600342232, -2.560463060852705, -2.034539655383111, -2.2884211762425397, -1.1334871028932398, -2.3034837196639364, -2.268143272260597, -2.407119915361718, -2.097941430719678, -2.729839523905879, -2.602194694762521, -2.0394011703218027, 1.0764956640274128, -2.142146934770523, -2.6354608518317963, -2.818037248441529, -2.4554500081106503, -2.1970394351310945, -2.9785945326783554, -2.5374440667368896, -1.685198207122132, -3.1816448761497473, -2.683619103986172, -2.9719897049356554, -2.1631539815356446, 1.0539849669262615, -2.108376670327047},
    {-3.3323233541159922, -2.1149469907042686, -2.5484538585717016, -2.4172883548402804, -3.3794001430959897, -2.002593127509561, -2.5731390457519807, -2.272759505163381, -2.8840997970633104, -1.9771318272153822, -2.1140002827917352, -1.5368778940353207, -2.8624764975050043, -1.2625556275845011, -3.4828858102164055, -1.915854241477749, -2.948748561578342, 0.8337450770399466, -1.6584648750893505, -1.7990772549631586, -2.7627860963911535, -1.7078440055351367, -1.9101534842810903, -2.824320141243178, -2.5262146114828647, -2.7214592414751637, -3.3800073263589288, -2.0795678879055277, -1.7394377295688361, -1.4962778964810701, 0.17899760606018977, -1.3937334995495523},
    {-3.2065883541239466, -1.116307209758959, -2.2758184104835095, -2.164279971686688, -2.8481889198777246, -0.6146335868418369, -2.345692956097584, -1.5556245767437755, -2.7867645291510614, -2.0476945276633365, -1.2681195662624298, -1.0097270573868333, -2.9045889973732386, -1.0333331208219936, -3.447731295811394, -1.9056283800905311, -2.909656480542554, 1.4914244307720907, -1.4333519867172655, -1.3363199579904461, -2.545149632176057, -1.5098321395604661, -2.262957388858762, -2.216210861556267, -1.9979182017700943, -2.4554846410651154, -3.2925820163420485, -1.150734551389357, -1.5563543293326998, -1.5349425580104, 1.198127969090041, -1.1544109710136594},
    {-3.658608120938906, -1.873039403843081, -2.3488545925385997, -1.9513947452639258, -3.1750389790818674, -1.0230416607501422, -2.040240980176159, -1.8597745736584963, -2.766232751297575, -1.656608337173127, -2.0613713896847106, -1.1996947045103756, -3.144065464266498, -1.4720690738127464, -3.3422442699402777, -1.8257726620391252, -2.8761166578560675, 1.614828582584011, -0.9315819817865275, -1.475307621327814, -3.0176714371657245, -1.5085285724051816, -1.9510004211831846, -2.5905345693538884, -2.5034812495104948, -2.8104066699999595, -3.5731896598712227, -1.251769319758822, -1.3886113567378435, -1.4394274406846606, 1.2532221797512866, -1.4061968131134788},
    {-3.489570555840841, -1.6017626316080011, -2.428826710492688, -2.389947045006732, -3.445409065814652, -1.443504982544564, -2.295743400999476, -1.6296250465895763, -2.8444013549547704, -2.129661487396513, -1.8483002500860253, -1.6521917371124735, -3.473942319214212, -1.8986652570254117, -3.3123608800015165, -1.8890036820079377, -3.16683247659466, 1.4464625049755837, -0.776221845414345, -1.9031682167359476, -3.136367218304032, -1.873475508729701, -2.5628448117568388, -2.666030067281617, -2.46890089839412, -3.1199897043876703, -3.5434925527378387, -1.8528123314977158, -2.0081217869442303, -1.3948831461415698, 0.7925393494263433, -1.2605449258267367},
    {-3.1575620959912256, -1.9005657904030593, -2.9220298831231974, -3.072659308360136, -3.4161041297030925, -2.2536409497036622, -2.912520984328621, -2.3015236458668613, -3.1675999250967526, -2.1842294650247864, -2.56926291792937, -2.4083593597384847, -3.0589765040537555, -2.6305798634184647, -3.247738561358511, -2.4562571367919905, -2.7965251966822966, 1.176050341087505, -1.6202896042632224, -2.8997044173421385, -2.9054770039054487, -2.6832001127094673, -3.165480504393257, -2.930988530805825, -2.6516683402672316, -2.9030928145825423, -3.3348029077887578, -2.4958042051613742, -2.69676544067764, -2.2434646323935516, 0.8848471782616135, -2.1282860394361753},
    {-4.003059090753325, -2.0730515726385823, -3.0431628216157947, -3.1323596210240456, -3.6000082703277916, -2.2305663466085384, -3.2148508463645107, -2.4582927912412704, -3.4370178046174353, -2.8292270442128893, -2.4741860160675055, -1.9677896257188028, -3.454466755669014, -2.1036495515046307, -3.866524488546594, -2.8442450069241714, -3.3865137837949075, 1.3132439712363133, -1.4890979302216771, -2.5625140747085444, -3.6008027487358154, -2.3983598719949315, -3.1520586152583414, -3.3508956419595646, -3.0103791271803444, -3.281310774369165, -3.7406811662443724, -2.183241276845832, -2.3390027004678413, -1.7409414285550862, 0.8177588118359091, -1.507693147629032},
    {-4.540840603949086, -1.9690142013962242, -3.091870524529587, -2.9212657264852218, -4.020765525718384, -1.4561679043908005, -3.031645621116003, -2.219309364655066, -3.3980833943677524, -2.984589822301037, -2.628705940427964, -1.5741197494550876, -4.3304311551503005, -1.7954252729248659, -4.552111416707784, -2.537955926501293, -4.031977767765207, 2.415600700839417, -1.2372186973737869, -1.8900823264189421, -3.426909209469479, -1.7587182997475075, -2.994084803224266, -3.5014924078848626, -3.2323703030772473, -3.8180431984035805, -4.4540418053669795, -1.7192247196608772, -2.215915885086469, -1.6502832261573994, 1.7238107292994354, -1.1370877490639706},
    {-4.757890876074715, -1.230442568439665, -2.2319063250390894, -2.577735247641751, -4.263144645182616, -0.7397637345239312, -3.0540319904221347, -1.8016132344520646, -3.6529015083219956, -3.5334598846633836, -1.3767686237691381, -0.5546448242763866, -4.510961412334268, -0.2875072422496758, -4.90037582941902, -1.885364061472845, -4.5238105283682355, 2.8018425332585517, -0.18885740958564298, -1.2541312140652734, -3.5703532069772628, -0.9079256861247167, -2.7804644011538233, -3.215009587523315, -2.232734832858171, -4.648314073769307, -4.859916697810567, -1.1284022908508515, -1.4368630719350755, -0.32895002697825937, 2.418411904003803, -0.30344816198447644},
    {-4.654836839335572, -1.9716407401238432, -3.110845554849547, -2.9509335893315956, -4.476693094494744, -1.4584782567311654, -3.2137822272092165, -2.304848191662059, -3.9312349338802766, -3.6555319732932423, -2.269275912383796, -1.1689141635881317, -4.285654963313122, -1.400866611274835, -4.511400971006171, -2.710462965273445, -4.29636768450214, 1.677901231834784, -1.1191220738634386, -2.2773107886269144, -3.694711098699015, -1.6756293869121341, -3.0422243715373822, -3.803654797422025, -2.8645051394969507, -4.368771189210988, -4.596097030735828, -2.0177910460935835, -2.061766585010847, -1.6085880461253572, 1.3736137519855145, -1.1230471638634427},
    {-4.377172735624976, -2.423760411890207, -3.3412979797043127, -3.4179679361446222, -4.234126458695749, -2.29429768574135, -3.3365518023615017, -2.5506284501013936, -3.5788780168382512, -2.9914697551216807, -2.925212138117638, -2.206912904043476, -4.174055579924543, -2.3851610472964495, -4.067708201418954, -2.8240087135165215, -4.158382322471624, 1.495189376428215, -1.7028558487580523, -3.0251747145068224, -3.5261013826242396, -2.665116599491188, -3.4456831476810073, -3.912958392048792, -3.50337070132235, -4.008120629461781, -4.370110459317891, -2.6276368049556065, -2.787294351027496, -2.1207983073615595, 0.9528393070842853, -2.1723359191130274},
    {-4.44367452942246, -1.8380837450842706, -2.8501350726079506, -2.996843202435419, -4.3915719868398675, -1.3596978893661567, -3.536068952528975, -2.6299523637028166, -3.5679522071200522, -3.695821595045854, -2.385071188941649, -1.084832488999204, -4.798275319839047, -1.3224720157938328, -4.663045084889355, -2.4543532198611526, -4.418871339071338, 2.202973065762253, -1.1250263629380006, -1.9339688681372509, -3.62198464665759, -2.029944018040652, -3.204098762426009, -3.8591590622672602, -2.913758176301028, -4.2593134571409985, -4.827419673229426, -1.9699805594851993, -1.9878828000320998, -1.0498237111463962, 1.3288029771713281, -1.0796728467839924},
    {-4.513749144708215, -1.7285497261483895, -3.024348471434962, -3.3500164031444672, -4.404290002651408, -1.9617689953022575, -3.698883209641195, -2.161707809352993, -3.7000382617443783, -3.298762113304219, -2.50071212939231, -1.3803872922923233, -4.218120322243386, -1.225817921894611, -4.459886005560411, -2.866000523114376, -4.377369983959742, 1.7848538439955184, -1.3635993278481782, -2.2406762563043356, -3.4100687111325527, -2.2806122268687874, -3.2432046425246432, -3.8580776577310516, -3.454937504675897, -4.0647775551160095, -4.592121456015863, -2.4314612852119937, -2.1891932674078953, -1.4320012640270536, 2.007631035704998, -1.51375378917268},
    {-4.648787954761066, -2.0816354869912304, -3.2889076037960367, -3.6541504996178995, -4.464503889037455, -2.0483966571947514, -3.8941022610021054, -2.4119149985891397, -3.5792569733501187, -3.743530580480176, -2.370087780218497, -1.8458581539509071, -4.6970248053255865, -1.4045637381856348, -4.83692864717814, -3.0217975362388407, -4.679375631248922, 1.4616768553001576, -1.5562871571023702, -2.5622729944770066, -3.7148893762210604, -2.4817747291701795, -3.6518462244386387, -3.7724649473846634, -3.5867727653452057, -4.405043791025727, -4.6428351302840545, -2.620283944775803, -2.549095733902688, -1.9238364487136805, 1.392233753506911, -1.726222518804543},
    {-5.0553279535545395, -2.304223719960691, -3.074398631674665, -3.4044179337680425, -4.552101191147553, -1.705151469778508, -3.2941928784469483, -2.3974584033747943, -4.048577425784794, -3.5158583706628703, -2.5866204251851297, -1.4698644488738957, -4.761814017474836, -1.35481432531142, -4.783544724182729, -2.888325188715181, -4.751284724850752, 1.7827792541842744, -1.3468993280335657, -2.422292797139202, -3.7450459078836413, -1.890721555363861, -3.3605145919536343, -3.874108733877738, -3.1404815762591825, -4.391216003454891, -4.980822814234198, -2.395142219975373, -2.520177811849133, -1.532995051875962, 1.0706080356383103, -1.3314944138344191},
    {-4.721804366969412, -1.524931119558961, -2.4976597851883993, -3.191509397578258, -4.473847121071793, -1.38025522523808, -3.3653954088586304, -2.325889986497676, -3.8000597856979867, -4.074934335187315, -1.7688058896413863, -0.7660299288738847, -4.830334022454273, -0.6715726196473378, -5.12553166559906, -2.477624657897124, -4.952344729886926, 2.2927016613413653, -0.7089436764677737, -1.8059977585913638, -3.4529430818643316, -1.562341332486641, -3.394113413531813, -3.8206323439247876, -3.2191505598830323, -4.4688383529229325, -4.845705369289187, -1.706348940796942, -1.5935074696336415, -0.8692149788521584, 1.740261044273753, -0.926725823426576}
};

static const float b1[32] = {5.747859898704099, 5.605480205007223, 5.592763783887501, 5.713304197625083, 5.574275972701631, 5.5060101641874155, 5.6847988327159875, 5.601536816941903, 5.584955789383061, 5.825128500268436, 5.663215706112882, 5.574565657854267, 5.870380158198311, 5.4757278658354664, 5.650083138597385, 5.49211854441989, 5.849307416677639, 5.638230095661646, 5.5723767391864785, 5.579998874912618, 5.671522757742016, 5.4768503741982215, 5.835669702159604, 5.628737290290598, 5.422993262412024, 5.740844145447529, 5.576231934531217, 5.510510585559907, 5.5006165236565545, 5.526362210410604, 5.6573064670638695, 5.538594392230996};

static const float w2[32][16] = {
    {5.2996927254353166, 5.305620244555197, -0.3412250643641981, 4.928485560669981, 4.893862820084312, 5.540666898633476, 4.738759324460354, 4.745273595658264, 5.410372736624807, 4.7990485697467475, 4.7300341436048505, 5.022858747480672, 5.1181936238985335, 4.917216534703636, 4.521318784614551, 4.827386296795364},
    {4.960437897949396, 5.224506272671226, -0.1242322844992735, 5.009941960941503, 4.568159967377825, 5.216671819900476, 4.9220609894071865, 5.110842044540113, 4.60735237951297, 5.156643586604839, 4.718507872408753, 4.962068163547427, 4.691843204736154, 4.866732258672315, 4.710084969685931, 4.929526109585737},
    {4.547745786235974, 4.830049890075688, -0.3739904843803325, 4.542925717430488, 4.693794577426952, 5.194958343618557, 4.484862130361821, 5.008546749773946, 4.4246982667556125, 4.930836216103597, 4.615959615056208, 4.493100922357593, 4.509139498816043, 4.536358072579823, 4.435413274361242, 4.519267909397293},
    {4.686802073617265, 5.29681129591127, -0.3462331462034913, 5.103127757177432, 5.194080258385869, 4.819623626020728, 4.967272959531846, 4.633362129452467, 4.854155630233748, 4.815169108018188, 4.769499727582075, 4.859168017426179, 5.233169875920045, 4.858371040236158, 4.723170387559377, 5.220293276248961},
    {4.951390852925961, 5.000125151302281, 0.08114791253420782, 5.115245640215698, 4.747376236528419, 5.299608464162491, 4.853514011224251, 4.9010806681551875, 4.975203031098499, 4.675260008567893, 5.053201935793393, 4.866486985322975, 5.334174396339679, 5.3814966074072945, 5.084182593831845, 4.6288403864534855},
    {4.810276542416774, 4.836806110590122, 0.1064203288570053, 4.752047364473174, 4.9003740845235315, 4.945130216616191, 4.386251730385726, 4.207477758473205, 4.742364005238435, 4.787084997909492, 4.409316297907098, 4.484426320455714, 4.520114865814509, 4.708299337269684, 4.150097349738192, 4.764409087007827},
    {5.106000464019742, 5.427261712221929, 0.2541378203765406, 4.982848784978227, 4.918505735974863, 5.009827157629625, 5.143746234496416, 5.133317270810165, 5.404177132508974, 5.531801965850732, 5.272524283163435, 5.130383520094508, 5.462418732643089, 5.379429480093623, 4.931689494158169, 4.9098397910354965},
    {4.912711140726817, 5.203764155745802, 0.2173567331634327, 5.439061462570861, 5.104735403518276, 4.8720906759224505, 4.850632745085913, 5.121105882847119, 4.797980221586951, 4.91427557219591, 4.944706805605816, 5.1615571507825, 5.080503030901931, 4.763511573572918, 4.649175607296879, 5.338869258013517},
    {4.935152003442915, 5.587917245450508, 0.18606059542857434, 4.994042074017166, 4.937011341849183, 4.972837006232431, 5.073313029883824, 4.923561387140785, 5.287411745685873, 5.048685160536547, 5.021091975187324, 5.4609600935951015, 5.376168019272318, 5.239269378815557, 5.049179906576019, 5.220057936199297},
    {5.566260946635396, 5.743397666067906, -0.23891801466470558, 5.6085577912001385, 5.122669036508072, 5.498675061188616, 5.258715193846763, 5.203931706093172, 5.12158237023481, 5.37567131710895, 4.916018412361199, 5.603574786607259, 5.144018284826099, 5.500255865948366, 5.208076839648617, 4.964912712546996},
    {4.429377640896342, 4.55272538156491, -0.2808407314773502, 4.569721590169848, 4.879013704877806, 4.4881520160644275, 4.319574518933598, 4.630385260903697, 4.31318521493604, 4.457750317771899, 4.577373273141786, 4.318280765212572, 4.4183897004428845, 4.466728916080961, 4.5803281975578924, 4.393531487332588},
    {4.289819049844822, 4.76326103265248, -0.2877482783622812, 4.62662280819148, 4.715898397673697, 5.1386826460957495, 4.430181624009288, 4.965502514922746, 4.489039809631895, 5.027985715817068, 4.480941750039403, 4.394602989397328, 4.761085084744954, 4.6973835184073875, 4.1416725200000535, 4.53316479368492},
    {5.295979268332347, 5.152681318634518, -0.17681858269960488, 5.64488422339031, 5.0930647431938265, 5.14673075106215, 4.974939730960841, 5.293803495961912, 4.978298248789848, 5.086858134599764, 4.945063160249745, 5.066257574983567, 5.593628652117481, 5.290753100956239, 4.950260823173756, 4.821832811597108},
    {4.076666235838279, 5.028195061401299, -0.0020915939917960954, 4.633479566065818, 4.570806447372101, 4.927985485712436, 4.678282603610317, 4.859191308588909, 4.796257642698256, 4.464217051253572, 4.70845344898514, 4.3826124406472164, 4.625857133018576, 4.875906628394471, 4.695253696423004, 4.3090941774963225},
    {4.863921536691165, 5.034605032886019, 0.26326985321712004, 5.285331564589373, 4.9056323725273145, 5.6239036254783805, 4.7894731338193495, 5.008125971201779, 5.580232285873243, 5.096548841308896, 5.10458651812518, 5.394965023387214, 5.355087845257656, 5.490207028018659, 5.219855237248437, 5.36968682621368},
    {4.591698162471012, 4.673259943094227, 0.3063616196974954, 4.673797005790875, 4.882011848403793, 5.138906262818584, 4.85527851923113, 4.576430402137284, 4.696190766041877, 5.198662225966948, 4.61547011706469, 4.4647928300674735, 4.803187074049121, 4.9981680730935905, 4.435262304571077, 4.9672781888485344},
    {5.244244847504236, 5.282573522956421, -0.1284553955352182, 5.423215935944938, 4.9044840974881625, 5.438674555931375, 5.07427016194407, 5.197414005120956, 5.122371659589104, 5.339156580651202, 5.243691219974637, 5.141000512180586, 5.17001228747151, 5.029919353591869, 4.604369341132044, 4.97954619390117},
    {5.212706952356633, 5.129816012218014, -0.3247880761972021, 5.56359509717019, 4.892976697334819, 4.783920177703293, 5.062366227263705, 4.950633846130331, 5.2918900602246195, 5.428431181911044, 4.569581121178464, 5.2456135136010165, 5.167772919552149, 5.031364234920327, 4.481316681823798, 5.04569204744676},
    {4.561865381024628, 4.729005764674552, -0.37041530336040296, 5.155200999332991, 4.919581913392198, 4.794247383290765, 4.575268812863798, 5.005120717676334, 4.772111830435173, 5.244901831766837, 5.070928868117385, 4.93293851561047, 4.84588890846186, 5.276573414844568, 4.749434680021387, 5.0671821142739395},
    {4.633773980224563, 4.52428521092487, -0.1122484649239166, 4.785666635174297, 4.887463579593942, 4.380651720782674, 4.345578672412948, 4.8727370998263915, 4.698714886221216, 4.482500555755485, 4.29358911587484, 4.4308309354086095, 4.610353621006654, 4.600288376889533, 4.282515126005966, 4.417068244815287},
    {4.756676677621029, 5.272715449272382, 0.08475822671657236, 5.158015893249731, 4.976914539365177, 5.041230998878787, 4.915958217268639, 5.22618446264667, 5.009973179844873, 5.053714673116124, 5.295987365772795, 5.142155320920799, 4.887143750611976, 4.885266981055614, 5.145998120920549, 5.287845261686772},
    {4.717668171580789, 5.022738332961515, -0.09662710842460412, 4.750840302038928, 4.854726956181294, 4.89509691897213, 4.5894726829308405, 4.606797694394015, 4.67173274132266, 4.850601446057893, 4.629505920964005, 4.647206830938217, 4.326599929537859, 4.905218405817969, 4.1914413723009325, 4.476749925576497},
    {5.337846439593753, 5.431418405320447, 0.05305025727143557, 5.4704438356251615, 5.059364723052515, 5.604453317896064, 4.736654835892237, 5.39102417477492, 5.362638033878975, 4.943887604687064, 5.107024907091491, 5.391757218596486, 4.948082061656927, 5.634588750847302, 4.9289684699031495, 5.379200778020838},
    {4.752820176125889, 5.243591136366275, -0.2835085515573545, 4.660337388267987, 4.902053392963338, 5.105453291885799, 4.337021734934119, 4.801294514134915, 4.948238698463777, 4.699425000478713, 4.583437288342684, 4.602891930499709, 4.949062787837128, 4.933949808834615, 4.728840585549433, 4.524080752972065},
    {4.468889926544833, 4.588709538353761, -0.00652619913977757, 5.084747565385512, 4.936004348828409, 4.756515621926769, 4.657165260681085, 4.471404253939253, 4.958847276761407, 4.764604086238789, 4.860623963437361, 4.716262940497186, 4.702953913850935, 4.640473336339809, 4.249960660500514, 4.898506659544034},
    {5.095784939272077, 5.041403315753754, -0.16783679106002153, 5.364875267085471, 4.990930721697518, 5.183908639253774, 4.796418123852815, 5.308457014841579, 5.126270626658689, 5.357418532553306, 5.462655792063837, 4.99300287277583, 5.428696577933005, 5.644989783430965, 4.70114418537196, 5.201949096353833},
    {5.005986044357446, 4.87302128394787, -0.0687332027041635, 5.3696552418546455, 4.872283046467484, 5.090029063771926, 4.786379044579121, 5.094885424509011, 5.2207176190885605, 5.078738846673328, 5.305602781726325, 5.091290326088425, 5.541877952409753, 5.1964518437227385, 4.932838786148565, 4.9188425200246275},
    {4.517567426109966, 4.94136741415522, -0.0814597139527205, 4.845136794170916, 4.803730397522482, 4.893743716354567, 4.301738591406585, 4.574198983377294, 4.557220984915206, 4.9348934261324295, 4.916253526158692, 4.8109576850148486, 4.517239879287914, 4.890762901507421, 4.12811068481211, 4.492826932648264},
    {4.379700430563892, 4.761651550725528, 0.19195154532768613, 4.549054103896234, 4.596974467418674, 4.724090620243154, 4.0772375182743765, 4.411048226341021, 4.326352772599844, 5.037301268561244, 4.893999569531629, 4.527446416919618, 4.800825760758687, 4.702568261903299, 4.649682567954264, 4.8532645432207095},
    {4.559997559015981, 4.884127101014686, -0.2147344855800746, 4.9152477693646475, 5.026278227014951, 4.700390869083553, 4.857995430163886, 4.740271687453742, 4.913295126402813, 4.915941214523639, 4.380110047929147, 4.92296052464579, 4.761220440497711, 5.036013385349636, 4.5671147764333035, 4.822705245189212},
    {4.643092092245597, 5.229487553933974, -0.2580441013052642, 5.025422922641055, 4.560058963833671, 4.514738284097957, 4.714468773119583, 4.565001551642947, 4.804060493228511, 4.902520254405943, 4.303044141408003, 4.667019788262234, 4.977619071441651, 4.632159374730652, 4.622868528069527, 5.038236231883183},
    {4.361938506104533, 4.970723801364099, 0.17623769542272014, 4.895686543157414, 4.9914565920839795, 4.921292903373547, 4.637427930513597, 4.744755326840444, 4.369435757729638, 4.422819949510613, 4.733735847579421, 4.813847624652581, 4.736736502906894, 4.542283129044015, 4.618068567455826, 4.563986276437363}
};

static const float b2[16] = {4.763276499054479, 4.668054018707529, -0.03983830124454685, 4.888624893150341, 4.4892064005998185, 4.725248088624305, 4.751654065824932, 4.519326461002013, 4.766652680491647, 4.752488395637218, 4.7240763251323825, 4.874424059905469, 4.696145218891407, 4.744888970541494, 4.872127636926282, 4.759262379151796};

static const float w3[16][12] = {
    {-2.8895058087126264, -3.2627648659469886, -3.1340929981498657, -3.2886681491328202, -3.40054796276358, -2.989154725443437, -3.141847888300726, -3.2474681134040075, -3.570898471723887, -3.0683800405591786, -3.747942204824386, -3.0297237217434354},
    {-3.45680302104082, -3.327936054105313, -3.601982314409441, -3.762317322647324, -3.4228195874496405, -3.4038410731773774, -3.5324296341985533, -3.7880472421318507, -2.999043558020811, -3.053277715075709, -3.421557404148246, -3.6564941471940666},
    {-0.3775028944488379, 0.40274710806647124, 0.3962918506658056, -0.03771326783247145, 0.2887196967466841, 0.375539955357692, 0.25630503262285914, -0.47001022038872525, -0.29800146589573623, 0.1673262136526127, -0.04667660904469128, 0.08795661197300553},
    {-3.596413833990806, -3.2664725376344013, -3.144201628553194, -3.652385455976099, -3.6079331439563935, -3.511673890465519, -3.787649143675279, -3.0893872002017657, -3.016054400718878, -3.783537532633954, -3.5308800009453867, -3.259565306019014},
    {-2.9769084044049166, -3.6939450045844135, -3.193675316223692, -3.6591148212894127, -3.8713703882160746, -3.247454606472113, -3.336836306729389, -3.7645607062903186, -3.2831512604701114, -3.2832013243023366, -3.6887669137935815, -3.1407017380376177},
    {-3.511280218783484, -3.1616045786476294, -3.167253511026841, -3.549841423749351, -3.8211107329796685, -3.388621022500823, -3.336545744434892, -3.08370552736592, -3.63130875330068, -3.3753599766855333, -3.4378652278046564, -3.6532494113449254},
    {-3.487923461881523, -3.1210916557133457, -3.2566770381156522, -3.456775974588406, -2.9769693464245144, -3.4634562730469707, -2.750853800885248, -3.200613131821898, -3.578606810665151, -3.014724588810758, -2.9178426802842985, -3.6326193179368587},
    {-3.2011566617142204, -3.734528434444903, -3.5912437134494315, -3.0544868099146463, -3.7069251837753496, -3.129094641085986, -3.806569162368384, -3.659658737391521, -3.4530337105162068, -3.7177505823563086, -2.950510863294344, -3.929421006048237},
    {-3.4536105725324835, -3.330883063142686, -3.036376629004185, -3.20324348570549, -3.036283922083145, -3.4683656098295432, -3.6703218429271067, -3.4311864801199308, -3.640731395747137, -3.605115876944657, -3.7480264714933247, -3.0958576766786647},
    {-3.1187760096830432, -3.136547575315889, -3.4072735052342282, -3.1766375694448183, -3.0889103474934942, -3.608021438925637, -3.638345445928221, -3.8962694224392513, -3.5157147369746755, -3.8703812598557863, -3.1039063372674636, -3.9113692241512004},
    {-3.2769310220716767, -3.1763713417047157, -3.4949718046489853, -2.90273976820438, -2.990575137345996, -3.353598158916573, -3.294737138475735, -3.2497822296549086, -3.8912574180761634, -3.0641063646951956, -3.4702523213825085, -2.9338951955761883},
    {-3.72482964330518, -3.3594534143874992, -3.3970833853815514, -3.2075867000059777, -3.9683821447259464, -3.620110317001884, -3.3867991806365128, -3.503770372150804, -2.9567916645627332, -3.3101340976468907, -3.43194904654701, -3.3392980750644274},
    {-3.7156092541881263, -3.671607525407724, -3.6097734580839664, -3.7407138297943843, -3.2185963693517756, -3.2211882644700114, -3.1053931909028565, -3.315130199674966, -3.2624965292832107, -3.710406644763492, -3.7067002899812533, -3.257376628870239},
    {-3.3087286389891504, -3.2939944077856946, -3.8200954354479255, -3.558869089836359, -3.3971207808464725, -3.6833135672827986, -2.9150706560867783, -3.137386776009126, -3.5191258912432626, -3.2031632547231066, -3.242650340079386, -3.5475745075803338},
    {-3.4373181451689585, -3.3696442827890367, -2.9243119674284297, -3.3091143982310784, -2.732680884030197, -3.4073625745079985, -3.3490793526161844, -2.9304826745943666, -3.1987922258810118, -2.7221339432651686, -2.968683151137817, -3.189345846759315},
    {-3.3638145184083292, -3.552238782867983, -3.7154836478427646, -2.963027144645885, -3.279424828090522, -3.075667644060395, -3.487073128814618, -3.1980066135163727, -3.1944310654206465, -3.6978768104792996, -3.1149562038803538, -3.0228873382669192}
};

static const float b3[12] = {-2.3379717108764533, -1.5678191525332459, -2.32722545031147, -2.1467341710045797, -2.1698829158691626, -1.7972439441645063, -1.8797819148655204, -1.5284329547666957, -1.1508880102131251, -1.6447795998085055, -1.257370239856414, -1.7897553961623849};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
