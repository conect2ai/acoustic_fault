#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.2220895370203397, -0.9873377043424185, 0.9330422230498893, 2.375086489902256, -2.8929481912862554, 1.8664317054695263, -1.829497086409396, 0.5381704221246164, 0.4949619277226954, -1.6213572694853224, 3.807974655510097, 0.009271905285310699, -1.706285197177264, 2.9661901469805123, 0.08046606762877635, -1.8864100718725363},
    {-2.27759013947642, -1.9571197435845347, 0.4241488981601217, 0.3951110515982548, -2.9462187622638063, 0.964363455634304, -2.6451495795028928, 0.9951096590139842, 0.9080919086712308, -3.4462596595230366, 1.0928338791975412, 0.29951433112358533, -1.7584439963334406, 2.9285195428062902, -2.8324288332651335, -4.031576858241907},
    {-5.27128149766884, -3.69865144440596, -1.2090701807472413, 0.035888983910761826, -4.9980050446956, -0.45462296499172944, -4.126633225902092, -1.784142643677749, -3.8478443092919563, -5.0241592099061, -0.23636442341750627, -3.1217231130760434, -4.626127910046592, 0.9189719747437358, -3.853524012654237, -5.511026277802178},
    {-5.38087753518952, -4.018942309925606, -0.8697110096362062, 0.5776337255880728, -5.347928393254354, -0.5212963407642528, -4.649889143923036, -3.4326049334140065, -2.28885582394399, -5.09188523592172, 1.004378989510959, -3.1147456229837034, -4.227196041546785, 1.486936337566989, -3.0743390803879174, -5.135871788999322},
    {-5.532508973314242, -5.26457443206299, -1.5449773979190582, -0.20763171522256524, -5.234963142396765, -0.3974892187026998, -4.697068376518271, -4.503958757190518, -2.136877944249868, -5.121956368039597, 0.6465701232432992, -3.0841124560775817, -4.912634133938385, 1.9425027484475026, -3.752947711376191, -5.769539969224358},
    {-4.491446829523379, -5.245782001968435, -0.5243445460425521, -0.36511595113998796, -4.2325349499597795, 0.6300756084021181, -3.405368585995821, -3.6102213218930412, -2.3268811484021548, -4.497445247852281, 0.5559627627464071, -3.0416875441906317, -3.971651871190661, 2.266580685232163, -3.691928007976857, -5.008236575120292},
    {-3.2549306618003615, -4.589565131175171, 0.23328254202805737, -0.1650515041697192, -2.948403785075445, 1.2924718382925475, -2.608961840162048, -2.647618998171761, -1.4093988116679146, -3.4492267226284787, 0.5306989424267731, -1.8199439348606992, -2.2458714606396026, 3.0941942398072175, -3.3931506707928323, -4.536783181545076},
    {-4.072496171191841, -4.514474918477343, 0.2578661662040411, 0.2598145934942947, -3.6001675355571083, -0.1116858746666675, -3.634030957981092, -2.9213790879390436, -1.8751068487431266, -3.3726790846143726, 0.9746027147793921, -2.317186276025342, -2.9465599908093107, 2.6255735804993687, -3.5704576435223716, -4.197939583764138},
    {-4.300843866658962, -3.495841573893315, 0.09720542315080152, 0.36171275407906284, -3.872581047237026, -0.590841845484132, -3.815732768054902, -2.687673444161534, -1.6133142694177687, -3.907804679422488, 1.163884651122117, -2.5178993067336775, -3.7745785241271905, 1.900923128064501, -2.796380090005869, -3.868883357909556},
    {-3.851993963366985, -3.382290802678296, 0.7175952943929402, 0.680018072705926, -3.971249755152558, 0.19662209949161527, -3.585371129790007, -1.5641858048226134, -0.3716795056486544, -3.5883006827942285, 1.2624562989484085, -1.612438956388862, -3.293447797994806, 2.268005946793799, -4.110119623164712, -4.387091457072361},
    {-3.677770308009887, -2.83579178094881, -0.3431208792727129, 0.05613449573741453, -3.8238822679545836, 0.6898886888670419, -3.390513896409375, -2.251891952887362, 0.19117466655245852, -3.582325918964644, 1.2886393730313255, -1.0059818954307234, -3.4095721899552465, 2.289122506020348, -4.406497337054471, -3.9815379126176955},
    {-4.630072952669464, -2.8787128233249897, -0.10965634873701244, 0.09941109561469312, -4.406384513146826, -0.6874148933242702, -4.570148157695679, -2.9448278697591967, -1.25402863152138, -3.7706831242299845, -0.08686937651408734, -2.984118300913045, -3.3346564898334203, 0.7880298035731909, -4.794388093587916, -3.400418812126654},
    {-4.347804253754785, -3.207488753840118, -0.17737729147697354, -0.02746087913043743, -4.69469699172288, -0.8284712408907534, -4.799169065639792, -2.546056763847048, -2.5712455558273724, -4.204397169816117, -0.4542289872923818, -3.1363472514035267, -3.7285926485706327, 0.6133429440924542, -4.823733967938733, -3.898014733944304},
    {-4.626317660551981, -3.949979990227222, -0.3276979043304384, -0.5230854174635019, -4.507139900919276, -1.6687625276772815, -5.198803794575111, -2.4174466050498187, -2.681827445812865, -4.171541935454305, -0.46810322816865213, -3.059593669822095, -3.8545477795390064, 0.733418563373683, -5.124804175545085, -4.214655130964037},
    {-4.8019756710300285, -4.364914286628693, -0.3090227791939754, -1.0227670289898796, -3.697324464326835, -1.2827194366579042, -4.566080861814752, -2.16087553416115, -2.9436643323382077, -3.7045238757935084, 0.10053633904329938, -2.9523806315570154, -3.424774824793253, 1.4384021777444842, -5.322348958826735, -4.1542396523933},
    {-4.746025700795816, -4.581927982175008, -0.16809430676021758, -0.09021094089138405, -4.448161770565612, -0.7849356745602243, -4.716443826569254, -1.7060883461069278, -3.14583859144425, -4.474717282161038, -0.439219719477967, -3.2298382722600314, -3.983167118869345, 2.0299179019646685, -5.009264429961335, -5.031427937152232},
    {-4.865694195613911, -4.127835412666458, -0.10789311483402231, -0.09378906557465268, -4.610367763642574, -1.2557316900978797, -4.69877223504233, -1.8918870032317023, -3.0287246483147547, -4.7081937107966105, -0.19559471861366784, -2.9823289270366775, -4.230187711133595, 1.8542842603205159, -4.552866676202004, -4.916318644497857},
    {-5.241649568395283, -3.8862688025919025, -0.5334059222926023, -0.11379402315385823, -4.152246878746499, -0.9936924307397538, -4.275519782218975, -2.0112137523425857, -3.733681528883393, -4.020347111429651, 0.41618344883041297, -3.2515819902688774, -4.2233173443310825, 1.1464881142438972, -4.8748777933226854, -4.104574442352087},
    {-5.286490006166113, -4.1323095922719935, -0.7133287933241163, -0.33191391139001725, -4.4280166758720885, -0.9011744836217656, -4.487301066465758, -2.7174628024770513, -3.717013514056875, -3.832270600140682, 0.6084677710847868, -3.5086981795627765, -4.225567400342082, 0.6203179086927967, -4.933732891887977, -4.570042987821317},
    {-5.310742426221841, -4.525114266812544, -0.1636736165516197, 0.12680717989326673, -4.902168620568085, -0.3403736651927832, -5.108058878716278, -2.6406648118922464, -2.7538093450039427, -4.200395334806846, 0.5940680775713282, -3.75898381661317, -4.121104620571085, 0.687955113909892, -5.243041702489942, -5.108702068135789},
    {-4.789290528247977, -4.021940572943522, -0.3234210943704259, 0.11362756887721916, -4.90316427585041, -0.6800974640055082, -4.71326128174958, -2.0105610141937915, -1.7531942985903695, -4.3094566280891256, 0.5051039994883839, -2.976386994517826, -3.933932688135889, 1.4393553306174893, -4.932775753226009, -4.474336413271371},
    {-4.57641887920444, -3.5179664982568593, -0.2408083248240914, 0.3172808760224503, -4.026925591150197, -0.5395694221585873, -4.235190220034811, -2.119484733049991, -1.8103904400843103, -4.051794502755704, 1.0353008825054644, -2.9834139613279853, -3.74290246743912, 1.7991838560327023, -4.14758559102712, -4.108056871183165},
    {-4.604233615985524, -2.951206235458937, -0.18519915510588633, 0.6382313070732142, -3.4718438912123055, -0.49942006752873325, -3.6838597697574382, -1.3016150271493023, -1.5723686593639583, -3.383009489803668, 1.7742759105563057, -1.8636317265152567, -3.45192333200249, 2.1958063615942174, -3.659411861900073, -3.212059492585233},
    {-4.474417494185935, -3.480582488166776, -0.40910737624657756, 0.2646599657075384, -3.876347313505432, -0.7955963393987611, -3.8376083785049873, -1.4176979457088812, -1.6125270265848484, -3.844181130641264, 1.2861314176925591, -2.4438635558770976, -3.712972291087448, 1.9876496110592667, -4.207521194704843, -3.8679197515217223},
    {-4.75992170212626, -3.511400449447869, -0.7352813335601869, 0.11904204051861099, -4.822386172111783, -1.1018120730006709, -3.713111404847918, -2.203122068160561, -1.7465953799590428, -4.42943789735907, 0.12262661724973942, -2.3373787822905214, -4.152179260607007, 1.2416045240950104, -4.525155769782824, -4.439799708617139},
    {-4.511360279870332, -3.171316354879199, -0.7106265562048856, 0.4315476427747447, -3.924877232569613, -0.9179159666290435, -3.7447973635642935, -1.8977690961529334, -1.6850225904109186, -3.876317360293655, 0.022760022722949094, -2.6169147682712897, -3.749891519796862, 0.9145216662218345, -4.255266265718059, -3.644586593521091},
    {-4.730767847638188, -3.0241870578619734, 0.146966962476858, 0.39844864050471407, -4.423371011971802, -0.5829495958703865, -4.180552584026856, -1.4410879366226956, -2.34485250197286, -4.310543013096289, 0.1472697154972912, -2.1664137779125707, -4.1053239777736446, 1.2665178459273885, -4.303951337378477, -4.2472053159822725},
    {-5.055896087111754, -3.829276356888021, -0.8035632114274573, -0.006863213681741671, -4.728016003329841, -0.8299123023276619, -4.584562435418552, -1.7579954100418336, -2.268756579295657, -4.4311048918420015, 0.25644125455571554, -2.5195823410745453, -4.343538385623767, 1.3625742206334195, -4.783894766997133, -4.733741758670535},
    {-4.797987050433277, -3.97518697696606, -0.8239741930395131, -0.144959738234743, -4.614145281095538, -0.9184402318474822, -4.390105807782923, -1.0838765512502404, -1.6617496277537738, -4.639139924015269, -0.016178367640838916, -2.2438044919966047, -4.0598852890859725, 1.2739800980888505, -5.230231562267368, -4.824462004926272},
    {-4.756221136770508, -3.7402175646457443, -0.8368626717372664, 0.0952598736478177, -5.238606198845, -1.7090085573444063, -4.264554854819351, -0.9870979956657939, -1.7397756282230508, -4.914167432688639, -0.4530603184207206, -2.2286074787435597, -4.3464693850371585, 0.7247078841955094, -5.106331668528111, -5.064231618836666},
    {-0.834433117452492, 0.19094333404045558, -1.0408554834630475, 0.4391066419937893, -1.8563051052466557, -0.421341665698518, -0.49121908165680045, -1.2684810553646397, -1.6623307191682628, -2.2382558898259988, -1.3498603761603272, -0.9160487886288594, -0.8216857383687589, -1.963262460029534, -2.5602001031933406, -2.426013031792782},
    {-2.6879541974689856, -1.8464701824407674, -0.29117970863758813, 0.3708667644703681, -3.300716230717342, 1.062643390138963, -1.7621215839788038, -0.6277862318828903, -0.5204133436121684, -2.550696562772406, 2.131542806430585, 0.16537212903910523, -2.7647906686327377, 1.6428391906095001, -2.775726762246039, -3.348035999846294},
    {-1.7239119084569496, -2.154784702799302, -1.0395099112273785, 0.5820272209493583, -1.435390013209417, -0.901940777591165, -1.141550032302491, -1.4593480122291012, -1.9884372641852879, -1.014539035514237, -0.525828703366031, -2.160949500961402, -1.5983016567237134, -1.6993255696880372, -1.7606175131783057, -1.4402698291538114},
    {-0.07167871338645586, -0.9403903369539713, -1.2375868554680791, -0.011955047835411403, -0.8064524012315045, -1.1761453425089443, -0.9878758505247051, -0.5945306651546249, 0.5962794074494373, 0.03554266087561004, 0.29958334349989807, -0.12233441238830724, -1.5597737092026025, -0.13579647475849396, -1.7379793693472987, 0.001112012956319524},
    {-1.7700881037678973, -1.87832706330425, -1.7513295019702684, -0.24136242090746046, -1.8892817628248704, -0.5733992900373631, -1.7792965529269074, -1.590792463092732, -1.1332479880774724, -2.014748967739863, -0.2215735832290521, -0.9587469559584758, -2.965826259281889, 0.04161494198683383, -2.0271614641162614, -2.0946244318769525},
    {-0.8641294312405562, -1.2552681448668355, -0.256068242469176, 0.5458205218000343, -1.1239488108641849, 0.009951142575417241, -1.3015091561896235, -0.3785494584665958, -0.828012541506395, -0.971598872375667, 0.25647698766247207, -0.798577466938322, -0.96854799333726, -0.1106020794316066, -0.6273562876930858, -0.535293308619552},
    {-1.2371798901966395, -1.3944187798332837, -0.7347103120741044, 0.3396771068331171, -1.6680037807349923, -0.01863971304839338, -1.7253301545975757, -1.0776880564935647, -1.0253991048035365, -1.7089595219771254, -0.47400902163135716, -0.9920013766526498, -1.2498019167167336, -0.12847381182410694, -1.590601101134222, -1.4471868126154612},
    {-1.5622283699171673, -1.813156615530727, -1.0715541356384837, 0.1757801848676633, -1.5627495927156572, -0.6809762820852467, -2.674290218242274, -1.3294435363902688, -2.667329087988165, -1.9489007134543692, -0.6737989902742091, -1.8993730313747885, -2.223850229290684, -0.37211496525876114, -1.8551665597085267, -1.1993805184428536},
    {-2.1983110754850266, -2.4133303381946445, -1.7369412864832108, -0.0880667110389784, -2.7806032113131445, -0.9515740959497189, -2.9327802563526104, -2.310203830184058, -2.366324026729268, -2.539932030759172, -0.3916667034014191, -1.900319256779074, -2.1844417908770564, -0.1876310727295919, -2.2676525541605965, -1.7529078901397097},
    {-2.5112917091808518, -2.397596701358709, -0.5109048092135392, 0.8304534589236784, -2.81338502772958, -0.1109825051107355, -1.893305509071448, -2.083174085208564, -1.7686678126847986, -2.4312201190393417, -0.29953075345983254, -1.6413453000542761, -1.895346519926465, -0.5136783526007528, -2.43625799584259, -3.1113593639390476},
    {-2.851417641937612, -2.8646972564209054, -2.1246352076003423, -0.13991592964689467, -3.4586837863152358, -1.0924722540738654, -2.8985801536805926, -2.823487002637241, -2.202987838835563, -3.2009264302820015, -1.5016910122944136, -1.836114197003838, -2.788911519140988, -1.5908594888298782, -3.079232875007694, -3.0420296924505448},
    {-2.3091594607289982, -2.7613905628940256, -1.1886155249311428, 0.35099179118636936, -2.4718382385093753, -1.0695048750668608, -2.356388735980046, -1.6628562682114096, -1.6673645557563797, -1.9640467120743295, -0.8099263489382422, -1.6015823798603641, -1.965621054484694, -0.8700832664253154, -2.1810933629536002, -2.1426819953644842},
    {-2.7449975981548134, -2.6057663651166405, -2.218835195113499, 0.1217147407048998, -2.790462893716839, -1.4574782567572575, -2.599799263722897, -2.958176185974832, -2.1392111914483087, -2.5419281124846425, -0.8248050541708907, -1.563982487534532, -2.5182428788543794, -1.393195709669201, -1.991252108166609, -2.2718346908698197},
    {-2.2630747434597502, -3.271755877722714, -0.9850775244648001, 0.5775028232647672, -2.593150315882868, -0.5541342887037439, -2.0254947896480293, -2.5091016810308524, -1.686155946282824, -2.40103609133581, -0.6955410212427631, -1.4999312347108318, -1.9526356478585047, -1.6518796413865626, -2.0823036216513984, -2.7575790409080017},
    {-2.872022911285288, -3.6302635576327256, -1.956547511097219, -0.003333850115880005, -3.3378817909577387, -1.3736419529499675, -2.2278295357517823, -2.903026110773863, -2.449330393347725, -3.0476888774575834, -0.7906594125305413, -2.22493906233609, -2.4357197086153812, -1.2978489244245126, -1.8973443002786026, -2.9462051375074467},
    {-3.166707559721962, -4.107376870735654, -2.447714698025047, -0.7070652912871539, -3.3192404409215324, -2.10711343340379, -2.795762733996872, -3.011040290763872, -2.993592525934548, -3.158894818441282, -1.3160736416104795, -2.2054037656115084, -2.7148087695596432, -1.9986623717526064, -2.9617441873284283, -3.3759838713237067},
    {-2.4753059664616903, -2.920876996480849, -1.9889724441232048, -0.15482097113552135, -2.086948302805335, -1.9110815333631619, -2.991041527099285, -1.7918808783781952, -2.6039814311028198, -2.549513196235084, -1.432944072869623, -2.380124635733773, -1.4428004863179502, -2.215362441808108, -0.9653708246108079, -1.5363439119702254},
    {-3.0934775647044677, -3.425752694561118, -2.6484210996122624, -0.6035843275260686, -2.5438647209403045, -2.669217001679966, -2.659362458553089, -1.8757913027059545, -3.53504661992682, -2.6759359594020826, -1.3971437896455592, -2.56463656101197, -2.710395758100713, -1.7759489865140987, -2.5420156826156917, -2.861888991621817},
    {-2.408481017488679, -2.9404418757380495, -3.264118657679707, -0.5365496539132321, -2.2826448868806035, -2.410396865837693, -1.8351274360176846, -2.9584746936260626, -3.6152345442496086, -2.4872990429799087, -1.941479184031762, -2.5750094698995785, -1.9788446526878254, -2.5582004658494135, -1.7599203797221818, -1.8694127636150377},
    {-1.7781410468563128, -3.3600734899583036, -2.605648899949808, 0.0485911342546384, -2.1063359068403797, -2.019317952750701, -1.8377744931496116, -2.6374444476820487, -2.692152015581086, -2.186729795808216, -0.7064891774232569, -1.9091137337334896, -0.9839958301174359, -1.889733509064086, -1.4628197990332128, -2.297244643089266},
    {-2.701442896576334, -3.619619582054717, -3.4875078546030287, -0.8597236166746407, -3.305213684837762, -2.789797042661348, -3.088903010155014, -3.37050698811919, -1.8821339078557433, -3.0917992837153228, -1.8260833851511575, -2.3288091027698914, -2.2277044639913752, -2.1721800140313103, -2.134099475206367, -2.8365417304961045},
    {-4.327977472166818, -4.625141195613304, -3.2016909212499676, -0.5945105810682147, -4.139328457240721, -1.6053768503049433, -3.0113963728237994, -3.6861799533045705, -2.694588695693394, -4.009875710308705, -0.9000312069044762, -2.457516547508198, -3.6483281704615393, -1.6592916147271544, -2.9142506434341473, -4.151491749578111},
    {-3.197796523563209, -3.928510799120901, -3.274731158346245, -0.1779330241977797, -3.539950423488663, -1.6324878610514244, -1.4951360675075036, -3.994282168897597, -3.340461924534585, -3.214846167546015, -1.288263412120156, -2.5031999439064516, -2.418375441715517, -1.9034466858433725, -0.8748114667541005, -3.0036504259694485},
    {-2.4500632769087094, -3.8435917078108, -2.724001737821594, -0.4106646319749152, -2.750785903817815, -2.0922607330757357, -1.6472258023022288, -3.7491420195772913, -3.959407799588884, -2.670192676615338, -1.9525164561343682, -3.4168145040756794, -1.6325188713048893, -2.54118654061846, -1.2234211154901562, -2.315093098604004},
    {-2.7688580091583503, -4.0635297011513085, -2.74134568456041, -0.4045310168468518, -3.2453112600053626, -2.0063820994672192, -2.06694025698241, -3.2969900363389613, -3.934024659657464, -3.244100222532274, -1.823725927028633, -3.107876064735405, -2.5959091132864596, -2.3006026033302995, -2.2620245573329387, -3.237460888528033},
    {-1.93892500118134, -3.2388270670436183, -3.0532669907432495, 0.02592736229119162, -3.018848450577101, -2.227132133088046, -1.748240590140067, -3.1885128177963864, -3.1354365943033025, -2.2184835131625307, -1.9284711174355198, -2.671734351220675, -2.8644866819517882, -3.0393475058954387, -1.3379225522183702, -1.3442170122047288},
    {-2.349759729696576, -4.1292035659522055, -2.5884141137708454, -0.3643002373528522, -3.3180920855317493, -1.337934647000156, -1.5061777366452043, -3.2261084159867557, -2.752313744020933, -3.0075148895114654, -1.2609692607414498, -1.690594881117777, -2.284390271959079, -1.9607606430235134, -2.2461271124664672, -3.2375899657221994},
    {-2.5421124315532766, -3.6847096979173726, -2.9085133868314563, -0.32444062202363, -3.3396830276127356, -2.336689381721938, -1.640001557571043, -2.836054796200252, -3.26595066396376, -2.6045927709370553, -1.5011688473738218, -1.824682403859422, -2.7275217818291995, -2.579247876891983, -2.6101841491375435, -2.890046527172504},
    {-2.7829490329404947, -4.4449788733574085, -3.103663930409535, -0.44136208302519425, -3.1206587441643094, -2.4583207440832155, -0.9567985152863895, -2.838830621732596, -3.3828648232304634, -2.639904253345927, -1.40057870383278, -1.9742553121768667, -2.7176870435306486, -2.1991721060146707, -2.052755001106141, -3.0828801659759355},
    {-2.30909311083193, -4.10275791719, -2.719668041497081, -0.16276281060921824, -2.9735403664557647, -2.5184871083704268, -1.3811112090705797, -2.549614532845458, -2.57286164731399, -2.7120520490389803, -1.3358308984631884, -1.6026752114524139, -1.4744627432666455, -1.6094043104317486, -1.07245655376829, -3.169078892023607},
    {1.311930693004478, 0.44597949076408494, -3.0832799509671567, -3.666942621816765, 1.1874090072427754, -3.10991611408896, 2.066532943652619, 1.0875804117630172, 2.4196563852466504, 1.6335060873334768, 2.9930961221629953, 2.371626959703592, -1.123753236884075, 2.9904185512593524, -0.3968962436221176, 0.6822530339098574},
    {0.09449197535640844, -0.47711996506415727, -3.4223514659243808, -3.4417615601019196, -0.014527627744825354, -3.0151437463397426, 1.3262384534917961, 0.36313752511630615, 1.9276475512460987, 0.4240323721416854, 3.2488994447897253, 2.359049475602213, -2.0258602849421794, 3.5801767298446814, -1.052048178375391, -0.3667233622868929},
    {0.6070265893562695, -0.3770021186294615, -3.7662686963996754, -4.206860645645688, 0.8049276809075322, -3.3227770411643105, 2.5149147032254207, 0.17540588518359979, 2.5136108963133066, 1.0915131307220451, 4.929443162867875, 3.8167501761152143, -1.7736625498405743, 4.818683273095629, -0.7126404494549958, 0.06296972970851611},
    {0.8004965574448627, 0.013978391361686921, -3.528081921031561, -3.7514864451923837, 0.8055003165764244, -3.4051860793660347, 2.2544258918800844, 0.7362388005774068, 2.4580159906275894, 1.1804275958159356, 4.034111973469132, 3.408535099388688, -1.3901327209693646, 4.290721033823452, -0.7710090111497273, 0.4714886050954583},
    {1.0403375858794013, 0.25240266674404704, -3.961803380060452, -3.9873429317002618, 1.0015283877314867, -3.26687287954415, 1.8370779992395811, 0.9919456509539631, 2.705072499359857, 1.48566870530773, 4.004579885107073, 3.1054818580619004, -1.9370121578288386, 4.318562361957946, -0.7897061304228293, 0.457028115704806},
    {0.9889223045512794, -0.31184668395578663, -4.230611347692526, -4.497723035977469, 1.0719237098080319, -3.8626731951404873, 1.8931375703912876, 0.24311956653182, 2.712062836147924, 1.0118294167592659, 4.418048848037542, 3.274530388264748, -2.206056709069933, 4.655582979340725, -1.5071618425008284, 0.37501766317719243},
    {1.4503843007622883, -0.5090262053194798, -4.119933200003366, -4.578222322798777, 1.0855065256177094, -4.005938741767053, 2.3747500919402826, 0.19060177811386977, 2.7024343039105805, 1.403496973329226, 4.322624672043168, 3.6171517295274294, -1.9587928382397224, 4.187804256563587, -1.1196592654433803, -0.03142411259794713},
    {1.9939970013823924, -0.048383325723969264, -3.957195830268023, -4.547617514090311, 1.4003787987462768, -3.564414211852536, 2.861457675432098, 0.7486028485269498, 3.497367017777153, 2.090107413232579, 4.725177673296417, 4.124500142619591, -1.6686481413463154, 4.580702230770754, -0.6419331205521382, 0.8830695371222258},
    {1.7140886531211517, -0.6326308314250257, -4.402334645812123, -4.88440570335995, 1.4904309955026545, -4.296483094523726, 3.2455415358492865, 0.46907736934226857, 3.4360479528853656, 1.818899613844323, 5.478754417087635, 4.376864593254294, -2.1602992724368835, 5.192920134537342, -0.6679070918194558, 0.48062622558314244},
    {0.3556437645133114, -1.320798832385893, -4.519700505312588, -4.647764285562682, 0.3441910786998807, -4.156542403250937, 1.989473585520612, -0.6473314765871958, 2.6151372364309915, 0.440543032773383, 4.5730707282415874, 3.4488627908964817, -2.508747776935083, 4.425326752429458, -1.6008664360308427, -0.41745741612388104},
    {0.5870376353754715, -0.6031552698981666, -3.8308031097005073, -4.216771137001942, 0.8871054094146616, -3.468691421062807, 2.041972743624379, -0.4005688153386124, 2.431380596756514, 0.9264622766318201, 4.865970321303019, 3.6149431509402934, -2.1972893977619914, 4.54654090132582, -1.4437139508459738, -0.04561665704086822},
    {0.9250743307607212, -0.34873788384682186, -4.23244484250385, -4.455943078672988, 1.2359169431476746, -3.7051923499502175, 2.5770930949678963, 0.24636449058230908, 2.840724088102997, 0.8208433530353219, 5.325053260851692, 3.835457150472234, -2.381388346636468, 5.10541206868563, -1.427830186769589, 0.29651554962078014},
    {0.8152243365734976, -0.7147788086342673, -4.233543318241691, -4.8087195525146, 0.7887358203227679, -4.424860415218077, 2.6369835946361904, -0.03330570971471041, 2.901384729664189, 1.0623646054500693, 4.714042104007759, 3.572986682825968, -2.8604683296581537, 4.88764788399127, -1.8120441114248904, -0.061247028296822166},
    {1.330125046476459, -0.7741430076403583, -4.4232127695283205, -4.347191721125353, 0.7802349244675116, -4.065397493464854, 2.0567255987453827, -0.020433520164840013, 2.6904941041595976, 0.9471353470070569, 4.607120123250316, 3.1190276016352105, -2.069622947461782, 4.273798358337198, -1.2557551927577735, -0.014517274137838425},
    {1.4825980303620263, -0.7593711161088152, -4.298626997198249, -4.618339701571662, 0.9985400775855098, -4.348169544692477, 2.446370352179796, 0.2572288197264717, 2.867168793483533, 1.0810274803733535, 4.388436606439446, 3.558082831160238, -2.2479032852079053, 3.834813895598594, -0.99554997219177, 0.2753181443137487},
    {1.222913921231466, -0.7973423624594755, -4.142524169143599, -4.8354010100812825, 0.6650512538542521, -4.3084975797917355, 2.4913425611313085, 0.30584046229509343, 2.963293365014736, 1.3426962558589066, 4.537105700267464, 3.2126926127021553, -2.668484656957637, 4.603498891875818, -1.1615484159782197, 0.027918650817343422},
    {1.579124002059789, -0.31984384199862764, -4.444385199413552, -4.891633700285551, 1.636955385943733, -4.03716345219252, 3.389138833785842, 0.5862169552233043, 3.2677733024574986, 1.850161054185078, 5.108638229605425, 4.076321659392789, -2.4635113482890536, 5.156077860259673, -1.2580741490486809, 1.0526389420906408},
    {1.4524047603348353, -1.0089394683151254, -4.612436353969013, -5.315840805267773, 1.3022227979905947, -4.55990207639754, 3.0478323590954055, 0.1350550968989661, 3.1010704581741497, 1.0237537600302111, 5.227391279459047, 3.821644458319432, -2.4609693690653143, 4.782282686251896, -1.155650175944813, 0.33481186253796025},
    {1.0485535444064307, -1.158124518717864, -4.607937732613769, -5.194026459636249, 0.8839657347111373, -4.746485925972864, 2.647249032233335, -0.6730736827938117, 2.58982755955283, 0.6099336977432157, 4.9964037411192885, 3.4275761933621682, -2.9775027175702444, 4.5491669791661105, -1.8481671231155559, -0.032015777175413186},
    {1.8256130575394764, -0.5829496221826452, -4.316339701036294, -4.493737842005239, 1.4359951400487967, -4.044450414430857, 3.023286748724605, 0.1863529467976759, 3.3892715714932966, 1.632301421841578, 5.365009605538663, 4.0496038060424455, -2.51882819813448, 4.782387323752377, -1.265799267819765, 0.6229920932936089},
    {1.669988018513394, 0.08428015858622753, -4.301162619900412, -4.724237265050737, 1.2899260697744641, -3.9201727996219597, 3.0142824037137648, 0.4218094774055596, 2.7276715040786397, 1.7816351625395401, 4.5343201990793816, 3.3690987770951777, -2.181821295277776, 4.865102704920167, -0.7828803871606188, 0.8212009624700832},
    {0.9375403840516028, -0.862531213456095, -4.357432378649322, -4.647938488262381, 0.9176875098048258, -3.880106590223897, 2.7215590346880583, -0.2521373998951741, 3.046787697295348, 0.9278060648352312, 5.4083896361557215, 3.570039460548075, -2.654368329669371, 5.216339069421029, -1.5151796523662635, -0.027965178209988832},
    {1.3541135725167632, -0.8351215831066716, -4.624840140309985, -4.970994189368874, 1.1381713957916642, -4.631996114017014, 2.6190564717905795, 0.04600094218537726, 2.7855371423849027, 1.0104625218955916, 5.4687077104066475, 3.3997159913661354, -2.924591376429602, 5.199852024718497, -1.3611493924196765, 0.43308553978319125},
    {1.3827380908357756, -1.0119187225589819, -4.792729054830865, -5.253681133541973, 0.8493571751889013, -4.641074535632863, 3.0624748616307373, -0.044166859948897096, 3.364572123655887, 1.272110844956481, 5.263482692539339, 3.9058648836560224, -2.7613066565355404, 5.472821941935192, -1.7429733025675311, 0.12459742367598868},
    {1.131489447744992, -0.25291566460737097, -4.6768265162913405, -4.947522249816656, 1.4613474584376311, -4.152907236740055, 3.2616948943079245, 0.3260148774119895, 3.433764605291177, 1.3411727355150826, 5.616526483704787, 4.005193669873338, -3.0529643515079976, 5.427111092509256, -1.7834449228984783, 0.5699073141180383},
    {0.7840109845412607, -0.9215256544176894, -5.01988903511916, -5.289848619278836, 0.6399480253651982, -4.541027043539035, 3.184015690566038, 0.003986770332446215, 3.0596175370429046, 0.7938599717321134, 5.181997524777442, 3.5221991626375244, -2.974812889724545, 5.157315407088642, -1.6974221767686863, -0.32024255607816954},
    {1.4454204162443196, -0.3968726232709431, -4.622031604522789, -5.335097796304139, 1.1546835836544063, -4.5738821206441225, 3.23743062126691, 0.47360470847738034, 3.553200543053275, 1.80429621654057, 5.47796670809501, 3.9986790738751483, -2.9341687599044355, 5.23265581123109, -1.6803158078067566, 0.2645887360748275},
    {1.9545700050471724, -0.42269571181712334, -4.247386826760344, -5.3131833735809, 1.1698914799442248, -3.9250716296375145, 4.136909065979624, -0.05599737980033891, 3.938326174199174, 1.5702068570028958, 5.751973018435549, 4.171358101657888, -2.6403183737670917, 5.2520794504029595, -1.57268679748155, 0.7281076364396406},
    {1.2142311206693337, -1.076730488506912, -4.6393002625606865, -5.323869766005178, 0.326183278471359, -4.507881112110883, 2.976698907020428, -0.9034481780529063, 3.066527630179324, 1.0710854880040794, 5.3163221513111845, 3.7902794158787247, -2.8204743129064216, 5.063737305194117, -1.6104842637649943, -0.023258723064820994},
    {2.102371185991757, -0.29437630824643324, -4.631950860703009, -5.136998366559674, 1.5413341605165742, -4.340639504862114, 3.47502509000956, 0.21880907313309708, 3.7969339508266806, 1.844215630026637, 5.7861570409002985, 4.252528195474647, -2.490337724470803, 5.465043910069995, -1.1064015351369065, 0.7928196738680987},
    {1.2562449149402815, 0.9785430024546862, -0.23720196300016097, 0.8739086837778991, 0.5949014529890637, -0.5903732028756243, 0.8202568143936938, -2.0479123449428185, 0.01229381398387725, 0.4202246836438674, -0.9681016264412956, -0.09988685771790429, 1.1538556411841623, -1.045827883213622, 0.9421666937316023, 0.6398840131824435},
    {0.6989093141421748, -0.33170267806022863, 0.0005724702210885018, 0.6204134826270388, 0.8759726992038689, 1.3665018994614868, 1.3441230545222866, 0.29019255699927676, -0.21374306099021737, 1.1528817852062203, 1.2791236923159408, 0.33916753160382335, -0.8036597206757339, 1.1519922383974575, -0.5970969393317241, 1.7030985824359306},
    {-0.8423134649403115, -0.7480090187186195, 1.0960004941329224, 2.02321348549197, -1.9319585640964476, 0.32353045621725846, -0.8577192757474159, -0.11451061464028134, -1.1160797115921097, -1.1014819372686224, -0.9763022533565049, -1.3330277258830607, -0.10613766904647941, -1.8017373169175983, -0.3564270704819499, -0.9557705432804857},
    {-0.09819987105788731, -1.0605679655252405, -0.9792157500834037, 0.32751229326304787, -1.0698806363371778, -1.304957674783685, -0.9380683821037883, -0.7028709867963919, -0.566911506139977, 0.17228916291129734, 0.409142257133611, 0.03262222363332752, -0.9850028474119317, 0.07951888846268297, -1.1484312677625637, -0.43551653513161576},
    {-1.571833704471124, -2.235989620216598, -2.2428366322323465, -0.41087848041423813, -2.239803451191059, -1.4853739193040094, -1.4929827209135687, -1.8698023991288601, -1.2011741825677296, -2.064616676821181, -0.3662010273298979, -1.0930251222014988, -2.423752711433847, -0.07122849509282486, -1.541333016436754, -2.274499834255596},
    {-0.701121393707209, -0.933628461525284, 0.15665017917121077, 0.9397671461985877, -0.9039675697116873, 0.2288798362019894, -1.2460611580628753, -0.09322362340550838, -0.6685316250115992, -0.7570249017850188, -0.28809884563728355, -1.142868165896557, -0.44551128159758874, -0.4888542014812899, 0.13212381423926928, -0.19211057744509952},
    {-0.5742776983481549, -0.6121732892320212, -0.7717158840837705, 0.6358772089221635, -1.3673952727310914, 0.041489728892390235, -1.0263166533875983, -0.7226387800176197, -0.5576212457681508, -0.9632348599763041, -0.5042616509476735, -0.2040281845317181, -0.5999493665148157, -0.0473734949840629, -0.6689667601486592, -0.6657632437816029},
    {-1.1118541741437653, -1.4043449789365103, -1.0386909342292459, 0.591654277509896, -0.8812458457216159, -0.44555522197676245, -1.381986264604489, -0.9502134923009862, -1.2054452418807717, -1.2178387764450926, -0.18253482608427127, -0.9617917357647953, -1.5513605838854427, 0.17799006232779213, -1.2763422582713517, -0.5084156357115944},
    {-1.7361338759539575, -1.9288953831256161, -1.6729956532345285, 0.07074539987646766, -2.172519590091239, -0.6830131213872677, -2.2574479790144815, -1.7549896476316789, -1.4486946294436822, -2.1029428714733664, 0.14522520909319714, -1.0282096075560885, -1.863563450477432, -0.01912564508986135, -1.8849609329900352, -1.5511065907183959},
    {-2.3375521456585275, -2.2877509699093665, -0.9916840785099393, 0.5955758434004477, -2.5169797241660796, -0.24841820078111387, -1.1206190490684795, -1.888128092208031, -1.2213656389809784, -2.204276509326781, -0.14334002831059917, -1.193927540682423, -1.4558101121388505, -0.5708040465700484, -1.750109086808702, -2.5609132521111486},
    {-0.9333486667624006, -1.526041842657879, -1.4447954835352153, 0.3291222843188305, -2.0967462051269603, -0.4837024528031707, -0.13609535356015795, -2.1299913484822266, -1.045645373361928, -0.8763417698307148, -0.5600842504921294, -0.030289189912373043, -1.5640410113345553, -0.7016805675040739, -1.3410733291928578, -1.33306950143666},
    {-1.2245563152807075, -2.2981511146778746, -1.2715687656717711, 0.2420694253666537, -1.9769585631603095, -0.5118231939470947, -1.5374551819453326, -1.5992556970201917, -0.9754190423191789, -1.1288637996631525, -0.35513333868043256, -0.8082334067088645, -1.5565587756941164, -0.9179066567624246, -1.1803896024782916, -1.6858242622854238},
    {-0.6255314194171391, -1.7147147277549109, -0.980688008296338, 1.3055109486514775, -1.1207777761590725, -0.5356355937702882, -0.3844361453117673, -1.868014749652433, -0.9280843376138571, -1.1227876005461264, -0.6026044202381006, -0.587253071483914, -0.4387540841344486, -0.8561061863293957, -0.7479115124061902, -1.162997850626393},
    {-0.25286787638151537, -1.7550029694528362, -0.07829914118797747, 2.0366070165604713, -0.8116553885904253, 0.807207341276853, -0.7601974634756697, -1.5264113085572064, -0.7095687722848523, -0.4341433530249551, -0.1938876663120767, -0.30724409126463464, 0.466957794363899, -0.7485972196595764, 0.015338840484521684, -0.7455612649929516},
    {-1.484449920984287, -2.681198556772126, -0.8158026529836235, 1.0595604722349345, -1.9879325807954262, -0.1148927042796744, -0.9629332246000735, -2.8962848018316505, -1.8973260026273417, -1.728563651448864, -0.9447601786427566, -1.8704278592451655, -0.693829846230387, -1.3690000984388389, -0.4592601002298844, -1.6148796419564913},
    {-0.5835042374752136, -2.597709187001696, -1.2118247675380154, 0.9150290187465174, -1.1374961036725322, -0.7641733466374628, -0.5448502891339537, -1.4162044692069393, -0.8650729168077561, -1.0120642100465171, 0.2262796355408753, -0.409057657863373, -0.5098380467384109, -0.8660151081440197, -0.352802949310338, -0.910025574415946},
    {-0.8612806290011265, -2.1093056912935637, -1.782725479161283, 0.4776433934689149, -0.6889143570068089, -1.3843804494314145, -1.4199421625615891, -1.9183906432871731, -0.540710174235447, -1.6124002370572625, -0.9245932690770922, -1.0265226119257285, -0.11992271489887563, -1.73314912068181, 0.23169820313243766, -0.36075459269039345},
    {-1.6373516936102261, -3.060285862539801, -2.512835268038718, 0.11354591113553693, -1.9619209120388876, -2.179077288534054, -0.9659785704214994, -2.7599427061775827, -1.7320994425254308, -2.008708358144385, -0.7551054591888775, -1.2594502189260128, -1.8004310303106, -1.4469318267165323, -1.117192499687346, -1.9073052974679852},
    {-0.3427239545639814, -2.354883480524688, -2.5398735566774864, 0.08872282212557792, -1.5584805803298716, -2.0073521196574835, -0.02451824078471988, -2.1022222379459548, -1.5563136840885137, -1.0791130708038756, -0.6537614889897025, -0.6236789959327507, -0.8529226170852864, -1.3493402425062284, -0.41100589554832556, -0.6228484869566916},
    {-0.6528126598111501, -2.529943368113217, -2.4249575677112003, 0.2926133366901596, -1.4608526830586173, -1.2740361034741734, -0.5973564663513442, -2.18321784269352, -1.303778460578014, -1.4621708218656042, -0.29423985526192303, -0.5117984150426581, -0.3291618999666657, -1.254679187562679, 0.016170403395311162, -1.41566828533278},
    {-0.10678787629417796, -3.117557084846476, -2.5147855870161306, 0.08684997510316186, -0.881628052094115, -1.4861799101970607, -0.6835807594547396, -3.465712278192682, -0.8397309446177483, -1.3744492485611715, -0.9821736977828162, -1.2455523429360473, -0.018590596499129676, -1.273772162201456, 0.698632844826991, -1.058015259909856},
    {-1.7619759390413032, -4.064928436111398, -3.177099281927222, 0.07247181592299856, -2.6140581443265654, -2.0477904213570794, -0.3459659257807663, -4.244842768513229, -1.8290608514010072, -2.2513282581779754, -0.9848052057692473, -2.2110384178748332, -0.6108407048747121, -1.7452944360326978, 0.40835352050067514, -2.1384889343446147},
    {-0.36752812177832994, -2.717501583543663, -2.528090060399584, 0.9468034897455547, -1.9081531106920933, -1.2921481867714062, 0.8730865766039647, -3.528516091328163, -1.9961528512119406, -1.323685403472611, -1.0774018335611255, -1.9263782479246505, 0.8830259285778278, -1.7170192851415143, 1.5496001971962767, -0.3791726386880408},
    {-0.30709011948884707, -2.8860288248793684, -2.2882775091083305, 0.6218075844283234, -1.5342097342790113, -1.7746666901033203, 0.49574200451380196, -3.4826231463754422, -2.3977314903188405, -1.5532009739548707, -2.2730642394464744, -2.745698062065989, -0.08783211121736911, -3.062569402961298, 1.2860609466382389, -0.629342636279285},
    {-1.5196175887945729, -3.3405176549063222, -3.4386424420782764, -0.22062594050567702, -2.480986808497617, -2.5229694817759283, -0.24051352697667427, -3.329574075073384, -2.2779800891015705, -2.175819994364431, -1.4629188462162068, -1.9607260668606354, -1.5692963823302917, -2.016678971192001, -0.5067640833641232, -1.9005127390868233},
    {-0.37534934703131173, -2.235459726708732, -2.727241772567562, 0.429075658846502, -1.673730454895404, -1.792271655817116, 0.685352271713666, -3.1341659206196484, -1.8527885705889209, -1.0887569629268248, -1.210728196692095, -1.744549375001597, -0.6377776561161931, -2.1789788308150295, 0.22472412736055117, 0.00370321690135583},
    {-0.7005643868144624, -3.678226763470173, -2.6868038343005423, 0.5991412212965317, -2.1148402276158733, -1.728677065173656, 0.37877187857534345, -4.012947807332167, -2.7482411929931834, -2.00208020481426, -2.310479381699745, -1.693238640907735, -0.3956082694441321, -2.7905169511703893, -0.2644622024687883, -1.2585928163640716},
    {-0.917198066292137, -3.4368828962555864, -2.8925430097447187, 0.26576558879747825, -2.129820126837637, -1.9213770300910487, 0.2910110046891945, -3.6055347340773465, -2.9187601146393143, -1.801674883890036, -2.1159648148577452, -1.8917763049711587, -1.0754849472105268, -3.038824194796009, -0.5276570146353723, -1.4990813092411193},
    {-1.2794508193823761, -4.0315114799683, -3.3684943279208333, 0.04644650140813948, -2.088855165381298, -2.4011778940288386, 0.5420359020497968, -4.281755608126872, -2.631486585804387, -1.8965666758725335, -1.9403254227014435, -1.7378484486073444, -0.5635538728513569, -2.5056602799726506, -0.08494964325512835, -1.1772476381379364},
    {0.16740042769156394, -3.2825237991248835, -2.8395754331606526, 0.6077016395855488, -0.5048872340126913, -2.422886016072558, 0.6576160086165497, -3.520796079077656, -1.334007873022319, -0.9742918238303209, -1.5382056327611462, -1.2104768228194247, 0.8615904737404654, -2.2749985374053914, 1.8322111302291757, -0.6255103920072259}
};

static const float b1[16] = {6.295037980563967, 6.399852686012808, 7.068573003610451, 7.260371974655206, 6.299405729234743, 6.958189813794693, 6.487684386594918, 6.348985942559407, 6.831365221410929, 6.1118127625376335, 7.306530655874866, 6.6090189381479, 6.367648760316589, 7.440027004972253, 6.212264106804559, 6.238609374006876};

static const float w2[16][12] = {
    {-3.0531805588194114, -3.1121056167831322, -3.282050741670001, -2.4885287383380112, -2.1822279317233484, -2.695421276078812, -2.2408034621254327, -2.1240180589896838, -3.073827219291815, -2.544458597003109, -2.29471549195331, -2.635073396489766},
    {-2.9394353190511793, -2.849381920536555, -2.5428408205626227, -3.404690547481587, -1.8828511942848805, -3.2162175964384367, -2.807313907428418, -2.7413008229556786, -2.8393820093878883, -2.016609150092106, -2.6597830239629525, -2.516815431294245},
    {-3.1954672667182566, -3.2609700776179893, -3.0913839851145966, -3.3674746743399777, -3.230352539880702, -2.9788632999054605, -2.670354296361935, -2.4577343866109342, -3.3634446407189604, -3.2842693005207075, -3.1111212576033718, -3.4821099450988777},
    {-3.71394941561434, -3.2331206751680326, -3.322040093482604, -3.714903989558887, -3.347073823697126, -3.3699231056043666, -3.2769942495927014, -3.618277456303086, -3.2574744357999093, -3.307952383944776, -3.2978135187168327, -3.866475333599166},
    {-2.302265637526764, -2.97870681890773, -2.4450347254503093, -2.214085842561588, -2.573494946442225, -2.3098274638447873, -2.975581152002438, -2.9163166303555785, -2.3052975238366646, -3.328861842358669, -2.5598596317348963, -2.507282563316406},
    {-2.692777483858737, -3.1749955016518565, -3.201006143861798, -2.5018756425743525, -3.007855778353189, -3.3033801157262874, -3.7536522839372806, -3.5824985829130673, -2.988125542985817, -3.0019026118331316, -3.369600471544884, -2.1093581261563155},
    {-3.1118977809460184, -2.593591830683085, -2.5356490702729055, -2.833157419444467, -3.1535850424114584, -2.775152439401555, -2.8134711550723877, -3.082505731526239, -2.07333158421489, -2.8378492757686895, -2.328701148370606, -2.5924535649266223},
    {-2.983128102970678, -3.0072653283428434, -1.9600674564096627, -1.9453745846736001, -2.793452678725059, -2.893768808963151, -1.5898089512961644, -2.7032847618775055, -2.5922856069480704, -2.1968736185986977, -3.1744471731179495, -2.444419627773707},
    {-2.6211125038556387, -3.108574491605726, -3.118918211257778, -2.566724158905952, -2.7282603785325557, -2.4184069764916214, -3.414253355750385, -2.5702801867084006, -2.9370659772573315, -2.157098837558185, -3.2099503568773113, -2.899893016991652},
    {-1.7994190982057963, -2.258571135045969, -2.4435091152886623, -2.7095248230594935, -3.2972661746149208, -2.6035091379639903, -2.814762082210556, -2.6202832228189497, -2.5713659935908324, -2.979159298481177, -2.9400605293630195, -2.62718327353636},
    {-2.7357995685441, -2.8681017593127205, -2.995473779700026, -3.317593906260219, -3.196965823135154, -3.2539861785007242, -3.2458026130388573, -4.20563094898104, -2.9543141526487604, -3.4390623329449754, -3.7766685313931134, -3.4648961666069606},
    {-2.966447680905269, -2.7590376211354584, -2.9399408147697907, -2.6997586874160957, -2.4351568755811557, -2.9963224202051073, -2.331078421358964, -2.4994907893405705, -3.172307722280673, -2.7718952179705747, -2.402004722534703, -2.6430665092830603},
    {-2.615197195457468, -2.6194099892062566, -2.8577046153624237, -2.378956224682327, -3.2703707385650076, -2.506959617442077, -2.6294669302460676, -2.5735423499418553, -2.9553316412681925, -2.724174737666686, -1.8541935633465447, -2.881923313193298},
    {-3.9809711166763795, -3.7665116276203823, -3.661266146008612, -3.723388070956046, -3.6628499418908023, -3.518684582563313, -3.466966859120648, -2.817312926045899, -3.693903203360493, -3.570643133774924, -3.136715898260645, -3.2896135501050083},
    {-2.795913482946983, -2.681762716648175, -3.076252269524331, -3.05691619477441, -2.098376701001453, -2.38060491985643, -2.983225339739925, -2.856646202459085, -1.880481526727667, -2.983331343919491, -3.236673464106137, -2.4275996977145398},
    {-2.2923481149971607, -1.6138850129118811, -2.2607521245200806, -2.7015045327286895, -2.879801359431264, -2.4773315171387313, -3.1015576882500775, -2.707835090506509, -3.647184249927539, -2.5751528876273877, -2.7725600329888773, -3.302775746535926}
};

static const float b2[12] = {-4.793244926823827, -4.887270512030514, -4.776618330822484, -4.505584718731633, -4.849606404769748, -4.2834282163088435, -4.420582700604268, -4.647675905394489, -3.6247945646190107, -4.654130647366994, -4.586280333256931, -4.017080389590444};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
