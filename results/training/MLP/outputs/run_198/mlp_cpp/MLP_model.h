#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.6193381367241239, 3.1298831656367696, 2.5212284547730306, 3.518550052813717, 1.0775564174327918, -0.3266226939589416, 4.1328613286458555, -0.5605630061023444, 3.2739503264569043, 4.087485882455743, 1.421741545704297, -1.4378439120663657, 0.5787632015053596, 1.9359950874258371, 0.16210895632455563, 0.10108686347647267, 0.4280834928118959, 0.7577115403754433, 0.13208024218358425, 1.2103298486613443, 3.1615832735973193, 1.4389809855428326, 1.4873941107548752, 1.5182661396694903, -0.8329216768128719, 1.6007004430218599, 0.6132092052652353, 1.0917959239819246, 1.360571732202108, 3.0070840664328604, 0.5651329273372839, 2.9249724117318032},
    {1.8845666276345319, 2.5481887605004974, 3.8412018177040825, 1.539821653624094, 2.668738107477153, 1.160555503342623, 1.7303222995534049, 0.18400542826133842, 1.890048014223947, 0.6337691168303123, 2.056612525810157, -3.3509126099563176, -2.4065418003634145, 3.008745979189315, -1.3187804767470135, 1.559201117723839, 1.0252664777391447, -1.3701232774283856, -1.9262338837648187, 1.1890957578395764, 2.0674461589617885, 2.44649377962721, -0.23250731989102058, 1.6216611866026698, 1.2225933797765347, 0.3524121471022985, -1.1998962389619852, -1.3045051231679843, -0.6105855794571702, 2.3195996367409015, 0.08876839121992669, 0.8432973544313744},
    {2.204390637545678, 1.7671491773245303, 3.8222966595791936, 0.8285713606379684, 0.6926727618773713, 0.5919511254335798, 3.334644456719829, -1.8858279923252346, 3.2066830987598487, 3.3069577858939048, 2.2691110516680117, -2.2782597344027535, -3.3233415224519023, 0.7809107172123949, -2.7191060352852228, -0.2589503925950537, 0.3192342079998469, 2.472781922873899, -0.8453482965743683, -0.3487596981037243, 3.4778232966657225, 0.9831052961582407, -1.6956556913812562, 4.068542951604002, 2.419779864382122, 0.7939206845571741, -2.451444574667449, -0.34643080031927154, 0.17087129770810341, 2.416193669255887, -2.233720941495015, -1.4708992103676661},
    {-0.6348952740461975, 0.6862022913735195, -0.5948907008651234, 1.0972633642298597, -0.19186908165931546, -1.4260387654192674, 2.974490526065658, -2.73668380289907, 2.515363483245221, 2.762284928000049, 0.7156074131609615, -3.8715563711636998, -1.3196591272234817, 2.151146884049255, -2.1126095549303607, -1.2816345198612495, 0.22397363292022948, -2.313568446687118, -3.2747415666741406, -0.16802785866643136, 1.9696798881033253, -1.148257959623911, -2.096571454907586, 1.672816558826378, 0.06491770753853542, -0.6369811943560216, 0.08460075454525144, -0.8710051183434209, -1.1805683677046268, 2.6965897791979323, -1.9973782396889954, -3.5686124287440055},
    {0.7588125349827837, 0.6517392778919254, -1.7917662395489105, -0.5098670313920933, -3.1352299964308252, -2.443295381686054, 2.931962186587184, -3.8775858445144844, 0.09699796882928126, 0.8966663212452972, -0.013907611818837965, -5.313545807625665, -4.420942301384728, 0.7680480986334697, -3.670479833210808, -1.0810621062530719, -2.11722545083816, -0.5647135457352047, -4.888508563700638, -3.4666899258375565, 0.9631303518766644, -1.174905016383235, -2.5080121522809606, 1.7948337592739476, 0.1589919156309873, -0.8242152052043279, -3.389911255633831, -2.232336078416004, -3.342340945952284, 2.2306232842230895, -3.77114026570524, -4.494381441639827},
    {-0.30939005489552895, -0.3902764774248211, -2.6155291170532884, 0.9116141015987654, -3.0240073756987855, -2.7251188393702233, -0.9858641159316233, -6.409738848609154, 0.44557075747480795, -1.2255187104183323, 0.06825141534870344, -5.954341646812771, -3.8225657330472087, -0.026479848916441104, -3.41753486277462, -1.6233475486579696, -1.2135000531281104, -2.8336163971810238, -3.426231060688237, -1.7925725909314365, 0.307631309639297, -2.5422360685193355, -3.346884758318608, 2.623325197528084, 0.14289269928334714, -2.7750560688939823, -5.746619680177128, -3.79507892775145, -1.9919988255999277, 0.7836632635054075, -4.667219814477306, -2.370273216665848},
    {0.5331578962335317, 2.0666129624604923, -5.07895899083471, 0.5811719971488346, -2.1648691163044953, -2.094645006084585, 0.48134092097122955, -3.2629093261555098, -0.5993020928723767, 0.341658260361568, -0.3401663032521594, -4.458000305122765, -4.245019755976008, 0.2260462227569516, -3.984961480289345, -0.06880927858810157, -1.3016905648202013, -0.25211667459413195, -6.193198226851725, -3.1666883965098056, 1.4623514712093466, -1.8751876312748832, -3.4120872198668546, 0.43927638439155636, -1.1488896247532012, -0.9307821104523062, -5.12663157343025, -3.140000976708021, -3.697580580849695, 2.5607798309460303, -3.810536410692999, -3.4369625531845993},
    {0.16003100910555268, 1.6172149725279072, -3.695876611575311, -0.34515362489042756, -2.147873800307145, -2.481089430205277, 0.6972704929125128, -3.233270926071258, -1.3642438695898547, -0.6430428065535889, -0.0341636807305284, -4.882283065496962, -2.769383673109725, 0.4206911570956093, -3.714645030550623, -2.585472441727695, -1.8203571361238986, -0.7818948940785367, -5.394160715723533, -2.002206612161835, -0.0845746322940936, -2.938175699934469, -6.228424119068093, 2.04180894908967, 1.3164047558477818, -4.136197352998592, -2.654614189538941, -4.549289000593248, -2.7728487561585773, 0.5868717109784569, -2.227414785287458, -4.104098347498},
    {-0.4738076762779305, -0.469934711202832, -2.108873014893183, 1.1529670703625563, -3.608800344851425, -1.802170587102108, 3.7862158235010344, -5.636556822613177, 0.7957319788846817, 1.498926596807564, -0.7310849634870324, -3.68181202795826, -3.539158157206002, -0.8706551287243707, -3.63168089916619, -2.0464354696076956, -3.09887726816887, -0.285694665382512, -5.269392794347758, -4.269612138700438, 0.8768316625734748, -1.672531764191502, -2.6197213725776427, -0.4850480299896716, -0.5498614807175052, -2.51520834683506, -4.374823172238022, -7.070858498904223, -2.61722068124791, -0.1758602540335233, -2.668444190550607, -4.045732567690571},
    {0.5335744154369424, 0.451368313836795, -2.308748955911206, 2.943204835005492, -1.692077953887552, -1.0985666512035879, 1.7528623669933312, -2.875510998490236, 2.3377000888705566, 0.20893108267498223, -0.3271351856383712, -5.359481899064695, -4.362062325928584, 1.8996655223874266, -3.755205786980555, -1.338841915609425, -3.4724651103408912, -1.0208695714345333, -6.688145146537372, -1.8255894361354912, 1.8066010534262957, -1.2285346909064199, -4.078271872346426, 2.185767831756126, 0.5918410267310531, -3.0595203157620494, -4.164374218972821, -2.4914242268918114, -2.4014580112737582, 0.10570062766847535, -1.3362795272862784, -5.565768152670688},
    {-0.32137300832812604, 0.11756209381812158, -1.533004047312863, 0.35632360312927647, -3.6682390467152617, -1.090351740077695, 1.2319863263195927, -4.089607757543624, 1.3880919925802169, -0.5674015900963787, 0.4913474514351173, -2.510721195542464, -3.003046348454523, 3.074205025882085, -4.167913251057895, 0.6704903504521643, -1.3311475546061888, -2.931936165321785, -5.067913954725502, -2.7655040912959485, 0.11052678573342654, 0.32880270498786635, -1.858185547035035, -0.8343939170229759, 0.1163277010685219, -1.839013279286021, -2.8708359815698623, -4.776401710190419, -1.943189502051849, -0.16173548357522155, -1.3740184748739404, -3.5323925928464814},
    {-0.19640032581269473, 0.7871673994578579, -3.183803921726053, 0.395316051984691, -1.6940764973741853, -2.143773453461358, 2.4513988128230255, -4.002323159597409, 1.07247624304296, -1.4482157276136427, -1.3879313864341327, -4.993667867276487, -2.821560797510447, -0.24092921747479573, -2.443878163971446, -0.7010981449951753, -2.9181000338721876, -3.095010442523422, -5.215829227167092, -2.1614433086515223, -0.1507025215888726, -3.925628153332122, -3.362282510845264, 0.5164958034093013, -0.07013374407387522, -3.2986523590762395, -2.7182158408622947, -4.828927837569673, -3.543424641012261, 0.11077806158618542, -1.4386449281837836, -2.6110514072019404},
    {0.09731801188112094, 0.4234905117355692, -1.860475383047095, 0.4988678328772426, -0.6833038914622956, -3.430695903466547, 1.9532637856168158, -4.19347556168875, 1.4389681459697523, -0.20341386680119009, -0.775758732433067, -4.443107373241373, -1.703563330633221, 0.46748284797985634, -2.7893471316851306, -3.3790451625910247, -1.570045662683952, -2.4625177654723913, -4.34562968379383, -3.8187191931997573, 0.803946180854596, 0.5285222283648796, -6.192283168168946, 0.8962136254119313, 1.1456984999320543, -2.1946344870415357, -3.7100192998028643, -3.793665132224115, -3.921458838509629, 0.6285249718317177, -4.05186764716077, -3.9764821111535933},
    {-1.205696875488207, 1.4637918863466493, -2.40897162326387, 1.1486054064947608, -3.54514193213634, -0.9173913393947016, 1.6803563606064709, -5.191866147004358, -0.7079353633721631, 1.4594588436986211, 0.839712057751402, -4.249807971048403, -4.5611423608805115, 2.165482145264175, -2.5549685486324423, -2.0033572907786583, -2.7345675767424904, -1.3796862321173387, -5.494852052017875, -2.426525229847091, 0.8289009574588461, -1.4994787053450103, -5.521934321957933, 0.44428727380366856, -1.31991542070835, -2.1533752220497218, -4.737473996926845, -1.8091240169234417, -3.692189541218886, 2.28794065494971, -1.5633857072018478, -4.841421418276222},
    {1.651908255229358, 0.3049964333541836, -0.4592373309853629, 1.7221292883138182, -1.6432437332371788, -1.35726174215758, 1.7616992659057453, -5.0828836174223095, 1.1375185812000126, 1.5370875878765047, -0.6814506968919085, -5.2194899564780615, -4.071278116851352, 0.773670610113825, -3.7823221303534833, -1.5352564721174105, -3.6372310378412998, 0.011999914102946676, -3.9259917829427833, -1.4685067168066814, 0.6910029225900656, -1.971554841346679, -6.162755578533961, 2.325276734512947, -0.4717785175819506, -2.5929131674479504, -3.7707653361776554, -3.793068993790754, -1.0686113781582962, -0.043326566921201924, -0.08755668637270439, -2.1641987673818015},
    {-0.5207815184954714, 0.7295894123608401, -1.5380776836524495, 0.625190113780473, -3.048268453057445, -1.4023094789323305, 2.7488350406419935, -5.8048151762934035, 0.5970295026307183, 2.152325176014196, 0.49052846888998103, -3.2507283015267796, -4.724194399330795, 1.0339512325402358, -2.2948778437448314, -3.2423967633717634, -0.549265123296042, -1.9593020656303246, -3.1662442162194915, -0.693715191888013, 0.8244679576433585, -1.4210367526322607, -3.9291655982255542, 3.6826114322012717, -0.875304295119283, -1.9487604578593867, -4.636947993986545, -3.86504296738805, -2.3586861943338415, 2.340667816719008, -3.2068769039775025, -2.6518151910607854},
    {-0.8338629174980442, 0.3835752281850941, -2.1758098131110875, 1.795661873564251, 0.5847647918604431, -1.026798405624452, 2.1777635335884398, -2.807645738549305, 1.8879249685631456, 0.3335477299799085, 0.45405288942583855, -3.2371206766971157, -3.3363894386264232, 0.5402809838576227, -4.44169758474914, -0.5918119303529398, -2.829641742214772, -1.1614853054945289, -4.2325533447652885, 0.22954164435738172, 1.491753628147044, 0.8744359314109755, -3.7838441235757267, 1.3496932742820034, 0.9455606872496856, 0.03165052775140656, -4.0336944141399576, -1.5146998731827774, -0.8129445608997914, 0.6813466844726841, -1.2705561158164838, -1.821527179080745},
    {2.03987744129182, 2.2419745044768553, 0.968188192289281, 1.3587826771889633, 1.4631538936190187, -0.14220694359901093, 2.5076309143761026, -1.367068132959402, 2.862169311645451, 1.280060509186956, 0.06278181702271184, -1.4695081884776462, -2.0649015863932916, 2.442961086016834, -1.903154811164662, -0.1705889083508821, -1.461007628840188, -1.815733620183731, -0.739872594682206, 1.287556868942309, 2.045444221876687, 1.0584475297165588, -0.6200967647482726, 3.7857813525096202, -0.07090119709097303, 0.2250625686069722, -0.9129033300063651, -2.883109159479626, -0.24477859733210422, 2.324359340756565, -1.5957557023359956, -2.1851660253164233},
    {1.1148510290326805, 1.4223493311432973, -0.4656082447073146, 2.5477206287809713, -1.3897223056976313, -2.4171026036029306, 2.3851198944984398, -2.2064980410204513, 1.9157230024969099, 0.12865039786766816, 0.5488389246103315, -3.7746563618007496, -1.4436586828755427, 0.6813276725982157, -4.367688331057465, -0.7702001513107891, -2.5628659949459625, -1.2320452570701736, -2.3927377175873477, -2.6023389420044007, -0.13472460348643633, -0.08044685473196234, -3.7207543768387525, 2.2108387901524473, 0.9239874575242961, -0.01359582459310814, -1.4344036752212925, -2.5948752218824325, -1.4933370284589707, 2.46830214028604, -2.681469911530611, -4.316477637409191},
    {1.884245550845269, 1.5134579808560695, -0.7759018545207332, 4.326624195087691, -0.4891300639231067, -3.4352120094645877, 3.2037945044055802, -2.071801613818891, 2.5151403380827957, 0.6879008709989516, 0.2708074423167927, -4.6689855533458955, -2.4555479968461404, 1.1117312174798872, -2.7602206436344443, -2.8822895377836275, -3.605249205240931, -2.8734466749121994, -3.5425291761430096, -0.5318683508605487, 3.307176196182895, -1.9349349722082338, -3.582978942124839, 4.407430378405819, -1.6421491495042702, -1.8859601785455364, -2.5305422705339615, -3.9041929019168946, -4.255271288210128, 1.7583520164896431, -1.9660915995471573, -4.984354934986823},
    {-0.6454276138724342, 1.3960596227381274, -2.215112315210954, 0.8908344832887273, -1.0102042865292602, -1.596572090399121, 0.9549851777023102, -5.216741077484989, 3.3703381588867565, 0.4858674327429517, 0.4616407281792649, -5.246286846144002, -3.9109079362527597, 1.6985809139232013, -3.0733659877091957, -1.5568091245072115, -1.8205177045874368, -2.1798666430748033, -2.9049495505289062, -1.022234279624715, 0.4667428966652032, -0.11726834758252706, -4.659393928149487, 1.7699547064968288, -0.23791402236818507, 0.24875991782626403, -2.535366674239463, -2.8188921842226677, -1.4396472851005133, 1.6065309633999811, -1.5203300261942225, -3.962404201623276},
    {0.6607124041471907, 2.012464007636326, 1.0603405456752977, 2.3376124322128686, -0.869538275801804, -0.6816003655466958, 3.9589579134342836, -2.05661396513468, 3.005570136788668, 2.6438005659643706, 1.9257796367525502, -0.5180805766955254, -3.143727704546287, 2.9160838891060763, -1.6666459746933888, -0.013871239343482096, -0.7829805276193571, -1.2676731270202395, -3.8006566430113624, -0.4534300766263976, 1.1313678166557806, 0.26296548439999895, -4.318587970792836, 2.894142952957598, -0.21242227416291734, 0.004678149043114115, -1.183883838401427, -2.8945889496014137, -1.5312991737147033, 1.7631060694550502, -0.019854445691827947, -3.0327751327359924},
    {2.443070072264685, 1.6748304578298816, -0.010504544488964422, -0.2177385824066791, -0.6286624258823479, 0.09537254756763885, 2.219743600394307, -1.0753600821526303, 2.582797636506913, 3.357888243098397, -0.27335981971940493, -0.8602111544592117, -0.8622659839374426, 2.3434832885795163, -1.0160916580703636, 0.18217286192991514, -1.2457545993651649, -0.3317486779386597, -0.26050130420965933, 0.8109075076768929, 2.773532395887741, 2.268059894073191, -3.2028206852625316, 4.682050728447793, 0.8792698272878545, 0.19953992311953073, -1.4810567304148465, -0.17672950807443738, -0.22416758391580952, 3.058784814021229, -1.8593437487045172, -2.9498536128124866},
    {0.6727667951788782, 0.6867811070838525, 2.1799171002087108, 1.6077653176211657, -0.5339048897588556, -1.7217469000688315, 3.4334988527231904, -2.9952465053356936, 3.1452236330192984, 2.0143484761629296, 0.7803130850959333, -3.523154004433487, -3.615895657663026, 0.9538649114489661, -0.9235077800637562, 0.9101408447477782, 0.47942343312873237, -0.9840301024359378, -2.214328371419174, -0.8838596990746674, 1.8862402016209794, 1.3260279769164884, -3.320116835334838, 3.1633469454940037, 0.9424662054742381, 0.65150820216082, -0.5440670033182538, -1.6354005550584587, -0.3404103201978026, 4.032430312126923, -2.9017737105420944, -3.4551370286173464},
    {1.0491345486591168, -0.39362497916881634, 1.1927229348374693, 0.35865409863075043, -1.2438695595393634, -1.5968960827306955, 3.097273248690663, -2.9398235461282427, 0.11895559635536719, 2.70209955320322, 0.22177643092902313, -3.5953375271786623, -3.39783312784455, 1.736295278956348, -5.770446921388638, 0.1352020075748304, -1.0757154521678767, -2.7511045986382396, -4.4686542295571545, 1.3770545399232936, 1.9224309244436235, 0.18042878057145187, -3.759322805934394, 4.074385852485308, -2.8699587059536933, -1.491804688230579, -4.038568583637941, -3.070449631980067, -3.87088954447075, 2.251286951453431, -1.6516714689973, -2.600875960691141},
    {2.040499879457105, -1.327499975267953, -0.24315092864070112, 1.2605298248239554, -2.6490772731845946, -2.1039400680897447, 2.0220406886904594, -1.7638439692972112, 1.2526815088272825, 1.5339003819139132, 0.01887862526375135, -5.019490934198432, -3.9897292077723754, -0.990680116209456, -2.645886231300565, -2.2690086892976375, -1.5953317059546588, 0.17516345838959566, -2.929019432425231, 1.7965276980428675, 1.7964609723547478, -1.337722128316168, -2.1325162814023573, 2.477292588577787, 0.21251248049840368, -2.3943038466137, -2.300020877877963, -2.709345091470458, -1.203237244430994, -0.5464608696037354, -1.9303314107900653, -2.4337936056949236},
    {0.49532336072199407, 1.1164377992896048, 0.03873547325345701, 1.5785571374296035, -0.308439719626014, 1.8219716089652385, 2.4336678327178896, -3.4357641880822594, 1.807848081124365, 2.036834683376828, 2.3339152404407386, -3.91923287085821, -3.3664470435919003, 1.4108786804206501, -1.3213989818130925, -1.6301458182424584, -1.7886417393092005, 0.0934195923218439, -1.5434679105883917, 0.8354046813376609, 0.9966307979023078, 1.636504974598448, -3.6973441808113283, 1.7372084245419648, -0.10454338238114771, -0.7510220972141175, 0.09115645059321144, 0.5256127622014843, -0.8354609470914449, 2.32860243302553, -0.7638193174734242, -2.4543568579623707},
    {1.8252445081073514, 1.0729421787687727, 0.603051589128903, 1.1978001108765466, -2.198285808590484, 0.42592080170907815, 2.925640873774574, -2.9499649141091218, 1.1063320900849232, 2.7469822381804234, -0.2269131490308945, -2.782368604819043, -3.270889406266878, 0.04911513372325827, -2.311209125647632, 1.5251459451871408, 0.15515048309690896, -3.0234401506965334, -5.003245782691428, 0.6703460036000864, 1.9029481318744463, 0.4270320407764991, -2.953835690001983, 3.04724883518698, 0.538817595238429, -0.024228200421834403, -2.8722793704552037, -1.592176268320801, -1.8255156431128572, 1.902607361501522, -0.13878790735860805, -2.390305130127538},
    {2.3223311280818137, -0.17080087336078253, -0.8709632104443751, 1.9794024231438292, 0.6652576243996942, -0.28361429228121887, 4.0406020161344225, -3.27503217522888, 2.410931534314244, 2.2850469724216884, 2.5200329062841984, -2.610125308691716, -4.408882847323948, 3.0632140932883227, -1.3410556000600213, -1.1312821085747127, -1.492858930247976, -1.6159838487674159, -2.595300401130616, 1.3353811688539727, 1.3568152347569569, -0.7491641613317742, -3.840526225694772, 2.3083388269755862, 0.48151442949985185, 0.29306879446148815, -1.4720434677229135, -1.0045073731679535, -2.1805565523936394, 1.443945019569086, -1.2830699287593323, -5.04192036094538},
    {1.0942068621362009, 3.808218166637984, -1.8885566693076261, 2.3799960832019154, 0.43381456168075877, -1.0639161347050206, 2.905580158214057, -0.6857617818014076, 3.543670118804547, 3.5019870128675574, 2.537671995383855, -5.293120621899256, -3.3183039903121028, 2.0496098299007555, -3.4583590674351723, 2.15798491054881, -1.82331139699418, 0.39687784205886606, -3.3110235827580303, 0.28078708378419676, 3.443613077157796, -0.012754526502130086, -3.609179277640222, 3.6305541151541814, -1.7942875308832331, -1.1666031846832223, -1.688546607222871, -1.841469698750908, -0.49356734484308895, 2.8533245092070936, -1.1346771951561503, -3.729087070410226},
    {-0.12438732302864813, -3.6834701943695616, -0.8777817382454495, 0.2865408020896194, -0.3433336116808904, 0.6061639888626045, -2.093175040520222, 0.17231599911645304, -1.8299032303599962, -0.5090887157938623, -0.042705843191955944, -1.157478870293223, -0.4574197882899449, -0.29748016531815386, -0.30078923354535897, -1.4750781636399153, -1.4951752678282786, 1.539503872234301, 0.1540134860707556, -0.4519018590076461, -0.5454612775044418, 0.7923453804116475, -0.8569866744265401, 3.89280761306182, -0.14286807016911535, -2.83082038021192, -2.037340955814344, 1.509819518263137, 0.6770857522545521, -1.4639781778237408, 0.7276857876791843, -1.3342005139995743},
    {-0.2054978259245512, -0.311492056711952, -0.08477411958929588, 0.8020303058540512, 0.2916330091780495, -1.9373265600912926, 1.5260376914439069, 0.971023823845149, -0.04742228050027765, 1.1537091548095162, 1.1982227116490975, -0.7632877455581427, -2.956597001263352, 1.5154150177750396, -2.22055241955704, 0.6223441138335899, 0.6451162324535215, 0.5107278480329356, -0.5033480812635471, 1.1842961693626595, -0.23826354048777057, 0.48252391596944305, -0.10010859925178323, 2.34960035106459, -1.9843430233714918, -0.7173417064082245, -2.376178330772016, -1.4065562558006202, 0.41498458878175987, 3.044999099755911, 0.13822118653222967, -0.04194007240865638},
    {0.9641795720563745, -0.7807847602091298, -2.7328702455797353, 0.7079621039589143, -3.942932214860913, -2.999960280094575, 0.8081058297906881, 0.14021850552598483, 1.0062642875062784, -1.5180097234264003, -0.9109523624593623, -1.7328558358728836, -0.17854675217480856, -2.781642685045826, -0.076498437346931, 0.7661947382949464, 0.5209930235020985, -1.6354978878253257, -3.103545901110271, -2.153786218326728, -0.35386092625858856, -3.227972172536386, -1.7899521238537321, 0.18405495544782538, -1.663083877557283, -1.3050846873768494, -2.5986111959811113, -0.6298576321836622, -1.442840108537813, -1.106389666415809, -1.3515192738582076, -0.8158752935123794},
    {-0.8612064989184143, 0.28053619026304266, -0.8541052097803392, 1.5931910525272794, -1.0497905281328104, -1.7335550917585067, -0.40273904539973915, -1.8097936158887826, -2.647527860290357, -2.079304419459865, -1.1143363106663982, -0.6751046694870174, 2.5325549939599257, 0.16188115130339525, -2.4362310157661824, -1.3306183679434287, -1.914505722520194, -0.45743886623833147, -0.2630916583752464, -1.0034346727038341, -1.1672318754451774, -0.6575384635439706, 0.11690537122202783, -2.0552469928266413, -1.4399032488063008, -0.3483177865129536, -0.8980074002105563, 0.3550879176527362, -2.7486578635238352, 0.4194273431019124, -1.9443281033871338, -2.053644741092359},
    {0.31597068381842053, 1.338131525588453, -3.0795505623026, -0.07318417594502702, -1.0501350568272334, -1.9482664141284958, 1.483052726211312, -1.098068224449027, -1.8084449623499055, -0.004764208020485983, -0.007822557043617364, -0.3205521758555515, -0.576090217786029, -1.425731786323059, -3.7089766607030454, -2.173499166282373, -1.8821417559098856, 0.46673845888405824, 0.054447561548092036, -2.5082996997400326, -0.2525398011308855, -1.7203421744054723, -2.844424156702528, -0.24549368778858885, -2.5140886353893985, -0.11819644507810903, -0.7011646865032405, -2.101199509292735, -1.1102822200207125, -0.41143461607034876, -3.284819451125679, -2.484996728625261},
    {1.9041983701017513, -0.9471739564573162, -3.326692562428047, -0.5350968487664431, -0.8704482209038978, -1.6683628699760116, 0.2778383547445694, -0.779789044168093, 1.7214495620355648, -0.14379236128228318, -0.626182137178795, -1.2444792279026007, -4.424506763701195, 0.46418613538646497, -1.6661919016051139, -0.8807371579682233, -0.5459768635145801, -1.3555872996905622, -2.02491623099384, -2.1311840841934937, -0.4883478806690886, -1.5806999493953688, -1.2271094959247877, 0.28397407360501997, -1.262923582459136, 1.5216500380037694, -1.4156346560205175, -1.6738587965705254, -2.6780233661936794, -0.09475914784283511, -3.720845505471428, -0.6375098109456219},
    {-1.5801740310914882, -1.1478316705475662, -0.671599490895107, -1.8167253452119971, -3.4507577912895444, -3.2952633211428135, 0.07843566381397228, -1.2407928159580017, 0.006113685634563853, -0.4689283465928839, 0.08039443086459165, -1.8777554104032863, -1.2495684207772606, -2.0472114658264484, -3.4475704508682083, -0.19304878061193478, -2.896971754539996, -1.3884410730030021, -3.2257824503715637, -3.564365214548122, 0.6427686512180916, -1.9573605929838036, -2.991579823483237, -1.1626077576465923, -0.9780516805280833, -0.8600237111639994, -1.5401618437371218, -2.8730807334627184, -1.8018046651351518, 1.1510353806486302, -1.7835360946564283, -2.5575143704190855},
    {0.9181225657706025, 0.5447437563824858, -2.1692731133456284, -0.4336698383107506, -0.9995126317001545, -3.7022917288115065, -0.5625401507711508, -0.678877084609482, -1.6074385296122937, -0.2564156103221099, 0.8251967580186108, -0.45501940121146783, 1.1464857545142673, -0.6097914832027838, -2.099169365689726, -0.42189265508737056, -1.2339209891982998, 1.4939168936251679, -2.8610423665727285, -1.2555308175923179, 1.3763592389817152, -1.4873958416922868, -0.5236416033274516, 0.7111507646756617, -0.9089150785056707, -1.4929997755800184, 1.6302198633074039, -0.6688415729619046, 0.16167023459004803, -0.25516252401290607, -1.9469356027547613, 0.7824851250211903},
    {0.9501538098864108, -1.4573913742075837, -0.2608949888840606, -0.3238108273409056, -1.3978894966129003, -0.5714034314021853, -0.7806583667795527, -0.6758701587069651, 2.067902377494341, -1.7516638514526306, 0.29376368819357207, -1.9668151250092185, -0.19625933307382307, -2.029174762646742, -0.747101476634628, 0.35605424601682284, -0.3519126852232086, 0.509204061506181, -4.390365228145039, -1.0095880119414775, -2.755285509169067, -1.2986772056932838, -1.398502026148711, 1.843060816689978, 1.0040511436923532, -2.7116491182170432, -1.049362705979477, -1.5166155722632941, -2.122321668171775, 1.1100447924330779, -0.41297367958119346, -1.4843024416221935},
    {1.3621128485058438, -0.6541401190883107, -0.007214926337278501, 1.496640573543625, -1.5310853600180645, 1.214733921397675, 0.20457543302119732, -1.514737774874579, -0.6317837856746751, -0.7853477050397549, 1.370108997017097, -2.0320594457196313, -1.9250703271764078, -1.9836711351165204, -2.60448633497471, 0.4177069444188157, -2.0115503617784736, -0.0066524490333516135, -2.435125368962453, -1.7094523561636379, 1.173703913140528, -1.68882685354884, -3.3005437087655536, 1.9776603875196628, -1.7503307026837553, -0.8745845517228381, 0.15134543455872582, -1.274103429019007, -2.1469081644727543, 1.762004780551764, -0.4389502938504678, -0.7606592961262969},
    {-0.332431235492926, 0.21079951716797246, -0.14988854650184394, -1.4773514254126883, -0.7742525684774209, -0.34219250257018025, -0.24979139872080164, -2.0304692318013213, -2.274105419559911, -1.130982368204564, -1.026094028367641, -3.2025423452844564, -0.8006990343309247, 0.03520543103871365, -2.3495439663110425, -3.229977127855483, -2.9473638351363256, -0.5903872400185565, -1.2236410678780398, -1.4024851754368948, -0.7610491866278691, -1.2516895323548998, 0.29407250077042624, -0.9927210131524516, -1.918593222101532, -5.211247066514309, -1.8584681270654246, 0.17890493806138064, -4.26750460052278, 0.3953094608392483, -1.0567265389327136, -1.0041853626306225},
    {0.994016389053338, -1.1975499100942046, -2.637902049747114, 1.4780484255706414, -0.7431640339215715, -0.9819924377738882, -0.5007834686505133, -2.359349207829292, -0.08217922898246116, -0.2379309234036041, 1.4032441570835172, -0.3028133738855777, -2.653816043932533, -1.3515298743595945, -0.8208570983467892, -3.1977349345935213, -1.5121177442546967, 1.0881009130693533, -2.294275879030617, -0.6483146492585227, -0.17545129343427215, -2.210644433157208, -2.6755535535853774, 1.043342911176718, -0.284409699436954, -1.9471276776990987, -0.44510422143916634, -2.8712631089990137, -2.4108859788077894, -0.6943676145508619, -1.8908788882366963, -2.150629119560524},
    {0.9908713790317155, -0.8184892648413241, -3.1718026627042004, -0.37676054468766995, -1.0662016335074744, -1.604612198452727, -0.40040243552875343, -1.080984188671571, 1.5148402276574007, -0.003740692077720498, -1.447413441911583, -1.641837183300169, -1.8593957920313529, 0.9274303231885358, -1.9199690729780838, -3.6480011249173887, -1.5150524810102008, -0.784238969648872, -2.023083790314213, -0.8619727122247117, 1.2780483737936188, -0.8698692138572965, -1.3444157137317205, 0.6923467143666089, -0.20498716161392164, -2.463250154640771, -2.758328597118637, -1.3236434811720947, -0.9627577587685175, -1.3051326153696727, -1.1187676561660016, -1.725812221914513},
    {1.9583487051632618, -1.4110879840145858, -1.9324517612252334, -1.5778190424787115, -2.57953580768242, -1.7917035942377741, 1.320083912896999, -1.688043352762784, -1.7653144398420046, -0.49531996925911825, -0.4185468209866286, -1.722648419384837, -3.5162719009346515, -2.0868384585006967, -1.946532396810056, -2.6014896431443906, -2.8443591038182654, 1.3474961008450914, -4.986019789818959, -0.7616342991105715, 0.7587951610081248, -4.2617019048973726, -1.8954464837883926, 0.7068553902174751, -1.5375208535984075, -3.0341563996875824, -1.7687290795592443, -3.4842872022340368, -0.7069866375364745, -0.8957409234103181, -1.538777202485899, -0.9771008856606658},
    {0.5422004546005721, -0.1447491372208223, -4.056228633987472, 0.11650987344991207, -3.8466956976226325, -1.5833408583865474, 0.7903331556908625, -2.629352037720147, 0.5008041412129864, -0.27913469079439907, 1.0397319955036919, -2.9056471188997186, -1.727370005138102, -0.8615170550437223, -2.364445353923967, -3.14851837890781, -0.4987588950150674, -0.2603098636819431, -0.6194902304490544, -1.1472072684468058, 0.23687369643784828, 0.15457827450882275, -2.108978356962901, -0.2970691663456471, 0.1291893728100863, -4.002319867014044, -3.166764961784712, -2.3342703840382053, -1.2690462566653506, 1.1538349375698265, 0.21674491985994296, -3.941594874018441},
    {0.4340797638889467, -1.0361704261247693, -2.2214486580723776, 0.18049273016324366, -1.2761139872676346, -1.3931086805996935, -0.9970593543601793, -3.4768421075756697, -2.2136226830067223, -2.7836401622206437, -1.4267794772338005, -3.0952029911404204, -1.2006935147552835, -1.4557136836602955, -2.650557558406373, -2.4063554681634525, -1.5450799373469957, 1.1602626703510097, -1.679159971454138, -2.040013666967368, 0.6899074305586959, -0.1929481110401574, -0.8257988452072648, 1.1503125954959905, 0.29384011585854736, -3.4964170180771865, 1.0328750497971744, -1.0189557310591306, -3.5240540840002073, -0.03701449436926726, -4.178005233360426, -1.477497038597176},
    {-0.603482291462869, 1.341446120781, -2.7721152248576173, -1.4450983953000733, 0.03179161684868735, -3.3330986352698924, -0.5972014506217456, -0.18955151089946032, -1.184876106101064, -4.192312445559981, -1.2898322564217262, 0.0333490571766871, -1.2081289344663066, -1.1156067502419693, 0.15604343529499995, -0.029840391841191884, -0.790648047296907, -0.11866749630157562, -1.5139284368628667, -1.1902592658989959, 0.443167351818005, -1.1846914473572687, -0.2576072863211992, 0.3987015277176319, 0.5639313006326389, -0.7209804223729867, -0.26185089643133674, -1.9532585845497201, 0.21490248159993233, 0.8458248157827504, -3.147771719311908, 1.9891345535927742},
    {1.760743240572632, 0.12525753002357193, -1.5749214307636739, -0.01478988649414611, -0.6224507523797433, -2.5796615796539126, 1.1689865918785023, -0.7150818850506919, -0.3726760107086047, -2.121409483478391, 0.040311022800180334, -1.0356421549550103, -2.3978678854665016, 0.3206270254222146, 0.028709319126450535, -1.2013402262599195, 1.2957774084357325, 1.594853734708379, 0.22181682055834803, 0.5259284282320695, -0.3110146213088965, -0.8096370321302454, -0.4920870098715259, -0.3712878191153631, -2.0949667439492785, 0.14195975450686366, -2.4411079313169686, 0.6232427461104393, -0.4833143248670943, -0.42991580050693906, -1.4834333674226359, 0.1046684225772382},
    {2.318213277119202, 0.7535803008138852, -3.389571921594925, 0.5823572548911378, -3.1037932785169096, -1.9438473034017687, -0.14068781573447217, -1.6037122957758316, -2.3856313982608826, -1.3354806237367407, -1.4154106163916924, -2.488067899909443, -1.9629245707494936, -1.7298250358541685, 0.025421127751675623, -2.3761073855402475, -2.4287300616855103, -0.07022054010283099, 0.2742411400807553, -1.2075188534306924, -1.4555494512408291, -4.553067088003104, -1.4950353871605166, -0.9509629965778269, -2.5391590945516627, 0.2687549546141073, -2.0589550529625527, -0.24223369489663957, 0.28111840706509894, -1.2827069784320235, -3.581911333347025, -1.0248125892530167},
    {1.1983248616882134, -1.385887120348605, -4.8214477660552, -1.2035778943417996, -1.0652257495591604, -1.868738763372178, -1.4899878872392813, -1.1015487670355146, -1.5994825201231793, -1.5904203423788044, -0.9676889629182012, -3.689840375532973, -2.3806308307991024, -1.6254438098023087, -2.1971044081265063, -1.897094654297072, -2.080335426488077, -0.7332225342369175, -3.971908541172305, -1.3359868985093506, 0.8999292596585099, -3.887199450472217, -1.4030094444790027, -0.8658270127317763, -1.1892342601804455, -2.7568329444154402, -1.6286111304867512, -1.5447755956412812, -2.747806246755405, -1.6240524361766475, -2.5310344066619703, -1.8097990100430748},
    {-0.5026904852274526, -1.9524534814368029, -3.0689075046326906, -0.7352014007968075, -1.4841276822237677, -2.9266614109809272, -1.3280272341663284, -2.551733810356762, -2.677788129935631, -0.6451671754757439, -0.5903714693473016, -3.4526631341204554, -0.7775998214529104, -0.15596317966788778, -2.7653928881143783, -2.624514317386589, -0.3367746212214584, 1.1789919970667482, -3.2939984960884368, -3.1150704163963145, -0.2459477976283459, -3.389851494323533, -2.530156649390325, -0.4859087722700598, -0.9330288387892607, -2.865979778592033, -1.1244960175208587, -3.354107844405137, -2.7360811273204217, 0.9192014431784226, -2.7890522434986185, -0.171604518847371},
    {2.5731140361416416, -0.1274709844460603, -1.2131491827579717, 1.0785239633443287, 0.1798384482959824, -1.300437012771173, 0.6215589102655873, -1.1587856737718065, -1.5570147523011988, 0.4777233881080978, 0.37603968558457096, -2.4231955476165417, -2.0914799059944493, -1.5057590676358343, -2.5661325543676847, 0.2504343372065521, -1.2900993410520953, 1.1979608942661861, -3.1181706436653527, -0.9324334911332555, 0.6932121367741446, 0.09922021728706695, -1.3585224078532692, 1.7943906238165195, -1.6595536346145723, 1.1583835394580777, -1.4946522101590765, -0.3556101242550933, -1.1581731689713741, 1.147754028432757, 0.17558731627829044, -0.4018678818924502},
    {0.6267679867934012, 1.0553412708404921, 0.09881642821491522, 0.7738490508769242, -0.49798187485201745, -1.2333006564808842, 1.589992793500047, 0.3114227262426393, -1.6069259697482001, -1.6034700309754744, 1.712774883689876, -2.329607728552109, 0.8882343511106688, -1.3814999728778845, 0.26394875666203066, -2.152279768592704, -2.3390729821543372, 3.2880598867464865, -0.6252657844185646, -1.2734476074942536, 2.4304243932372684, -2.850078643925309, 1.1080366690523984, -0.09923083046824281, 0.40301265266987485, -1.6739261598616324, -2.015692496275017, -1.7210552054370163, -0.6355402720011946, 2.110088253467713, -3.0195526943029103, 0.0406224320991512},
    {1.692353652825748, 0.4602089703510554, -2.6443024904478034, -0.732261300078237, -0.39452020629995405, -1.7507215008666777, 0.26934753448675913, -2.0109846935367006, -0.4631020065814416, -2.273663928255478, -0.2938821259172995, -1.1711929688800753, -1.2466627169805284, -2.7354822381662394, 0.7134083789414678, -2.203907252777245, -3.5169606180621424, 0.2466482530389927, -1.2489482581996925, -2.910111004641278, 0.4876245248230087, -4.389699499733532, -0.3347396502579673, 0.8575497008826706, -3.0108102947444855, -1.1139388150224803, 0.04864122945195464, -0.4561005904053879, 0.3082241599771528, 1.1497529436262208, -2.7792855838403807, -0.9174807170194956},
    {2.221346363250119, 0.11433538201498498, -0.9521797960175353, 1.1291529459974674, -1.1652050923817505, -1.2906299405196466, 1.2439392345479148, -0.876429375080649, -0.8081956309016018, -2.793796725580084, 0.31516776885991715, -3.9547237642662845, -0.9781584192950679, -3.2059045934895507, -0.6535540103236174, -1.8922796781627476, -2.4945999417413103, -0.6392680828183258, -1.3125731383895136, -2.4100295399657425, -0.33825527796642946, -1.711190095727466, -2.0082519170372195, 0.5059447240051985, -0.5300951643652355, -1.4521348793022562, -3.8668795860427285, -3.0518347496060794, -1.878069219059159, 0.5396653276544208, -2.011196519642157, -2.1056384754878246},
    {2.3066093399954304, -0.016860064989822437, -4.854231411079421, 0.2003364269715118, -2.4685621409119407, -1.7626431605008257, -1.0280750857405252, -1.0685652769307383, -1.8473766393195188, -3.3499005568127798, 1.6558160976507177, -1.2691453620947675, 1.172940158418092, -3.0750381592457243, -0.6161737430594935, -2.428781342999684, -3.0686705042476525, -0.9802854380291673, -1.614066671447158, -1.7157256343382767, -1.002433480369108, -3.5931889420243137, -0.5875893517350148, -1.3404938894273695, -1.9151976690850603, -1.5767030317741038, -0.8283065030254253, -2.3856382424839078, -1.0560674923773943, 1.6617590456799192, -2.1138406909351803, -0.7141440566236866},
    {1.598543817820754, -0.05704674316487412, -2.241350281875529, -0.08254214618944447, -1.436195974045139, -1.7724315518133664, 0.44120686257210423, 0.2643194769544667, 0.2605487545301509, -0.5759871272203894, 0.8485296839197964, -2.1363030406636523, -1.4830485341201256, -1.9897459395308004, -0.6521666370549581, -2.235945925482856, -0.4255209991168822, 1.3423293657910376, -0.7127032965761754, -1.8522015839316655, 1.4782455783196258, -1.6656176477161224, -1.7927466150388682, -0.6525471227261485, 0.20805463245687705, -2.410182742406182, -2.251830939294049, 0.038154194062697905, -0.604532350960394, -0.7346867304298408, -1.1113385743312307, -0.24807667095388336},
    {2.5679314152806128, 0.029088951961054904, -2.4985987177825155, -0.9225908021390967, -3.8907635904408493, -1.2360318296964945, 0.4096854465558209, -2.284923745964425, -2.9899067192444395, -2.5347697735526924, 0.9069928163875465, -2.450596195635523, -1.5511375861730998, -2.06739891281988, 0.4817656309525213, -2.4228426267759136, -2.8803495843027593, 1.4173269087837221, -1.9796835333734601, -2.1202592117251413, -0.24935400436893573, -1.8682903178400547, -1.6402222186731923, -1.2426871713993248, -1.4775039417114937, -2.3261800454970727, -2.411859157556212, -1.2080389160779832, -0.6784160300256382, 1.237548108616991, -1.789343253435074, -2.690069472268344},
    {2.014996236026198, -1.2226802243860742, -2.9223643905864365, 1.880840029910677, -1.7426612297886264, -1.8290785344436022, -0.05400711758629049, -1.2271177046808681, -1.9092147340920036, -0.999911269120456, -0.22181067153761938, -2.540989546935072, -0.8089892009427914, -1.8190393716415758, -2.2575080570659685, -2.590153403903177, -1.6975940404194245, 0.5285814652347013, -1.5034088426182814, -3.0379185177259065, -0.12650937071139554, -2.6138340962487976, 0.1175723532210497, 0.5931884712279223, -2.8610871706555425, -1.3776499296411564, -2.044922944422649, -0.9835205783495768, -1.563279277109535, 2.604597269531504, -2.200837557386795, 1.722703933500173},
    {2.728153084201915, -0.34154102905319444, -2.088796666591143, -0.3881292963795036, -0.9903978968888343, -4.160451009391405, -0.4780844949112087, -2.4364106841249655, 0.34876500217934486, -0.8765383738857657, 1.467559850245135, -0.36229098830679063, -1.733395903567606, -1.486091857594734, 1.2167179317303267, -2.1310175069368387, -0.4122540115392611, 3.6946994685230354, 0.16422006311232068, -1.2254260950938052, 0.4173191655650684, -1.6207663327120798, -2.0073992614708738, 0.7122605741300005, -1.594252148156997, -4.567320956034776, -2.2580107225053085, -2.214964623192751, -1.3680737005440813, -0.30583134021306796, -2.2613541255018927, -1.256006163834126},
    {-0.358069413808729, -3.2768122698334183, -1.7638718959772905, 0.4677241359678894, -0.033971932704057906, -0.6658569420517281, -1.7150806600961952, -0.6941539631721236, -0.5670914223474665, 2.107926543383785, -0.7837626120268143, 0.5733778591440798, 0.12645582240021472, -0.6884319517794463, -0.49513626978972214, -0.3089647933417851, -1.8429763452292365, 2.378427654070372, -1.3338542077538316, 0.36095544234233073, -0.16151621528278673, 0.13212654635223614, 0.49973968961045556, 0.4944398036108199, -0.3806816776616329, -1.0748105716211476, -0.5452079792949072, 0.4122487522951585, -0.39314075739132515, 1.5740393245327526, -0.9006175533149744, -0.4625148347153532},
    {2.591597999721141, 0.06318173507484848, -0.05243476126425218, 1.6219551580362457, 2.686435990061252, -1.0759947313807663, 0.8713433562897785, 4.046074022463478, 2.5088481111333385, 0.560069470414816, 0.3181311595044312, 2.696315439545713, 0.6753779412334858, -1.2044147318041805, -0.2531856659212358, 1.0361228558412732, -1.2023673110437545, 3.662964911446851, 2.532779787859376, 0.46026764216796, 2.9781583423552496, 0.08273640252731156, 1.9199144995749464, 2.641340268964063, -0.8990663664385424, -1.2512419403620105, -0.6635948235640668, 1.9417008530658098, -0.5197259559521697, 2.349436876317939, 0.91684740288091, -0.6282131733400013},
    {-1.3463889974079593, -1.7667538461603607, 0.7580470020315188, 1.7507075037661108, 2.6614180594373487, -0.45186185983022764, -0.5726411725038525, 2.4988376288650507, -0.8779062172881081, -1.8295300196211604, -0.6249662573245508, -1.8298880021415629, 2.844707568497456, -1.6874777692485352, 0.3306880888992391, 0.7269023526823984, -2.2687316239783, 1.718531996320594, 1.0738200690438877, -1.4928308052313328, 2.0665991487249187, -3.465624600898242, 0.8386958060274701, -0.35668878180271285, -3.1897350448208157, 1.760536727502623, 0.020897569412583257, -0.0558922936777572, -0.46107562553505715, 0.8848245204207272, -0.19652041272998405, 0.03542719810154376},
    {0.06120112791827276, -2.250451341331526, -0.11389070484071619, 5.501225206074481, 3.8852869341198337, -0.5740747350462541, 0.7698104582732469, 2.486547499087424, 2.272403400303519, 1.2777425810048195, -1.9768407088361326, 0.5103042330089773, 2.9806670525177186, -0.42706894074165064, 0.5055144716098281, -0.3773549431575252, -3.2088309966356183, 1.742597834263856, 2.245022746514992, -3.2546342538343005, -0.7671171781445554, -0.8500073498289247, 3.829423121920364, -0.32479676078639236, -0.7044476467838104, -2.663941310335961, 0.2960705856148594, 2.5975705274509373, -1.2701041237393031, 3.626524898470123, -3.387498968916564, -0.5832582959837193},
    {1.692628714019096, -2.6456493382143935, 0.9434938202717837, 3.559013463534783, 1.2572833960881873, -1.0529807265965658, -0.41590185503370175, 1.0579503244284012, 1.492862411756922, -0.26837287870963733, -3.330018452128353, -0.030268414398548833, 0.6807751883165579, -0.6174167368738673, -1.067752707305707, 0.48997840262502385, -1.6151713567171668, -0.006726303263333795, 2.0909940231683293, 0.2808367186835126, 1.6529527388966987, -1.2431714550722464, 1.1635181862206798, -0.3229663257440584, -3.6850379473455646, -1.3022871493739645, 0.4620419710946658, 1.777355091376886, -3.783225667855281, 2.8651834093253794, -2.7002399783570015, 1.351342507900937},
    {3.0701034346441007, -0.049259547212844985, 1.5087977975827038, 2.719076353223067, 1.967904590085643, -2.825864878982051, 0.7902973617297603, 3.362611557941319, 0.8216313974309887, -1.39635913198444, -0.7335153233280848, 2.1249691336404193, -0.8840270261063724, 0.09857794900606534, -0.33565342525299774, -1.655169833736764, -3.2994211336256196, -0.6942175792026583, 1.60253070230438, -4.313024960657382, 3.3642146036525826, -2.085122644252923, 2.223480816882505, 0.12813502552051279, 0.32320426476114017, -1.5015354730653643, 1.1109483774169493, 2.4278888026483134, -1.222756004361691, 6.0153712190422794, -0.07111314223446558, -1.9376974903080488},
    {1.7232256768368455, -2.902917720325872, 0.684041161268782, 2.531907393690896, 0.7811614174639752, -2.5458148386007395, -0.4612811482510196, 2.045549779919198, 0.3175191460930196, 1.5204917476892554, -1.9866897086402082, 1.075769166154918, -1.252035622817955, -0.394178776686119, 0.7785022655075533, 0.18409951535697852, -2.335027546912708, -0.7102375135342653, 0.21943718091310718, -2.234384177579908, 1.8087332343083036, -1.0239366189208152, 1.2087547037913702, 1.1168393817734328, -2.6266292257093022, -2.4294749690874937, 0.5305849338070042, 1.5753536693098382, -2.827327507545314, 3.612062754328967, 0.12821762576498164, 2.3123122433934684},
    {0.2985887172438709, -2.6191299893205793, 2.217504644304685, 2.8323421529831037, 1.4226307303394412, -1.835364701327121, 0.5164825568594251, 0.9443749270486149, 0.8594472211027826, -0.3353713561662125, -3.3488421921016838, 0.6869265534941499, 0.7868507061075329, 1.4102323905813285, -0.8281970187491567, -1.9148651706996944, -1.6632494383039427, -0.2687650386467888, 0.19389893796612784, -0.8790298045996884, 0.4517735029725493, 0.06714600937389527, 1.2228540689118639, -0.05190711023662416, -1.5368440718559242, 1.2903191171615824, -1.2852831429455374, 2.8431007097390952, -2.3076726530731446, 3.774061744527664, 1.2343212041843628, 0.541731835339698},
    {0.14646611616519842, -1.8685681272289878, 0.4724257171107842, 1.6567583308148564, 3.0570312661523498, -1.2512519182055097, -0.0901606245989268, 2.127922848118464, -0.1638023620899089, 0.6082371262054154, -1.538821727951873, 1.1190444867416744, 0.2808892754316395, -0.35254510408473044, -0.12120781747645953, -3.7749206630302665, -1.824612342388442, 1.436884626033834, 0.7773942011112429, -1.0270721385076258, 1.9331931880625748, -0.7436253800370302, 1.5753025447445752, -1.7675327994969234, 0.5207031018528759, 0.7487982433764564, -2.6602389288464936, 4.229119385229984, -0.967286173437824, 2.495817250487766, -1.221202302953307, 1.1829333882586257},
    {2.229567781054368, -0.19226110308626448, 1.6679112311203574, 1.6434795655092824, 3.002920085270122, -2.167853125431881, 1.3051536513967221, 3.463928878327398, -1.962582640340408, 2.3715495859888116, -2.7933549121423416, 0.6333283326776442, 0.7073915544478091, -0.08000758821887102, 0.7809699616983493, -1.935457878964083, -1.0953735972078853, 0.3320911500581665, 0.6195827658459432, -1.1549923653179894, 1.9631638863538414, -1.3435444004513832, 2.156200665884287, -0.12063706898683238, -2.41022405755151, -1.2533087310116393, -0.23709807533663818, 2.469143212127243, -1.0755625208827393, 1.013379477670288, 0.14948569209932894, -0.8756515053244847},
    {2.7068298949897813, -0.8845159472666438, -0.2786937752075578, 4.563744986808474, 3.1610786527585972, 1.0133210583147134, -1.3524619513892957, 0.3951220268229805, -2.2540394070058336, -0.5446519677092636, -2.755152847873706, 0.44788086585747977, -1.2595739219832442, 1.145855263763184, -0.8458407887355012, -2.0853640597114307, -0.0748922458789417, 0.2263843105710686, 0.10225356996069852, -2.196377440407329, -0.2315643931269962, 0.8154289836672227, 2.923621618515458, -0.06013067160748764, -1.1019646768977274, -0.22322350999325247, -2.2507671274532113, 1.8695804286386426, -0.989193327991689, 0.5686758478546723, -1.4123699562094172, -1.255504381381592},
    {2.1951465534285264, -2.1432590186027345, 1.1502930548014982, 0.35856391978371355, 1.8112074075321878, -0.04474156334899633, -1.1077920598589104, 0.7395019908518972, -0.8211951341211502, 0.8001384876037216, -4.476319296906284, 1.6051487574738155, -0.5328234170363267, 1.5801922984193153, 1.9824457651398792, 1.9227128347519715, -2.2398979482683345, 1.3726623380442213, 2.1462533580072134, -0.528415807611151, 1.4041792241668705, -0.7153898915475175, 1.805845837046393, 1.6982628528188828, -2.756780933141062, -1.6087920331574967, -0.23770750711894248, 4.203470795191092, -1.7270871276436168, 1.3816888598390649, -1.7589970938365824, -0.6978233102793631},
    {2.67248704019286, -1.93870166787865, -1.0828861790254622, 2.1857648699710412, -0.5933702819305837, -3.589871090243337, -1.2769262359342262, -0.39504928214512164, -0.7727936354518515, -0.6357488056639562, -4.92809609292858, 1.966482291435583, -0.1893916177268944, 0.7146734460799108, -1.6085607201367198, -1.7666529920562153, -3.799344599492048, 0.6121089522774461, 0.09272838548981234, -3.3304327647616816, -0.1474071347838515, -0.6139469170080445, 0.9021683608206863, 2.1539782696727774, -1.3201914133715076, -1.0762571179772873, -1.5828347124000433, 2.119665585910722, -1.116561723510041, 3.8287096144298376, -1.031451747527067, -1.0407298487905687},
    {0.5872766909981516, -0.8852716505072422, -0.23652289052242467, 1.0936348906007742, 0.23111276116246765, -4.058911193348282, -2.422341922357502, -0.5620344881300117, -0.6324503423037251, -1.1647554835464753, -2.751561602435576, 1.0965316945176187, -1.6275318161865935, -0.5523323110812418, 2.980358999001039, -2.0349076080481465, -1.877621637478596, 0.6892771415091185, 0.7662109069398642, 0.36264174969466806, -1.4015408432722425, -0.5257595932065792, 0.9219512514482243, 0.22492692970404016, -0.7909003511142841, -1.209394751661971, -1.61405185304164, 2.008805037225155, -1.439443068333983, 0.17967595065920686, 0.40322562633141557, 0.017248953338171186},
    {0.12569800986624205, -0.5070750553782767, 2.331354214576733, 2.410788601767364, 2.219902068462278, -3.249446521099786, -0.3634894673911037, -0.45698243465339783, -1.5893467699284098, 0.21686703679532604, -2.395656112193988, 1.5450731910905111, 0.7828509687855499, 0.9602686578937698, 1.2201297924527963, -0.06033815437400171, -2.3295436877913938, 1.4536641244009614, 0.027645171208962153, -1.3833138678655192, 0.02104737883922178, 0.08191465208097723, 2.135387016385545, 2.42882421821509, -1.6602009745332946, -2.651143304841522, -1.085273516610562, 1.3651939889631612, 2.0703695569720355, 4.125948663626508, -2.096941849279255, -0.28856496737973836},
    {-0.7981957910440702, 1.2154198926220752, 0.7169532465412705, 1.5550429017511507, 2.387003402411607, -0.9040916577722568, -1.679678574874438, 0.5840639439545107, 1.7834420932598516, -1.9982862474343217, -3.6563779319930765, 1.2456789921162321, 0.36799578119937254, 0.25321857501714307, -0.41780633581290944, 0.29332374163621094, -1.0122465206093654, 0.8598898187734685, 1.4855103143366486, -1.9817484416495463, 1.562658903158226, 1.2224534941165641, 1.2044232640100088, 0.3934308791969467, -3.4553625607251446, -0.9009476712511207, -1.2868698786866595, 0.36623076143105787, -0.8020146189924786, 2.1271128525635605, -2.120106597929939, -1.1800650194566227},
    {1.6348986122413507, -0.6729312421712732, -0.06432154140853093, 2.886195229239948, 2.8614528454733175, 0.38459345232262426, -1.1543435213246707, 0.14307309264863205, -0.6213836715454081, -0.1746914200331553, -1.7457113035390432, 1.2038720220722445, -0.5067210806999124, 0.29376236961335744, -2.567650847498871, -0.26191413367974004, -1.6527150105569306, 3.211733900148252, 0.08300192944515299, -1.0648758914544054, 0.9883734396814274, 0.9808663385131623, -0.20582632872553974, 1.91109778323169, -2.404656045143067, 0.833060819223433, -2.062034803010812, 1.5164614649202393, 2.897319612463852, 2.6527223840098477, -2.980873277255284, -1.6369965651104499},
    {1.906103932330122, 0.48286941789495347, 1.258138714180273, 4.629160929563064, 3.5405463339276237, -0.06388285244102622, 1.3991996739262915, 1.6780829556592112, -1.8890466288252343, -1.262485113483007, -1.9721177211125243, 0.17930208182279259, -0.4730792482124937, -0.08068880041435099, -1.1960030773870194, -0.8238860745314699, -0.4614831746085959, 2.870145832328454, 1.4587420213761124, -0.8781613036189394, 0.1938925323509443, -0.01910619290267376, -1.589178793263478, 0.42159260202760823, -0.6349697752598339, 1.351350248878338, -1.2352296774125617, 3.205910758596235, 0.3140993055010491, 2.336847020220116, -1.754639540744164, -1.3402889368698574},
    {-0.2094040558283503, -0.6539040375012543, 1.357199434859484, 4.56458856451775, 4.1775676605598555, -0.31008897995294327, -0.11183605830252687, 0.30155006433067244, -0.6335208120307528, 0.6364490718263114, -3.126092442911904, 0.837652024916129, -1.1081556835908046, -0.9464638052063166, 1.376878228768555, -1.0080656397467236, -2.4400757586130664, 2.170592856673301, 0.5847150453189777, -2.4200069061792755, -0.144226716318702, -0.21090935568636515, -1.5202764297629714, 0.25617260642819034, -3.002947058130635, -0.11275589839983843, -0.12285912300800764, 0.7552689563619918, 1.067527811052378, -0.21998932452441688, -3.176695361692753, -2.0134979648394746},
    {-0.29556378887437285, 0.06372609123345571, 1.4773308856288714, 2.4730173254319054, 0.7140211203469722, -0.9264878806793686, -1.675103189184824, 1.1495523063375683, -1.0220907450476622, 1.1964476795173615, -0.8955486477570073, -0.28563791154590057, -1.2962220947541785, 0.17830107276945675, 1.5314758362293814, -0.16333178840637713, -2.160322817288615, 2.097229436786056, -0.7517902679161735, -4.104515127654665, 0.8522338987142409, 1.025989724119988, 0.5939463223041738, 1.03724829144132, -1.0055600605667063, 1.0788443845410003, -0.29795958244065013, 2.384094358427472, -0.17262263897600982, 1.301056472270899, -0.868301459944385, -1.1246456860201695},
    {0.21892334644608177, -0.3496133571785553, 1.5843231827875757, 3.7925408247795493, 5.820920823300179, -1.206029196946175, -1.4628827976816976, 0.7155333225004545, -2.0886005414664686, -0.03926266496887436, -2.436532584057627, 0.05017715186661125, 0.051466743303455964, 0.9229833992818662, 0.40938257086928614, -1.5070143494231585, -1.5123589668999982, -0.8574161022634781, 1.8984472394288325, -3.2702433748685795, 0.8733720112276459, -1.1320243227061055, 0.8473028087580322, -0.28090957276024553, 1.180271190406049, -0.9288194140488666, 1.222223975685575, 1.068819818052685, -0.5444119236760673, 1.0319826502721483, 0.008589441530224371, -1.638657733947009},
    {-0.919806196030108, 0.38663592713810685, 0.8608622333884495, 3.3300035500756717, 4.5932417313713305, -0.7910595168291655, -1.1769850987098247, 0.8100025683630669, -0.5729187782292806, 2.1199287966098677, -3.9352496519791207, 2.382893266163517, -0.5866901549728476, -0.3585001970123001, 0.015554930122348827, -0.6472458187263547, -1.1051671231485347, -1.824390301815819, 2.579645486398495, -1.178532190888305, 2.767012550584995, 0.13994142362350911, 2.7616573362698826, -1.9896158141876268, -3.5783743352984616, -1.899013694694168, -2.302876636613322, 3.6529160066223634, 0.6611474515052275, 1.2707664120408846, -0.3866792307643885, -1.733781987828663},
    {-0.8355646301801418, -1.1859688901403613, 1.5922361471892998, 2.7991604969660915, 2.7330152598418143, -1.0137512400368742, -0.7195960705453448, 2.950559536132076, -1.3639888681665924, -1.0167632749040922, -2.1276541008861822, 0.1845688084421802, 0.9280855209691856, 0.32257690524212146, -0.25695818519063224, -0.648908429359714, -2.053351882837702, -2.3166685264839417, 3.3533054985498514, -1.2501031671703788, 2.877670461845531, 0.23619603250443774, -0.47624094516388177, 0.5330655523817667, -1.2591252454641708, -0.685331737325486, -0.08497394074963963, 2.137076732440617, -1.949388966842826, 2.095400890933982, -1.3605563530302658, -0.6684797174557555},
    {0.9687096057820149, -1.2981394013027607, 2.6199018752763177, 0.8069421699111843, 1.5737288392457323, -2.145478288595534, 0.1269570734953382, 1.331386651121567, 0.3679768043358063, -0.7841484587169657, -1.8604250981176023, -0.7378305247874638, 0.439525443794022, 0.8936035116066056, 1.8045619579898324, -1.4578956113309434, -0.6684049044358088, -0.057250979117181175, 2.1773241329263047, -0.07571940304711769, 2.4447579164866187, 0.04254747012413521, 1.4033813412261968, -0.24124959542483873, -0.8052029496839423, -1.1850064443454877, -1.503952401555319, 1.0167663290108009, 0.5496984127033081, 3.5574343421343295, -3.3373470160196743, 0.2671185372603085},
    {1.2527753253991456, -0.35755814015335835, 2.9512897606371453, 2.5446143419360245, 1.4685236501735122, -2.0253353321776317, -0.23937558870746428, 1.0376588709093244, -1.0765220341961432, 0.055180895107943, -4.075699665108859, -0.23093931320078898, 0.5477715420922415, 0.18512651551253714, 3.1387878958471935, -2.041080426370124, -1.5808599562945482, 0.8226090701940849, 0.32105328431171437, -2.0717797278529173, 1.6633210971685282, -2.405235702350795, -0.5184745196560618, 0.23095918979155966, -4.370566602668279, -1.7752829103514307, -2.0364877143357507, 2.725740188722716, -1.4450102629854367, 2.9695565988967716, -0.3483249759436411, -0.40794931397115647},
    {2.3163604920175183, -1.95376291141145, 0.2252890882327408, 4.209877111214323, 3.5809010505531345, -2.7753097713679855, -0.0699229622833035, -0.9431430337452449, 0.2958235509788411, -1.5590279568106853, -3.1755877195288384, -0.14114349022964068, 1.5652110435600277, -0.7657179917435082, 1.5037788420460738, -2.2468805842055457, -2.8057489050476714, 0.5914070458081403, 2.1972430688603564, -0.42660937844628, 1.9373887861103833, -2.4765019823761456, 2.543946005153193, 1.2503816282979214, -2.388216390498342, -3.0667797225727598, -1.9168009338518035, 2.2510964458330847, 0.15131896053495678, 3.2173569390408203, -0.04250131582446311, -1.436800202562184},
    {0.11856754388783868, -1.573433188477387, 1.612279111971784, 3.7172272122935888, 0.9252106463969707, -1.3008245666766562, -1.8304750408343535, -0.07375573917826636, -1.7708165724172837, 0.5339693282140477, -3.0618807824565883, 1.3509406811130094, -1.7924290554437574, 1.4673679799201838, 0.9744695612376503, -0.21100141680807302, -4.656746098811291, 1.459645312548729, 1.3388355354008368, -0.5403896802594139, 1.6394246205631173, 0.4674441679119461, 2.421806424199397, 1.756247552936897, -4.054733954519455, -1.1085464451320608, -0.8964113106192747, -0.5315389109328177, 0.24954527984573588, 3.344780556094835, -1.1486598348487767, -1.6822194727632473},
    {0.4739114179131848, -1.861201814604189, 0.7758466423910255, -0.1135563549291636, 4.406208621587814, -4.8097140623511345, -1.7889256166598972, -0.7730688033208828, -0.826261090097671, -0.1853130042696317, -2.4883443634942597, 0.8823257438726483, 0.5098111017487046, -1.0084937763563686, 1.8541976313806705, -4.852100136414383, -3.938603682039495, 1.9301690779434162, 0.9661399504152816, -0.7490504604733842, 2.611921438011678, -0.2765337874996915, -0.21656692649233583, 1.8928368796599333, -3.170544803860856, -1.001848859079087, -4.8250924442553345, -0.5387647733218638, -1.1413528651006042, 2.4756541080922485, -2.612620728139771, -2.534834497032138},
    {0.04217228025137608, -1.009230473152705, 0.8131158306647894, 2.8029279870861044, 3.216280818918013, -2.812891637440821, -2.3971665535182303, 1.5465039076908556, -2.6635218444204707, -0.5712756300522494, -2.326283242556999, -0.3070589389504599, -1.388927313349797, -2.2574936252287814, 0.8727885148225607, -0.6607157426100164, -1.4706221177091798, 0.3848975069843989, 0.6659608684104297, -2.2026149926295626, 2.2380130728042835, -1.5252485187648743, 0.48127428567620273, 2.2799675267769643, -2.7778489683046583, -0.9649795292443354, -0.9192920783462133, 3.5516723016797944, -1.8506756712974095, 1.1615139650267883, -4.1814649409351645, -0.6541076468096176},
    {2.6171456068583145, 0.3673420828033589, 0.4862310844879599, 2.362193273075402, 3.842802653026307, -5.157977447209053, 0.4894734918932548, 2.2818159651205914, -0.7925402968911482, -3.091312408351408, -1.6054206393813255, 2.0284207797858906, -1.6404468915489274, 0.04298530682475584, -0.3209237540707208, -2.6693285376018836, -2.841913432716106, 1.2020853977480634, 1.403262072955323, -2.0259459911464397, 2.183634912766759, -0.586339148846386, 0.7572598170132508, -0.5014886025149587, -0.19511293315687395, 1.5771175598475948, -1.4694957139232172, 3.1998097944246386, -0.25272941750555666, 1.6517232483961275, -1.4097893376285588, 0.42327247392368245},
    {1.187090560217587, -2.8698279082570943, -1.9340339717548194, -1.0137586743238078, 0.11732939438702403, 0.030068337124207655, -1.48830633005811, 1.4413763824399048, -1.9380145752164577, -3.4436099812206575, 0.6000508894703998, -0.3147445341777103, 3.3970882194113754, -0.8054686490844444, -0.5155857248981721, 1.9065678913062019, -0.6051851153200374, 1.3702805723761395, 0.9331253250814345, -0.02966723740230286, -0.7043473532717196, -2.9787606024775912, -0.11960843925598433, -0.7087137492351778, 0.322305796463783, -4.306538759520447, -1.8201284400945474, 0.42198752611109475, 0.9394573967374084, -1.5776630336898843, 2.6786598057902484, -0.545694798590449},
    {0.848609470167001, 0.7710967953189821, -0.7341544122264173, -0.7679974881209549, -1.2242049320712423, 2.028681479216987, 0.8391319560246117, -1.8431812499203082, 2.8762737948409773, -0.8866319161008772, -0.49957030436744376, 0.35225571519178955, 1.4692991123635446, 0.055470380527905865, 0.5870950345253327, -1.2370358765175904, -1.0300589678067067, 0.4577946067212451, -1.8743130380791604, -1.3108027202394088, 1.4050219902114023, 1.4255212126627907, 0.9065668326639361, -1.3829433213332667, -0.48847894595484853, -1.5088189440296773, -1.0963302980641985, 1.6029498924274357, -0.9165378583012118, -0.25264002352422094, -1.4989772488339503, -0.9141449833191497},
    {0.034855745948978396, -0.7857446356192685, -5.653434148997401, 0.813103794625363, -3.113241920371116, -2.0417636168212554, -0.5785234709030749, -0.5595569635353373, 0.5579415443850938, -0.7296015068267422, -1.5308355480989932, -1.1420314917122887, 0.07680355433134148, -0.7719610534562666, -3.189888286368114, -0.3618884345117651, -1.1246055796089547, 0.07335009488032701, -2.354326044544228, -0.25448683109629455, 0.8347599378988934, -3.1969237928070307, -0.7717306197007879, 1.4190684759536942, -0.5449903414421807, -1.1996499787886707, 0.9237285683416355, -3.0939959319160697, -0.7330342538580906, -0.18118446932366344, 1.8868763927861474, 1.2239083566903204},
    {-0.7133503198320119, 2.9979365513699046, -2.2105138741337083, 0.44472280617523147, -2.343398071526643, -1.6424439688640933, -1.6195931201734444, -1.878240250887068, -1.701772176864162, -1.7462434999793526, -0.726980411678268, -2.207895048325678, -0.9717679935525922, -0.057498784401024294, -1.7581592848681622, 0.2962826974293991, -3.2337600204937296, 0.1416311827761325, 2.0236385503134113, -2.2875128488156777, 0.0030605011180727436, -0.1930398812676755, -1.066717999331427, -1.1044409894163016, 0.07133018826256524, -0.37185660784345576, 0.45986748849242637, 1.6972639360053858, -0.41980342416227356, 1.1332458933576361, -0.05890934502942126, -0.4664380361064694},
    {1.3367526272720895, 0.7175110157826481, -3.6681445646201776, -0.7188169794650933, -0.2158993595949622, -3.82955955296253, 1.004152200196989, -0.32639421682239367, 1.4906017164116891, -0.5090296073582552, -1.5360434105456944, -2.4871917365629903, -0.4644029162397419, -2.8398829937792134, -3.584375377524011, 0.2097444498621143, -1.6765487777799724, 2.182426032615543, 0.3590246050387822, -1.0111165518792562, 2.704383650250275, -0.48159887460215717, -0.980523795422689, 1.1400884847393968, -1.4088776580053008, 0.7879689367678364, 1.3449902089607857, -0.4254690602372281, -1.3076320806926676, 1.7789221141794147, -1.536534745030895, -1.1166180166806179},
    {0.09137200514622544, 2.357582850623486, -1.3973207068572473, -1.3102350823536446, -2.6545807375872346, -3.591701949709029, 1.726212143568664, 0.13051895660316437, 1.4529373911173675, -1.1014521728192166, 0.7739032670251993, -1.2726560452438065, -0.5223269204907788, 0.6216372954915413, -1.5651802721594175, -1.980331718421933, -2.2165432970163668, -0.26228588901601185, -2.2113316882765814, -1.2715739208677088, 1.8090379169387394, -1.8914335938966933, -1.0408814180217092, -1.353850955639722, -1.8638513550454365, 0.3242670358707687, -2.974476715109127, -1.991711431581435, -2.6790654581928517, -1.0149536363875713, -2.2442127874725943, -1.175928621322302},
    {-0.9542060488323394, 0.14474172418105707, -1.814953922657609, -0.9652392806310194, -1.442883987105739, -0.2781972050940713, -1.6198731775454402, -1.8608236596862033, -0.6142915603076082, -1.329107081548156, 2.151261971723028, -1.3593603581847098, -0.28377900231983877, -0.8859465436477991, -0.8593448590541811, -1.5632109298782044, 1.1370769409805452, -0.9100918762085914, -2.5176956518913944, -1.9082752172637725, -1.443663629906307, -1.1730349711827575, -2.0971021702492165, -3.8385347526504283, -0.17770494689506056, -3.320443495774517, -2.4639044185958316, -1.0014456825629183, -3.0782945048863897, -0.9171166742384239, -0.7128354131638894, -2.4621557897412956},
    {-3.1664895807533946, 0.19387650617676827, -0.501159793165391, -1.6232204232057856, -1.870763074207906, -1.4996721751068336, -0.7110570781196489, -1.561763591163621, -0.057100519454612426, 2.3110295630837414, -0.19782160018984352, 0.1357309245037329, -0.2552663445142485, -0.026498272136301654, -0.6878783767738391, 1.0339837293428518, -0.3445402185262159, -0.1737589743388028, 0.19207153284312525, -0.3964232800051222, 1.123846405324826, -1.3539335414363625, -0.8875506797529925, 0.521005259363747, -0.9576167551931067, -1.1252372432288102, 0.21708177694675374, -1.8927530591595612, 0.4263993323174459, -0.24914311482416318, -4.261190129537713, 1.058132911742322},
    {-0.11304132704214918, 0.03526847795249787, 0.1648502925310569, 0.17977008185044993, -1.8495897932130223, 0.7126647840960021, -0.47883986633732195, -1.5766497074422596, -2.1979459621260418, 0.9424152022304582, -0.04407301202195931, -1.6528986967406023, 1.1089745267911575, -3.180973750298806, 0.7799550587050295, -0.5780120136940269, -1.1012585366170513, -0.28836810328458373, -0.9513612173107894, -0.9968937917355265, 0.5717092542045171, -1.901406915090542, -1.0744318004196003, -0.18857609630009706, -0.9786624232209586, -2.1821161215340887, 1.0479801192390705, -0.3856061637423837, 1.397931385385816, -0.7981606807087352, -0.17413866297410382, 0.28183102524756215},
    {0.06696222214960888, -3.243819444050145, 0.5824841045028938, -1.2804945487080392, -0.0066566978227194954, 0.29776096694224086, -0.21604584047501738, -0.8895014962317491, -1.8508152738376382, -2.482182759363181, 2.047570031654689, 0.5339126271748944, -1.955290357938595, -1.2539342294846425, 1.3932501684689331, -2.5442074914532817, -2.2442738068231947, -1.2615309336842453, -1.7385112311947484, -3.194586935847813, -0.03644013588300824, -1.0823033754188047, 0.07245640544736229, 1.2362897740953132, -0.47954822633229016, 0.9419528521779189, -3.225462722124664, -0.23448820334970463, -1.8219463470053896, -0.34868701694236864, -2.055442135515175, -2.0928072065501926},
    {-2.0026619850485203, -1.9520665050398733, 1.4273797040801022, -0.9386800903372915, -1.634324507096379, 2.381950529313982, -2.145073810112767, -2.1431547038558643, -0.32192844190428377, -1.9711780120818, -0.293276583595993, -0.8799976789541436, -0.46524385175256816, -3.0162490658058414, -0.40502157738290256, -0.997454204578804, -0.48007444778981073, -2.6903670295945568, 0.8140665577392485, 0.250138027388603, -2.9127315673970853, -0.9797252450792253, 0.09429941216719648, -1.79244916806033, -1.6200345831058307, -1.3632714986250734, -1.2423150211812537, -0.2299763345441745, -2.9939460753742173, -2.682520513814038, 0.2392759227630044, -1.2228688617571302},
    {-1.065494911037348, -0.2886353341437399, 0.05910799184080242, 2.038567834472764, -0.8632075155838383, 0.6871098151079501, 0.24037146494940065, -2.0853745996599264, -2.9635578620799437, -1.0986487545920847, -1.0097287321482105, -4.166652181374289, 0.0006673515131803418, -2.514061082853646, 0.2613573446106199, -0.6247414203970671, -0.7011673882908631, -1.2974610792657595, -0.7806995432584082, -2.6126411743221984, -1.3071010870430986, -2.1286374479865446, -2.561203568649503, 0.27034373085408797, 0.4862638986793216, -1.118246915959373, -2.6385629536148723, -1.4476623432804376, -0.4843839322484382, -0.6880780080255132, 1.4615864999881618, 2.0421347497709883},
    {1.037663181098981, -1.12356698731637, -0.8466904890739921, 0.29811568693423407, 0.15477748325807894, -0.0641686651933251, -0.3869838312317185, -2.2161289802786976, 0.6260506639928076, -1.0592503400113724, -1.5763634237164024, -0.9244494488000985, -1.0571713129983402, -0.5344287798695139, -0.7819696936392498, -0.16628628274683824, -1.460872729088053, -0.22606406586725833, 0.37989556367033017, -1.5440398036743728, 0.7428129456486271, -1.6285968094318979, -0.35972103574787934, -1.277719536074272, 1.4340108774336566, -2.322115189028894, -0.5500965196113663, 0.20694688743527387, 0.02513231785722732, -2.2427869296351672, 0.09778725741701387, 0.9232431817166947},
    {1.4105899606458774, -0.7802523609432732, -1.9249515078382629, -0.1008800232515765, 0.6917620313311779, -1.5802586379767296, 1.0824871702025791, -1.3706743655068387, -0.7237092070190467, -0.3483107894245818, 1.2578905192999912, -1.25649870854607, -0.21830834058657908, -1.6269965524102112, -0.6036609305057808, 1.388689526864385, -2.9007877653159135, 1.5602273552213735, -3.5732118996376165, 1.2197715663010782, -0.05202672273552878, -0.6573400566120021, 0.2965678358045133, -1.1947572412843779, -1.0316701114853162, -2.571105000072674, -1.7870737400578267, -2.0304562791692207, 0.08194510921896886, -1.5849722319975679, 0.986363887739521, -1.1293988741716645},
    {1.3016613977765783, 0.05043861044360282, -1.1858530270725032, 0.8029364858722627, -0.7168527021925875, -2.2176355666170147, 0.14197173778561234, -1.0377539555747402, -0.3592651234720235, -2.368150914418434, -0.19134525360057356, -1.009170888673986, -2.734880842209474, -1.80910803959341, 1.6799176254097477, -1.2770673424832968, 0.323028160372131, 0.11749916909010437, -3.463419214086266, -1.6850757771463771, -1.631003847531746, -0.7612223034629587, -2.2520352860804227, -0.4077641333951331, -0.05953416874773963, -2.682366806787304, -3.369707096902761, -2.991140737357929, -1.695743938919381, 0.39290020300336687, -0.8253072648985903, -3.1521685553794767},
    {1.4584715647372755, -0.10253774625494361, 0.43761161972481993, -0.5425280896778447, -2.8748922153555934, -1.6045171116773969, -0.06749493898992708, -1.5845894379687266, -0.29340692633876847, 0.02660294354727839, -0.8264399414199776, -1.3672145544763172, 0.3034500567237794, -1.3927152353552419, -0.8210011758295638, -2.105277109048028, -1.5883399864498788, 2.012474534674905, -1.1188313419901457, -1.4732399971745769, 0.55295217051159, -2.1045429524625816, -0.5396870597977453, -0.6884347183279363, 0.6405765354356313, -1.2348634034160364, -1.7169170143610681, -0.41750962891729454, -2.3886770248277562, 1.6844270858493553, -3.5028400428208815, -1.3805378852740333},
    {0.7288426162012926, 1.5187599053480043, -3.1650418000889764, -1.8199288627506964, 0.36735280387803615, -1.0110697445534584, -2.2810500436475483, 0.23260707125076097, -3.900613352317242, -1.5590280831145704, -1.0563256787673059, -0.1710399549658058, -0.8743527361080061, -1.0074474008798706, 1.9137335118487944, -2.1485988916201686, -1.492930919082959, 1.3195475039703353, -1.0759717223699616, -1.143030844068777, -1.0796237129097401, -0.8548882049119905, -0.045470430926010344, -3.2230496489308487, 0.1740818760497232, -2.443435637807483, 0.998755617153901, -2.229680814795843, 1.2090342325859615, 0.08507349157786026, -1.849830856756184, 0.03168539735680403},
    {0.41444887455835694, 1.2832008933613968, -2.93333699266094, -0.41322522207093226, -3.0974994354141985, -2.7585748173551683, -0.6923816338622497, 0.02714572890507018, -2.070382118229992, -1.8837342685697192, 0.21652281199522225, -1.4806902212267383, -0.7680318923795909, -1.0733694550896415, 1.1615149159897569, -2.087882722684748, -3.5636486952239395, 0.8193203800900752, -0.07431200056216977, -2.5291166069540565, 2.576700342604622, -3.981704655818711, 0.15762878305185266, 0.016165176901962747, -3.437945216313987, -2.407120758550036, -1.004889296608789, -1.4895884767750047, -0.00013938755435526434, 0.157769771987801, -4.3463216106673785, -0.0808455048626019},
    {2.277483254050568, 4.141584346006028, -2.982387143445848, 0.029723948493337354, -1.9953477863181324, -2.545889240433549, -1.548106914972594, -1.3590428669301913, -2.6441008411627336, -1.2031592376214482, -0.4937597288151654, -1.2467838492035896, -0.8338898099071217, -0.71091637386238, 0.32766361896899615, -2.0379032122410226, -2.1769549285054275, 0.364850539808924, -2.2677118561593623, 0.8576022629639353, 0.18934202331322234, -3.150555754351617, -1.1977460832379465, -2.6037357326387878, -1.6988369137655401, 0.9390405091240498, 0.902240580439809, -0.23691954666087478, -2.0939444223770867, 0.20897847811566372, -0.4515438194673471, 0.9592093350032211},
    {2.0442177228035887, 1.799977728475959, -2.947629398554826, -0.37794293946107554, -0.6996410183657619, -2.2911860056804914, 0.3051358727826739, -1.0952724046568936, 0.5332632587787861, -1.3695542129837242, -0.5855174666168006, -3.428657447250459, -1.847478429200397, -2.5277567097446125, -0.32201301808877475, -2.6906426653810764, 2.420353452690018, -0.703266961941796, 1.135694562592422, -0.5626771435851333, 0.5453871803922347, -2.216198255776969, 1.199844757728669, -1.712260066007345, -2.020035783560253, -1.660984397634614, -0.517725599170884, 0.6803718526224815, 0.5601222580037307, 1.3868482389537582, -1.9827488747993345, 0.242309789693525},
    {0.6950611247692133, 1.5570463970074013, -1.3093777673527836, -1.782977224358672, -1.0850561176666487, -2.597712726275512, -1.1822294093168788, 1.8392234693846794, -0.20807972567316632, -6.281955717138661, 0.021396884884256152, -1.336659117640334, -0.6646025868415133, -1.147428738043341, 0.9857075175714537, -2.8497499767374492, -0.2587546839316607, 1.5502565356345266, 0.47106101201939654, -1.934024081066153, 0.6525418713429652, -1.2687386705283463, 0.4530284772768586, -1.2714827489662417, -1.3284787779690577, -0.6870184673977018, -0.24899965465112708, -3.4320572272265326, -0.6093461843829687, -0.1706564153108126, -0.5147295518228147, 1.0545869515817627},
    {0.3071962561761437, 1.5703034973129155, 1.2511440386072887, 0.8534169817388547, 1.7198415138739558, -3.011685084911489, -2.6399925722898123, 0.9944667855942263, -1.839958759646444, -4.036788527342961, -1.740698854716867, -0.4031967840403777, 1.4942406335748444, -1.4356238571047366, 0.12317994786570417, -1.8526152664198463, -1.0293541725462976, 2.9843980616711954, 0.8685788700135321, -0.7930240732527569, 1.5793038193549673, -0.43239869342369314, -0.18479250698436198, -0.870893389461846, -2.627572070468165, -2.393762624865477, 0.08361198018086181, -0.8192564516886806, 0.14041280071144316, 0.23560675130311742, -2.2685226908225915, -0.013666248310140332},
    {2.1659012830732625, 0.2846935125894593, -1.4494989623865697, 0.029664864956445672, -0.4455270293963005, -3.0809670305425203, -0.9184430984554875, -0.9230997923692926, -2.6394114017600923, -2.2621057698416127, -1.5984691013664676, -0.5787169426238322, 2.1949953881048208, -4.290428203643171, 2.0160697909948726, -2.6939085110034644, -3.415124707013314, 2.1124466118793372, 1.126775309528947, -1.4074259889461511, 0.7084812982757411, -1.8726978359898634, 1.053262125357368, 1.6471800465759325, 0.039920090691180785, -0.02615388290225328, 0.0663371607335544, -2.358888419109427, 0.5503990182387003, 2.245102697456133, -0.1743770245077056, -1.0991549807182472},
    {3.3376230629431847, 3.818736480346175, -2.4849627236195775, 0.3458800735422734, 0.8073610784876545, -3.684905810761877, -0.17830886589656222, -0.9455003450811296, -0.3088611632758626, -2.157042234806533, -0.7782165090221329, -2.0412025648247853, -0.8937833064975043, -4.531250162376427, 1.2525672641368957, -2.325022878765962, -2.253220186621816, 0.5218325453732358, -0.9999084622614827, -2.0016178681495833, 2.393392962870169, -0.6454195537283525, 0.11675316578634914, -1.3059045924134574, -1.0257551303212258, -2.439409563429335, -0.46306881139860756, -2.0540719162921026, -0.11093677937503053, 0.40255115710599365, -1.814524158675977, 0.35277497783813555},
    {-0.98166496341922, -1.657875373300941, -0.4323500316515543, 2.5138943618081706, -1.4642947963410027, -2.3011246711245055, 0.12228743749081765, -1.4334071366350654, -2.1836216797072447, -3.664391956006616, -0.6585647519256653, -2.861791836257516, -1.1848071221912813, -2.726040640084643, -1.190194301990623, -5.581010697315912, -2.6669518390088554, 2.9289730562389447, -1.1684171563928525, 0.8885874917879021, -1.4713312400924152, -1.5658056637402775, -0.6005681722180418, -0.9067878348659004, -0.9146669878952548, -3.845022861446664, -1.9059164056214712, -2.441585960472282, 0.1694101618547627, -0.5922097025912753, -2.151647346204196, 1.1913044243600552},
    {1.1650929063218358, 0.0008861231832371992, -2.7339285094516175, 0.9647546969572847, -0.7053882875857935, -2.8947067942705162, -0.759920510253519, -1.0748105773476069, -2.4069756414729984, -3.650458103973132, -0.4624281643217161, 0.36188787984835535, -0.0802598077315814, -4.819569696076811, 2.394794514517478, -3.8326017222038153, -3.386971571458794, 2.411154904583141, -0.49975708371085475, -0.6018459840896075, 0.9467418093924881, -2.6959408175224286, 0.17178701441744, -1.0964873805767865, 0.04865178038071906, -3.693901334690516, -1.927223859962711, -0.9115623657742165, 3.3905918625987725, -0.33951509049057715, -1.594173398375623, -1.6052272793569555},
    {1.659823782035755, 0.4829134269991744, -3.433547153855228, 1.3158269016304522, -2.361256444303617, -1.9004168838563125, -1.1976462814173645, 0.8162455319577456, -3.6672913125933886, -2.7661418625430465, -1.811287289885871, -0.39277911394456005, 1.3665821291373696, -2.208337533779143, 1.011029172713847, -2.48412077892628, -1.3944719236468812, 1.5949109421588457, 1.3497682497188166, -2.757102168076051, 0.8097582786633764, -2.0590892996104255, -0.192055514046828, -2.006255047363654, -1.4376503421424605, -1.6052051300757093, -2.2530674788599105, -1.6913038799215998, 0.010379202855048626, 0.8413604447270322, -0.3425473100183279, -0.6833574797411421},
    {3.093754221400077, 0.23415771194146734, -5.125575959328974, -0.5850002261241282, -2.0530156486127407, -2.922445992053391, -1.1275575144616155, -0.7108246466506686, -1.225615013427196, -2.08193090519583, -1.0083992053892474, -1.1007072452832898, -1.4100661212036778, -3.235499008111114, 1.5443857308903957, -4.942542529852219, -0.48451092848449534, 1.9705077255365617, -0.6086734530572692, -1.33731433352005, 0.11826804171729513, -1.8331140911277375, 0.2354699924538403, -0.02174938558672833, -1.4616628372722698, -4.908719888363293, -1.5094772787596171, -1.7618381027218335, -2.256437197268779, -1.0093334855889968, -3.791506956364546, 0.6694242326916546},
    {2.5536556094421683, -1.029150213900561, -3.3882229846938294, -0.01658268303625168, -0.6105545202659866, -3.2395796449472596, -2.4476620306558843, 0.07925356780545562, -4.375724388648416, -3.171081721857726, -1.345848201914261, -1.5756637775151492, 0.05134007514787234, -3.587480921350886, 0.14445725384637062, -3.7017530825534117, -1.1304543072009112, 0.8863644857196216, 0.4310050175014345, -3.431514505416301, 1.8718583007682474, -3.5754523277086845, -0.05648864732493385, -0.4451353744989352, -1.9823059593347425, -2.4120580118946604, -0.17171825975627258, 1.7093947325458205, 1.1187429765621135, 0.35640785109356876, -0.7078697729152212, -0.6870638454867034},
    {4.519769645410934, 0.40606097661388846, -1.486676072070212, 1.5447044145328865, -0.9052587253300304, -3.1480114347225108, -2.8246465468572644, 1.5763185734311163, -3.5978373366559944, -4.778236898874946, -1.1351494898566723, 0.012056757975193125, -0.08010379470659275, -2.969911661007394, 1.1572107094228474, -4.4737530049842755, -0.47286583019224826, 3.3611766257433158, 0.10388377706781639, -1.6680565279797999, 0.49417788845128696, -2.2750325863625243, -0.9052853131943335, -0.12373262718904349, -0.49809092799776583, -1.6634939200827368, -0.7469194428014178, -0.116079017301327, 1.3275511421629023, 0.9096192918904851, -3.0479179650237507, 0.011598516667796646}
};

static const float b1[32] = {5.438391665065835, 5.648525057104181, 6.324103071932334, 5.989448730136739, 6.059439743867727, 6.293759010512491, 4.554203869664926, 5.874054393894653, 5.058362311525449, 5.9808578495752265, 5.845712378503029, 6.152225993403537, 5.722688830722134, 6.218715058673265, 5.761020141714266, 5.522890534842476, 5.630897226408519, 5.066864928690961, 6.087937639554407, 5.736381587650504, 4.682819018350085, 4.57582048685941, 6.048190800973111, 5.1563378263107715, 4.17888811641796, 6.097596272633809, 5.061347864245488, 5.7512529983591545, 4.934550743409461, 5.8247555183466915, 5.433261021493757, 5.793092497469541};

static const float w2[32][16] = {
    {3.3001609018191624, 3.606460699488132, 3.562635686190439, 1.4334968247563766, 3.7947205116291736, 0.66024827280854, -0.8416936904367839, 4.889654084205177, -1.4755255478016318, 3.7511842393480843, 3.685439736128947, -0.6677580712805116, -0.6015134235715873, 1.4851798827234037, 4.3599193929938025, 4.806648043083102},
    {5.329002051582958, 4.078617838561627, 2.4491979546298066, 0.7654024514807399, 2.1613989631544124, -0.19803990379418085, -0.8370642542605025, 2.95183578851638, 0.4182543876398421, 3.64531510239424, 3.2627638811549535, 1.6203317478443697, 0.17338397439422507, 4.000042761933394, 2.6921606264714737, 5.51092038322811},
    {5.427164022771509, 5.615610183235324, 5.674747112980934, 2.3997062412294334, 3.184281634225479, -0.5188397450926893, -1.6712986035505013, 4.946641158911536, 0.38388412531334876, 6.822580510881195, 4.160129002080472, 0.7283410106644759, 0.7005840037474822, 5.472012298000144, 4.919571110925334, 5.398067983284927},
    {4.53808333599519, 5.331545619994806, 3.9609241606921066, 1.4378757035227814, 2.06339864567885, -1.475274058308085, -0.5504200525867495, 5.460510151360815, -1.5337037796538737, 5.252794679061176, 4.038703076109752, -1.4507663429149726, 0.3115280244484449, 4.258595564199392, 3.5503497807290927, 3.6496366970739267},
    {4.344413164884785, 5.7083420500136155, 3.4143924951782294, 1.5906305017191806, 2.6695306482783576, 0.20518081533364357, -0.6052125289792263, 4.4771818984349405, -0.07490823066725362, 4.416783835525069, 4.387052450563264, -0.126191899431276, -0.6991496530653818, 3.8392874713781997, 4.803651327459041, 5.715140870425441},
    {5.434031965106463, 5.773601956232692, 4.798165070326338, 1.13741225778927, 3.692207763292889, -1.158874592168923, -0.33380020376982367, 4.280053688480653, -2.025023571020113, 6.3895840581730905, 2.5953087712810423, -0.6906546971110225, -0.27950744582779363, 2.8916487097796804, 5.338236393090835, 5.474961339190815},
    {1.6217530482661522, 4.098059683353317, 4.44133690661892, 1.975759037024095, 3.5435704751113475, 0.11666164967635376, 1.3934162945793782, 3.9037033170726567, 0.30138914889461343, 3.6663826104866004, 4.46138795659285, 0.11394343621526734, -1.590183110024278, 4.091128123249098, 2.1718807751263958, 2.802680341657816},
    {5.5355539629472315, 4.262909914174677, 6.253852735711289, -0.17087389943356074, 3.976125956567567, 0.1370717787276931, -0.8385036316772068, 5.424450042430641, -0.26740804728307677, 3.5705219631568825, 3.38763422359764, -1.8715129819975551, -0.2163834582574167, 3.8701146607042545, 3.4135604345086743, 5.961193114754674},
    {3.335284639505169, 5.172172058253103, 3.6049034771212365, 1.8081485199252931, 3.720227407036592, -1.1612002661333722, 0.4254649351859945, 4.136883522375867, 1.0780783702739165, 4.618569519182857, 2.6318226975384675, 0.8958428941804927, 0.26475761517196766, 3.098777046925555, 3.225319447274205, 4.197196028309234},
    {5.4457233584459654, 7.020724226404443, 2.9401783402952217, 0.5373639468366221, 3.8228811124023103, -0.9249096878023338, -0.49895003632155366, 4.293708568041213, -3.0160135820756344, 5.473776200311946, 3.3146737362726078, -0.09300050475610613, -0.9127166869689625, 4.867847272786601, 5.128066302221123, 3.3174879394107495},
    {5.528773038145886, 4.612980761629675, 3.815504725707767, 1.1128097925677811, 2.3467610261220835, -0.018867274514445215, -1.745136346247113, 4.543846480849988, -0.33063890719684813, 2.56716205933738, 3.2243886300013544, -0.9324553871657443, -0.054585101496567895, 3.1000888933811104, 3.932055930512572, 4.086376353226112},
    {6.633622478748358, 5.554331659920575, 2.6653980694608808, 0.5528051345551303, 4.87176044888196, -0.5307160050485088, -0.10423710015432017, 3.0681557302249987, -0.08554141947170203, 2.9879711160498226, 2.9433708456382237, 0.19926495032415684, -0.8878111687584456, 4.775167899589026, 4.902644340428601, 3.897400212339182},
    {4.889986319782093, 5.613802988607099, 5.8281388046324025, 4.759368845958908, 4.471305468161384, -1.0353875727776054, -2.0129448370421232, 3.0708561169181365, -0.44849218639936816, 3.4877894363276605, 4.693231267438672, -0.13437974938051556, -0.34054318290235935, 4.1934049757179075, 4.294717594729941, 5.009408370491576},
    {6.6325606648870705, 5.269899826159593, 2.6963254238985788, 3.744174439292979, 3.5322353136369133, -0.2632302757642586, 1.553156284091534, 4.329899549247016, -1.8245193585467565, 4.654366547577451, 2.2334352564106354, -0.6086936335272102, -2.1315288512675634, 3.0009705590185756, 4.58126395850761, 5.723544514511866},
    {5.181953613157969, 6.542364259581888, 4.967144524388995, 2.3834779521055176, 4.365288020655704, -0.054893682504337175, 0.043942054481736235, 5.016726292120255, 0.8735433182558661, 2.9377451202655194, 3.9229049302337344, -1.1437672807270773, -1.2425688368466505, 1.8075944247021243, 3.7054805855745605, 4.300656237726743},
    {4.034005982361968, 5.420762311848646, 3.8924085203807763, 2.6482660733680783, 2.997047317948375, -0.4862853825311077, -1.0174965186314662, 4.711837625054077, -0.17140779079645427, 2.263176088497095, 3.86378162150444, -0.9592426147395913, -0.8670213097007695, 5.368435741289455, 3.447943996052539, 4.351426001560653},
    {3.56327150539667, 6.72820279676238, 3.8759865156970164, 3.1072988673414064, 3.602361988973532, 0.48410388257930703, 0.46267142425079477, 6.417675825955991, 0.3479968045480143, 4.978846900939858, 3.7996989305135154, -0.8065614319056662, -1.3932045849945263, 3.9273363838205273, 3.8556424020987117, 4.144197497609399},
    {4.817420687658167, 4.713333561924638, 3.7985759747282857, 3.879329559113548, 3.394895199817443, -0.1818092892031288, -0.475822346929014, 3.402495006603916, 0.14365992310317197, 4.2415028384080635, 2.8781436400135316, 0.28656563053328177, -1.0960049053158185, 3.7503610391070117, 2.095033697234658, 3.7694797027432116},
    {4.8776413596697035, 6.053184857565177, 3.902161525936344, 2.1283676458363407, 4.682344544216328, -0.34114522302529304, 0.34310965511588093, 5.404244008721916, -1.2740747064803204, 6.089659579950761, 5.098883673722466, -0.21828822711310128, 1.5805553127673178, 3.9552791403347647, 3.383145417573518, 4.635906652594525},
    {5.313253178950346, 4.370718866233808, 3.9933560455649273, 2.6741260402416027, 2.768557209755882, -1.5823099517378922, -2.0497669943522343, 3.271431747659754, -3.257082799288376, 5.1721773698793, 5.396146006637628, 2.188085205414156, -2.063203582605857, 5.070316669225243, 4.680879549749659, 3.859463548086997},
    {3.008874631582493, 4.927836414512833, 3.789258801588097, 1.0034029192112794, 3.702219089928836, -0.47587075479595936, -1.5277908237662952, 2.7875790602198616, 0.42569114587146195, 3.389105188623168, 4.456215422772758, -0.3896401947734869, 0.06344701960557568, 4.01772315637722, 3.836645032953226, 2.449075953765565},
    {4.4407561855204625, 4.979339855221285, 3.261980807556783, 1.7936028635255639, 2.6128730306452623, -0.9928560593633862, -1.2451096045667607, 5.727532767790814, 0.9555574614365798, 2.090678471310915, 4.736536080102923, 1.057875220622988, -0.6930337102916445, 3.9959707398398234, 3.59324901134915, 3.67332364633745},
    {5.007882403675887, 5.111738191635227, 3.504092762233864, 2.8050696100028483, 4.480279327508411, -0.40903552968845175, -0.765795524170612, 6.010604286431635, -0.13091091672995447, 5.141501070837288, 2.551792137064305, -1.5118566655288532, 0.829729647721951, 5.152956286410531, 3.376354958548136, 4.204619090314876},
    {2.7346318368733025, 4.7358742240501535, 4.687080440301985, 2.4006387828907916, 3.786677372562719, 0.6637716716757165, -2.5819163335039836, 4.203392517156845, -0.7939191235862064, 3.8836288820311617, 4.1739950433807, -1.3282338335768495, -1.1630013261572154, 2.529759098857212, 1.6463674716799903, 5.231490238410449},
    {2.079283083803693, 4.591918841124219, 5.089273553368896, 2.8285786376909927, 1.8936027881240103, 0.900828377267223, -1.749931007957577, 3.5819951822040417, 0.34398429137946845, 2.6391580314828165, 3.1545526309435803, 1.5490916030414383, 0.23525444463997489, 4.653479002867867, 2.839657547772076, 5.773520271050272},
    {5.021651220730282, 4.787350498849326, 4.602351672514448, 3.0142648061965285, 4.679444576393744, -0.5836325096987367, -0.01139340943825079, 4.743677291611561, -0.0539587388918412, 5.738187965683956, 4.630702908419809, -1.2504591936446552, -0.45455272579054573, 5.430425898043141, 4.535365287670401, 3.893614931038203},
    {4.681740512485783, 4.859655777049413, 4.023833011288997, 2.6036751866950048, 4.44115032545656, 1.2643828351894775, -0.3179600934872068, 3.780487426188375, -1.9420837450367905, 4.438401692354489, 5.42992040412397, -0.7847132743257028, -1.2914060303186294, 3.4331982514514165, 2.6501167850843754, 3.428922874255475},
    {4.663965627586308, 5.393461951444729, 2.7272872649190507, 2.5428531753956243, 1.310612862341526, 0.09830181779853082, 0.14200394116751722, 5.239671847808867, -0.3640582043831671, 4.2397913238349805, 5.690736362840781, 0.7705367115873694, -1.0083047361053492, 4.76984893377001, 4.147722282469703, 5.832382458498245},
    {4.386991066117587, 3.4089432468045255, 5.167436654572767, 3.336171854542569, 4.414159580247508, 0.1498784445707346, -0.0880072220818415, 5.100629535543559, 0.6050106150123418, 1.8580999502169333, 5.946376942029847, 0.66413208104579, -1.4521193547042361, 4.406370979733242, 4.161227750090155, 5.787477349521132},
    {5.155045775815844, 4.381709352386722, 3.2587115572220573, 2.731661894307031, 1.6537792557388378, -1.114192219275136, -1.128615108424202, 3.7007477434942753, -0.5866292109650376, 3.885669453251074, 5.226830112092122, 0.3424077226048668, 0.19381573768695012, 4.869524006303599, 4.9535814920822, 4.420654827398757},
    {5.585125653672051, 3.9218885240781804, 3.729633139071515, 2.8813129716869272, 2.430078566325484, 0.8852294604327695, 0.26022907775502724, 3.953674695781444, -0.20248171420269478, 3.661916763053527, 4.789013308978896, 1.0475909078551335, -0.15681146331979146, 5.4469790620020415, 5.737971582603404, 4.353897454310734},
    {5.002418772360951, 3.6986325647970117, 5.141591794966049, 3.5845290819031916, 3.1579501246151964, -1.1000830959509587, -1.3463539838127598, 3.862819686687756, -1.3674021709869557, 4.285440764728122, 6.76406855771655, 0.5773484652432803, -1.1528894357774813, 5.48657388697254, 6.334466227031117, 4.910343696017969}
};

static const float b2[16] = {5.788360576183071, 6.0573189741284, 4.738624044598862, 2.68887448502582, 4.0821964504180235, -0.6998531091864972, -0.0902119230559879, 5.469230327641062, -0.543629725300382, 5.186918996384711, 4.460797809424259, -0.12161342309789569, -0.4629862035805008, 5.227204099274683, 4.998481227104812, 5.243846673251762};

static const float w3[16][12] = {
    {-3.322019629982042, -3.9290742776688754, -2.718362700835218, -2.9242478254130098, -4.271398292011136, -4.477874813692625, -3.0670816051388767, -4.103661765384171, -4.96393017760172, -1.2577650578524513, -4.34525734360889, -4.109762395901629},
    {-4.298287781296484, -2.964581247408661, -4.106280995874801, -3.7079508045737395, -4.500063239036081, -2.9981306361439346, -3.249878995126266, -3.5044219629181166, -2.551746671107765, -2.5222170377108313, -4.2763299620353585, -3.96506327537771},
    {-3.246507668646326, -3.414779603572867, -1.5444306437484212, -3.6444303132776055, -2.0052549942658366, -4.424698786278128, -2.4829767064253443, -3.0247358877798174, -1.8494891067178387, -2.8080317252418525, -1.9825308226834581, -3.015055283936933},
    {-3.041470893768479, -3.4674645246646127, -1.4816561126105952, -3.25137688301974, -2.8433915601124466, 0.26135286469679914, -1.1336968285013902, -0.7615531624390822, -1.707474423427288, -0.8558620340596095, -3.923124572275634, -2.267216261625894},
    {-2.1808930177966466, -2.620325628130845, -2.2270173808443974, -0.2759636086466627, -2.19330430011045, -2.152946134955253, -2.869786754205454, -2.7668699564957486, -2.5124057017004966, -4.503997882473923, -3.163222979995267, -3.2711303012728647},
    {0.6230534593911681, 0.9396719546394801, -1.2576183558030671, -0.15989382137385738, 0.4758298773529822, 1.6319284332405204, 1.2211491373318322, 1.0304338383115696, 2.3248377708552583, -0.25343515882982653, 1.2173967897899547, -0.07201866258801813},
    {1.1368589990133575, -0.43525888436442245, 0.908295149327337, -1.0391722107727437, 0.7797317947093656, -0.03773934912923381, 0.5204939684531386, 0.24129053958639934, -0.6211967648661788, 0.15026498301940178, 0.30742604227360304, -3.282021695803715},
    {-1.50642781659613, -2.4675931513503437, -2.9257257039459463, -3.7751241076296482, -2.9237743200774995, -2.2941598133217456, -3.307734709442861, -4.3221799436609825, -2.876301184888264, -3.800487852021431, -3.0414021355988012, -4.46190273049653},
    {0.32875698930284697, 0.7577106852128985, -0.4201977960542194, 2.514341656449553, -1.2410421719884406, 0.5000538133671698, 0.7169234182450568, 0.48955907815203226, -0.876055775158142, -0.6361514697003039, 0.7088112741666005, 0.12350128471459418},
    {-3.2202026255619685, -4.9658727997388095, -3.2293697919381743, -2.475692105504282, -2.6134325430217, -2.9481038087343143, -2.7098985859206848, -1.5714855210160432, -3.543054799246661, -2.605620329009733, -3.66355551996255, -2.851923125709235},
    {-2.2260650018124117, -1.0732028280443553, -4.573358936170053, -4.4428856105450905, -2.8559038097403255, -2.446176364465462, -4.553812573684191, -4.0104501777569554, -1.9747514492141363, -2.7224659392135253, -2.464340648127282, -2.882115824922745},
    {-0.9544031621026434, -0.09342430194176013, -0.5126901841382595, -1.037653110745983, 0.06349160047313479, -0.5888935226767196, 0.3273595340052577, 0.21030097047180546, 0.3054316538371443, 0.008223407879046301, -1.1566762009617861, -2.6063487927857176},
    {0.3319575819699079, -0.8626583490059897, 0.6211118507458043, 0.21784993727634744, 0.813835870873519, -1.0747938210872865, 0.3289116519368396, 1.4960314571875792, -0.6321671182065514, 1.0856291634413933, -0.3217841626826731, -1.6941799377149398},
    {-1.7333935638650642, -4.17742527718217, -2.712823096434503, -4.110803461707516, -2.284886633740622, -2.926086743894073, -2.764787889869305, -2.7953596814791584, -3.7937011739187856, -3.4936690806268533, -3.7108923843097066, -1.6063842985260166},
    {-3.8432599548619315, -1.1622814571056472, -4.182948936010505, -1.4306831116386327, -4.018176620735741, -3.347277698623965, -3.1966803977654306, -4.472204099309423, -3.577809072783868, -3.63816440671823, -2.3946290644796115, -3.3719408015884063},
    {-5.208423680584721, -3.98808032523519, -3.5301191722219905, -3.6332751517736592, -3.098540931387124, -4.672615591592457, -3.9718460897052936, -1.8319328339365553, -3.978942000473586, -5.427910445966003, -1.4370790605478976, -1.7922423144029198}
};

static const float b3[12] = {-2.822816333285326, -2.551691813462244, -2.3584008001364096, -2.6150744880133834, -3.0102408449439326, -2.4436568270100905, -2.492799736527603, -2.520110662219431, -2.3424807963617704, -2.777573281184309, -2.539795361679325, -2.4135013950882147};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
