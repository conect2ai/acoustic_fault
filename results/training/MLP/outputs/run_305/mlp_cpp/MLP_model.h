#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {2.4396549881473657, 3.982991381432212, 3.407684853057326, 0.008544510756621852, -0.6861109859751114, 0.29884546947047547, 3.3599613588423995, 2.4666148458039885, 2.6246404306035975, 3.9031257850615484, 0.4974936156676811, 0.12042463328584903, 1.4022455905052202, 1.8607456974170995, 5.510913138645005, 3.0010774574667054},
    {0.7310287078034733, -0.2512088707407394, -0.837386773455311, -1.450717038739831, 1.5441496870209215, -0.04081159568063732, -1.245462380116953, 0.9723636362147294, 0.6268300138063988, 1.180346860128351, -2.0216309918701967, -2.990734532693516, 2.9022304585095555, -3.4922057889073854, 1.8636973092536175, 3.1251820837797015},
    {0.7898299865691758, 0.138115094471676, 0.273360784659749, -3.5935317533794944, -2.5162662231413666, -4.13497402542402, -0.009610236064800264, 0.6042958009204475, -1.5089581008455983, -1.2222733428657029, -3.197792622581066, -3.9617689049413385, 1.1591201166284026, -1.9842900342543695, 0.32750714210507764, 0.5329821536896789},
    {-1.3029038828891808, -1.4196873965561798, -2.0200920561430955, -3.4261063145962294, 0.7140624831897333, -2.743607539824172, 0.3145352538967774, -1.0693183229701702, -1.615827668182624, 0.5771708618171763, -5.220515517007083, -4.536242072267509, -1.2832553728995622, -2.1022832273713585, 1.6605769626711593, 1.0104807422280777},
    {-3.3203726516911765, -1.7981329917998725, -1.5695420327137684, -4.845337188087585, -2.4188557868689187, -6.210210796066833, 0.19807339884587047, 0.8613753542460791, 0.31371651733297956, -1.7771602929607293, -3.9260591969362664, -5.056281591179169, -1.510803197548296, -1.412239583314504, -2.068724349153907, 0.7116774395607793},
    {-1.6250526821441273, -2.243841105961755, -4.542337050770612, -3.739820147526054, -1.623110467783343, -5.370571216281927, -1.336714132175387, 1.6734696858290845, -0.8253185238434492, -2.1001288694721056, -5.819600813736184, -6.375598074661049, -0.32657803696437976, -2.037380959713321, -3.5125064079403763, 0.6247941242584991},
    {-2.918634082511004, -2.5569815422196864, 0.141726081986802, -3.878790560755924, -0.22035582528388298, -4.407500455590703, -1.1110234332365128, 0.24903478967071535, 0.9349361159359165, -1.7383781853512765, -2.4311867441596817, -4.882607195760081, -1.2998181737552637, -3.4343375349407084, -2.9800846018383798, -2.9637979177989746},
    {-2.0194186373579672, -1.3641695853574909, -2.206439654872916, -3.3304579653711914, -0.8278452369894168, -2.064890198868168, 1.1332301309776223, -1.0811403557512698, 1.4406958227647317, -3.5149623355842934, -5.536025654906994, -4.187600069751043, -2.0221761840882166, -2.4820054194602648, -2.216532859673137, -0.5654890222852483},
    {-0.4968206331657774, -3.0720043134040735, -3.670260710404417, -3.5750376906277643, -2.7841931981586456, -3.2445471684074167, -0.19444636989380318, -0.31468653598552976, 1.2453926240367412, -0.1612843624295155, -4.905677609048632, -6.191528877687833, -1.4642652950103063, -1.3219040681923306, -1.4510513154218834, 1.6634521017716948},
    {-1.424936314251865, -2.9391485154781645, -2.9862055485113785, -3.728746036268454, -0.8971284522750244, -2.1878182594632856, -1.8989026156830444, 0.4935531146365859, 0.9932853624418935, 1.1264845211442363, -3.325527611757285, -4.759775776477154, -2.0219402047567985, -2.839833436364809, -1.0724473630114773, 1.8329634778403057},
    {-2.4718686764425373, -3.0274487570385236, -3.562546839313188, -4.976295242517527, -1.8124443825917524, -2.2891445942830537, -0.31830032733535985, -0.30438725966205865, 1.11618572775804, 0.1224937641645994, -5.385040113141744, -4.535296442068228, -0.6842819474440731, -4.85166332541504, -0.860737290976887, 0.4749432423019401},
    {-4.004927098666108, -3.635297851788533, -1.9854166822763697, -5.6326839710638525, 0.17954151723421505, -3.47567894725277, 0.09231689834576184, 0.6012131424055713, 0.917498247146116, -0.302783460417674, -3.861503539273408, -5.056623078471022, -2.215910147399375, -3.884385151421719, -0.009937349193358895, -1.7924533194136407},
    {-0.7539284221357837, -0.9868713379662071, -3.2502169145995965, -2.6843944094865995, 0.21906948256131778, -2.0960586979140463, -0.4838273092623764, 0.9281919035240314, 1.070034507017152, -0.7065870917597138, -5.615499704860386, -4.860879865193132, -3.0859597681730584, -3.668807596592353, -2.5450161361141617, 0.3386301695014744},
    {0.1574810584077562, -1.5806588565914326, 0.4588051225238567, -4.8335150383326235, -0.9991739754843554, -2.088311461949457, -1.6133679292127336, 0.3326116175171613, 0.7433057946070161, -2.281111603890719, -6.874284235856404, -4.245742187568983, -0.9486444126594532, -5.108142981809657, 0.8725741685616671, 0.8269374419418166},
    {-0.30345459616607456, -0.7977829408492856, -3.0070838892886194, -6.519278987841952, -1.5191029966928355, -3.741094213675026, 0.974028647356158, 0.5913027858982, 1.8233200204868532, -1.2387340893005783, -5.682985832661191, -4.500273649205185, -1.9681978100706645, -5.240156821300663, -0.37589489869837117, 0.4796002907564256},
    {-1.339514375975761, -3.747341149295449, -1.8972313706768194, -3.5160282373964913, 1.640370100130016, -2.3756999602988986, 0.8445059109049954, -1.027810937637488, 0.06679390300552333, -2.629428100367417, -5.442209212481324, -3.04006669712909, -0.042430980386032956, -3.7684298122014135, 0.0224931745078233, -0.6034243291930983},
    {1.092767209543656, -1.1545616636427911, 0.8267415377377595, -4.7713026678528125, -1.9488585590318146, -1.8014189162402912, 1.053663991225303, 1.480439485857829, -0.43511318030554086, -1.171883035885183, -3.9420972727708277, -5.348335666519542, -0.7074188380157981, -5.049715107346455, -1.2311150519779301, 1.2356439933220928},
    {0.7037622774510307, 0.08222259586932038, -1.9853388555665294, -4.404658341522515, -0.8484614236440292, -1.0057895345866135, 0.1908560476168498, 0.9582803466635228, -0.7907262849368776, -1.8068732219963672, -3.6590133462938645, -3.223838143071497, 0.5308075900949197, -1.7781221258379758, -2.316409709941948, -0.8693504030011121},
    {-1.6495878185074249, -2.768153548890511, -1.366530619314448, -4.498370373508957, -1.1212580014174849, -0.36265720061658413, 0.7441841508112207, -0.10201561678594918, -0.20661841444085133, 0.2182378519260042, -3.644524841871386, -4.677155525447972, -3.515591109738525, -3.2687984495217535, 0.6499488179146453, -1.9883741638898307},
    {-2.054001849663655, 0.0838986545144532, -1.917917393832927, -4.343579435437965, -3.2186913081737947, -3.3290647794430086, -0.7050146317442482, -0.3596748785942506, -0.8040260939546334, -2.487024485668562, -3.2348732515305136, -5.7674773967244635, -1.320696470167478, -2.4182796166223466, 0.5504270419235876, -1.8375026766470361},
    {-2.969661145113333, -0.7364062418971791, -1.9658322801178483, -6.616003920303701, -0.4211877549463685, -2.1291976506805215, -0.8890086069944322, 1.3046388445363348, -0.4311512249612203, -0.33116973153650325, -6.636013830039959, -5.122887385713324, -2.2333961786640226, -4.367457952533927, -1.222853999387231, -0.6954007664605955},
    {-1.0125438652816312, 0.2841405244416661, 1.3084903433765156, -1.3346312930953117, -1.8358566290596146, -0.29000892794055944, -0.7577780601511832, -0.5386540889556155, 1.206668655170428, 0.6348211109197157, -4.548431146812472, -5.307062462336447, -0.9754970537282679, -3.0256477710563816, 0.7305283000223749, 2.2415797477871173},
    {1.1072522383360832, 3.6786866277455568, 0.0822837802963409, -2.555677396315043, -1.1963188630963917, 0.8634884833911566, 0.02039816188265006, 1.5346793127885288, 0.6707791680099687, 1.1316530662307513, -3.752144880068818, -3.9649498068889812, 0.28133926895403916, -1.9929283621355214, 0.3376445627064316, 0.526388375757886},
    {-3.111731217668586, -0.7465142407208287, -1.6237795313785093, -3.5747500728141626, 0.5313327920421875, -0.7608075033322115, 0.9707251126613268, -0.12954500095316998, 0.06104055106934248, 1.1249964182033776, -5.045173111567798, -3.7127018407601753, -1.5050765149640009, -5.4504104205603765, 1.4602008610125978, -0.3591251506006854},
    {-1.8082184066416962, -1.0672224463073114, -1.0518389709163807, -3.368619857593486, 0.5568857596438357, -2.6054925422004813, 0.5631132806558992, -2.1755556486838197, -0.6129039746151318, 0.15354016150819286, -3.7530381880839667, -5.089475406853072, -1.9027237744284842, -2.6119521963619707, -0.3733612585382842, 2.0524765473782005},
    {0.39514045277260745, -3.17157484711801, -1.1156902977636747, -4.1268368559992705, 0.9286545782896792, 0.058351982370120244, -0.28731642177050853, -0.4013204500769145, 0.9335245735009489, -1.7000208788808628, -4.15425583263695, -4.083526860377771, -0.8477063035614817, -4.085479881586756, 1.289405597201941, 0.6169062964936457},
    {-2.7322648979117865, -3.041638060208372, -0.3478230451027064, -2.9352090578713312, -0.2239180980006948, -0.8170976272842508, 1.7548147336898516, 0.7225596960418563, 0.6550454121408503, -0.024546353083226752, -2.446230189480749, -4.403013724680851, -0.2628130395003418, -4.087981861388983, -0.7180095846227169, -0.18866030325892982},
    {0.32371830503183097, -2.0997998837987057, -1.730760453583425, -4.4784927735100055, 0.2925647293793423, -3.582963751361839, 0.8502072559974521, -0.2033329417936164, -0.46950887414687104, 2.2124807493210468, -4.545682380993769, -4.865302279297681, -0.8468126961206865, -4.050537764211691, 0.19553358233821588, 0.6841465051099328},
    {-2.0284725248353146, -1.8674467456397756, -2.6348653286753336, -1.8486255298808922, -1.3485109986302215, -3.414510944907971, -1.8293845320700386, 2.30631865658124, -0.966689030477909, 0.12450852555212254, -4.8306331928311605, -5.255704709721814, -0.42379292310868405, -3.7574913484052095, 0.5995661143147499, -1.2488542653816346},
    {-1.2454869372955244, 0.6956152503032006, -1.4774993055892218, -3.5288510139054985, -1.08196487829997, -3.023477636074938, -0.6519095032515154, -0.16126547095911678, -0.6117021943984514, -0.07372102322696426, -2.018697255247718, -4.365366058059383, -2.303364671703175, -5.253574669123896, 1.4323328738622398, 0.8409114110038801},
    {0.6897200334900124, -1.4224860251370959, 0.3471271229201238, 0.5243598406739883, -0.49955114247891785, -2.2874901771962803, -0.36502091766104033, 0.35933042391945724, 2.8347612533933004, 0.1619175828347685, 1.296513423931674, -0.9689512403649316, -1.751972521822813, -2.7502430763450367, -2.0354955503534344, -2.455383262551303},
    {-1.8415907408860355, 0.24254185662783218, -1.150762349310735, -4.230227363035137, -2.5301310985244063, -1.1722123325342295, -0.44846354075604555, 1.1439632681531486, 1.4835032715878893, 1.4821920856858626, -2.121789317061094, -2.530907134301229, 1.6708378842011868, -0.15459424489487905, -1.7877671936213089, -0.3496559345297615},
    {-4.5252410960624525, -2.578908544535046, -0.6212053010764628, -2.641025459385667, -3.2518871282862607, -3.697935512320001, 0.739142743852506, -0.43807622622231296, -0.8473771313565825, -4.807703856809121, -2.6681104597568104, -3.1898968011823237, -1.8456996885873436, -1.2515157236894066, -2.0854048399779512, -3.3482644434413933},
    {-1.4854241133681207, -0.8366984793140586, -0.8235956142199659, -1.4821528898332808, -2.997339043245769, 0.5152769320697503, 1.5464392146732513, 1.020515769241843, 0.7258989777095617, -0.45335945537364547, -1.7380600687934062, -0.7982038104171992, -1.5850090533613164, -1.1256463878922294, 0.49783858869297415, -2.8804925007372892},
    {-1.0986062755444694, 1.3371383232594212, -1.517960797555206, -3.6397105430973076, -0.9122404255124977, -2.9734741847886488, -0.3123463579798721, 1.1217380529553695, -0.9609865651786115, -2.8435161118041212, -2.8682291807199345, -2.6945198849094965, -2.211667489183618, -4.303276095064404, -2.1880974849920833, -2.7650127600270804},
    {0.43365201520717633, 0.4742858698724118, -0.7828194758843801, -0.8486305737596225, -1.5999330375699017, -1.8744080284432088, -0.6549064461279274, -0.024826072635376204, 1.1185490707790735, -3.0747867882081446, -2.7173661619463916, -2.7973211169246484, -0.40469743666643426, -2.1407474442508994, -0.9466689068487333, -0.07682974714107012},
    {-0.20493899608337712, 0.905411203034603, -0.8985870082394708, -1.8657633302718173, -1.2997382642734523, -2.8517494441142164, 0.3911862313843041, -0.2018409886897238, 0.624125541591208, -0.9503810417605023, -1.1923100454459097, -1.2472598801248511, 0.32228472712813083, -2.0346783388515264, 1.0888157503992661, -2.396234481039535},
    {-2.061467203806659, 0.10457645782085245, -1.6807102834768008, -1.8817145459707092, -2.1164488380822846, -0.6278685910055708, 1.3460973708237354, 1.7908041263847327, -0.8843725122078049, -2.918173934978717, -1.188601125991185, -1.8826180702833795, 0.421859822876985, -2.3451292406998645, 0.28995503434769765, -3.5127852229193937},
    {-2.31964701579316, -0.03560567512312517, -0.8370172533524453, -3.0901401609115378, -2.604088679192508, -2.885848465478116, 2.2654728523489998, 2.1593825475581165, -0.9293447968490758, -1.0963232427378957, -2.1243140264426805, -3.3428622336017413, -1.4217659092854225, -0.45350630671063435, -1.6857434548675938, -1.7952509114392183},
    {-1.5200376548000023, 1.8368965169148976, -0.56432042293543, -2.035054739607892, -2.750325520927787, -1.8897689723959001, -1.511091988564603, -0.690475646877045, 1.7317901615466287, -2.361932363279167, -1.1581013275019412, -2.1413661362650775, -0.6431905408826653, -3.1796316901015746, -2.772994454702961, -3.3522165577338665},
    {-0.741564027896285, 0.5102757806901767, -1.1419637809210756, -1.8239936135543084, -1.8689837498427688, -4.232960724630143, -1.9199932148730283, -0.9811928150024862, 2.1974565895062135, -3.5683069621336885, -2.3230242833590276, -4.482916579784069, -0.325231484235772, -1.7757027038145063, -1.946026029522234, -2.0878123652585816},
    {-2.4372637446933596, 1.791775961095649, -0.2339799639507938, -1.2354848010599377, -3.262791101531988, -3.383238116263148, -0.8178985768150974, 0.23422431007673325, -0.19089692912906348, -0.9796773633941585, -2.6883352962062057, -2.2899224100278293, -0.5041660266984884, -0.9181335759825255, -2.1177435298322456, -3.5393617144411635},
    {-2.855284138146799, -0.3422524902333718, 0.280711700936622, -2.7469614164217515, -2.6743213094393177, -3.8510032308731357, -0.5910037388286679, 1.2721276942339466, 0.47188542478755136, -3.4456574209998148, -4.785142150500974, -2.6529384082857153, -2.609975782052632, -2.1809142368806587, -3.5629405624243358, -2.4050143857823865},
    {-2.196884581654928, 0.2933451862388416, -0.47906511098443494, -1.2762356375684585, -1.4724904056591772, -4.017380607877816, -2.308711813780752, 0.05011288901431626, -0.4472772191969013, -3.724378595995169, -3.038136677219839, -3.052943536373159, -2.4297853171841144, -3.246643849227317, -1.697661795583913, -0.8341002968723003},
    {-0.18594934110967215, -1.9646825302997237, -0.8803012372724487, -2.26039470140493, -2.693007522561261, -4.333811961421297, 0.753820773352492, -0.012090913220804392, 1.7841640772435063, -2.0225106500104744, -2.2566530490744245, -3.626110316447509, -2.442430640760708, -1.8308469075241856, -3.016169137969407, -2.2545403992268893},
    {-0.7150568678130065, 0.8340768101836127, 0.7139554005238581, -2.0767686035455615, -3.247675549505929, -4.369141668610012, -1.114256429089515, 0.7867570065522651, 1.8294080511001474, -2.7894483063911593, -4.179565080398803, -2.783668622171328, -2.822018970002312, -2.1683831801541427, -2.2500633579874765, -3.230177641512187},
    {0.336645404481896, -0.2026208147272056, 2.026049295479854, -1.7073386122938312, -1.0495352429746159, -1.904003203959094, 0.020640027005749014, -0.20723568520943558, 1.9688821072899, -0.8445813920376037, -0.8523156479369273, -1.1580650837947704, -2.0795299588267984, -0.6078439035107711, -1.6195844409351272, -0.007270414509596681},
    {0.5374721869916264, -0.35402438716806617, 0.5145337643677502, -2.304193387548534, -1.7710894826637833, -1.171657057886035, -0.01581901835262228, 0.6209062848417001, -0.39455995556990453, -2.2923488478505525, -2.9277826471985438, -2.384058319967473, -0.1775276067214507, -1.0780165838879714, 0.3087137483576305, -2.7940088821288334},
    {0.8632337709118713, 1.017057721358105, -0.32443482705686144, -2.2432743915762177, -2.1013025378795684, -3.286540528311502, -0.8947423199856749, -0.3267140512561795, 0.8437190916345606, -2.321645708513717, -1.7156840321922873, -1.3501067977799457, -2.152385795255269, -1.9487289275219806, -2.2053665040027024, -3.150122898738632},
    {-2.706903618930598, 0.49763869695284857, 0.2900276516219006, -4.45690611548265, -2.301785736016436, -5.2393782522776915, -1.2865372686931522, 0.5464044793318804, 0.1808681696260334, -2.091071006743979, -4.670923320608522, -2.749517671673081, -1.9540334545562381, -0.8948034381751854, -2.391518254083301, -2.8205241648702266},
    {-1.0084606259100741, 1.5421872141955784, -1.7188557381646326, -4.253340478773144, -4.0330246523108455, -3.8994368992197224, 0.07617325711070669, -1.3224630258213754, 0.8130290318347588, -4.367752371512797, -2.3741323492575743, -4.026452550708827, -3.621802481659463, -3.16417853158099, -1.8980770108841143, -2.575375930267229},
    {-2.238854427405177, 0.5139264614687645, 1.616641477569912, -3.4603143162894314, -2.85980437659221, -3.6477569152246874, -1.3364136239057334, -0.5837056743752864, 3.1665074618231945, -2.7592636078125494, -1.1894420232335814, -2.727748057059775, -1.1511922901135017, 0.1904079123982939, -1.6163356925793089, -3.1559116583022293},
    {-2.1671060112826743, 1.6833263311076445, 0.5929701087002319, -1.5715844904080671, -2.840178813177147, -5.686826139512724, 1.6777950006523064, 2.1266483151710536, 2.42141518332644, -3.2285132481357963, 0.5931240812149992, -0.8514878651704219, -2.6195642870651525, 2.2037928021667463, -2.463422325135364, -3.522780395078631},
    {-1.732271493273279, 1.3571318821020084, 1.2805144053874131, -1.8150768274604894, -2.202328535682011, -4.184861688047553, 1.3349478422739147, 0.5220636536140536, 0.9040402243946615, -5.267523312256474, -0.3247269335965057, -1.1910644765907594, -1.633702395867, -1.401305106568206, -0.40727767611682186, -2.8951575894445924},
    {-4.1869272169369465, 0.5217156266170564, 2.5962143903868666, -2.6450714495191248, -2.173447347674923, -4.962932521335198, 0.650558967085198, -0.08060136707106455, 3.1589424906388537, -3.811809024122719, -2.8983568387482377, -4.1174000704955755, -1.0152591533991577, -2.2968614467861377, -1.666450297982309, -2.2390716661430643},
    {-3.682161834471951, 2.4107145213639396, 1.6310676049638377, -2.08734486425598, -2.529131874742769, -3.2636181388539427, -0.33993298592631305, 0.9785672150897526, 1.3055521279261537, -3.154347720621048, -0.5749312098752006, -3.553705709118463, -3.367861553183844, -0.9135106518354884, -1.6859475772336976, -4.018671216987034},
    {-1.0106646519172862, 1.167973232630829, 0.35415022794768236, -3.275578371832035, -1.7962116406250954, -4.170476976777316, -1.3205265794504915, 1.483564134435927, 1.2631644696577478, -3.1050484049460225, -3.7719872797510914, -2.0803816579503307, -2.2339224857527866, 0.7010813918619339, -1.4792250217061296, -2.43985867204297},
    {-1.528008388146672, 0.8005084915742343, 0.24113070058876057, -0.39396842380060676, -3.0731273692650714, -4.955782065054463, 1.3271408225270291, 1.427510485252479, -0.5454249514245424, -5.267864202543744, -3.317438535745665, -3.3693076007329874, -1.552779448096699, -2.2891009725683316, 0.33471832971619897, -4.17467704694477},
    {0.6737886708228232, -0.16649140107688282, 0.07232748488204715, -2.3605368663509885, -2.448659725248442, -4.263734922850423, 0.9623214875437943, 2.025819309561799, -0.12742955037628562, -3.8899075321416436, -3.065478325902768, -2.6359974587568207, -1.598670753283333, -0.511386935652713, -1.0222134005423476, -3.6677682294232263},
    {-2.4289328457527413, 1.3868149440907798, 1.2757807819777047, -0.5324269951456574, -2.624281199756474, -3.7966165018371663, 0.5130359548471954, -0.84597165986939, 0.9259978350539038, -1.1460896350308665, -1.766769652304349, -0.6673414354259575, -1.5074064712200503, -0.37629823071448715, -1.0395284372950384, -3.6161757603746265},
    {2.5869228477709525, -2.1686180732514053, -3.543888169093931, 1.7679751682847322, 0.2790701962350967, 0.7048564633587326, 2.0451446803066613, -1.3693273260513494, -1.2897413791022996, -0.35622551016140597, 3.230447426365415, -0.2924482092351898, -1.2539431286740756, 1.7401592221255844, 3.2462949364816542, -2.95062925086075},
    {2.48267837766365, -0.13008219257355258, 0.9058641078635065, 1.8111083888880797, -1.036435160794514, -2.6989354741804763, 2.6873441231331987, 1.9043182628191202, 1.0503820802958912, -0.4618477590605155, 2.7566281343885435, 2.2023929134720452, 0.2945264137423841, 0.25157428567647644, 2.6950915246210783, -0.5030277823082872},
    {1.5542312380393073, -2.2938165536537714, -1.773803014607746, 2.7508653186565035, 1.3032101327072205, -0.4233442610597118, 2.5419554896624788, 0.2780186507720166, -2.0939330253255903, 0.1531169064538848, 1.928689415682257, 2.698616162132066, -0.18434355810227157, 2.143436154293667, 2.055278631896666, -0.6519119550425898},
    {3.844643429222055, -0.40235239365802805, -0.5064385652171789, 2.089527755973894, 1.5212989825261747, -1.7423746932308208, 3.0238058868037623, 1.3187777431523495, -0.7107430174467615, 1.0116198177387727, 1.1756322272977564, 2.5379201953073998, -0.2922805212652079, 2.5958865133755813, 2.3522462264342594, 0.6297572721456778},
    {1.8106603072575822, -0.46735950945896326, -1.465601438258019, 1.8769997753890126, 0.2559512876938285, -0.1436614737058202, 2.9064272098084984, 0.26468106972853855, 0.7919122916640883, 1.260325596623069, 0.9736890513907833, 1.8228204754024484, -0.6403576611225341, 2.603558303967068, 0.7538656362307254, 1.2670136851627005},
    {-0.03100324689428977, -3.919704753658186, -1.895137216300505, 2.035371480721216, 1.7472921465722775, -1.7769754737349563, 1.333869413689037, -0.19311721703809817, -1.5180439954442264, -1.0345273709216143, 2.3582637353441136, 0.9479227032975324, 0.5641811629800759, 0.5657887944036478, 1.4001935463480248, -1.121307127414499},
    {0.8398704864645505, -1.654527648270732, -1.5013007573871677, 1.137360689086678, 1.4528099955719131, -1.7463590608953758, 0.5981126144480858, 1.462201934782674, -2.011875177764688, 1.337827375696938, 2.9225700552842717, 3.8971473918588124, 0.026013088429939213, 1.4845065738535936, -0.31914362724849044, -1.7144361653046418},
    {2.3399160143853175, -2.612263391237511, 0.023299362423176644, 2.1166574325392853, 0.11303973516068283, 0.9467743933975895, 3.3920726884754338, 0.42630238982427726, -0.025996602198062633, -0.30421201211767707, 3.215856160880023, 1.4878582318785436, -1.2413680891973975, 1.0627471823353214, 0.7704413896289246, 1.1759851866728468},
    {2.4338342907870625, -2.1621868485479223, 0.18099305633840143, 1.7106211990871714, -0.27162121393592364, -0.6872506411297141, 2.5727177466797633, 1.155280394243379, -1.6931630100557276, 0.3692956176073665, 3.2072297460919685, 3.750759238054805, -1.8036011468745174, 0.8410421078413407, 0.9178054743631728, 0.2592850556230682},
    {1.6165280242729951, -0.571025247497405, -1.7667286487880693, 3.4764734666995163, 0.847252881335654, -2.6832078480000914, 3.1146265986555113, 0.837877563888578, 0.38193541958672717, -0.7736379164847332, 2.88288882462399, 3.600126848154101, -0.31902422323613383, 3.862936847083107, 0.8372934521954655, -0.10937479333153166},
    {2.5931628710835204, -2.249183287363675, -2.9055942343589103, 1.238685201740969, 0.3876605892180369, -0.49962282871448627, 3.017537439618865, 1.5517243433261187, -2.1871784643553123, 2.492168912001, 2.933737433304882, 3.366186133200277, -0.20823168335738979, -0.4885210390871789, 0.9716692131460252, 0.38300952820872447},
    {2.7196411219378502, -2.564065130709526, -4.241888015692457, -0.15703946269940358, 1.34156105960899, 0.8207725750296752, -0.17914714470664458, 1.4711882186021277, -2.250500824782027, -0.18061998156908296, 4.323348637465045, 3.2703360263707784, -0.6626250704455283, 0.18297066694932565, 1.6431508387020848, 0.4820272212471616},
    {2.2622549462088313, -2.2334622464103653, -1.1918345461691662, 1.5945302191626978, -0.5047044626561874, 0.8324507328028121, 1.494488500012104, 1.332988544738914, -2.9673761286648257, 0.9357745204330664, 2.203610032335754, 3.3182788403086763, -0.6029268975942679, 0.6459136239626306, -0.2961168034269391, -0.8828084232276845},
    {1.054524926255298, -2.791883923731031, -4.6222300201872875, 1.2363659979119699, 1.2908490628791733, -1.5330718277293658, 1.2124989994446105, 1.1219311836076837, -1.632708714699542, -0.18214824098564047, 4.681191426713402, 3.73298087512856, -1.8577740821164561, 2.2771215342258633, 0.7349513497661472, -0.7587089879539693},
    {3.689720294758696, -2.891433497847645, -2.4620823758515495, 1.6704472188374886, 1.0063244744405684, -1.1231429705841982, 1.9254743206551224, 0.5664629649106301, -2.378132474015126, 2.894175897600922, 2.7511821288078377, 3.0100858970916025, -0.15491744280810335, 0.3778888279425632, 3.168222994453815, -1.4664291934341427},
    {3.7313891644919654, -2.1967540271816093, -4.032537452757745, 2.216178714411612, 0.24300232350657333, -5.037371117891003, 1.4806947912012365, -0.7443559824908125, -2.2666481870806154, -0.03547383653983406, 2.342510008386881, 2.83740918211171, -0.5425964081384738, 1.5632753187890174, 1.8614512374968524, -1.4819560613848395},
    {3.1735912584677686, -1.7472412791732586, -4.241393782675427, 1.9942815883170264, 0.10611555086942812, -3.3112921563242166, 2.0224390556450755, -0.6300546332257291, -1.5885477115112283, 0.46698390777692855, 0.5581597088079231, 3.186967058801824, -2.0732128678606996, -0.3987694127067228, 1.246359053508358, -1.3265466282903235},
    {2.346224556933524, -0.07614717529278112, -3.0433524422378424, 3.4259344817790027, 0.3921668478462172, -0.9919670094671874, 3.094323214870562, 0.396207556992383, -1.5915414598876112, 1.038565164480074, 1.0750351925330228, 3.014821060806534, -0.3031094955106139, 2.8547199378056414, 1.5609110688466485, -2.156363114543284},
    {2.2589421024011136, -1.9245395198597828, -2.2976582193214306, 1.8220027390635152, 1.3637375381945498, -1.4980299077880417, 3.8896144316337535, 2.722407643803372, -2.3848046675608767, 0.0001227109194287103, 1.9803923190838257, 2.6665278339978347, -0.14764474504207278, 3.2367068978391313, 2.7896268956436563, 0.03004866131109156},
    {0.7705734643125332, -2.3438709876310058, -3.1252876145046304, 0.2823082514718976, 1.2327885799012792, -3.8930429049675013, 2.687172157766767, 0.7612363068196041, -0.9518371073073553, -0.8774206057408181, 1.5089509123403968, 1.241476289443629, 0.8535545887971968, 0.7845540878663994, 1.2618909736937245, -0.7561300857524692},
    {2.40377007129796, -2.3130903660559645, -3.3170286837862877, 1.52428440592282, 0.4374345292279963, -1.6678376956273702, 4.345426946051237, 1.2925284278418905, -0.3867321244717429, -1.4384104454186466, 3.4958170994977604, 3.6154411561664777, -0.4373769781634105, 0.8679268553426612, 3.6909773822297516, -0.23062280228341672},
    {1.7276140054990805, -2.7116755271051605, -2.971886564267532, 1.3543310165506712, 1.593453324612979, -3.173758419307179, 3.4383026812632207, 3.074135078609703, -3.336164259936531, 1.0967397263345489, 5.031959629559349, 3.6708583374152104, -1.114583619943125, 1.5473146682320462, 1.2768880434200502, -0.5216400661104712},
    {2.4652667418778873, -1.888212734502807, -3.298544562785195, 1.7146093888400653, 0.9354510711876908, -1.9392548509530252, 2.2132079242243132, -1.0602748725769982, -1.9388609307989857, -0.42811654069301674, 1.3645639468327682, 2.964324237812387, -1.375125116360017, -0.06193288948401883, 1.8507874301179992, -1.0660287471381171},
    {0.9671484204977694, -2.633226135976142, -3.255105125158185, 2.1041253659005124, 1.1777901820841934, -2.872310970734158, 4.511094486366033, 1.6705905280533262, -2.4376843929178476, 0.5548273508901259, 2.1081070101706247, 1.2017803223749806, -1.8390937641490848, 1.709107232940232, 1.052201465601058, -1.312058961440571},
    {2.8076046894415905, -1.0162875881229163, -2.2747190290802433, 2.26928181783522, 2.4260872668351268, -0.033236417409290425, 5.371557546206238, 4.270346402415837, 0.37359187877297195, 1.3591490326734752, 1.652310546778567, 3.644068090968934, -0.3102506325105411, 1.7556187433953727, 1.7541385299487067, 0.7722812624835174},
    {4.491662022914671, -0.5890869216698982, -2.854338507114069, 3.013547798259166, 1.8514980494542586, -1.0435826762533706, 3.677410917048594, 2.435652570731693, -1.6187473576057247, 0.47040410200562127, 1.3316533438827949, 2.9166923076010356, -1.5153261525430588, 0.3959161016045858, 2.0611296019372967, -1.0299095460679335},
    {2.105053745417606, -1.5223640523190467, -3.9369104288590577, 1.2544242441255007, 0.5956444245896746, -1.0247028960413591, 4.418592739062993, -0.7132114762164609, -1.2206602465110081, 0.4028443286527548, 1.7878874454832452, 1.4427252920156737, 0.5875710952619085, 1.8436666417363343, 0.8014912636223832, -1.5090150344335973},
    {1.5771320614585398, -1.3830858033531273, -1.6024308803694973, 4.368757904617989, 0.8174238178638276, -3.1846723353471664, 4.7034968232888845, 1.5614404932341883, -1.2315962160073939, 0.6273545814904178, 1.393970990124473, 2.7567051787202534, -1.3020580267975337, 0.7884224676168947, 1.1759531205170675, -3.430021966908144},
    {0.9474455792063304, -0.4981993529596008, -3.6877171531741135, 1.1811814251255501, 1.9681280293153187, -2.66576153020196, 5.425218338429188, 3.4790091198174147, -1.793440337668754, 0.41736558098513526, 2.1931968143713285, 4.33288294209809, -0.4820156755143858, 1.6036107785365719, 1.8190847620348851, -1.1511564002981682},
    {2.8178189444150417, -3.0031737872053417, -4.315193549700501, 4.16005159886921, -0.48515698460327256, -2.8522701724327826, 3.051685803228334, 1.0386372981947403, -2.388565939352031, 1.009188696855544, 2.963806543526978, 2.702713145503587, -1.1236876170912744, 1.6409866606375074, 2.234014447591292, -2.7037706239914834},
    {-1.1553668437828217, -1.7873539657170214, 0.24172920738211473, 2.2700147526612278, 2.4099546572502617, -2.11575093703604, 0.23704577079859532, -2.387104986931699, 1.230542781847175, 0.8143031970948452, 1.2545173710602224, 1.19440777289254, -3.5997171615251298, 0.05508497515274427, -2.8612003034447904, -1.8393336003981982},
    {-1.1354328411378183, 1.3053132263732794, -1.0335352718287016, -0.8190779761414413, -1.7716777192250486, -1.7540946817243115, -0.150986468979094, 1.300266945764036, 1.562915464990511, -2.2204161349451774, -1.0996752317361793, 0.022637962726679627, -0.7982871922587419, -1.983567887571539, -1.6400837050698382, -1.5297341607165964},
    {-3.13480950884395, 0.14600709516031785, 1.202529191688312, -1.127279669405601, -0.4190203683022885, -3.6874105700809707, -0.1396747572569041, 0.390569713735337, 2.119117955480983, -0.6007782695552205, -2.9279620196605984, -2.2066064028071817, -2.139568630659426, -1.4694970511006824, -0.6622530131051992, -2.550575414546886},
    {-1.9175254407209796, 0.6467977358321454, -1.7273045502252484, -1.580013986170277, -0.9400138261314639, -2.815001576278451, -0.5707136738405639, -0.6937027710964782, 1.5413036010898598, -1.8299784254381857, -1.3407920335587824, -3.0192019923377753, -1.4173936058050682, 0.2314685963145167, -0.5996345589602935, -1.6348983993384416},
    {-1.1687744619917868, 0.03602754055832779, -0.8741749517128838, -3.3711331587933153, -3.252401378095924, -3.3981287230256005, -0.4010328033461222, -0.31852476854510825, -0.36718672774133326, -1.948758939980006, -4.249104346524662, -1.8284923084066678, -1.287160397044524, -2.629258709659667, -1.5656292707146449, -1.8742797034157843},
    {-1.9650564705468065, -0.4803574300814544, -0.1615569394781028, -2.8561003978355575, -0.4968812002915208, -1.6610864272784664, -1.289803683226665, 0.053740023385073964, 2.0601155782968683, -2.831388785444888, -1.5404456678371627, -1.448435218695616, -1.036496547459775, -0.762025130230038, -0.8096149271482713, -1.8161534413472136},
    {-1.8408273237901585, -1.1310388562595008, 0.42678188100462006, -1.533552534837843, 1.143947643780128, -2.8043582835647745, 0.07746728384367382, -0.02619298959218893, 1.392408270994788, -0.13998912205054842, -1.0109639853518915, -2.282490740606582, -0.03818555543094482, -0.9180425738313841, -0.39423952208680474, 0.09355158557200763},
    {3.0290730815185065, 0.27721953108963526, 1.5791393142257806, -0.21687349526820265, -2.168226857318083, -0.04801998195082937, 0.5239688397864368, 0.2694716747224989, 0.6480113907659548, 0.8038189369389711, 0.4350302290448497, -1.898477428596466, -1.5985109483735136, -0.903211333176817, 0.7325063030333007, 0.15186155352572303},
    {-0.13384683978509077, -0.038925690722178205, -0.17957511778918514, -2.1135318221950086, -1.8986356289410178, -2.573325145268328, -0.2682770004083998, -0.5931232020724201, 1.4966906146457362, -0.8079668584886953, -2.2696412172151295, -1.6009140054108737, -0.8711776633747219, 0.02117127799468154, -0.7125960789683627, -2.260749084785804},
    {-0.9685039552489209, -0.06873854057126873, 1.1107481335814955, -0.5013257832283832, -2.203013043185226, -1.8755583983435233, -0.918434325918005, 0.6109493171944093, 0.5045571862091351, -1.3963177696175917, -2.993720717148575, -1.5149527133722387, -2.386175961778173, -2.5758218062965508, -3.7972383869318675, -2.6586011959098115},
    {-1.1947155773521854, -0.23379130346401994, -0.9927453487473792, -3.7646083570385804, -1.3905843873483916, -2.727128482882955, -0.9327536863932276, -0.10947040801065673, 0.1544018922305466, -0.8873511982349725, -1.4554446143693411, -2.617051493604966, -1.5712405851658846, -1.4443849825736512, -0.14270824609057411, -2.0446763193625195},
    {-1.5013452758178438, 0.3912867487318763, -1.161769644544961, -0.7675077023441957, -0.8353876288082647, -0.3838969212667697, -0.8038545730387695, -0.30820559701808964, 1.032228615825065, -0.3306487006663538, -3.390619784317141, -2.1141916506532024, -2.0272946298976655, 0.13947102572476985, -1.2537617953944322, -2.1653891016011033},
    {-0.5386949095202888, -0.07798879357003766, -0.5496119965184053, 0.17019718347994867, -0.33289301062448867, -0.9572620720832342, -3.276577587357, -0.9076686358518651, 1.3560424955888137, -1.8123105402456008, 0.4767725613846095, -0.9385765360707109, -0.4181962887074967, 1.0483871048492241, -2.942366805707859, -1.3694136960908614},
    {-0.10075161575873104, 1.3591247063019423, 1.6505156815196205, 0.35988041326816816, -1.5513477650957244, -2.7446968209722447, -0.33560593240401504, -1.0606034037853875, 1.3118638467639159, -1.718986158375715, 0.5186547336032843, -1.1671813317141375, -1.5343579124394269, -0.4752375548229748, 1.1462444813827621, -2.1171892711620806},
    {-1.172269424609346, 0.7455308399888793, 0.9477391480658154, -2.0677767722177323, -1.2189136543170198, -2.0193708687118384, 0.19655056485080102, 0.5304674762376838, 3.455867931900852, -3.4941907316719396, -4.750845377020895, -2.6060171817993516, -2.2182568309432047, -0.7005027729310602, -2.7824468533717126, -0.7731850877737075},
    {-2.240478272572025, 0.40232639694427036, -0.10855237471980589, -1.9470680110842136, -1.072368044174771, -5.084335423378371, 0.04302955429959869, 1.0828098577148388, 2.345444458756255, -1.0374673778176393, -1.51928785728935, -1.6728316572951922, -1.4478908257481506, 1.4000391385045023, -0.3984904586980443, -2.7541770941130963},
    {-4.666046549302001, 0.3971425458422754, 1.579707152508649, 0.5349870799630904, 0.9914957321950587, -0.7323177441734053, 0.49244503843039916, 0.29091927921000915, 0.9466358288770952, -0.6937671676618359, 0.6552277240764234, -0.8538093048163038, 0.49277021142830363, 0.5079551442177839, -0.22576294208064165, 0.44354959637762803},
    {-1.6364627186949166, 0.9190212570043085, -0.4837815630584463, -3.9182777108762727, -0.3253181288303529, -2.6595876875602866, 0.32839490162144735, 0.5905957909193196, -1.5949645080441361, -0.6546358758756031, -0.5009014764453301, -4.126606958553354, -1.3845912966172809, 1.6571968112988436, 0.3515959093342084, -4.437205958146013},
    {-1.240566769675115, -0.1703937219736715, 0.8157329482835116, -0.7878405672192174, -1.4563116689077085, -2.5939678578975305, 0.31933466208160943, 1.4394745923319165, 1.4781954102351298, -2.975801387262457, -1.2950707144367943, 0.10975484541197009, -1.9052956940377506, -0.005626906993393402, -2.135322092983932, -2.3613844224906106},
    {0.040813699660380696, 1.2045308381375823, 1.5820307513236669, 0.7980926439188569, -2.084091992896016, -4.779497849546516, 0.9439899860942303, -0.4434582615840999, 2.175717577535851, 0.20671443900517883, 0.05033600078062495, -0.16870735156274258, -2.719778346456076, 1.5015937755445696, -2.8675878367151806, -2.6027214023544976},
    {-0.5937626078623097, 2.7898723111050963, 1.7573098247895882, -0.8019015496341723, -0.8135407884715391, -2.033529862787166, 0.0723211394043141, 0.23548154696778476, 1.0865653208970165, -2.5034722534436207, 0.23599298055444085, -1.8237290012937921, -0.560276661304559, -0.3768187468954775, -1.361589819693899, -4.052502145876445},
    {-2.117201850335449, 1.4124893272727763, 2.837493739222314, 0.07316966955684154, 0.5030504613735254, -3.2897765249421735, -0.47942871920314795, 1.9193077806886383, 2.381328812472064, -3.446412247015792, 1.9343808953618857, 0.08949633567508092, -0.41898858340978296, 2.291325997185368, -2.0827554079845907, -4.792050915216932},
    {-1.9681092622905119, 1.1901909392861691, 3.045873495615125, 1.5825302123489629, 0.8290675761262484, -1.5217356025659308, 1.6002804576603489, 0.4732602457302763, 2.2011124139596143, -3.370959939069527, 1.9094004331969776, 2.1809710313081205, -2.3101372673239435, 2.8130815966396545, -2.936589041036992, -2.750790314921572},
    {-1.5456835398065625, 1.7570067762489552, 1.742234322070389, 1.66771836937655, 0.17049240216689976, -2.1945962694780046, 0.06725629810211005, -0.7550392413382897, 1.7704603892067974, -5.361675591347482, 0.7618247558084357, 1.595319114449651, -0.4575116460891205, 0.31095711283278304, -1.9808613016046297, -3.377667793544156},
    {-2.306596484978657, 1.0395633453876971, 0.07637026858454976, -1.123474008165017, -2.2139622297184083, -4.247762714802844, 0.18062978542555333, 0.056911079963810215, 3.3542793039139345, -4.439731519865221, -1.838945073066801, -1.7871510457913315, -1.8565142351407775, -1.2728167996237585, -1.974379761480124, -3.5068552824264905},
    {-1.0796927330119177, 1.199531679583392, 1.642485559788737, -1.1994082466369478, -0.2964072816982947, -3.462685598867876, 1.3239446285552305, 1.2624397870010426, 1.0292936116205362, -1.6941502211953232, -1.570024968559264, 0.6085352785072302, -2.8459703377079197, 1.246844116575053, -2.7250098084683048, -4.305248572900981},
    {-2.111945805715167, 2.729768110695046, -0.5821241045960981, -0.038134919614560746, -0.9855451323638907, -2.305588059159557, 0.7835358586660737, -1.0495209200333944, 0.7758625240594602, -2.0746444966915822, -0.585499503988361, 0.11594689492248023, -0.35511943833071336, -1.7698190352211385, -2.0674504553624624, -3.477567425798892},
    {-0.08778579293923995, 2.238710046181645, 1.5986868088211041, 0.15640855751565994, 0.22328203155290294, -3.0848501239737423, -0.0769861945198425, -0.31066097821120536, 0.528236831834731, -3.4556456839846033, -2.225339371666187, -1.5752110665256756, -1.9154654606115693, 0.3736802549234114, -0.7157400411160281, -5.716229825201922},
    {1.051442531414243, -0.3684300587477932, 1.1545061659507352, 1.0131769885932789, 1.6335351697737346, -1.8939094828401712, 2.367486012540522, 0.9753558031737343, 0.27837956936670116, -3.8391497039256994, -0.17891728567033988, -0.8516464372113611, -0.4949846949180145, 0.537122824406525, -0.5044608422774233, -3.4803818876819377},
    {-0.4544513959696721, 0.8914978362756802, 1.1100583816530762, 2.151435572073167, -0.8986887239088595, -2.5319359214656614, -0.15602197324188322, -0.8423360778714705, 2.7428796795675345, -2.5447057904628143, 1.7566781925839574, -0.009182548540661566, -2.531939290516948, 3.0412011350697807, -0.8752807966023628, -3.523500787171258}
};

static const float b1[16] = {5.730305657670007, 5.409659685695045, 6.043447336903598, 6.464332587910813, 5.592901425940934, 7.02978264500533, 5.58473393530892, 3.138995240562564, 5.1974337787325355, 6.248121385757477, 6.598252517209557, 6.899275588160176, 4.27419421004128, 5.170955744138086, 5.224206042636517, 6.33049704077791};

static const float w2[16][12] = {
    {-4.475670221238555, -4.030006772317652, -2.5770348809733163, -2.0372681554156067, -1.9649915188640485, -3.7903000976574504, -2.872733166069843, -2.6473484092896897, -2.6283881264212487, -3.756267023378066, -2.6746196366551964, -2.533896678789956},
    {-3.9283120835020524, -2.9163584773751623, -2.6819892318316803, -5.019016893317768, -3.13190208947782, -1.275405414207806, -3.1538184982499384, -1.8120087316090476, -2.635292898068272, -1.9005622408748244, -2.9947730221366657, -2.150472428890075},
    {-3.948020055646012, -2.938795563025848, -3.5481925165790855, -2.603097823694143, -2.3932661641547397, -3.8240872957379985, -2.7510566757835972, -4.581458527054271, -1.7639445230249298, -3.2338621458899026, -2.6116430667292962, -4.123544550480435},
    {-3.246261173062914, -3.6125112906241053, -3.3033915795136393, -3.0225046580783066, -3.952272265589957, -2.8916743619637906, -2.419518409111146, -3.570278709138232, -5.334615533010195, -2.600160924549063, -3.123322512210997, -2.408909504307897},
    {-5.128639190784963, -2.412165536624089, -3.688295658978225, -3.889606620955432, -2.7677427278335944, -1.7843836703232505, -4.265301332532995, -1.375563169359719, -1.8386481648376587, -3.475257814928882, -1.3749633553247709, -5.207310337217654},
    {-2.3162153881716536, -3.515767065268049, -2.766697193660872, -3.377513797449417, -3.956557053991552, -4.301485453979097, -3.4658053737556407, -3.550823345425851, -4.3786191958316465, -3.5170503153688433, -3.566103695700754, -5.000729046775183},
    {-2.5225378634267672, -3.0557041130110343, -2.6881073405407694, -2.8127218241807728, -2.2291541927587306, -3.4042607366135607, -3.8155023211542463, -3.3925977668493075, -1.6645019565702195, -3.5197273287960904, -2.945338685072329, -3.053705451728817},
    {-3.002436271600979, -0.8691095506404725, -1.686639169920563, -1.6489113869473417, -4.457285316385367, -1.5205077978603736, -0.5483154970853581, -2.116379907292783, -1.9647286326143112, -1.4821355444886837, -2.2184454059907446, -0.7102450398993189},
    {-2.0074983711953727, -2.109993673898295, -2.8804479553592457, -2.323233080000844, -4.537309804659918, -3.2882712240673535, -3.1846321148404235, -1.9856287232034784, -3.8234920270808295, -3.3307331061624263, -2.2145163287705563, -2.4016428597783546},
    {-3.329301333465164, -3.5295139763187136, -3.6756880871121487, -4.272562321537778, -2.9128783084062024, -4.257141700550813, -3.1863587775880133, -4.146981772345021, -2.5326490879431973, -2.410411421477624, -3.146967980553646, -2.500022042542477},
    {-3.7692287336680286, -4.057097726788625, -3.5861516016160873, -3.786380001636264, -2.6449065405965975, -3.4539899810751016, -4.4520974834779015, -2.698857308485944, -3.436132185168036, -3.043558974893576, -3.335448474816215, -2.7494328073668024},
    {-2.618246054777882, -2.3460850490078147, -3.250905088958558, -2.9982582585152118, -3.718965879374828, -2.7215889320067665, -3.6506425525762327, -4.762979337817659, -3.943800133903622, -3.700840026200626, -3.057870915965473, -3.82081541501375},
    {-2.904488983564447, -2.352007222866746, -2.331039197133526, 0.023481441616170638, -1.805910824215008, -2.8254776510380695, -3.5568867426410864, -5.078604332746677, -2.0028603192261265, -4.025116033057356, -3.6116567410591456, -0.39884544220063173},
    {-2.019266935843262, -2.786857365494678, -3.4646923473808275, -3.235591717705378, -2.7663114468836456, -3.632136258088599, -2.5133521422875877, -2.2150464906162397, -1.3438722623585957, -3.591844528296121, -3.786098375364074, -3.814356889888357},
    {-2.082489358941293, -2.037212006962495, -2.145576241349498, -3.613015374972658, -4.050232820745851, -2.2594609606513156, -1.130444050096194, -2.597989546416585, -4.098223352400106, -1.4381042939904713, -3.816855359301218, -3.7812469416881127},
    {-3.0476386823892927, -4.108701462639843, -3.082534858968607, -3.1267829618832637, -2.726013062740251, -2.175277811114128, -2.3349179486395806, -1.5169005030775613, -4.262656943210939, -2.572045548100793, -4.106695581142268, -2.2589578431049344}
};

static const float b2[12] = {-4.4166751294491196, -4.540647686292555, -3.0574159312424856, -4.015003445199696, -3.810491442647493, -3.3894678455439924, -3.5172323840523, -4.0280752125247075, -2.959376305759312, -3.7043604852671055, -3.1886382845817263, -4.043816394680244};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
