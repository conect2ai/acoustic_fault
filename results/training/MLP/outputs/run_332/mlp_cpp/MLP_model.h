#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.26876352101663503, 0.12447927920426081, 0.23799924952963106, 0.026403500025235917, 0.3742906409849009, 0.5847855158341081, -0.4186289277681899, 0.4504967376482629, 0.2614695594500295, -0.25214483799915255, -0.283497365074623, 0.4338993880013619, 0.27860137013543673, 0.5858963922337527, 0.11726109791166424, 0.40033697897062615, 0.10032979454521244, -0.10293394260728451, 0.17461143661712564, -0.36745009503834286, 0.40484953482339614, 0.31878098389578147, 0.31708589142956184, 0.1163467499426387, -0.22566414942478946, 0.046736797560585824, 0.45714692949441804, -0.3639047054938993, 0.2021408855396023, 0.5779255225418715, 0.1642758160597738, -0.00658639417365287, -0.3657437128194358, 0.12197037537254299, 0.32958354571256177, 0.2076165820213708, 0.2844351572162463, 0.4541586328672779, 0.13179277416014648, -0.0988382055340185, 0.1542539150313331, 0.29916569242772223, -0.08285882077541754, 0.5009210761463141, -0.18840758025668164, -0.006516578137225188, -0.01627887957342957, 0.1772414415659915, 0.5420284715637411, 0.3744742713311313, 0.5671454128911327, 0.04246434959332197, -0.07141203996450698, -0.22870141168409347, 0.004515456571232993, -0.386498457280777, 0.3075018407340001, 0.11815491673979711, -0.09414231597558119, 0.19011363807032503, 0.2629527119849643, 0.3229730523568256, 0.4528429591993208, 0.3798917890514355},
    {-0.3115907704639894, -0.17035295220092703, 0.2826833828263992, 0.06237794235300674, 0.42748451254880143, 0.6178543870736658, -0.2204386755348122, 0.36763926548536563, 0.5489628607444923, -0.6537500341062864, -0.35417793434358563, 0.3494089113983753, -0.17020122290630474, 0.4390151481129349, 0.07703963226049432, 0.4676992522021377, 0.12031096250591354, -0.4214666935416418, 0.4722880785683845, -0.5119026936738249, 0.3301679657295616, 0.19809058331970247, 0.7151784977431752, 0.3661571579592342, -0.27167141339256307, 0.3420606619310169, 0.6283919378512822, -0.40928414517333916, 0.03259666212677622, 0.48931305497364114, 0.3652400986154472, -0.05732582408370573, -0.32963306698489475, 0.35946251484546243, 0.34040389369073515, 0.48172395319734823, 0.6244684374616183, 0.2293344653246936, -0.22082815454011992, -0.4122300433745366, 0.2668871853512099, 0.3507168087984801, -0.2305899670497621, 0.25532178993025423, -0.10968905850821238, -0.6749931646873687, 0.26829863252908714, -0.28547888842838137, 0.29350514944804246, 0.15671575135944663, 0.7402765707599406, -0.2817559062124459, -0.6804648905941114, 0.23599835290942361, 0.44736021738962284, -0.4392137969050788, 0.22706969052527626, 0.059155449586259616, -0.32282857111098245, 0.2123300904365341, 0.45406229979691914, 0.2212407431624722, -0.07564748373860597, 0.41824728915821885},
    {-0.40560790635336386, -0.2996874848635972, 0.3944738341683055, -0.40450604723471545, 0.36331422590929524, 0.3840141627720601, -0.3503925706845652, 0.4328997174518181, 0.3689675147057045, -0.3524407356640924, -0.15223310742573376, 0.036871433177489824, -0.3262889396434856, 0.48185561013690736, 0.21017922169455716, 0.47884127606183013, 0.48491381303419584, -0.5666976286310642, 0.28827634320457, -0.3572443935595373, 0.3583815053615017, 0.47057659225577175, 0.5590270521524282, 0.3863005102269128, -0.30587840075155925, -0.11707837305871091, 0.5328655828492557, -0.31164456181558686, 0.204225288574552, 0.3912996772391861, 0.04060880481792253, -0.27724910049721796, -0.4122534800891058, 0.37848621772122515, 0.19842177386946241, 0.4722511872966172, 0.3737499175914057, 0.6889100965710893, -0.35162139315261365, -0.4052331736853981, 0.26782294039417226, 0.05022256877105432, 0.18542465572937603, 0.31650978545047953, -0.08282249423381409, -0.19668383184907423, -0.08891195759949454, -0.5529349196966172, 0.7349973147425124, 0.32187539999095904, 0.6666660209708078, -0.5501757434725153, -0.354821318412564, -0.06430147223271888, 0.3805949538477991, -0.3601557713040549, 0.35040147488796797, -0.041615399437814005, -0.33443065924217225, 0.4152957229384476, 0.18336640176737307, -0.15532950062400097, 0.4854714139578611, 0.6138672309462576},
    {-0.637728029334343, -0.3282389448326463, 0.1416052113481373, -0.34221489061743593, 0.5357900077264808, 0.4332472778215754, -0.4874730244517041, 0.4370364209321295, 0.42023184874176833, -0.20318550686054562, -0.23502679601328574, 0.058483641730016266, -0.385818003307367, 0.6553352501345678, 0.6198675667692441, 0.5544992627863953, 0.26088169079570384, -0.177479158411916, 0.38831626877551956, -0.3147403334230885, 0.29365450795468767, 0.6653993362901641, 0.3254514222936175, 0.6031502607435302, -0.4321010353770477, -0.16678711551259268, 0.6813129450174515, -0.5172915143060268, -0.11160535049090313, 0.4765522300080519, 0.10839323061926232, -0.3935417701867023, -0.6025144122614652, 0.2068670880027545, -0.18766113264996526, 0.712638790193832, 0.4284625135152242, 0.38763338538763886, -0.40603605756317485, -0.5070817468800644, 0.18743792606435042, 0.13176211565910795, -0.19032019431513106, 0.230156624393385, -0.4785352531037636, -0.539039391507228, -0.048507409975659804, -0.14498886720659077, 0.4276432703085704, 0.17699816049925576, 0.3795603253186604, -0.36985394179043685, -0.5958830875602096, -0.13751930808336882, 0.3535972515058331, -0.6395287734218879, 0.593074548834548, -0.284556775860095, -0.6815854129707464, 0.22729548138958192, 0.3237258994638579, -0.16521405634368694, 0.5746994031271019, 0.3056823272007627},
    {-0.6041866971400904, -0.587317100714912, 0.0596933699962818, -0.4530342619888857, 0.5707650658976426, 0.5119011776005493, -0.7694684076763892, 0.6527121100959784, 0.4307152991602048, -0.5033864348260543, -0.6685140633543334, -0.3854861352704145, -0.3063635290602953, 0.457778129822421, 0.26173476103808624, 0.737730688687637, 0.377448189238636, -0.6824260160744938, 0.16442950601534698, -0.5756084015891877, 0.5098345332583971, 0.3495211920378027, 0.12803059109047768, 0.3708350972620209, -0.47050875503919687, -0.1332049148102188, 0.3685230317207902, -0.47530460755153037, 0.18079909264452218, 0.3669499534507786, -0.08953231160338435, -0.6365493478210859, -0.5979455625942686, 0.49943159609136295, -0.39728234254519706, 0.5683206360261791, 0.6704183506119631, 0.7216984691789755, -0.5282149372747124, -0.20794469542827412, 0.013252478897424157, -0.37906334311530715, -0.302158397472397, 0.4688629575171661, -0.3603716870797597, -0.42039156724894927, -0.0490942054134203, -0.43287498488212667, 0.4236645538936559, 0.2894253607738568, 0.5471351851718494, -0.6438730405234407, -0.5592037633683762, -0.20712335237217336, 0.1782485733017802, -0.3215061112128191, 0.23935361180251252, -0.2430495104272153, -0.5294328724596995, 0.46911803140127956, 0.43060658166563454, -0.467509872858205, 0.298378048904266, 0.45138007184425827},
    {-0.6645996388097271, -0.45759253497597296, -0.052004215300678835, -0.68228773899195, 0.3952330619310582, 0.08043852763765644, -0.18463268197300778, 0.46957635445643653, 0.04727256817698414, -0.4882660348968302, -0.3624137128360975, -0.5795670869376265, -0.21348956623396664, 0.6224435415835919, 0.35348769932826124, 0.6417099176435627, 0.21683435944278553, -0.23659820705563683, 0.2282121078711918, -0.07975878594076902, 0.4507124059022749, 0.5968348537378734, 0.201118623824508, 0.6274075647860287, -0.43300465108150993, -0.09391944858408263, 0.7159078462680782, -0.7404732890052008, 0.26037617046274997, 0.5000369707823796, -0.22319335904569618, -0.5161703662910666, -0.44782785251864693, 0.4550457179670335, -0.4681227899342121, 0.25454815269228676, 0.5055992919804374, 0.44101901266728544, -0.260474122171953, -0.4447128901686204, -0.18719300583209347, -0.08062903074177163, -0.036117552623862625, 0.245597800238974, -0.2708203401317642, -0.529106275607705, 0.37801379564717913, -0.6603484522125672, 0.50726973802494, 0.28750149798430846, 0.32770976411642017, -0.652402363449481, -0.3696410607321115, -0.21632244416879026, 0.08764427299988892, -0.5034601248950571, 0.4552360240199846, -0.1222625420432867, -0.5468574552470432, 0.2748381354244084, 0.24927789574977943, -0.48095080858040457, 0.5393451275241956, 0.4850482458224251},
    {-0.5221259723176944, -0.14236706276034056, -0.1731257908059594, -0.6385732202582662, 0.3786722950599085, 0.34382355680590887, -0.350081906353642, 0.47308781568431285, 0.2509639841998169, -0.782805742564983, -0.25974728126304264, -0.3247310127740813, -0.1993083394485841, 0.5892546988497815, 0.31514926121800824, 0.46070159310188863, 0.12615377539708994, -0.3696936557792542, -0.04271753880037904, -0.24714131228671124, 0.5605053532838766, 0.17869933046156125, 0.022818107546593122, 0.6678282852701659, -0.5436362036923107, -0.11709215118894452, 0.7616268797098374, -0.45589839208816657, -0.057581001121245354, 0.586860229324281, -0.34487834168349635, -0.4432414352562273, -0.4655984067501198, 0.148772212874903, -0.491349054525482, 0.4687191727538331, 0.5464541587918186, 0.5790908135014375, -0.6679854759369572, -0.23185867327756005, -0.05916629021314825, -0.24972394553854005, -0.4831615884001173, 0.44793883399092094, -0.37487828317488014, -0.250786520097424, 0.2793311106114323, -0.545850117708989, 0.6670758501884005, 0.17533010725590933, 0.44522773380591646, -0.6380857175129465, -0.20059785912864553, -0.2797599828988424, -0.17095343618059594, -0.5898349336848908, 0.4128000367367613, -0.17864154015640227, -0.5722401675970821, 0.5961509575859776, 0.39948069620315946, -0.5294051168411138, 0.5130643107221396, 0.3896182958825979},
    {-0.6035106138451901, -0.36837735764388463, -0.21121444791842392, -0.2281980614787507, 0.270307066880818, 0.6009670361763205, -0.4143534898300703, 0.2921613252158515, 0.0329959009532243, -0.5280154563747663, -0.32763015234456605, -0.3805064834540077, -0.5173490300070852, 0.8121616716318361, 0.3626444897889957, 0.6087380757669775, 0.03581151238766296, -0.607644386552515, -0.030648781969979857, -0.4745578124065858, 0.7373576470525293, 0.4398812154790683, 0.179556571870828, 0.15754995943824426, -0.6035238665269925, -0.30711675088478796, 0.6871359534510294, -0.48014838099145557, 0.05812011393489434, 0.6530043493709534, -0.1474578996520576, -0.6747475693568453, -0.2724190213202656, 0.02297948688482812, -0.2851638928014836, 0.34127253527142876, 0.31742317398772146, 0.524020731467955, -0.5188736531033683, -0.643152955190023, -0.1220579777896179, -0.02279739883431925, -0.5475878470878631, 0.6544700436324773, -0.5594318155431515, -0.23217660396985343, 0.16512567406099782, -0.3553483725727201, 0.82303002754187, 0.2459867895740697, 0.41159514109847506, -0.542876365328546, -0.3245760829705349, -0.2465218690769869, -0.05423780020685125, -0.6550130624504252, 0.14399157862418077, -0.10201197661044217, -0.5968375903863637, 0.5353560036277436, 0.16081830505071049, -0.821182014864647, 0.4769655718750665, 0.33948297844232544},
    {-0.7952638792936433, -0.5035296372642095, 0.09341402335861866, -0.5692290866580976, 0.28538901902792024, 0.29098463069007185, -0.4942099190067278, 0.3678500640155235, 0.059195153868129936, -0.5489151958872681, -0.5586652718295468, -0.2559473446609979, -0.4833113090679026, 0.4931781038537522, 0.42056293337344464, 0.5358896887278748, -0.0956878023471527, -0.4273407275028133, 0.1983468326647831, -0.2576495256448145, 0.45536915891644664, 0.3161849885629344, 0.23052662540580582, 0.5918945006676161, -0.2481460516666095, -0.6028973405424474, 0.4259380648764578, -0.4093940308891327, 0.18180134882185608, 0.41137981925281203, -0.25130268412321044, -0.7720349055240154, -0.5340979702354136, 0.14111989290202293, -0.29425064835046666, 0.2905143718499896, 0.46426774452292546, 0.564883884740028, -0.531335051468129, -0.386060710119642, -0.10065123240638296, 0.19693045896918546, -0.5768823895218294, 0.310385664627002, -0.5972551152748431, -0.4849122851780815, 0.057860762447963655, -0.34867320495828424, 0.6003395445474407, 0.189640475124185, 0.5074238502083606, -0.54311617546318, -0.44003068179225047, -0.49233116570109586, -0.016298577667950943, -0.564689964533201, 0.3031676897901473, -0.22837187673980885, -0.8524760272028827, 0.49607774257262754, 0.1205972292551211, -0.4800371215229758, 0.5892546642467129, 0.7050860324147578},
    {-0.5008825719328727, -0.3669992181337698, -0.06885257086588531, -0.6156137372021739, 0.2852621362271151, 0.36241777828750427, -0.14928901404600844, 0.561380450869217, 0.2212767263513188, -0.5780241358695729, -0.5484428982917186, -0.2290591074308827, -0.5945054456399889, 0.5475407771947538, 0.3239453976548384, 0.6585982634020303, 0.11154614200366231, -0.40042840951995173, 0.1384502693102864, -0.49171419573476727, 0.550939714453766, 0.49572593148644784, 0.2542101929662895, 0.47900972147081283, -0.5494155829850454, -0.169062310547035, 0.6446728427949815, -0.6877948933538772, 0.23898950549822887, 0.3599234137463324, -0.17914590007601972, -0.6254225565233673, -0.5410623938481536, 0.5134405510597398, -0.18225649910611633, 0.31257059586274544, 0.5256300204275575, 0.15776487210746407, -0.3981458317455221, -0.5443038777818644, 0.13957176506551652, 0.2520459478461352, -0.30290622329465977, 0.5394968236419713, -0.5232223795433353, -0.5459099757532923, 0.2588398950154214, -0.5894681037399903, 0.5389390848092915, 0.384839367459827, 0.43485319416379614, -0.434750594385419, -0.500815523856589, -0.16964626632742527, 0.129562679634139, -0.5399959405182451, 0.39322479788032233, 0.013712734645510347, -0.648253476170771, 0.3765224707261049, 0.3303358862091824, -0.529655703813097, 0.5624727301772021, 0.5340044336077572},
    {-0.34736687313209075, -0.33312559132312913, -0.019300670416847493, -0.4670599142386571, 0.2933183196145527, 0.3109813025859209, -0.22389302326711985, 0.2781782032376954, 0.0365283966045385, -0.6138613749020543, -0.33877114126762037, -0.23141837167854015, -0.3855237459596162, 0.5967584331266631, 0.251699900323533, 0.3842688667349572, -0.10812438294464483, -0.39756678194058664, -0.03015879733389268, -0.6226225034489764, 0.17665291170666014, -0.07369190666478873, 0.2399315854673648, 0.00025306231987728896, -0.27282005433619855, -0.2863462936680026, 0.4546960454432262, -0.45077543621834887, -0.07083855637667172, 0.30750181601813453, -0.21957372270975134, -0.4411739417346366, -0.62055486700634, 0.0009747431569675472, -0.21511080701954122, 0.3536961345588791, 0.14684348963674526, 0.3115747606569286, -0.5717079384486965, -0.383405316992169, 0.000363484588954223, 0.19498637780047814, -0.34842385568510914, 0.26207557613034654, -0.5112199706651167, -0.5548296556257168, 0.023171758495449588, -0.21612885450602068, 0.29256874751870326, 0.275516076395525, 0.584695181730236, -0.274645378696391, -0.5211433317264729, -0.31194054196281346, 0.17626535765264162, -0.4722691869193141, 0.011001723297864634, -0.14737322827717186, -0.6589026931850527, 0.22505920017615902, 0.055395147365584485, -0.3781048053375543, 0.25287165468134676, 0.39939163507270853},
    {-0.5882019737733465, -0.5341933845269924, -0.23386794620064208, -0.38885457724323086, 0.13407215381487908, 0.2234100163337642, -0.2666736281406799, 0.1326311422399934, 0.002673227838595949, -0.4258524890970906, -0.6025867088256687, -0.4054516122674125, -0.35077674629127803, 0.3034969347202288, 0.1001659299421634, 0.46384479184209687, -0.021135501843327516, -0.34006024119422296, 0.028449338151702898, -0.3911276982304352, 0.1637347121961504, 0.10477894907239602, -0.07491711916244768, 0.1543182007163383, -0.34514121282257887, -0.07936560716878946, 0.15962946147315416, -0.7454873388767725, 0.028631949830817405, 0.20317409357243812, -0.31642611863831677, -0.45124332294289626, -0.5845558018954822, -0.048258924142456916, -0.7220304388902227, 0.539879691634599, 0.35397727623742353, 0.28407570733576115, -0.2716038862472583, -0.4616654253775258, -0.08284653671037037, -0.11997126691990152, -0.38240194281744205, 0.14767070967331178, -0.5936236208770298, -0.6054389507804373, 0.018885798979092917, -0.4516165112129415, 0.24297903450507366, -0.06481547500948275, 0.5961484629776529, -0.6362575251713308, -0.33914743657360935, -0.2196537755274661, -0.16214081877496905, -0.6970091050960802, 0.217694714211568, -0.413221106112169, -0.40314429703749766, 0.319917952647611, 0.07693489457352325, -0.7924597464495868, 0.2755634177099997, 0.7432387534883542},
    {-0.5897976731114785, -0.3167644079302548, -0.15846261821293575, -0.6342862344572537, 0.12242817740171652, 0.2978073023142218, -0.49930122468019855, 0.3812392367905485, -0.2496031314954837, -0.4810420791876293, -0.28424412687846434, -0.5046531184450076, -0.5860366330135253, 0.379910563407183, 0.2034151385032898, 0.2528384783433994, -0.02029775202100995, -0.4206970973392545, 0.4053072030640185, -0.5199802542876653, 0.29835520400882715, 0.2158170717325954, 0.07495838871469919, 0.1879596951790723, -0.1775684524394388, -0.43673514110805256, 0.3039026070070735, -0.4634716379716025, 0.081052812233749, 0.2820891708530799, -0.38473900263075483, -0.6646190352866158, -0.38239542498984475, -0.09171980356610368, -0.1733747557204896, 0.5461305320127998, 0.3544699960760394, 0.23664626802402552, -0.5207122477161343, -0.4048510780027526, -0.25800005195269693, 0.05770490705462724, -0.31497376608791716, 0.24872946025679718, -0.48212663116156784, -0.48334989642563375, 0.22064587759413268, -0.5177476491312705, 0.19045556041960324, 0.07068729371761905, 0.32527391267206657, -0.7250590363486883, -0.7604543052671929, -0.6356929721201954, 0.028435431563030404, -0.7153909640702186, 0.3909096160971565, -0.06336218535750343, -0.5965610779572615, -0.02577382673410458, -0.18904091351422725, -0.6663874249704386, 0.3048572489948933, 0.42156362177273177},
    {-0.4318548796932071, -0.23765707097685565, 0.0715039189948286, -0.5471180552312863, 0.3383952846287614, 0.3688883343779349, -0.29699207091188995, 0.1765315308691329, 0.0882634349213928, -0.9207434881529565, -0.4970572990981179, -0.37513924181666586, -0.2966600838423562, 0.27548054879286005, 0.27753059026423144, 0.4076693209028385, 0.0023555655011228914, -0.5579437240582096, 0.0677852280366163, -0.6861140440729929, 0.13405210862827766, 0.22950702429937153, 0.07189695754341245, 0.1946156330332307, -0.39416283078378267, -0.5093934104822679, 0.3896407413896059, -0.5003630769646862, -0.027585852298920823, 0.40898119922666165, -0.3366301667621779, -0.44328100885986027, -0.4405442463551067, 0.11898287951357193, -0.4686202093721596, 0.4487266899594623, 0.4782308112970041, 0.5111465489880166, -0.630166958969245, -0.2220105373809541, -0.29530828957022526, -0.21774547227305194, -0.465421464186433, 0.2455421349091583, -0.4643400662711491, -0.44068948561567933, -0.23262927364332325, -0.7972201151493657, 0.1275500226741843, 0.058945832433482274, 0.5122762779838042, -0.3928859575530443, -0.336142867162773, -0.27923274543049015, 0.04893210976880742, -0.47748775274661726, 0.2916669128226975, -0.20324076355883966, -0.5149871245766701, 0.25353707955869176, 0.11961109177416632, -0.22271882140112928, 0.4348649237384916, 0.5330299105405445},
    {-0.49979716735755664, -0.39205611390415745, 0.15037366085652246, -0.41267081561832275, 0.450393266765937, 0.21011638353819315, -0.3944579402242213, 0.5416518669183802, 0.05800869003561168, -0.5260845984111857, -0.6785606092710489, -0.6235507371825317, -0.6488530547977196, 0.4495075654900798, 0.6259192268934332, 0.5467468690473345, 0.0977106921936018, -0.34252832406580963, 0.041757174987745324, -0.5364757409307088, 0.3852205435733666, 0.4063987941490673, 0.262716311634066, 0.2744196250590963, -0.5447897034999497, -0.29798196729189785, 0.6522786388634924, -0.6386248732089653, -0.11422414859936823, 0.5416101260505137, -0.24652220936256558, -0.42742149877076563, -0.40200051080538146, 0.4448293026561771, -0.6119275001517949, 0.6161579066463706, 0.5236777838927278, 0.4637272484715889, -0.3388905140355317, -0.4855295363452358, -0.04719650506052977, 0.23090099981010376, -0.29619549492931546, 0.2608391605818758, -0.6702883881538679, -0.6257639048038428, -0.12834250060739683, -0.6469441991325707, 0.19287446048574622, 0.13170847078413392, 0.12991458203459474, -0.4204401665458383, -0.42888747146111256, -0.050006973971863544, -0.02428640631305172, -0.41399876076521114, 0.3509122893173618, -0.19445023750870358, -0.5313497413936944, 0.1847398377949136, 0.1361104019504539, -0.44489039608374187, 0.387986838910902, 0.2908009524305871},
    {-0.636454073681053, -0.46778154181997306, 0.31776793035032913, -0.5933336679295654, 0.38618496955625436, 0.5218362205663193, -0.27865541519551945, 0.43095910740110266, 0.2013477383820567, -0.6925379968863316, -0.21472979673134238, -0.3235634859302017, -0.7303585733596974, 0.4464173175030912, 0.36721133763873487, 0.6333090192744272, 0.08150250878583229, -0.25114463260647835, 0.183366190626915, -0.37351063068801704, 0.33338874857848194, 0.25530273228300143, 0.356533187299985, 0.539383610571875, -0.2990487183539503, -0.23982546176427136, 0.5698276845857663, -0.18327059392717082, 0.2512674771772481, 0.4151226167671051, -0.1009036137860686, -0.6255785159554219, -0.6036701485032372, 0.5974773743798674, -0.14421254025915045, 0.6385229799538065, 0.5442392396530401, 0.7111758021020124, -0.7542874702764335, -0.5603568576150092, 0.056253636953559304, 0.10767795227341703, -0.12285298578967524, 0.2193801905328159, -0.5744185710087725, -0.42253526692763005, 0.15821286649776567, -0.4181033077332765, 0.48846920707465885, 0.35392748449245726, 0.3925794193631716, -0.6435241702090526, -0.6281718508331641, -0.3170420850876771, 0.2731862887335528, -0.5435202051637654, 0.5302825456316178, -0.1652155914528697, -0.44197885945909393, 0.2484207076234577, 0.3657788776639144, -0.16971372633905824, 0.5154333883108356, 0.6017822296213501},
    {-0.544632693816621, -0.3618484965894867, 0.13819506851632615, -0.32061186926430174, 0.4310601162783461, 0.6196774701794228, -0.240341080607473, 0.5320271882480386, 0.10147077515402035, -0.5350683075598391, -0.4225550290919732, -0.05154119265643508, -0.5236868654284997, 0.43102528191255063, 0.7537263869359516, 0.4532879300377397, 0.24982202968143616, -0.44065837794395907, 0.3923711426173602, -0.3197171972925145, 0.3058105112196077, 0.5838325116742357, 0.3734501807340457, 0.7019667596973781, -0.40326730205391487, -0.10124923948236912, 0.5705508055898728, -0.48955421921924275, -0.0777446440945327, 0.46898477586125725, -0.0033960657369432527, -0.4262909920358106, -0.596321563787583, 0.43746176183798957, 0.10894373254165113, 0.2988994585578543, 0.5076321260077604, 0.5322174626988153, -0.44753336084634504, -0.39438799710248945, 0.20098295115857442, -0.02186119901551673, 0.0638284225305443, 0.17814505273122092, -0.26129672922479735, -0.6862760114412505, 0.15190535029242236, -0.15012972853276663, 0.5989025282378779, 0.4423642726823823, 0.49460702320909594, -0.5332926788747426, -0.30740045481058276, 0.05216618603359823, 0.08040273723306104, -0.5235489689682007, 0.6267195851905605, -0.11292471680592939, -0.5716069951429276, 0.54832331841552, 0.3455816585670468, -0.422700266111573, 0.5810858933791879, 0.6226800610501261},
    {-0.7404855628125736, -0.4259648800873617, 0.26520600180058707, -0.3356529893370564, 0.23831121972449082, 0.5683782269703348, -0.45710426615390165, 0.4557165481121692, 0.25169774196410677, -0.6719731585535478, -0.48998759508842243, -0.2566610915299704, -0.2107185518217963, 0.6308467983840219, 0.5971543548369157, 0.7171968288063733, 0.23002493783018566, -0.5528749560725899, 0.24744165479184, -0.29588142756461555, 0.7314901957629704, 0.5856743201864723, 0.5546187675818002, 0.6598705816963697, -0.47229605254997825, -0.14664808004655924, 0.5300370044212734, -0.370241901886582, 0.07701772934729764, 0.4770357347515324, 0.06455532880922775, -0.5278019176897736, -0.3501901790457771, 0.46568530463108315, -0.12797356647687907, 0.528135408175969, 0.6224673123411112, 0.28078368801967474, -0.39859315861696054, -0.2081097390923217, -0.01772895228962997, -0.15606365501874372, -0.09720832560023435, 0.35314824753574153, -0.4729831295711601, -0.6201397365993748, 0.14631705652692695, -0.17533468857308473, 0.5189898196178789, 0.1501178519948155, 0.6021620516859533, -0.37410732503882166, -0.4262577320997254, -0.15937711573209748, 0.23289564264947119, -0.6871849527011384, 0.5214043041146589, -0.24862769409016064, -0.42347184000822, 0.40876775026239653, 0.3593294898937845, -0.3032105719513657, 0.444794631442868, 0.504820719128973},
    {-0.5957072192770395, -0.3188330835440107, -0.017871775182657073, -0.46469167086133856, 0.423565615143531, 0.3383151294537519, -0.3208246912583214, 0.46205301744794697, 0.37239194123184527, -0.5369991651939121, -0.5024040837059469, -0.5521359655903593, -0.41523863713687137, 0.7212482845910385, 0.5058712596830622, 0.5255831275124581, 0.30742702566901287, -0.37253497400527374, 0.06578213501284443, -0.528092663494659, 0.236567040104976, 0.4311901206870307, 0.3133149593938919, 0.6657166186972734, -0.502808922480366, -0.19953365169518503, 0.37337634113475954, -0.3512193575435339, 0.023517353025976052, 0.4049112581538914, -0.2569386092426425, -0.6799060716038692, -0.3751400492960196, 0.1791895515499981, 0.019100537791624562, 0.49356488452742237, 0.4897644034571427, 0.7115682447563316, -0.5167045087749836, -0.3578645890680043, -0.18670155857193368, 0.03566663002620197, -0.18302528691241762, 0.31030272825629274, -0.4611837409189748, -0.44608776030220293, 0.23897481751451655, -0.42931919764152787, 0.7840465819123165, 0.38803547205148414, 0.2759628177592092, -0.5875226658078513, -0.3701812336043218, -0.19237563057362608, 0.055462747762173734, -0.48720565013153233, 0.6394626871037247, -0.001991638356821759, -0.4922909825639302, 0.41837015045482595, 0.2768983479615746, -0.1457490375150547, 0.5690696082846012, 0.5205442119058702},
    {-0.5907542006649226, -0.46446752040395745, 0.147754667104842, -0.2914246351712002, 0.38590329006142243, 0.4612941135777611, -0.5664854747267157, 0.44972436061316484, 0.10207645378262915, -0.6741944617903576, -0.4350410377999487, -0.3601875477634926, -0.5323310114013396, 0.4284656072204526, 0.4933808445881559, 0.5903572641676722, 0.2797026192993132, -0.5300945722139282, -0.06779241128563689, -0.37171546963966173, 0.4430617291648168, 0.2536598465440903, 0.21809998984223442, 0.6016142281435111, -0.172880653891861, -0.3633035563734194, 0.6503575745678919, -0.38893237462436037, 0.195446328112855, 0.4435714289218772, -0.16146119855296356, -0.9288233477392994, -0.4209864458775089, 0.19792034148598797, -0.10424558834035602, 0.6991696749272905, 0.5033059343803814, 0.49107071373206196, -0.2693613917668839, -0.42250403566144346, -0.3474840762513579, 0.11603041266648122, -0.32072744544218423, 0.34900839704584813, -0.44651377701381256, -0.5674433426395851, 0.26604962159801265, -0.5079251204713482, 0.5486346206593672, 0.13795101899528364, 0.6384686944627301, -0.6942729701442926, -0.5626396367305607, -0.5471444062530549, -0.04446070950856973, -0.6491606110187906, 0.34181903022327537, 0.15217152228129202, -0.6642895827097529, 0.34459992972073294, 0.44661364043997287, -0.1350136613181637, 0.6415827019990253, 0.6166443758476186},
    {-0.4414803728067511, -0.4184909596351095, 0.35933084257073883, -0.2362740371353318, 0.03448571885197682, 0.28147608116472245, -0.21062491012738466, 0.23028687038604134, 0.09321494916031443, -0.5411796069583126, -0.6221344118071261, -0.27254731918403147, -0.28458603397055104, 0.5299339740614932, 0.722383068620033, 0.5600397433120644, 0.46397656661001446, -0.6646217292428226, 0.124496519883573, -0.4857004524135677, 0.5251888873211515, 0.36306550487783046, 0.12074355174255876, 0.4016450377202541, -0.346991181753936, -0.38501597343239247, 0.704917471799802, -0.44474194110766535, 0.014998659982146731, 0.5856450032394391, -0.06820490306880972, -0.7120263088934344, -0.7005048038591895, 0.22909401810182875, -0.2361099750975643, 0.3674189190322587, 0.6542055081796296, 0.6558994554904235, -0.41782767776565, -0.260910052552938, -0.23245876902250814, 0.18412723462356173, -0.007850781182463667, 0.4596441984764482, -0.362448523441121, -0.5583156323282579, 0.04490361378185103, -0.39340104652125674, 0.5508046527161773, 0.2396868498274368, 0.4534169634337384, -0.6227654784777582, -0.3278219523737332, -0.08200955170160636, 0.3792708734477919, -0.5004385912279175, 0.5085060844600434, -0.1640014789770706, -0.7430143039715658, 0.6634160886204187, 0.39692544427524656, -0.4276516162043937, 0.7563288722474658, 0.5456591139566328},
    {-0.7759696435809941, -0.4803157617156073, 0.22353668342501729, -0.30509386231396884, 0.689838491905833, 0.5764483457381133, -0.22144927509091233, 0.6345890926788468, 0.30602601194998513, -0.34211657609425655, -0.7514774478931235, -0.2172526929404451, -0.27545294337293713, 0.45622138221711167, 0.48398440855068386, 0.6740469676801679, 0.3765441167593766, -0.5556265449911573, 0.11797999365906374, -0.5933347144238226, 0.36840372463409926, 0.5180885184688685, 0.39348567902164877, 0.39010889471677396, -0.45260020993931593, -0.00714741553205079, 0.5579020531854054, -0.2974060829366605, 0.26278940781241517, 0.583865862978067, -0.1829072513911205, -0.29857234563160956, -0.23557612708259948, 0.09789423121242727, 0.06664496085300776, 0.4376440529701138, 0.5795307385507179, 0.8266598824131928, -0.28928363324215156, -0.532732771882077, -0.036867230281970455, -0.025637545897575918, 0.010321857068561254, 0.46315696779478, -0.25028275016077967, -0.5099782170108528, 0.2466627951293425, -0.4241430997427074, 0.7287375224263115, 0.3282948559070104, 0.5001426815078129, -0.6039767230846665, -0.39742378037937914, 0.002069303745955672, 0.10630540636169868, -0.5126928524652451, 0.32598635409058024, -0.12256143900997246, -0.7565299639223521, 0.4344380501539199, 0.4621050387495551, -0.3230360600564552, 0.6688665904095167, 0.7622393598841957},
    {-0.4796325594241342, -0.11762528804095138, 0.36810963166091804, -0.256371216636376, 0.49588267955592946, 0.6267271662882332, -0.4161022751730289, 0.3905508499234039, 0.0799552135484252, -0.5352852746836118, -0.5025304146585313, -0.1014298158326415, -0.05246158973905457, 0.9048627771794189, 0.4746339989282551, 0.6346394549114788, 0.4157826520754376, -0.31759339740737275, 0.23299061290176795, -0.23114087610513423, 0.4647764931047663, 0.4714273441639378, 0.2757498066123648, 0.26609756386600086, -0.6120997836110722, -0.1287567118646412, 0.6317545509485296, -0.3351539888110779, 0.13002543327058888, 0.5698975802748325, -0.23907402055596724, -0.42998715673707083, -0.2502636914439967, -0.08114889227067973, 0.10685290648225204, 0.5133561085080438, 0.6878896735543375, 0.6112941049054454, -0.482728151223011, -0.34269593100072937, -0.008627398251214351, 0.10634056301337345, 0.23366643981874638, 0.4309010547293089, -0.2849809338523019, -0.5379149896889182, -0.1264705187684412, -0.2373500899840976, 0.5109065868338074, 0.585676343854437, 0.4943496553923266, -0.2934099965379036, -0.40820380956211905, -0.1471574518994811, 0.03508540235210057, -0.33928942641012794, 0.4213015734831631, 0.002014360826559407, -0.6033185105172872, 0.5283554938330813, 0.3553217833763609, -0.17678788456581346, 0.6372342886491119, 0.7523423452808333},
    {-0.49653102111012487, -0.28427107868598683, 0.18935593353776106, -0.5048485250220316, 0.5462132268603378, 0.4426691589435365, -0.3200926036448561, 0.6530749075360375, -0.1461845217409529, -0.5997914256015598, -0.2418322238869904, -0.01526739014559813, -0.410540994930002, 0.6570206537767309, 0.45409290810754505, 0.6382983718592454, 0.19973479896569296, -0.5480635866817676, 0.5307500705465537, -0.37320206589918, 0.36547892630064616, 0.36644314087470214, 0.631099750619833, 0.46185233775153767, -0.45921569069971474, -0.3456234697661667, 0.8323172033636423, -0.657476557527928, 0.27117688028872555, 0.6316486331844728, -0.060130222523264505, -0.6004700882658007, -0.7411812866675304, 0.21465859903087378, 0.1814220200768714, 0.5964707734612023, 0.40769762044852487, 0.33499001018482494, -0.1906325635838585, -0.5319841883056934, 0.3568877034437435, 0.1401923732292111, -0.024732589614966174, 0.5912457110483978, -0.24036886316647813, -0.514796302969242, -0.10458139296155188, -0.31712344543414717, 0.4479879340545673, 0.43895414957331264, 0.5650706722420142, -0.4533363607104914, -0.6700473093860897, -0.18533480108821646, 0.2704492404632978, -0.6873693518010947, 0.4870705766319796, -0.007496678640665543, -0.4831842846343763, 0.6024565587437337, 0.31360115485905155, -0.15954998678919893, 0.8911931237483278, 0.31259489266253654},
    {-0.6786996649316017, -0.5238763196178637, 0.209402070298815, -0.41661094785504976, 0.5128303218337588, 0.3789672881581956, -0.7229702407447296, 0.2612068695416079, -0.10924011429015759, -0.6549512799003906, -0.6237471737083634, -0.062300173998834106, -0.4478575727203103, 0.48917266711041996, 0.20194793035707775, 0.5809493347784666, 0.03679733001492384, -0.5407013541366159, 0.24222786582643008, -0.4415717136254389, 0.28645288918772677, 0.17252847650557954, 0.4739351796378005, 0.30808384887196416, -0.30218282499210175, -0.17127411585909516, 0.5583612231966529, -0.27658477851299645, 0.3338329249772941, 0.7149139069579004, -0.01524909120900363, -0.42010473727835107, -0.6407684726959407, 0.3889087072350032, 0.09625574478946579, 0.5182173287188636, 0.5103050099773292, 0.7852608137694502, -0.5076996244684666, -0.3315949994180979, 0.2759324522446933, 0.20787857044366098, 0.007519813791772655, 0.4915289033591019, -0.7847261053281184, -0.6265865296373503, 0.15632540941715165, -0.4608278433544042, 0.6201492595893693, 0.45940272142616184, 0.6831738260569251, -0.8331416314298056, -0.2991384391602062, 0.03755247725917613, 0.3810782429955267, -0.541706503352489, 0.35364400864388207, -0.08083381640525128, -0.6096768401379523, 0.34715491249117675, 0.26945873676176163, -0.4180742064530423, 0.7288674130096671, 0.6622375930501668},
    {-0.6162985856596077, -0.30519745934428866, 0.5496884143428347, -0.17251990143972168, 0.38723486813563684, 0.5195428861118742, -0.4987817134184182, 0.6643323318362649, 0.11243415005432551, -0.6726818381530091, -0.383005800488099, -0.22453486478628512, -0.3955412153510517, 0.5672830861764816, 0.47416035837206844, 0.4104420290109342, 0.034089357824604635, -0.59764964119507, 0.023056540316600534, -0.37316359574322056, 0.19707719915282407, 0.42267826675618875, 0.5223461902379266, 0.5624820869264867, -0.610238245361128, -0.4206820278697093, 0.3591528379734642, -0.5784922855157765, 0.28689135759155393, 0.5540563499135105, -0.2618316465082005, -0.6135417633980782, -0.589208400466618, 0.2675492355688091, -0.07169906649605193, 0.4355280639218513, 0.6423212931214181, 0.5083379766117224, -0.5515445664898457, -0.44111026585638335, 0.08706614875271848, -0.12313415216642058, -0.3195548460872975, 0.2370839564971405, -0.43415485808630416, -0.643235810473282, 0.06321262055034464, -0.35102670150850696, 0.5648232428345282, 0.2599896333806471, 0.838134185064409, -0.7778728758986996, -0.45700426167078034, -0.28200153082734636, 0.23133751417505266, -0.5345209828568932, 0.24458736315282714, -0.1259470356318218, -0.5980153607569413, 0.4703849242190539, 0.2300370500612858, -0.24289444260629683, 0.6285789376615999, 0.6450026635142196},
    {-0.4954556779705961, -0.30015620948984306, 0.1878357310758175, -0.2017969295112092, 0.4081479265086488, 0.29344725852367654, -0.5190542802546758, 0.6145415879742597, 0.21855340795119219, -0.6773359309255921, -0.7128185825087855, -0.05216384022433779, -0.2911294238499267, 0.27354678684418826, 0.46183823148890213, 0.522989114292438, 0.025204768468550555, -0.39614196485120656, 0.5120881879163967, -0.46313291975374105, 0.28587198738623204, 0.4666391829997511, 0.4553182240139038, 0.32000061749153064, -0.472067660590174, -0.3636770990357033, 0.368721167527328, -0.2833552998584068, 0.10719819237010915, 0.6816882174323553, -0.08215345199312761, -0.4415831881134777, -0.36917429706867844, 0.33685792295545397, -0.2717313621109964, 0.5145640227967628, 0.5755886107815261, 0.2649876656398914, -0.5910793001762947, -0.25601774542604894, 0.05384769117072754, 0.3041831957721204, -0.2880486813440432, 0.4384541752843267, -0.3236577158779044, -0.5821238042107623, 0.2143326013252089, -0.3602286698261392, 0.5194596962486335, 0.28381715920029055, 0.547201484097173, -0.47246557210063317, -0.48671940100330885, -0.15997354617251114, 0.3144184919462757, -0.44711364934434866, 0.45932137044524557, 0.07158805874702366, -0.6685126372230201, 0.56250887727648, 0.37425859062593714, -0.48500417041903243, 0.5302612085237446, 0.5359375335869769},
    {-0.42330044011686313, -0.25273506532688894, 0.39034378297964123, -0.43914769977788876, 0.5070099351030166, 0.45155474743491714, -0.6428706218880719, 0.4910995105016077, 0.24035861618190502, -0.651388870329095, -0.40874849389896273, -0.13962715707594864, -0.4798159791421612, 0.656034339383727, 0.6096097096423321, 0.6869932816396254, 0.3342258609769349, -0.48404176291943196, 0.42371274505498374, -0.6103040118876313, 0.26651377111108127, 0.5309645159922393, 0.6283465717127049, 0.6184091292650459, -0.41054538016041636, -0.35628372245548634, 0.5675419780977328, -0.54702912655069, -0.049237484971573875, 0.7255167605848898, -0.10370060163996453, -0.3134554766846172, -0.5280809255999924, 0.3382922878107531, 0.0029178064500810807, 0.38871336096967396, 0.5078157352724512, 0.6891119334746755, -0.4504387076039278, -0.3399593900013805, 0.27225907570639896, 0.06056249566382594, 0.085493936943374, 0.45600219156183425, -0.5937332281007099, -1.027733716729192, 0.06022022332639872, -0.5911376505740156, 0.7934052058332766, 0.4796542465440789, 0.6343123782144644, -0.3671790246077083, -0.47648289397249594, -0.16756156401926026, 0.2869296480039819, -0.7529986851702951, 0.4749261634002625, 0.2671133926736428, -0.5031752745826967, 0.43644543484921733, 0.33524565434169945, -0.3162270369670581, 0.5150239813148729, 0.7686557806547654},
    {-0.46783829797073834, -0.39147377504848513, 0.002753312507115037, -0.08342205470368731, 0.41426736137604814, 0.6957830795894003, -0.41927038233383, 0.6795043055017425, 0.22276563052728102, -0.5032684382756004, -0.4991556809797275, -0.18280392841721535, -0.3865889874355515, 0.5413775030228106, 0.3671433959914858, 0.5636220549372389, 0.07982187988111454, -0.6177248403753227, 0.2683314286058029, -0.46804407296971307, 0.2686417523703749, 0.2760785596448237, 0.6025167222015262, 0.32238932366170014, -0.49353245391387524, 0.07782265963155979, 0.8455956725874295, -0.5669465693648537, 0.364034129641011, 0.5377946534351136, -0.016999979237812733, -0.3236860016288047, -0.49228504705614995, 0.31094047664105456, 0.28910272285456184, 0.27985128281657257, 0.7475026391175733, 0.49677593265985104, -0.6873683888085935, -0.3847674274124375, -0.03199012554616829, 0.41111460860824617, -0.08298964849657457, 0.18060808039876391, -0.579451430784641, -0.4311825682412315, 0.11990988024960025, -0.5301667338309848, 0.6587192912569089, 0.3021813165787296, 0.5388976266448975, -0.6479256517414134, -0.3638209604365979, -0.0845935202072038, 0.4103731248238693, -0.4021291011508162, 0.5812379979570182, 0.2122812901194673, -0.6340307337385854, 0.3763600753532522, 0.4836697752007086, -0.14565392269347885, 0.5592660914216906, 0.5084161072039886},
    {-0.351123132998662, -0.32131837709329436, 0.21738693722573788, 0.08498181540438382, 0.7572713902312269, 0.4289792347371584, -0.34483751158572784, 0.5211374931513557, 0.2974901496600575, -0.5813278193179651, -0.3264209597669666, -0.150194397388308, -0.3591479751496274, 0.5688864928624745, 0.45523110549938206, 0.6787204201209308, 0.1260408696100654, -0.46770377297005333, 0.40877512750117034, -0.13668677428560838, 0.2615174187133085, 0.125275812926283, 0.49124241064311736, 0.31025105806281295, -0.14782532702170334, -0.11590729829717902, 0.4195634323724093, -0.5970531539658392, 0.2050175052738404, 0.704349636873881, -0.028781448729539135, -0.5183381568458141, -0.38783633746039164, 0.42404393014437913, 0.3159681222804884, 0.4929822403571173, 0.2013749043874437, 0.5307622868753237, -0.2628700291199704, -0.1928189836264542, -0.002756251170669655, 0.24908383056248398, -0.2682383336936099, 0.5793736042289639, -0.42760268538722557, -0.5858661466473991, 0.11139440663725654, -0.6160432030844909, 0.3676835998522158, 0.28114744097038563, 0.5065841974820843, -0.2489429636572707, -0.47507843549923684, -0.06788948642025212, 0.2274622338723379, -0.8232208232085066, 0.4543751134965591, 0.08562143579706578, -0.4737323773079377, 0.6194687143335373, 0.6942224817132053, -0.19757686388177872, 0.5995779857629863, 0.4793351309758627},
    {-0.17417008395001615, -0.2327382168920791, -0.3921722467656076, -0.5041056558927616, -0.37291846116914507, -0.3863095560401764, -0.2745020895481802, -0.2831059869310527, -0.33048373453240715, -0.41228282207062167, -0.47044565132187244, -0.4892195332226811, -0.38406937395109303, -0.34581776483752336, -0.43590509103339325, -0.33446702515671983, 0.03604210034618717, -0.1754005093957645, -0.4547654768043511, 0.11026931042295526, -0.5580745857233909, -0.2396714974847235, -0.09975765860911595, -0.43240669693940126, -0.12871787233885812, -0.30494944940378954, -0.4671563627282483, -0.05144350558834382, -0.10630471862286855, -0.13790342744073059, -0.38728865015378566, -0.3708947584126546, 0.027832982215399926, -0.08358511841412326, -0.2532669983747224, -0.5277762900701776, -0.2707138567577901, -0.6414729713638603, -0.395312533050839, 0.08768154146384266, -0.2454315314804866, -0.42409260107530694, -0.398726999033807, -0.0023018536561844887, -0.17054554314718806, -0.38388920795356923, -0.35054713239327395, -0.09472285281561026, -0.7199207077957043, -0.09468290659679758, -0.2283392648725099, -0.3935594639646659, -0.2829540996329862, -0.5253738029201614, -0.36693043058545777, -0.0011809406955852148, 0.27001731499166837, -0.32943968687625846, -0.21834391628127725, 0.041769859437456314, -0.24410991290641307, -0.39691582316402857, -0.46376920834539437, -0.3040577244860698},
    {-0.0738333429829829, -0.16341100863280628, -0.12735173512409198, -0.3442049272300868, 0.09595608274485747, 0.22267378038855123, -0.2853331203912118, 0.1454102123989106, 0.3426694418274763, -0.16341536245847357, -0.19085428012381092, 0.010136701134651609, 0.006907343821910736, 0.3046937468009097, -0.1293635008872329, 0.13370850597577696, 0.16520402097871784, -0.3803426759325065, -0.09443756659483556, -0.1868699020586702, 0.1865772535029691, -0.07467240721072664, 0.5113073322580636, -0.027940383345452492, -0.24112060925202636, 0.0891801564801808, -0.27931926648236316, -0.5381063101695617, -0.12003036987367155, 0.25260228469578755, -0.023916626337683624, -0.5440001513365492, -0.09668291414213684, -0.00540603942860001, -0.10886242163539017, 0.3193054269677365, 0.3607238242555898, 0.1653436723468864, -0.01758823830939878, -0.33843909934153255, 0.2603251206812191, -0.10090282484821778, -0.24789480698790237, 0.23674072633051896, -0.039645820562054096, -0.3856312361409533, -0.17802643817039818, -0.2948063457924651, 0.3152611545748749, 0.42733025837141253, 0.4202423577795034, 0.05492052422646578, -0.16489410106262128, -0.19405422474267617, -0.21221436887287143, -0.3808353547152564, 0.4722179875415401, -0.16017888183630183, -0.16289171966366386, 0.22522167374748422, 0.049931550968684145, -0.4006065773757517, 0.5078435634955256, 0.5532868588264948},
    {-0.17705404211694772, -0.12575983071768607, -0.5424037726554565, -0.30940981972728904, -0.4467661099776078, -0.17125800744777456, -0.25370287559223575, -0.27635256597856606, 0.00694099371809439, -0.18329525720238926, -0.28827573794281286, -0.5374617365202928, -0.15904975797348705, -0.20061580795356412, -0.204629250841721, -0.23450669494226664, -0.08492893251659889, -0.3885745516512285, -0.3400630277379295, -0.015104417242456088, -0.1944449958499399, -0.11218909014348809, -0.21291562455970395, 0.16102453848472487, -0.3846381191472009, -0.7277386451907608, -0.24903994590495634, -0.2755467439314412, -0.012199624327975849, -0.05993030542162143, -0.409364994826149, -0.2418952689940408, -0.18494803852404737, -0.2378171190989811, -0.42661843164293967, 0.10042482149091049, -0.16100518642133252, 0.00427842467413294, -0.569123776407093, -0.10896212461719883, -0.6073949017800059, -0.5291503376783773, -0.2610909616456575, -0.20145203888906235, -0.4186764642998487, -0.12666333174413613, -0.15586897259865376, -0.057540349877629286, -0.3181374163910409, -0.26739386081347727, -0.07509563301016142, -0.22508504996427575, -0.11935118429271989, -0.42332234692970433, -0.4793290230823383, -0.07007591706301079, -0.21212539645735673, -0.5593971656313007, 0.035126834962044044, 0.17688431330729387, -0.466540480295693, -0.21649400226180462, -0.2895771758749665, 0.15528202223632537},
    {-0.21249626214812142, -0.4192477268451819, -0.5182123675392619, -0.24767322565377994, -0.328565551755035, -0.3425644573238601, -0.2812221781281787, -0.48574770223081315, -0.1211571094496029, -0.13801305062323888, -0.7548288898750495, -0.4212401457631336, -0.06110914414696265, -0.18022626147908624, -0.26004529819117655, -0.3179050379638859, 0.07901687855898688, -0.09859612734674052, -0.12920921340286173, -0.17541318138256679, -0.1049014690942662, -0.2540834144393701, -0.17085710594228543, -0.16327830887274858, -0.5173276354192675, -0.5237761817764175, -0.3503899334141659, -0.09413518409969068, -0.36114973796476774, -0.07687644812410281, -0.624823490639754, -0.27188987435197814, -0.2190070764002384, -0.04873325154303857, -0.3482938603744715, -0.30272692326973305, 0.11657917856955653, 0.024495962439723677, -0.6055958732741493, 0.0272070845535609, -0.45952559581934493, -0.3319783023396085, -0.3468425613901538, 0.1767960345483737, -0.34193682026773586, -0.11064601608247758, -0.26074772847806593, -0.281556194929303, -0.358826175516055, -0.3060043568533862, -0.04969921513012812, -0.3355938129456633, -0.0373734819020884, -0.43040538394124667, -0.6788271509590152, -0.38196858202791356, 0.2502325010252258, -0.4871174570397822, -0.11365298146911414, -0.25586463793432795, -0.5212467113603914, -0.2649568185207055, -0.5370611078777957, -0.22254784942130956},
    {-0.534087509225122, -0.2958656071682723, -0.43386148063412505, -0.566897678138911, -0.2684987051600906, -0.15991702603032076, -0.3405783332144026, -0.36436948110195483, -0.11005436912351772, -0.46143240933312424, -0.3837557202378795, -0.2757539798352307, -0.012774086774563372, 0.07701840521035339, -0.1576193369011215, 0.3266199591960674, 0.17614242916391384, -0.2470944864807615, -0.22847006860992483, -0.33871127247632216, -0.2631223786433278, -0.01945790805117336, -0.21349145057898594, -0.08349610533208178, -0.34217564904824077, -0.318662385133334, -0.11698625583220126, -0.34619185606759373, -0.10486432782708446, -0.05953739462745456, -0.4016935830785307, -0.25131015363766845, -0.5647986480485581, 0.053122383624090504, -0.13785196800297386, 0.20119385072236654, -0.006430256972640376, 0.26968211950055143, -0.7679796152504216, 0.12096066360945291, -0.15733155722324313, -0.5072068643601216, -0.5006841497300498, 0.2264200636095073, -0.34060852384973184, -0.2614902800489367, -0.01944053661775134, -0.17662103074241955, 0.05222529249660362, -0.030153638281350766, 0.03497174366456463, -0.34677174980837283, -0.2644988874218822, -0.4366026841898134, -0.2394950321805727, -0.15030646341239637, 0.12841524130373627, -0.5287570198311367, -0.20742251197090172, 0.03274190135122872, -0.46098855167848546, -0.274418791317509, -0.09164983520961059, -0.004309931022430548},
    {-0.30730752518648174, -0.1910228538033186, -0.6789241485545566, -0.40443617985095154, -0.2924330874535308, 0.020820515137585156, -0.35465714705391654, -0.4154357807204087, 0.12638851486113623, -0.1972912969668022, -0.38695327533666835, -0.6244970071440109, -0.20298225670340228, 0.10973537558794699, -0.15793301966610257, -0.16747573120202588, -0.06597075300281251, -0.11792809272088325, -0.11160035080605599, -0.3675360934864567, 0.24370554056533913, 0.17651984757142086, -0.10645464426493252, 0.032968809405610186, -0.24449542608992572, -0.15496329246222437, 0.12729798325254363, -0.28746431859148275, -0.12165810451340545, 0.1318825317912985, -0.27528838457338495, -0.5582193251626043, -0.09625320224029686, -0.17024641588569248, -0.3874920775203658, -0.0754472351375712, 0.11264933410771168, 0.046765250019850595, -0.5472444961447246, -0.1158126989455935, -0.4280687825368696, -0.5308505933096153, -0.43788868459784785, 0.20945755584951103, -0.07721967904103079, -0.3101364656029607, -0.0979784430865216, -0.041144312291939794, 0.10307322001822404, 0.02794359933664125, -0.1165902105538484, -0.20655025638446, 0.17161616691231615, -0.32777393701490204, -0.5334912589730099, 0.20400358269579053, -0.03447462064394983, -0.37308288754808727, -0.18463262884859036, 0.13364863114715353, -0.36865437625335506, -0.17880003413159862, -0.1706883684992509, 0.047783057795482864},
    {-0.20514959432373814, -0.022335855994694204, -0.31841530432642984, -0.30908449226026075, -0.21656512261706362, -0.21469429300484302, -0.029825953112703047, -0.31243726734174737, 0.12512180120921565, -0.08339799780369621, -0.3689052033772706, -0.23748097041943508, -0.08711783205425956, -0.0771756063749488, -0.07301142282205464, 0.007224395417424444, -0.09565966071144298, 0.1580949606357341, -0.44135988719710545, 0.2749283500685453, 0.03465499676759852, 0.003209042894813925, -0.1909331211463666, -0.035965593538150736, -0.06248483951194259, -0.6091844033803678, -0.2588237794361663, -0.1441342056367353, -0.02656895199500771, 0.28023274715952423, -0.7172201880010377, -0.3934980153729032, -0.42252032829347014, -0.12269202553679416, -0.5242604418765168, 0.06878814827934587, 0.14285942181984587, -0.13376685849207093, -0.24964642017235678, -0.12023053755026815, -0.2705646224257582, -0.4326231047296454, -0.5843047314695726, 0.07278990912090884, -0.14657201888326235, -0.003572422997320119, -0.023696869914208944, -0.16529560304495236, 0.031379246581267756, 0.07081554602679824, -0.08704921681281635, -0.2913002927600538, -0.32165407782410077, -0.36654479772417325, -0.33100916287584325, 0.11914149627839427, -0.09411529253240448, -0.4715478994647629, -0.1996221008276975, 0.21627446722974022, -0.7398864476372569, -0.3298031800816969, -0.1080000177390046, -0.03680800677577833},
    {-0.2508033188943289, -0.2795619276153405, -0.34063811219305257, -0.40704608270598985, -0.4729934325588829, 0.19998698859235292, -0.4259373936300541, -0.4088151841095258, 0.28241336361857095, -0.3374976722333709, -0.5990731562007497, -0.6785695697073157, -0.10740591996159822, -0.014211881729740689, -0.25328636159954615, -0.05738095405691599, 0.09482704712725801, -0.19128218457382767, -0.5694676250772427, -0.01383319791904785, 0.22043956570330947, 0.0287581799280631, -0.3974646554293251, 0.02119236215086925, -0.3299994620611534, -0.42491191377336873, -0.030164382282170808, -0.2961143803265814, -0.09012562486353229, 0.08262506837175751, -0.10267056252082056, -0.11321336490713561, -0.447049903658429, -0.06110865482316235, -0.3267564335583812, 0.07859477909289987, -0.28013084126174465, -0.15452436799377423, -0.7922748928320801, 0.03374507336351452, -0.2803702419106895, -0.2548725237315005, -0.23585530124930448, 0.07891187500839468, -0.5157370593663413, -0.1682622659408306, 0.141250095330104, -0.2620986702624472, 0.08508076616611915, -0.27656187342257543, 0.0927828200660484, -0.3442121924209125, -0.22387264025248715, -0.6351802025648428, -0.5950333321480119, -0.2576283008662561, 0.08684342125789357, -0.7075384635634453, -0.3044617700129372, 0.1169712530817467, -0.37673550291622476, -0.3221748697672017, 0.022609634260229557, 0.11212247036746766},
    {-0.15529230326165705, -0.17754350132329483, -0.1716764345323581, -0.7049585039475365, -0.44928631812644415, 0.33433073133740054, -0.3140631728770118, 0.004719003131443192, 0.13230161533925067, -0.2443020243902169, -0.5330251468931977, -0.5321727740428374, -0.10517926698625008, -0.1299131254984432, -0.07243368979703096, -0.32126752900974076, 0.25283742660005004, -0.18412885589009736, -0.3763370195949803, -0.37887735560264885, 0.27274821109933595, 0.04000787042039887, -0.1757227327492593, 0.012685741916574669, -0.3363623158050026, -0.2070674873206414, -0.1411879969034939, -0.3137158144943954, -0.07818080482488904, 0.18396770239621438, -0.4347765662989786, -0.3751367081622647, -0.13829933396753188, 0.09571186905256823, -0.14769890320629417, -0.07849128200250795, 0.07424683096859043, -0.05845288327810531, -0.4994215428515323, -0.1167755272300423, -0.5733578029996876, -0.2573150075459325, -0.5425785212703759, 0.14424912296428127, -0.3843295217659255, 0.09268365207471546, 0.24576055316006354, -0.06457783686218582, 0.20769039155325297, 0.025204247764123347, 0.27710968590170715, -0.43311221300150615, -0.22866013143488043, -0.44512917384252393, -0.2878261507511518, -0.2771196623977281, 0.3281512902884658, -0.5147417893012061, -0.44495725350798615, 0.10454622711583278, -0.18458400361145888, -0.3193359613777562, -0.16232258090640217, 0.1460686861136503},
    {-0.5067195519443102, -0.024678437245180897, 0.008412455524925224, -0.6855144116831112, -0.43285568060400376, 0.18445022760202873, -0.48782312677408396, -0.3768531045654633, -0.201084876196253, -0.5078588919091765, -0.5141762883322382, -0.5127401131480964, -0.1427126179508626, -0.11923629483795589, 0.06502313467738577, -0.017489149738221594, 0.222743423614274, -0.3179958530732228, -0.24803237381684792, -0.17024224343547295, 0.10705356029531142, 0.2815396538500419, -0.03688528992760864, -0.04043382998071627, -0.318005785259783, -0.5236575290042366, -0.09054371437666085, -0.26728855014946235, -0.46334244863215435, -0.044442673711330295, -0.3341142118624223, -0.1555987002786257, -0.30745430965107146, 0.059958974169936397, -0.4452042756210037, 0.37617326910930804, 0.12767985904699564, 0.04932747310310884, -0.2925598789284311, -0.13675663903032256, -0.6038879187502978, -0.38908571129926933, -0.521756838371642, 0.20477300997333725, -0.4518658705627376, -0.12325256555961397, 0.11620533327296345, -0.16898941206212564, 0.19938282799453125, -0.23143783285976083, 0.2427573208663914, -0.6045641223050472, -0.3612591923471156, -0.42557430103247007, -0.30315346252335307, -0.29276798395408715, 0.07337781682539057, -0.3724170900332526, -0.24480096792618852, 0.06301472041394862, -0.317356842940399, -0.3552249806988416, -0.3691038559775614, -0.1418856188396467},
    {-0.29609530860317257, -0.38110190850468795, -0.5002552588050144, -0.4167489041409192, -0.7719416935234186, -0.03912019900765573, -0.2100410079698522, -0.5304775217536281, -0.01660905625846655, -0.5653998180198352, -0.37450616933069913, -0.29937241244976237, -0.21411613988653097, -0.29789630500590647, -0.3373954730078444, -0.21644802266871627, -0.062302084438659776, 0.12888762220598504, -0.39614818958594267, -0.11703785962454513, -0.3466403380611463, -0.18643383267473307, -0.6249974197324376, -0.13646127937370928, -0.2976590694618574, -0.2602862002555594, -0.4483586110364344, -0.457064507091919, -0.09718342328977309, -0.10783208824712055, -0.4634761716853319, -0.47547107381761716, -0.27462678153917247, -0.14664649384770198, -0.36809019592767306, -0.3112915814266818, -0.22152521986779397, 0.04632571247106564, -0.2916260095921882, -0.012603187365134112, -0.26985760837190853, -0.4915639604747785, -0.5873857647687236, -0.06151071278813071, -0.16990960168726005, -0.007526528721279428, 0.0781745375876978, -0.010174602046751828, -0.09394291428298111, 0.14534427981854695, -0.02169406930674395, -0.2537177102628116, -0.30442609227158995, -0.06327268198743687, -0.20307201179507797, -0.02168557324350881, 0.037208391078821346, -0.4784346965313511, -0.4062753749666288, -0.004490752588548357, -0.24429931733783514, -0.4531259366128101, -0.3713274650182466, -0.26208609324855947},
    {-0.5280909277361877, -0.37039700747168675, -0.46632071999087765, -0.47538845907375354, -0.3179870380043784, -0.16007848071264927, -0.4268264009042122, -0.5351629277702735, 0.15986633143614157, -0.5981404282623823, -0.3558096388047754, -0.49597487979662447, -0.42642360417698405, -0.1619713755523285, -0.34515195902020235, 0.011363701544173902, 0.14585745607884404, -0.24123238336143965, -0.3177866707859818, 0.13788319727644768, -0.10429547231362744, 0.003185885067794311, -0.2991476659951809, -0.13031356246712836, -0.7650201380109555, -0.6124999446068079, -0.3695787652667888, -0.3809008156089131, -0.23382127429683144, -0.15344885992667484, -0.6034010549259693, -0.40397939698282853, -0.06515236665050086, -0.49499835802794945, -0.560624433449661, 0.10326427011122259, -0.2993142305678646, 0.2318306055747349, -0.3842185903233493, -0.23402940033678765, -0.47943864249042617, -0.3935957399924887, -0.4922959039494692, 0.14650070529129575, -0.2930208673742023, -0.041415899779796074, 0.00485565525969141, 0.166800317950507, 0.08164962511519797, -0.3604446945078445, -0.11338987449069711, -0.16472677297598484, -0.28393670902241264, -0.5899178438331304, -0.3276332643801383, -0.23444962611407588, -0.0512416907967992, -0.7456389684953504, -0.525589554204371, 0.2766658212062496, -0.16150698872799416, -0.3491348352319116, -0.19658990803104714, -0.0750403963965205},
    {-0.38096960734353885, -0.38355554865915886, -0.2988624325892712, -0.33400539287034475, -0.2544621215891664, -0.08174687015400224, -0.42506958245162985, -0.27005541019369717, 0.1809003949325672, -0.593188359321473, -0.4967125863844253, -0.478373630367449, -0.08475673795910883, -0.049821098909777914, -0.2551259878986074, -0.11451320281818517, -0.14079462972165213, -0.39158599824492796, -0.4174897468587718, -0.13526362744922812, 0.28277114972878276, -0.13155308344829658, -0.019414471635397872, -0.09075926117558458, -0.5633894698103799, -0.3288572458094027, -0.02451155789860616, -0.35859300142947276, -0.21850591686974852, -0.2898066627220505, -0.4755492022798507, -0.4556659385905333, -0.4101590684691366, -0.4612688165322557, -0.27502656466191866, 0.2922141470210393, 0.125088017552701, 0.3420000095763251, -0.4632961668958164, -0.18755483044392593, -0.5577220645105063, -0.4329244038948284, -0.6794029419205487, 0.045829717021302264, -0.5277688359601861, -0.2187966018143221, -0.17119776656624086, -0.24874153102153293, 0.10501988660183324, -0.17919081144235394, -0.035943860089091624, -0.557305424260615, -0.1463347656678897, -0.3998222345769235, -0.24473601671491957, -0.3579232333772038, -0.19827897216362017, -0.7505617251664097, -0.4152392144174158, 0.2766985509285861, -0.05779309316386698, -0.043565925482640946, -0.09353947861725467, -0.0626968032077394},
    {-0.6433770987249303, -0.36431113061213055, -0.40338265496400405, -0.33249193622262346, -0.5369389182468779, 0.04867674917849176, -0.3023788329740603, -0.1584581928463638, 0.07806759762136493, -0.44851226699695784, -0.42900163303751576, -0.3679965861907229, 0.06913862068162044, -0.06235806421455226, 0.020291287047951936, -0.11145341387720445, -0.0021564366629575503, -0.5113699381510907, -0.21196869524712578, 0.007511379363188409, 0.17783639574999202, 0.043266723070672766, -0.3720423629561626, -0.15360240586816656, -0.553910779208834, -0.32412326531980373, -0.4506854998856535, -0.44773649193901255, -0.24506368926200553, -0.13977953597158982, -0.42410004104133964, -0.7071604130562944, -0.3493214763327824, -0.30822329735890236, -0.2790530271508342, -0.12063505331800474, -0.15093003153595572, 0.26669568867414595, -0.47880429493394727, -0.10634329282465432, -0.41256187152345447, -0.42771336181731257, -0.5879553681551484, -0.03511072261293891, -0.6005895919557279, -0.31710391529950843, -0.00204486590116844, -0.08477362402797783, 0.08014805105001852, 0.012599015006315549, -0.07833573448319682, -0.4838664799999145, -0.2379832370783038, -0.4850559866209318, -0.626879755448187, -0.1340535475273237, -0.0677541631464854, -0.736539140004932, -0.4278876539599272, 0.17659158699490565, -0.35049938219420373, -0.4648073844395079, -0.30191580142738333, -0.09526134432367644},
    {-0.44465645988007785, -0.27051736534568616, -0.38887379763224633, -0.34105727700731586, -0.3076604681809264, -0.04444865325146337, -0.5068857073001846, -0.4192530836217694, 0.4081724550022599, -0.07486842555730372, -0.6360869216274939, -0.2788384668259341, -0.32742252005506906, -0.06026488644202038, -0.13972340354890328, -0.26576796286667814, 0.2383896292282798, -0.395868257673162, -0.47743226281551615, 0.29428670807931945, 0.13646737524582728, 0.04822467698686892, -0.32110725694905073, -0.01939998567730976, -0.4658170679009943, -0.47099213024449593, -0.17526006025094176, -0.30307754555922095, -0.05035163365584206, -0.08718500865882901, -0.5540232338860861, -0.6298769045462242, -0.37843428453674877, -0.10814386800838648, -0.5881013720697265, 0.20454726620970767, -0.013812715354516876, -0.2506482276494198, -0.5316903741703967, -0.1933246787418253, -0.5930402047253577, -0.2697982198845408, -0.4547264321294597, 0.01414524599916761, -0.45232301788839824, -0.1871322956542069, 0.22271753804078703, 0.28372882119723447, 0.13068849687771544, -0.44072951992660886, -0.10459841480532031, -0.4810931710852992, -0.35274076606968874, -0.4929726935763769, -0.49561120416190774, -0.4662437699627241, 0.058305678665208756, -0.44296138157023096, -0.2366702191998906, 0.048948601817679425, -0.38691567177699354, -0.20890667648000624, -0.08861395947743367, 0.039713527917689104},
    {-0.47864753491555134, -0.11787289362219801, -0.4569921935171412, -0.5344973898868498, -0.4120853688680068, -0.29234268727640794, -0.44201265240526866, -0.457776627797666, 0.07871023244676242, -0.10546220054048393, -0.5495947799158775, -0.394876170643763, -0.19399748231685549, -0.38437628816693, 0.2510924943880406, -0.12611943697613395, -0.03954747138057135, -0.1440829148570369, -0.42392477625402925, -0.13854112701658655, -0.33607576931045147, 0.20043618916075048, -0.21793518793978234, 0.22454352152585552, -0.7652560982349487, -0.5416314532056224, -0.16869650161597138, -0.46803672527323187, -0.3032400076579653, -0.5113045029802328, -0.24221907286151523, -0.49413600621340803, -0.10530486393515365, -0.2059434370226983, -0.5091342612833198, -0.0864096774113938, 0.15555354509030953, -0.11441442705459909, -0.41771555016289136, -0.14101416888081175, -0.3851486109867622, -0.4974068314676842, -0.22804715466200945, -0.14335439086950372, -0.5628999553530788, 0.06078615345209592, -0.07242310844970185, 0.15185665086957761, 0.4000237063973538, -0.2030326403476853, -0.11010315676074982, -0.3317029882453922, -0.27740754165346315, -0.4692895590744306, -0.5135866710549758, -0.08899849291114306, -0.2526959274393338, -0.6884042893902427, -0.22345569595634338, 0.2780482540271439, -0.4218245633131055, -0.4562452780666916, -0.09786402979072921, -0.004381184026212445},
    {-0.14872380273036456, -0.21773956811955722, -0.27877577284864685, -0.47783269933216704, -0.5115609711858412, -0.0025946156527537514, -0.29058033560663427, -0.5763871325958453, 0.14748896290975377, -0.413971193183005, -0.34678029037308433, -0.3781363517709828, -0.16211204023127784, 0.0024093549123655428, -0.0667139444936602, -0.2550266893303293, 0.23712605215267538, -0.4495001212870564, -0.44571614442743324, -0.16861920090358878, -0.175911306455921, -0.08561322740079012, -0.0799098167138538, 0.012166086038320938, -0.48331553741577105, -0.5535048441537278, -0.48146270024746707, -0.312507058248494, 0.02602136931196599, -0.04347344824249245, -0.29349793613585445, -0.15637461458148266, -0.4621936144373372, -0.27622505727560037, -0.5188854062229072, 0.16134068291325196, -0.2644119263343571, 0.1552983015318408, -0.5774125814622728, 0.010533465954849384, -0.6907740183262088, -0.554990313914981, -0.5723327909256696, -0.2585284347236535, -0.5550420758554424, 0.15900460456613413, 0.03769279081301344, -0.07672978741669871, 0.0056600301954452805, -0.28833100008876655, 0.11430460920335885, -0.25488398308548993, -0.4128947699173499, -0.7020446725994464, -0.31184613803716416, -0.34530031119321775, -0.00897946565666524, -0.5974321125532477, -0.34097675861323185, 0.1576646396742542, -0.24269207193371345, -0.13907098709016402, -0.28556674131202486, -0.04656624640169564},
    {-0.33285053018913974, -0.18144651185124755, -0.17468341301371787, 0.02718915455780679, -0.4467902337791676, -0.13153041480138175, -0.14127859346280316, -0.252671461180712, 0.15101629649202378, -0.4905280050853372, -0.19340867082380722, -0.1685685857206251, -0.22973950695586365, 0.11930996912162145, 0.14244432028467924, -0.02459075760126938, 0.3762298205382545, -0.24590785140951385, -0.355243562220827, 0.36346174070566456, 0.3246613102825326, -0.14433135757349067, -0.16434355490653532, 0.17584443549327705, -0.3763863226763834, -0.46870138447326326, -0.027930262030791183, -0.4492296733378853, -0.17358999922951565, 0.21425380633537747, -0.14547203933471334, -0.28661562784072947, -0.7255440573800389, -0.48797004267413513, -0.18273441435389212, 0.045862740253626876, 0.1743729729846323, -0.06534404048319008, -0.220083475232539, 0.3390884495663553, -0.7309815576462229, -0.40937949261936857, -0.22759072630465504, 0.14438800444618893, -0.518516132571047, 0.014900742769602923, 0.020411905421273028, 0.0654457442323478, 0.19669008310409627, 0.11053182350927547, 0.010608512119537415, -0.4238402244673882, -0.4234451530618335, -0.48292853288652837, -0.5768765440498578, -0.1903255647573396, 0.1125692606230618, -0.3845615803497528, -0.3079642584522146, 0.3426949389838524, -0.025524175453224496, -0.08019156990152419, 0.12233627430692431, 0.20549213386691048},
    {-0.4253901130005118, -0.3709086040454845, -0.4820609919353443, -0.3864984842654526, -0.5293199005306444, -0.1500230989201592, -0.23676523695344565, -0.3479201242873257, 0.38049381594119397, -0.1291528041304284, -0.38214284240363805, -0.6131228303751753, -0.3739841387034932, -0.24577529245096413, -0.03294154505363314, -0.4716818705280217, -0.04659526569501577, -0.14396776451127946, -0.20239387161777836, 0.012639869968787064, 0.09548249108959583, 0.38237587111276217, -0.5169671034345342, -0.1443590044808422, -0.6972365037265147, -0.454392464171107, -0.49336195738561683, -0.5730034012019657, 0.13827136718218652, 0.07121428458869697, -0.5077746629855661, -0.2565636663201017, -0.312415694343523, -0.3469035917263341, -0.43136212370317, 0.26649632452673844, -0.041370849771977206, 0.3342134653392392, -0.5200646939049036, -0.0938240790532367, -0.6095971633988095, -0.43865162630318155, -0.154609050780367, -0.1835809976532143, -0.40319215105672984, -0.1672370726817179, 0.005811445326319751, -0.18367850437888533, -0.34237388890926973, -0.08223573682880822, -0.12618303037454637, -0.6471390705373432, -0.09362752728167784, -0.4570750599725895, -0.40738829720343045, -0.00014730776281053103, -0.4180063516511713, -0.4461993314597762, -0.4324226880562831, 0.12216876894466318, -0.7588693727480421, -0.2598730115763248, -0.37521418707781745, 0.019952796114769487},
    {-0.3650667567082562, -0.3127361664909005, -0.6230683198658348, -0.5723968286950251, -0.7506747429284675, -0.3512948760036035, -0.38755056016746864, -0.32532031906214615, 0.07087285601775593, -0.010585256382274859, -0.5321071247550725, -0.3365632319863759, -0.3128638398546422, -0.1571104383822517, -0.18546973712984618, -0.23918704931777077, 0.20820027325525936, -0.16384690096496207, -0.4956272560953622, 0.26866133922429863, 0.21180158175108127, 0.15442109435497142, -0.41924462388396866, 0.0886459988521749, -0.6324409568133248, -0.5671604082419136, -0.5431107130148625, -0.23893512440782264, -0.26622296500437564, -0.17231724973578572, -0.3452583953213174, -0.5291517554677921, -0.2746659498267539, -0.03255467773953428, -0.40290382396248864, -0.021709657712279517, -0.21028392821174466, 0.07135647968949596, -0.6485154677108546, 0.02754034941545952, -0.28937699292178337, -0.5838870525692195, -0.5266959840462666, -0.023525565060591294, -0.56638871739985, -0.058626450581874094, 0.09511907443943574, 0.09680960660546555, -0.14606232733327815, -0.26240631087301786, -0.1585787144339205, -0.4559653868850626, -0.2656152256255751, -0.4023824800750071, -0.8119448942337827, -0.1758692829607182, -0.14010714427354726, -0.5871490867602365, -0.31359435897192994, -0.026220866955340653, -0.42104703427380175, -0.2844624648663951, -0.18804182504328218, -0.0512967890912562},
    {-0.32631871008947383, -0.4098943527354728, -0.22225893777534075, -0.7716618651737834, -0.3599052047525606, 0.055232769551199726, -0.3791225719770279, -0.3183587399878345, 0.08179148295725652, -0.677658960414724, -0.7126545407271578, -0.4861254652434088, -0.014828842672753192, -0.18420584076442723, -0.056304790069852347, -0.3668186783010768, 0.05122966040393104, -0.20593600265753717, -0.5288667883107332, 0.027176719530952454, -0.07402183137073, 0.0036045124148156426, -0.3303490926334198, 0.06848033769239438, -0.589599377527625, -0.4647938665715368, -0.39880495699325486, -0.3103777723377162, -0.06992287037336006, -0.020051683251992063, -0.4201443090265952, -0.4078036393295185, 0.07684800738011675, -0.019643414923046873, -0.5577725032093291, 0.20442800416256363, -0.06493018521375254, 0.15183866495681358, -0.5186830433169989, -0.11248600938195844, -0.33638887239846393, -0.4019271526813014, -0.49622590097860614, 0.11059283891075236, -0.3435977344129719, -0.2964842464220624, 0.1713237886213859, -0.09548267539419729, 0.13751811530212962, -0.0012893859675903307, 0.019898725365721286, -0.6148372724743182, -0.3308822370749822, -0.36963380396475914, -0.27093045760426354, -0.4395458476693852, 0.11271154210514554, -0.3238595785481898, -0.2336913681566051, 0.2145870007787958, -0.6061352841610206, -0.19290524970652204, -0.38756513908727647, 0.03279575548347897},
    {-0.44657287849726496, -0.44488330791670033, -0.30718759793269124, -0.6398875190550787, -0.32930629505889675, 0.10579813438042024, -0.38368747982214096, -0.038265463914857065, 0.2300606082594777, -0.1211239915937848, -0.4685489518248195, -0.33435124153563023, -0.29228790351828865, 0.22072731851524452, 0.31955233001268496, 0.020007610077211455, 0.3230757205914501, -0.46243934810128545, -0.2837408362915361, 0.08150866482351442, 0.3446343223658689, 0.29734610765065345, -0.36030367391259377, 0.4393251555874811, -0.499394948800644, -0.4404674223645243, 0.05577111613589011, -0.6265233069886255, 0.015790160287449062, 0.34960726907827455, -0.655105049825226, -0.5125232970674748, -0.30043893613158823, -0.15040256508657063, -0.376682362384214, 0.15266112501491902, 0.24704015885305333, 0.3723647681331152, -0.4048065646125206, 0.1112031503875068, -0.3043171289769641, -0.48903538147943326, -0.3200260082633142, 0.19269613486668966, -0.344139871194129, -0.035456791532888554, 0.011043730778543159, -0.16150861591493165, 0.33223984477909446, -0.04249519642320218, 0.13725549488641625, -0.37476997338708173, -0.2779610847131393, -0.5950958206459525, -0.21133978175260462, -0.3021876123360919, 0.5347365002982079, -0.3440975022761906, -0.3332869925458609, 0.26284919990051225, -0.1022345330044772, -0.2829208377594966, -0.1861535478349697, 0.48368794528244247},
    {-0.5116931709563305, -0.3411017058008244, -0.2849240925512641, -0.4523352784292135, -0.4281081780460946, 0.11800311857465741, -0.2256716279238448, -0.14837450494174348, 0.1504786518907302, 0.004814951522136276, -0.2510524030105546, -0.20775826310295767, -0.1387589915657348, 0.32152313682085115, 0.16465099091583488, -0.10726877811683493, 0.1359899788929661, 0.11637441764159781, -0.22974083719562566, 0.3619538792985147, 0.3389825289604625, 0.5184979895983028, -0.28193057543981853, 0.367098220160307, -0.34861609463434895, -0.42647793380894805, -0.17428223461145942, -0.21595280887981042, -0.1535066111226986, 0.2710420184604927, -0.5838553310853788, 0.25861636469038307, 0.14368744594092417, -0.28408186738262203, -0.5729713947310494, 0.23910190794005143, 0.10195575844255926, 0.43781367298919316, -0.6733937771555019, 0.12127873799625832, -0.4790384665376226, -0.43356958143304447, -0.13387404393271118, 0.3312253710195362, -0.08415855284288835, 0.23966057059484386, 0.23106007924688177, 0.09689957565764885, 0.18952515085313423, -0.13333098522213888, -0.16745086355526112, -0.1719672737668103, 0.015011161162454085, -0.4428103792000879, -0.6744534301434364, 0.19650825456545315, 0.15576500632345883, -0.36812097055532794, -0.3463983861210665, 0.21687541518608183, -0.29397786957598127, -0.1360717554376354, 0.19893084976810307, 0.34301666524583413},
    {-0.3346810414346404, -0.3809956784570825, -0.4059275565788477, -0.5011152448852974, -0.647036351753239, 0.03669373713686973, -0.325866214732481, -0.28759261194097946, 0.20161674822246453, 0.07200485515873968, -0.38140530482412677, -0.6441400677983382, 0.058742458145086454, 0.03867711419372015, 0.501524371316793, -0.49537128751492276, 0.2926476463942499, -0.06350417697109145, -0.4509380913448821, 0.11046792299239397, 0.16029795283837733, 0.21214674813580828, -0.1843574785912287, 0.04086818556451539, -0.8387912756053013, -0.5015682352653503, -0.5211663050467295, -0.2516386257141094, -0.22782159719465844, -0.1665144874162253, -0.5023002835854538, -0.4324208668728744, 0.12425648536232006, -0.17659912130694838, -0.5232382066999993, 0.19400494645832064, -0.11856872802274138, 0.06352110965223338, -0.7067685257915536, 0.015527303722739163, -0.48231848226472174, -0.7853923039238162, -0.1095463775598743, 0.40305910705792947, -0.3339993572430318, 0.3962509655825406, 0.03014684201574256, 0.3316496620417955, 0.32193445407597915, -0.11742011337696727, -0.09782892650242832, -0.3789225840980813, -0.3973194489312016, -0.632384301604297, -0.6795345098870909, -0.10604225495985878, 0.30710549344027993, -0.8013490525760115, -0.10462395388980579, 0.26304702436172395, -0.4378240827946934, -0.5021387131889541, -0.13015303362823738, 0.02723377266921382},
    {-0.5691905552511922, -0.5298104620549399, -0.5524084038823908, -0.3986413524999514, -0.6543321586515157, 0.10257054638855537, -0.3826512722339735, -0.5050531241873876, -0.14440009379942306, -0.19815989793892477, -0.4703717419587976, -0.5345241354571638, -0.24719584116282808, -0.19031875778257448, -0.3801228759602075, -0.500015228167255, -0.20079471121176376, -0.10171164183607767, -0.2378636766848851, -0.041043919357762894, -0.02394686902758255, -0.11472827915725618, -0.2555014617516481, 0.2053199746174672, -0.4809769713586123, -0.28927431819028043, -0.492724463084076, -0.22382253466887747, -0.2326188518682946, 0.04679191502895501, -0.5324584942262136, -0.4943498809549471, -0.29338365989228343, -0.15491551756234945, -0.5337413249298241, 0.41153937630978055, 0.027863295172536242, 0.2038147275156055, -0.3323076652667646, -0.11207672760479502, -0.38770536945373685, -0.3564551106198077, -0.4969300761526959, 0.05932252869179633, -0.2122816300981392, 0.04837817724773101, 0.09661317147602554, 0.007583241956354154, -0.2143533582923538, -0.20721254976242548, -0.06908180322696159, -0.493712750372856, -0.25606627450198116, -0.46478925814375766, -0.4948933283416527, -0.17607368881614258, 0.07737812032605493, -0.5097778523285449, -0.33860748019761994, -0.0003539100114946721, -0.4396318558685039, -0.2558820756932512, -0.3792512812914665, 0.06777934426279483},
    {-0.597086105597399, -0.4940418322459813, -0.6101492998238136, -0.18934529270589184, -0.611600199027885, 0.026319089868035057, -0.5070120187231563, -0.49351891316931457, 0.21847028445428898, -0.0018401022754178566, -0.3991084791924566, -0.29363059769310257, 0.036077263344128356, -0.004661699029056221, -0.09550299307457775, -0.07597196667359286, 0.12848133854091276, 0.016616827985204995, -0.41642320801198496, 0.3365874419061436, -0.013711455434228125, 0.14824538127633002, -0.23297821256107068, 0.3157266115369415, -0.5551654446253578, -0.2984340507659443, -0.27997168561172014, -0.5699716763078819, -0.10678681768347113, -0.264317491909389, -0.5356099974272329, -0.05241473010797292, -0.17860576174845766, -0.18548771025332716, -0.5154318840215073, -0.0670836354331958, -0.44619458904637216, -0.03611645699163971, -0.36425338915039895, 0.14616378753527404, -0.3954820344116924, -0.609476966176233, -0.5092670624968593, 0.002048765405298008, -0.2364958675233837, 0.33067641575739165, -0.0072979037632715455, 0.2865116991473486, 0.05644387672774536, -0.2143401270301079, -0.4630094729557283, -0.5458527970977486, -0.30155571908540596, -0.571723217745606, -0.8786256017326722, 0.13950131088630116, 0.20865496297309566, -0.645290438520359, -0.21182984876042904, -0.11189907690577838, -0.2918505798662664, -0.307484048020073, -0.45115985611196785, -0.16273225667799304},
    {-0.5018317732935932, -0.2885384422895565, -0.47037195313423924, -0.4302053466513036, -0.5620134665792528, 0.28395579516292235, -0.38481238664567835, -0.46954604528450833, 0.1577803839015106, -0.3300984132647508, -0.270271409583542, -0.552846966085312, 0.19389212455151156, 0.3194369516036402, -0.140274000567411, -0.026253952435058698, 0.35676173712160353, -0.4728229434205821, -0.5203893927332578, 0.20873032433306077, 0.30347447422060064, 0.24314519154881684, -0.3344270708547894, 0.3976248940057433, -0.4964291716604098, -0.7490573536535955, -0.38265671048518646, -0.729515305476396, -0.17789976194421206, -0.02263376496350254, -0.5687221120201624, -0.4102131669988215, 0.11284803176244924, -0.2631289459403782, -0.6863835198627919, 0.10925676171420856, 0.18930864233267233, 0.09540941404126389, -0.3299256310439801, 0.43571468118648227, -0.37325040254880454, -0.46156311983526144, -0.41090225510579315, 0.28276421294578563, -0.33063023829802607, 0.12403903679378808, 0.260669048824294, -0.05542043364247348, 0.18835146652641827, -0.21255706099818403, -0.15549637043706704, -0.5517247205326609, -0.34225454987682863, -0.3336393870471159, -0.6155229808778456, 0.018448024883043077, 0.29368088129393793, -0.6922187857441149, -0.28058946713489635, 0.2405906845397247, -0.24504364257080408, -0.4214450660716307, 0.06442115988071434, 0.3189771488824745},
    {-0.3957732821815891, -0.4084421938902072, -0.47934604374599354, -0.6791792680673079, -0.42186623479570035, 0.14166050202511235, -0.519263613763942, -0.5011145422413923, 0.07725268895921894, -0.51288585812395, -0.5111858927762154, -0.39190116882612486, 0.019470872080090927, 0.0007952167608391661, -0.14974961842246845, -0.29061059525127786, 0.24631891854375765, -0.1423622374630654, -0.4600342157023356, 0.013621496458449813, 0.17807937384749803, 0.10742771603614377, -0.28063837959799803, 0.051299444612196474, -0.4936570287055231, -0.5365720780049404, -0.4201940246125868, -0.547246085944051, 0.01882072384543832, -0.005881243470793532, -0.3904683700182673, -0.15781294647796762, 0.08216030042968653, -0.07511766953129513, -0.725416971277865, 0.2608294994215786, 0.05005902572159138, 0.05885479947190279, -0.5017029193281114, 0.1271423164742283, -0.38198527804634924, -0.32432923790773727, -0.661810694260068, -0.0002826211377841582, -0.5050486759854838, -0.14430793948060913, 0.03908686489660913, -0.17601413726674808, -0.008587589924163648, -0.28739445069989306, 0.05618795336790107, -0.4859194258434539, -0.2815104476590154, -0.3851030075365443, -0.5541071849918071, -0.5534212540482251, 0.0027488095479029956, -0.7713724094652232, -0.26634653399694097, -0.09381680915742574, -0.31781188680967526, -0.39721310116333586, -0.17401191841237848, 0.17047853433569155},
    {-0.2810034338014981, -0.26894446032544217, -0.4014628231467084, -0.5195579321568564, -0.6339656841675372, -0.013481027736010854, -0.2551162615754605, -0.5397845792946017, 0.04095721157062363, 0.14494806045327321, -0.5756103383570279, -0.4461205202010014, 0.07036518667782359, 0.12248999148071343, 0.16782090586737825, -0.2702657047261631, 0.4564133208884272, -0.20561711814826722, -0.5250414779928275, 0.2455850817076119, 0.13515992168911972, 0.07063347648885246, -0.29301491929955326, 0.15998926599383403, -0.765691559492044, -0.6888449904316346, -0.25811418812263365, -0.21114456375764382, -0.3401089926413363, -0.000671484850589637, -0.6640763714787379, -0.4789993134398201, -0.30467517481890294, -0.33263044889560417, -0.774983286296146, -0.0801047883203534, -0.12201464954840509, 0.18288247671074634, -0.5039519459603395, 0.26647212234837064, -0.4644110495723449, -0.4852892486752472, -0.28747375097009054, 0.2500376682013594, -0.4437372419484228, 0.3075528958706939, 0.11683980529705625, 0.09995016436349825, 0.19230341111818544, -0.24930711667449304, 0.05826804696043286, -0.7777286290410992, -0.2255230684126162, -0.5656104119625969, -0.1993561457374228, -0.06748605044611572, 0.14174093415093142, -0.6318522362865672, -0.35619301796963604, -0.02906461812935285, -0.3892431493508874, -0.21901775737437942, -0.18767356961045703, -0.2571479369299637},
    {-0.4250104479927013, -0.4358526651348801, -0.5604519226449703, -0.3051991890487605, -0.4749035177257067, 0.35725212244477367, 0.021953746549874135, -0.4581431324209766, 0.16932114121673877, -0.4342157717561386, -0.43945517989330257, -0.5485844453897518, -0.08036533645207213, 0.3854782312740993, 0.2728713318406247, 0.07366382165288435, 0.3840932729471681, -0.12086209687533789, -0.2779906753102672, 0.1316206381317807, 0.1987345688989127, 0.26904364366064915, -0.23849933875081333, 0.1641198889111499, -0.46571855764894354, -0.3934649022979046, -0.3163373274524977, -0.3574934983870706, 0.1368105541375462, 0.061193876824347446, -0.5790599623204534, -0.438396128631813, -0.08799517626941568, 0.004454988582155393, -0.46586718288909534, 0.19186943198084777, 0.25236697613790865, 0.23064260622588273, -0.19597065149889906, 0.09540391778237024, -0.4051040314631769, -0.740212599335785, -0.2996953161188814, 0.12328465121116329, -0.1755034172918601, 0.2455289807015582, -0.004323050515651685, 0.21179585240645502, 0.062123576837266714, -0.100674761395028, 0.06844723653498186, -0.29023907819436046, -0.26348010021373036, -0.3308314010450269, -0.720492240208279, 0.0540669221871482, 0.3201310914277893, -0.5953499250091969, -0.3090361199923606, 0.12075518789700475, -0.17415327674608538, -0.35128888643910317, -0.16965866973351793, 0.18947426104705123},
    {0.012811752954090363, 0.2774960772383702, -0.33285226019263636, 0.25876728754847206, 0.19208017383238396, -0.152763529753221, 0.08088199169511504, 0.14134588381662147, -0.3918661210520675, 0.18702781533907004, -0.3752913035215872, 0.17306791800458413, -0.3511416803465005, -0.1760537941311087, -0.4075303560553839, -0.006643184462237228, -0.22115258422516568, -0.19060928446951816, -0.007826751983179787, -0.2566585454717763, 0.023356057921677546, -0.5093328736374565, 0.47204909057385563, -0.43688000987347264, -0.1837465137118415, 0.29596208344940445, -0.07584618878460374, 0.49382532969989107, -0.337290064761304, -0.29694599644727687, -0.09812856573052285, -0.1556630099202873, -0.013285029986636103, -0.23400003260666455, -0.17764926792614236, -0.31865449685796604, -0.26158053723249614, 0.1964023124707723, 0.18728876673465072, -0.4520795746379217, 0.3716823801560327, 0.19622877222177282, -0.4171362582913788, -0.3593125647514681, 0.005473040762990964, 0.14990664209512702, -0.34230480571513655, 0.5405783065968037, 0.1252844635010381, -0.46211282073100346, 0.07312786650101832, 0.18956545073695652, 0.13495399756433973, 0.41547755787964, -0.10870615308648375, 0.0714198787643468, -0.604550659278162, 0.049488088906708916, 0.2808977249508652, -0.3891946659559266, 0.5554786129572947, 0.5486557656811815, -0.20293777073395153, 0.01917633636358519},
    {0.3470640763579845, 0.26626391906585756, -0.3593724574866237, 0.46183013066487416, 0.06056565732644042, -0.10869345125111456, 0.005860796000469844, 0.17095315878424008, -0.37881739166389417, 0.3531706202627365, -0.3627063899004323, 0.2790079746019576, -0.20360560948315468, -0.6576102567512555, -0.5087528393904825, -0.06327198411058604, -0.26580060529188143, -0.030097217142663887, 0.20707139230320146, -0.17905997329921833, -0.13485699799339176, -0.4596779640485834, 0.1322379191118203, -0.5590057441292845, 0.15599944359721474, 0.399294226656785, -0.08197150574998087, -0.025928584390083057, -0.12186348443021221, -0.19159506079474842, 0.26800233058478184, -0.257418928171862, 0.21078303017250916, -0.36264258101318486, -0.005677359183322772, -0.25207229484138066, -0.013655839542651621, 0.12488708780610756, -0.14051965306776526, -0.10381805714963879, 0.2785939826755503, 0.20718013697505633, -0.3759992479190938, -0.3275958310336645, 0.2760429834653011, 0.3147168283004298, -0.43940906282720976, 0.22982600986295101, -0.3115863439852146, -0.5884663240570532, 0.25799067230359235, 0.1205976703207792, 0.3353647895179585, -0.008393922647901108, -0.049642886237499156, 0.08424672869839957, -0.2833863761225018, 0.5137240837312669, 0.06781225167744763, -0.19340671539855492, 0.40384207335652644, 0.35683158499873324, 0.008485102026317316, -0.026528697569184984},
    {0.09838465976630181, 0.2003006592541157, -0.3488257130764708, 0.14950246284925758, -0.10445644556497226, -0.11763559412678401, 0.23255531088483192, 0.0010248764847182934, -0.29887800641702855, 0.4514997897147987, -0.07367205514067764, 0.35538386223611834, -0.3556469010917507, -0.3460735807647109, -0.389026158227224, -0.13209390076820518, -0.5342360934168823, -0.23399076128112, 0.3839954534824175, -0.6850492532519303, -0.2253365884579619, -0.41154521405740463, 0.22349664357373195, -0.40590977981491844, 0.02349473173135171, 0.33591399938801597, -0.36066693493902385, -0.06250253761448936, -0.4473153150803659, -0.22755451385016306, 0.19591324672808988, -0.08770480994208191, 0.134467465784071, -0.5179642015964939, 0.21427293715240617, -0.27701910181105016, -0.1897777782313167, -0.2525401357087011, -0.06299051133904882, -0.34179036105470706, 0.23793068959843766, 0.33839954140089806, -0.507700603473248, -0.10702530026152991, 0.34423247006129604, 0.1362892691612665, -0.7843917811782267, 0.43728233209597356, -0.1761341802600331, -0.6489705812138421, 0.2719328896337832, 0.04079769226599391, 0.30836258436401326, 0.3296374560710033, -0.22566447851904353, 0.2341631914523927, -0.2998384052536944, 0.153363975805842, 0.43886059471915956, -0.07818514108758413, 0.4741551328796778, 0.19201314058424035, -0.2052926089519947, 0.031304886626491536},
    {0.22736380392515854, 0.06609966084770466, 0.05460699787676197, 0.3115224741527476, -0.09256753209913134, -0.31590572907967035, 0.20747855070133558, 0.2577692118203274, -0.11802461467820147, -0.008916160022983054, -0.3317012190536115, 0.3369065092661211, -0.18174685895093035, -0.30834204654220165, -0.3121919294312167, 0.15994617305290043, -0.34467152305880816, -0.30649538042498703, 0.3984245257965043, -0.4455928102912782, -0.14184144702224946, -0.6287954906830002, 0.5157775660748225, -0.3653669094199597, -0.5678983101784743, 0.5302026932778244, -0.12690719475069961, -0.13171128595996642, -0.3929737782530268, -0.07017540442205283, -0.18354195954439131, -0.29132011099512606, -0.12433141131487653, -0.6555362867157063, -0.1704485336999253, -0.4266639773768224, -0.03480880516825636, 0.26322908296674835, 0.48434766031305543, -0.12852971103454944, 0.4102530246127455, 0.3187085548830394, -0.5266687346222246, -0.18025864546663511, 0.37501861897553995, -0.10692041169693087, -0.5626060953953304, 0.25649076318959696, -0.09822296741516084, -0.6221733362616971, 0.004535918684796176, 0.5232315139368845, 0.5625679619483178, 0.14816047328580786, -0.2668082676583323, 0.2875465835284625, -0.42363376871811664, 0.3206108660296248, 0.4793766472664429, -0.04092493336554226, 0.36328776999168055, 0.4763762389167504, 0.12215304430513402, 0.4144745608603674},
    {0.11968793149727186, 0.14984997570631484, -0.2784791654445848, 0.29453057295868396, -0.11366726434177263, -0.48020694650990897, 0.07069641088374198, 0.2691415672349599, -0.5104773154366191, 0.014870431442493351, -0.16364017222128152, 0.13634402673901944, -0.42825820299719136, -0.4419035584150506, -0.2619230568513848, 0.1425637377202625, 0.11460696546468988, 0.05364026228603654, 0.460332883496199, -0.626633708633147, 0.20976513246764017, -0.18022111705313207, 0.7389513801339664, -0.5012086579994491, -0.1740805474612553, 0.35704843610979514, -0.20425864580843656, -0.19969209665565457, -0.36133362394316326, -0.3433970085313587, 0.1719868954338448, -0.12530998769057405, -0.16190680302194563, -0.4494347864397578, 0.21826177783469045, -0.1554333172986577, -0.20053541423475038, 0.08755806133160648, 0.019115475799081176, -0.2773221479996216, 0.05762805099781775, 0.3845391780822408, -0.5722984331638361, -0.2962568809335428, 0.39170974861716956, -0.19065487087084423, -0.3774668689742086, 0.23324955309415113, -0.3002868377489114, -0.5075848378572917, 0.017787893797212916, 0.45297087076955345, -0.03131183117408387, 0.2100845497501338, -0.15227907282277817, 0.31842261349284345, -0.2856889223677194, 0.5722532279411464, 0.07736777632791834, -0.26591061597130267, 0.3923273516413176, 0.6732754872654375, 0.02128219690381098, 0.2339631009127087},
    {0.4938662329662201, 0.23981816750845542, -0.11405517369597018, 0.4759217527323121, -0.13092720874839425, -0.2034208457688526, 0.4832492184042527, 0.4240978794239804, -0.45166452297585813, -0.01886383760375949, -0.3488830132932398, 0.4322831669455202, -0.6153207096230716, -0.17314869130411567, -0.3830620820368187, 0.18566208647856877, -0.16274500824194585, -0.12562061415597658, 0.27421708377903, -0.3713899614655156, 0.06653776275041301, -0.546639234437653, 0.2644126002261986, -0.43943968059168864, -0.21909691249844618, 0.4234391401359592, 0.026451287400024337, -0.31673267583222525, -0.23185223438602642, -0.022360365099828722, 0.3550397398347283, -0.34558581471920197, 0.10571439832499417, -0.2942569631338652, 0.34620824457559907, -0.3519532866182464, 0.016869487695662426, 0.5233803051135296, 0.2526178250275961, -0.2902969392810632, 0.030772994776590623, 0.004433248204532414, -0.3447374215958195, -0.5135075229866873, 0.3376362115843682, 0.18368752008990563, -0.4062257329890339, 0.5653832034468521, -0.423888498791936, -0.3852637364447091, -0.18115550496447783, 0.26225811618616557, 0.16945605073434453, 0.4168693550085954, -0.3063685994386689, 0.19035070868645043, -0.13339569283492184, 0.2709385174517888, 0.29835804409647126, -0.42799305882424477, 0.4063281075760812, 0.5673777256807313, 0.13123248034443372, 0.5365177656147},
    {0.3538672822221473, 0.17128480063809376, -0.39926682122479235, 0.2648086869846304, 0.06284060380035772, -0.23197342760754058, 0.19681025688222786, -0.12775902548010848, -0.48427180978784007, 0.3607636851328988, -0.5122767701858735, 0.45308490388425915, -0.3344775722548919, -0.5471655961019058, -0.44840742395756467, 0.1981204586150293, -0.34181468551109134, -0.07207760823820697, 0.1910191030818684, -0.20373526469008527, -0.059224434412506174, -0.6977694594480358, 0.16861191505082074, -0.6173876173156702, -0.6328981784396017, 0.13985417125674215, 0.47163959437780756, -0.36700269279213554, -0.3648994219058584, -0.39747367726903043, 0.36852568475490566, -0.3773262988954955, -0.3584911456274284, -0.31321930916981067, -0.10952861626119464, -0.5292431499875375, -0.15546780096800836, 0.3757663265338841, -0.20920595722598576, -0.12574775420910103, 0.3298081418140105, 0.39995002890088194, -0.48814677143848517, -0.3931560977952135, 0.03973501782606752, 0.35646385135463476, -0.673553646711525, 0.3365303333752585, -0.20290090584399334, -0.6193206903202494, -0.07482235264767555, 0.3376833315048692, 0.11833878607848505, 0.27473730594808, -0.4326544148503966, 0.4432359309485125, -0.4887176061347708, 0.3946911246970279, 0.29883473172070324, -0.12390913997910782, 0.5101083039535101, 0.4585739485186473, -0.3287496957443605, 0.15532112135923412},
    {0.3633580599027269, 0.1283308333409273, -0.4811516085935672, 0.17505719479480214, 0.07178120942452064, -0.10481681523913715, 0.035450997441510756, 0.2562127456643164, -0.4508608016140806, 0.1786312091764863, -0.16633485352101293, 0.6169832457453308, -0.4553370064881972, -0.5118521463264859, -0.6674982613109894, 0.1336540413497246, -0.5676743610585085, -0.14606728050735343, 0.3264683494262059, -0.28943403310948695, -0.279859903008645, -0.7613224621161296, 0.4979965481801931, -0.20905077619208318, -0.7010110645005009, 0.2779228878952293, 0.19439464320869912, -0.12799285948588338, -0.4817871855962151, -0.2041484124993738, 0.23664828783751363, -0.247385754447202, -0.1499309821948897, -0.5628738102362707, -0.04437857001491575, -0.21129593987420958, -0.24088452254639472, 0.2843673467680909, 0.13676431153659313, -0.2570163327293241, 0.14256693099251322, 0.16170453108754654, -0.341103586620819, -0.4744103595930819, 0.3421963394185796, 0.38626456095316225, -0.28510362989654336, 0.3393913927250904, -0.36808046221695095, -0.5638693912246073, -0.1499044796394807, 0.31157926869760355, -0.04553680546706485, 0.45453164103588306, -0.30515699087870773, 0.10219320772575657, -0.4165723870470225, 0.6638507567279153, 0.6488904010213746, -0.28708423807232986, 0.279453004216567, 0.35088186505422175, -0.2802084618721599, 0.3601684475951254},
    {0.5267590810169321, 0.13095500398391746, -0.5464410185448437, 0.23506650066300488, -0.03601818713532435, -0.2327590765721971, 0.5028122436107793, 0.28880063773010467, -0.656441924669876, 0.5310976729032006, -0.2879710390277455, 0.6866847164090224, -0.35523287507245954, -0.7067011174198032, -0.4733161623004903, 0.11200237919759401, -0.5934285066552202, -0.16641675098746475, 0.4053959838169966, -0.4111634809529423, -0.27402078593728313, -0.4063732435222147, 0.38796388983736546, -0.5676331167338856, -0.2577644183606554, 0.5020460925650461, 0.1338996326418234, -0.16313086729337342, -0.4578930787304874, -0.2507510789759183, 0.6098177341618695, -0.30572994522359825, -0.21136026962158258, -0.3425218202490566, 0.02768937411271893, -0.26616176386829066, 0.00043285688873883656, 0.2903402364948119, 0.23513301766529643, -0.5294674975157085, 0.2599889874992042, 0.13248319218342128, -0.4743625455462043, -0.4383829907037652, 0.4073482804408155, 0.2297045690282422, -0.46588372655419874, 0.44208787692161716, -0.08448561361389798, -0.5168336675126153, 0.09503584599607476, 0.36389393702612693, 0.4508691651457209, 0.32501703354015216, -0.4214698091640833, 0.299809554812469, -0.09740440804887583, 0.4426681268502756, 0.45570474252689697, -0.31045663695062764, 0.37122442354225077, 0.25559235517160156, -0.4748021118557528, 0.4171000882296565},
    {0.5144681986940609, 0.2678474033631919, -0.48481606071828165, 0.3792268161662682, 0.1301435589973084, -0.530018032906554, 0.1713236544846324, 0.43046775265338544, -0.5651333210313396, 0.22235021197834398, -0.3017635657533766, 0.40588958143903325, -0.24069477887044435, -0.5560376091430301, -0.4665259367531872, -0.08812370002056737, -0.36546454588830224, -0.3507934647776446, 0.25124070513696023, -0.5212284314073373, -0.09910328313965082, -0.43634757891819637, 0.43220115382605206, -0.4504112941246172, -0.4792594126233129, 0.39854874905878845, 0.09788008138486931, 0.12904285975225935, -0.39029973698144993, -0.583544924844855, 0.17684522741339392, -0.33661744773765, -0.2972887722595167, -0.49610669706426014, -0.062268905326766925, -0.35949318759349325, 0.260633821804322, 0.5401770488381469, 0.1205002466943129, -0.6372209357124881, 0.590764793634711, 0.4950555985628548, -0.16181164952284485, -0.4712541149002258, 0.288696820093437, 0.24591775208231545, -0.42491750149948704, 0.6451086770825328, -0.0671634351169465, -0.46226381945458456, 0.13228902178256313, 0.21941664308212697, 0.433502176127195, 0.27277697668347983, -0.4731240288167861, 0.41624309902243206, 0.03362499906188493, 0.34402219261502237, 0.47142324167084154, -0.24646139545782275, 0.3064782002607815, 0.6039225178705635, -0.09277608592009666, 0.004638949885031492},
    {-0.03667808932625989, 0.21378140244916982, -0.4521104004383705, 0.3111049661409962, 0.11454545776570423, -0.1129862583352332, 0.3561603587009893, 0.2685376019320088, -0.2997872554351401, 0.1500733002230837, -0.19781488905746497, 0.37938803277888933, -0.49202113269654957, -0.19230384341787915, -0.4021614902351437, -0.007096708536755103, -0.4715878454847342, -0.2985300143994857, 0.14404168267223735, -0.24207727884324373, 0.2915572755697172, -0.41742849588292874, 0.6428314990954465, -0.4372347721335911, -0.3027583488276678, 0.2171960218242049, 0.17760119461086427, -0.2335730875386467, -0.48309050859219266, -0.4886728023371499, 0.20437318638154195, -0.42765935983848014, -0.2434600363044324, -0.25291747290731864, -0.14086134431547068, -0.4014140411066846, 0.0866654156954987, 0.10899688072818683, 0.15367915815986566, -0.23941071608870793, 0.3171919882662248, -0.02538539153287315, -0.2873153992874894, -0.5710953505811368, 0.14907893138431122, 0.1519144361346933, -0.6856353017087403, 0.5758769802472541, 0.10445325511384616, -0.1528481702663172, 0.03301506698026409, 0.2310029466519155, 0.3728323107779158, 0.4733266374894509, -0.4088285857762799, 0.26669812922993175, 0.17024208441490335, 0.41732984815569113, 0.34320788102058103, -0.24091513104313028, 0.42732531663811557, 0.15953780823124394, -0.27433122756951517, -0.07507152771153179},
    {0.07836385947734188, 0.47808438937209885, -0.622915784435369, -0.021539177789441945, 0.2519536862277086, -0.24822980451941593, 0.43690826556795154, 0.3159936046397878, -0.560262627990526, 0.46692888530849275, -0.21209753493033381, 0.28866109980211174, -0.46801342169384696, -0.32301382848534466, -0.44435562139746476, -0.3013192093123719, -0.11822951095909556, -0.22990263275069742, 0.14422586278561486, -0.4033411392840063, 0.060112861247170954, -0.5374321704881467, 0.5997430230260925, -0.5573056617795581, -0.67894071458758, 0.6448852960277056, 0.10224994675962565, -0.3695862051051527, -0.5699462459209201, -0.48355586223842084, 0.18941227572586278, -0.3847259204168777, -0.2095020955435837, -0.3815882373700129, 0.01154802644166281, -0.35073761480792814, -0.14451925221693215, 0.09192682191067846, 0.057995221652609064, -0.3095599903072425, 0.4577011493766908, 0.06136161036400652, -0.23691466834828515, -0.16481168546906586, 0.1530692323123379, 0.47553483767593924, -0.3876092858228065, 0.2865765026525791, -0.2783816280965216, -0.3713877517605603, -0.3420428597490756, 0.3014265492664511, 0.3710155175935638, 0.33963815624251426, -0.22151815375870523, 0.48703827294254326, -0.12503146346889368, 0.6294766016118593, 0.4936638516133925, -0.30088692422257113, 0.5752178936584599, 0.43478458836445805, -0.4893058718952291, 0.15696942363213387},
    {0.44123342382959624, 0.27842081892669374, -0.5644201686434963, 0.7511198187521521, 0.39034766475083293, -0.24627336720426105, 0.3510147982719213, 0.4137136331867921, -0.45563936939475636, 0.10977840767833212, -0.43738175987476047, 0.48854449435219977, -0.5199166172021478, -0.22308139189549303, -0.388420114801888, 0.12515255688688132, -0.5262298677294557, -0.3393115295660203, 0.4275402224764612, -0.2354969416456358, 0.028242042580877178, -0.28537633840447235, 0.4777039168545458, -0.15157974866482893, -0.30451843987335986, 0.0927035562824738, 0.36606658545682635, -0.1347337093856588, -0.746224512993626, -0.42426547445582946, 0.37991816709669923, -0.1361726596314499, -0.24670905157916756, -0.3200285518959211, -0.10745933553140552, -0.2799562467077361, -0.3275643172473894, 0.0998587810368425, 0.25297837405825735, -0.41298196153554456, 0.1727522572203916, 0.5660289739694326, -0.5080277771908998, -0.386971737138111, 0.5184188635107737, 0.23629690911927156, -0.42608429173234885, 0.5441312488309579, -0.220590713174286, -0.32236085790031344, -0.06332424180301995, 0.3616713546588904, 0.3200956241061243, 0.4699018138285477, -0.32518273237566675, 0.11061928512523915, -0.2911019141133471, 0.5089257773223231, 0.07222863807305714, -0.3708760786430364, 0.4416973897121223, 0.6295679901716834, 0.04017863742043477, -0.19357846092761583},
    {0.23638898180041326, 0.36915195033271053, -0.26977363003252863, 0.5285471115303848, 0.4515575876653858, -0.05049504401789471, 0.24649433098383117, 0.20553994793823052, -0.4511777966204465, 0.2222476161663851, -0.28789874642884933, 0.5652476829695341, -0.6674161871564779, -0.0291339912492167, -0.21595683349250636, 0.1373965105862985, -0.554269943753536, -0.0893656064827283, 0.05802431370390545, -0.09765188640053271, 0.2709593266592107, -0.5355577695398277, 0.4030213198636896, 0.057585035429733956, -0.2466082009136353, 0.595277823481467, 0.11778252991576121, -0.05807455950841028, -0.8127266756428175, -0.44096669151522133, 0.49450791123563864, -0.6706881650478377, -0.22827123555704049, -0.2735435554998664, -0.2605804290476336, -0.358496589257569, -0.5072193865457458, 0.37992484971755386, 0.2987240719660327, -0.022468979548286853, 0.41473055979857837, 0.2832156026091936, -0.31622637457569447, -0.3128275803813488, 0.5547866214804394, 0.14955904228988925, -0.5823432619088296, 0.512962796257802, -0.4890529543890822, -0.5890556380115887, 0.012974634625072992, 0.5013856527741714, 0.44392281328479377, 0.2487980376914958, -0.4140742966154527, 0.237208975369282, -0.4255012519568755, 0.18682772977928666, 0.2762495686596655, -0.32445760246806676, 0.4522254018231374, 0.4629367590966103, -0.44789343183616476, 0.07285821397089985},
    {0.2116696931331398, 0.3847102965983796, -0.10626570260410824, 0.4474400852570294, -0.10103220214381411, -0.09682337142691222, 0.282032112397491, 0.24013225120091589, -0.6350029655636311, 0.4446976381109376, -0.5106451863598059, 0.679448726277437, -0.6479921489543968, -0.09424877720393744, -0.2484884398327995, 0.2594105513022291, -0.47676793620672603, -0.29336044727602745, 0.11439191786883048, -0.4379832197304163, 0.10061585426529039, -0.5577858832213773, 0.1820054149051501, 0.04441767363622061, -0.27685031128735876, 0.35489416086074593, 0.08057928036025977, 0.13009526977551533, -0.26124763762410474, -0.4853462944794519, 0.07501761587610076, -0.35180468688141714, -0.4305849993209034, -0.5010753544499669, 0.13527409061444223, -0.7116367362148721, -0.18803949017058524, 0.5087520651363685, 0.34349425283316715, -0.08231471922973956, 0.4817148193652313, 0.1299744897466103, -0.2529418833064189, -0.38230548535427417, 0.5599074184905304, 0.49941474502167177, -0.6692552508469294, 0.32496977600713817, -0.5549111002864977, -0.5956805989397331, -0.016554221104823106, 0.29373913170820914, 0.059911743739538496, 0.15530632351602483, -0.035108803873662185, 0.10969386614896356, -0.529339014144444, 0.223398493538781, 0.3586647424330186, -0.5551802102386008, 0.01839547092880423, 0.6296359933054877, -0.07028008005718987, 0.21345550245365214},
    {0.13645104087796864, -0.01608364276147196, -0.2951900867614465, 0.47297459413275234, -0.05563941071752584, -0.5747475430306385, 0.4904494159243468, 0.32846155808130456, -0.17966788426202562, 0.2441315610930076, -0.5820442820949828, 0.38447364042803095, -0.47415450762304095, -0.34433406861580995, -0.05653914368695835, 0.15405125811569348, -0.5010699493039918, -0.33656911448292554, 0.0999785396830744, -0.21578515298080844, -0.2671049810770097, -0.24856947008510685, 0.462569792573619, -0.29315664371838424, -0.6602906157009786, 0.5600391394959771, -0.0050806857322787625, 0.11794102429080788, -0.6428204048438513, -0.5272455029573452, 0.2839342524054134, -0.5858256896383383, -0.22306254405878656, -0.45764643923100773, -0.16690976498051172, -0.3112071257961506, -0.16627019216929081, 0.47437378711185374, 0.3440336375175323, -0.45084767443655516, 0.431106986036526, 0.2971657696663207, -0.22720773706615613, -0.3511034909424803, 0.562278972632891, 0.46760893283643024, -0.36861320344146503, 0.44818037916003856, -0.363557206942794, -0.6925492887423049, 0.022682009136930917, 0.22263754730362856, 0.27799118969901004, 0.3027376227531907, -0.22530914557449358, 0.5224958246822412, -0.3721209948250932, 0.19614189345869948, 0.6358886841450158, -0.4202682163278215, 0.4420566026381743, 0.4459146384131874, -0.5046751789275823, -0.0010086717613339874},
    {-0.052301641117811035, 0.0600820609275909, -0.4670534042689176, 0.1737122844860824, 0.009519502421471815, -0.24993783417609866, 0.21417270976610417, 0.17835765365308592, -0.39420527029165897, 0.0006761225196989743, -0.706159835180949, 0.4152864090768814, -0.5261968543859673, 0.003517149854942063, -0.23236240128409294, 0.6391621834060695, -0.4319189831985178, -0.3179216412151891, 0.18864562421682837, -0.4892118855000433, 0.01187922669826978, -0.6046150048970501, 0.2337696359243931, -0.45931168569404557, -0.24470401783817594, 0.3270187546768867, 0.26369719277180215, 0.1594187273650886, -0.4496144538836301, -0.4635535362409696, 0.2678363903872329, -0.2385184743392151, -0.36694643865177495, -0.4666914419397354, -0.15158375651169298, -0.30211679132809777, 0.2841309374827651, 0.1839830038424495, 0.29001379857764753, -0.15671680894472947, 0.17540554689017235, 0.5204122530444159, -0.5058425361701936, -0.5129718717753786, 0.3816049168515824, 0.40874075707819274, -0.42034588188205196, 0.43441143320500175, -0.037097738791874585, -0.1505064793576733, 0.17181168580519698, 0.7915993456731621, 0.23183055279339843, 0.3980810280114378, -0.486928384538868, 0.016824184148849407, -0.38631638660549894, 0.5052733406884776, 0.4401648807310103, -0.16462525469458988, 0.19832857546623262, 0.42274828958123456, -0.452164307535567, 0.16824537960323116},
    {-0.20012332382978515, 0.24086193467977937, -0.506210445200267, 0.34177356571428064, 0.09625747009527495, -0.1542549250553385, 0.19518268824807705, 0.19215114577773154, -0.5002353217266141, 0.23203705907779418, -0.40940727977027896, 0.7127655124843604, -0.1696774672210424, -0.26098218716796334, -0.5174749717258849, 0.3434167249341458, -0.5766145597224239, -0.3333054889736559, 0.31966132219749943, -0.4503260201566108, -0.14506747244529544, -0.29729817275491993, 0.5146374189879529, -0.5835302604699408, -0.5533345421591055, 0.4201035764877171, 0.007728567157748762, 0.37165791155259803, -0.34747165516331235, 0.08562218605344821, 0.32102445276990593, -0.4861757387071159, -0.3657141101489033, -0.2920502436251204, -0.09315110532374447, -0.38202482368516383, 0.024422209186748634, 0.09708628770350658, 0.3657047769924209, -0.35425352641736024, 0.29653692024321193, 0.23897172027381736, -0.7963940109343112, -0.5861502585208154, 0.56968593837233, 0.4379121149386439, -0.4107273513526568, 0.5372855811597953, 0.021614191497162143, -0.5384675389776716, 0.10865514169443233, 0.4634080060233602, -0.019787317195054194, 0.35731985514186393, -0.47874428641403954, 0.4070193991790612, -0.1462209301272742, 0.4424211728213888, 0.5178253290952581, -0.1405939727961262, 0.6212582254337758, 0.5989306334867069, -0.1797546102472281, 0.18983141584642138},
    {-0.07882112260218177, 0.3985258201727528, -0.4647064632267627, 0.345621172012268, 0.12278923030498827, -0.42476747578545526, 0.36114790913511285, -0.2071574346309023, -0.3140128329252072, 0.5513907916082698, -0.45873638940906625, 0.32385912059814553, -0.2629776575084149, -0.2959693725747111, -0.2745246975500883, 0.3660449510851285, -0.2641977192309406, 0.07501038356862515, -0.07367184434080366, -0.3567949920575223, -0.4101945107546764, -0.2773448286904612, 0.5152059728835552, -0.32623213041938026, -0.2741584756964924, 0.4041565855829337, 0.3657740725577709, 0.27620859443786283, -0.5251090873928728, -0.13898935136429472, 0.2139560662867091, -0.4729852392884081, -0.35795546882507256, -0.3885319688759222, -0.1985374496522754, -0.5315639951418314, 0.04925946825069478, -0.018815634396997835, 0.12796427566174515, -0.4287277162719601, 0.39595232860704777, 0.4531227531620574, -0.36362150038831154, -0.5417350474251952, 0.37144017292998593, 0.31939998903709843, -0.2527668491647464, 0.38640271798938014, -0.25863923148593587, -0.17967263401349653, 0.0538930726753934, 0.4088247497173454, 0.5328036131033486, 0.27559526724887684, -0.30230665157819986, 0.32310222659357346, -0.40356978294146223, 0.16097803622608162, 0.5640619936155147, 0.015134366101995336, 0.4972576676617103, 0.40139008972186085, -0.21464340850806682, 0.06358207381264194},
    {0.21367675263330355, 0.46155423929424294, -0.6336743993855715, 0.7081775186883694, 0.228733410544722, -0.32255089433987755, 0.20287117755490608, -0.03568562051247778, -0.5770836187258988, 0.24177933986910727, -0.030956395127322726, 0.003404441929443993, -0.3266967579191096, -0.4421876890778952, -0.4043581204735941, 0.3451859863414082, -0.2746987170589905, -0.11226008718292976, 0.18879799276399276, -0.19413950462743848, -0.04634849802891647, -0.5186031177173471, 0.4981490186332015, -0.26437665788535913, -0.2378079901681908, 0.38600923864925935, 0.36826162046344685, 0.16616787278582634, -0.5644289838437846, -0.3858860072854915, 0.16024440634305206, -0.13729275791271, -0.5359172865156054, -0.42184383837233314, 0.0767437107786963, -0.3697869427193328, -0.14840751057417245, 0.38900651390930385, 0.1775798721275969, -0.25394425583860414, 0.3687604996542407, 0.49373496914943155, -0.5611090041008394, -0.33686124593597544, 0.4884137682525422, 0.48988691291394476, -0.4979178389572267, 0.29633682045489024, -0.17898916866343928, -0.37030616994326343, 0.07649053121589663, 0.4692742709945018, 0.18442933746952458, 0.3304341017251144, -0.4251752457068778, 0.33799222594344863, -0.4362560137112655, 0.4795516935858791, 0.8944538682715539, -0.4598594859875522, 0.6058458317506021, 0.22515151386446722, -0.053327093952410067, 0.33435386715683774},
    {-0.1137533924102992, 0.1943632786919521, -0.5830412735085734, 0.34578633308679424, 0.2684025671833689, -0.7403087861034923, 0.4676893523699918, 0.10734655670074686, -0.42790970624628144, 0.30306427539103264, -0.21106521289871658, 0.5712057994911529, -0.6473172469210715, -0.09497205845624936, -0.4169159876616843, 0.026393264737579893, -0.32196329715393757, -0.3558940501099459, 0.188978973078893, -0.5717665828340102, 0.15780052766711614, -0.6749752884963616, 0.5331804270638723, -0.2940050363215329, -0.33164508898155126, 0.33391383508418493, 0.04033984110114311, 0.24252188389641452, -0.7684181417099926, -0.3931949124156319, 0.3138979056411461, -0.41843590991251833, -0.6065138241188595, -0.3812910549338026, -0.15894900774204143, -0.5631944739546778, -0.13499710625563885, 0.3505646822104431, -0.006993426546125489, -0.2578452477160773, 0.5314932008393463, 0.19491044626085796, -0.5162165957571169, -0.42423422077697975, 0.649509333503306, 0.14637067539979046, -0.49854675477239785, 0.4387802567053448, -0.2590095781257357, -0.31848060045467375, 0.07403237008972069, 0.5234615657156139, 0.311226198543375, 0.20194112282798954, -0.4131840314377811, 0.20233932774870603, -0.4431574649467817, 0.4593052531485692, 0.10749182264877931, -0.10649083528043077, 0.3439990607408084, 0.5458563843325348, -0.4096121165619528, 0.3074915249383768},
    {0.1219784326075539, 0.33684671609227984, -0.4554598156157083, 0.46069007476608853, 0.2150467803770378, -0.4114975883792136, 0.2742491877354226, 0.30689876864232546, -0.1601843268644276, 0.49188737259474313, -0.7277139752130254, 0.573837096209468, -0.43878073037343585, -0.28032296984571536, -0.3621125675074593, 0.3699006673337853, -0.40958171619974965, -0.08808563442295922, 0.5396552626987795, -0.2015444598329206, 0.28506126135431886, -0.3795383200363901, 0.6822295388041487, -0.22347370595058286, -0.29234652471588457, 0.47889832270716126, 0.2576791111016674, 0.1551135406059363, -0.5438078611226069, -0.25506504095353494, 0.4274603065433016, -0.4731061235496016, 0.0953236519359015, -0.6124334962435716, -0.24383586737193483, -0.437501904786283, -0.06303310389389552, 0.3067073701738553, 0.01834544265806915, -0.277963023743957, 0.5349597984169263, 0.49266142466593793, -0.466044821861866, -0.4277341445670685, 0.30823008839056737, 0.4043633734522338, -0.8258262044976376, 0.3642555429276472, -0.5122103893629276, -0.5062959648423122, 0.09937297831846492, 0.48699287236298217, 0.3955778103355466, 0.19432181487842903, -0.44271266457749825, 0.20988976758472633, -0.38778388670721686, 0.4199568154455665, 0.525960229869419, -0.25665298561369876, 0.694802697128292, 0.7119308601007942, -0.4348787097857255, 0.37171726225242957},
    {-0.2895109875536611, 0.020030331478327904, -0.5779354906556674, 0.29823704841664883, 0.1753862390714071, -0.5026409162553465, 0.46531057359955, 0.007163682769256933, -0.4149479551488994, 0.2643465456866057, -0.5588682913769818, 0.612820157929538, -0.4302987167914752, -0.3007132739486445, -0.5414463722838448, 0.34882133995318093, -0.5450722274369034, -0.039878364674469126, 0.3012040304384798, -0.2928835329038774, -0.05987768277962227, -0.4660661054164025, 0.42962853675270407, -0.3985528147423708, -0.44715529319435005, 0.5742928338898128, 0.11613960962468367, -0.07470111410067969, -0.7113702573533354, -0.28975931698976465, 0.0796704346611389, -0.33365689557763606, -0.005541673766243124, -0.6590560820896199, -0.4821352141830496, -0.49999776735446017, -0.15413269451723582, 0.30545395045465645, 0.442450102268162, -0.3122053716137071, 0.5054502016672556, 0.3295508633781139, -0.2750002894464416, -0.2969432240506844, 0.5263234638446648, 0.40791620056072075, -0.6596537931480034, 0.38436052509021845, -0.41181436610234456, -0.4921208544559666, -0.039053045321030024, 0.48493438763756824, 0.4892872298990379, 0.7031710317629314, -0.2518838854146351, 0.3887384749121031, -0.37480722128657473, 0.43187443841891177, 0.5020472151751706, -0.4174725723126609, 0.44667565531147707, 0.5153138564088681, -0.5686028383005828, 0.3359046584198296},
    {-0.003560571354473889, 0.20599952120673534, -0.3761405742098766, 0.4022440863341124, -0.1181299067948074, -0.39294863600825497, 0.447717412284444, -0.013396044400443124, -0.353428703654222, 0.18321659333679183, -0.2099666378223084, 0.5842671721827472, -0.6958798919576358, -0.31079481116482, -0.34593965751763667, 0.40982350448664706, -0.6760196888326034, 0.07201165832572667, 0.5681732696183706, -0.25981108906220995, 0.10469279814866765, -0.4002827846830541, 0.3507395824316565, -0.33286704459725935, -0.33873689670288054, 0.33033245639875114, -0.14527883174978073, 0.06174747242565098, -0.5649382248182421, -0.47034553522782313, 0.30917101894469906, -0.22356921417903097, -0.14813160576580073, -0.5578843981157886, -0.0901782701676936, -0.31563491265319166, -0.29208940276541323, 0.08312199515588536, 0.31678637698390516, -0.19378204911347205, 0.13898169684402714, 0.27184173671540673, -0.47314030062036083, -0.36437717969599337, 0.26355484765278137, 0.46309364379815116, -0.42134378375017434, 0.507508315908653, -0.24287235085461553, -0.47250422099382267, 0.07474854001808319, 0.6413527485701167, 0.2611064250715202, 0.3030491604579929, -0.17573255768061583, 0.5301893127023791, -0.30579138792208377, 0.5427204539321496, 0.40832986266613946, -0.14714714922023703, 0.48753492645348934, 0.36677391997325887, -0.2999942829118279, 0.4095295112476417},
    {0.4081444692068362, 0.3182827785746579, -0.53877866548126, 0.7657077458830167, -0.14179785083869936, -0.5891147461659055, 0.49333276028967926, 0.2941109851250227, -0.6690627867852197, 0.25279832171780736, -0.5278667560038989, 0.4156372865878568, -0.40788006758340917, -0.28009110140516785, -0.28318767537726597, 0.26749421291968956, -0.3257159758320604, -0.15788781406576113, 0.44510239674017016, -0.5387541859756153, -0.0145390097337721, -0.28634363351427533, 0.6363080476321179, -0.28026305454241346, -0.17823321208796022, 0.4111456569871482, 0.3911369558803016, -0.07566209051517746, -0.5106525748868742, -0.23453408479504506, -0.01657866207912046, -0.4370878448095312, -0.15030423336359108, -0.5537456983485286, -0.16119105102231604, -0.30320557347099614, 0.06401367990255107, 0.2759490355312752, 0.32528859893085477, -0.15376024175111566, 0.3239436903251444, 0.33227025188287546, -0.32245443733548473, -0.7527185495551059, 0.5385815854104827, 0.1626573794560788, -0.3997293630132249, 0.24892873970427162, -0.169256150485276, -0.22133356361787274, 0.0847831259351862, 0.47146796788675727, 0.1414081269818464, 0.4486069158804406, -0.44273413858334937, 0.2295548568171298, -0.16974887582137635, 0.5794647213472826, 0.5508815346019454, 0.06314058289139377, 0.4843452878325898, 0.5510026100541471, -0.2874937690672408, 0.18560134354662366},
    {0.2487656584649925, 0.3501585209350508, -0.30451858367652535, 0.29681496371204463, 0.018846032312433536, -0.48401813982260655, 0.19636642888597278, -0.3491619249711741, -0.44270752981297207, 0.21295899368557628, -0.31950337296528464, 0.5150722147953489, -0.2345450741112873, -0.4357299011355548, -0.33741893036959364, 0.40267007851548675, -0.5702368444637987, -0.28063346783725074, 0.4210533728765295, -0.4043844218338653, -0.0331726404064202, -0.31719344550184614, 0.44203711816551894, -0.11756347427147452, -0.5038570887192637, 0.5353682917723428, 0.2054974957753121, 0.04204631766159643, -0.3763462468965272, -0.3188201413746743, -0.07597757809828994, -0.3410207320479127, -0.2358228365169504, -0.31787999585096444, -0.49342702215905937, -0.6355644980322578, -0.07314405298772099, 0.27520629994241025, 0.0847820488206773, -0.3685233082434821, 0.5763786579521929, 0.3113366687386426, -0.44343770437129676, -0.44289385803180537, 0.8526294079609072, 0.4280501366517743, -0.6906230295829566, 0.39385896857302294, -0.22456944840116613, -0.6186176080711211, 0.26309741372988493, 0.5391214276952578, -0.03071054305880202, 0.49444899447479057, -0.48085904808247615, 0.2615599945384283, -0.4002747434469328, 0.41577707917811757, 0.7123050609850937, -0.4631602776010541, 0.5379110516525, 0.5216638538020565, -0.30548458255070116, 0.5299325900707035},
    {0.23058652171627164, -0.01649342913971819, -0.37993540838494266, 0.3789939296312631, -0.08427759430552205, -0.3720494518283173, 0.4020889063435375, 0.17836668127522387, -0.6280089359220193, 0.154947452134215, -0.31825314300277135, 0.3728099457896087, -0.32188608801119933, -0.5835954583355385, -0.4628473697417072, 0.2942939482919307, -0.6503184725378777, -0.456245272207229, 0.3277773394125363, -0.4081140884194407, -0.35313976124418567, -0.5189959389924091, 0.4617185946351945, -0.25876582223498423, -0.39531939811757116, 0.5905525461173035, 0.29572844105070845, 0.033603201953551355, -0.5362321388409496, -0.4183208133067975, -0.018560133973463958, -0.3445310023572023, -0.15480314209837442, -0.5690530064483142, 0.03417860914490436, -0.2539156481749533, -0.1008262373073779, 0.41304841019967553, 0.5495946826995102, -0.5453348091866641, 0.5277585154508816, 0.4389671460150461, -0.4514480924882312, -0.35840059439015065, 0.3483887463709721, 0.38056204604671173, -0.4602630974433217, 0.3278719903026199, -0.09458252753158083, -0.4860847411755913, -0.07791816125134839, 0.4730847654542047, 0.3755148602233949, 0.4039325951850702, -0.3435441525076761, 0.3908177914863405, -0.7430679095885624, 0.4412434730791686, 0.44761599451236295, -0.4629037886212405, 0.4390228429657188, 0.5958903212899876, -0.28549902652927805, 0.2112652748439648},
    {0.3311901044233896, -0.01362115727902724, -0.40812785598229867, 0.19653490272338792, -0.15204053668356624, -0.2972614504601249, 0.47051050901423097, -0.05898101247011582, -0.4262080277670457, 0.29967470125289136, -0.35254203001316137, 0.5796091653941141, -0.31409798274761036, -0.4085367754940909, -0.5771113004371274, 0.5641018206143217, -0.6951092797623435, -0.1450958970994992, 0.2525368128637721, -0.4116316354355541, 0.12658176383625772, -0.3156943115078631, 0.33669120190172397, -0.29632690526478384, -0.7694166021811686, 0.4965390427801453, 0.23035022752576775, -0.2227435088061022, -0.5553522737059696, -0.514803221398948, 0.05089099156836901, -0.322115324997659, -0.2612579597214871, -0.5283438166444153, -0.4626737168309343, -0.46382683191498836, -0.260722154694406, 0.2765850848889995, 0.6597647941209255, -0.3990080696799113, 0.7312768099660649, 0.04421732416456976, -0.4770131499234782, -0.24082358639194407, 0.6455160075563418, 0.312667813549187, -0.39797746242901544, 0.562850621402616, -0.21966239626454598, -0.2969301092278787, 0.23463367616406905, 0.33229925872446475, 0.004821954272537507, 0.20328726063073319, -0.1349667983351753, 0.16639191790525396, -0.5015852537079543, 0.42468795114318786, 0.49633967492946224, -0.12129667451938812, 0.5210926531175059, 0.7973325672304299, -0.49479714062179075, -0.08531813740858708},
    {0.02637314135577743, 0.14215210089149075, -0.3338099451129784, 0.32669432097997336, -0.014894226169181762, -0.48641368103557664, 0.41538383031454634, 0.1809428815965637, -0.43741781984808925, 0.30632383891894915, -0.5400668312908512, 0.1704962592059931, -0.3329942591411983, -0.3603966008027746, -0.567019543511613, 0.43290153512195206, -0.47644306369465067, -0.29364115288553483, 0.18411593433140191, -0.5145783843085454, -0.28660525271212917, -0.2493450959383968, 0.573792793441002, -0.2705853546951663, -0.33392332372935357, 0.5641609393049809, -0.13564539542316692, 0.04796138483030766, -0.5225754622025149, -0.3466089812120137, -0.07999991107508674, -0.3190723936207987, -0.18262822953455377, -0.3834249279540507, -0.3704793956364469, -0.3179504789113518, -0.13538968874317017, 0.3388722822971512, 0.42804483743869143, -0.4943356463829303, 0.6625991923798682, 0.26559044378960794, -0.4513076572912189, -0.44289213752913587, 0.525898706915213, 0.36736582399885886, -0.570585773176804, 0.43359023159995674, -0.08731790216754377, -0.44324176629740863, -0.04096186232349949, 0.46758573828333955, 0.2043692941626007, 0.6733635777907814, -0.5276253177908512, 0.5849344875196657, -0.39960678521024484, 0.6473710501668108, 0.4439984460040688, -0.23406156371938475, 0.4212234666007117, 0.5678826413271978, -0.23092735272675838, -0.09472659526949666},
    {-0.04739506114139144, 0.1062490423196342, -0.7355302938461599, 0.5992384134275144, 0.013516206476262126, -0.40476522396673914, 0.3428232765195556, -0.19209384160777349, -0.5577057925381036, 0.2540838422928303, -0.2582234157834565, 0.5819899383861864, -0.4256771089545733, -0.5485540223102829, -0.297587550307732, 0.44634729145698354, -0.37634023716860204, -0.10371518476933038, 0.43104486301634587, -0.4431534204319052, 0.07847724127937217, -0.268392969484823, 0.43292177179719754, -0.2041494224533709, -0.44981864429125534, 0.4765865297738361, -0.11968262578137302, -0.04486372581141874, -0.6130300815385469, -0.44304014415081944, 0.4371821011796526, -0.6239471863497554, 0.044768632472754845, -0.3974989351016577, -0.4469987574155446, -0.5194361454231008, -0.04526668785194055, 0.26409773670759634, 0.4839806794250922, -0.349730172820674, 0.36464078925958243, 0.43644127787066794, -0.5374716002298114, -0.29601995493351857, 0.6848485957749819, 0.5017980651005096, -0.7896536631246921, 0.578933244756308, -0.35311766631205155, -0.5524216987747815, -0.2201287899133152, 0.28825418403572767, 0.09207337039395715, 0.44583543032602035, -0.38762618042668145, 0.4564640189296046, -0.290402170240904, 0.47796952443939017, 0.45702894170892966, -0.3169187661001021, 0.4654254966532142, 0.45968398970061347, -0.2960773125336141, -0.09034116025758183},
    {-0.05293314766812892, -0.3170130099331403, -0.24403149600089924, -0.49777804045543994, -0.3122970149802766, -0.45088161767226587, 0.014112082017895777, -0.5270248527399701, -0.6012295625544919, -0.24160251731670965, -0.40389256184304206, -0.5704898333122623, -0.019865099242551778, -0.12176974867368333, -0.06665598258301696, -0.6286802113185974, 0.21761874437525858, -0.11617610075566868, -0.5415422423146274, 0.2853092270515693, -0.644246229800711, -0.049121943777855226, -0.3167000635650434, -0.08093562110464803, -0.10769764893140242, -0.4829456055513944, -0.36243330059516, 0.10768619582368832, -0.036001193492870905, -0.41111777275878747, -0.2898633729476836, -0.3306434792978948, 0.1190193380248933, -0.04178356674008087, -0.4430952653372332, -0.12766434849358912, -0.1554355076266031, -0.3826682259893404, -0.3333890949531156, 0.16877635320619264, -0.6526891332031346, -0.5431116626060408, -0.12326496666730134, -0.1969893289609894, -0.005779636765404725, 0.03074333946244384, -0.003506733468611163, 0.019118788035271974, -0.6401994258213257, -0.22325213615755668, -0.46077665503103227, -0.36433968285381135, -0.20903630663978273, -0.46945995425472353, -0.5666647385265943, 0.20599528760802904, -0.18117205388412536, -0.437938877777529, -0.275383092441499, -0.2685033450337854, -0.12158850493195608, -0.5667245488652856, -0.3791356805090093, -0.20459776869037133},
    {0.08543522659311288, -0.08158263734218406, -0.2280045628118824, -0.37211366264265994, -0.24460353693636208, -0.2922615079822638, -0.2994757735304695, -0.03059364025967059, -0.02348751813864536, 0.07704646249357626, 0.13026004308488234, -0.45258489982567585, -0.09242182735400405, 0.11193489444677567, 0.08479121561136928, -0.05497759377372926, 0.055055046601438735, -0.13518352902130942, -0.050004211349392494, 0.15890812398345155, 0.11871695262507066, 0.25018537340000185, -0.0484633291381048, -0.06513489620037585, -0.0933796491209759, 0.015624241946515478, -0.35096345867807366, 0.12923737796039383, 0.21604439325201383, 0.08303307193701526, -0.2648620804691547, -0.49081927901275124, 0.25317305202008805, -0.3211568848622389, -0.2111938235198823, 0.28179909160989786, 0.00012723234544044645, -0.29468537492772745, 0.0052084629111213655, -0.10684697792320834, -0.1729703239413454, -0.3527472765613212, -0.16056328049716093, -0.027833606411389173, 0.013150114914492148, -0.0021192246950699593, 0.19575636212092984, 0.13041788940136495, -0.057024850032702135, 0.3368788115687691, -0.12154790536832029, -0.01737875520151123, -0.020652593405394392, -0.22533383709131286, -0.39693731352428047, 0.08913687203903431, -0.06745256348273136, -0.5434908891978856, 0.14293543353499344, 0.0926023658280803, -0.07737170466634745, -0.3501299422733959, -0.08740495731826005, -0.029871879532012747},
    {-0.2955008525432448, -0.19669728216253599, -0.37606445094733904, -0.5162553714831445, -0.3659784888670651, 0.00802235534451504, -0.07720936227703779, -0.4133357192311901, 0.1313322247956923, -0.1689333783724408, -0.5139403442102534, -0.5409439470840344, -0.09989684280092255, -0.06346406285419627, -0.07168858736065095, -0.3759620238565061, 0.3391914097523595, -0.032859975957987106, -0.5335210723396184, 0.23017625952376325, 0.06497725062535684, -0.021161824523572455, -0.010791651643855966, 0.031733626031822955, -0.29960992228357014, -0.44567083982380323, -0.04608194620259797, 0.0005489768485876635, -0.07385544389908334, -0.013768290170003672, -0.38376008608908124, -0.5802472633142276, 0.08554966633428379, -0.10326715795752714, -0.6502501794501504, 0.13411229645688513, 0.043473246134316135, 0.10584556450999939, -0.47077168100090616, 0.13614240896813012, -0.6248645996099765, -0.2751761756859653, -0.18828133356702584, -0.04527383028617368, -0.21671051511505793, -0.04318592218921652, 0.11737298517885936, -0.07645062817236502, -0.11330906437756337, -0.29135059715778594, -0.22698018177143675, -0.2990208221672444, -0.3268024901794557, -0.1495138081678988, -0.31621840030434545, -0.14274664720928365, 0.026049437559277872, -0.23004818503134905, -0.03145387543314417, 0.44759675383439895, -0.3844423437712605, -0.2708016651830241, -0.3524127464072643, -0.05070058262617231},
    {-0.18941826332342426, -0.5029116789063524, -0.3611363679196208, -0.1225316608883544, -0.14139013907904716, -0.0960618598840343, -0.2643203063716532, -0.31631382168200783, 0.03886543588676303, 0.22434510913833927, -0.3755299790588487, -0.2021783174221379, -0.000820286031037071, -0.030811012811290513, 0.034904971309440175, -0.04371566720034464, 0.24237497107294426, -0.07773915170041262, -0.393691111147726, 0.07492173680710591, 0.0010112133625677967, 0.014324118288426639, -0.21256063340465753, -0.11380651381420681, -0.36299928259469394, -0.2705089514868968, -0.02558799291954294, -0.20057908621836323, -0.5156369841501491, -0.04825465353437079, -0.26764152995753576, -0.05354641629810633, 0.15438799484505838, -0.2736745524072113, -0.40699055374002696, 0.1730151716700884, 0.1662473272716063, 0.21846060724659563, -0.5278876085316196, 0.26235761189081674, -0.4260870797381148, -0.3261829157383885, -0.40422282284186184, 0.06790667834968056, -0.30451676266776473, -0.156921086496345, -0.06031940248750287, 0.17313908230968267, -0.04762336013452865, -0.3134061874337233, -0.03839893532617882, -0.207100696342317, -0.031082804193199864, -0.396670847897826, -0.384911767735878, 0.20200637284112138, 0.060956658373874435, -0.20490883385530945, 0.0827901951172674, 0.09968222871679847, -0.5792512265517, 0.04167712576249287, -0.0014208309039380161, -0.03537358542056449},
    {-0.6059330701125041, -0.04227240576980776, -0.263719538149643, -0.3869935990574902, -0.2312808499668093, 0.21848240839765293, -0.3483932336312174, -0.10476717026016438, 0.01549892229945656, 0.22751614378477367, -0.21653742738389128, -0.19948522199869084, 0.12986435717299777, 0.006414202202694956, 0.020660001762649715, 0.17154752391557326, 0.20348867055804526, -0.16298151457334378, -0.2594151675288625, -0.016721090976326364, 0.03582715650395765, 0.174507993600052, -0.323497304032908, 0.17825744349717326, -0.30504273267924964, -0.15163061574089967, 0.040679773066092446, -0.0752348512536486, -0.2355592230938006, 0.18591902440156405, -0.34418034676229003, -0.040675183893588644, -0.45016000807806145, 0.10179006118659556, -0.3617090412330689, 0.10427842401194659, 0.1020920014059805, 0.3570767340944787, -0.4542266061058091, -0.0051020459563882676, -0.4036205518544264, -0.6894269203020557, -0.31807635954034996, 0.16153194275259236, -0.20763843631797066, 0.10835441972612536, 0.2022825213523937, 0.17118567239477153, 0.2243081651578285, -0.20156122916187647, 0.2103816067481586, -0.3030723447044737, -0.17106115431088506, -0.08048061204361652, -0.3180910395726343, 0.19597468909849153, 0.22173922343177802, -0.26311329233036096, 0.13422888866029947, 0.2531448657441947, -0.33771262470713476, -0.13666746676969274, 0.17474933445442847, 0.1937541043329739},
    {-0.31756615244718783, -0.028412975759220808, -0.07824014463289727, -0.12672743734739805, -0.2790813798184579, -0.06605360986948985, -0.1863903782577046, -0.25439668075411753, 0.16897249621650803, -0.1742219914663631, -0.10540883411181518, -0.3070150247401354, -0.1497202777872407, 0.1816240218959578, -0.11900813151771732, -0.3317594416075121, -0.0921884329451784, -0.023009160034206166, -0.20027533632843503, -0.03814178715109185, -0.0560355950452374, -0.07741455059279073, -0.15261418511191857, -0.19572044704463465, -0.2567775774911686, -0.03980027123667055, 0.05099396895253206, 0.11726350883052185, -0.09858881586563606, -0.06928278524615941, -0.25360702961804443, -0.24377937761768037, 0.1376878434360623, -0.19589616177581276, -0.1434565894573381, -0.10812526380045842, 0.21094143761860973, 0.09532397828395768, -0.2829721346833429, -0.2881338949845866, -0.29249329420647174, -0.6085404318414739, -0.3041626622052342, 0.27090388242581875, -0.02879998130688828, 0.07823882113337728, 0.15643673121060384, 0.07651054614466897, -0.01910120443433918, -0.1869130684273216, 0.11560220274409581, -0.13384733663619036, -0.1602124196871254, -0.2774181308300479, -0.2549329960313421, -0.14524401430556652, 0.1671253662656817, -0.411700942514989, 0.1312464259297488, 0.1329592945097264, -0.14365459536134467, -0.14067775352173395, -0.15426042592719594, 0.09707400098542526},
    {-0.22272134860254925, -0.21379392818624984, -0.49909218886335716, -0.4855764134197246, -0.3567770139334812, -0.016384017359850452, 0.046002106204151155, -0.40135020164619445, 0.2122039300435947, -0.36219379672401053, -0.34405406260705185, -0.4820901941511649, -0.32648230607600853, -0.13469483764428514, -0.42272972395722763, -0.3145631413150089, 0.32007367562030165, 0.048729296515248405, -0.41922047793602246, -0.3514292873212723, -0.10419499780913517, -0.025138836874512505, -0.4621039422519581, -0.05758701602918678, -0.36147107940712925, -0.27274784228866955, -0.2745105846751374, -0.5098163260162315, 0.2409675588342008, 0.027022029255219362, -0.3408462553242311, -0.12425198985524488, -0.01655768771442706, -0.34578875812299914, -0.4484352371458994, -0.02340456280884758, 0.06454267860466914, -0.117230464363921, -0.173818980777005, -0.04414905002709004, -0.47460799203007575, -0.40346480190397294, -0.12897302345805198, 0.16598337557849507, -0.09062450570874069, -0.21070044639586916, -0.2807640608165962, 0.2728424123349087, 0.16252626773546194, -0.2703971814409399, 0.055580865307255554, -0.1837966837295344, -0.09190063958202271, -0.4700004032477525, -0.25027838512684036, -0.3152485404154263, 0.12308662415977624, -0.39248364244155204, -0.1998794551607713, 0.058858421513019114, -0.41882926913163127, -0.2721118632871418, -0.12501347476482966, -0.3923171916618828},
    {-0.005968872901132465, -0.09589086499678488, -0.1999515996648608, -0.12322593745132139, -0.1842230138518843, 0.2565712540102532, -0.07374150783813356, -0.41183484963520034, 0.03684598288180433, -0.2503159906697232, -0.29508811037498867, -0.4911489826129948, -0.1883301895116562, 0.06845591602524179, -0.2756480388343266, -0.0337093107117379, 0.14924592638414283, 0.0795057154306655, -0.04480917664892729, -0.07113782218299704, 0.15429776537423023, 0.05211956812656796, -0.3985220895105893, 0.3018657697107102, -0.40555520547631096, -0.2739591918837802, -0.25215308997986197, -0.3868130979976949, 0.408330838231371, 0.12756916455706926, -0.10076787437844228, -0.0799909046929497, -0.44655572544282285, -0.1128796052754553, -0.2267360792498184, 0.12457554314841919, -0.08368129661888328, 0.09056342554070322, -0.6909491591154703, 0.12248848830344188, -0.20900077214323504, -0.4176660053447624, -0.10609128285347108, -0.007838149203174213, -0.43581250436321667, -0.14813399125032614, 0.24202088195228005, 0.41539410435882135, 0.022414493994593426, 0.112532672734926, 0.02277878463096926, -0.09957271428099553, -0.09467095320183494, -0.13297726720238173, -0.360522159340898, 0.010867408502060106, -0.07063447001862277, -0.8135584138936873, 0.08369005886219878, 0.5151382054137484, -0.12357756952572548, -0.0926948048064692, -0.26217185832982237, 0.016915022858206293},
    {-0.11484915928196286, -0.19255894564225312, -0.374173987877251, -0.42388527152615646, -0.29628311756667414, 0.026297473556813947, 0.10021789192232584, -0.3174056421633141, 0.12354565835412207, -0.24018063061976283, -0.5634087998873815, -0.597265821614584, 0.24941046949908124, -0.2371542632236861, -0.10724930146969447, -0.22530957081404276, 0.4298956861801997, -0.2579884892490531, -0.21676778156635437, -0.21055239816230933, 0.17693982412516235, 0.3596869043090319, -0.25963350295132503, 0.030279424442582015, -0.34917061433181534, -0.43497590965018224, -0.19658630654233666, -0.24765911299210597, 0.19720479382672318, 0.2912904982540288, -0.4335134192734936, -0.11473187813818235, -0.25777183938386483, -0.08845194193390349, -0.29979875193513117, 0.3390416649935286, -0.11058565452590953, 0.02590834768363273, -0.1187076279155759, 0.18923659302805484, -0.5244732083651115, -0.1028233802441617, -0.3180839372350751, 0.11944543358106915, -0.5343839937477752, 0.012148141350108919, 0.049278609643300615, 0.3063204990044464, 0.09780210008819888, -0.013674525817407577, 0.1287534625368436, -0.32168764530472116, -0.15810930705831924, -0.12473214993051379, -0.381743333580875, 0.17656410918706814, 0.044816367739982786, -0.26009129674507403, -0.2889295105818196, 0.3081737999689778, 0.042923863726219764, -0.258198435815608, -0.5804370132371455, -0.12353725133996238},
    {-0.05579082455183133, -0.04019168432529231, -0.2337529379434169, -0.12951423474415885, -0.24530215930887994, -0.24263431008796996, -0.278016263106511, -0.23071855208889544, 0.08869402583017669, -0.18069026061048382, -0.23587457108930537, -0.24664272397850034, 0.10651063161413618, 0.30352563924350257, -0.2501358559373242, -0.1338689281461646, 0.07886502058798922, -0.28640134385039273, -0.6222176018635344, -0.19370524908986902, 0.26974471272795914, 0.2137301904735507, 0.028053589413024722, 0.26310566958203196, -0.5927291062150456, -0.5270604325874587, -0.15211128111344005, -0.4243809898163096, -0.08351882896386667, 0.3831784467860825, -0.3994090640224224, -0.11659333849955077, -0.2887625716840795, -0.03360269933795534, -0.21030063321084635, 0.5050937030188577, 0.08140969603360654, 0.08314742672902332, -0.4376581370017446, -0.00684161406030665, -0.07411728969994814, -0.30776387895968893, -0.4156034429838101, 0.07007959411836344, -0.5145792090882471, -0.0066375486385308845, 0.04194737424758496, 0.22380393537990656, 0.26366852354237874, 0.09015161096909986, 0.28148211284262836, -0.3874687870748652, -0.39018186698532487, -0.6265962295801182, -0.29645697457929704, -0.045618585012132964, 0.2647769287027729, -0.4344702698831874, -0.05922565546431024, 0.2268167609567189, -0.5344580579652682, -0.1043310749041064, -0.29266902127530053, -0.4561878004355177},
    {-0.2760779234428518, -0.011366431301215046, -0.44629455488860237, -0.4686003103846205, -0.45230207988111515, -0.10065948714730104, 0.06406928517483663, -0.5799422839327896, 0.17372892010264715, -0.4569763768316967, -0.40788500115855486, -0.2774607427975021, -0.10142185289865277, -0.12486367004221897, -0.4184659596622486, -0.5819140812650299, 0.2886170498240588, -0.030418295790326823, -0.2959282350862435, 0.13590471934808834, -0.11020203518371087, -0.10542034183925407, -0.5066691618661654, -0.06807483618426347, -0.2589915195869678, -0.36087530571915755, -0.5015829859439003, -0.27972077287572816, 0.012061172078906623, 0.19575166351506978, -0.3411859945952073, -0.25029569084523545, -0.012423545635396136, -0.11357100506158399, -0.6720419071134714, 0.2926195337913089, -0.34362653235369145, 0.010820004993204582, -0.1492936689114946, 0.0657767876364797, -0.2768185778890639, -0.3832256435743536, -0.3857037327318842, 0.10138441140297087, -0.029331259023352294, 0.22821529724901504, 0.08085841262774826, 0.26507296792323787, 0.15527824022580147, 0.03369291172204825, -0.13726670355124337, -0.30932000739604737, 0.0759919427287982, -0.12665022473791498, -0.14281698771690088, 0.1564982366676457, 0.07556755183267534, -0.46724573019499127, -0.30133013558793437, -0.02790732314892263, -0.07742903262201033, -0.08430863058700244, -0.1590090296661748, -0.3995767665072199},
    {0.08336317419684101, -0.3516419872733966, -0.3789361910665086, -0.40861123695896917, -0.37315542542133323, 0.04021028628074361, -0.32478406577180396, -0.48953548129068464, 0.21379891009108654, -0.2929284314109575, -0.2162245938198299, -0.5621598435351546, 0.050171695518377184, -0.2543865014072579, -0.3132691074004751, -0.3068042930469554, 0.18304428346607687, -0.3171682489570235, -0.3975083176414758, 0.18016052942427901, -0.024555912795054716, 0.2751260584681554, -0.3390301948433603, 0.12441094888926019, -0.5432906097272048, -0.7735052890987512, -0.5028846568681177, -0.3931235225638092, 0.06087370832934883, -0.0226627105194395, -0.7576082226621611, -0.3381375726026533, -0.055302533126304676, -0.16202658384497323, -0.5969967864096369, 0.23968875344869744, 0.028405806842871483, 0.13486149441783327, -0.175224512670749, -0.19538678354080607, -0.36741418604022663, -0.4217500685741122, -0.7428840005543302, 0.21660909857309674, -0.38522494913769956, -0.15706128948986342, 0.2685778665817678, -0.0017152442551969748, 0.10522049237651059, 0.06840415671648167, 0.07988316183079473, -0.4103148448131891, -0.38275615327298995, -0.2873796330532825, -0.5077327753890457, 0.0023581706449304117, 0.05129894726016511, -0.4753218436246853, -0.45553212400187626, 0.03856230245474616, -0.005979643174856077, -0.2006196875152656, -0.059762010522692345, -0.2893144445692497},
    {0.041958412594243204, -0.3686196600453702, -0.10316987789345479, -0.34102213902071066, -0.28796150715071167, -0.15566568878586723, -0.3013386640373702, -0.14883596732610113, 0.08780145508434187, -0.2527818669581964, -0.528068979396017, -0.43000383506169565, 0.12426470856339124, -0.1262310806177647, -0.042016754482420295, -0.15826768312841574, 0.05624706490339237, -0.11661968923619961, -0.19584944444390284, 0.26853435851481505, 0.19263090543615924, 0.0009438450839751844, -0.3271363571757815, -0.150252615839874, -0.48227244879510134, -0.5146109948059169, -0.08983492784320596, -0.5187278807034664, -0.32201946353756883, 0.0015711894744770212, -0.4163471910534863, -0.21859890527255318, -0.29044951601448665, -0.2596792854887172, -0.40707469747948943, -0.10193034034715402, -0.11755598684764271, 0.04532402305869453, -0.13812740080111935, 0.04288329240186353, -0.45952921554835546, -0.4261828248780693, -0.40332712968686807, 0.2198351841273301, -0.34063574521231405, 0.054668816791459976, 0.19072896790476526, -0.13230227957632804, 0.1757260216473404, -0.10488266258136453, -0.2060726325843222, -0.22162575867056816, 0.0016423776426575934, -0.5495931712551497, 0.09798793040438734, -0.015507222353532885, -0.00108736311909106, -0.44253149259591795, -0.3678809035016172, -0.17139944189235387, -0.19588607227391866, -0.23821647096407966, -0.2465165510472428, -0.17161534145523602},
    {-0.23781755148351053, -0.11117594053617241, -0.4716364816378968, -0.47758279748455584, -0.3008484676351593, -0.27288975646417096, -0.029642256520677836, -0.4491856799256936, 0.1833225330325219, -0.40512395154622427, -0.6682010073767891, -0.22293823186292241, -0.01146273142315436, -0.11859935968823816, -0.023755754702701557, -0.10723661352033942, 0.10986399265261733, 0.07683732965392741, -0.2585880737785299, 0.016909828568485517, 0.01318030809043942, 0.07700970577336301, -0.11775795329963062, -0.07917928956873035, -0.4882834501961007, -0.2052648445523826, -0.06411921501285861, -0.5234486614741374, 0.12455429433589997, -0.25721507856633385, -0.4242582353311395, -0.4819652858576045, 0.0616923680935245, -0.15783212155253995, -0.40649731081227225, -0.15388136547294098, -0.19538628612386658, 0.265583090872435, -0.0880768747538598, -0.0018005770700271551, -0.6599871895593129, -0.4508952989526382, -0.3728855764567303, 0.2764961385325863, -0.18646420544675182, 0.0490097246484449, -0.20484681662875134, 0.17742875939951247, -0.1314186130549055, -0.1403401421983535, -0.18020203320062375, -0.27624845401499, -0.07311494023336336, -0.3039479564372558, -0.3475577312035117, -0.32812592415017927, 0.045462759314895095, -0.3193581447272551, -0.5909443516092275, 0.4676955080615696, -0.09719500209128494, -0.19438258496442254, -0.3468751507886647, -0.15373535273648156},
    {-0.23621109946275862, -0.16467288689411264, -0.327021733926854, -0.5254002015151938, -0.40554738089654474, -0.1012528947850554, -0.3372967268176429, -0.23394514631090588, 0.1786791746467426, -0.2503111236793951, -0.3235872311443127, -0.3330623932549569, -0.17550266046637206, -0.25415345337842077, 0.020285456307066935, -0.21346279269689175, 0.27723227443655196, 0.16371257804448625, -0.305015645244642, 0.21900828125620733, 0.2246479901105122, 0.02124035897242421, -0.3364746837778347, 0.23272468155543424, -0.3318498652857176, -0.45624936620339224, -0.24269530160571934, -0.24081104998743752, -0.048600044813731674, -0.29602233755193985, -0.5016444586097296, -0.5741381997564727, -0.09693558995776241, -0.15263294438171124, -0.38051699888364554, 0.323728636954503, -0.4128789118589647, 0.1786385928035107, -0.06364246937872846, -0.016241948236903524, -0.6208465408422436, -0.14587098406795204, -0.27365230335749324, 0.2309413723963756, -0.25896551001533025, 0.06310460362799832, 0.07668445433716897, 0.33174351450936074, 0.12289290812792418, 0.013432949765387187, -0.005969982766268803, -0.06715331699107704, -0.1623205174740161, -0.1441449240069986, -0.5094677971189107, -0.12073158695072017, -0.004140000208171085, -0.24965517300313272, 0.0010957972259945505, 0.02790685133459995, 0.13179657540044698, -0.20750885807706945, -0.3135472744868853, -0.02445554829052813},
    {-0.19022985588754382, -0.17988422673207025, -0.1281798362998106, -0.6213145632599197, -0.47185406964882065, -0.1766534762013156, -0.2440478515044352, -0.23446736960055914, 0.22619934269879113, 0.1327852337718022, -0.13257084622761922, -0.22905888121569523, -0.2906085648715276, -0.05331525820609554, 0.02503068705217754, -0.19109309152906612, 0.280369475464279, -0.13555923123582123, -0.5143823644406544, 0.005874805066209166, 0.1310184669463687, 0.1931629585791139, -0.34001877289832294, 0.0580635007616218, -0.37974647612437507, -0.26909130574203005, -0.5093341299669235, -0.42986126124333207, 0.08770420273845954, -0.18408345039443602, -0.6228691081959618, -0.32876227184534884, -0.07020927477526252, -0.20492845794830117, -0.49206374440549383, 0.07427979623209802, 0.31423044468211614, 0.06557821029727041, -0.3109180063177453, 0.1298041018296658, -0.01309256859887439, -0.5882347790556444, -0.3874163332639235, 0.281920376196281, -0.3627939299862743, 0.2454106329556379, 0.15224921099053884, 0.22568434566417794, 0.01685212761743215, 0.2764292174676474, 0.13251749025573756, 0.005994185236490384, -0.1962153071427525, -0.4344667548783464, -0.5408504561680147, -0.05211312475989262, 0.1010846755510146, -0.42296116454841814, -0.3984146468575207, 0.0615502645516142, -0.2850064538971703, -0.312569041952673, -0.32049746346526603, -0.12152626017047964},
    {-0.3189283760914424, -0.1644931385423869, -0.08477121685785377, -0.37005571823840233, -0.07465610327814999, -0.014951715909396994, -0.15422237167250202, -0.3390461300169363, 0.08303991715477961, -0.048516879384909596, 0.1155903278032927, -0.036538720930671634, 0.01731499479874353, 0.2287889210958982, 0.14698571247418782, -0.2539425772709863, 0.2866803368593243, -0.11018360792441877, -0.46805618635886037, 0.05146193622038254, 0.12531671849676754, -0.018365013375648918, -0.21251018647877898, 0.24051204853843386, -0.2942518967684237, -0.3680783829861373, -0.2972461274485088, -0.24212792014625945, -0.12462475158256539, -0.19325727233127593, -0.3926729194392493, -0.09584011166673401, -0.3316560195253781, -0.4661196282554776, -0.319194404696995, 0.14194445532593694, 0.024346478663176897, 0.2183010758998185, -0.1786265237580511, 0.26386095317824754, -0.404407518588326, -0.47104120314279657, 0.024345931592283505, -0.18433386195413576, -0.25446239453864844, 0.5441194829438153, -0.03932070436575445, 0.25236487407639296, 0.3324975050889026, 0.16362674434141444, -0.09553901933146157, 0.11547934460288925, -0.06580644542911332, -0.5692807686592276, -0.33138107346124085, 0.2763769346606708, 0.20779572976181937, -0.46565225540860883, 0.08958957978711125, 0.20759253684486237, -0.22366628714918665, 0.09558709227869171, -0.40842742504329, 0.15364183429215786},
    {-0.6777260364349784, -0.18237817943864099, -0.3230158564165482, -0.4508793586345926, -0.20134466742010293, 0.12150989631262436, 0.05440751480771309, -0.5473367540454362, 0.15505076060993422, 0.0946384421776096, -0.016185535001350206, -0.30957172932084315, 0.0807664819318877, 0.07282674400972877, 0.24991897036631777, -0.18124536198767882, 0.17008866248533072, -0.3436644254710663, -0.503588747840542, 0.3997185517824232, 0.016932606808648366, -0.0035217591036443485, -0.2210935508703141, 0.15310568821653506, -0.4039148060016145, -0.4863176625836187, -0.1267883675250018, -0.3410163003002169, -0.03789380830238283, 0.136875751168062, -0.3339583884969062, -0.1706923440384767, -0.06904568930045803, -0.3551005652809572, -0.2314784492809137, 0.12454976634985525, 0.02505531657893157, 0.10948784660270312, -0.09128856310045969, 0.2469040139640947, -0.25328379299703224, -0.33961520413353674, -0.1264345718278987, 0.16204136336978078, -0.5594052994336574, 0.011256088394951022, 0.09561940942388458, 0.16886050878323006, 0.3081483734206966, -0.24777182179124774, 0.09602372229137197, -0.3865610876281346, 0.14441930153351443, -0.37973898164218983, -0.4582538262627038, 0.3587148638407236, 0.30232477312487194, -0.4721785255256617, -0.055156916594305376, 0.23817815381103893, -0.20856536931433464, 0.13206616566748816, 0.06533891249608154, 0.08818275619837017},
    {-0.44371174706257904, -0.4826968332461718, -0.37474138225523307, -0.3143563414911871, -0.4893046449525083, -0.1138287719293297, -0.5304726929123326, -0.2998075538406602, 0.05706051271969623, 0.005940193364625817, -0.03750070579912831, -0.15896105721557918, -0.12395726238930521, 0.13071251277692644, 0.18083788064105824, -0.6445308691461911, 0.30710342589933565, 0.07691150344968353, -0.31948760622149236, 0.39009563957805504, 0.24032017746393391, 0.35867383164527533, -0.6095002543502609, 0.09910282333725882, -0.5041596837698182, -0.41560592124304846, -0.4264430475344719, -0.30437273294255657, -0.19123753828847004, 0.03582424551801486, -0.5289398326809159, -0.14459657753788627, 0.01780767843586399, 0.06401704776949094, -0.6080424970083054, -0.18263737247522033, -0.07302378045649233, 0.3939858367536328, -0.40713068090960514, 0.3253375991764367, -0.32758974463897766, -0.4730813301349491, -0.1174581328651055, 0.07124118305248872, -0.5079896189025215, 0.40036429882017405, -0.00970643679004915, 0.14984057690690034, 0.33478435244147353, -0.16039007383762532, -0.18815593503013725, -0.31161886144898726, 0.035986820930731585, -0.329573505383399, -0.43166257516070816, 0.5855275533304353, -0.309017259157469, -0.2387812478012654, 0.04801920997376967, 0.2507748908883497, -0.18922697835946417, -0.19205865893241794, -0.40827550511730426, -0.33741236927170803},
    {-0.540854019891623, -0.23680183458817625, -0.10345292842308136, -0.588185143851687, -0.40479335441281084, 0.12267250687038474, -0.2839173295677616, -0.4287784955662349, 0.04743434470752721, -0.1455888909327983, -0.4299858066155512, -0.23592701606347224, -0.0825342429165533, -0.34429806320523754, -0.290836672293319, -0.2141278467918989, 0.40128104110118, 0.04259446373116228, -0.3347777848909908, 0.0772114781926494, 0.19769554535552614, 0.19379514109888926, -0.6433480000451742, 0.16089134474450825, -0.6584962606769882, -0.48196777074980557, -0.4558908302297042, -0.29713031858160693, -0.35149842079576427, -0.24941720889951016, -0.7443038106963981, -0.2610405547814753, 0.0598664788366928, 0.03056423081221934, -0.3826549265451005, -0.0757858395689285, -0.057983275012367, -0.146376630442689, -0.31624669490653795, 0.20380495185047445, -0.4560756173127951, -0.7500102106250718, -0.6538762894043575, 0.004991514728917141, -0.30322898734964254, 0.3740415456304961, 0.18813700888825954, 0.20334976702743146, -0.2634776524566193, -0.1530678816135126, -0.2455519593754945, -0.5898231632658033, -0.08753660141184047, -0.3971828194321938, -0.6139621104577194, 0.10115199725728131, 0.16059253524742897, -0.4490685364343565, -0.08980099646379744, -0.015812842831760956, -0.17909543749909956, 0.04309536782260843, -0.4275061641391935, 0.060772581915585905},
    {-0.1353669594266904, -0.10444628714169496, -0.2954045508422991, -0.554699067747654, -0.5259199675270975, -0.025556834825326245, -0.11856743833165616, -0.42783723669637025, -0.020054929262027198, 0.17774303003864111, -0.26666993453707627, -0.5223794883176982, -0.3868657073974257, 0.041420310730302695, 0.24133537051577386, -0.1957570470589397, 0.3276189461508875, -0.17603407382418237, -0.3449850585945805, 0.030663534397246815, 0.10497303015862539, 0.38419931716907385, -0.5039094685596385, 0.2473979434002874, -0.2822566375093305, -0.4701591513796538, -0.23417632124902107, -0.3505036856752767, 0.1605712607253144, -0.06275477281797845, -0.4689985616887584, -0.24613975039280633, 0.12315827793689563, -0.08375552088593743, -0.7448988210468939, 0.3236402009306399, -0.03198253460459548, 0.3708354530818482, -0.45416138507324627, 0.16303660454179458, -0.20132105812297052, -0.6101621728622423, -0.7051482199397371, 0.19334364275292804, -0.2825287594600262, 0.13351123524424466, 0.20089916815571346, 0.2661192897160683, 0.17952290499056875, -0.18256814907716357, -0.2713113061275544, -0.6623477119036709, -0.3216543850440171, -0.18963004699471003, -0.543688151245332, 0.11583620251269874, 0.20430488024712767, -0.5332963417902432, 0.03309390944464045, 0.05901945636807025, -0.28400545392148985, -0.4329840539322102, -0.4016172024651038, 0.03595914043763026},
    {-0.0607825973742793, -0.4128634588908426, -0.15855408201782034, -0.4881743067144228, -0.6695564069702629, 0.41129494074408357, -0.14370343167619343, -0.47494342661706646, 0.46721961429612496, 0.1554022365592878, -0.07812211435069241, -0.26615851149150377, -0.09174558780318658, -0.20179109178351629, 0.6088214104469147, -0.5417238335521102, 0.36394440622625046, 0.24431694431231987, -0.34879927894339174, 0.3934795540803199, 0.5829861768464821, 0.5829819938442642, -0.3463211168943274, 0.7571983420156412, -0.26781526229403024, -0.08009781792794418, -0.250598656370521, -0.2631859701165337, 0.10647994922727068, 0.278857084966444, -0.6922114642161916, 0.0901028209379277, 0.13011426238118776, -0.09812173015372129, -0.7917225508621806, 0.08045212393506823, -0.11833600501796011, 0.2991937282338162, -0.420870207410064, 0.24579967323784332, -0.2377903312993424, -0.48389879884937376, -0.06335178554750732, 0.3609527740598067, -0.26024561894603077, 0.2970450810373939, 0.1822857192986653, 0.29357363393705915, 0.33843582684084905, -0.21684236898300527, -0.6430886961164618, -0.2669993834706494, 0.2518241535174058, -0.5567788293548965, -0.5633166217899602, 0.16314097605608938, 0.29028693666728006, -0.3387674242226665, 0.1639014326464178, 0.385443974562246, -0.2844745623677299, -0.3043591254362195, -0.1384943673667733, 0.09192673385522501},
    {-0.20584131012147996, -0.24875204246229723, -0.41652642867427364, -0.26602736152387163, -0.6542226468228838, -0.11225663734792789, -0.3493612543640493, -0.5429303932561087, 0.10476862513253953, 0.5217096374387769, -0.07123597647838208, -0.19990999289146139, 0.3764483219772054, 0.23086780406069965, 0.2666884445577676, -0.3811003021828476, 0.24414901395373026, 0.20025147092382187, -0.41091716112832966, 0.47136317084685325, 0.43594000421974344, 0.39003249633173176, -0.49088936215262563, 0.5538911960130755, -0.5625198703732422, -0.18272873899873981, -0.35714521423551304, -0.004498339515147584, -0.2173011964287492, -0.2402034101252665, -0.5176401077442709, 0.315221453667943, 0.4159017501013518, -0.28442718471022505, -0.7544433839486817, 0.016822157921671452, -0.5227918088592484, 0.4533221907571884, -0.2814824746760949, 0.7599275389552602, -0.71281126629574, -0.5185724511350054, 0.17151782680131963, 0.3849718422190631, -0.05792293073074179, 0.43792064312431556, 0.2943702318312381, 0.48664623886869485, 0.06936509915787799, -0.3823575226850829, -0.8044287228524525, -0.2376677903471132, 0.1394903929901953, -0.43787484552998923, -0.6911992089355122, 0.5933588839887541, 0.20603916885054524, -0.28534826197124163, 0.22008852279910346, 0.13656609272169795, -0.1865457959513791, -0.3586030117224899, -0.21036385874771, -0.13308566444818423},
    {-0.3189488208201451, -0.44099411844661024, -0.31417768704244703, -0.55294647448187, -0.5462079221235472, -0.1105520606910724, -0.4426204647881926, -0.5515643295197419, 0.11869576179396142, 0.09676169240060357, -0.25140248911102664, -0.4399742980836627, 0.2837971731391347, -0.13783512533847006, 0.37313952318753, -0.35025004295652123, 0.3516130688132555, 0.3310204327084343, -0.5836943783608894, 0.627095919641989, 0.16742260217031418, 0.5368327421601702, -0.5076920318520867, 0.10639606114285259, -0.51145913690238, -0.4864785459913017, -0.37767427707356616, -0.6249573759154724, -0.10560406802260357, 0.0757068695072776, -0.5973949372764982, -0.06510410026856416, 0.38564298495904753, -0.2084162153508021, -0.5038873590460639, -0.12519534321818795, -0.10937072105779191, 0.04870726185987413, -0.27395981766300037, 0.1634910334031992, -0.33429284999891995, -0.4735704023936964, -0.10648627610234321, 0.20026975974108696, -0.016175340204272016, 0.41468585766510985, 0.033785584559566116, -0.011510297648284828, 0.1495924275312575, -0.35057574481032777, -0.6800529661787049, -0.18264638652262344, 0.11070587841144029, -0.5255821936869427, -0.5195356116439259, 0.3819064517434064, 0.011132939291342021, -0.7196852475739925, 0.2378072577501956, 0.16040632396646437, -0.39153875418243184, -0.36379502806628894, -0.2564565533236627, -0.21773069522698946},
    {-0.2602046859509675, -0.41699446251494, -0.37565477008636383, -0.4102278537410932, -0.6149609922060062, 0.03908282355057967, -0.3016669287913616, -0.5841798183946718, 0.11231775751584884, 0.059977706240024936, -0.2643060222670536, -0.30246251173733735, 0.2441872741271156, -0.1532130092679632, -0.002537493051812015, -0.5341395885710899, 0.06952685312511143, -0.013016638897234426, -0.4662666774088523, 0.06848193533714583, 0.03202458335873754, 0.23066770487703112, -0.4350303915218818, -0.07987342430800604, -0.36462341623723504, -0.505829814454433, -0.4722656991081045, -0.8205440743952894, -0.17661382212015933, -0.30278589984354193, -0.5946906848065413, -0.31843111728675516, -0.22968232232449357, -0.27378981205200126, -0.2339767784576706, -0.21435490467350823, -0.20150401892436604, 0.24593973556616738, -0.22632823515546358, 0.535486057615305, -0.3649254137878329, -0.647159050471517, -0.38303293123694215, 0.17394248926379152, -0.39223902870894867, 0.18086370835324433, 0.2975700746219444, 0.04398763995663591, -0.09681876638966976, -0.140634621157718, -0.2939718319156911, -0.4524217468568395, 0.12420823380745002, -0.7009615480306326, -0.33495916560372857, -0.017715570441399542, 0.18680868944891854, -0.22866681414626963, -0.1513996666290437, 0.16365486259131717, -0.49916134619962915, -0.2844492904698915, -0.18562276524979754, -0.4476501403763461},
    {-0.26179332854581877, -0.17800434233104373, -0.2828987472160222, -0.40837835414380574, -0.7080535495386, -0.2857802318083379, -0.29508465257269983, -0.4917369458780966, 0.06142878396203889, 0.18571005718422215, -0.4136097058741835, -0.14717414045647287, 0.2750474846506546, 0.07293296728235671, -0.05313060113060212, -0.46524684818768175, 0.43814726918069913, 0.14667881931355345, -0.5139490598380068, 0.3127133237591031, 0.29254122580901437, 0.27589596844677394, -0.3068480167902302, 0.12851105612911695, -0.3572321661809593, -0.520910646282077, -0.10551637295949862, -0.21867278854527372, -0.14536896962317955, -0.44775222037850543, -0.4697799442473225, 0.29089354702636844, -0.0309761866153978, -0.2151536668789996, -0.7194999563742022, 0.06724310551419257, -0.22493354789827621, 0.2193830878303964, -0.4113542587999746, 0.37195314148730735, -0.2354626734486824, -0.5192582617983118, -0.21080025809576058, 0.08762262071250458, -0.09924237141159867, 0.44726188145465173, 0.16496657558357647, 0.21949508985701013, 0.07219601571799376, -0.3160563788342968, -0.4129625133834844, -0.28792084633181064, 0.20235568168302226, -0.452627453476907, -0.5713019046201819, 0.5623622763269118, -0.09969145381347547, -0.3002526364363322, 0.3660301852510951, 0.11406454155512323, -0.497667665451098, -0.1722320782848563, -0.3096860111966376, -0.28738831266039794},
    {-0.30026691477295264, -0.3124477212867886, -0.23064654709323762, -0.524613612086731, -0.6770573073619728, -0.2035672783068098, -0.2658543083647636, -0.43604870842466287, 0.18024344383109642, -0.10337738823315246, -0.3681697074197092, -0.18934828509070611, 0.2803203594214289, 0.008385941865119378, 0.10128443129785897, -0.2846444496777813, 0.2756205895161782, 0.483822949319058, -0.3678364881723956, 0.5495503452467256, 0.23329733660125485, 0.5268935350116266, -0.3676434841514989, 0.5397269835235872, -0.717679624192005, -0.5235368265356058, -0.476684861676978, -0.25779136823570903, -0.04783752391774748, -0.04537944036066999, -0.39002708477311304, -0.13795717048181902, -0.01748662266855809, -0.27784672687276746, -0.6720826886723791, -0.0581688299196736, -0.027809925117895158, 0.03297511228501477, -0.09961461554392002, 0.5439027135679755, -0.2556638320887078, -0.7123393318861936, -0.36053362003716644, 0.05377535086378909, 0.000777555960156209, 0.3238918489202041, -0.08280775390063415, -0.02120943976117991, -0.1947723881264063, -0.37520343350252355, -0.34943761118866845, -0.4315631873714634, -0.3963350478137245, -0.545866381543613, -0.5922524502882941, 0.21342206209059558, 0.1726390824123963, -0.5288280829963884, -0.020858615710651226, 0.0631562028131037, 0.07187391060762972, -0.2362065603178611, -0.3098755886364892, -0.07646905842757039},
    {-0.31371587554894154, -0.3934845620820704, -0.5888551078400482, -0.4334846621530115, -0.49852525483736204, 0.11627939980117515, -0.1550213453335066, -0.7427087719654162, 0.11862164840846748, 0.31245090899126077, -0.46732764610996985, -0.46681160895911233, -0.05771602801956611, 0.06665771161253162, 0.316267584306477, -0.5132570194800358, 0.28868244631633416, 0.009924737130058847, -0.6306280882338873, 0.39112712595127413, -0.004004715712898348, 0.3034255773244505, -0.44032814068808873, 0.16992217394385198, -0.5334924583191024, -0.6822991427768104, -0.33191034286995946, -0.23507377525502773, 0.028305433958603333, 0.05232788503073204, -0.3815571425148819, -0.3399363762183372, 0.04750475641470065, -0.2930584694269638, -0.5176880516048693, 0.16396760806407532, 0.022326229566715552, 0.2109971274277851, -0.318596944465736, 0.5459074841712813, -0.5145905680892344, -0.5601342742860115, -0.37229572534038513, 0.24495973217730438, -0.25207285441938493, 0.21187441340776558, 0.25788844099498304, 0.284422164654962, 0.06884328760406105, -0.1899824437945864, -0.45867284132908975, -0.383606839647134, -0.08699945743083357, -0.5443122170446323, -0.5463218284535478, 0.3431852321368442, 0.28819920533249704, -0.725412699353537, -0.10709114504478436, 0.32809128466508475, -0.4493903114158284, -0.43456915867563645, -0.5216632649775375, -0.22607547601718533},
    {-0.037376888843559004, -0.3191821949743228, -0.10532221554754134, -0.5883690189326187, -0.5456965680270955, 0.023019304035638868, -0.4078764695424963, -0.6962765436888372, 0.32779544928341664, 0.2624456176654612, -0.4155080559739062, -0.21611678142573362, -0.03815043542033389, -0.20751105844162465, 0.34861263944500964, -0.18595462018098413, 0.37493426486111897, 0.023238757916626374, -0.6704128259631533, 0.583648597550556, 0.3390890168702751, 0.3831891165978372, -0.4401575802582377, 0.4778193075753827, -0.37095598136198615, -0.6579314318636554, -0.22413658174791984, -0.16844014254790196, 0.01759506305304145, -0.17096282549490488, -0.6118931872563287, -0.19293662324512437, 0.3332993487829234, -0.40708440290364195, -0.4918580638565439, 0.04509831507127208, -0.12816534808100627, 0.07490713609861553, -0.432985398942341, 0.4840795767988367, -0.33656428563271124, -0.662464728865464, -0.0044141879992780925, 0.6836715764616009, -0.26761063199657253, 0.4002381313219951, 0.33237473668793516, 0.35812515897768643, -0.11790058990054919, -0.27043757928461937, -0.4904398462449377, -0.525660574599576, 0.05047744688433656, -0.5988370886967418, -0.7628264627612915, 0.40411134905400115, 0.13502663327150277, -0.3804046609922154, 0.1202974208519176, 0.2740366497308305, -0.595445757224565, -0.40037879816063643, -0.4211181522233455, -0.0823437226139959},
    {-0.22807837151184407, -0.3823106868764409, -0.25522440735747803, -0.6777964811189903, -0.2735552337675376, 0.1680560594585489, -0.31909288227450094, -0.7600317588303203, 0.20389524761676017, 0.14298258959255608, -0.18674918428438553, -0.2936488947192388, 0.055415857381212075, -0.1464071435549827, 0.36980904729811814, -0.45973222416369347, 0.06398626411573276, 0.4045624311545776, -0.8171738011533488, 0.3793163943389166, 0.20796031688655467, 0.2296177747915677, -0.46037496141044854, 0.5078517769663635, -0.5044860769964998, -0.4425162794619746, -0.5586905505439079, -0.2525343382838811, -0.21467393355823813, -0.27787763529580006, -0.5921285549732367, 0.051112582499695705, 0.0722462101252444, -0.3722603126932916, -0.2725691108857298, -0.08719170445327212, 0.03040698658551961, 0.08900367793894176, -0.2862003733491029, 0.4293705475494379, -0.5564670016110832, -0.8324528088055018, -0.38642607915356936, 0.14441791564740214, -0.1145806703366175, 0.5747007882558693, 0.3370327662796671, 0.5986562980192973, 0.2525333222869665, -0.17204820677498842, -0.5718868285762976, -0.28925018487740867, -0.0042271755099151185, -0.41371132467583915, -0.489078726615874, 0.21311904455524422, 0.045559484606842234, -0.7020145603212073, 0.24271591156533903, -0.02321435833622702, -0.268740023755421, -0.20027188314100655, -0.31586186808477, -0.20676741666325607}
};

static const float b1[64] = {0.6261657808973302, 0.359822793199305, 0.634380822184538, 0.6380412579018503, 0.5838408994577668, 0.5695506678599995, 0.4653563281548938, 0.5705943439342889, 0.5096036255741285, 0.6141252029517438, 0.6179792956853396, 0.6068286599239422, 0.5841520577499533, 0.6007462812121487, 0.627527290621251, 0.5855986658475493, 0.5465096696946797, 0.42538037815422675, 0.5005202075966834, 0.540109394203908, 0.4356104286994336, 0.5995334940043953, 0.6067432807284844, 0.6225255649827791, 0.6150881045403934, 0.6345819071034368, 0.5803654858456818, 0.5486347196603193, 0.5899903967195511, 0.6094934701702361, 0.5856251334238551, 0.6253335842026673, 0.5639353980878754, 0.5467271614211557, 0.5986678537557493, 0.5242264448641903, 0.5406653555500687, 0.577762513203802, 0.621356733009232, 0.461620098009121, 0.5949679379077366, 0.6512868497652999, 0.6397495433693814, 0.5582998721749893, 0.6210332384888344, 0.6409253163429114, 0.5517926613249968, 0.5974662531995095, 0.6185329675884437, 0.5958768073220837, 0.624730096925258, 0.6418675289990499, 0.37397167205834037, 0.5764775636079972, 0.6383261025604905, 0.6223633986652123, 0.5157852702313895, 0.6231348550808086, 0.6064172997126489, 0.47421205191661636, 0.6477028327545411, 0.6000565799985899, 0.6343034620265479, 0.6214365185155764};

static const float w2[64][32] = {
    {-0.14145777408203578, -0.033138659235374845, 0.47064487140258476, 0.6479766016920403, 0.2031970240426602, 0.5724038022193213, 0.713796114867742, 0.5823603513569557, 0.7429183924231013, 0.2832877969352714, -0.054619504406177403, 0.5922485173321183, 0.9096746619768862, 0.6091904414643613, 0.8015395601960246, 0.5053341750178437, 0.577765672648246, 0.6363391678697389, 0.5273769983471981, 0.5866186674518987, 0.5933472004027585, 0.8459061194754578, 0.563689711503251, 0.9056124214626036, 0.5629964905672891, 0.8430556282849243, 0.15065894065522792, 0.1631415072069463, 0.6580234815290784, -0.10545956790334175, 0.5536938199561208, 0.5740686932761152},
    {-0.03881646466141095, 0.5008070162055962, 0.5492119926274953, 0.477430302599806, 0.2876288161465425, 0.7842694068478193, 0.4787740726510068, 0.6226817864252954, 0.2234690461074582, 0.5194780064841947, -0.021417439080311542, 0.6572923836026526, 0.19800753423533685, 0.4368569829143856, 0.5686209285309978, 0.4849248346483654, 0.38437071866244465, 0.5586702048925589, 0.5767593924484581, 0.7535120834368545, 0.3698229103980639, 0.28622204595993106, 0.5768675644394997, 0.5137187114562931, 0.6685073670326562, 0.4869456410420277, 0.7859867301352668, 0.08090948100101106, 0.2942722714098032, 0.3481428636980526, 0.3838674026866553, 0.5450112996575867},
    {-0.16480884150310446, 0.43185579169295507, 0.612700489970509, 0.601297568251179, 0.6917054774852957, 0.6330695420684299, 0.8488019342373773, 0.691220982184715, 0.6610272570903948, 0.6726536580833754, -0.20266498276251976, 0.7015183403077726, 0.5585629303649643, 0.7189943799422313, 0.5151875405436366, 0.7038861541942251, 0.40047099624131666, 0.6243459019646217, 0.6622102671694516, 0.5561523506990752, 0.3756752557626697, 0.5729278597717106, 0.7119388270629403, 0.500882516179244, 0.5583723422080928, 0.4101368682744458, 0.5006700644055919, 0.053703084219388374, 0.22348127422184716, 0.09288247591447736, 0.6719358005910371, 0.4458897947591843},
    {-0.31989429072192066, 0.39920569205070655, 0.551383118867945, 0.6485257257681014, 0.5186047926649953, 0.5544946388449458, 0.7819289184601588, 0.11619709073892573, 0.31076707721211894, 0.19092075344349496, -0.2530470738596921, 0.9168246893881856, 0.7435058324476561, 0.3207655947353792, 0.5940692650164661, 0.5967231749278736, 0.8227561824430426, 0.43497315036135537, 0.5164055644745575, 0.6748031473630642, 0.9761126290597884, 0.7489071308435525, 0.5916269238396016, 0.917148225790482, 0.5063077089031359, 0.7430670741283195, 0.8693760726267089, 0.06973978080294177, 0.4765903308007792, 0.24762849539281312, 0.84584045632197, 0.6340333789358603},
    {0.06788854746151227, 0.5094167318853013, 0.4044549304436573, 0.7082555176086566, 0.5898469722142141, 0.5740376952882533, 0.5424932847827404, 0.6134032050342366, 0.5400733063825697, 0.16469025307722643, -0.21116054246987367, 0.36477627593020967, 0.6799287382007195, 0.6397660472377454, 0.7354255934386511, 0.529756041802888, 0.5156172851858101, 0.4998790694520618, 0.7150969330000191, 0.5835223619809464, 0.8227316710307413, 0.555186880897531, 0.7587208499307239, 0.7359634623874034, 0.5666922825164398, 0.599611477257851, 0.5605715881031738, -0.3388217080758397, 0.6833899714543258, -0.31124724562170125, 0.5152080188230658, 0.5708860087387734},
    {0.21130484739897992, 0.345231314070295, 0.4367499744930659, 0.5086051334483424, 0.2428063605905883, 0.4591457554253218, 0.7398994701547355, 0.38709230602389777, 0.5375479270522263, 0.12541788925620712, 0.33125395474334246, 0.6460060332072098, 0.4840116415141151, 0.16388754624482674, 0.4726800242686511, 0.5991992933089274, 0.5039189588315998, 0.7610268348361598, 0.6284614710562333, 0.8402816114960397, 0.6021982277193039, 0.5588134364585523, 0.6635983414870996, 0.42317841281237445, 0.5720037316006362, 0.4783927829388297, 0.47400638918682125, -0.5300616613664272, 0.3850531867622879, -0.16253986153158423, 0.5782832303800117, 0.6380781764317284},
    {-0.10138142077937046, 0.46175712781417855, 0.29875995188507254, 0.7169268395767174, 0.6010574909374631, 0.3656742865883251, 0.25432200312531955, 0.4317989324823404, 0.4329881928839759, 0.3735834421562858, 0.14339516992725368, 0.49745985429294304, 0.6252736959268795, 0.3290276317922412, 0.7195734756533975, 0.34576164167988926, 0.4174254507711753, 0.5546741256383727, 0.3999318897122092, 0.3176407517031919, 0.5183810575009031, 0.37890056815547857, 0.711563301990148, 0.9770713166672054, 0.5690003396065095, 0.4559635118078466, 0.7591596986338757, -0.22226290310188737, 0.3510295047703536, -0.0002710551540335971, 0.4042753696793129, 0.7518404097987369},
    {0.09007466925802043, 0.24260124322326074, 0.5257634155596552, 0.39953761980852726, 0.3315254908410982, 0.45299539646031195, 0.17533264221100375, 0.24742736218566486, 0.7865393278446333, 0.11512977894671031, 0.031931025387149675, 0.6714510326997218, 0.7401860513440529, 0.5437686312143092, 0.75910156125754, 0.3494377589081082, 0.5809167642104929, 0.9235466293219604, 0.643007783628807, 0.7273604429620147, 0.6110532244389615, 0.7664392356616686, 0.5847149812289323, 0.6671627213079477, 0.7208050971533894, 0.36869349786104555, 0.4481419183646147, 0.10384426952631795, 0.43298481769966646, 0.07168952994825015, 0.6703826313829793, 0.48307006923969925},
    {0.21810311875363722, 0.15307368878252237, 0.5363911482280151, 0.6161364874132008, 0.6166428031315027, 0.6467080769902216, 0.34854737912644573, 0.23161864567477272, 0.5390423730668888, 0.3318302668047948, 0.03670418374011359, 0.3225868080159733, 0.41352793172283014, 0.6864879623106477, 0.4569084417160148, 0.4454685718551846, 0.8129004226033729, 0.6950346294049081, 0.23468646198389997, 0.388796850796817, 0.7035585879246271, 0.5688466017617251, 0.4762568346865977, 0.15352738119077766, 0.3286166478315048, 0.5676571711618562, 0.49357163802486037, -0.11863739011579504, 0.33025313715252763, -0.35117258145494057, 0.48006932392387125, 0.36717103586237365},
    {-0.3851612429995354, 0.45985333519574384, 0.4214054992148134, 0.4954131173067322, 0.5582676924453243, 0.7270378651323315, 0.7524915637427269, 0.17441155960628907, 0.5780059628915452, 0.1761500358955242, -0.1051875711091897, 0.8903689173436674, 0.542218660976898, 0.6417920186389989, 0.5827933407709265, 0.6743999760056827, 0.6811802579177426, 0.8246949591667097, 0.9493670822224942, 0.4878829923424111, 0.5596383960832123, 0.5871347662239115, 0.6553142321715134, 0.771158338217811, 0.7520182033305717, 0.2539282964930018, 0.8582278062423658, -0.09573368388095031, 0.42330428552969585, 0.11911586569365996, 0.7687373594569393, 0.6985543476736013},
    {0.17956125224498967, 0.6317777470100328, 0.5046707129106528, 0.8082602885309403, 0.5451150040204248, 0.5377197610614833, 0.7923356848090929, 0.08506002798606953, 0.4714448060768054, 0.6874043764789041, -0.06573024188785861, 0.6439825188205345, 0.5049669628519685, 0.6511594938657081, 0.3321569954088323, 0.881649981905315, 0.5033016855232908, 0.6872957254943827, 0.4638672655251246, 0.5686053655221607, 1.0670432474488605, 0.4948026458170315, 0.7305471281332155, 0.825442646527019, 0.576567729984046, 0.40189249444904795, 0.595051391402137, 0.006385068395875486, 0.4536448414394154, -0.024001066842860335, 0.2105780890299267, 0.35592908926064243},
    {-0.15279756848004608, 0.36341667118904686, 0.5623055480025014, 0.43427249443497556, 0.37145211627936964, 0.5056910662257466, 0.5072242444556108, 0.4151517211390799, 0.7319430982049003, 0.29189798695918473, -0.0862570630859729, 0.2602070697823497, 0.52968868916758, 0.6906089754432834, 0.7971769883930554, 0.309380763584422, 0.29785574696149486, 0.8487426146393157, 0.8112630772176551, 0.8624791052602685, 0.527834722141887, 0.7886385520792286, 0.5658409067257381, 0.6626115693314607, 0.6917286166905576, 0.5981298311711442, 0.9955595056970088, 0.1018248006153358, 0.7062437248114483, -0.1099668184207283, 0.34427725800472464, 0.3290589898180392},
    {0.0714650647503019, 0.6760339254620572, 0.5218426414991513, 0.7287543603134737, 0.933933741571797, 0.5690884467156021, 0.6713973681258628, 0.0016600842318329459, 0.7298473918143787, 0.31754396987780886, -0.17425445505442555, 0.4882608154537431, 0.4352408271301429, 0.6137111294446603, 0.33549942705606106, 0.7714560744328497, 0.525637588540245, 0.46913924530253026, 0.3909853924671827, 0.43865130263074004, 0.35105027448311943, 0.7978525415894928, 0.643143729840607, 0.41979315146785245, 0.7646577621090396, 0.813030371207211, 0.4538067352976799, -0.29218744447234446, 0.31042395659531896, -0.1272331422552508, 0.6474946219879224, 0.4885032060408824},
    {-0.21491577687422933, 0.394415648349517, 0.7049140836078363, 0.7849455059600272, 0.7909168393078215, 0.4640069671091288, 0.7211821568535195, 0.4241178427207314, 0.40553429682886416, -0.2142330059852903, 0.1250544951550825, 0.39086371461454955, 0.2989815324889096, 0.8979311307209723, 0.7442016577713324, 0.6986699047833242, 0.6090392817591879, 0.4803780983856184, 0.35362137848697495, 0.5502818293147309, 0.5413318768268005, 0.6074160868029737, 0.8380886291962643, 0.5497738177307725, 0.2672142246877166, 0.7870260478468045, 0.2268549222251565, 0.04213223994371508, 0.738011525986106, 0.19885852093919648, 0.25394001137905736, 0.6424641459991984},
    {-0.03913833382666043, 0.21636545180518696, 0.5245683744040902, 0.448344543649234, 0.516690919392206, 0.625316528453894, 0.5368673476465726, 0.5719991871598527, 0.7090411210857679, 0.3220380435747557, -0.012498474683220039, 0.5634532439842929, 0.49943847479485365, 0.3025655883769499, 0.685789025181115, 0.5950817713426354, 0.6599801726174014, 0.5369697502919882, 0.27177377815606385, 0.4310447344930237, 0.5743855802562805, 0.5611835665772659, 0.7118130337406252, 0.5487992843207014, 0.33908539853204983, 0.5495264322703176, 0.4627523056326904, -0.15775104248713134, 0.5736283694630526, -0.17674983709141165, 0.5040158710869879, 0.704132174180147},
    {0.06621852714167988, 0.06528247722758829, 0.7772010406251175, 0.684406706547076, 0.4702460445675804, 0.5825513162286656, 0.6520490930536804, 0.504168962842714, 0.6410653489149524, 0.14941248610677513, 0.016378516788683642, 0.8405424690267385, 0.6030329786252522, 0.33770281446141903, 0.6872080980385684, 0.19934193741242454, 0.6174795533587797, 0.9278704511800226, 0.7347108590736284, 0.5616500305311105, 0.7766352566344883, 0.4817565328676502, 0.6223394445015857, 0.5560536108614687, 0.47620846836956676, 0.3962408245171957, 0.8668360491342876, 0.20682998293778765, 0.4357704078790981, 0.1686726228402506, 1.0197776870250528, 0.4204879860387143},
    {0.02809758730747629, 0.5103655708350464, 0.5027028023556083, 0.510642215335834, 0.6931478940075174, 0.7061354259634957, 0.633875544672652, 0.15746744825746348, 0.7760058313048579, 0.19163872765362658, 0.01720212812220194, 0.19014823116232432, 0.3364798111402364, 0.6785775715062393, 0.6411265082428479, 0.5035753321286344, 0.734637295275927, 0.23467048495026646, 0.7291566288783708, 0.5900852012575922, 0.45610748137334833, 0.3517632031051673, 0.5024738718052736, 0.5579371138472704, 0.5770245726733219, 0.5596044012092297, 0.14542366472765517, 0.22623531056621649, 0.6836670664590214, 0.39301108254268485, 0.5640619140595687, 0.2370438542840215},
    {-0.0014860507493019309, 0.5940750889274997, 0.7009449667326054, 0.7012013242155056, 0.427191065132529, 0.6222661281630819, 0.31545427015101496, 0.3467575770015041, 0.7119484618581585, 0.3468141096424112, -0.008694511444085826, 0.5385193834730021, 0.5647563317912524, 0.7064354119286735, 0.4405788193096223, 0.2650674210312886, 0.7403667587225712, 0.5830440292971057, 0.5604070833271017, 0.8223960906787827, 0.34846907160571033, 0.45441548360927286, 0.5087722481553366, 0.46190496351958377, 0.6721572956710867, 0.3875146396024127, 0.3385067031794114, -0.08105863124344266, 0.1986893729842473, 0.17058567535377045, 0.5541778520087804, 0.41656283623912294},
    {0.20251145930892203, 0.32224753407091455, 0.39145785053318827, 0.42675369332684615, 0.6084859987142037, 0.4850518027320348, 0.483778247483744, 0.3980171072395398, 0.29866397628905483, 0.47362421642214714, -0.18606645885127232, 0.5976439179171903, 0.5971978999035292, 0.741186179756722, 0.48686724295488737, 0.6451500657255093, 0.812947851786098, 0.5687694820902597, 0.526724082820314, 0.38177063936545097, 0.4663315592020309, 0.51748275803227, 0.7926596728712564, 0.5118110150984356, 0.46645810857248354, 0.4496607345332459, 0.8550765012450892, -0.18333653700403482, 0.5273958063907334, -0.09768369703558577, 0.5059008254179497, 0.5023853872353303},
    {-0.026390893390942305, 0.812115000771391, 0.37375678166152465, 0.37153615970531917, 0.6386915466664095, 0.636493122072288, 0.6241282158650387, 0.29607277635637164, 0.6312176132277999, 0.30901841170566713, -0.07011802265287174, 0.7905819438155209, 0.31120585798115624, 0.5456020996055632, 0.46470731353394706, 0.7149929561283493, 0.49783686598351407, 0.5229238188212161, 0.5688687282640601, 0.43272623206372984, 0.5359467805582366, 0.5891704414070017, 0.4332829024165626, 0.568165330537551, 0.6008395447939299, 0.634510608746839, 0.37036543615157286, 0.23275899532963656, 0.14770433144026748, 0.09253644655226585, 0.1711884493823946, 0.5700243026197418},
    {0.05268609922287626, 0.6086946009965428, 0.6647523368236095, 0.9493788273657798, 0.3943810729277931, 0.48316311451202043, 0.5828852801321498, 0.2596186009626253, 0.44808055155750776, 0.31315514576492876, 0.014853820664945812, 0.7435311858508064, 0.4396689279387629, 0.4478283871295923, 0.6630387953706041, 0.5221663027596377, 0.4483964106303002, 0.35003072760011267, 0.5073898482127904, 0.3225570587599095, 0.46713678647514356, 0.517987338689658, 0.26129426556446667, 0.4001511158565997, 0.6698291222731843, 0.16985601223626776, 0.5470637957211936, -0.2303990065428454, 0.33773192759140586, -0.29024620354752484, 0.4492795448113429, 0.5483080673640621},
    {-0.2562431281622119, 0.42298805626679803, 0.5311066959899972, 0.8639276247599613, 0.4582565652660138, 0.3884627827872512, 1.0009164673665212, 0.26210658668491416, 0.7179976771983451, 0.02690645724450338, 0.17709100785852674, 0.5084351737052891, 0.5497063293611842, 0.2961676201567433, 0.4783291902084925, 0.7868004697007117, 0.6312274850174228, 0.471493305045243, 0.45803421509449466, 0.26860859806006854, 0.4314179500588493, 0.42976017876507017, 0.48674105398064715, 0.5381330206595136, 0.5081305967361452, 0.6058396517238599, 0.20667779826855154, -0.34052690938356, 0.40772350229909265, -0.24773877950878073, 0.6396621220082446, 0.4447448605789525},
    {-0.4600539128929845, 0.27016076954961377, 0.41875347820981773, 0.5983272729919122, 0.33087867801503973, 0.6686810043323128, 0.33457298978798317, 0.37656897399156336, 0.48343957924427594, 0.3096365347520293, -0.14391657351368778, 0.8465391388255189, 0.6908144196071722, 0.5939910432902381, 0.4953199961058306, 0.4881171360116611, 0.46959053325478356, 0.4453192381179134, 0.5383885686154246, 0.6716066703926815, 0.5526806046110971, 0.5642113553227598, 0.786889793429033, 0.5901330636181729, 0.3935957296510154, 0.7449579906173398, 0.4587287823596378, -0.07103930817816125, 0.3702001515344762, 0.06764040232400578, 1.0438760871459651, 0.6172591276865628},
    {-0.2696684773269075, 0.16881575033270152, 0.49254768627612566, 0.7992497907648015, 0.8165050370284537, 0.4027385078779288, 0.6655635237447018, 0.07737501683607158, 0.7984194464821418, 0.6794457971559267, -0.09475446363348634, 0.4501164679586049, 0.796628422939858, 0.9553428965797517, 0.42243866308903827, 0.3053607918099532, 0.5585676157399635, 0.6470187732748581, 0.6516976561608359, 0.41411472975149294, 0.4868442728912897, 0.41479521971852873, 0.5119706003005492, 0.642358879749992, 0.6038035715730664, 0.26767641068140546, 0.5078286422372348, -0.3622721681377342, 0.5680353821237093, 0.005937015120859837, 0.5518305956134583, 0.1762606692929267},
    {-0.2850382450300853, 0.3710980988541979, 0.2505612564764484, 0.6774767394387141, 0.6378473550935246, 0.6608883340765829, 0.40761449181941717, 0.40967237805742135, 0.5723165251944439, 0.3362815450070374, 0.17950330396098574, 0.47106309838205396, 0.4405395088444552, 0.6948376433584499, 1.0599315664910403, 0.7303130347574085, 0.5787328749869814, 0.40551478963506227, 0.47902118727254883, 0.5419774802331828, 0.7949537985087299, 0.7945260481356201, 0.6174200952177454, 0.7220662163888181, 0.5781636147039532, 0.48135740441012365, 0.3779922707193195, -0.08324390277472218, 0.6630278890124377, -0.26060194193246994, 0.6218846763287316, 0.4580785430188078},
    {-0.08999774956645687, -0.09071581314088481, 0.5642934232405351, 0.6988375055902656, 0.5599286417334268, 0.6233926844519715, 0.7113466876184967, 0.3161465176036683, 0.5589606503131609, 0.6139502728494237, 0.004776128740490664, 0.5464884734028922, 0.6928502214218515, 0.7991766097569089, 0.4153437721987387, 0.5855173530677239, 0.5997075725933599, 0.6384811165994462, 0.8946598916038206, 0.5695068146021235, 0.5745279495296269, 0.6807357760922366, 0.5301349558380424, 0.4647440083052181, 0.6795788222723729, 0.84588341990082, 0.5065307053773047, 0.045431705516545025, 0.44050748225273123, 0.10495191833148038, 0.4213832841341213, 0.4863645622451963},
    {-4.006904285802228e-05, 0.5832491019920222, 0.7323262950835064, 0.5849948352925641, 0.7229249539051161, 0.39478672634671114, 0.710931830087584, 0.34875451514968464, 0.4050273480085955, 0.2305051783523469, -0.16664596298233586, 0.5234782463462322, 0.605737006267308, 0.5169233832354186, 0.8232169016161835, 0.33426831398419704, 1.0914649881487086, 0.4533327567079994, 0.9078998733960404, 0.49235290716547586, 0.4815267998332611, 0.5696385324955123, 0.8811962450526524, 0.6636877478935911, 0.5519129741988263, 0.5812437830426965, 0.7875480461598627, -0.061839706870471196, 0.26581627110882455, -0.2940940411478576, 0.360603268728287, 0.36881816921128163},
    {0.0006672193326188676, 0.6168153605677177, 0.6957323991478593, 0.5743762102971137, 0.38743509718852087, 0.4681756255184981, 0.43026806531999257, 0.45982572051104853, 0.2866495416123241, 0.47208761557195267, 0.05247914641121123, 0.58941928889785, 0.7684576199283247, 0.45563663598948756, 0.6341791658051563, 0.8288183570085147, 0.5164807679802319, 0.5536352795222177, 0.8031071721869786, 0.40485444857856123, 0.5235508497189838, 0.5543190330740179, 0.5729665381120629, 0.6434401498057933, 0.5460084831011344, 0.5516014310070766, 0.41937646078208496, -0.23132983904830048, 0.4856228669539168, 0.18965409708043235, 0.48339784852263884, 0.5376067975174313},
    {-0.28090541406613995, 0.4714862195453273, 0.6350608392051071, 0.11151595725852582, 0.3784194540164176, 0.2494023083607519, 0.5824595772271269, 0.26206672019469573, 0.7136534400786351, 0.5088604023574427, -0.11961999592699822, 0.5077192655608405, 0.589464770885793, 0.6983287725552724, 0.7632760951983023, 0.8295251270590462, 0.4470773592561971, 0.3804415334829355, 0.3894415546023729, 0.6756444984328009, 0.2558177402325006, 0.2974050561519069, 0.5181603313474955, 0.7040714756470904, 0.446249112699526, 0.729741160665084, 0.5009045062561642, -0.21325816435758171, 0.2813641163263895, 0.10629304325566036, 0.2514721740843698, 0.4146698000614559},
    {0.09781502233416517, 0.20805890462435403, 0.8256321297469308, 0.5896811118141717, 0.43186200786720685, 0.5902386129766076, 0.98112618192984, 0.4054451459501285, 0.5135852809218865, 0.0369323791304323, -0.14403558502921868, 0.5025267943095004, 0.7472457181506521, 0.7037640858442398, 0.8022346364108333, 0.9283333664768552, 0.7530644647806247, 0.3891562340734446, 0.36186623601884116, 0.5822246114089067, 0.6918753946144365, 0.28542136405861823, 0.44529967278747956, 0.5955495829826799, 0.522153686409824, 0.43476000639321316, 0.7012062839260879, 0.14078066708022527, 0.48130355729479096, 0.07251690440940292, 0.7666997095138776, 0.19866692134168532},
    {-0.28808737689723746, 0.7485948178961755, 0.5154922618996186, 0.6210747827984547, 0.13746297833868845, 0.5160295683571522, 0.6732456350093121, 0.1458225794231347, 0.6838863078912834, 0.3029026235659739, -0.020383857126391493, 0.7962386470834558, 0.7523782631119309, 0.5318539055528803, 0.3896582764499984, 0.7988886293057905, 0.6454036077898331, 0.7354353730048713, 0.502798763842735, 0.6489418479700266, 0.7173950051844143, 0.463927234460809, 0.4795241864643334, 0.5359257201692158, 0.5853878573769493, 0.4449249533905124, 0.6458821182654163, -0.10676710917399, 0.5056924432353103, 0.23884217305879304, 0.5387251262807705, 0.49007025748135474},
    {-0.19845530337814152, 0.39935024986102907, 0.7499752865746373, 0.25738256615773486, 0.7252409572812468, 0.49991728769206933, 0.8090815161867444, 0.0567471757169406, 0.5300955722081189, 0.48910058600900286, -0.09150313396559742, 0.3665067949649328, 0.647516425018997, 0.7685907187066694, 0.5996648703513836, 0.7852171583086318, 0.8748039073194525, 0.44599122869513813, 0.6898695678436249, 0.7242670146941259, 0.42384711578354856, 0.7397308705132042, 0.8201025931760331, 0.4867045567318294, 0.8365244224866663, 0.7079636546785832, 0.5363778152014962, -0.031293266008912086, 0.450797643749652, -0.04357315894250569, 0.3781302699902697, 0.30274749924635497},
    {0.16061380352767715, 0.6677803307550096, 0.26923886671997627, 0.1808659006846117, 0.6533281127929484, 0.6534240107901282, 0.4750845671728233, 0.42647653772486405, 0.523782713447177, 0.05871724183136468, -0.358842915110309, 0.4734761573060948, 0.6862741545003003, 0.5975739446360397, 0.539236548263012, 0.8996966808932306, 0.5875315281842307, 0.42962266389421216, 0.7387030561262062, 0.3131794109965261, 0.5098035557166863, 0.5416517725821229, 0.6850463100129203, 0.5998179002759154, 0.21401340999438656, 0.6406642830313124, 0.6348351405653656, 0.0047561604014982216, 0.3926891271628372, -0.24883722879757222, 0.2509260910423042, 0.6130666836483044},
    {0.2119907018405773, 0.4225567049063165, 0.5105212739478665, 0.6234068155989003, 0.6581018382166025, 0.5044687804262528, 0.853160246005721, 0.23122272211177314, 0.4079304920743228, 0.4275533078314146, -0.22753600965788268, 0.7402869939666168, 0.5504793735806165, 0.813082913417794, 0.5748003329733634, 0.6047199194537902, 0.3332601016584769, 0.5905045696722127, 0.7600643523124904, 0.7672391080357213, 0.4824467586602563, 0.594698355097598, 0.38269370352830817, 0.4674279360592983, 0.5906399342234058, 0.1588135986324441, 0.42581535370666146, 0.10005840359000148, 0.5396796875777078, -0.04054948720576511, 0.7014131798736772, 0.3140958746261853},
    {0.30082656973707317, 0.21008181066934487, 0.5238423637218597, 0.6510440098656137, 0.6773500597017558, 0.6376143660937409, 0.595185886936321, 0.4826803454010055, 0.41633008841273733, 0.1748001381407478, 0.004101861369836382, 0.7573837210575329, 0.8133764101585992, 0.41883820163973423, 0.44721172645234364, 0.48782086008245934, 0.3707609371945402, 0.4601010562407644, 0.5027884125326163, 0.9241592115279942, 0.48920127725080215, 0.6516429754979624, 0.6225047483468356, 0.7128950075634353, 0.8334709937600119, 0.424499389042942, 0.35493759841678213, 0.09106188042658944, 0.2906248365894492, -0.10509929515384323, 0.6412782510178594, 0.2993471648595881},
    {0.16226007378484317, 0.2992498890552811, 0.8168283542846648, 0.4672291999114849, 0.7670632779552193, 0.18673744226173505, 0.7864929835957077, 0.23415417099081923, 0.7561911946740191, 0.6504671861010666, 0.003936398148841537, 0.45951727044259644, 0.3354384547479016, 0.46506255496246157, 0.7978410124652093, 0.4614315783813209, 0.4943849517998703, 0.5165806636005672, 0.8128034000211227, 0.3851384697092971, 0.4296703498065247, 0.35710118173604083, 0.3607223724312355, 0.38647365875890416, 0.5553258739658449, 0.36563785503359064, 0.3929395058679252, 0.07987880596659411, 0.37977468364241046, -0.022503429251774378, 0.5925045313601119, -0.06270677921971184},
    {0.0066433698198504415, 0.2387310412833542, 0.633859227404142, 0.016180541686980403, 0.4694233878795764, 0.6783016079743281, 0.8443422189478316, 0.15114014327915343, 0.40235939713101027, 0.7179808315525466, -0.048520158604774176, 0.4877072907606963, 0.42408086741312223, 0.6020527833346736, 0.348291985132248, 0.6346517351817479, 0.8816593620851622, 1.083811193856506, 0.49816961645947616, 0.44337318189232633, 0.36127325595340476, 0.4386170118211944, 0.45153642911448844, 0.5385069507420182, 0.6118772007470107, 0.7310201908753385, 0.5862096195595456, -0.25137223946925424, 0.46849933869709737, -0.3957372915024098, 0.653758009606774, 0.49628527382107246},
    {-0.295702009321398, 0.032944656463020514, 0.7733183711220846, 0.5788533852975862, 0.406429912749989, 0.6892173331094775, 0.6356705608029095, 0.30416740442508416, 0.2628768333421889, 0.12895943766408952, -0.04427143782763144, 0.5886859389967238, 0.6600338062538333, 0.506330977203924, 0.26294671187969887, 0.6025540504453355, 0.527805901079777, 0.7752047969709496, 0.5450449917628376, 0.21117653057391936, 0.6518899732491542, 0.562843812381123, 0.41098464098629434, 0.517887895627688, 0.7931122327289066, 0.5259790843228518, 0.5654931286612004, 0.10996642158220668, 0.5839065128415452, -0.10942693176017156, 0.47977028535562755, 0.6710754903462045},
    {-0.3268310151308259, 0.41034279027488213, 0.43710328711475827, 0.7662219197614493, 0.5135648332759927, 0.7575434502108774, 0.5288128412110414, 0.3056154175189152, 0.6779050137875791, 0.28503997248980645, 0.0527478031572215, 0.8036168781648277, 0.7404707642911829, 0.5124766452009722, 0.739800618799718, 0.6780673460239818, 0.5543055484325864, 0.610314815800448, 1.1634434650464682, 0.7132463936152662, 0.6463719895554448, 0.7883158724540894, 0.7140043180129089, 0.6615272481558546, 0.6004000284485632, 0.5258123039425394, 0.7102968427745071, -0.06868152450814806, 0.12768748770713043, -0.002177849696054773, 0.5222495592446399, 0.6000731931382727},
    {-0.07357517239812261, 0.03964351449036627, 0.7463925932211893, 0.5193495526880233, 0.8548225562899295, 0.700554624332475, 0.273798992647211, 0.5765294279230634, 0.7262320159323579, 0.3596756749600892, -0.1791813990462265, 0.6921472667365463, 0.6296488732684876, 0.9227653774046187, 0.4463263474131901, 0.46707147389087883, 0.9023824870409073, 0.26103716204525895, 0.6502597106111826, 0.696156879932301, 0.33794560837868326, 0.3375040962512527, 0.11235770038758908, 0.3115002075106528, 0.6934537721599415, 0.3859177337262123, 0.3514390490423397, 0.0699613267373916, 0.2202967483127162, -0.1023004910916177, 0.4203646034499275, 0.6217281417957176},
    {-0.023612305997391232, 0.5551657921406726, 0.37715492178196897, 0.6514242639233345, 0.3962239640708085, 0.5909600399658133, 0.7380835053826776, 0.5605294847978287, 0.5062282336833358, 0.3302904525100719, 0.03855171244024317, 0.4933293735808732, 0.8640481752221595, 0.1544726037476643, 0.35739357964564145, 0.5181055306951937, 0.7517913431442944, 0.5168633443967396, 0.7900334771771971, 0.6696790694154925, 0.5947397154982612, 0.7009811924602259, 0.9366999037509474, 0.5628772995771586, 0.8079621667047786, 0.8696492635299773, 0.554368828801315, -0.03208655330181339, 0.47225711460271025, -0.02764382005975686, 0.5433353457476386, 0.5935348592191125},
    {-0.06670992678355804, 0.24219592184759972, 0.4534569073954563, 0.5205965104995398, 0.47628113100056435, 0.5737679744159885, 0.7355786112848738, 0.13899162003825666, 0.46978432006347076, 0.17598451496815692, -0.05472235436987137, 0.21530315999721072, 0.9479625433413874, 0.5918071121985711, 0.7375517375372573, 0.5009981712379575, 0.5794119030064503, 0.5738891738376699, 0.642521214468804, 0.49650722092781935, 0.7937457453096899, 0.4801837366811201, 0.6626449541270854, 0.6385660908980515, 0.6082811538540162, 0.45953827964678495, 0.7287476403459688, -0.07475237921078265, 0.610179700780909, -0.05605301576639946, 0.704197208000295, 0.5316098892273705},
    {-0.12408288849014512, 0.06631203938908822, 0.4561414452561206, 0.8017316100047499, 0.6779930464794259, 0.9341382010818444, 0.856505037486426, 0.4133473880196469, 1.0538406795096864, 0.47239147496357375, -0.03711195643251606, 0.5307912885067559, 0.540979385275413, 0.8314761740523511, 0.5681137117079217, 0.4844057781828683, 0.5205816841458765, 0.8521491403262215, 0.6647551044808492, 0.694070162152019, 0.4583937713046131, 0.7830837359130715, 0.6761919430018906, 0.418596075557433, 0.6488452919418527, 0.5407212653342407, 0.3382481682095204, -0.010866524329226898, 0.4365574777728396, 0.0699640998875765, 0.6366929067037831, 0.4378030869630247},
    {0.042996540466282394, 0.3781130356002895, 0.27168663157482437, 0.5235393080188587, 0.5362682119838246, 0.318900555939827, 0.6757413162701557, 0.05454464474275115, 0.49499232944226995, 0.38141296697898486, -0.09135070745910573, 0.4084411773116511, 0.6502261630931758, 0.7866993637677278, 0.7495960142158152, 0.41800672851738263, 0.5159369473834321, 0.8142080102965842, 0.43548698202698893, 0.6185016058201114, 0.47161547954835525, 0.20060744539885142, 0.6603453648515681, 0.4551280918733476, 0.4539837709834217, 0.4201841210265702, 0.4107374998996721, -0.050494391312569095, 0.5343385684094791, -0.34441666700986734, 0.5722699925539841, 0.451203368856987},
    {-0.027444029856625245, 0.23503505809579306, 0.40624296081893385, 0.507303051586419, 0.5760168539976105, 0.7374728166498191, 0.42424561938395305, 0.65682609903126, 0.4458035283762145, 0.094615353918615, 0.015254015418645576, 0.8411938838265017, 0.5318195230689076, 0.7635251980325768, 0.6935909588608808, 0.3328549982173913, 0.6207785282672905, 0.8128133109257931, 0.5418661822265735, 0.559401839405689, 0.5781511336779716, 0.4612624215342848, 0.6306267970470679, 0.851633099223863, 0.5702714069461162, 0.7355815889659737, 0.226630364034602, -0.0118996270190123, 0.5160514796212666, -0.274511292897572, 0.5532091635679365, 0.5186233601425728},
    {-0.1873765884433109, 0.3610175916178044, 0.5350887618188488, 0.5476449280120541, 0.6124970806574942, 0.8102046468707459, 0.5583325070767744, 0.47844546679274097, 0.4769903421334325, 0.3366101079368812, -0.20593379918137683, 0.6229029470995598, 0.6653183498300431, 0.6163535924059843, 0.5469603222102445, 0.4165308308635945, 0.7442142798834733, 0.6709383673170901, 0.5963257538209714, 0.5299968793767801, 0.6828602352712239, 0.6811180595455516, 0.4102207619350388, 0.6090684384340556, 0.3886811404079443, 0.5567965175359181, 0.5614321785634777, -0.23233335065918195, 0.28058832260219574, 0.5212640975334968, 0.568838651357351, 0.5656636411719053},
    {0.06739034377709387, 0.23341993898456875, 0.4865738175603151, 0.591848664279201, 0.48474249517003826, 0.5379788405548506, 0.35827190506845596, 0.39898842392900463, 0.36182706704901, 0.4343701008704308, -0.30482264978376816, 0.35570012703342196, 0.5838922075833236, 0.7838370468635271, 0.4493468806135859, 0.5188827811416156, 0.5863668162671456, 0.7085546211920419, 0.2575287193314456, 0.6546702479094737, 0.44706630569064687, 0.6198619918659346, 0.1675788152753076, 0.6523895604066321, 0.8071942571381561, 0.47727099621667546, 0.5332285699674058, 0.06041909619312345, 0.46681347618196933, -0.196697469926883, 0.4925708461257994, 0.2881285548214716},
    {0.42316232695566813, 0.3291356819449803, 0.42991256159773694, 0.6279999038481063, 0.7725773232159933, 0.7601384900845879, 0.971491456933455, 0.4320389255930232, 0.4942037097020576, 0.442046987740677, -0.24100263826052357, 0.8540063307320056, 0.5513982188557455, 0.7231583293753833, 0.5526219736429183, 0.6951427929450882, 0.8056125193277105, 0.5421428091748741, 0.680260708524973, 0.5862275754402069, 0.40371832462583856, 0.5112644425397106, 0.4014025959878905, 0.6256364438397897, 0.4984650510889348, 0.5110233049950947, 0.6379517816311576, 0.09265947549428961, 0.5504481167931287, 0.22056839497620262, 0.3196487141510243, 0.4857049037976047},
    {0.06090487698674398, 0.3445797421602682, 0.5370355762428489, 0.6315758274313179, 0.4015546214136605, 0.6185488595741379, 0.39736959613826456, 0.5416644760504346, 0.8233430573119028, 0.12127947885194437, -0.12682925290703426, 0.49099029464304944, 0.5666884062608897, 0.5506359021210371, 0.7610484924286236, 0.4852474029876599, 0.20773869030035802, 0.6618702189141039, 0.24918271874586811, 0.7753535449067618, 0.3639693497866847, 0.4773820415983763, 0.47007142247759914, 0.736819714715805, 0.3794625220664859, 0.2946853312058934, 0.7235389862561254, 0.12210330738434078, 0.3876479235247025, -0.07585697117952805, 0.4124860789474202, 0.40694871919679265},
    {-0.2222223461262768, 0.2706404978889577, 0.36613303621355425, 0.47854277068246426, 0.39054793556385525, 0.5426694110767215, 0.3388941446149633, 0.15608389538679351, 0.4888638304985864, 0.5569513024742794, -0.06136499760052876, 0.2086577236580647, 0.6875060985825202, 0.7656558542539867, 0.4406138475916217, 0.5642595881034435, 0.6169116499059462, 0.63184421635526, 0.7008069590545304, 0.5770321201551146, 0.8789067605660592, 0.5375092121020708, 0.5424039886961624, 0.7595792980971166, 0.5476559836606592, 0.5088545202849447, 0.16175003559180165, 0.24243456110299916, 0.24769666761736792, 0.0547000185286853, 0.40108481040797656, 0.9030400815726587},
    {-0.17695242852791634, 0.4040598678405742, 0.5430189341669169, 0.5257190934182246, 0.5378889152638443, 0.5105729318744351, 0.3973725205438684, 0.028342304127967306, 0.3422836457174764, 0.5179860714016401, -0.35147920260367804, 0.5066054333683592, 0.35649488441877697, 0.7193894963400949, 0.852923921327912, 0.5955953413051129, 0.2862951711062291, 0.40476166681067804, 0.3965189717998182, 0.6409432458697606, 0.48675463938386004, 0.6335284148528137, 0.563395010073332, 0.5114053978833027, 0.5900709964920379, 0.6009127289702201, 0.5836213696659391, -0.46015067358317313, 0.4054252739812815, -0.18261944538336491, 0.5195343805037689, 0.5588816714081785},
    {-0.11953742071618, 0.4331198846194108, 0.6082339990513603, 0.7527707614705568, 0.4138503363314041, 0.696971047634362, 0.5360006392747179, 0.5721168012125641, 0.4254008943348897, 0.22289429763455929, -0.31008294085876636, 0.5210024134243155, 0.5153562675359846, 0.7630615180867425, 0.7176088827729725, 0.47694813922808454, 0.5080339975028696, 0.6031548660802623, 0.5408270358782892, 0.5331498887437542, 0.8888584566265268, 0.4575702608912476, 0.49983645732454085, 0.5908733582280392, 0.7440950578557881, 0.6975448383794615, 0.7657808115559397, -0.2971106386877233, 0.2628202472368656, 0.2637651733387959, 0.7060604434224629, 0.1695837369282405},
    {0.2584274063054036, 0.19042921313199587, 0.41114102321440915, 0.4879727004561386, 0.42498013213940294, 0.5927064298213713, 0.5966328520765775, 0.3460135601969567, 0.6276441175029801, 0.34003450835969035, 0.4785172782716099, 0.27857679110461187, 0.33206766534088106, 0.7374601399875736, 0.25527428013801945, 0.7171409220647504, 0.20517148144927405, 0.4484556556675399, 0.6269195361214565, 0.6652782132040255, 0.5530105074702422, 0.5817612920941067, 0.02995192516767586, 0.3499207605480053, 0.1880131670210597, 0.628268463838223, 0.7055863160243319, 0.0590851115222094, 0.3209052212850495, 0.10563518297629086, 0.5866101440855663, 0.3202186838005897},
    {0.3909334454841435, 0.3862431003341512, 0.7248929548895221, 0.7008499861676145, 0.5928756401818707, 0.49987877989770524, 0.4392535819409321, 0.26848867640723867, 0.6450754363387933, 0.4520240224274433, -0.4137618485363359, 0.7129730578826705, 0.4572104093465373, 0.5936222488618275, 0.7458918914488452, 0.7812576523274966, 0.5772353944101069, 0.9529419875949003, 0.6852391406188008, 0.5422258847702762, 0.594647286024225, 0.8186792467914475, 0.7154498288593826, 0.570909543278826, 0.5349039662899927, 0.604757405929297, 0.6000822338309953, 0.05610852184574409, 0.5497410294103721, 0.16102457122123062, 0.5204552323665795, 0.38710335927235495},
    {-0.07064853270764372, 0.3261230301377472, 0.5146464943841709, 1.0102512469815133, 0.752635127018809, 0.3777768336224689, 0.48678894646022997, 0.16204539625305422, 0.9144348967266366, 0.5288500508027917, -0.19712156814515622, 0.5375990123989859, 0.7999610544115905, 0.42545072234963205, 0.7373388237865842, 0.8600990631870018, 0.3974720493201161, 0.8309451518769465, 0.9403443131390435, 0.49062814555109474, 0.3721725085906212, 0.44207233536278584, 0.5593759403684049, 0.700836594744405, 0.5748282401280237, 0.17884842121375402, 0.6420424711078843, -0.29250900127976076, 0.40923647978698546, -0.08229147616824109, 0.4835384580510291, 0.5925110495520984},
    {-0.26596803348146075, 0.3073168000721109, 0.47283228188906073, 0.4944215492073587, 0.5859058949934276, 0.7091456036880321, 0.5569739277528478, 0.2550228529482254, 0.6703477457033656, 0.20091829107142783, -0.21958515224395259, 0.5283416201688488, 0.7936252676514156, 0.7037961299475284, 0.704489681406229, 0.5520815598901632, 0.637017009516436, 0.4409262259422851, 0.5593034641351902, 0.6641469233451258, 0.6311618462134704, 0.4152335213433387, 0.4206351304764207, 0.7740512763141193, 0.44843633008976813, 0.7935602977390023, 0.6018743209415389, -0.040947274328241454, 0.2110412802223326, -0.09494861432859766, 0.64212113701949, 0.41727957752538913},
    {-0.2453214841318797, 0.028693794843268252, 0.818456124962706, 0.43090691703191053, 0.5605127208512217, 0.41177672651233377, 0.35486314467855706, 0.09394524167839602, 0.5008929586664036, 0.4536571449540105, -0.07310007739822283, 0.5943812500663653, 0.5332655452974179, 0.9165239951094712, 0.6583213896192878, 0.31334437174290264, 0.37206909300994356, 0.4417118732478781, 0.15797310926624505, 0.8453960643039596, 0.4989177714935636, 0.36360395299196135, 0.47780505846487326, 0.4179925313042319, 0.5127050833172985, 0.5420572043870596, 0.6577223215713411, -0.068957756119334, 0.4283713706179303, -0.09737234902417286, 0.333111974658886, 0.7858028767604855},
    {-0.1492998404751433, 0.548741487948112, 0.771902882325166, 0.5173259942177041, 0.6778912086603629, 0.8078190622263682, 0.6276908996583007, 0.3311087808540482, 0.5949359421830707, 0.1801234312346917, -0.15192132690457735, 0.34228176956243905, 0.7795451780233715, 0.36577663604513916, 0.6580996729361697, 0.8837586866294476, 0.8488122846055793, 0.5284690977597581, 0.5659404137920672, 0.4141055416392389, 0.3771616718610188, 0.5938800919573866, 0.5572696445379394, 0.5208906791806045, 0.649050475741893, 0.3898646541528232, 0.8184454374566303, 0.06678079138726557, 0.27765854135105184, -0.08038353964459506, 0.6476759452022908, 0.6596576196995301},
    {0.20346237389912206, 0.33833142391090254, 0.4868102370785605, 0.5735601570560703, 0.8847797400922874, 0.793978677028989, 0.49798455478532194, 0.32156545504712564, 0.807660091877044, 0.47055295872118735, -0.197816116191207, 0.45618653486636934, 0.7595088077064783, 0.5875147401178027, 0.6351050294268321, 0.6059324212617461, 0.5308098693875016, 0.5973338924154036, 0.7159533706242379, 0.560252513300443, 0.1896922549535074, 0.998369986880188, 0.6367329254169009, 0.8468191128389179, 0.48772303804033146, 0.6835296609370807, 0.6158002400527676, -0.18854278760590196, 0.41165076109251564, -0.3114789698802155, 0.7279753482247279, 0.6503637626713924},
    {0.13925982588576297, 0.1882009038735765, 0.7369561953003037, 0.4318827819859423, 0.7691329240761864, 0.5440288016983946, 0.6037221597537068, 0.07387728531964165, 0.20747033171841503, 0.41167013866549734, -0.05497678576924588, 0.4782115125760455, 0.3677379644784339, 0.8396892559877579, 0.5829164712055372, 0.5513857749880362, 0.43318254550821617, 0.8299910543758577, 0.9552469378262319, 0.43816410623599034, 0.30831162184580596, 0.2457870149130225, 0.24465570517590415, 0.3011148532647952, 0.3499388727039566, 0.6205186821644567, 0.4086058190714021, 0.07440968080758827, 0.5913636307189905, -0.3802265331778301, 0.5212518858099796, 0.6133525396970431},
    {-0.10868710660802856, 0.23807463984461522, 0.8447346224900845, 0.7565793423655365, 0.5861185325305642, 0.6630317872197607, 0.6385719824500317, 0.4627318206481083, 0.4548640582043823, 0.2110189475113137, -0.08322870592052271, 0.6941494229897518, 0.7631727750907499, 0.7403012541750672, 0.610947865690452, 0.684706020741472, 0.5301999080103831, 0.4514685203419381, 0.5383366427497284, 0.5548643928719375, 0.3245940977239929, 0.6190228544558724, 0.9500818784702816, 0.4342742953136642, 0.5388845174061312, 0.5713292399258287, 0.4522848841677099, 0.025400104425507, 0.5938905710099399, -0.013619393131587255, 0.5013366855477119, 0.26377984786429765},
    {-0.045069389096256476, 0.42706365116981854, 0.5693331742141698, 0.7170439592100312, 0.6938684860147888, 0.6182884553374398, 0.361610227184421, 0.5729281374832706, 0.800333808200384, 0.30944744177434935, -0.0400516053779626, 0.4725855463325922, 0.511298751692151, 0.7304854686855955, 0.5395673070405511, 0.7633220569840897, 0.13580243044782508, 0.35901672913054133, 0.8870359818129913, 0.805373135555717, 0.547079449726895, 0.4932220509294693, 0.7689490260089085, 0.7031719818025136, 0.4961851272752778, 0.5634143172923123, 0.5521839442890215, 0.10027653393959891, 0.44808020270310756, 0.09636388302020954, 0.7671852229381277, 0.720900801430466},
    {-0.04433279795641914, 0.4424979076775052, 0.597360559634855, 0.569566660213368, 0.17636498108628826, 0.7107437837722437, 0.8703667734514924, 0.10880723944194534, 0.40822470075576517, 0.4409256931148401, -0.0016480454141270093, 0.4796493844267746, 0.5198304519761161, 0.6014467243806465, 0.4784358504456079, 0.5302010750150203, 0.8585527679870847, 0.5958921408889543, 0.21827108038001392, 0.48844767067784484, 0.6029782595887614, 0.6446893638467371, 0.6656698572713488, 0.7769040248214143, 0.4775938500218975, 0.5277627390563651, 0.4971355461039388, -0.20584494020517094, 0.6702060898579173, -0.128553880507635, 0.5358641990682027, 0.4008678428376561},
    {-0.35906835715759394, 0.19250331098247184, 0.5701373549200882, 0.568235962605, 0.33828644149522064, 0.6871184743960589, 0.6144658262704598, 0.2890701323317241, 0.4256311410246905, 0.22587361624794078, 0.08579291355306513, 0.6163275509840531, 0.6746123875863423, 0.37700376256787665, 0.6178009353651192, 0.5525524983465865, 0.6885649011618589, 0.5902087623223715, 0.6045559560856797, 0.5586624930125274, 0.6203918205739424, 0.2757516450105595, 0.477057485414271, 0.5176699289876501, 0.46024103227267804, 0.7278080543553398, 0.7901575292391105, -0.2633169035115192, 0.31127208205985546, 0.0661242643483311, 0.7747360196583292, 0.2731582491201817}
};

static const float b2[32] = {-0.04031597731261902, 0.3165410089298709, 0.5316329790839227, 0.5214032120628953, 0.5023342695011844, 0.5181265200786485, 0.5335944252097663, 0.322350789438217, 0.5010229978421464, 0.3136035113075731, 0.008240409953173591, 0.524666660136141, 0.5271742733875355, 0.5546508400479061, 0.5172503786509237, 0.5257938000641755, 0.5854776028985779, 0.5752556003160207, 0.5603134142455717, 0.5411951258643879, 0.5538012018463969, 0.5012806741380854, 0.5106748639167514, 0.5039007379196451, 0.5228388327017474, 0.5511215500650345, 0.5114232666301552, -0.09158111387916151, 0.3773154955840165, -0.016273036558217727, 0.48846906241574944, 0.4871334634190756};

static const float w3[32][16] = {
    {0.08046701604362047, 0.12949725617667998, 0.030993641183750944, -0.4656073106141585, 0.442447754957024, -0.011295797139284924, -0.4842981398250461, 0.4869564377359693, -0.1972642860024539, 0.020073577102510246, 0.1037253464117582, 0.2529736880132606, 0.4931410566508866, -0.14139796178064823, 0.25218911580997416, -0.3861974939732443},
    {0.5737178068837422, 0.4706764119062416, 0.29637095929191026, 0.3910828297787791, 0.5728546850965975, 0.0916221838600993, 0.6309194014052141, 0.009272886260687906, 0.5676571259061516, 0.6082409182947447, -0.06544801468472532, -0.1150079298297582, 0.3973904191133748, 0.1761750151809441, 0.4792014334356226, 0.3508637785644266},
    {0.6647317252432764, 0.20599090944740822, 0.7171119527228363, 0.4342554156308016, 0.5568422520227817, 0.6394726727016555, -0.21732787607157553, -0.4079595616432826, 0.7432792440155022, 0.028456082817481364, 0.1582605225914088, -0.2463114607174654, 0.8700838685402986, -0.20982165867013408, 0.4574270337004851, 0.45919900360872296},
    {0.38128813193350825, 0.41031599878273245, 0.605676026357654, 0.9474177857530293, 0.757449630126257, 0.4838624740179404, 0.15938953290266608, 0.18776427205686197, 0.9104911716075805, 0.332667032426217, 0.04802036386206951, 0.19150718488408808, 0.711649242026968, -0.07335118010029205, 0.869017184805608, 0.22625559088949515},
    {0.6298582765242763, 0.28222525892281985, 0.6372448462015897, 0.49211487485532185, 1.144501987324051, 0.8379041444815475, -0.20058050646650025, 0.3348525716599519, 0.47533677499968235, 0.5333444422818011, -0.09913871660137955, 0.2910594569006607, 0.5501541145900916, -0.01721966724477439, 0.29997182907658515, 0.6653434006855108},
    {0.4783984779604172, 0.3466899669589129, 0.7825129866457866, 0.4902760967192029, 0.7575027439621865, 0.8431459237721043, -0.2126683286451906, 0.43840420478756614, 0.712441643499485, 0.3785961339501497, -0.11938809767738101, -0.02344006008160072, 0.5258113477115853, -0.24694263359150362, 0.8757555543914933, 0.8990165203312925},
    {0.687766778152317, 0.41000843007047266, 0.5844534018440394, 0.6906196781257118, 0.8875253743605724, 0.4609798881178996, -0.4503930224295652, -0.3487410890174102, 0.8943128742929584, 0.18618624131714762, -0.02579204691492629, 0.21778545105377548, 0.4116001277650336, 0.021943188511743088, 0.3273465301767156, 0.5906050941475784},
    {0.814173106151918, 0.054183878660630506, 0.2113908297794076, 0.3926775596346597, 0.4716150997161359, 0.9010550722048648, -0.11459357213212115, 0.31021527967985996, 0.25624782580132194, 0.11862941306389, 0.033305033476560296, -0.3317248481708537, 0.5502436213300795, -0.04430601369010483, 0.3564440638151864, 0.5165220134487081},
    {1.000952685600047, 0.17718858165172016, 0.9178544450842496, 0.7295341211436962, 0.78461149476536, 0.4688097640494439, -0.2308953361461093, 0.16002988446908417, 0.5624208770156949, 0.47006787880309037, -0.3598797211443601, -0.17794753893124754, 1.077321324520043, 0.13446830689926767, 0.38252734862038795, 0.7332195808486587},
    {0.3986309444631696, 0.763606574421472, 0.10935978719435639, 0.15255383326426109, 0.17730681844506074, 0.6696782649796368, 0.1108145535552452, -0.16747460124709448, 0.5694819458638902, 0.35636237413189137, 0.3257600115755782, -0.27577767876934695, 0.4329193057051667, 0.5856279179933905, 0.31070429147680256, 0.8933892407367064},
    {-0.2092198477740162, 0.46055373931994525, -0.0601807309785259, 0.35457922192014685, -0.10863973618321654, 0.8960014120252784, 0.04938319468853521, -0.20477666645138104, 0.1133827659754234, -0.043936151820598686, -0.2099885570899174, -0.04088678953654891, -0.2787771291005377, -0.05377315439716396, 0.0013585542163487506, -0.6392663215469442},
    {0.19277396673946584, 0.28106238770222913, 0.9689328560711848, 0.44696582253647, 0.6975758526417369, 0.7053146852280578, 0.09712721071292912, -0.02731899392606794, 0.4406500773805821, 0.40350522365377717, -0.0817698520115815, 0.11503860442493581, 0.678447666458286, 0.1648198902541505, 0.24927870743294406, 0.787671117002309},
    {1.09865764133256, 0.45666374774752866, 0.8786661213351025, 0.9131514007196964, 0.9558505024495898, 0.5916680989891172, -0.05998372349269795, -0.028381496204682652, 0.224812127310252, 0.14211413428426015, -0.06645081743748761, -0.23479201572565406, 0.23629357327403178, -0.39823560464890395, 0.4928190296225935, 0.7768403795992626},
    {0.5261868888057215, 0.5986847073648436, 0.3623022611241766, 0.6672719260444219, 0.5971548150059753, 0.2999567009778248, 0.3546545730720598, -0.33549048570936557, 0.681534944962105, 0.5699807497413624, 0.06297008608123651, -0.10543587500425376, 0.4770614446854101, -0.21521842611802117, 0.3197651625372204, 0.7330320675668768},
    {0.6166333469956438, 0.5097117064214556, 0.8572080810219601, 0.7158975143305902, 0.450875932760667, 0.37294882474931895, 0.21548025201518117, 0.03740142336508326, 0.9108042302165159, 0.44141523488700296, -0.5865593374698163, -0.35129866869778875, 0.5043355873973292, -0.13048704435532685, 0.5813868786723618, 0.7135728046031748},
    {0.6673146746199993, 1.0544347392052438, 0.45929079601200556, 0.8253291343423377, 0.25315386335665163, 0.7593358618024851, -0.37437468600556234, -0.18027194591060478, 0.8175051117873147, 0.25540342499699153, 0.05060436766121622, -0.158166339119581, 0.5808804183648294, 0.274799453293505, 0.9249712376584146, 0.9478834090286459},
    {0.5810117345142987, 0.5094525512496935, 0.6773197880435895, 0.6379261348762445, 0.6095295621162116, 0.11804530004527658, -0.23226571245025418, -0.0057651927193266, 0.5736939604348893, 0.17332502169988734, 0.10102229290672178, -0.4830498993143458, 0.7482309371509488, 0.127034203060687, 0.7129309604107346, 0.7182789858584736},
    {0.5915555330743073, 0.3815109266881871, 0.6467746178536687, 0.814857965525379, 0.7526570169070266, 0.5846352933160057, -0.20827636077511402, -0.32100391896887476, 0.5823741447921609, 0.5622527032835647, -0.7036825733486587, -0.3095480510619856, 0.9799649578543796, -0.13892623399552587, 0.48659368331044967, 0.59271576637599},
    {0.5265670966772825, 0.19510166914402902, 0.7612883513255729, 0.677281120716503, 0.5072230161536767, 0.7249968131625857, 0.02435249708663924, -0.3671510825238422, 0.6463500721555773, 0.15659241504849875, 0.06230682906885414, -0.13222144838115787, 0.7492390180650863, 0.3733907110446396, 0.19858047982827448, 0.6577400145167804},
    {0.6734862179842829, 0.2813434015066162, 0.7418553322292711, 0.9936878749284244, 0.6191270278913482, 0.09812804637239604, -0.2176376452324252, -0.38677695376422605, 0.7793401956862097, 0.540994998049586, 0.4955295622093939, -0.13273875191106707, 0.33495487960869746, -0.36053702208851157, 0.6040542774864853, 0.6495821672906956},
    {0.16067920815544073, -0.25489528004647655, 0.8684757323977734, 0.970143054077509, 0.8927392749680529, 0.6143070094919486, -0.05327848466062287, 0.42440120122158476, 0.5258345230621028, 0.07167843906473505, -0.2599540547429242, -0.38422529175558817, 0.5265649918589594, 0.3480972418872587, 0.8521688780314046, 0.6762670834582483},
    {0.8005876391101547, 0.45515948416702523, 1.0852050986983086, 1.2670779059155477, 0.5181608374918207, 0.9737746530465405, 0.2306493473553975, 0.17105718354319138, 0.9442048131305338, 0.9325258478064767, 0.02825367823523193, -0.3749236280389057, 0.9761179088596742, 0.15027964219012344, 0.6255760584492799, 1.0872881476288372},
    {0.5607457139064603, 0.6009100991797862, 0.35876228010234984, 0.53576464216025, 1.0335064779794072, 0.8871356363363418, 0.306106566191381, 0.2331347336163303, 0.8970445960560375, 0.7138665287324751, 0.06438512355268818, 0.3244844585261818, 0.7680933538144046, -0.04445259896415314, 0.6129973614837259, 0.8262244273090488},
    {0.9874828658536026, 0.34515330124412347, 0.29308693610496656, 0.4650451704106737, 0.839412007750897, 0.4982713669613797, -0.13914845103057447, -0.2060047825326732, 0.6525416168314125, 0.43168414438255187, -0.3568769548878354, 0.2315572824681021, 0.43465518197670044, -0.5831536761069056, 0.25161914302785204, 1.0152902987826558},
    {0.4400373425916493, 0.4309625863620385, 0.12412314199417268, 0.5150873367956101, 0.9294489985846112, 0.8736983585416186, -0.2364222683242899, -0.20194037663845585, 0.608210964852105, 0.6474915464108224, 0.12163806791632407, 0.09820096990144321, 0.640168379982733, -0.17339005143958128, 0.40595422373999906, 0.7594155634736544},
    {0.8983728065948187, 0.6347548143647053, 0.8659932929222346, 1.0359131399106138, 0.5120363215652839, 0.6681984052644446, -0.16698307843027912, 0.15722480366039884, 0.8700363919640125, 0.4752313900323545, -0.051450204349941624, -0.08528821015213471, 0.6515451175005869, 0.5280846363573676, 0.849056558199528, 1.0981056218486995},
    {0.7859092021116773, 0.7269424429815954, 1.2910020649137615, 0.18472731421215333, 0.6137794237955008, 0.4030679592656157, 0.11600489948568736, -0.04277560076991071, 0.9200728026140413, 0.6033041938012802, 0.42964319140100826, -0.02392523021942265, 0.519294108669727, 0.2769691977885776, 0.5356578815695183, 0.7691415400838076},
    {0.007025925790597987, -0.04968636235007248, 0.2939307370443584, 0.09970840349406321, -0.4035074259476183, -0.18351163510163568, -0.017310615508749513, 0.314952592529163, -0.12110875620558632, -0.2060397544896333, -0.07183723775457951, 0.012285703700922461, -0.27542391525914933, 0.12751046359337728, -0.4146836996030133, 0.17641497833403508},
    {0.8158339246935306, 0.3621106678501961, 0.48493548564502675, 0.7296261626711296, 0.3704162157198042, 0.5258201031537311, 0.35999842841111634, -0.018603347675043385, 0.5156099461233362, 0.8826537530479055, -0.1479040939720881, 0.06225657296126072, 0.283973052639554, 0.16119929176337175, 0.24219928069939636, 0.6275014352318703},
    {0.04723794151610074, 0.34649110142295003, -0.45902712112021365, -0.04367618323319113, 0.373002949871795, 0.04931530055108991, 0.015450591221075909, 0.096857415750416, 0.014884817006472435, 0.41480597664678953, -0.03588275134243157, 0.2727964477251567, 0.20653325152506122, -0.1823146029549512, 0.28177092435066353, -0.03748431871705192},
    {0.2113142269591596, 0.5807390952795437, 0.6132429923218554, 1.0133296696302192, 0.40899197585494856, 0.5127961312732386, -0.008929668457333602, -0.007595843253358326, 0.7046862001795636, 0.6170159051894933, -0.1739017252020842, -0.20104970175902503, 0.20886470579707936, 0.07770209484378908, 0.4793076878536096, 0.5010821897891481},
    {0.8544777451801917, 0.6873606437556748, 0.36014992573366506, 0.5814345632118959, 0.578142223147887, 0.26144532051076386, 0.2920227164083992, -0.052120561110692964, 0.5073126960976803, 0.656012810155091, 0.28798479083761125, 0.038670335897471673, 0.9000862375208303, -0.0351285688396459, 0.44471660091243803, 0.7734631272757279}
};

static const float b3[16] = {0.36478327938279165, 0.3678563255674798, 0.39196157373466817, 0.40849683457785, 0.36459946545114347, 0.45576594735482484, -0.026200182522013022, -0.024062446302372732, 0.3534200689076719, 0.12646292987036048, -0.03701427236787261, -0.017318564339303563, 0.48630645297779257, -0.03241940415342467, 0.39070247136626995, 0.35983986394341017};

static const float w4[16][12] = {
    {-0.6876378316089684, -0.12156303472182785, -0.6442898957450098, -0.473469292933618, -0.6912074300148459, -0.3888989312549933, -0.19606672219542765, -0.3039537837940456, -0.592764245130433, -0.8433062147511858, -0.2537894515496434, -0.7124731361714124},
    {-0.9800084427187726, -0.7174098727281233, 0.09675701091006388, -0.567853149604506, -0.6077177382962433, -0.8086075095193356, -1.0512602661097115, -0.33974828469235097, -0.21504501073252266, -0.33867443213162335, -0.12040870991135746, -0.614577498704378},
    {-0.6480150501187188, -0.5623998732406521, -0.5575225821834322, -0.6329755930558, -0.6310724697678477, -0.986238932081284, -0.6618646293798546, -0.5331699411892744, -0.3790232087612795, -0.7979530040603945, -0.6548738000593752, -0.8956361376654953},
    {-0.4910367189457517, -0.45886670822129727, -0.8539365911790062, -0.5441234507731787, -0.5561802673120392, -0.9820706699063267, -0.06235654106085123, -0.9359783669752899, -1.1123138631259428, -0.32633412878043894, -0.844582586323657, -0.6631862620790745},
    {-1.0349450829151932, -0.4493330773175383, -0.5920764901988084, -0.35375710382666303, -1.1808068053627112, -0.09853189926087738, -0.8615922097126161, -0.29776462039863943, 0.022985849104104936, -0.2830302786055132, -0.3080406674797498, -0.7688747371135106},
    {-0.4915988850242888, -0.7442481863129363, -0.2127690645078791, -1.0299059279423401, -0.22812048864922124, -0.6145131344262492, -0.8904888442877924, -0.28998665570600346, -0.720363783639402, -0.49853926966971424, -0.7624899151905368, -0.17131851074022666},
    {0.013519438000304987, -0.4541286349635064, -0.3630887779106115, 0.687612117432873, 0.07490201663805647, 0.16976813925597103, 0.3977094837787526, -0.7907387693421062, 0.7183441323483258, -0.18289809130795684, 0.10052126710415747, -0.773763481529814},
    {-0.16733110830599873, -0.15368114401233707, 0.8602565702813751, 0.018737130160275298, -0.10811882312642108, 0.4394609436740708, -0.43776016096573195, -0.40325637952965543, 0.3337429529502609, -0.1433644222329787, 0.12000979273273589, 0.36928898205789384},
    {-0.5812894063963064, -0.7402118816698161, -0.8697589402699271, -1.0044989430273294, -0.3792398904010575, -0.4411997696846995, -1.1167796446159655, -0.7347542745472657, -0.4791851974460282, -0.41942594162768315, -0.865446361503053, -0.1594965438138764},
    {-0.7828579560142019, 0.02661678593380951, -0.5750794669786277, -0.612230809468061, -0.4676083332766956, -0.5770763240910444, 0.3925284106066765, -0.9654275664589629, 0.07901797699205737, 0.3231180408658748, -0.7859182323587147, 0.2412387168734441},
    {0.21652026324214124, -0.7780552801941002, 0.37358990778458345, 0.344546888089906, -0.3051505292865491, 1.2350566720829574, -0.22877110704342585, 0.1358120922353005, 0.023309952981576915, -0.2196022761783009, -0.2711944026118372, 0.21070547835578327},
    {0.29919141753797257, 0.17374390777172943, -0.46554984656981785, -0.16729200305629405, 0.04647555300045003, -0.2694511252781849, 0.6535296710576022, 0.09012813489906026, -0.07389264026506168, 0.34485177519519955, -0.07559375003997124, -0.008815759245502052},
    {-0.31909338025110257, -0.8870168122147651, -0.3509446550342418, 0.30858448171125896, -0.5751106702647314, -0.9616707990933461, -0.8091502903321273, -0.6702394037645618, -0.7289397595943039, -1.0155115364400575, -0.7720999893686853, -0.5921416788697531},
    {-0.22334787196189745, -0.15274217067190354, -0.06558486936284676, 0.2750064889331451, 0.5824999510022193, -0.07645085347983033, 0.6695383772280761, 0.027591913954559753, 0.5164801469445498, -0.005125104206754635, -0.0907126042028167, 0.11046270408819531},
    {-0.14939651395842538, -0.5296967292202112, -0.4610255348376344, -0.6170156299760661, -0.5031187806256319, -0.49438022845416885, -0.16727461545341962, -0.7663410202518637, -0.686639036172904, -1.2368535255626811, -0.6514190203386029, -0.9077393494205505},
    {-0.39226694283858987, -1.184220993073246, -0.9876027447214886, -0.9547775859814617, -0.5087339850384403, -0.19019291780696254, -0.792353958850493, -0.587241126446702, -1.196028505091671, -0.7815910926632966, -0.12449245091901463, -0.8781627483430945}
};

static const float b4[12] = {-0.21144681042950472, -0.2793586209117837, -0.3310189706632863, -0.19937349597428555, -0.1521213075199931, -0.12621847465679786, -0.14990828881545903, -0.18561439136189495, -0.17321960391190858, -0.21523963418072198, -0.13271321738684982, -0.14393391039334974};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
