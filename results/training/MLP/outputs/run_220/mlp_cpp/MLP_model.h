#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.36930025535045247, 0.17278941403886294, 0.5593465904034934, -0.08796203651397354, 0.3359665568165976, 0.028986739914349288, -0.06472019994705949, 0.46944803374919186, 0.6486909593647286, 0.6026586657577548, 0.6293503559262809, 0.531503507090602, -0.21405283527747243, 0.34837196920801444, 0.030060575641644022, 0.5308484045319406, 0.2564837521886889, 0.49559682299945745, 0.20472599549990722, 0.2778752237302793, 0.3177705466045241, -0.29928612314966924, 0.15272912341376318, 0.41959426266498406, -0.09088481637773457, 0.5351060322451036, 0.45160461726622075, 0.5252778478598099, 0.6828264793477937, 0.5773853710984375, 0.4364593298687484, 0.07666132804785598, 0.7394934588194765, 0.01273967222441603, -0.19080696507450973, 0.04853603472507623, -0.10687099105925155, 0.15250305021408772, 0.5605334444423462, 0.07223219370954612, -0.1782168390818705, 0.5970946991210833, 0.10112446152334899, 0.3215208438902831, 0.05933546215890188, 0.5378176226622459, 0.1522806098578733, 0.16685612191035526, 0.6030364383154627, 0.37437460651496085, -0.2511150702542552, 0.04279038172783926, 0.09729039724270089, 0.17982582933631147, -0.0157443881265131, 0.2276166324972087, 0.05365214631640588, 0.03184215113315884, -0.2985698255772743, 0.2525345260889654, 0.6700110243806036, -0.15377910650604296, 0.24038208616661386, 0.07367868822590123},
    {-0.34483587356533096, -0.24772515346467808, 0.41846770634091074, -0.10437218777673359, 0.12819676540956312, -0.278467997092938, -0.31444655266348065, 0.26689809737244163, 0.2878140601631142, 0.4006810177619017, 0.43265848193824924, 0.2826825688360482, -0.24707828658527037, 0.11859687756303698, -0.13730964089837888, 0.2983124417468155, 0.0738014102851298, 0.5679057666199715, 0.09192806698013463, 0.6108115194228152, 0.05979918219748916, -0.6553502234867671, -0.25508366194615056, 0.30937952443371786, -0.3665587042797558, 0.16173696871631263, 0.1124231130189046, 0.5635719265983251, 0.482387033418085, 0.6058425201647039, -0.09649154065151523, -0.15931603081023848, 0.4107219993846857, -0.49252304025302607, -0.48087084805484037, -0.4529433786913169, -0.22553260624308258, -0.38520970730609655, 0.16728707741204948, -0.12538015563870095, -0.2927095104586303, 0.24397002169840457, -0.31084671200670616, -0.033497936424045395, -0.201108498729755, 0.1570773565242991, -0.5538984452359615, -0.43397096325639056, 0.1813335249423641, -0.22810032224673749, -0.7017500624175699, -0.5615847976455669, -0.5244959888113708, -0.5400056516219156, -0.22767534406590875, -0.042382863332650386, -0.7021365543819177, -0.18648345305909353, -0.5235142302003386, -0.051608589830190364, 0.5666983202028537, -0.6354474037770753, -0.15880397541895153, -0.3582248704236535},
    {0.04409693442806834, -0.2535247651977735, 0.5636403016372685, -0.28560275281852276, 0.040765142233893666, -0.6008353965085497, -0.26508233740158105, 0.3987701943450915, 0.5702324576310048, 0.3863316187189683, 0.6036277914545002, 0.48922457858107926, -0.1784548457532207, 0.20590935981882225, -0.5826484814752143, 0.5716273892234133, -0.22342838795829834, 0.7717670661508307, -0.10258867616341326, 0.660820483771222, 0.3058603004464139, -0.3261500791147579, -0.5570679530863228, 0.6772291944016958, -0.48711648555528203, 0.34675562190121406, 0.22847988845045966, 0.7036177358407488, 0.6645468723141128, 0.4532550384824473, 0.5289401389065009, -0.14427140164096405, 0.32957894559633566, -0.6474102712815892, -0.384306112958203, -0.46650508246612515, -0.20728856517082547, -0.2880208698020201, 0.6759956530359695, -0.2172013333644864, -0.3278772297317232, 0.44716408174039307, -0.4580882693641557, 0.03273639786503659, -0.4769300605876348, 0.568114678584864, -0.20209092903304743, -0.21337846215114997, 0.6032359685824285, -0.32343484293930336, -0.524751657882342, -0.40511719858841344, -0.3069595598243978, -0.21100683386397076, -0.3847924816906081, -0.08917869831783472, -0.27296153458474287, -0.1556546127789732, -0.45955538025629783, 0.027379240622206515, 0.6357748889864177, -0.35723726456721094, -0.4692398405714904, -0.529689058409749},
    {-0.46794974511708315, -0.2371688984722312, 0.3300138475668158, -0.611166174774125, -0.4815236280254214, -0.3621335264591577, -0.40399753856801934, 0.588018359130674, 0.6714823666817678, 0.6081555072805042, 0.5058705075072052, 0.2968114393119106, -0.573142622964506, 0.41374933061790875, -0.6677997380622274, 0.45884379097820954, -0.6734476093217966, 0.481642874467774, -0.3019407741282041, 0.6003966108166854, 0.2865335502841782, -0.651053263818328, -0.3934960932363504, 0.40042733244784023, -0.6049458157892031, 0.30095764188394875, -0.01498965601125971, 0.4615309460389452, 0.29467214128545516, 0.5646032943164346, 0.4257868273506696, -0.5854333988757655, 0.5217601722959074, -0.417607624661057, -0.42545148017769113, -0.5127237389856161, -0.34622543448160853, -0.4767299309557845, 0.4130923647268645, -0.28619967720653033, -0.4134161866533623, 0.5227919490013914, -0.4996629473489622, -0.006660145326540061, -0.558935304149971, 0.4286811671691094, -0.3991641879997107, -0.5905168646924188, 0.3036224235835828, -0.40165812676067497, -0.4758307981943841, -0.4079026764534135, -0.6288677870163841, -0.4694802669169155, -0.7326641564538175, -0.4322911348674799, -0.4459591587394068, -0.6600263449387703, -0.5056935586370146, -0.17691231436015437, 0.6148034189402556, -0.5608516437856128, -0.626826498821955, -0.5820970777447044},
    {-0.4410412263085919, -0.49802031346198905, 0.21673515573416322, -0.6873549597518972, -0.4486262032146231, -0.34720957090775006, -0.6098484641599681, 0.3574086153134604, 0.4791994542376374, 0.36076038982939956, 0.41881901235254565, 0.3578628342884275, -0.753365279999829, 0.38772372960359724, -0.6625105292573629, 0.2121646605517083, -0.6110671452219866, 0.5664273148493905, -0.4144922235018572, 0.3365555216315121, 0.08994939448774493, -0.7329430643615698, -0.5424611900696095, 0.2490285147975802, -0.7127618239085659, 0.10322909344420322, 0.07193171485205652, 0.6433998681427144, 0.14497185702056514, 0.5659237229178428, 0.4875804894897173, -0.6888208780131343, 0.3472479492988791, -0.40748168321299333, -0.45839475226508447, -0.471918903674632, -0.3572609001688195, -0.5619016806748371, 0.4455148276381234, -0.5192842738958655, -0.7257476420375384, 0.5055936524874742, -0.4520192436313992, -0.177908733936832, -0.5461097988627734, 0.10941779060972026, -0.43843752540315634, -0.38141428747603817, 0.47384175654177646, -0.3606343850756805, -0.6380285311990537, -0.42639980755849777, -0.6310496441006465, -0.4036105194606118, -0.5750603876706314, -0.48462584620528065, -0.5235750566283907, -0.4739447374408148, -0.49706687736282534, -0.4945464840013061, 0.377239196226413, -0.6924144609639006, -0.5526614538381489, -0.37582722254028733},
    {-0.4501905592970712, -0.6302701877995668, 0.11761963185582905, -0.39700770618573933, -0.3156548420864558, -0.34931770207817303, -0.4593460925918867, 0.4519717400623407, 0.15590512223563377, 0.38754963234768286, 0.1770669591177586, 0.40651410116223785, -0.7327200171704791, 0.22685507539924485, -0.5416283886909559, 0.26472513106866596, -0.4882237362877969, 0.4075960743055902, -0.623782102705208, 0.044650300369636076, 0.13663578229372503, -0.6992832280333421, -0.4435485358479308, 0.25422403862472787, -0.5422382138978085, 0.15985807172523875, -0.05722332469738666, 0.36238471220538776, 0.006024335879542131, 0.4504836509195359, 0.36272027371797727, -0.6820053364013171, 0.057510009201680076, -0.46490234285091103, -0.6765341678307787, -0.7262980689075279, -0.5047532155802399, -0.298743672332494, 0.5572838131576225, -0.35258648666454845, -0.5364297713772822, 0.3380622958662166, -0.47325694550839004, -0.0840514189236247, -0.7072064091922051, 0.045392922582010484, -0.1342376134765787, -0.5184821600831128, 0.4338449146783251, -0.49925382527286793, -0.544261091991484, -0.5605437545594065, -0.7329262644515245, -0.38767314720158075, -0.723445120416646, -0.5607049433186461, -0.4858478462057937, -0.37128316505033454, -0.2777108626555038, -0.28754241603194075, 0.40614174450651314, -0.6421322417174931, -0.5636815345839171, -0.7276023349105583},
    {-0.33907387002130746, -0.4976582467037327, 0.20412983739761262, -0.573673940593683, -0.49672347117339777, -0.3063751945314633, -0.6227362260511998, 0.15475886009384657, 0.3735212016816431, 0.20149094183323277, -0.127782263566227, 0.1581542083511945, -0.5526205988770462, -0.06788211541753879, -0.5828738078414415, 0.19501031776022026, -0.6269740463975877, 0.15040825490994975, -0.5271181343852217, 0.03320800782529102, -0.200247389179045, -0.7173990067463574, -0.40728062531494313, -0.09080621870574586, -0.7182566745446829, 0.05418152262950808, 0.09304339030650573, 0.4189370884771733, 0.05033173177373337, 0.30606589820733515, 0.47919468464713344, -0.7065140844334913, 0.09063567105761068, -0.47085254700820356, -0.48308563568317486, -0.46457452771591146, -0.4998930759447255, -0.410345338158455, 0.36187214079851193, -0.41563261911021304, -0.6829859862466678, 0.3877715227403938, -0.6574734859559882, 0.030155628302782518, -0.6970682372077407, -0.06829154669013578, -0.2610313982070745, -0.6609903350337687, 0.1835734454313729, -0.4997621267448422, -0.7164737363695234, -0.41125512403120945, -0.6332665394196048, -0.5522212560087061, -0.6159688825532222, -0.5937760406421723, -0.6154437666316926, -0.40554225493910945, -0.372506103698747, -0.3046957698914519, 0.266141945982753, -0.658356237501153, -0.5680398429568687, -0.6535785710191857},
    {-0.4970129883173185, -0.5426227703514173, 0.09316337486684874, -0.5180876960096683, -0.4649406755743971, -0.5353514947885152, -0.7278609216779, 0.4648432818663845, 0.35526479763956575, 0.24444200051243734, -0.13280407861911106, 0.13943988194729343, -0.7143739955850655, -0.057505303551947225, -0.42085936158188614, 0.33523756116423603, -0.44940010804968894, 0.16338156386363495, -0.5776780323366978, 0.10340723735399818, 0.07018690997062038, -0.6314037644263263, -0.6144024453073007, 0.077258079167978, -0.5221287107975444, 0.010627351153978356, -0.06550392196305661, 0.19482397639326843, -0.08814303019884949, 0.11498208996213169, 0.3697740405464907, -0.3837538995118744, 0.10257733431474429, -0.4712723658735406, -0.5057386250735416, -0.5950407158140275, -0.5915957671332804, -0.6336595600778969, 0.5260369034848247, -0.5301590188396077, -0.7684609966557542, 0.36994510300956385, -0.7454131986752318, -0.26774200487988004, -0.6417887536900652, 0.12229269385386783, -0.14473437519736823, -0.38612977020314715, 0.18725538049022716, -0.4666026832927296, -0.3847220431270193, -0.3137084824098798, -0.5248533812163518, -0.6042179790013683, -0.6626386205168098, -0.36598051030182477, -0.34026735868296165, -0.5765479195631421, -0.26031233334968845, -0.5384761984451739, 0.46495211015278143, -0.42087434717400235, -0.6577673960962342, -0.49085532589535713},
    {-0.547626957015205, -0.42242894632412614, 0.285197209370269, -0.6313319378641153, -0.5755463609926168, -0.4006607517241633, -0.599285312168868, 0.1272910875562108, 0.3017559970752132, 0.13274268428438205, 0.10274606785790451, 0.3621546594456343, -0.7210163401064906, 0.05179062199398272, -0.4644524626424215, 0.013918840636667805, -0.4804172529378271, 0.26760354790923474, -0.46263542070870994, -0.007633573605432344, 0.24660752614525328, -0.42727245072544245, -0.4448560262507553, 0.20049861710712988, -0.428252449568941, -0.14523774741228712, -0.013743821212743727, 0.5245084884563391, -0.1876636511255703, 0.1552860526071862, 0.1715609171285617, -0.6635409460872718, 0.10217276437156272, -0.41635118583194125, -0.6900443637245998, -0.6566740176927508, -0.5225122787754694, -0.6579813199218771, 0.503157500786867, -0.682491842971211, -0.6300757260351063, 0.3349987694367534, -0.6928617699081188, -0.19358783417476552, -0.4119073189799622, -0.025339191449500635, -0.29789815821069693, -0.49436251062583936, 0.009525468837920952, -0.6769042096725859, -0.6796588777057534, -0.4919791765167456, -0.6580318443616341, -0.4996797358803842, -0.4677105861357737, -0.41105047689369484, -0.43068426881077987, -0.6748529658198847, -0.29001582201253756, -0.48601087231724166, 0.4964430452240569, -0.4568908248394413, -0.6512196426432144, -0.35503709428750113},
    {-0.6122762593581219, -0.5943691250128811, 0.2963113950917879, -0.47070967264738084, -0.2432068906704117, -0.7294973312104666, -0.6586535484558983, 0.2847910374728041, 0.1895229954017145, -0.033619957939175035, -0.1520293401862413, 0.4022596864129132, -0.4975159717687661, -0.1105658719190955, -0.3910503253019679, 0.05405249437674658, -0.35751717455180176, 0.5923194684083075, -0.3850751777616654, 0.3954133653860198, 0.10820381308647177, -0.6043250320762694, -0.39456584868675476, -0.03545588457669098, -0.5188623933858832, 0.13821892590330961, 0.2022760693725486, 0.4444323935596197, 0.1250133267448609, 0.22930729930083013, 0.21653081824752132, -0.4803527362329353, -0.08657954236557452, -0.5695215614459502, -0.6289632418433618, -0.4086399439703071, -0.45873564677583994, -0.6246584498749234, 0.27846312185108674, -0.6855762413322263, -0.5385063581729845, 0.18597142728096977, -0.5034387575278112, -0.1635395135142216, -0.35701640135899415, 0.1752973837441084, -0.2842101480392383, -0.4954950545721297, -0.0014259102600414188, -0.4400475920282201, -0.6915800851477749, -0.48489277935676106, -0.49199498896934424, -0.4306248467888738, -0.6613066304603177, -0.4339115767962777, -0.48070769839233757, -0.670748031163997, -0.55498788381415, -0.42839624957984906, 0.29963906506179616, -0.48760922337573803, -0.6065281564405355, -0.4826960713137646},
    {-0.39479399508519375, -0.39256547211273796, 0.04725358863126446, -0.3419774273262874, -0.46866157826192556, -0.6574512881065632, -0.6413053566964748, -0.10346231864851135, 0.13989494805796385, -0.11617202462162565, -0.06291805311827108, 0.11972093755489603, -0.6047927332782218, -0.3959461165242851, -0.6816199770866956, -0.09923307966774499, -0.5010585778533788, 0.5894540658853488, -0.1717014265578513, 0.2525573643965248, 0.17043004864188593, -0.6102530260748246, -0.5609495176364053, -0.17829761185455953, -0.5435472911229208, -0.15600364973849062, -0.19916534820774534, 0.3240667207436348, -0.11786195775351573, 0.051328214062024, -0.08025697388776978, -0.36759431866276265, -0.037488200017125606, -0.4232997694065332, -0.3976549539418263, -0.35319741024656354, -0.35452089857799324, -0.5128877521809437, 0.31881397120499716, -0.68734424696206, -0.7251342634360661, 0.07876312723877321, -0.5944955073424122, -0.2759143335496097, -0.35789410571394037, 0.020870372158624195, -0.6710848909054747, -0.49060125236571783, 0.1033281910402337, -0.5040947987038937, -0.677220640140505, -0.4767319301050106, -0.5780516711020861, -0.4851827324519382, -0.7129464586447769, -0.5592664440731935, -0.3913277407418389, -0.456379560959601, -0.38650893201926995, -0.3666946249552597, 0.3978202286186218, -0.5050835702992523, -0.60514330151831, -0.6226877780871137},
    {-0.5802238812342699, -0.27259012594873233, 0.037673451199952565, -0.3888444249397571, -0.5105239930009263, -0.6856467414062767, -0.43704147127793846, -0.15500328218628434, -0.139898457011197, -0.10776358565040488, -0.2937526775718714, -0.03172278014673271, -0.5104704200108078, -0.400553763804588, -0.45562215962975977, -0.03465498508469433, -0.6138119918674364, 0.40885458092028754, -0.18697060846483976, 0.05451204357999539, 0.07921120986855248, -0.7842016768085367, -0.6844588707997812, -0.15065600295668877, -0.5799554637307157, -0.3246451934236191, -0.02633183083097956, 0.07242310133552478, -0.3473822071296875, 0.21141345120205737, 0.08426237362278155, -0.42293885886196403, -0.16261551175554206, -0.36970029192889237, -0.6532152012386947, -0.41062900460926005, -0.36221914614910106, -0.5976869672548173, 0.13471579818803556, -0.6897022226416345, -0.6185754234087143, -0.15569222810862635, -0.6947294977822605, -0.42830680474830135, -0.5988831256728981, -0.17950802886030182, -0.5656161845521387, -0.38552737631005474, 0.035691213400580964, -0.6157177957751105, -0.6599869395441966, -0.5762398186029893, -0.7164678393046279, -0.3731017067595878, -0.5157637236508942, -0.5332821733862335, -0.36691270425888123, -0.717387461114701, -0.3730932926416776, -0.5730762701555081, 0.259685345151992, -0.568411540785294, -0.3874291586480568, -0.5652600343521105},
    {-0.5880606089014999, -0.2620392132976906, 0.16752022977601572, -0.6514634076592971, -0.365457124589355, -0.5487682858625178, -0.589567540543399, 0.18488135874816203, 0.03556733438553432, -0.28963430200347573, -0.14217381631039389, 0.22147712878993261, -0.401940317824849, -0.35094552999881395, -0.5675984136541746, -0.2568119024594477, -0.33933128186303435, 0.34262491808411605, -0.1723498261867351, 0.3567026217780239, -0.0665994486056188, -0.45289327397464124, -0.7241679623358579, -0.1442239879722378, -0.4707659794897164, -0.12744610640163645, 0.003803060269961369, 0.03267556152561901, -0.38096329815092855, 0.28890310329670776, 0.04509022892031474, -0.3519322614731613, -0.2940143826050087, -0.49880688845193316, -0.6330371207368098, -0.6045580425199931, -0.25326349624062344, -0.40390001829815014, -0.08458564126884166, -0.4242267252694662, -0.7311147864657538, 0.1395851571427124, -0.6810713707986279, -0.3997624154755394, -0.3506652686297866, -0.2611611488434124, -0.6073913453531619, -0.37092009209303406, -0.09799142482472882, -0.595163676826127, -0.6819940102059503, -0.5455015853503374, -0.7015156159001793, -0.6505311856827903, -0.6963777090213937, -0.5337622009898625, -0.3714648965137788, -0.7127021282070473, -0.4172236566721159, -0.4310029893856187, 0.01914593566623952, -0.48395929583597824, -0.4339221945680881, -0.49487230072512745},
    {-0.45792825459297204, -0.5046581993096613, -0.047049708412026145, -0.6772896874062502, -0.2699877614002148, -0.6529159557140628, -0.518063739214697, 0.1444561781905262, 0.20591138668956696, -0.14994657626881489, -0.2181767106201966, 0.2089579297316333, -0.3834912541806361, -0.07660952779704347, -0.6013685874401605, -0.3099254187630917, -0.5660489585463585, 0.19286659013422316, -0.2725314869871447, 0.3231003860603327, 0.08387226852486981, -0.5088063192961491, -0.7031364657578498, -0.11872378260244207, -0.3277281239647365, -0.238675624869095, -0.14756331658439714, 0.2465548056471897, -0.10468912533366892, 0.2372644060516933, 0.03457843636769779, -0.5196251368607739, -0.3246458510399124, -0.7097465495200111, -0.7336325273084646, -0.3586443933689309, -0.3772260282319171, -0.3854332405187162, 0.15019955483289357, -0.4923137239919475, -0.3883707163554111, -0.09704903119403328, -0.645952768952847, -0.3994083329671616, -0.6778588604914972, -0.227203213472949, -0.3677226563443048, -0.524882684891762, 0.0771391820673124, -0.559248526762466, -0.6511510524518525, -0.3488088493355156, -0.38043349328556875, -0.6462778447433716, -0.6389165766696373, -0.2724588406285969, -0.403641360594969, -0.6247176318565457, -0.4973207851013997, -0.230283866412573, 0.18657544958108419, -0.42075492583372875, -0.6440772369347176, -0.4495688106052832},
    {-0.5395422280283612, -0.45028822061518037, 0.2395499942566931, -0.4101517418099298, -0.49051476472318395, -0.7350038615099338, -0.40134508353611237, 0.1724813206535444, 0.15826332547089136, -0.09379295502709904, -0.10221328580198945, 0.3658282592602643, -0.6668413144796966, 0.0015908201156536231, -0.4510886981201398, -0.07552189795061336, -0.6127341027775997, 0.3663013384678304, -0.449132802691531, 0.41665307244102384, 0.31793279716513384, -0.4809492708471121, -0.4358403426400754, -0.08174635697150369, -0.39619026244364214, 0.015790452214639566, -0.14463658388220868, 0.38068763467737016, -0.1543600024327724, 0.3287340705323323, 0.08875308288757533, -0.6272726607497893, 0.08574417935537883, -0.5682251369189153, -0.5381206535027214, -0.3896547504995507, -0.31611624074504485, -0.6413515658440605, 0.35053694758368514, -0.4889746637351479, -0.4276318332387844, 0.02622672341195382, -0.5213038519098332, -0.41313676357677415, -0.4947780234919154, 0.03307061877805627, -0.3200239912750361, -0.5982149379158136, -0.004026005490323818, -0.3937098774683441, -0.5842341792706525, -0.3196312273287425, -0.42478255743213256, -0.6165713305349771, -0.6818147132221919, -0.23855529311364407, -0.694491432585398, -0.6748805432404484, -0.5939673423834626, -0.3870846225420014, 0.2668118336741621, -0.6122002288502346, -0.38417530239952014, -0.4730379435563791},
    {-0.49610390282403616, -0.4722398536708887, 0.44937797019699277, -0.6899227065377607, -0.5637437955429743, -0.6549752361323542, -0.45467336350404236, 0.3078518499544384, 0.2627827824000559, 0.2764874666266437, 0.24290233131454878, 0.40203944083619325, -0.5710093984940418, -0.23113277525914583, -0.5778837182459109, 0.3502322390575605, -0.5519798964471294, 0.5311476151963257, -0.2641309032007309, 0.19559319914064482, 0.3359456741731974, -0.6085743864731976, -0.6446112144507268, -0.06199770850102642, -0.4451467510323926, -0.11034658516502914, 0.06034967652181756, 0.5600663086865215, -0.2105812157336545, 0.3682196707597703, 0.19837611366398142, -0.5253290519471228, 0.1879660806756383, -0.5366112390879094, -0.6765191116251479, -0.6783779623803358, -0.3968974303303236, -0.429465046363535, 0.4582897121089417, -0.6630489919656061, -0.732186617543173, 0.3742201756960722, -0.6179723558639966, -0.2982485543089826, -0.4138570071947968, -0.03983929130292919, -0.3604438351361934, -0.6383938103991414, 0.061449967326949156, -0.48056002607935233, -0.45365031739872613, -0.594304654035475, -0.4399712209182342, -0.41382962062206585, -0.717351585262113, -0.3104098881087333, -0.5840903172972942, -0.463040588695741, -0.44149011018565587, -0.3788299709634256, 0.42233127622940936, -0.5122802458021218, -0.588647503475568, -0.6341069424537557},
    {-0.5356469212330879, -0.30563232179023575, 0.4748985452500198, -0.3723352759318375, -0.40044100692359674, -0.3806496947890801, -0.4304087936968591, 0.620350851358139, 0.5432138178940502, 0.3876106850360678, 0.19140030017263432, 0.27902288044332335, -0.48310419525269105, -0.008063481571384232, -0.7030467458057212, 0.30956441634804044, -0.4188732887254507, 0.6954101655420217, -0.3444254108333673, 0.6828934971497747, 0.4317803659908223, -0.5627446832419667, -0.45964153125753016, 0.40301311392311645, -0.4720118774320506, 0.29985128372161957, -0.01970293962348636, 0.5184257853190302, 0.20726045517846087, 0.5113471469084937, 0.46307129836811795, -0.5724695835957203, 0.42624530987895554, -0.4643732508727894, -0.4747647588563547, -0.6394601000916728, -0.2638782185504673, -0.3502375111304078, 0.2870024017167434, -0.4047293682371875, -0.39113824736702374, 0.26725749062014487, -0.5117083673836249, -0.3630180385162255, -0.5507130777320527, 0.17221514047513858, -0.47135362973885864, -0.5565739533949321, 0.5232180145136938, -0.6213188952753165, -0.46491162051643886, -0.3690206950219716, -0.40959303491857346, -0.5675754860865645, -0.406601150833113, -0.48701690756263927, -0.353456759445459, -0.6397771101240441, -0.5283764074785999, -0.21867789878581084, 0.5325396552631501, -0.5653759947829797, -0.41172003305525423, -0.5852140861644531},
    {-0.08326017105791214, -0.2716490005813452, 0.41784696612615735, -0.5921255429427592, -0.31558253846297935, -0.352076891861826, -0.4680211632557878, 0.4356144760706247, 0.5331176141027532, 0.6281408077900104, 0.46816237175797704, 0.6437399995906661, -0.2758789659351094, 0.3396473188419311, -0.2944265288779477, 0.5764832952594935, -0.489566587997181, 0.6153571545505154, -0.290181222957419, 0.40741205506127764, 0.6408689728043749, -0.3789016034329613, -0.5085141535355147, 0.6398863285468634, -0.25480914412605427, 0.47729373143128634, 0.24107154067411873, 0.5137405130310655, 0.43755192280788824, 0.6687214953174704, 0.3520918504623291, -0.2549686893094506, 0.5027611280525673, -0.6171906680677236, -0.4493548900719593, -0.5634316720472732, -0.489584610061041, -0.624289412652572, 0.6563427901924402, -0.35819889939902333, -0.3998622020303678, 0.5919715697042949, -0.5626143741234947, -0.135134128257914, -0.2824031546599779, 0.31972372260009235, -0.10968481921830339, -0.47208292941479, 0.37175653982992285, -0.3186601866133989, -0.6238643833070814, -0.4952248349178216, -0.5671418795245529, -0.3779671306116028, -0.3576606304492866, -0.0024143644082260914, -0.40624028871271234, -0.389480837064804, -0.6053749225113263, -0.2094835002790057, 0.38788367338972596, -0.511062218052748, -0.4467334303263375, -0.39570905495271563},
    {-0.33874399385656234, -0.4425227708025745, 0.3776774266894128, -0.5769311744826474, -0.14212780924568916, -0.6396374275162077, -0.2688682492328371, 0.3855032448063838, 0.4059971046466564, 0.5798158520619939, 0.6366794771212269, 0.5893411089153519, -0.39953366152716685, 0.28739599472776767, -0.4941557187902523, 0.4233023245776361, -0.3718591447509764, 0.6826629443656188, -0.27204714551807824, 0.7139857586920758, 0.6299925578761099, -0.3223111288820516, -0.6586723306699551, 0.5089283079961858, -0.41998386405868227, 0.4633815555681579, 0.10524413317981503, 0.38443800806979633, 0.1992200189418606, 0.5954840949755822, 0.5940502384907511, -0.460779920389876, 0.5110639166807717, -0.4713200208922959, -0.3811605537149108, -0.3772568384610219, -0.27502154869884343, -0.44019992107336375, 0.358812552737252, -0.377820929934845, -0.5356017330196522, 0.5671358231552501, -0.3350799510572008, -0.25927094477171003, -0.49413983861603117, 0.4112855548018032, -0.08527478370902848, -0.4141228318124641, 0.6327596374882768, -0.44826225679811554, -0.46776267642800734, -0.23452136291010253, -0.29968157907614523, -0.4679274975852425, -0.45965086162583396, -0.0026850548745116117, -0.45639137521322676, -0.5511028796729361, -0.28071096976667975, -0.34858171173239977, 0.41940312386343037, -0.5825740960095278, -0.5609660215963758, -0.29222991416520255},
    {-0.3442575736696488, -0.2704359430579156, 0.5553639405181114, -0.3071722561785172, -0.4707760388936231, -0.3595873927702146, -0.5860686934298197, 0.35102280293475197, 0.349233829290838, 0.48452240381064465, 0.3684120600366411, 0.37094777379897703, -0.5576794314215685, -0.12678232087789637, -0.644686354854715, 0.24003120055096483, -0.35969594000485755, 0.5860356037034566, -0.194445257817048, 0.4412468866245402, 0.22879960673573865, -0.6179135110794786, -0.633606368985638, 0.26941545325699323, -0.3831175813673336, 0.48306673175429743, -0.01729115248136004, 0.669991980168553, -0.0365246895126305, 0.6046632423609946, 0.40419429853104666, -0.4524427468059834, 0.13780717553319696, -0.4603917012353551, -0.48909751354516673, -0.3006021414981835, -0.4915585006833364, -0.4767273587480373, 0.39970435634976936, -0.44400768473620805, -0.54663221326124, 0.44282159843394875, -0.6452478684237829, -0.43949112325258344, -0.4127698160935031, 0.32460348845551507, -0.5406594352885133, -0.5169124355694017, 0.2705713131441622, -0.5336080347959674, -0.5713141781835179, -0.5826455885110295, -0.4834583080945107, -0.48723243398036253, -0.4085467977288098, -0.23538432366738576, -0.5139582419161469, -0.4562729113806067, -0.30814525930113024, -0.29696932046067687, 0.6418513816309882, -0.6309324277021022, -0.5488309952737624, -0.5008130782087982},
    {-0.5347240080567615, -0.24968845019491864, 0.47251400250215936, -0.6288942170678584, -0.4465779613825893, -0.49650843223976243, -0.2993115589328749, 0.4913597392702872, 0.4965631276634564, 0.41715572205332396, 0.39010730133978516, 0.6475713121789257, -0.6288562895356266, -0.2579595247263819, -0.3501118213868335, 0.37685978933727543, -0.3397068119530923, 0.5543972469842158, -0.3606264595359171, 0.6888497588824999, 0.277984391885238, -0.7491849738522662, -0.38180648898215436, 0.02198203652241932, -0.5846469434367707, 0.2961320281711342, -0.1756013160534303, 0.6636790338163284, 0.005910844271405249, 0.36002782763903723, 0.4436178731823913, -0.27623552641847354, 0.06913600186875005, -0.575646392875528, -0.6199402050585772, -0.5701902882746128, -0.2128571805410597, -0.5887056397872533, 0.2783594137044534, -0.6555634527757594, -0.4416800997087472, 0.09119112766989597, -0.6928733014157579, -0.3979256230950312, -0.5996082684917278, -0.05066158592753019, -0.49821992485459526, -0.4437701034669222, 0.3870149579521157, -0.33536842710916254, -0.6362959757432998, -0.3614549709470556, -0.4649653526862055, -0.5054427863486335, -0.4985350091292238, -0.4336008362579794, -0.6095225514769916, -0.5698026870545917, -0.42749446377031136, -0.34183872565914, 0.5303542353103547, -0.5679848654927216, -0.4421245836415155, -0.547720948175154},
    {-0.24571481727201355, -0.17410674333830545, 0.7199893838405698, -0.39445904573051765, -0.039992134442415034, -0.6239590556115984, -0.5312770457535191, 0.42276728224380283, 0.4602665020073932, 0.5279679905191379, 0.5965886415111333, 0.6755569050624746, -0.223464819503011, 0.1511774938045844, -0.29722463994157483, 0.5735836181782438, -0.3898628941956013, 0.7462356134107498, 0.13398362226984428, 0.5265109545110992, 0.3609454463852086, -0.5828110029009507, -0.47579472893376296, 0.5739748202517911, -0.3967843213537096, 0.5526366365090403, 0.0006765554429429275, 0.4900682941273954, 0.3349026893485309, 0.7838596116856037, 0.41044244235448313, -0.049385031242581166, 0.3548159871545756, -0.5198194857059247, -0.3832781690889314, -0.3464490515553435, -0.3387720469715048, -0.2938509621823011, 0.5202358939308848, -0.5332630166809988, -0.5036537960039649, 0.5038223954896224, -0.3457748446037969, -0.2252020575534891, -0.3864206426993434, 0.4667687026852107, -0.46825232923308147, -0.33011430489702787, 0.6069694015928869, -0.4873006677633885, -0.4121123962092483, -0.23171383228821468, -0.5690017645877596, -0.2923866726718557, -0.4418006883550804, -0.18268014390895315, -0.6126776638956108, -0.6048995659869401, -0.6146397318164487, 0.016287695050486297, 0.7953731526484826, -0.3044693448937768, -0.2841212202484721, -0.4965190453467686},
    {-0.29303922879926464, -0.15848464253330066, 0.7432067614626882, -0.43220911765817566, 0.06479304115531494, -0.5653642917838833, -0.44304640003336937, 0.5178232229383112, 0.6775003815453962, 0.5553275039774764, 0.5762617518991957, 0.7459135733080547, -0.15716733941218738, 0.3979230807396036, -0.21298333339896133, 0.6809360635862156, -0.16357069259099477, 0.7754968619087456, 0.24397316733355265, 0.5111618065112022, 0.5841666651231758, -0.3147398447020031, -0.5038150004372475, 0.37938179984543907, -0.29880915650893725, 0.5118516172957472, 0.06812769958472174, 0.6009136501648333, 0.5273662305573279, 0.5136449353177946, 0.330679876700364, 0.059003449861953536, 0.6591404938317968, -0.3069223684107717, -0.48130067828276124, -0.2036980616923259, -0.12750525645697008, -0.40068819866652944, 0.6132565165920613, -0.2057690423803051, -0.5020268221776355, 0.4342871686156356, -0.478143160045375, -0.061200018945480196, -0.18337739819106524, 0.6532583615634856, -0.2552585897561846, -0.2858962997239302, 0.7437692303530054, -0.3566836960585084, -0.47138210598075686, -0.4750879084697425, -0.21782748837558727, -0.26274685502685546, -0.3417257326388958, 0.222056707969606, -0.2365552778227554, -0.27701837481191904, -0.4787412469305048, 0.3189034786221936, 0.7098069696731848, -0.5175243448614445, -0.24441816185404372, -0.3592741210317836},
    {-0.4178853202276141, 0.024193694950000146, 0.4281078175022997, -0.3894447628424399, -0.04119402402621237, -0.6366970871552345, -0.5335155640150577, 0.4163148706238339, 0.47338687495151366, 0.35541858786684294, 0.5233941858338594, 0.6718762775339657, -0.21018270573615355, 0.31811464684901164, -0.44419689632684445, 0.6037023174502357, -0.5135627050657928, 0.6557287391299629, -0.1224716611867718, 0.6350050176598374, 0.4280779431663151, -0.6340933668817369, -0.46546260574774573, 0.2875630580979745, -0.3994458874930538, 0.5198109764367878, 0.03482339979125116, 0.6833146613278023, 0.2775385678988173, 0.6869927373075474, 0.3406264181451513, -0.17177971777954257, 0.33919292501034853, -0.6187673146167831, -0.5230391794533396, -0.2970850009862696, -0.47410691080865736, -0.5582300479672229, 0.33057561375396166, -0.46054184428211137, -0.454713922442504, 0.2898056415656205, -0.5887932474631629, -0.3839755866310463, -0.19278520005579675, 0.4595203902868948, -0.33154069808350434, -0.36628499160160416, 0.29399538057272495, -0.5629728169574738, -0.6494621068981403, -0.470059044547203, -0.4557956381732802, -0.4477029998048988, -0.40810454740859836, 0.027194722170908667, -0.6276367180767781, -0.2988843636245094, -0.29792787409080923, -0.035450111095045825, 0.4517204349930027, -0.5828808540643493, -0.3330246381518577, -0.5265693791257843},
    {-0.26323277592018046, -0.13793351479556556, 0.4760746544648415, -0.6281844538640627, -0.29693365186923315, -0.6998147437999785, -0.36418594013925676, 0.30986232487666204, 0.32716378633100673, 0.42189905741858263, 0.05002082654764965, 0.559157891151451, -0.32484859029753554, -0.0439584234369825, -0.3566846670310611, 0.0171079492814116, -0.29564434079441665, 0.757415127172768, -0.3309325373799215, 0.5233719257374413, 0.26848894226533837, -0.7163605151002547, -0.5699427894766813, 0.0815143191095079, -0.29875109348841716, 0.49224964618520756, -0.16460738812158263, 0.6175585571632313, 0.07578978976310831, 0.606396905170437, 0.20531873585292845, -0.3694701718176282, -0.0842622462868787, -0.5959174889042615, -0.5099749622251619, -0.3430277955432045, -0.4773281843454459, -0.44209950694891026, 0.313734280145147, -0.5872651086618071, -0.5965230523156334, 0.2834910707391999, -0.3859240801037605, -0.4850792217355228, -0.42659395486612567, -0.04835511982815613, -0.6536371817235519, -0.5571367155394197, 0.20670771818381672, -0.6123087201680407, -0.38483862751813436, -0.663913464102281, -0.6803128737822184, -0.29769002224184093, -0.3079767597136709, -0.030031374779786082, -0.6998025491167635, -0.32339185316699137, -0.5131565505404926, -0.2784461802639361, 0.37094763049176094, -0.3940359616055799, -0.5912372063308405, -0.33583126713766404},
    {-0.2807706284553184, -0.0777182552914531, 0.29087174080422207, -0.37184939871334377, -0.24628301666260807, -0.4354023946833469, -0.4754497676669049, 0.5813736825831369, 0.5835221032173886, 0.2650755300883224, 0.23082883795515113, 0.5758884589875735, -0.5748811702781242, 0.13722712504131068, -0.3933819152869894, 0.1320413979936768, -0.49375788169929463, 0.46496880321073053, -0.06792920691533008, 0.38234146618045584, 0.2331885238110751, -0.7330749416944411, -0.6215330057181063, 0.10730678204203146, -0.38159815926466834, 0.4231991051066806, 0.017304055094937515, 0.6531591153695528, 0.08901853350964284, 0.41520932069204053, 0.42591647550077144, -0.38150854051667965, 0.2341903785318046, -0.5889650832352153, -0.5821816078633019, -0.45323694882913174, -0.41610211809404574, -0.5707569229679755, 0.3661802396530957, -0.4247086319960045, -0.6055193217039065, 0.3840062286908001, -0.4212811737179208, -0.4873349988826334, -0.4372892646545412, 0.18197120636202824, -0.5702198024525176, -0.29409639875344634, 0.4833906468413967, -0.42007294447098503, -0.48622515615912376, -0.28167148290212646, -0.526058013331089, -0.33895905636755724, -0.46169942897711885, 0.0034002764140422716, -0.37329651726534974, -0.6034760006412656, -0.30289089860067564, -0.03837008089589027, 0.4789102602140946, -0.6477672404956456, -0.25313442659284807, -0.30998199538651133},
    {-0.362592450067456, -0.14776528246403065, 0.6791416798638595, -0.38189280475526605, -0.38642763160833815, -0.7014764568102213, -0.5205110591949336, 0.588375358012275, 0.469429882268715, 0.4311335194401602, 0.5848832603252495, 0.37943701523726653, -0.4768819622642004, 0.03616868676254218, -0.3367259085543337, 0.3085190928802983, -0.41286665589071886, 0.5303112015314421, -0.23162077475863807, 0.6847641937832567, 0.6058535965140922, -0.7203771867006813, -0.4536594885610056, 0.4257372215777518, -0.505309145171167, 0.42263399520651096, 0.0751380841587977, 0.5400760120947871, 0.1321717208080356, 0.636105581727681, 0.5192182288228596, -0.3243666682475942, 0.5227079524573374, -0.6612643441857512, -0.6654951590628617, -0.44638712592539664, -0.22107883611185697, -0.4014916303690104, 0.3223457561667417, -0.2912585817238797, -0.5381985701726124, 0.4762304484929448, -0.30597327197551455, -0.33789343633146346, -0.46406313866501897, 0.3211512327328759, -0.34799797380707825, -0.359796996195487, 0.6266607855086404, -0.5375882719904286, -0.44571479838170897, -0.6132844670400873, -0.3354256616589864, -0.5131287453437804, -0.37603713918850307, 0.007045244614972116, -0.6713117907084143, -0.5317395595956435, -0.3990992167374657, 0.04262268281407704, 0.47489912970034737, -0.3855316773758661, -0.4243400297462665, -0.4385231620084428},
    {-0.3418064463399425, -0.1774048860208289, 0.3713005705258195, -0.33687659872113873, -0.37691961204040675, -0.49257419374747907, -0.5276955032023, 0.29453721718717407, 0.6570037802461027, 0.3046755065805907, 0.49687058792665956, 0.5780531491429552, -0.46511526767927436, 0.22376127604273166, -0.46318560068043196, 0.47986739247862953, -0.5272686792880944, 0.5856557016876821, -0.16384954407830268, 0.7533237248532778, 0.2528621735949124, -0.6287146099528842, -0.5700517124183866, 0.5257514439437618, -0.31251689008448424, 0.5781124563634386, 0.07302284728381662, 0.3714621821168801, 0.4582866317243529, 0.4667964278278465, 0.34503799476211866, -0.40912982939306314, 0.41098208728524027, -0.7128679091964085, -0.4473202576449508, -0.39181063649745607, -0.462461405756064, -0.408177548599349, 0.40852205800382624, -0.5724433646946471, -0.4807674378168107, 0.5165117605308728, -0.46348659795761993, -0.454063400733067, -0.44893332565270777, 0.23102779136540724, -0.42177918144536203, -0.2627696199567768, 0.5061891383449342, -0.29011489880356617, -0.5140306462799374, -0.33559720616707445, -0.5830476342046126, -0.5642625895989596, -0.6211570435639431, -0.28182872270716003, -0.4950174377658633, -0.4637572841516621, -0.5595322351858549, -0.04207671168873115, 0.6774562716559405, -0.34063565720421085, -0.3022389203860198, -0.511804404562506},
    {-0.3950401826718651, -0.28180213350358657, 0.5067905992168251, -0.4169021895879702, -0.4201111890939749, -0.6197574942211612, -0.3101666340458057, 0.4045451993263242, 0.5178224868358643, 0.48040268235184425, 0.5053214272035434, 0.4011970880147595, -0.32857080189626425, -0.05290371906294816, -0.3091491649044632, 0.4778280173433476, -0.23835094810850607, 0.5852120251810494, -0.12264274073812213, 0.6964655265260287, 0.41166935647113945, -0.7353074171038669, -0.4003228855108056, 0.38961500945907535, -0.3904954672107875, 0.548662206221546, -0.028440556465142684, 0.49451714218472587, 0.05008033904044389, 0.6633975964578356, 0.1579126109418647, -0.41289460439692577, 0.2229284970586293, -0.6926072319297959, -0.6985011468761068, -0.5169706214195193, -0.15728949595179328, -0.4017094915332425, 0.5534414438308738, -0.41727325551973143, -0.6767508958712493, 0.4570468665436259, -0.6107399715683619, -0.459669330739927, -0.30725412096259996, 0.19647961061757305, -0.35668819625784837, -0.4992737065760861, 0.20142822250928763, -0.5759149632980357, -0.5164520303184601, -0.6749916579289752, -0.49675558480156184, -0.41956102854254895, -0.544746526046996, -0.01649627957136932, -0.41235383301298917, -0.5481883518198613, -0.30239794507652323, 0.005948032465995527, 0.4383281479059677, -0.5365388898946422, -0.5631057507407105, -0.32576477799592213},
    {-0.5338468785605769, -0.19654112798962275, 0.37949675388054055, -0.43457654474531987, -0.18310155353008728, -0.6748621636673036, -0.30889913041822625, 0.3326311309278462, 0.284541029047551, 0.4065186923876448, 0.1813350567531842, 0.5534409904165288, -0.4255028950233384, -0.14784864423942704, -0.5540345102029789, 0.39980441765743097, -0.23032059710468217, 0.6150711261737494, -0.18075784534831763, 0.7100737916364858, 0.4638192103505959, -0.772623613560538, -0.4984036216388939, 0.07584023404589556, -0.48214925544481685, 0.30699699340323594, -0.22113288417191518, 0.5997077042573301, 0.28759565844380997, 0.465763259586883, 0.33597906986043236, -0.20445089776577047, 0.026850032908324137, -0.4283092182386294, -0.5384383391336566, -0.2444447239420849, -0.32088010477302253, -0.6373727404019858, 0.5397469025397056, -0.4766241420143262, -0.5712182495061866, 0.31436965773560416, -0.5584510566628385, -0.23525598456532695, -0.34091525333755374, 0.1168073099081628, -0.44149495667197836, -0.4358411324087288, 0.475030747901267, -0.5850282715077468, -0.38953500313033823, -0.6587151842891708, -0.5511803695022762, -0.3459946127621978, -0.26578296028238024, 0.042968484609661996, -0.4943634409266767, -0.3330171024032146, -0.6500269922343491, -0.060127697079210826, 0.5238285833498585, -0.4706261836091255, -0.27285407775402676, -0.5206221631998232},
    {-0.017373534178387478, 0.020065706970390642, -0.5351255479768563, -0.4068196610381897, -0.10077951415870123, -0.07893039860350899, -0.019915449776694922, -0.5560866309977022, -0.040936223976380214, -0.465469174409417, 0.06845334054328779, -0.19722282542124522, 0.022576670231258176, -0.5031904741303657, -0.011831229490102567, -0.3191263602961588, 0.09494094578255471, -0.426486261056269, -0.4395802133918082, -0.4603995980619967, -0.09671591422910736, -0.08303314660126339, -0.10072499831918959, -0.13181884984825706, -0.18006059756806508, -0.34149929904332554, 0.03642065036391635, 0.11799036055483511, 0.09678961730479299, -0.2850287771673649, 0.2552960320643986, -0.24116236217998788, 0.002139738361914016, -0.005484044952699611, 0.12870361477271722, -0.22301712388799866, 0.23570137354522466, -0.10345542571538738, -0.45237553390901636, -0.031415865241302694, -0.23687235570286616, -0.2252325689058732, 0.1519534910284941, 0.18083205404955988, 0.129052724478478, -0.010621045148774719, -0.43011502372324173, -0.27007334459376675, -0.05583973482064816, -0.2759381235942263, -0.11084566316254557, 0.04557360197163401, 0.0059678703100161405, 0.04675708340047759, -0.20504168762700936, 0.12307638626944385, 0.21536683044350563, -0.09996137414956338, 0.10020241478392844, -0.16184455672388717, -0.3352696339468232, -0.024085498424446267, -0.2333901407587035, 0.022809065463140675},
    {0.048795143392952316, -0.19651648111419812, 0.5489739363451808, 0.0017571100813392408, -0.3380948632261751, -0.1251009419552774, -0.2447911687282223, 0.3570953468359777, 0.23099279151492455, 0.4868576075174261, 0.2627266791782425, 0.3060499857008035, -0.35719372103314984, 0.29097862319120193, -0.06481031555893092, 0.4175148286656662, -0.24612526384488154, 0.4903534369565718, -0.20986418100948676, 0.016664223285006306, 0.2935256755405357, -0.39153720989739066, -0.18229333699442996, 0.08139946920832554, -0.15587831573667935, 0.286618501611305, 0.07676523888349193, 0.41178415247906375, 0.21432277559475577, 0.20765487200348287, 0.10835371933079668, 0.053131800406985494, 0.1354508253913508, -0.33049648008126087, -0.42751701172560225, -0.3765264988877075, -0.3528937813412387, -0.4547179191705026, 0.5129802574760309, 0.009740415462899724, -0.41066730482401465, 0.2640826883396603, -0.32341266378322725, 0.32526034870110265, -0.22318650074992585, 0.29491377449860523, 0.1292826572965942, -0.3756188357049721, 0.20331028303985033, -0.3198334460727485, -0.3577528814931727, -0.291185629563779, -0.3925390644233225, -0.1845992988943233, -0.29132617781075787, 0.3384549481575339, -0.2815808159798216, -0.2913241084656904, -0.5009195742027237, -0.1789364732835564, 0.1277939225946751, -0.5740594327076038, -0.4298869300412999, -0.5827009667976831},
    {0.19967950535198967, -0.10837425634133009, 0.05054755002164345, -0.1933682822326594, -0.591376920369251, 0.06838609354877284, -0.3498537390498766, 0.17238866009055095, 0.051127890853820884, -0.17304654781315132, 0.012230217740594703, -0.1129238158428179, -0.5121543930570472, 0.10742470487864028, -0.26587505547884965, 0.2533581972951056, -0.30888055539775366, -0.1695189328563338, -0.5440856717155208, -0.3678431817275213, 0.022319565615821962, 0.15379823487334526, -0.2447928038792146, -0.372478296909535, -0.3921911031934871, 0.05348152814453104, 0.13210172824925287, -0.21240894430069526, -0.22237848430078835, -0.22893233759283188, 0.2982037818245261, -0.11390622856625444, -0.05843393376352639, -0.12784345520317428, -0.31432461581660465, -0.15996211248318648, -0.28806905926167403, -0.17864799066844228, 0.044662806247866574, -0.3569081701632729, -0.1397055167014878, 0.17524892631955868, -0.27196467060197166, 0.16421600775119632, -0.19805454459908678, 0.3779700909944979, 0.21009475036636097, -0.25696242458411, 0.11931233235536766, -0.2691237147366483, -0.07605728771637436, 0.0844093342729265, -0.12904044067246476, -0.2459852273804019, -0.23851693847688157, -0.2055465373634091, 0.42282121487796437, -0.25236265605586294, -0.10275654945066312, -0.3692255992069875, 0.04854114052577619, 0.0010189930775379205, -0.26708497817624616, -0.349327164787656},
    {-0.41905637956241454, 0.03822491732299863, 0.17451413806133942, -0.17359266131349937, -0.5218262009254846, -0.027542173132124682, -0.1455438063685905, -0.28868279428878274, 0.08922453367603385, -0.3338052689370511, -0.21008973341938597, 0.12838043268009977, -0.4559047448609223, 0.06948056625449892, -0.14859346101049803, -0.07788329731902272, -0.12526419122600682, -0.19143078525744991, -0.5046234154248636, -0.4822030710834164, 0.1524297692291466, -0.30277111826340236, -0.3737109545370083, -0.1655631507535687, -0.447640890492072, -0.16370425797039448, -0.026475721293721492, 0.0637313905570335, -0.4341060064265373, -0.03737510824875889, 0.07411842525522383, -0.05324580780072173, -0.2535180063514335, -0.24023476833522384, -0.2777136259478444, -0.07907197505999553, -0.5298151243079805, 0.04627195189440972, -0.27400797494846013, -0.47893217459742465, -0.3514917922616391, 0.1686805231298375, -0.4641942832034191, -0.22095552114409361, -0.2747024844031873, -0.07895187320468179, -0.16723020440188963, -0.2985078621854768, 0.25088582285199845, -0.003013808919567908, -0.10028142360841977, -0.0077383269759329736, -0.18730078007980902, -0.14882075871045303, -0.246314975695793, -0.020693568527043578, -0.24881877241836955, -0.2840635453535344, -0.3335907756923464, -0.1339279796354243, -0.09985767576102972, -0.06392292174935114, -0.3904499966027949, -0.43982589843720915},
    {-0.3236783518776547, -0.11700950335349686, 0.145333827940823, -0.36469703600521586, -0.2809111474832568, -0.28547477995754766, -0.1900485336347042, 0.1708139281958397, 0.05870233545168809, 0.22879665874688, -0.21382414598194832, 0.3073428549603349, -0.44203005922689653, 0.14304580895125837, -0.5838472893663637, 0.23785531905498414, -0.18569234041023683, -0.0631151190028101, -0.28341163259997415, 0.08158960487286283, 0.3212069393561555, -0.49555080513731975, -0.6199512660099681, 0.24204978698929955, -0.6335185274873215, -0.2582332532682068, 0.17027072427609238, 0.2791668662331251, -0.2909436815986333, 0.2707982917501573, -0.011032384258087795, -0.24594037755100182, -0.09029679564369027, -0.5041980759865499, -0.33386131693029053, -0.49908097688394726, -0.5566840580976913, -0.12220698621825979, 0.36940746097409727, -0.23067575837269305, -0.3088910541478786, 0.18912630804421668, -0.23298923919435957, -0.1936304803973681, -0.5105302220599265, 0.2830667051353934, 0.09401791056015663, -0.2964436350211241, 0.21288746818591803, -0.22421584942198572, -0.5650938424373555, -0.41507332897650545, -0.5296932213078019, -0.484992776976035, -0.5103160766970701, -0.12381708865508835, -0.22962568998520608, -0.49973149518005305, -0.40024264101198215, -0.2185665892734138, 0.21143285024653474, -0.26560882785782414, -0.4582333444944108, -0.6223976797995691},
    {-0.020155730043137567, -0.5085486704533086, 0.23912377831339787, -0.4271125997543753, -0.24898086900008295, -0.3332113999322998, -0.45836692060455403, -0.07251938934811997, -0.07682281065927797, -0.0494160716366215, -0.19650005432377662, -0.00886354924801921, -0.5377371146394315, 0.026916363506386116, -0.31970954129094414, 0.23050123473897968, -0.4003963244167995, -0.22918812649911088, -0.5008218267172159, -0.06215050719671949, -0.1096266282850425, -0.34896324150859415, -0.22681982718216395, 0.06488214819165895, -0.5127610517323536, -0.2568711568185418, 0.3393306353888937, 0.21503758391643704, -0.388418634573765, 0.27981003044161057, 0.31615360763249833, -0.20918718829019572, 0.3151534170920626, -0.31041704728855674, -0.39675441856500526, -0.4755174000730494, -0.5158826997918402, -0.3727174212641985, 0.18875336558234337, -0.06153026348881614, -0.45492911957320326, 0.2555386291975908, -0.4063634675274474, 0.275131535146884, -0.44758806955578295, 0.19157711009385078, 0.06007279738461981, -0.2577283391736687, 0.10530857251458482, -0.16432709564673084, -0.3293904058773163, -0.161797972034604, -0.2782282489355135, -0.4306117200311593, -0.4458571774898386, -0.19406135640081146, 0.11261116679776928, -0.32109358436095964, 0.022109564319894272, -0.542123377272691, 0.17494450496281308, -0.16744636070539923, -0.4677069350146347, -0.20459995061595684},
    {-0.3543241628733305, -0.5687490027215442, 0.3248334720779744, -0.5209352593612758, -0.5509463744336701, -0.11828546253794878, -0.4216311586028833, -0.025781462268867076, 0.11442167848860305, 0.22325099398219778, -0.14145743002226904, 0.1757244643226509, -0.5241586955943265, -0.10842678855505006, -0.21368950311735516, 0.08157605627082815, -0.5347229181778745, 0.12173296359455682, -0.4423723133543648, -0.08244276502202948, -0.09395896908959268, -0.5590107070428304, -0.5061363245793267, -0.31661287576877084, -0.4687523565452703, -0.3248503374826989, 0.003164411913175614, -0.009909532563787371, -0.3479346838700701, 0.2892486189156793, 0.15181461888077144, -0.23872450954895816, 0.07993896469754569, -0.14488605757183795, -0.35019734387581153, -0.2825500248502589, -0.3353469322521713, -0.19150881739539524, 0.1355548756633697, -0.3490493286730149, -0.6058674484318514, -0.08451894011526227, -0.3730027003981802, 0.21157816829732634, -0.553034356566809, 0.12019794026100174, -0.12061032846486731, -0.36241097214261775, 0.1357262359142979, -0.6103633921365588, -0.39986067964691496, -0.20143878103425833, -0.34373664059417264, -0.46712061721658704, -0.3831826567654869, -0.4754677605037998, -0.34276119697017343, -0.2637235361995956, -0.31571578066392847, -0.49947376419647266, 0.10805456898904146, -0.3235430557375902, -0.41754428096542645, -0.394558979875531},
    {-0.05011127761222305, -0.11796617969332661, 0.4277170853911533, -0.4412302726543699, -0.4510037437154349, -0.347703602094456, -0.25666754294676886, -0.1646500467013962, 0.08003904076400341, 0.19772911511196273, -0.010828340025700434, 0.36823379133822426, -0.2203890732065542, 0.32258247096573767, -0.5027778988573934, 0.1007199454623806, -0.18983254204211308, 0.18554971995524822, -0.42442532914460096, -0.2457288803595264, 0.25258657265036916, -0.44213060121639397, -0.38323493262059416, -0.0740907523949206, -0.3586216836650676, -0.031978739275441544, 0.0159295717157187, -0.059328754402221906, -0.03195229536047866, 0.13591319793170806, 0.04486194410248061, 0.022280588798404857, 0.34386828801804326, -0.15405932244682238, -0.48912008572491456, -0.4582099411224201, -0.1444739143505785, -0.42692173873073125, 0.11532021377098843, -0.3330303114468454, -0.2525922646830854, 0.1545983238691518, -0.06068196390036962, 0.2643843070570184, -0.5240448791160573, -0.03561060672812061, 0.058183871032906384, -0.5628624977972032, 0.18957156973370484, -0.38227034995999465, -0.18875310396902137, -0.2526770613357369, -0.2483066810247226, -0.4973560047385887, -0.24497385982404954, -0.10366585455560347, 0.08237706573609252, -0.2833109388700134, -0.49087521655223887, -0.17665084644534473, -0.042749329409714765, -0.34681328489495156, -0.45176253977741, -0.5729720866542132},
    {0.08685156488675713, -0.2777400848632552, 0.30754631744864225, -0.2846859024823748, -0.47161605612448326, -0.03651019371978077, -0.44162152671113725, 0.11748996941248362, 0.03825719579172413, -0.1324563827537806, -0.135121486112802, 0.1876080953036413, -0.4502016835571483, 0.3353186660587619, -0.28513585532644403, 0.36063929011097223, -0.24978022049323187, 0.13040317654986455, -0.3585441629896454, -0.1734311680342069, 0.18506266161455678, -0.43741244320135764, -0.39831369780347003, 0.04460046152671503, -0.5279596128815427, -0.12484398527412788, 0.1435276548913287, 0.3220072343270636, -0.16005574308590875, 0.09818067859265117, 0.12643749367866125, -0.39973104667695475, 0.36560533245250665, -0.4568597589885139, -0.4215303562484628, -0.40562251178533903, -0.3241563209430309, -0.5032805725824933, 0.33818688974842886, -0.5066869103487545, -0.42229216757721455, 0.1628849550568697, -0.3715457915543292, -0.1625227350290433, -0.23806013858249703, 0.2985801607328203, 0.16692689014585238, -0.45381535350130475, 0.1825056001590932, -0.15687023772571476, -0.3804033611804805, -0.3602301901277911, -0.33505309711502196, -0.3398792669619783, -0.5032383780268583, -0.213563724490173, -0.07084127606535717, -0.2822879271455711, -0.49640465326851435, -0.5074183930349078, 0.1294014818418551, -0.30600773286501515, -0.580361236805466, -0.5401158957036012},
    {-0.06194763785492762, -0.32679080588930515, 0.22393529869181167, -0.6626120113956585, -0.578017939403503, -0.3314816601634013, -0.635533393091659, -0.09391362278780274, 0.27098286385661746, -0.042330040031841175, -0.143563256837062, 0.16431917487666564, -0.3171612505887415, 0.32427621854585487, -0.525551232487499, 0.336542643957625, -0.6515106877878297, 0.19589147106976554, -0.6117398978093064, -0.09887502281404925, -0.026651715111373774, -0.222382658080917, -0.4664056745254315, -0.23387913731472965, -0.32548042811624445, 0.12425900705225593, 0.03413376270720012, 0.3128713402738052, -0.12348724581469696, 0.19154145308630452, 0.12568727258592552, -0.3503679341389036, 0.27474284225447826, -0.5087313964266266, -0.4555193207650214, -0.3351825740099519, -0.4698925128371448, -0.18097341698954483, 0.3296641904224403, -0.5360579367720032, -0.6164877683123168, -0.08633234834207103, -0.6223056477344711, 0.20463527327161923, -0.521213791541336, 0.3351011498809449, 0.1969522479214459, -0.5771198536908866, 0.2517410548186577, -0.28885621183643756, -0.49113405256954185, -0.2341600600727983, -0.5440138113999272, -0.31100659119944907, -0.5396825637572151, -0.2307000569849458, -0.33665152687033345, -0.6131646000576076, -0.4042232953872749, -0.4593484689364112, -0.08105032500941531, -0.5716579000321235, -0.3870706902536376, -0.43896647428046137},
    {-0.2995538059707918, -0.24117096228824234, 0.0897190979875142, -0.25456276212078727, -0.36278803340092863, -0.217764954473886, -0.2655298662100682, -0.2026843912442862, 0.17897264160285997, 0.028796053693185296, 0.023464271383757607, 0.23586111880631397, -0.4320206694869448, 0.11147837321263779, -0.33703599201455336, 0.017240573370889353, -0.2224212677847128, -0.27779194420971887, -0.6342177483038134, -0.36314253810273894, 0.005208195195731197, -0.4906858821096082, -0.42158477835774016, -0.22547479662879563, -0.45192905412190054, -0.16747075327920286, 0.130001813894442, 0.19527542831479275, -0.4783650651730519, 0.0316855216167543, 0.11495339616797806, -0.28702133627651644, 0.03293344359962843, -0.15443858455777182, -0.4703296459934062, -0.5165381336810282, -0.421491418232032, -0.36403236537094535, 0.10167168452090541, -0.590765633304331, -0.6049773171898396, 0.012427413297363568, -0.4025548986995295, -0.18860628346338976, -0.39978786345633305, 0.10938530653398913, 0.08353448306966384, -0.5617631635478753, 0.207979503322516, -0.4615856883409073, -0.31905990839731696, -0.3396679332487741, -0.17521432942655898, -0.517551797092958, -0.5133384020342218, -0.3243451854943168, -0.2131588091596879, -0.3575748804757129, -0.18559834766949682, -0.5317315228796676, -0.20909221623219423, -0.4305918085779921, -0.5144255540670915, -0.39623745399883775},
    {-0.07414742236655483, -0.5236280297312887, -0.08684212334033288, -0.43823676144764145, -0.29063506246329185, -0.4583172870119163, -0.622519448395869, -0.1696563921056347, 0.015617764409874958, 0.14553016460306642, 0.1879505542920738, 0.3266502301899678, -0.6120253154458611, 0.35564257032249486, -0.24423631294614975, 0.027598750874791068, -0.28474448629701704, -0.16526939548122913, -0.4050417399778061, -0.14622615025310687, -0.11057909270745693, -0.5418239064522135, -0.5267865097789671, -0.3571483558345789, -0.5276440506651486, -0.07343726105669544, 0.037751907996397396, 0.11597647878344451, -0.4734296770796171, -0.0678480575585962, -0.03175232055270834, -0.20517437297673988, 0.360505750189415, -0.37038870529456125, -0.4714251820355312, -0.3632810787085533, -0.25952458374669435, -0.25455864525256844, 0.02426791230421376, -0.5252583020893941, -0.6290195633768944, 0.06519305666978174, -0.5351230566496067, 0.0881758663115683, -0.5260968083839046, 0.3418112859977448, 0.09553924903888528, -0.2615899528894333, 0.14164640204996015, -0.18219171139273294, -0.3383865345061891, -0.3464410899122839, -0.32121833172580605, -0.34973453900629337, -0.5512546692784306, -0.3463041899043345, 0.10172127117491334, -0.6242630648443512, -0.43484902954384647, -0.6956011165300271, 0.12847321713342275, -0.5481493363346679, -0.5639561764892567, -0.6337346624915324},
    {-0.3301771885874015, -0.33002508449517637, 0.14551986813003556, -0.38929367816631794, -0.491002382633069, -0.46234296752522375, -0.5268178077466568, 0.042056652146019564, 0.08693955044152153, 0.06324856644065117, 0.058847676490088666, 0.05224417989538799, -0.5220816746929419, 0.1103239276124501, -0.5166751288256248, 0.11855035881285432, -0.33709728237367065, 0.06443577817496257, -0.6446565545423859, -0.3541420131180932, 0.07979316027347239, -0.6676418259994572, -0.6287473553648104, -0.40590933796238754, -0.6794121038264803, -0.3715617756311938, -0.03923949383546866, -0.015633952475460126, -0.3163238266458434, -0.28298973173865005, -0.05744012443593556, -0.4796005000118499, 0.20432618503103592, -0.15992029013395345, -0.4708928842986554, -0.3653003140039197, -0.35461480903635106, -0.43309322932026917, 0.28382442898230004, -0.41989396493334524, -0.533231450312601, 0.008992598009359786, -0.5816278301585395, 0.038881375915109345, -0.6110545561991113, 0.25019557329390496, 0.05510708779615827, -0.6330752489656377, 0.014257689345897353, -0.47804153036876423, -0.37422250956291303, 0.0036114123980716907, -0.3956948210427311, -0.5017869302002642, -0.5804084818476469, -0.0794697457443082, 0.044637482689476995, -0.3215090536183746, -0.41907993291052326, -0.4758173652624872, 0.16152548128631497, -0.3073912928047831, -0.4544824996820396, -0.6439289144788277},
    {-0.19484855548905045, -0.542618747434469, 0.22171618935656323, -0.5742545109372144, -0.42802713918592683, -0.387283683482469, -0.5700275678783631, -0.10452598945788469, -0.07365236455192835, -0.038669911261076884, -0.1260411808172537, 0.21146635535968605, -0.5656789471154259, 0.3152081155484474, -0.6465119989698385, 0.2539980059581694, -0.6017287395149922, -0.20759707809152933, -0.5043245095948028, -0.1935144936395391, -0.28990005394596585, -0.3737356167576927, -0.345731642726243, -0.29034731376605183, -0.6670447167086383, -0.07139079503187748, 0.18448713618449883, 0.21859550381687876, -0.17821921020052398, -0.18238504935796498, 0.11186734039418607, -0.5254429850146923, 0.2183317053896077, -0.308451611234455, -0.6413399029654507, -0.2638535590841762, -0.27531395236547196, -0.38608015202997487, 0.3467304912882424, -0.48558991734711343, -0.48302937133507756, -0.060124368267030104, -0.4394706670638005, 0.04393463132163793, -0.4623733197743055, 0.31274433720632366, -0.12264901662204472, -0.4514547455041772, 0.3431332353258253, -0.5430003372925664, -0.5583137277041973, -0.36656543300596844, -0.45924028193437894, -0.3238694514483719, -0.5797123284487117, -0.229174488522895, -0.07559660607257677, -0.3839051493065701, -0.37543400526679394, -0.5826000475833657, 0.1381644019492823, -0.5709405965041388, -0.5507082630659303, -0.6226440671713204},
    {-0.1888448024175018, -0.6245546403887062, 0.12273695147676987, -0.4310600244701935, -0.5913021798837462, -0.19725563998011772, -0.4757588606781055, 0.23582519068276805, -0.026373919008682977, 0.22242679712072708, 0.3732885997787257, 0.02001899725188403, -0.29590407928619206, 0.2912541871903157, -0.5354796265356435, 0.19227464871484368, -0.3052935364749562, -0.23563428459719665, -0.5379799384601853, -0.10491962999802829, 0.021487958981954988, -0.4322131663621991, -0.5047068866799546, -0.04540196671328819, -0.4641977002031436, -0.21505382861366343, 0.09091602622833334, 0.4076257841564906, -0.009920229067865037, -0.043634147405367064, 0.24204822013019095, -0.34705250631987, 0.0956790703350734, -0.4521657698276543, -0.32550988968779176, -0.44014368247390995, -0.47993738503626693, -0.049514158211104345, 0.4656288482111728, -0.3925558342289747, -0.4269539948883618, 0.37032927653011016, -0.2871254688377798, 0.2528069666440488, -0.35214266784076664, 0.2633486534812352, 0.13300833074678048, -0.2054933437081994, 0.1758589039374845, -0.2610870311177565, -0.4756486096263775, -0.1836797316711038, -0.4988326481122463, -0.3467891368067451, -0.38778841131088065, -0.4829538484962677, 0.16890218541164137, -0.586628961256839, -0.12447123309962671, -0.5072175012893014, 0.33287863884911606, -0.4291162938833699, -0.5755522218568969, -0.3768653639250045},
    {-0.1342712266665844, -0.29549812346002413, -0.01921217183570923, -0.3048643490010987, -0.6456393370626735, -0.07867066657885534, -0.4290328322194857, 0.23756782204603638, -0.03242495865790171, 0.20240312852593723, 0.29029972123841213, -0.0547098734685897, -0.47503493577082384, 0.04725736919377899, -0.32432236984897495, 0.17815812550558915, -0.38133400632431025, -0.14216056092915075, -0.7277076704288276, -0.13872759436957852, 0.021530214285287553, -0.12259732668510225, -0.5001180258271772, -0.0008171753661200998, -0.3316045774447987, -0.3134876659515118, 0.06197750945277287, 0.04600218749084983, -0.09545187690947801, -0.1420473537014124, 0.10556844817283957, -0.38185581034036287, -0.10976999635704526, -0.29919224802673294, -0.47708868948081673, -0.38214480065058254, -0.5366740437372844, 0.006766979743718613, 0.1389893456016469, -0.4822953528078622, -0.26834915063071846, 0.06978484007072162, -0.4378024516538922, -0.0816350762083024, -0.4774999579042415, 0.38980347327760967, -0.07954122828718961, -0.38058999905135005, 0.12743820777394094, -0.47860753467891326, -0.4754890434466439, 0.008820790217628311, -0.6333301670837933, -0.21932450949104215, -0.2502730944448139, -0.45593673336115337, -0.08573533267175913, -0.5074196538415425, -0.013217798622164443, -0.6289642839659604, 0.1361003382951014, -0.20015685298327157, -0.566056667922682, -0.6655189401374465},
    {0.008724178323064644, -0.5383959863541985, 0.17021627068241332, -0.22856281223621722, -0.38894148984596305, -0.1258241962246427, -0.5753286302469633, 0.07090941939845313, -0.05556719341147297, 0.15160959126451876, 0.24150605885712595, 0.03158685765476759, -0.48254373313828436, 0.4588664590326736, -0.4129883966951261, 0.4535110921970071, -0.39382694177123456, -0.07330098449211156, -0.47368653417272166, -0.03830570802583104, -0.10581756103820669, -0.4462051316654734, -0.381953179464744, -0.013313387503453988, -0.45662512907104724, 0.16934993703515597, 0.25292360353383553, 0.029881204953472833, -0.2294363582993286, -0.14330151107233105, 0.02548911057695145, -0.34514183501995754, -0.01507283921610228, -0.12980135759960273, -0.3047372225519991, -0.33548737429624553, -0.5539202113258429, -0.18834244857586685, 0.3430975119096566, -0.15212076875878447, -0.2692475085351298, 0.3203106456162758, -0.2805111540693128, -0.031218592679989145, -0.2676398726730529, 0.393915802568249, 0.21377616745649955, -0.1910948711081392, 0.22638918074010717, -0.22643335034865994, -0.25770174973813864, 0.20784057710968576, -0.39075314605107675, -0.225938210559788, -0.2996535550198296, -0.2962671111010499, 0.07718666936908206, -0.415258690857375, 0.0047699324527136185, -0.2076644741721927, 0.27824032416511596, -0.3195818433314731, -0.4101629145856577, -0.17955418345499877},
    {-0.16031795578387384, -0.4769416056328432, 0.311161823260669, -0.48794089895538595, -0.335055834309937, -0.10891742323646743, -0.49437944628406855, 0.40347029007257235, -0.0296463301156033, 0.4330902041491336, 0.4913130870390946, 0.04158764683008957, -0.49362296352869794, 0.3762673803829059, -0.4266698542079388, 0.4531127248173936, -0.11894070267507895, 0.035949816047601314, -0.4072027177792067, 0.16756538464956952, 0.1698368095882376, -0.25198357779259634, -0.43087546499050083, 0.26481404531318814, -0.3271987262704248, 0.1716852997125407, 0.06929257548595127, 0.28445797571476406, 0.1367242989314789, 0.17910036380611666, 0.05702899524803724, -0.11420542623619703, 0.3247591085114591, -0.38674700968373993, -0.5077303680449189, -0.30423413852737713, -0.24418499750225953, 0.07703434550780375, 0.0911656426857585, -0.06396128291821575, -0.16416410711584425, 0.32660782309035163, -0.10652567570511141, -0.15140510982439753, -0.2235210280273477, 0.3409874662861625, 0.16618847997402117, -0.2850102078652752, 0.14593052255604058, -0.4681539784969266, -0.3675743472717601, 0.1786820913685482, -0.3928154299245986, 0.06626666856150419, -0.30642222196474433, 0.013381858459524096, -0.19410248334363048, -0.428059469173202, -0.22681296206882123, -0.34637505998982565, 0.2939625099029929, -0.2166598979664467, -0.10278935845291977, -0.4809647000140117},
    {-0.222690307355246, -0.513073488596509, 0.23094616918963445, -0.32155238945050396, -0.3645426382810667, -0.42440743824525207, -0.5445552560551015, 0.026010171757816853, -0.08882498276678841, -0.028089177315016776, -0.07908851672786449, 0.0025977920733212096, -0.4443365930065754, 0.4487209588571755, -0.5312885113068866, 0.3441233343250602, -0.6562594845319136, -0.16441201597467883, -0.31643380768800505, -0.49626540712065587, 0.2133999890183546, -0.26655465901669606, -0.37674750774064486, -0.18847626083821756, -0.39730822866421905, -0.275398519606953, 0.029950814961058794, -0.07613604424672454, -0.40169642827703617, -0.02953694712900859, 0.19198386584621233, -0.3536676689892852, 0.17451804388314038, -0.4899610588150796, -0.479330567373023, -0.392646972150575, -0.5574676379465121, -0.21128761733126133, -0.014039002290919308, -0.17131271434119208, -0.3023187585205504, 0.02538787641977063, -0.45837438599093333, -0.06656653302363949, -0.5803363257776933, 0.32289437331999915, 0.12047918996030178, -0.558824319396486, 0.21917151661576842, -0.39005695899906623, -0.23779863393275116, -0.1411798533887912, -0.24060361517559067, -0.24111530333020326, -0.584314890745682, -0.4417075810399794, -0.11783862786929855, -0.31232594955564263, -0.3130413415147736, -0.4690827386174055, 0.06831344334821261, -0.21262162887952876, -0.5459097580318707, -0.5674451359337257},
    {-0.16828565144934693, -0.4648862068359188, -0.08885301842231427, -0.5133801028942121, -0.5011484414127614, -0.1273312132146555, -0.48736064062750245, -0.00964706576192447, 0.21776468009978558, 0.2700149552066079, 0.2597016621690807, 0.09796738611584689, -0.45064338979913204, 0.25517730260027605, -0.706138526687107, 0.08409323793946792, -0.47364840124573193, -0.008528080250247422, -0.55172492545256, -0.43094069972399346, -0.07587032011600112, -0.3459738492133504, -0.6054973723533418, 0.05494127062522628, -0.6369829049674512, -0.2573638944327522, 0.12042916813956213, 0.041670226322860986, -0.15716094225599442, -0.1999946757161763, 0.3337259262581129, -0.35131073508589333, 0.34569135967541104, -0.3553503220193665, -0.3510369179935985, -0.32427157121699524, -0.492503964769817, -0.13712331457492677, 0.24367647690707014, -0.3884609714850319, -0.395433402759325, 0.1617500255128259, -0.3326548487550671, 0.23984772439477114, -0.7274038717325171, 0.15700274293736197, 0.15477937047671847, -0.4968073305351144, 0.09462684828811606, -0.28578327720039964, -0.3960621972777378, -0.13401912094071192, -0.30219238282428684, -0.5835922847114892, -0.41858946204045466, -0.23667815794944833, 0.10868451052091092, -0.3291107976818324, -0.32506622595531914, -0.5774115139429861, 0.0744252299402082, -0.3060047572042496, -0.33445309007616214, -0.502233024107603},
    {-0.40067367718790453, -0.5726520568211376, -0.1880609139697399, -0.5619570069954457, -0.6999541944221828, -0.3756590430067937, -0.3767097670982238, -0.1807447639255243, 0.1483062738248983, 0.04547815074272358, 0.06399474960100376, 0.17183598185614782, -0.5895243015388012, -0.009403333063470628, -0.4082337061203334, -0.0398420159568341, -0.6824687599549367, -0.03854265331010972, -0.5071459273481095, -0.49651224716604403, 0.04813402157922883, -0.5907876551144282, -0.507980142768999, -0.2030484056411452, -0.6805214771016403, -0.10715153448867407, -0.11665189016818114, 0.13906966968960532, -0.4504340263161724, -0.14565054506225972, 0.2395355800098106, -0.27854142442873725, -0.06806329140313257, -0.3205441872559022, -0.7268252207898277, -0.5287611790027694, -0.3886469915062121, -0.45583734300027573, 0.1253746894508706, -0.6025483743694758, -0.6910957148244562, -0.056558403503944144, -0.637736313367382, -0.19025211041685347, -0.46199406084446815, -0.037836146725766816, -0.22471067417697232, -0.471400237341146, 0.2804452298507114, -0.3379952682109188, -0.3551345426711894, -0.30184553553495574, -0.591019264326166, -0.6389427238613693, -0.46468604637904637, -0.2411054628512346, -0.35573268688420245, -0.5682858492314572, -0.35455523858949045, -0.6881141182926044, 0.09552042936942558, -0.3812404384332015, -0.6490378581732043, -0.430680227364494},
    {-0.11516459129785916, -0.5063976589831743, 0.4189844161300321, -0.4873782012800955, -0.40310751411584583, -0.03356679467308232, -0.5811549704170852, 0.40872756689942463, 0.2114161164326469, 0.5291024305745412, 0.357894279989668, 0.22743250740281337, -0.3784876154844433, 0.2772875815290807, -0.28924252017324364, 0.4855887143820422, -0.6691925383250965, 0.18754452977655942, -0.7177238827301696, -0.07590136763776378, 0.37792866491132837, -0.2518672255474978, -0.6315009843916846, 0.4669677220630474, -0.31208367555148137, 0.376885087304587, 0.08246936735307882, 0.4438911430643343, 0.11881260809413373, 0.3196150009614987, 0.3245889340108519, -0.4409475534885417, 0.28093214274657907, -0.4656115830071862, -0.6912131976957814, -0.597033541467916, -0.3667927094547707, -0.2581516553363522, 0.408138989033129, -0.2254483980399678, -0.2789779153546561, 0.3274611519970509, -0.47986844395145456, 0.31225622245496376, -0.5115034074694261, 0.5262492832542769, 0.03273969857791607, -0.5642650975054261, 0.3993413607436648, -0.2667526269854785, -0.4781521915899256, 0.0064117204880661536, -0.5960627098430169, -0.14552379560543924, -0.6265915702442444, -0.13887892956125622, -0.1641526531767359, -0.3008037226829247, -0.2926803586637913, -0.4744387925610584, 0.32934258057013244, -0.5068597727056935, -0.3841259018413433, -0.4707374657294027},
    {0.14721366411122458, -0.4312188237828943, 0.1919661377399702, -0.3913918186310502, -0.48619611176397665, -0.09701082034945344, -0.561598701330911, 0.38759576916274024, 0.48816819935797345, 0.554725457608319, 0.32304424036840246, 0.3978208370277398, -0.5839099433531646, 0.6660526286431869, -0.5108634273857696, 0.4120389807572293, -0.36634254112192655, 0.17103073906723193, -0.7056506693775452, 0.006709198409718393, 0.4022415699976675, 0.024769590392500762, -0.46230828066324187, 0.5203216692717523, -0.45550157580960604, 0.13735562970195056, 0.20776969346519647, 0.23826890556681993, 0.3626620481675268, 0.21259764585331312, 0.5097228897458305, -0.3522183819098579, 0.45198852634387215, -0.22252252341619877, -0.5132103042392903, -0.2518266855544121, -0.5929682350114797, 0.16545628374319424, 0.5488530302694816, 0.019862618858388647, -0.08279665271262253, 0.5201471343909106, -0.07414826185784917, 0.22356501659950806, -0.38477135346940466, 0.4791374495898311, 0.49199511227732146, -0.2580036394694789, 0.3650655306871365, -0.15379708696800554, 0.12174820084641484, 0.21635900359133795, -0.40720705531316614, 0.24465678249080455, -0.6114879577549241, -0.11022287586222806, 0.28417410388890035, -0.29732629055568094, 0.29005459632725356, -0.5429610311266634, 0.12358919705653457, 0.15791323060640935, -0.1607507137391974, -0.3477926629656492},
    {0.153664288756674, -0.6354844029231153, 0.20208070408945703, -0.4237550821228833, -0.7423274400057774, -0.22553020692571557, -0.39183683311068035, 0.3098732178075569, 0.35275801214758273, 0.26465885727544114, 0.281521234506809, 0.15496239386989066, -0.42520012475083, 0.29208678984482517, -0.45339195781528707, 0.325472802193768, -0.4308742969691223, -0.42650777092103903, -0.5368281100776617, -0.48053075659783717, -0.12848591940318693, -0.19551701248120065, -0.584322886657794, 0.2680079953391777, -0.43348577580869024, -0.15160674027984422, 0.21432591767832973, 0.23670310135848996, -0.12172955060490268, 0.2950958715533594, 0.5065192320458652, -0.3753716847792747, 0.3242295083854192, -0.313070704839455, -0.4045731141048205, -0.39550924725541525, -0.6666655509136422, -0.017974755486763288, 0.10842007946906589, -0.2515476541678741, -0.3498914371513293, 0.2624014660545215, -0.44890048365531754, 0.2601783923706136, -0.29041232299183894, 0.4349054979765735, 0.07121772430712116, -0.23558683014882992, 0.4005261487465707, -0.3889076599983585, -0.2911486379781411, -0.010853459521649221, -0.5533239474736097, -0.3048423115579148, -0.41015261077147736, -0.22916860666341482, 0.21127236627795545, -0.29014174385266167, 0.0440844716101975, -0.6825483912327813, -0.010073852356116695, -0.13508650629002594, -0.37584076321301463, -0.23999124720423198},
    {0.04613527645615947, -0.5666010080105311, 0.15439071696632203, -0.7347614294122817, -0.6298253960275909, -0.32738749340578166, -0.42784463989031146, 0.19377438880675443, -0.10575477256396175, 0.20156980116667136, 0.14745435577904492, 0.13038834864065166, -0.41338746075869715, 0.21484021105578036, -0.5850615850683906, 0.1614070068465919, -0.6513538204957235, -0.12878806555443775, -0.7008941431179767, -0.5169348919562362, 0.002834804186547533, -0.5977380994345038, -0.7117110618547728, -0.22250798116882484, -0.4557060742943092, 0.051386516993489256, 0.13635863094743453, 0.0698720080720248, -0.45588540384993775, 0.1821032399237602, 0.11349790540086109, -0.2331575970989148, 0.19106010498930664, -0.3923136239131153, -0.6062239248078448, -0.6397297706968196, -0.5389032003363882, -0.3020958146048635, 0.31962204184367154, -0.5952666339575055, -0.5693478171038067, 0.2838159929105316, -0.5148902325463757, -0.010649898950756876, -0.6528557485961715, 0.20808364873767093, 0.04072689360614618, -0.49785381826522, 0.05027651457230495, -0.4634364824493634, -0.41815130521561994, -0.10483506685389908, -0.5742631610110145, -0.49987564432038445, -0.5747999083133742, -0.5595961074353456, 0.06291489783887237, -0.463647028032572, -0.19688125511886567, -0.42516426648164235, 0.06662047865263909, -0.33042646748099824, -0.43457280502584456, -0.3903616387801504},
    {0.03853412102418541, -0.541939926450319, -0.10901203530959386, -0.5937882476417712, -0.5268576343897885, -0.17695144661487336, -0.49407245095062746, 0.27739212560115367, 0.21123932764995937, 0.36165323998989674, 0.22019382431541973, 0.0032065531709581175, -0.35523430254236715, 0.4348173050639602, -0.3446299334144055, 0.2919587874074226, -0.5882238711469613, -0.33975961743521577, -0.5421948294969912, -0.548905823166432, -0.1208012559031321, 0.1445055198501009, -0.5091319516310495, 0.11453833805401217, -0.6448917988725684, 0.05543616213097752, 0.35298142620880085, -0.047424015899343634, -0.29790263482371815, 0.18240807007470816, 0.38775302257124905, -0.16248794414296283, 0.43057775494186534, -0.3198111313062371, -0.2578118883913316, -0.4202107770091097, -0.4596447408411295, -0.010581558517726354, 0.33707113103604935, -0.37195939702430736, -0.30109930600829204, 0.35225262611892416, -0.19358830300773153, 0.3054821492193313, -0.26536227400092205, 0.4590935960576403, 0.20115775980177178, -0.3330395174314657, 0.44651244380676425, -0.1632642346020083, -0.26102720513636696, 0.09062339664537336, -0.31287273964322737, -0.10267937780063184, -0.558361728201704, -0.43741873728599245, 0.09313677872168286, -0.23095309020560828, -0.17459193611743726, -0.6641248335177491, -0.20903033707116583, -0.016564672776676618, -0.2568983481411083, -0.5844258228023373},
    {-0.009621368347879465, -0.45301470396418786, 0.24623484254902236, -0.6614267129925293, -0.35149405727232164, -0.195653942194169, -0.5772349325974276, 0.313875377889403, 0.27560884832700366, 0.45208348674776855, 0.3451841941234197, 0.09429389658043193, -0.29522286285371585, 0.4560428626461405, -0.629394414800878, 0.2563966988547785, -0.594958875065631, -0.28708870421113986, -0.7083968602448343, -0.34984660254512134, -0.020005558123752654, -0.30428037133559704, -0.47495697689956207, 0.22614981591822306, -0.3376292785169832, 0.23249965247909912, 0.3310638608425921, 0.24449351544386289, -0.21121643390981304, 0.009273190414116197, 0.535068749335811, -0.5086135543854412, 0.5393840067897242, -0.5900345670048074, -0.5329816428650355, -0.36552705586770934, -0.3768781834573353, 0.0159564542186534, 0.08273449485042662, -0.3818595892065162, -0.5692627108103164, 0.3035643776945624, -0.24583128343000996, 0.034396947087379906, -0.4668776810819648, 0.3427820044954581, -0.031459314350023505, -0.6046843286564147, 0.5056056498430779, -0.17884592902171195, -0.18722453168683087, 0.06854222290548602, -0.6315677773505372, -0.34833987241273046, -0.5579724196975989, -0.47615458534047206, 0.20085745343690187, -0.3787804933827578, -0.11858099453545863, -0.6405007841302638, 0.12825019514347272, -0.08899856474989493, -0.20617632042980621, -0.36948838907851506},
    {0.0440326576249755, -0.5368057968807715, -0.003225886899530255, -0.446035779126617, -0.6942226803993127, -0.4365426487988317, -0.45326269435171596, 0.24911756992128475, 0.1694490857297439, 0.2528829819786014, 0.018579068173013757, 0.1456843410287139, -0.6902871137641865, 0.39476848895786903, -0.4396028702389061, 0.31182349421427824, -0.7025766810626469, -0.24291319297134914, -0.7613544288569947, -0.2614133538131935, 0.11769783976287714, -0.2369059351753967, -0.4260596699303458, 0.09056870992577892, -0.42516592977199236, 0.17337157932618824, 0.07007134071424669, 0.3514129431960949, -0.030950547417491113, 0.01392215284173237, 0.41045535774460123, -0.5778610713421841, 0.37749801007780304, -0.3625897566830229, -0.5626114644743795, -0.4821685722641104, -0.5035358200363276, -0.10081849895947383, 0.17843488603361213, -0.360925433290573, -0.6532386770504974, 0.37387494457423265, -0.32889863862895585, 0.3346853576395929, -0.6975892522520125, 0.10670292369761925, -0.08505045654401733, -0.5478231146109434, 0.19896219640500493, -0.48168519578417446, -0.1892853637038893, -0.17307163984382826, -0.606293191240707, -0.3318488106039898, -0.6998066327276568, -0.19036477748368136, -0.09501914936250103, -0.5926010949477424, -0.18523416072097623, -0.40060029367967487, -0.12793316776633132, -0.383295605436721, -0.3506928819462247, -0.5816943659205142},
    {0.18883039374119373, -0.50991504349947, 0.13220481897706088, -0.7143903192462565, -0.6385548839973261, -0.23559476885446856, -0.684288656242719, 0.3398253596496544, 0.021499104348607464, 0.3059950926275154, 0.3484921758741648, 0.16193896020151427, -0.490121240731309, 0.2642728858936442, -0.4112843371388408, 0.43230782531332, -0.5709783749001709, -0.17973060288936277, -0.6312476104301152, -0.4546787208920792, 0.20959962568463797, -0.11732136761020161, -0.6663325006109707, 0.29249054501061333, -0.40203313198904117, 0.16037724552712507, 0.1364201749118305, 0.36896768233975274, 0.046727112520606545, 0.2940098209542519, 0.386732561380856, -0.24494211714222114, 0.24693287308253062, -0.6309620182308202, -0.5796759021320541, -0.36162701809167236, -0.3594537223119178, -0.0708710342589032, 0.07635936158826766, -0.22135767292149294, -0.6233130610109896, 0.45886854687752615, -0.571284646107974, 0.3148947042945258, -0.6549602549704282, 0.4081259432125896, 0.21257523034689937, -0.4277337999552321, 0.1614216889025891, -0.23294234183982473, -0.1906886057185823, 0.11600574057414453, -0.511785519142638, -0.2807315517817889, -0.6766083836172381, -0.33613885579791397, 0.04464648216138931, -0.3249009606609934, -0.10697564953913107, -0.6918970924126853, -0.14154665055013796, -0.2732940725725425, -0.5273549439797574, -0.403970050527139},
    {0.25931647562469645, -0.5410236905468886, 0.10965651407649192, -0.6398161665641114, -0.637036857665784, -0.03875082444776909, -0.6742685687338483, 0.41994179770878554, 0.33135424649056233, 0.4371521976583995, 0.3420152683008739, 0.04664579701764646, -0.3714657356394044, 0.3382001410609172, -0.3951889070896635, 0.43381461842973446, -0.6620216891812137, -0.18733376206661406, -0.6568035405668122, -0.308749695855971, 0.06311996519958178, -0.18111836126196315, -0.5475191757877484, 0.042601127994507805, -0.5075554828658737, 0.24551419889631476, 0.2433934767676652, 0.1979981001040268, 0.17372485087654815, 0.18652923201765365, 0.3276112005405847, -0.5325474527872698, 0.2012701887220797, -0.5089823976319311, -0.6522718218204342, -0.5943937991454636, -0.5906009077676363, 0.1554500721822244, 0.2122285938940068, -0.01060715840432402, -0.39469385708081417, 0.4133892505816098, -0.4771218141466765, 0.341309389693772, -0.4179898511630528, 0.42075997470052623, 0.17991511186779593, -0.32710055171561947, 0.4578337681508278, -0.3264315988934948, -0.06181208265677162, 0.03588568233245572, -0.2757509052088345, -0.19220570154622316, -0.3779554447319905, -0.10261514281697395, -0.015139775161551888, -0.2660957605422966, -0.11604049415090832, -0.3420645320383128, -0.02190097700258371, 0.02671089679796278, -0.20039464521821215, -0.34740052418300627},
    {-0.17312270468882587, -0.017192948199182052, -0.5333311311800355, -0.5631166263602115, -0.4267176045486715, -0.35054819705549534, -0.3882340152609186, 0.006180825276704509, -0.2060363099722513, 0.1744706586886994, -0.18344213619909086, -0.26126834064888993, -0.43990071356849153, -0.2731439628572889, 0.18528268360960434, 0.17623062600077646, 0.3196063515602277, 0.2017854968930464, 0.02419493344735109, 0.22529145726989355, 0.5169315858909628, -0.1233517899612319, 0.007463754781016115, 0.351044245384804, 0.11496727687343161, -0.44493589199832473, 0.19229904828429184, -0.30087641092645523, -0.40475760439479297, -0.09737786718211852, -0.23613581498029765, -0.12071479142469203, -0.18004076756703719, -0.3382538867697402, -0.36368478762124185, 0.03825533725605362, -0.35326421635579175, 0.23608955240889903, -0.24299149991966937, 0.11462036808391336, 0.3037308561972083, 0.22413859351379384, -0.5147104739240911, -0.384964587211265, 0.09228273993438253, 0.31673939099120235, -0.3009271144573125, 0.42744083556936424, -0.2680681135543985, -0.3003739752313771, 0.19132571199415738, 0.22738868324722564, -0.2793197154938106, 0.31533521385919666, -0.16749958551591496, -0.2078362470656152, -0.3059916735379706, 0.4676583327178389, -0.07061721555573502, 0.24526600215340524, -0.5608247951317856, -0.42716262858150456, 0.10914528919271868, -0.13988393179496364},
    {0.006869835982539151, 0.1922729952988221, -0.07754630247474244, -0.18944465319028442, -0.4022274414196938, -0.4198255646196264, -0.49428648642091627, 0.17826439789739684, -0.2845093154368794, 0.2837167207348776, 0.20218755594238255, -0.44588713507758787, -0.09810136615285042, 0.13409618086975233, 0.384845876140891, 0.006584681489518316, 0.3629335981825651, 0.33796705358830065, -0.09143878278883465, 0.40336451111912264, 0.4533223827103739, 0.3093851952692741, -0.08753846909086085, 0.41857201196380206, 0.18656035829714468, -0.519709695959308, 0.5095808325029862, 0.009894933584696279, -0.42023542236344763, -0.2788928059878876, -0.4598678339490695, -0.2963733694237725, 0.14915097375359118, -0.23415574258450836, -0.3301779695645156, 0.12552479539370262, -0.4452113888898384, 0.2915557059996521, -0.08880435004032088, 0.4809057377065962, 0.23076987209003605, 0.20169376200959088, -0.5190492211125369, -0.01659731110522106, 0.2258080253567174, 0.5983942453579323, 0.02079279894120769, 0.19406028656457658, 0.07696335353702424, 0.06801378674785996, -0.04970483065143116, 0.5365016511829898, -0.49824192460802835, 0.4983864757151347, -0.0818427599078324, -0.34864754584068086, -0.096910278709658, 0.31297940096836757, -0.12687722063294962, 0.19000560988304976, -0.349183960016257, -0.42776462390764786, 0.29973486538012833, -0.2310562801629455},
    {-0.19128564277405113, 0.20914717452370668, -0.14486255342984689, -0.03462421391926459, -0.5542247395115363, -0.26014728485088057, -0.5639746216232434, 0.06985458327368148, -0.4532859370871284, 0.11653102643287443, 0.04294223452620847, -0.22155884940398257, -0.5039379486801826, -0.24565711626746642, 0.4731173958313338, 0.004381095879203639, 0.11141820672008583, -0.004215600790782177, -0.21095430869213994, 0.09540101821050023, 0.31637060272042106, 0.271592376651072, 0.009907832568596805, 0.33660610348041303, 0.3116781855969447, -0.45326573152229466, 0.33134707685275583, -0.053382065740151606, -0.44211086260601046, -0.2673825161663864, -0.39753497580609903, -0.4269867156001631, 0.49697118678824553, -0.5351188832124387, -0.2891949081638577, 0.331825407847308, -0.3360349366348902, 0.4404237759754775, -0.28653154501129313, 0.20881210448240675, 0.11858098276417539, 0.3269928635896357, -0.5119041528445372, -0.06189120526215775, 0.2760823967320809, 0.46981845661055216, -0.3933451661528793, 0.4640480040339539, -0.1830097214476993, -0.12388144114328183, -0.046505306689351766, 0.3054003548111147, -0.3357383027851901, 0.5457966888496, 0.19117761724280125, -0.4176790495865701, -0.4532164662561012, 0.32717163076638145, 0.12382473280930556, 0.3830076464931418, -0.26127685089759095, -0.14864025129846548, 0.5190382663943838, -0.07156151120317387},
    {-0.1467065031944838, 0.16025895312562197, -0.3386662338945978, -0.05223888202076683, -0.2773207360168352, -0.6407649942359456, -0.6058809159362011, 0.03339915185889196, -0.23955093162720037, 0.4126292810723271, -0.0545423608785993, -0.5990814969422806, -0.385311992217446, -0.06786093179136429, 0.43251241240528504, 0.13773368535364594, 0.32632667647352437, 0.28415281910109297, -0.3179478678341145, 0.005980681057727985, 0.6427049305421286, 0.04168833255681149, -0.3715828011227506, 0.44681640885717405, 0.3906819354292575, -0.6003238966530966, 0.5664549034083208, -0.37676828320202893, -0.6354368813160041, -0.2450771177887576, -0.4842301441975023, -0.49653024694888703, 0.37669074631232585, -0.46608508281086103, -0.45579853316543373, 0.4206211794177547, -0.5707489019392447, 0.13137525252393384, -0.24135572186036533, 0.4031657287146844, 0.2972447885386938, 0.5737447484841003, -0.4461270706883989, -0.06184107193059056, 0.3546560980297729, 0.5715197675892575, -0.5306455172540524, 0.23772452095727487, -0.43433165512136596, -0.1540857423642226, -0.08859393142432952, 0.4428812655327232, -0.6154657310567875, 0.5306005128916796, -0.021931040484917348, -0.4897243082843281, -0.2995293057724676, 0.2577889673749402, 0.14972965310052008, 0.2904432090504722, -0.1502444035726404, -0.4929018369357458, 0.27164632561146296, 0.01323906881222112},
    {-0.12356310271529243, 0.5235962231478113, -0.14869994732166159, -0.13291388607276583, -0.10628099208986981, -0.5735377707183458, -0.23886462150899676, 0.25289702131731623, -0.17838332301472323, 0.35701032470469235, -0.3054280162918897, -0.5028343341908351, -0.23454579386162921, -0.3057875328850436, 0.25206006224812466, 0.21922904474231783, 0.3333781120798943, 0.15189395683391546, -0.39448441401455053, -0.005465980225955807, 0.5007762601947683, -0.029300384667110456, -0.48652211731832246, 0.2870012361625486, 0.052376501386918434, -0.395860294840428, 0.42645866286716105, -0.3933418671490734, -0.619325206285779, -0.1387225234415648, -0.07247535692125473, -0.4356269580701457, 0.023955359043874497, -0.24980257688366947, -0.1787011618911728, 0.34678591089459715, -0.5533509354734659, 0.3015867071431503, -0.3137118787351433, 0.08527458879153058, 0.13959993705898088, 0.21187137201346357, -0.6192013275031937, -0.19333807817596568, 0.2206896880798889, 0.4541839332173569, -0.2710431931959441, 0.15420867365655166, -0.43827602921048103, -0.272412823928157, 0.10497396304776115, 0.34341186027767534, -0.49869946915045266, 0.5243924404058385, 0.28022549540455816, -0.3030822895787778, -0.4421581647116709, 0.12391906136630002, 0.12157413041999383, 0.34225900213418065, -0.1508732094607775, -0.5056882760721898, 0.23772493535875952, -0.0033328820454983014},
    {-0.40380087564530737, 0.4580963763618277, 0.03552124925209572, -0.4172668412169765, -0.3021610394215813, -0.47388358171189715, -0.534011697033849, 0.29445971673950955, -0.19314839762705027, 0.24366511511784247, -0.35191531140815274, -0.5739787787608421, -0.30574536776124195, -0.30513843678291985, 0.39224980744534227, 0.19386650202090408, 0.39224870664820877, 0.4062095995599654, -0.23686701410419833, -0.15717591455305174, 0.27228393237044035, 0.0487022645278277, -0.2278751573182663, 0.43000479797362107, 0.06459169648295893, -0.49693002051866936, 0.4857029207949934, -0.29414929280023694, -0.48355768835171786, 0.09415179881360028, -0.24354429564415833, -0.5974094447440078, 0.25276277323911533, -0.3911968850656348, -0.2620679121713777, 0.28519961346908085, -0.6199260451696083, 0.4223472386309372, 0.018297380361546333, 0.19332326007059614, 0.4753265823416606, 0.14451970013391502, -0.6216630022981422, -0.15795376433210626, 0.05992639480680286, 0.29027759374103396, -0.16964226432623092, 0.32954469003382963, -0.17577588038471476, -0.41191147694142666, 0.3575087700425489, 0.3666850601059881, -0.24529925730312385, 0.36269478897218604, 0.0660267962302224, -0.4049902291504486, -0.49376289582086685, 0.3907279579893189, -0.0006485616174673471, 0.3404116329325312, -0.08295913128910035, -0.3292048822556532, 0.49815766669423606, -0.3321769506641983},
    {-0.5248758318796134, 0.31669043703064925, -0.18752861988426142, -0.38209058167134996, -0.37120468033200765, -0.6306322798875749, -0.4235603444554513, 0.19019102046511338, -0.3006052897269807, 0.26367877560626, -0.39094048986338803, -0.3336904206537587, -0.5294403370530987, 0.08875802892910097, 0.2986639871280775, 0.1089331409048408, 0.13519692407521935, 0.33000679904943625, -0.2797949973410058, -0.24763663864887267, 0.5497157149403563, 0.21937977457096414, -0.5378630522178696, 0.3774764893359926, 0.2276076849342651, -0.6843291162679707, 0.25003804301805976, -0.26990240812468225, -0.3338268638548025, -0.18645606316736962, -0.38420379426269624, -0.4773629534171972, 0.18536746911970514, -0.1883639687095474, -0.2666164544506584, 0.3530185405320403, -0.5120109674036002, 0.571683835048685, -0.11275141881163322, 0.5177534956933302, 0.28795812485663563, 0.10177911451344028, -0.5690086644856, -0.18069083070640576, 0.12964937371858765, 0.4658021870916457, -0.4334532328790311, 0.5655322936568121, -0.4686746873401155, -0.18941773614293725, 0.42063436546055644, 0.47947540621835294, -0.5306130756410387, 0.49759822737220416, -0.12956947039740593, -0.29549795977411397, -0.30997621840162676, 0.29421449606915356, 0.0009525972797734785, 0.4294382171440988, -0.23653252399761757, -0.5030967947217666, 0.390642594394167, -0.52956640488573},
    {-0.34120630731021695, 0.2108156132176351, -0.14503979507681825, -0.3580754059780433, -0.17965949824078342, -0.4501590240150398, -0.4406214927577175, 0.20553779742215827, -0.33868961080076365, 0.3369156216578113, -0.21690693688696566, -0.5219293693975874, -0.5615637433926332, 0.0377579099104177, 0.027087737444021816, 0.05114905937284789, 0.3165139039129165, 0.005314083252871907, -0.187695736587579, 0.0716512127095885, 0.5751299048392811, 0.14013103578963412, -0.35253999572851863, 0.20307418403877175, 0.4927005867380677, -0.5887885652990709, 0.339344074998116, -0.09835011348789327, -0.34300025232221837, -0.07933527370786106, -0.5750639406380691, -0.4175270842552476, 0.4215986343077458, -0.2794349670767474, -0.49594907792348547, 0.21533677278522245, -0.435547442571294, 0.40355814772787674, -0.05167369108257782, 0.2918719760656417, 0.46647273278933976, 0.2942317663793851, -0.5686131401609776, -0.5325725610222071, 0.3634801279139112, 0.4225053996172091, -0.1968380743883978, 0.4594667264145479, -0.4677946206305128, -0.44232090542149577, 0.2750082721005838, 0.19077488426310452, -0.21564503580932345, 0.26122737355258197, 0.23963408542570044, -0.6075011344576067, -0.28330869120474544, 0.5210912964760124, 0.23943586335197195, 0.40207258467659385, -0.5504628220403653, -0.3729178319031387, 0.5285437039214744, -0.15551656275019005},
    {-0.4006495863013004, 0.46829077221214194, -0.3410818486989018, -0.22883140827496573, -0.3865167924958993, -0.3022229522928752, -0.5045573701248497, 0.4184603342924588, -0.23804932161897452, 0.2794622968606344, -0.19907689720163393, -0.5386625410218565, -0.5261595481751415, -0.23119135992632942, 0.1751541625591271, -0.0064571187524546814, 0.48035119865324016, 0.08082149388730889, 0.055610641078609864, -0.10481255818420641, 0.550017148184243, -0.10155535621867604, -0.33542174208315917, 0.4089092205141119, 0.48210258596575956, -0.3666764616579161, 0.3981887992533248, -0.4832973684176574, -0.5334642119870865, -0.23661442436099908, -0.40409390147598034, -0.43867263852362814, 0.4688667759933102, -0.10938107782492353, -0.21507512545133745, 0.163146841756682, -0.5341520168554846, 0.29608273088636006, 0.14136170722973487, 0.18966049215485145, 0.5272145130854341, 0.4598124328143553, -0.29737552638439674, -0.4026085272267805, 0.17565875945134837, 0.3141569838404654, -0.429129451547226, 0.37142895035740287, -0.3423339965968654, -0.2287160994164551, 0.45153852482524853, 0.520081758474857, -0.3726430759079916, 0.4408591942408865, 0.09533358786132283, -0.6092486725957861, -0.055646585167093476, 0.4472542773349186, 0.20108740115223764, 0.3444441477235941, -0.541618130583205, -0.2214001437299559, 0.4847500874245148, -0.10475022961980254},
    {-0.34974492257900486, 0.5355216831819444, -0.4632035373571014, -0.3295118548576919, -0.20578268147854, -0.29261038736065326, -0.3481596849030856, 0.12596954232774046, -0.46347043764492873, 0.3718146101001708, 0.18989488459759613, -0.31637803546868976, -0.5212142960627107, -0.086737578964485, 0.23346719574883823, 0.16068160941750698, 0.39643806794483444, -0.03811647747465378, -0.11857246829794486, -0.0855187335075141, 0.5124711973871332, 0.06188441650560424, -0.2381080914853794, 0.3115207469638275, 0.5475209543168045, -0.38182424674632, 0.449835642008081, -0.41203170773487097, -0.5342109993769816, -0.22272174996343705, -0.5157677910268749, -0.5298893095265259, 0.1537469639237216, -0.3304324510426626, -0.05669273052307962, 0.3870002773271106, -0.411701415794963, 0.31373864091894854, 0.137853517320088, 0.3785530801876438, 0.35084550821614746, 0.4284140796797639, -0.5183050047994474, -0.2553690646368093, 0.3290319260701511, 0.320967388972347, -0.3550316075908236, 0.48149687525867413, -0.24789021078311518, -0.1097284990831155, 0.3641290058881481, 0.5843206851293744, -0.32696585991467136, 0.4818905828616695, 0.39270522296589555, -0.601205224194176, -0.17780479710133004, 0.27281732965116506, -0.10323857007013654, 0.4563780747724767, -0.3758358128084455, -0.06690719155945866, 0.28000251742599946, -0.1788949494671302},
    {-0.5404571986037984, 0.2673408942902853, -0.41807795910871337, -0.41625031130422135, -0.2252136576475971, -0.4972885857406266, -0.0954062527532381, 0.13058947543129387, -0.5379846560219422, 0.47575336842628224, 0.19053534230734437, -0.26996052391302366, -0.09492477955724384, 0.13408243757676064, 0.06354243563254862, 0.12900776534822678, 0.06421506885467333, 0.24497974481658558, -0.30147956763983313, 0.22758564920488572, 0.21407757232877014, 0.06114217385384856, -0.5034830092161251, 0.6157859773004891, 0.2512248450394461, -0.19232477989579388, 0.5037521393931494, -0.05451545255279713, -0.496735832074753, 0.1122972206421755, -0.315212453614722, -0.3271721948959116, 0.016920790920996288, -0.3080214810102752, -0.03260710306872313, 0.4369290306387889, -0.4207735325998495, 0.44001662022538585, 0.1669378376913881, 0.3088992166631075, 0.23169532592543782, 0.32701277719619326, -0.6210924146887309, -0.37284909407874606, 0.1632488622310412, 0.4776125674626953, -0.5040060415876697, 0.5974051928250173, -0.18270999518755993, -0.2213209474743084, 0.16553821637485897, 0.5614160754754353, -0.33566298024911784, 0.4169919658505626, 0.3138260679825351, -0.5043363366003716, -0.24511615629901337, 0.5571824302229325, -0.08225291425193497, 0.5480154722321472, -0.5773027079300597, -0.4055660965039103, 0.3523128508124132, -0.05712241603786166},
    {-0.18394055822348326, 0.3325436499835014, -0.3248413613018448, -0.5448586620192005, -0.1371458914966089, -0.2707915893602214, -0.5116014723638898, 0.21279703503225106, -0.44890782837508414, 0.5305449841690943, 0.008680477386365477, -0.3257944656872462, -0.1708968937758743, -0.13109028262811356, 0.46528944264267225, -0.01812343826291221, 0.2669238148678615, 0.4054985185420823, -0.2898249918758575, 0.25984612078948105, 0.26850019334233055, 0.40592905594663614, -0.5498596477646682, 0.6942666988322812, 0.2202507168421581, -0.5697069597483225, 0.2481625113960453, -0.3355070952958784, -0.2999617235948617, -0.09331783760005118, -0.1856204792418863, -0.5026885116438254, 0.3086640664216612, -0.4309359249475537, -0.04253562197738603, 0.09759170697432644, -0.5918485056412371, 0.3825961557514393, -0.1558195888448716, 0.5453096847770209, 0.22586140274106525, 0.32165481291191916, -0.5594058905567498, -0.1811018784989825, 0.49495976809377124, 0.5198954557221804, -0.2670506704577843, 0.36061815252753504, -0.4534370823603545, -0.5556719607828325, 0.3662582140871872, 0.5359567805754162, -0.30925284060633496, 0.5489316348575866, 0.16132001795572423, -0.5821697461839108, -0.044288549320924034, 0.4878674908471307, 0.26297160795902325, 0.4502835130590968, -0.6057937740276932, -0.2513375755386534, 0.36057573663395515, -0.3515267479012115},
    {-0.23244653723055028, 0.3358964850186054, -0.3010473351230624, -0.5760500968703204, -0.27315194782408186, -0.4323753223391454, -0.4759410302492741, 0.24540685482118152, -0.35620826405303974, 0.16136389423101316, -0.1148645504665722, -0.39795430304097057, -0.24258731577129006, -0.3321665607324938, 0.33698274879590867, 0.12228806389914433, 0.2677176239906116, 0.005059909002134157, -0.19329440792763175, -0.06759771742127696, 0.20121450432906623, 0.323536292209278, -0.2454904796208611, 0.5155847039184697, 0.3584799314121075, -0.6176792290280259, 0.42016955040858683, -0.14350631310497144, -0.6607547429792169, -0.19201341624625784, -0.44618277096964315, -0.4642618719385752, 0.28729314500316544, -0.3791773784016191, -0.1659257697028234, 0.09093193750224571, -0.2554982739418278, 0.29148138030871273, -0.38834802274653685, 0.5170462135390972, 0.2495580966731216, 0.20984768001001847, -0.6396022615120363, -0.2944670383299797, 0.41357353018463006, 0.20841364781655322, -0.31010233062539044, 0.3614927902576977, -0.2629129416287003, -0.49309444232911065, 0.13017371070075331, 0.1515688972383608, -0.24103617137660946, 0.52332441397136, 0.31786370632137123, -0.4619211732364126, -0.3788000091982377, 0.6038000056092562, -0.07849064807420589, 0.6160314643087964, -0.3713845444413231, -0.17840512191198532, 0.4925347421884366, -0.5124367741850587},
    {-0.443259677878761, 0.3655877172500828, -0.5366238823064995, -0.4019622050945017, -0.4114955073648802, -0.5097668512505882, -0.1327844771362907, 0.411106226901502, -0.48714579319218165, 0.019071297477692786, 0.14584627393765787, -0.36437132733448063, -0.4575361107244462, -0.2237825410899897, 0.3619327535389207, 0.28146904864231076, 0.18085746151024307, 0.07874822391954607, 0.0854137094041999, 0.10313812861497827, 0.5031434950604611, 0.15906569358973152, -0.23193719363679624, 0.6598947183296021, 0.41257322952558273, -0.5351697927058102, 0.4008229802620455, -0.24605373733974195, -0.5163030202443997, -0.40220619569701943, -0.4819941134537337, -0.41340574687544723, -0.09038717657844902, -0.5503022426316421, -0.32407644605704666, 0.4794136673263914, -0.20612029537791965, 0.40991176374789706, -0.2434153754117434, 0.49867107370644087, 0.3708494463020115, 0.43185304930437113, -0.5235209141599414, -0.40964343264947156, 0.4008200026832074, 0.40870585268087084, -0.4289517461831585, 0.4160794625218572, -0.42669841485234755, -0.48263786523269625, 0.35870570505813626, 0.30437693323064163, -0.4083634162614019, 0.6469464095936711, 0.4303367671412091, -0.523089537310437, 0.07799195468991073, 0.5945072376273813, 0.08999256430682127, 0.40129532896423625, -0.2881652362004121, -0.036192775247589286, 0.5858282358653085, -0.3369099231106722},
    {-0.10291928220618289, 0.25342984141500635, -0.5525789966879754, -0.36826074914547313, -0.41198468518753667, -0.34286937471819934, -0.3615147150875967, 0.13855720107421765, -0.4504329741216768, 0.11535877532221069, -0.041361854539482865, -0.38003923436837234, -0.3781162025517042, 0.09868038831111474, -0.042435192551617436, -0.09649981991093462, 0.3011756893186398, -0.050938868900196575, -0.39778691321240983, -0.14627061815730408, 0.5367708117546943, 0.3224737807611383, -0.470450372252279, 0.38536868377796335, 0.4033733539148181, -0.543401500595834, 0.49108109956461693, -0.3068033440192881, -0.5244684397249838, -0.10225711484029941, -0.31428802705008974, -0.48635046383149555, -0.15412872950239287, -0.36127229528432175, -0.5479200998246011, 0.4558459892645003, -0.36510220683669087, 0.46130895178934395, -0.072333151898537, 0.5127562056062736, 0.3258706361859969, 0.2051897640755342, -0.36420684521976654, -0.43571948478409595, 0.5290420211553545, 0.5539588221991985, -0.014373392364758163, 0.5928826360568161, -0.40201392808468356, -0.5472701549336102, 0.32163760791140955, 0.12451279535738222, -0.6143629836804186, 0.5558486014542294, 0.07378065756753656, -0.6712698325787643, 0.10320580944520591, 0.6009608443787926, 0.12348493976048333, 0.25705273613349827, -0.3081134381099388, -0.24380596901637835, 0.4025683353273026, -0.2994557655435177},
    {-0.33387264318894244, 0.45376137601472566, -0.5890176660066159, -0.3719678973780969, -0.638237635753217, -0.3799681278783579, -0.5589620764427351, 0.08559637088935758, -0.5743478693339082, 0.08025848705980326, 0.20127179230802722, -0.6360006594110733, -0.4999745910101241, -0.1809416197784444, 0.06682042458395278, -0.016036977122230397, 0.39477501699226175, 0.34794289807784595, -0.3017982674823216, -2.7093069939345046e-05, 0.5979053006568789, 0.17576071105210717, -0.19011620921764266, 0.5530407525568956, 0.439913500794317, -0.5216887640096556, 0.3054993772275639, -0.3409017309407534, -0.43974477445874827, -0.23281715407723555, -0.2939213453311067, -0.6168499697676217, -0.18469861981710384, -0.29103649618858246, -0.4697794166809496, 0.054512611099191983, -0.28279185833164455, 0.16109238606534856, -0.29738719957587045, 0.2694105422217087, 0.5056240267130693, 0.47192799609904773, -0.6340511406102805, -0.35940699671481663, 0.31510872627348235, 0.22775883544598022, -0.08625577796314665, 0.2832365600078966, -0.08109445663005946, -0.4024943929992773, 0.25480787177085285, 0.18057976338673165, -0.45883034091807573, 0.3801922230997508, 0.0849563332225593, -0.649849268834697, -0.15184536852010178, 0.2303470136718507, -0.19639892503343542, 0.3135088793955667, -0.5297977383079499, -0.18824185151725253, 0.27146933080918845, -0.051375923126259423},
    {-0.17038445254812573, 0.558286212848753, -0.5310954618082799, -0.5698176709741992, -0.20080562561348256, -0.4873425664441272, -0.47734034173813167, 0.3733103686822259, -0.34757327290115436, 0.301273035484878, 0.45004276069820953, -0.5930990228135872, -0.3029156273056473, -0.050119295905438656, 0.08025441228337449, 0.2202023882945649, 0.06424068867892108, 0.2850003286189401, -0.11913263227313546, 0.0028785788176312315, 0.26810280622546456, 0.10821430173447462, -0.22232606221342308, 0.6556176678977116, 0.45482410617059443, -0.4059419631578986, 0.4928490384337661, -0.3705778076316378, -0.34154500537891147, 0.08175652555799334, -0.21920450138802272, -0.4196000471133338, 0.16910236394475286, -0.5909215898040745, -0.5162968556269866, 0.14550435373660178, -0.4935633842404449, 0.4388166753848519, -0.014732407492645658, 0.5471411216551206, 0.331787450538778, 0.3715030353437618, -0.35906044520895347, -0.38260970523119703, 0.4519391945323083, 0.5620918278003891, -0.4196993216403289, 0.22351495161172452, -0.28899176153330347, -0.5915545212236769, 0.2728872085114032, 0.22209013249122536, -0.2573219526605783, 0.21470557800866794, 0.35087106353084774, -0.3909858720098751, -0.24951779145161485, 0.34516561162518483, -0.21431173356726008, 0.37429893017304167, -0.5033578064598099, -0.30892832588808716, 0.49250096402655785, -0.08879235390991096},
    {-0.4148931804778103, 0.49626025551202885, -0.5067612722715957, -0.2983980262655058, -0.16554047758293508, -0.33506142442528836, -0.33639127549273656, 0.19446805209633003, -0.3548917894961301, 0.5024547179206781, 0.26438671599952174, -0.37847473435493945, -0.4173346089399556, -0.2189540432795409, 0.12247329577392578, 0.07790468136849682, 0.14513193428340565, 0.208962137852095, -0.07150135071133679, 0.1453005200345917, 0.5852974609847474, 0.06628874150765332, -0.12169981189081763, 0.35083913516527254, 0.22582086724986725, -0.4785919978644275, 0.26696437035699755, -0.16240326738718971, -0.4118268251895277, 0.06122342661872724, -0.5817966268127397, -0.5893353010298542, 0.1446884653595265, -0.388989783339843, -0.5851016447528514, 0.24696013278538867, -0.6080887167342397, 0.21062752359649473, 0.18399857898490798, 0.5366364624721442, 0.22581014261946103, 0.5231996209137337, -0.26018859677397643, -0.4123957282928732, 0.3798096708616767, 0.29960435372783495, -0.4449957898567927, 0.3201039806276207, -0.02236554188106513, -0.5182429022110681, 0.4876204418925426, 0.27190903659627397, -0.25631571808922854, 0.4887911337238505, 0.030587240049207393, -0.5377127503077651, -0.19460860477636321, 0.4198478136372941, 0.11729230470668825, 0.2808886064526326, -0.5937666604845147, -0.2386375239630583, 0.3675253920408085, -0.281065162350391},
    {-0.3779186156698071, 0.40305240205085247, -0.3186892019873457, -0.5325637933209794, -0.4074108305903599, -0.44614950402126574, -0.3709455053816184, 0.15175508008690913, -0.594717368889187, 0.4253893922247305, 0.24674989508552014, -0.5827126718536946, -0.2750851880027315, -0.1317716946619119, -0.02830237309720762, 0.1855618099108649, 0.4979486482258996, 0.2610334984167645, -0.3426941189509058, -0.12241942794232094, 0.5993103064209323, 0.0692198615953924, -0.44987435267837017, 0.3515912439186375, 0.4931568750064882, -0.5939408563516031, 0.40177544611081006, -0.29504080112455777, -0.30414977665767856, -0.12603355535677715, -0.4795664488429335, -0.5616362773219338, 0.42987419912379304, -0.23010871517983258, -0.48140629410893254, 0.4562607365200141, -0.5330728427617231, 0.29054295252918694, 0.10743242704624667, 0.3460274054936995, 0.498338964540847, 0.537494004294785, -0.4050261096142759, -0.2010566964475445, 0.6214023919573626, 0.3430253575251234, -0.30610957757803753, 0.24774460266162696, -0.09973120084795585, -0.27788800499118865, 0.30164727205711234, 0.34038949898676957, -0.5236959282404993, 0.2869425238327901, 0.024703742402544516, -0.657890365755256, -0.25429622266738605, 0.4233191705807747, -0.056355757227179414, 0.3065277267268559, -0.12912386282752653, -0.2691058194433191, 0.44576927079104195, 0.07303186606910339},
    {-0.16129869341164793, 0.1884009536923427, -0.182341304978404, -0.453163973628639, -0.380756271030128, -0.30320792388238443, -0.2748936389822428, 0.3398592279180363, -0.6007536351704018, 0.3549375623882884, 0.350448905636713, -0.4184048333269662, -0.5149604162016441, 0.1445553760664793, 0.20288073158183087, 0.30405597651185273, 0.27455511586843245, 0.2041209561327661, -0.2799028011483586, 0.08588959746067297, 0.5151074243534245, 0.27447903983198946, -0.39282864483847085, 0.6771296213752164, 0.42701578367407594, -0.5266022074635681, 0.37348897059509173, -0.42855429789967797, -0.5494561096928906, -0.0541975313040305, -0.557473569166314, -0.45015941369288887, 0.3351745695189705, -0.3605760406182501, -0.2217188247024372, 0.426307319220417, -0.42414291402336707, 0.2745578445361811, 0.011888597069899145, 0.32548239067868756, 0.23934231393628239, 0.5245268627847192, -0.2607619334212916, -0.4465641364340447, 0.37598162646961, 0.4415885139949543, -0.546347498012822, 0.3173550561120994, -0.1471956423106827, -0.16415841139670637, 0.46510793732104516, 0.30629660426843935, -0.5128475832128916, 0.32051405626147444, 0.2427388191530844, -0.5920144331902771, 0.014888019762584973, 0.4503792638881841, -0.18755578815814553, 0.4105759589071749, -0.2500648516877429, -0.23465105178164009, 0.41667018036005166, 0.058348115554566767},
    {-0.5697394637324636, 0.3828515939409729, -0.08933450437569282, -0.5383003267440416, -0.19093747078029336, -0.38282302998009465, -0.1554958406707678, 0.05005994129987356, -0.4232795949571621, 0.3181359342363292, 0.094061171637493, -0.6431645273685314, -0.3519821860380038, 0.08274010046148726, -0.022251525956770758, 0.273203773024844, 0.31172821193578143, 0.18528864780375937, -0.06478936063107626, 0.14318301659416743, 0.30529972460460464, 0.14957855518546748, -0.15098851729866095, 0.4055872800772852, 0.5281618327008958, -0.28948122010150756, 0.3769534230392984, -0.38974212450751483, -0.29698373899749403, -0.17873803729869892, -0.2662996090321948, -0.3786268689862511, 0.4082361147721912, -0.45199386248179435, -0.44108774326237177, 0.16230263767388312, -0.644716255303412, 0.4188586962314082, -0.19016103935163328, 0.48286516684214037, 0.31741646231478315, 0.38585667503950777, -0.5985285114306939, -0.41031473037037675, 0.5437812798245613, 0.4451117437526816, -0.3479690818718353, 0.6115429641260118, -0.04752490763324448, -0.46054163369243245, 0.4014646946241734, 0.21827822395701701, -0.44055670930157603, 0.598802572496964, 0.2910409168369684, -0.5832989639890055, -0.1405780702183423, 0.28963859860512603, 0.22568787209526545, 0.40854816102659036, -0.1913096824209803, -0.19195470312071525, 0.5837870211378479, -0.3386223640084275},
    {-0.46692648462631325, 0.27108890088763565, -0.163468487984909, -0.44482246927405206, -0.4681205174336423, -0.22354291514450536, -0.33939042783630213, 0.3159948446373448, -0.6147644154690429, 0.08546193041068079, 0.4036199734513566, -0.25725345929347543, -0.5404936071685518, -0.18805738041416795, 0.38382057201332187, 0.043745858547329916, 0.5090165822442033, 0.29050896059520737, -0.2459512691417046, 0.10507629054411419, 0.32088027567566935, 0.3610735800784622, -0.2918773482040623, 0.42551716107172066, 0.42994251821316015, -0.3891846890745223, 0.533436222436438, -0.1465998087140384, -0.3612128788168033, -0.4125297385560074, -0.3441530907531753, -0.4630141798431763, 0.29602048055741836, -0.4811487601247972, -0.28547568218169095, 0.5529484891529919, -0.4857475363935695, 0.2539134163266839, 0.10962396436957189, 0.3903772166118159, 0.20232903462990834, 0.5064943986933078, -0.2302825564712496, -0.2562536251120536, 0.5485922875111849, 0.26116308969501795, -0.14237002112387698, 0.6424890782836722, 0.07312500630988085, -0.3935904720829758, 0.23456954182279213, 0.39755793408588325, -0.6120049341912432, 0.6695306335498675, 0.46900361825706266, -0.3967836330510708, -0.2375378191545691, 0.4600715749128326, 0.22690142867091778, 0.3466795733827204, -0.4291167430699034, -0.17486229618494437, 0.536706836419796, -0.20714272420671045},
    {-0.3666973676275004, 0.4617979567869965, -0.5366847610310234, -0.559070497661705, -0.4645332573147257, -0.41830115006716767, -0.1777081310707659, 0.3527873380369473, -0.636344139992827, 0.419978682976167, 0.2572683414249632, -0.42880491972196505, -0.6272464682540776, -0.16371415687092075, 0.12803746757134005, 0.30907176529055436, 0.1569227210541855, 0.2834446273207458, 0.013366652580492617, -0.08055500178184595, 0.48903717814336134, 0.2399903187939627, -0.15624542776138042, 0.7176614404231402, 0.2374594372992276, -0.6387603404468231, 0.4895423568607936, -0.5192196995421746, -0.4127794178443677, -0.37432933221976955, -0.5654831581882631, -0.48979218277262576, 0.016718014640819828, -0.535146683317678, -0.32801031008867493, 0.33855781756582565, -0.6363396347825444, 0.3537351237369849, -0.12025309470564861, 0.3624782855946174, 0.29326556017449434, 0.5431206333494456, -0.5361257564542874, -0.07351269611607719, 0.5873662080320645, 0.4821356408552832, -0.28379157543530326, 0.5237392653184644, -0.08333062885435165, -0.3277997577648382, 0.3710466480407186, 0.45158337521347675, -0.47758051389749606, 0.5878530811167857, 0.27733821203581077, -0.5535070512890597, -0.2097135531419093, 0.574023000980997, 0.3262796084779908, 0.611522703468461, -0.3699367250497693, -0.22865233820435346, 0.26168202931501794, -0.010243225500222507},
    {-0.2480735732482354, 0.5726280341203089, -0.2219161514462076, -0.4490325564861778, -0.575332272822351, -0.3160710310419205, -0.40216775320400333, 0.42842808511419006, -0.49829533397280873, 0.10402170177005156, 0.41310248252932935, -0.4796071663985151, -0.344655552682842, -0.14274549803242662, 0.37911605632592227, 0.445360925086467, 0.22957316004630784, 0.3827871790667502, -0.26432099593214076, -0.12047965957148883, 0.6035110973299105, 0.3981669586052642, -0.27590260159311775, 0.5367385832535368, 0.3233838013940338, -0.3839532684400412, 0.3580139173199544, -0.3363895215679201, -0.6642228969674999, -0.4156639612173268, -0.4029960025679962, -0.4115796224235121, 0.35600006584574667, -0.3013119765664131, -0.17531800071509174, 0.41272083935289844, -0.504881425771212, 0.16451932764020724, -0.25635815222136504, 0.618388107124455, 0.519036256458467, 0.6234332603755928, -0.607674106521337, -0.09041684084617647, 0.36226358149623816, 0.24256713482945452, -0.2263247906484691, 0.3894996597953495, -0.14182050362362056, -0.23401277768814963, 0.3858108040451314, 0.22154904628255326, -0.5356493996798563, 0.42311088259703805, 0.06861745235492034, -0.4035345402454555, 0.0072526405550260185, 0.37322573758048977, 0.20745154948680158, 0.48081502853130537, -0.27042103192694206, -0.27240778817057193, 0.5279431558840308, -0.18775213153434783},
    {-0.1624838982207939, 0.5312559860695469, -0.3613771763991975, -0.5443759250610269, -0.15540576207569534, -0.3641500662539401, -0.5192446814774988, 0.18037060801530666, -0.49414736826734224, 0.2881005420375225, 0.2738973900763046, -0.21871789258352117, -0.45783773603420846, 0.15652427972870583, 0.20735276281030707, 0.44464674674931703, 0.5728721909356206, 0.32041499649044564, -0.14598359745898976, 0.003488330868837077, 0.4947139359012561, 0.2742637419239895, -0.2866348896049415, 0.6711681273355142, 0.5585207645006034, -0.6412179133436307, 0.3785775159577274, -0.3933659963739099, -0.44619652808304633, -0.2250331874578925, -0.610085854680633, -0.40887899348316586, 0.39221614380642306, -0.204744399762404, -0.36936827443653136, 0.3017631506724603, -0.6505180996506685, 0.22977382715166578, -0.23594235886937337, 0.48068073589704785, 0.37803088704990645, 0.4627093549707885, -0.3727275202603586, -0.11146509305407165, 0.43217045268998905, 0.49649169353244904, -0.20795311057562596, 0.40656854906213125, -0.07502851480310353, -0.24799018120948524, 0.25386923758354984, 0.3037841431336883, -0.6531539715258683, 0.44735131465645067, 0.05294112943869104, -0.3014952646411004, -0.39897188760201324, 0.5247300992694293, 0.09373340194191555, 0.35922982009169035, -0.4676078884172813, -0.3888059819236922, 0.5856640402299408, -0.33501723585683635},
    {-0.24868434672203946, 0.5763934842333175, -0.4663767033672833, -0.43777451110583093, -0.3526191708103851, -0.5651774446226138, -0.43312771394150246, 0.3510594005990263, -0.3653569158426388, 0.29784308362694956, 0.17166753635833823, -0.2778147844701937, -0.5709218775331013, -0.042729679788951064, 0.2673476988649903, 0.1385996413301731, 0.621606709828261, 0.36305067496670246, -0.3295972070504968, -0.1647921409491797, 0.39076312366202837, 0.18499885648043296, -0.18728190027760733, 0.6375107629498541, 0.4675637940851325, -0.639121148606274, 0.4157628799413696, -0.5530634650330855, -0.5399571315991791, -0.45020960581571673, -0.6069642784439224, -0.4480751987748, 0.3943226419897299, -0.4203948876565347, -0.4570293831058678, 0.2258779351592025, -0.6087127165687389, 0.5063421342800765, -0.318250407650551, 0.6166106238778376, 0.4763281074806408, 0.5116149384153418, -0.4827515698142961, -0.4533466752008518, 0.5807055783693368, 0.2330523824998838, -0.3379313037192884, 0.6244919803401644, -0.2300181454356839, -0.39645347086043253, 0.2228284992968955, 0.4948214509250419, -0.5376246564339779, 0.4705221917196668, 0.27660601713197636, -0.36937372303964194, -0.10199600254830708, 0.5495559112901138, -0.003007718378005454, 0.5707199393654386, -0.43138256439242495, -0.06068704858934497, 0.5769424202526151, -0.21413640525330058},
    {-0.46809709766101254, 0.5309749622036146, -0.2595190044867012, -0.5605855061824796, -0.5764319981259637, -0.4335089576863105, -0.4823185623405075, 0.08558366641999877, -0.6145050843145082, 0.3657947347753704, 0.39316683677176334, -0.33646321254384154, -0.4753768151524107, -0.1855025545982812, 0.44202300119671145, 0.21132324976068326, 0.353882347426429, 0.00790339667715415, -0.2936721423316794, 0.11346305564034179, 0.55606284237145, 0.012827470179535772, -0.41954308938220974, 0.439283685053605, 0.5128395942857811, -0.5253919361411225, 0.3526517865830366, -0.28033379534179675, -0.49583225504913114, -0.11377481866898576, -0.2578456143172653, -0.41818401243060804, 0.26904729422463813, -0.281092506267944, -0.3573386297435644, 0.16634754387018208, -0.48159091166644047, 0.3046010487681263, -0.12159363755326894, 0.25264524731496624, 0.36570833620002835, 0.464542137655974, -0.3935018689189466, -0.4435544883943516, 0.526957469733245, 0.5754531833121037, -0.32281660369739074, 0.5503340575992238, -0.126135567344145, -0.4501931760273875, 0.08455064341153684, 0.19369810396134585, -0.5211556449728254, 0.5193925765849915, 0.25156976551476307, -0.33340367064224735, -0.303907884807478, 0.5899303639161828, -0.0089686435757795, 0.5803156051786682, -0.2727142063809361, -0.2884447690761101, 0.46106127034233213, -0.35053315471166346},
    {-0.47783649626001184, 0.47711593638640354, -0.31200314705262394, -0.39855697925574257, -0.45288911731265297, -0.6516809429058367, -0.647112154512171, 0.419870101818028, -0.532947270554089, 0.42087219994713365, 0.24837257391745238, -0.5552947276694967, -0.4305156292169383, 0.09284359657973788, 0.3591906885070143, 0.053165980433646856, 0.4275592000785989, -0.04042911606859491, -0.2021059401698458, 0.07850833705465497, 0.430764488601799, 0.3697978175576735, -0.48266547184392333, 0.3595997665159426, 0.3357125474258079, -0.4516525621805181, 0.6064422699403463, -0.10027806677227459, -0.2627121341113444, -0.38240985668357347, -0.3602693587313551, -0.6517390123735805, 0.17425735128919648, -0.3815653666298133, -0.5152592136313165, 0.32745299331055977, -0.6750396982375747, 0.3622700576063445, 0.11944473474556376, 0.5016762694905719, 0.16815338964157248, 0.4202109941785794, -0.5617856932785161, -0.32241407426221164, 0.48291016819789734, 0.6122670103956949, -0.40926932219907713, 0.3702100823000146, -0.2423350866520699, -0.3429772204808666, 0.045695146657188976, 0.37722513617142306, -0.6104702614700225, 0.35178598226754665, 0.30445410604847073, -0.599052233708517, -0.3671856672378016, 0.3004938234196532, 0.11726357898178205, 0.3552358247777299, -0.497928498066823, -0.3928509271627054, 0.2982921901850257, -0.20289626392588603},
    {-0.24902179233517238, 0.2569128417709484, -0.2933441686169671, -0.3941035872494833, -0.5265443531796544, -0.6487313865519422, -0.44926935931033307, 0.3783045534466936, -0.6195640452285045, 0.09346889270825028, 0.3187425353196767, -0.6405273038442174, -0.3422668100054962, 0.24706776166375008, -0.0015185659611317145, 0.3329850256182651, 0.4054927405867355, -0.002381918314394572, -0.23968680893710276, 0.04235377884552689, 0.37587437825617875, 0.3068044005742731, -0.3874381934453235, 0.5334640482597918, 0.4421754349311817, -0.33236910586974866, 0.5005171380037482, -0.18199916883204698, -0.45097419958781065, -0.0757250787341003, -0.41476602164691573, -0.4328733493993864, 0.31602651826919326, -0.5504339477608847, -0.5833081054256383, 0.4585726032061633, -0.49111960374433605, 0.14027881276466128, 0.04436868454247816, 0.3144491304985265, 0.44704521768828104, 0.6208238013037042, -0.5081830285705948, -0.11681083313827001, 0.5975448312795265, 0.5011446945554557, -0.20540439987938394, 0.46026508104632674, -0.005519761132425506, -0.26824123522211785, 0.4223435221360516, 0.4287706239888891, -0.650856759710853, 0.5098301464455719, -0.052749572613016285, -0.46691384305983163, -0.047039831227422134, 0.3963562879857313, -0.13587786702368423, 0.24331053215695145, -0.29905949138810217, -0.21258145296109043, 0.30082342867455275, -0.09817182354949686},
    {-0.516654053557034, 0.572468735372965, -0.49777453298600505, -0.3904418203290676, -0.2877445950651875, -0.5137888456324566, -0.42289654339449284, 0.3069879120917569, -0.5532368877765077, 0.14850844171572825, 0.149166507672653, -0.2979008041440892, -0.4962986323811384, 0.20445832368682237, 0.20831683400048656, 0.12068884051162086, 0.399071125706391, 0.14021119599649473, -0.05968254327619071, -0.0840165010619539, 0.6446044729911521, 0.28543862813784926, -0.5329400826249481, 0.6918203650856174, 0.5596395392490703, -0.5772387020337794, 0.37081910448951394, -0.4498247741424651, -0.28113358040172315, -0.1852725613735727, -0.5166910035261105, -0.5208175298539413, 0.12026359427241207, -0.6285094667706598, -0.3193753529558179, 0.2790205305983436, -0.4339294728688959, 0.4127914083859837, -0.1295666115667808, 0.496917193519708, 0.4297755826270097, 0.45090665968213506, -0.2886158465480978, -0.295224889850441, 0.5075453638174391, 0.2667837730117531, -0.19529130763670244, 0.5475808614230474, -0.2605924606384791, -0.35135070175266286, 0.46480933624783244, 0.31705731187834446, -0.6724269691606678, 0.5059587099891426, 0.31030971023703185, -0.389589195127277, 0.07126198275885422, 0.5861475134134736, 0.18372003341930332, 0.315010343319602, -0.3085939127872258, -0.33735000125000103, 0.28031043704267583, -0.20070735841840037},
    {-0.13550042083682473, -0.22699191415213585, -0.5560512437050521, -0.09747520337442082, -0.12757730210067336, 0.36641721215329776, -0.14264369916549982, -0.4388593086530566, -0.17713972369222256, -0.5453299105221754, -0.22950272563457563, 0.004835871983582562, 0.02757559646714729, -0.2846334165234348, 0.249748342270539, -0.5336496990852647, -0.1181904635910896, -0.2776706759489437, -0.26081149782363944, -0.6135072741891623, -0.09944026462974408, 0.24504542295098772, -0.05361845460804032, -0.48642844445561034, -0.2144711313939569, -0.292625393443631, 0.036753463261839175, -0.25605305863023003, -0.22432854854080264, -0.1976318222174486, 0.24752870027401244, -0.18423952373742855, 0.03368418652814915, 0.01115087718408752, -0.038917610078392645, 0.13257089918091663, 0.16059068415436026, 0.004713418844383547, -0.29525950089557546, 0.028490843106415732, 0.2353170288909281, -0.3052209001599982, 0.1804978670144758, -0.01947114630984654, 0.12850889349959735, 0.16540980056936422, -0.1435165957773769, -0.14896276862372848, 0.08456002491403512, 0.04929003789344319, 0.08573275545724289, 0.05432339820499882, -0.059227128049626494, 0.041991373021383664, -0.2846075412455812, 0.18914864114845248, 0.3783008801424889, 0.005001427818776859, 0.37728965991956903, -0.2979767995041613, -0.5131046636843996, 0.06658350618798155, 0.2002540497395876, 0.07891237824081966},
    {-0.005621982714271255, -0.24633363356594928, 0.28501505572105845, 0.11685987491605382, -0.11127099464369818, -0.14438531327994764, -0.21418377428137955, 0.1223049313976521, -0.15989934082724494, 0.1162431689247301, 0.04469382495077414, 0.06914070952565418, -0.38006545538220793, 0.43143655529930475, 0.1833604800612599, 0.15751511226811638, -0.04251520338722725, 0.16929416298662792, -0.1413700726994283, -0.10816821237809539, 0.31111996971199246, -0.02428789834546814, -0.1622748658894826, -0.15845467042821093, -0.07186991853809667, 0.15849416191471333, 0.21642877411630532, 0.08561405181637854, 0.02580783688172105, 0.08092733370292965, 0.14523161138435306, 0.09405125564512777, 0.06752409849789415, -0.13814956021440647, -0.21538472937186037, 0.10593076484587473, -0.24713450262511433, -0.06630183496529128, 0.06899288496113133, -0.1735046364363889, -0.12371770489109496, 0.14340330977603818, -0.005387439492535152, 0.050526896459978134, -0.33287719651519615, 0.20904670506553244, 0.19881459234824986, -0.11892374459397224, -0.022962530997582272, -0.17558796652736078, 0.2532889737268407, -0.0927055404314129, -0.14009181981432922, -0.187006165936341, -0.18164917114590654, 0.0896100089985069, 0.0479304160520197, 0.27385374639869237, -0.23837037704009875, 0.07334287465706339, 0.014603023602880226, 0.13476224287261018, 0.04311243847545262, 0.038330562710413484},
    {0.059096910587897226, -0.23070804220381666, -0.10946097088383676, -0.4644309656436631, -0.33884778261226456, -0.08559856516252987, -0.3226538970162426, 0.030935010582509182, -0.1586862850367571, 0.04952014706412978, -0.039027313153891824, -0.0730537394339452, -0.4075050845701854, 0.27398042941050366, -0.4874918325952159, 0.27790713326165334, -0.2136518898079102, -0.35206051650190845, -0.5783492334190293, -0.3359974025594097, -0.2544673013350518, -0.29708324831872274, -0.47607153721485795, -0.3267850799742735, -0.3302298860163465, -0.24186446767840852, 0.14667621928628, -0.11022072646046753, -0.16392066045431886, 0.0845009861735989, 0.3905049651426156, -0.2772022561896414, -0.2526250053201274, -0.2135526260621368, -0.18517129327804124, -0.16061653091287903, -0.13178348615718297, -0.006848196521083684, -0.04642932824187968, -0.3222630125845498, -0.3417936098040003, 0.22795667948308154, -0.10208768975455078, 0.015228630657823922, -0.20072102573547154, 0.17436297318657534, 0.1128908334403271, -0.2330736715090567, -0.014853301127719215, -0.2322969397678157, -0.25606940312248283, 0.16120046008197647, -0.41089549223288035, -0.07536700515960183, -0.3138129455586879, -0.3477453565684459, 0.3219164105885395, -0.43642756380281394, 0.06074077107627523, -0.420007882860602, 0.08978025183949319, -0.08107962984974677, -0.18075520041538432, -0.152299691655607},
    {-0.41247197392714363, 0.12461578477040063, 0.008634977644157136, -0.024540261232578124, -0.07534963679123957, -0.1371906651964493, -0.2439659758464419, -0.11547335738965248, -0.0759780191753057, -0.24604270473032425, -0.10058065442736426, -0.13505612110328064, -0.1651445451467233, -0.04934829099543825, -0.014775976876429375, -0.10301380533099516, -0.3453693665191657, -0.3232175026891902, -0.5325458145567401, -0.3826157570755205, 0.031037319554303562, 0.08932970572468245, -0.29984954136100345, -0.027552927408891786, -0.26884404810278734, -0.424427872462787, 0.10893402071218253, 0.06240836560548069, -0.4659888052379695, -0.34847461041111766, 0.158372275991837, -0.16340854239684763, -0.23874036390541145, 0.0910954610764414, 0.07325605053094925, -0.31088780293023444, -0.5199170768752377, 0.19504498752898577, 0.0770643911792504, -0.3479120297354997, -0.010207704208311434, -0.011402111816125448, -0.05181575342389699, -0.20454621293767236, -0.18235939103556484, 0.32584481923309877, 0.020445337181054308, -0.2624122243337466, 0.21293238992985336, 0.1955173973381885, -0.008093552947623475, 0.2905610327207239, -0.09160932742534224, -0.1495035340782377, -0.14489851398287823, 0.10272285606277139, -0.057625130902181784, -0.22710299786123841, -0.13285718276046424, -0.25167004308702184, 0.06922333988936831, -0.1942194065223287, -0.27830125212521084, -0.21039939659949825},
    {-0.25163773741252127, -0.2875955157819161, 0.25775614918588347, -0.02845683584203051, -0.11490384225709083, -0.21494927019293128, -0.10343639520044796, 0.2472390669658345, -0.051236542790167705, 0.24125697332039825, -0.11419771213499037, 0.3447559227964316, -0.5242393235023646, 0.4868441632705999, -0.2802322629477018, 0.3060599315224389, -0.10671582609415295, -0.18632826029257119, -0.3095175827034889, -0.09761713300859105, 0.4145381453331076, -0.18549843272026326, -0.4803586397587425, 0.3547794198709488, -0.5096248583960773, -0.3097160142656676, 0.07954526600500869, 0.3726561439812653, -0.21103204472800147, -0.09198926448284607, 0.2879360924511573, -0.2932407813835287, 0.274462876954187, -0.3035252970858096, -0.15161487674555127, -0.4255028694280971, -0.555685785856423, -0.0398447634877112, 0.26060150309892277, 0.09931512601517808, -0.35650889111113165, 0.30397224308357745, -0.2668550533735332, 0.2250478695231802, -0.46400806656151605, 0.4113727845153546, 0.33705654463630735, -0.15453997368196914, 0.15556098156036854, 0.09560738660083806, -0.26115401751974515, -0.010902521178883866, -0.2350252505738678, -0.02230408590123849, -0.3675490051164535, -0.30298774650316557, 0.044678989089719116, -0.2956286178816668, 0.1529544378797037, -0.2068374608482019, 0.14554992672421743, -0.1416176180529427, -0.3375630259891206, -0.49489029779354127},
    {-0.057924935679868006, -0.1344285413245103, 0.15278668428360803, -0.10957773787151641, -0.4232773366574577, -0.3316892213259528, -0.21007971694476932, 0.09502225965162543, -0.061382474562789474, 0.059162880104698216, 0.005420551847112908, 0.12072487176067861, -0.42793113833284485, 0.12503387933017718, -0.19972097465324928, 0.3341600459635635, -0.16497220903097287, -0.15200084870397207, -0.2514758952280217, 0.007812104919071403, 0.004342950229347543, -0.10867574128415193, -0.10872809662595222, -0.07900753672900898, -0.4805118044922902, -0.08860963172003924, 0.15317974611026458, 0.155381794360091, -0.3282555774884213, 0.3348416563614329, 0.34439852246026564, -0.25729534511021745, 0.10669794783702644, -0.4347995825936501, -0.36418326621175623, -0.4764848264258971, -0.34889091942878586, -0.3535458763160794, 0.3417523072705941, -0.030646748663905807, -0.48332093174312396, 0.04764911278608411, -0.4024541146649795, 0.37658473425216576, -0.4477119869125574, 0.12855013960797648, 0.20923711915275112, -0.12197320721183535, 0.05568264547289396, -0.17079285301376387, -0.3869823035761114, -0.08741975286494226, -0.13988546002066526, -0.20036786792703068, -0.4606512986315753, -0.11662617440748618, 0.1682306574200145, -0.055512749387074616, 0.13998405796797178, -0.18909321602437856, -0.11433649412802835, -0.26093334897296794, -0.3881024752256695, -0.05643754896214997},
    {-0.08301833241858446, -0.3261659447691332, 0.29817912290953313, -0.2428205231342148, -0.2296472782925924, -0.38895627515526404, -0.2894043652836052, 0.05471285120908449, 0.2585317333803567, 0.044124798283830126, -0.3141480834357733, -0.1491855416385271, -0.47720143334731074, -0.17456973076067117, -0.15431531154830058, -0.09552707140706593, -0.44942971123169073, -0.0037294404044134187, -0.4410658917493209, -0.488730411212603, -0.06597728927722038, -0.20454470959207627, -0.4225212128157646, -0.34346154969192033, -0.25090431958529924, 0.04033042969453698, -0.04437298079299481, -0.03826371485300612, -0.1716801379560251, 0.2804870138783344, 0.2821770279824173, -0.24897701967429628, 0.13322261964789042, -0.07097752528985146, -0.3903463006804829, -0.4632710690557485, -0.24963320614437776, -0.18172893952294475, 0.18909828244037133, -0.16220680517209582, -0.1893273264829888, 0.13759703602545534, -0.39061171783379595, 0.3723623392529053, -0.5587158965124772, 0.2677577542470372, -0.12261502838841327, -0.559569198013156, 0.30910516050969455, -0.45547136727472165, -0.09922923186827286, -0.13818484862283095, -0.2938847671543753, -0.4235706511574253, -0.2615970965598487, -0.11942803347726486, -0.005672882503513569, -0.3314260015702582, -0.4121902521499558, -0.5021224342453767, -0.03311754609135222, -0.5129928581046096, -0.4398615354206034, -0.4492014352915719},
    {0.22444455218063467, -0.2352156900525659, 0.009199181228983817, -0.11167797698789228, -0.2390824352396951, 0.03968009763147044, -0.18893355629957653, -0.0008154491348814771, 7.354890369645023e-05, 0.30687182105805894, -0.030211702012715648, 0.06431779604547397, -0.09589368546454322, 0.15839525732998777, -0.34078308462161283, -0.07706056170819481, -0.14448846575090935, -0.04449139306524741, -0.1300980621499505, -0.25534153806036847, 0.1617453667082174, -0.005679207835612377, -0.27357526496096846, -0.21675463089898134, -0.11827035696607978, -0.18549003723646162, 0.2410299144417276, -0.0367897637715908, 0.09154308543368513, -0.14276019286226962, 0.1881977571010292, -0.024269268083233674, 0.40188720520049714, -0.28908733410968246, -0.308769376137935, -0.1080946380936912, -0.02285443393264375, -0.3060202316620481, 0.050416605119336426, -0.20613406489390493, -0.007722378203642329, -0.05244971971153272, -0.18163815053807772, 0.3754987329159599, -0.3089024796295548, 0.3323213307574665, 0.203449257251107, -0.5191201183856127, 0.2593377899562623, 0.04212340991579239, -0.183390242250302, -0.11428334965186855, -0.2217236919727019, -0.3331570715690562, -0.44171804375473545, -0.020228432554257103, 0.3141611322563659, -0.26126190819407963, -0.45197171910980755, -0.45157812539374304, 0.2129658480588349, -0.08898536610357415, -0.35957545197631074, -0.47920540244641896},
    {-0.022632251536242886, -0.3731331132016558, 0.38692851152921576, -0.41693466285485004, -0.11466470655792836, -0.23874616796627476, -0.19804688214102442, -0.12885422754377202, 0.10772983642691748, 0.18697632541868153, 0.20478517918686737, 0.32171659158798327, -0.16674452715124233, 0.24802670531804974, -0.42241865984608606, 0.3545864107766189, -0.3393755367133362, 0.13526594779724574, -0.2241345081565167, -0.3765670808012984, 0.37648111235004694, -0.3066194391633272, -0.1700892191649302, 0.08204076904203429, -0.3421131475539779, -0.2646123942305839, 0.002608899957148941, 0.34405633701711996, 0.11393343231152209, -0.13657083573005607, -0.015374165817026275, -0.006981004110405532, 0.41985752403350984, -0.24748823228415343, -0.4997067297062053, -0.47181520927732074, -0.04076115619339232, -0.3108043328982682, 0.12887125539436628, -0.10902663425870796, -0.22157498552519445, 0.3306897385171738, -0.07124371544094595, -0.005297879997209771, -0.52313917400973, 0.22395234232783356, 0.20967708213201014, -0.2520331807605172, 0.0144059408003797, -0.037263354889906924, -0.21225612911114689, -0.19467840687652746, -0.3391362604132972, -0.4427906859549573, -0.4654620914633571, -0.12190077953597253, 0.1335646645552136, -0.37300292288078396, -0.4941092696487998, -0.15887962451161275, -0.027882504860847496, -0.16238722848677523, -0.43753727764325506, -0.45949622875756335},
    {0.17284855724180975, -0.24388219928072252, 0.08392962397701124, -0.5873828312998312, -0.27236980602875827, 0.08879304084030651, -0.4043612579811856, -0.11216668447471743, 0.05425563583881049, -0.00450738141028518, 0.0558563695539238, 0.3918975777269415, -0.2402236176143522, 0.4489161663365681, -0.19513661144683195, 0.37196238801472703, -0.5697099723691487, 0.1147235327663056, -0.6501234360951484, -0.020009487608546397, -0.10718034367114228, -0.2037666286650438, -0.45738017794024144, 0.2337373421963685, -0.29611900082672615, -0.02712390811815576, 0.06528508149778349, 0.46830890593183566, 0.005040182627958677, 0.22190601235136304, 0.37080172751876417, -0.19400161854138473, 0.40264152180840856, -0.479273363970905, -0.20109203735892722, -0.47553162547021904, -0.21349203465573746, -0.15372912847665762, 0.14817105307847417, -0.22154851696726147, -0.5961850817828133, -0.008768026043801586, -0.07749222073890452, 0.2935938382344103, -0.39551843330555875, 0.06496269928279619, 0.3660122358399743, -0.24425314047391736, 0.46294696707023236, -0.20492716723056603, -0.2780703953196431, -0.21929737117871237, -0.11514273397037834, -0.024801426094725708, -0.37751762435433184, -0.05178178214525696, 0.0842605296723531, -0.30084919084007306, -0.3859234851731162, -0.5184745628806833, -0.09679403673957011, -0.27383302040843716, -0.46152971090984957, -0.37560412080061145},
    {-0.21600937419142976, -0.02725353797052055, -0.19119544176756825, -0.4425812713547918, -0.36086937944820446, -0.1189855154983713, -0.316544671134356, -0.21724537025820026, 0.18169732453549425, 0.12948106662197556, 0.23354110933114475, 0.289566133019137, -0.2470698091130069, 0.3274621501200559, -0.05795776245971666, -0.18711059028477509, -0.07747465501785117, -0.3842402176283176, -0.6009109159186327, -0.13729529643440552, -0.13591558109723906, -0.28215985236314917, -0.4078740113337267, -0.1954823774467177, -0.49391384805599214, 0.015556507316582938, -0.08705668242212153, 0.2151628473393657, -0.08997685770325536, 0.06879103391392762, -0.07273552116520446, -0.32419161377773864, 0.18508488178220642, -0.11533949147496321, -0.366540868707538, -0.14446120822895053, -0.19206192089350857, -0.014663606796909857, 0.13085105296817875, -0.282481663839744, -0.38973304100120587, 0.07000831419111807, -0.030774680525730177, 0.18033804657728233, -0.3688853243933094, 0.221777405944813, 0.08417125046269404, -0.3567286755147082, 0.07053140130316289, -0.4022379499645633, -0.10803941668473442, -0.021458668689055688, -0.14617265263807294, -0.2531640918961536, -0.2704599012757319, 0.031620788081845326, 0.15240779733857304, -0.1467178287487869, -0.2301229742066982, -0.6114920908720456, -0.3343365375256571, -0.06875223165733901, -0.13767943395282042, -0.0921112865642942},
    {0.13508185528793304, -0.2194600920221388, -0.11644784684730168, -0.33479459508584664, -0.2624995028736112, -0.27985422588957576, -0.5416638598719756, 0.14218144223347595, 0.0535344259813637, 0.23893983236041552, 0.32825191753717875, 0.3944493606062628, -0.13801725671939108, 0.3408063359647636, -0.569668849521469, 0.1749628060105704, -0.1370262902349309, -0.13670199644395276, -0.6116618434434055, -0.19445605249166753, 0.06410493969448786, -0.4411886756265772, -0.4361160475384696, -0.3619493042291891, -0.25800037434061074, -0.29639386222809405, -0.023626179275895966, 0.2594766847028968, -0.18596858419990955, 0.002415436508600421, -0.06124971913295603, -0.2473600541988993, 0.2977509664276368, -0.2599475425814343, -0.09374205239515669, -0.46439908612890274, -0.2698912416214545, 0.11006270500789962, 0.1666492998219288, -0.2230361546350943, -0.17256506736628843, 0.10478533207143877, -0.4814575244664194, 0.09011114816176284, -0.20991777959745547, 0.42892002143847086, 0.2790294582582015, -0.524509171728569, 0.3487868766501538, -0.22145434963216218, -0.3014163935644725, 0.09681925271057981, -0.41047570336323536, -0.1872229925009563, -0.5577249982444848, -0.30652029333088177, 0.2439222538136257, -0.1804491107132284, 0.05605662540614092, -0.5985027788734748, 0.13604967513427046, -0.3702195705197672, -0.3434259103766613, -0.4070063439008519},
    {0.047550785405775814, -0.2922409666727241, 0.028101517882034157, -0.45145098926251914, -0.1950944370848915, -0.14466977171321885, -0.5762923438074171, -0.09282586553632045, 0.07678242725188163, -0.03355238270362689, 0.0305446585818337, 0.10854531856827371, -0.32571284343007095, 0.11673975891862454, -0.5200435577556933, 0.24324575514832844, -0.1978696344436415, -0.023393377843234798, -0.30049949858795205, -0.1406094648625137, 0.15638720936922543, -0.29580156834125443, -0.08611228504501905, -0.4128129269781042, -0.337536228219312, -0.0695135166167168, 0.10828795092839788, 0.026689955814695805, -0.2086520864900573, -0.11732080913002736, 0.17241038143302323, -0.2738787221861729, 0.26428427452979836, -0.05926574571363616, -0.239618353000063, -0.4059051146582134, -0.4112958727321208, 0.15040815133775803, 0.22069182064365644, -0.07676691795781863, -0.24360332947069802, -0.046000520235159194, -0.48637313133129445, -0.03705906754379809, -0.28379266873418274, 0.15559416744388432, 0.3414850638670315, -0.13418707859182805, 0.18841476079023256, -0.1238389047965964, -0.41765033074582586, 0.19777857256018114, -0.18099289750875322, -0.4423778164939409, -0.559222187568913, -0.06091648715413177, 0.28772602204375786, -0.2781108623147952, 0.19252822647905088, -0.616629097462204, -0.06223368669505805, -0.4398043644681127, -0.35900366958232444, -0.4981895292443981},
    {-0.06369183743539411, -0.2444511912703558, -0.036913539112759866, -0.45800945435134643, -0.34992329967846875, -0.07839689312960724, -0.5768973849937182, 0.008861717403526925, -0.1267268719513815, 0.07918995549759286, 0.04393067387779948, 0.263356025308252, -0.2084675915921277, 0.4905318698949527, -0.40962173566998855, 0.020668771413202003, -0.34492666557009766, -0.16558473661124867, -0.2932504468780037, -0.4188231227615475, -0.28722114057935827, 0.01668948627279086, -0.1455984639296808, -0.2020878058595592, -0.3265349320461494, -0.08969235502657799, -0.024383803305108757, -0.06217389435971922, -0.2903285377003927, -0.21332449619162736, 0.051931025417985, -0.432409815043891, 0.28748182376513853, -0.05019896446281152, -0.2273831830693692, -0.1158891060786724, -0.4496962089052697, 0.17097224214325676, 0.28543860419275935, -0.33897232042642006, -0.24703423819515816, -0.05479508552118974, -0.25935377721771263, 0.22445700490329043, -0.41699118417885916, 0.22716211594222904, 0.1992987245017513, -0.3353664418057072, 0.21072371828022707, -0.43836579455846814, -0.0380928089963966, -0.2095321100541912, -0.4130955572482633, -0.07149185223630612, -0.3789915296447935, 0.003765866638439139, 0.32324201337339337, -0.36565769939583875, -0.24111730207884507, -0.5534647811433249, 0.0160772411064325, -0.24518387406651793, -0.2525380836101312, -0.2804591950556531},
    {0.15825249609322362, -0.28071091674242304, 0.008093939965757416, -0.5476789405146624, -0.2723991914298654, 0.08158882021702703, -0.42220047797276666, 0.20810123376676493, 0.180780079505965, 0.3579168972526463, 0.3811856897573008, -0.01676871868378974, -0.4886715710190005, 0.4038701368915724, -0.4776374690043219, 0.09688227352020085, -0.5026233443088229, -0.29144972759372395, -0.4935008078783173, -0.16983865842675197, -0.0912567207527999, -0.04469926313992949, -0.05905331171489773, 0.17698423573062916, -0.5470264048844099, -0.23394708235724582, 0.14411505420037873, 0.1827841541433394, -0.061821996784450994, -0.13996785443563933, 0.12934457555377205, -0.1141337799463784, 0.42845070100028, -0.09072749989451014, -0.10032564190550279, -0.336613514443602, -0.37787431357772766, 0.10417069916167028, 0.2942343636029103, 0.04435583876910989, -0.0647445763902724, 0.3406125482070609, -0.017261710187104373, 0.18423663074580854, -0.36123859759228755, 0.18177657846772596, 0.25076957589425275, -0.06461259268482843, 0.4380555598412389, -0.3141628514902746, -0.2640568583583148, -0.06263833735373216, -0.3641056352469678, 0.01490756977806265, -0.27924338238816043, -0.3559122485865483, 0.3560662661204899, -0.40945748397885434, 0.19858601904510248, -0.6042137917819229, 0.05311176802177248, 0.148859534083072, -0.32560855357633495, -0.1828174829086212},
    {0.1130090173891397, -0.35539803448930296, 0.02424426472144969, -0.22825016901203637, -0.43866938118813026, 0.09787536854681535, -0.577776895921857, 0.03827471830139298, 0.28643119238264303, 0.30649777310424525, 0.41838300310695337, 0.07274721858524531, -0.5102612799116971, 0.1404085794220312, -0.22517603387584453, 0.23492821203170242, -0.2359712847843763, -0.1086607497839403, -0.6309119326680113, -0.3940163051712365, 0.10740553084743235, -0.11823334771742164, -0.4094032211670916, 0.2138603068719214, -0.4913662853961413, -0.2728998072623963, 0.2973589681084884, 0.24858272196871872, 0.14575200784860018, 0.23892588147632912, 0.156691677263115, -0.30419762399128775, 0.04947232411205989, -0.16841613489587748, -0.23371831524078185, -0.20825875289228069, -0.5963288459486648, 0.06604290455204466, 0.2313482760509936, -0.257230481702337, -0.012419184951673667, 0.35366514847304525, -0.13991099144624805, 0.09766517009422153, -0.16600438906700096, 0.4674048591490332, 0.3375065579428364, -0.3010520750142944, 0.40053246395265146, -0.4185034742797102, -0.36045829259929046, 0.290222665788415, -0.5308100771581498, -0.07955162227942618, -0.3225540009956135, -0.3900779812251964, 0.06355066341973573, -0.44989729761108693, 0.04528147033967275, -0.314556132485495, 0.22356153933306902, -0.07040358029050711, -0.05332308400422426, -0.40786196258965274},
    {0.20147994150018428, -0.5301170032846351, 0.23595216673896277, -0.16855376781920323, -0.37736489092598674, 0.2765397894577876, -0.39024269069474643, -0.06853867863953303, -0.02171987751855377, 0.27925374225612837, 0.4047465051669504, 0.11679086912328447, -0.352030894523018, 0.31778707915138843, -0.15605378043369292, 0.26907758088917416, -0.5536674832858137, -0.33417028979724, -0.23969982750275048, -0.11561579527817661, -0.3033482656631739, 0.11335510827278045, -0.07483636117962626, -0.216068972947201, -0.38618603765443116, 0.1554860781848776, 0.049397411232920296, 0.1405176946233686, -0.004516386896141501, 0.053406597534219606, 0.13826239284546374, -0.022411145823049185, -0.039971427489477164, -0.181248920360892, -0.24101496548350146, -0.1394021933667688, -0.5358241294702699, 0.059030961851917474, 0.26173412152411923, -0.27733833289868615, -0.1046805758899097, 0.2394245750401109, -0.3067105446177432, 0.19123004312531974, -0.42183392009295534, 0.4187091977659506, 0.060251273430508914, -0.2519619168717853, 0.12140571548779869, 0.15200910346429125, 0.20702013096940505, 0.08358038604580202, -0.10441645465088972, -0.22182047013065712, -0.10033919320622335, -0.40603340465243776, 0.29648437018828216, -0.14768820947573594, 0.007503661471117848, -0.3218740441246546, -0.14624795460095133, 0.04047294030079865, -0.1765931084457116, -0.41275065730610083},
    {-0.06755731591631614, -0.2983794701472141, 0.08361935066189706, -0.48677191522511176, -0.5759004814730858, 0.02924720961000247, -0.442442737152012, 0.09576002701532553, 0.07066152960824787, 0.4655223929812356, 0.24648836763321375, -0.05845470851965132, -0.4326407860056641, 0.3750883681812017, -0.37148907387099417, 0.28223158641890483, -0.29023845135093423, -0.20041431927406692, -0.3627039047202674, -0.27475136319155397, -0.02501892985909367, 0.13857542811687765, -0.26464564212920083, 0.08639838638367454, -0.28724095864163157, -0.12788900730098385, 0.17559209788194013, 0.10534313701962617, 0.21544304177070572, -0.035466766803806275, 0.3801329185479822, -0.25542193423274406, 0.3679100072496983, -0.23943893443692738, -0.26750961006765583, -0.41941578571245486, -0.3611577594535484, 0.35799150649869405, 0.23092353622571843, 0.19713320510194543, 0.02050938229532033, 0.3852785026943795, -0.020732885380673305, 0.04788622254279185, -0.4083144216978129, 0.24028387703477866, 0.2435771950228154, -0.19579771774292937, 0.458256552051395, -0.2614971230666653, 0.2629724410932051, 0.3879004574838836, -0.31977845509168806, 0.22026462802118824, -0.3854198010941312, -0.30808342463190536, 0.05852497823109066, -0.32925724774732557, 0.27594259272731547, -0.13546267334730794, 0.22787006739948157, -0.06296536856345486, -0.006905837920626341, -0.33009223834344736},
    {0.24381216501485148, -0.5825221162947358, 0.12629981358028275, -0.5134781665174132, -0.5926538791447645, -0.14686635952074456, -0.5610877717128827, 0.0674279536589552, 0.035066820811209584, 0.42818418959898513, 0.35169012067137906, 0.28023848711728083, -0.13933215671252197, 0.37488642963329044, -0.4260392463990014, 0.4915149197138006, -0.535861139504164, -0.4156373192946443, -0.35974908253934523, -0.2759454844876875, 0.18289382743619262, 0.1137114278487379, -0.2840319097596171, 0.10826220414145647, -0.42027124050729026, -0.19978188610082379, 0.26227643136453566, 0.2706022114213018, -0.305938323141619, -0.0447556024337295, 0.371693018387338, -0.2954669176223023, 0.49882951422226934, -0.39699415584586323, -0.3056173222572758, -0.40011792206461644, -0.5921186007101176, 0.10430564069630328, 0.06406381494887955, -0.08935150787811307, -0.2815600733797954, 0.28374715027297215, -0.17371435141220942, 0.2716253968605816, -0.4559774885618528, 0.23389110003380786, 0.393726641975352, -0.3423954712809832, 0.5184616512905449, -0.20640363002950907, -0.15857410333703176, 0.08402914082257257, -0.3383830961010945, 0.20183127676118076, -0.49034084139677525, -0.4601541268047188, 0.19370026590542175, -0.12356432788805191, 0.16368837862261518, -0.3769222515908241, -0.029951549936310662, -0.059639357916702385, -0.17419121590056325, -0.551454979984964},
    {-0.15400438663844124, -0.39644230594317664, -0.16186449744244708, -0.5801488380597779, -0.5166762736665543, 0.04515331577723849, -0.3322333151309228, 0.2382105835318533, 0.19226726858205384, 0.007455090844462071, 0.2963457304773891, 0.08221545734265523, -0.35043724264711584, 0.29054209635357914, -0.4428837700166264, 0.2826432573226915, -0.4499718554146675, -0.4163035226429587, -0.6214945863766118, -0.4158604571402338, -0.15779261195129685, -0.15881295492596426, -0.34399315308260064, 0.09874470500521018, -0.5676535604721056, -0.2603449090841405, 0.21844920507865023, 0.05446184358845292, 0.036298878029682645, -0.22648361605867862, 0.23704442118765845, -0.3130193645088724, 0.11195103676056288, -0.03672966065067008, -0.40729320036084005, -0.5223886657514933, -0.5012857425430559, 0.12775963012153352, 0.41170725817134013, -0.04695060741919158, -0.2752468084522173, 0.043496755603013415, -0.09771781878351024, 0.11001104466545783, -0.47468516493858215, 0.46289895855031044, 0.32042031448768804, -0.36452953056288956, 0.3429946762333802, -0.19053689674244823, -0.17602631579004957, 0.05884387910689515, -0.17940830533650212, -0.2569650017363366, -0.37359742805757823, -0.3415068702345832, 0.3441974691884836, -0.011422162344406997, -0.1846898144582273, -0.6791927447715614, 0.08245008316835196, -0.10878496292703327, -0.2403953450949532, -0.6167970949939114},
    {-0.1274861275830041, -0.6352340328190512, 0.22840145595249747, -0.429566497098852, -0.6614236337617794, 0.04112157990997185, -0.45696750991929075, 0.10689931815782275, 0.014085705103218965, 0.3027382084415037, 0.15735656180966243, -0.0033646361128544366, -0.23433395369597143, 0.25460608052516953, -0.5625759563951213, 0.19076667995931473, -0.5676618159709189, -0.4577374154426887, -0.4306779276622088, -0.4264270361025207, -0.01502874179006997, 0.16438779481505508, -0.3922847131598032, -0.0826997153729708, -0.5191247691045336, -0.06066750715615686, 0.030754123865215886, 0.21248290703039924, -0.3558611243254422, -0.1779323684472319, 0.4593488584221591, -0.4596250489650982, 0.4122450101413293, -0.020860019531652705, -0.5572606341616287, -0.5415649002549154, -0.35790559253103416, 0.2038684184706232, 0.1561470410450332, -0.18173803828996646, -0.45212741596427053, 0.36657957412399894, -0.4562057655093347, -0.015568723734743651, -0.3101928562692442, 0.22794071228091797, -0.0019014824794887798, -0.3399782217666477, 0.1370089846426198, -0.0843351185286579, 0.006626051929561641, 0.1449904302990692, -0.34841334962572806, -0.3331533259453509, -0.5233997467259289, -0.24794667160468165, 0.3461639714155899, -0.32949569225592124, 0.17729589915324426, -0.47720361769770947, 0.17759979633282433, -0.2639016241882836, -0.23308585720988675, -0.5526739500707625},
    {0.23871735570537123, -0.6548058867770076, 0.10929918667000733, -0.6510486746640388, -0.5189063432197996, 0.28857759461335525, -0.3136015009590274, 0.3344160598881433, 0.17401063888574947, 0.5224307233002095, 0.3619892570669073, -0.02979999827635713, -0.20528489190618804, 0.5351412696486452, -0.6111957537208745, 0.5403152650583826, -0.5226149464527823, -0.46640126298638335, -0.6246769576502719, -0.6132698544451444, 0.0023824455551126993, 0.3206311614204236, -0.2071310501585914, 0.28663171119127767, -0.38040154240468566, 0.10732732200277828, 0.149122730170382, 0.1693765277258719, 0.042100414881882445, 0.22121969554184384, 0.31663421826525767, -0.20007137642626208, 0.45322454951355423, -0.19250833316135632, -0.4528120442776376, -0.5453125570511025, -0.6025215511277064, 0.4144081764733482, 0.16129611343935482, -0.10717883002146474, -0.16590903308235677, 0.24778858863100373, -0.21592121401635128, 0.511645914749357, -0.5066603006567906, 0.5731733705092213, 0.44195168855748357, -0.0650088664944934, 0.4929976404086514, 0.011350950044718032, 0.20353745923857774, 0.49789671620834136, -0.12212668269483173, 0.2819521226271447, -0.47127085946857084, -0.4346258371225921, 0.3248195709810461, 0.032129063766412974, 0.18519677368753967, -0.4789504284193832, 0.32266750376930015, 0.16809595045471717, -0.06004760365247723, -0.2126519477415009},
    {0.505086976550108, -0.27276336772461945, 0.0897464334577412, -0.44052841613952803, -0.5817306570951807, 0.3053279863497893, -0.37752015580182025, 0.15568430473560138, 0.15074567624802132, 0.44241353721810883, 0.3410263550450726, 0.03674995811717113, -0.3736883452736059, 0.43847902880133777, -0.2338018046625482, 0.5060940907716474, -0.4999233698996772, -0.6078394245072269, -0.6811711292212357, -0.6803883286985, -0.11392007511250292, 0.40001928646867446, 0.028284616502976832, 0.3435799556956552, -0.32458564810945323, 0.14756214017831262, 0.3402692378651788, 0.2923648593675728, 0.3130301743902151, 0.059331081274497, 0.4489316157961211, -0.08329125212056955, 0.2867893227134674, -0.08589598732941706, -0.06263324990105558, -0.23220063384429962, -0.4946019836939631, 0.42661877648526053, 0.2958481141965639, 0.09730785595680441, 0.16463161283846864, 0.40625701662824676, -0.10172958231418622, 0.2996415287414285, -0.08902152911104928, 0.5420333053954066, 0.49425144635148327, -0.21135038144934157, 0.30360804163068766, 0.2449370508564949, 0.31049972843718693, 0.40602055783890434, -0.03480633298899179, 0.2460298841695719, -0.4332964297159978, -0.2243605177505539, 0.6343309776922799, 0.0076938376808236685, 0.35345450442145304, -0.4734930245691331, 0.08881240434216037, 0.34777844905234245, 0.11607585953174479, -0.13962320741367054},
    {0.1616035074111969, -0.6776021734379359, 0.23538993847211834, -0.5288122876489013, -0.6102725441667319, 0.06316436882629084, -0.37206718308443176, 0.22891772833434007, 0.28410044543880425, 0.37663178512596246, 0.45137367055686006, 0.06507139611872098, -0.5900736996799334, 0.3196215398497929, -0.5715822125070439, 0.28943374118341375, -0.5174400844768344, -0.6331220210796643, -0.6644897324994357, -0.5502948991702612, -0.14479084262606765, 0.3429356697848689, -0.4603008166361881, 0.09453779009033235, -0.33329447512063803, -0.10721458041026313, 0.3386218346878513, 0.09556134987296597, 0.06850027175226267, 0.023517466070068056, 0.442577381053872, -0.4606502052920904, 0.26992622629857504, -0.028985778638767248, -0.05173650304059319, -0.48898711267224115, -0.29218259629404525, 0.3144712251129083, 0.3652136822601792, -0.07368069366892487, -0.09428965525226606, 0.09587906190180184, -0.09389246841899027, 0.34253366313809464, -0.16997646916539275, 0.3053148537452057, 0.42248437122201166, -0.10462603167857909, 0.3850340153085833, 0.13092351400206692, 0.25435017649607816, 0.46668451125846944, -0.32100033627651453, 0.055475927715963796, -0.5068860119347647, -0.19526329804178633, 0.5024194608375451, -0.07169133743504061, 0.40810057467041655, -0.3048000374855775, 0.07368136193301227, 0.35543429023180834, -0.18688557810054424, -0.22058023845193356},
    {0.0997327416254994, -0.6598957893012899, 0.07104253344135968, -0.5688980604408828, -0.5436663814699484, -0.1203360181728092, -0.6839168133902734, 0.07286904660650051, 0.29454839304146957, 0.375253541414325, -0.0402420153788279, 0.16371169906755817, -0.6524040309648726, 0.24310359493378114, -0.3940914640473927, 0.4660986381010904, -0.6790439471845461, -0.46872206630109015, -0.7415976779169806, -0.604285400865947, -0.2604631634863425, 0.16409370212066718, -0.6549809884792959, -0.1380520667577735, -0.5237215904220999, 0.11808108031777187, 0.3064029118661189, 0.16226960773092547, -0.3427777763917886, 0.10318095847522375, 0.12900701140575907, -0.3082120345849544, 0.42492071192618186, -0.20997908182673103, -0.30645872045186556, -0.4422963644995511, -0.6856310464237443, 0.20884291958017276, 0.03140676339215453, -0.28849569851838813, -0.13006700233777588, 0.07268289203342199, -0.2389054138073281, 0.20992846945877794, -0.26913670555352665, 0.35588874359627476, 0.1868182303151522, -0.41394536203292387, 0.24268012612462514, -0.3499287636943335, -0.24580961494386527, 0.03967607390440238, -0.36225507949476976, -0.28982095374740496, -0.46093338996056243, -0.5738840899069978, 0.1623063430108418, -0.23070704968781663, 0.19045164587239893, -0.3567249727920971, 0.04186829521832795, 0.03765265326825568, -0.5367762755687865, -0.3067256743609363},
    {0.3271683116977092, -0.30645831264996015, -0.20034421061538432, -0.6537331732226136, -0.5604641367916204, 0.27898828896382905, -0.5390929369278127, 0.2030942334963715, -0.015228513081768454, 0.46579107682028525, 0.39661464701607874, 0.05691353075703953, -0.38399126878272094, 0.5025030606575586, -0.5749204319928272, 0.24922111132317737, -0.6736889263383086, -0.6621295839021809, -0.44982384966735334, -0.7155150811843091, 0.027911844383095706, 0.27624752701625926, -0.308530283683821, 0.14744785811708658, -0.47724478420207594, -0.05230108693082253, 0.4333802194750948, 0.037429373511666864, 0.10207936202206325, -0.055497533099254384, 0.43390630893292126, -0.23755077731861912, 0.24068885341022123, 0.00618921828993106, -0.04523643970721561, -0.5081904310786508, -0.4582640020106702, 0.24396713551007007, 0.08769973056638278, 0.04247692230539609, -0.3076712654023423, 0.28111106023375554, -0.0691842748784516, 0.36855528963182504, -0.40216523046084424, 0.5333333790128149, 0.16180210168309447, -0.16535939417626283, 0.4445654572815928, 0.18250771980123923, 0.1265426199839917, 0.17011908977236553, -0.23996842993506257, 0.005523567047638378, -0.516054005265288, -0.39740162718709415, 0.4705838493927503, -0.23541834102492382, 0.30010858667443474, -0.657276956203131, 0.03542881689931288, 0.13330915933220383, -0.052324074308890293, -0.4008344137982323},
    {0.2536567586406017, -0.4014603561445024, -0.2104417675171779, -0.36866646639910317, -0.44757138638477517, 0.14939653062177963, -0.3135012192557879, 0.28082039037261874, 0.37612551178339276, 0.2913235084126571, 0.3924245387687373, 0.18229171024580731, -0.24639358043041634, 0.3896981704749471, -0.651994771028952, 0.3884060002278269, -0.48175535108571427, -0.5635755211116525, -0.5695150432132245, -0.5874003602376657, -0.12607168263641513, 0.4600156625724565, -0.3207289369543526, -0.12681663130143295, -0.32142334788717775, 0.04194933051203516, 0.3721718410159113, 0.18732410519823645, -0.01661029780447334, 0.25909001227496903, 0.5387517095150757, -0.2511762232967188, 0.48797855224489073, -0.09196320219841236, -0.11272360268282398, -0.5349025676830708, -0.32171657346727617, 0.15832097775088524, 0.10889744619991153, -0.23825970942857563, -0.28289363508917453, 0.15080263814437872, 0.03034266792372694, 0.4696657102995907, -0.4959260859117248, 0.3140303990384248, 0.528148682535812, -0.4339840962377227, 0.30375683209303295, 0.14941322932662976, 0.0955672908542605, 0.23056699807561787, -0.1448353711116715, -0.12111582034415921, -0.5229039868662668, -0.4736504643633153, 0.565785030230767, -0.07125316059475517, 0.06695599218133255, -0.6568139679476079, -0.16104800130522523, 0.07804442524037541, -0.2985361489749641, -0.4307867635864341},
    {0.17412984607884696, -0.6669428647729677, -0.22603274939853693, -0.6475559823047468, -0.5729096804827937, -0.05934479268140414, -0.44103373468587365, 0.018733381414968917, 0.14666853844420105, 0.13044025211133653, 0.10478474333355416, 0.11627061936707608, -0.46773732078369956, 0.5769300351580428, -0.5921558649131625, 0.3034012348778024, -0.5332871036946675, -0.5428122793559532, -0.7798398152336393, -0.6249789375691674, 0.09168954850026755, 0.2797534732554914, -0.18847719246897213, 0.023344158198229624, -0.4262570658270988, 0.22056641809809752, 0.214741334935304, 0.05618553771280014, 0.1086964684029524, -0.09374540257010212, 0.5068650732525565, -0.40102334739387346, 0.309863686787874, -0.39737808304582345, -0.5180610970249367, -0.1903236587696335, -0.3317077209742929, 0.07128311911303974, 0.010900011130036013, 0.02490708483944318, -0.2743799867445747, 0.3015846103266953, -0.37694713094208937, 0.36801641877612346, -0.5391531438710009, 0.3238886165133869, 0.5444265897179728, -0.2883251410236974, 0.32532882901903776, -0.05627702448189127, -0.022208860137671673, 0.20024736790349223, -0.41698674012319636, -0.006803920336137143, -0.31341174758263285, -0.24058921172769582, 0.2450543615669469, -0.27930120047692003, 0.16437665214810773, -0.3650153609726213, 0.07527392465491661, 0.30603747748660887, -0.16322477594190685, -0.40995323561083336},
    {0.3295093579222769, -0.6402076707718813, -0.16489701318203134, -0.6708744632542083, -0.474050798928741, 0.22778247357246192, -0.5125847188822943, 0.09948193092847797, 0.34775486382234966, 0.19103901355641584, 0.201100208783519, 0.050128140851190765, -0.2871374533216684, 0.4630885467539202, -0.5411807133128443, 0.28410909705972726, -0.5825602933733324, -0.3023900167991912, -0.5614844694853227, -0.744483508284329, -0.04486782257876313, 0.4949720349939112, -0.30162346421591507, 0.021073277785942233, -0.3143988291684059, 0.1667258822045452, 0.24043039501782565, 0.02376691452850439, -0.07722131127672804, 0.25746655630707277, 0.3810592125300189, -0.4652459114659217, 0.4092939733727974, -0.422386318380778, -0.4153581954031044, -0.21498250724117932, -0.3841691663923909, 0.41154582124050654, 0.20646879100362117, -0.15521851939162806, 0.0020835239605317478, 0.46431797441224476, -0.3207172709200779, 0.5612493445356243, -0.36761099105985123, 0.23159174129769408, 0.5559932826352901, -0.3040157776397004, 0.3442895124030324, 0.08654649787163853, 0.37087782417726284, 0.5314864847202202, -0.13152829556234796, 0.03361620601617511, -0.3086552809806665, -0.47016891908495767, 0.5532356504342908, -0.29373400888441137, 0.27810982716429294, -0.5552405459659924, -0.10955745144556804, 0.2983487178708269, -0.3580203531632089, -0.19685725290779627},
    {0.35120759022951104, -0.5881522680484077, 0.18655009311664075, -0.5730455672017544, -0.5296095364297098, 0.36299292298774993, -0.33292711909596717, 0.2919823655160966, 0.07281490429789579, 0.4482385947440542, 0.21415241093032947, 0.05740654386439894, -0.47651574335593117, 0.5377048643288902, -0.3612434739289238, 0.46236922926958174, -0.6756009697840951, -0.47076967419766474, -0.7695772645122042, -0.5784375876007846, -0.1612792075548901, 0.4832870772374626, -0.086250036644189, 0.2507165844584835, -0.45061184648927843, 0.18616666453078373, 0.32166055769574325, 0.32062366700535994, 0.20938283476590586, 0.29330433187019833, 0.603048634211538, -0.28565550704102793, 0.29767536319700977, -0.29696556026928744, -0.21553241982985757, -0.4315848390710671, -0.5188507912948135, 0.17031771602494547, 0.21359328006764705, 0.04630109704628654, -0.14671275815075038, 0.43662617891550143, 0.03706763541076675, 0.42500372385996166, -0.16205964412884385, 0.40903141919558256, 0.25438224125546566, -0.34279520543120784, 0.3859304433478647, 0.11744936331823877, 0.38675469707440907, 0.5020844044361842, -0.31689398612596376, 0.2451737177067934, -0.4278145353483527, -0.2508414906981411, 0.5127069089972376, -0.04131064038044179, 0.2527995997885921, -0.588051608995279, -0.1026012141224692, 0.31097972270523117, -0.0795181891183815, -0.14473850140918693}
};

static const float b1[64] = {0.6132504044321978, 0.6915610238253236, 0.6845559678505625, 0.6841139691537275, 0.6739368107103688, 0.6846182368407139, 0.7128742656466467, 0.5385780705237568, 0.6964721543176411, 0.6764208566286307, 0.6901717661482231, 0.7270902615073594, 0.6813986150629953, 0.5612712527611464, 0.6640308926755335, 0.6572176842532528, 0.6809217094950311, 0.7348264666402903, 0.7247548212936106, 0.6997340411687965, 0.7198016400840748, 0.6867485069550425, 0.6943384614572695, 0.7055237181711972, 0.6792738718615092, 0.6900523887312219, 0.49698723902305425, 0.6951668497154221, 0.694423202255612, 0.6635437224862752, 0.693709203474075, 0.6428466045102452, 0.6901165734515916, 0.6735202844369326, 0.696601992302666, 0.5977769042351486, 0.6870989208052221, 0.5854091404263813, 0.5741440521952069, 0.6035285076068594, 0.6547051682745691, 0.66468647063635, 0.6899112623454334, 0.5802458516402882, 0.6897704750810002, 0.6722887818522891, 0.70040991731769, 0.6540194495052409, 0.6795983508480479, 0.6939623023012111, 0.6647645722620983, 0.6354993359920593, 0.7142105624051043, 0.6759481653149275, 0.7028322101345338, 0.6815650508168869, 0.6815702547684597, 0.7116806241885254, 0.546100840076901, 0.688941438936353, 0.7203177180296194, 0.6272559837197127, 0.6647448501225304, 0.7187712221478932};

static const float w2[64][32] = {
    {0.8129881788466835, 0.04177936003108331, 0.7385807643472727, 0.7285177439724594, 0.46701810997294335, -0.14137049742773586, 0.803413644916358, 0.8049493400953219, 0.4203527659191446, 0.7235562533466057, 0.7510016242360944, 0.4256315680794206, 0.39698359189722304, 0.23814904757182948, 0.39915877403024597, 0.07230655364158742, 0.4668509146101193, 0.4998601938804502, 0.48552253856681526, 0.6610130678278412, 0.4187926595305423, 0.7242640173541862, 0.39643428337906855, 0.31946987562787815, 0.5108779653361979, 0.8280866719181261, 0.8481497217474859, 0.6192625097847683, 0.7022632769944983, 0.3900272757784355, 0.588799887307426, 0.6902006667638587},
    {0.4252170814766447, -0.03195924531661885, 0.6075914090236751, 0.7580691418529115, 0.7027984856634222, -0.2401338160133047, 0.4218080798046823, 0.7630627583927091, 0.7636524784457459, 0.7622886288435806, 0.7494143259013227, 0.4378053249007216, 0.7965744229401985, 0.17815116961626856, 0.45382777505089267, 0.4246574927110184, 0.553913917449539, 0.4780431134393502, 0.5430954624037432, 0.5949620114230832, 0.5181224086838727, 0.5575955015862735, 0.6659061525940222, 0.34781593017347356, 0.44829287476684154, 0.6015346095002215, 0.6915325165067112, 0.3830445048170571, 0.7996363017419235, 0.8629958435850219, 0.8032957416250834, 0.40038198200006864},
    {0.5403837416611653, 0.04368923242999074, 0.29815234340639407, 0.6276546583734125, 0.33939823529960506, 0.11788597026873981, 0.7074899620487011, 0.7468135723481364, 0.5805021866843211, 0.40884782699846206, 0.4817892461571409, 0.6249582267542064, 0.43785271645362045, 0.2993192870579196, 0.5595740370478125, 0.002957162440831702, 0.681106110661821, 0.5157230959481026, 0.7043564297960965, 0.6939323348369176, 0.5550407030945634, 0.49060334237787206, 0.5314968556508437, 0.7181412517235929, 0.6729881215487704, 0.8311923412118419, 0.4745632780519569, 0.8333610912192644, 0.6791844748134662, 0.43857799852750506, 0.4367280608878724, 0.6355028783719452},
    {0.35919027341069604, -0.2194567422445509, 0.6611259317494375, 0.790273877218133, 0.402049684098096, -0.02599950219177129, 0.5538407172481885, 0.4852999569068261, 0.7813455126578203, 0.5943271739118452, 0.6436105591906885, 0.7706871649974701, 0.6623846619858125, 0.5183270508105857, 0.8393310689308541, 0.386137181596966, 0.49569993387313466, 0.735065133154766, 0.7407701485750946, 0.7368353922515483, 0.39756575808375216, 0.7357999760880971, 0.459461330792178, 0.4431901454938667, 0.45744778586190743, 0.586555375830945, 0.7612064951296449, 0.49698891491212316, 0.7519056842790145, 0.7056373093560531, 0.6248307956876793, 0.8165382413685506},
    {0.5471960456323909, 0.07430496687074323, 0.7166245275520061, 0.5810904076448103, 0.6973837807684983, 0.08698411936955329, 0.5106175589742705, 0.5114260232571431, 0.4343327204090142, 0.4882846456776577, 0.49971456612287174, 0.5700347974025595, 0.4307427910887995, 0.47315776143542587, 0.6250656503846478, -0.012466898578609574, 0.7657253334691425, 0.8752267545968939, 0.5993058992631712, 0.6657578969179601, 0.7821189455724535, 0.3714884000355307, 0.38105365265784474, 0.7362009036009703, 0.6800806452903371, 0.4487468270054972, 0.7766958415899553, 0.7325094436443742, 0.41295624857700536, 0.6829856634030517, 0.5341675196757215, 0.8449778359458566},
    {0.5872630467357369, 0.168827735752963, 0.515527907112741, 0.40159494722178507, 0.6973779260944584, -0.14540702656567686, 0.6447847082222394, 0.6474836980574431, 0.7377913512601962, 0.6402676493236215, 0.7535220099828468, 0.3348980344369533, 0.37637029767493163, 0.295531601694345, 0.7683397662770595, 0.027009926763352277, 0.5922181354863052, 0.5524869677130159, 0.5435467441054154, 0.3490309766447593, 0.7263614384985609, 0.7508212561665595, 0.7942568309742459, 0.7332644660766333, 0.5818811155819613, 0.8415506450036829, 0.6132317385122928, 0.6087422422671749, 0.7723149192303659, 0.509991371646963, 0.4010312268255591, 0.7388174663096923},
    {0.3743572650113711, -0.011193643369094933, 0.5084101914719605, 0.38913587165682734, 0.426084846953451, -0.060413722244809044, 0.648677362817714, 0.6463414785703808, 0.7855203289919243, 0.469301615020725, 0.4341936137003616, 0.2946917984086781, 0.5616292297119754, 0.12798572552919577, 0.7038396691265952, -0.001795698744385052, 0.6004494721750044, 0.8356644981824187, 0.5054722122009524, 0.45852146273942407, 0.8266100520867442, 0.5184319239614982, 0.6476441374594994, 0.44069926771728857, 0.458399012268008, 0.8193034682161516, 0.37008425178237325, 0.8443147766134969, 0.4973759542639708, 0.7535727901396235, 0.6607766568855915, 0.83701553154519},
    {0.5178244827792429, 0.15723182316299522, 0.4795276474600631, 0.6352626356987116, 0.6921477086819904, 0.13544915894196335, 0.4772425161802841, 0.49427259191534617, 0.5231572700503071, 0.38813343360546027, 0.49386285087740633, 0.5287776420667076, 0.49627127942607124, 0.2653000583062454, 0.4575902261019088, 0.43116527395470494, 0.6615944949607694, 0.5869684092765347, 0.521661245103376, 0.5213126645385704, 0.5516835959607481, 0.5827500415359408, 0.4845653645503698, 0.2831157926152633, 0.4422698086083624, 0.44085788098590195, 0.6088777312047309, 0.5117348641806444, 0.685850719118473, 0.6043698133606711, 0.5312864252836039, 0.7413288413237525},
    {0.5998900522444853, -0.14848301163419858, 0.50089860845182, 0.5864576607074349, 0.6275680885947538, -0.08236158095561184, 0.657493423698647, 0.37241165719750546, 0.809831946539818, 0.5719117959880101, 0.5595298658526363, 0.42678948871832323, 0.4147894844500441, 0.5435772136339508, 0.6119447821713208, 0.3102105976897976, 0.7520332650650462, 0.3832901562117921, 0.8217215918798854, 0.8128766765716439, 0.785567733791023, 0.6334190073099429, 0.5305951917715447, 0.399453257606714, 0.5042298964105628, 0.716359328401714, 0.8366871831536348, 0.7016707020502946, 0.41270741291565444, 0.49115569964434547, 0.34084854954983235, 0.6928686901899731},
    {0.4610892101942349, -0.03679683208891164, 0.5549424357842375, 0.7403401781933231, 0.6306467629468738, -0.17422151669812552, 0.4193940229407758, 0.726406110170531, 0.38575068724108896, 0.6966705440602706, 0.6575415222645817, 0.4617784190866066, 0.6603746011315627, 0.15877208158164122, 0.7161231909010546, 0.3193561994336249, 0.7681572653916481, 0.5095693256240595, 0.5720637768509139, 0.7577163631443425, 0.6506962813668246, 0.5372833205792121, 0.6106820293651438, 0.30618956957638355, 0.7887105013108239, 0.7054349566362319, 0.8168139867121494, 0.4067864906192748, 0.39815695276101337, 0.7029284501446289, 0.6160681876444668, 0.43633518532589355},
    {0.6076520504215559, 0.16660989111087995, 0.4369522296137469, 0.639412166262762, 0.4144959146602027, -0.2240118511778243, 0.6424039735585234, 0.4976895214220857, 0.6774269530068271, 0.6504349835266193, 0.6788151965437199, 0.5286647123821893, 0.357096616894617, 0.5698427812638545, 0.7951583012362132, 0.40019543127317686, 0.4816007926351933, 0.43625129412563834, 0.43311038617402814, 0.6354877803675922, 0.8119480139131455, 0.6824314263230662, 0.7740280564216221, 0.6325343409383503, 0.47799100176329024, 0.6598248293256994, 0.7385546390153696, 0.6376438172785146, 0.5071684509434072, 0.684742753248516, 0.7399366562576855, 0.44948294538843264},
    {0.7445968593782446, -0.06388086120856218, 0.35496241784471105, 0.5295152463254955, 0.36960717268838394, -0.28771379927470814, 0.5872367154137255, 0.6711432391208307, 0.3836967614235325, 0.5734710603656236, 0.5655859524368307, 0.6373418368812958, 0.43889878381285474, 0.4786037928873292, 0.758325113721894, 0.1371503562201635, 0.38622190362704434, 0.41333422871918324, 0.5697574293820888, 0.3438838064820506, 0.6339992347981205, 0.7522774910287086, 0.4777020025161223, 0.46471241720380496, 0.767560720335886, 0.6308544247992325, 0.5605601817514846, 0.4247624415017238, 0.5480209801996766, 0.8204141715035528, 0.6932727450282316, 0.6098125018957925},
    {0.8616200150740625, -0.16918043728180976, 0.650499671773819, 0.7556225219439181, 0.5719915401193005, -0.1293583811575485, 0.6430009191272729, 0.8253591236436316, 0.5885030563839203, 0.4930436522780192, 0.7790278730428469, 0.5936277852288562, 0.3745499741797431, 0.41530851530308144, 0.7702139163019418, 0.1954436351113241, 0.47517160424211713, 0.6641687882528667, 0.49022638944504926, 0.48135686591322996, 0.7544447765955712, 0.36852230516389406, 0.3990152847990999, 0.7512291468549054, 0.8266088526291396, 0.8757183591896768, 0.6286989051687315, 0.4206324857384221, 0.39280429968623565, 0.6053659343398066, 0.6516471171401781, 0.7215596507479832},
    {0.3800222851140868, -0.2531438377833375, 0.6640689414396146, 0.37235659616778144, 0.4163217167552551, -0.14767245125511821, 0.7174290502865539, 0.5185983426096739, 0.7356904946246697, 0.4184214458325611, 0.7135295503417266, 0.36786222894363524, 0.39349906121786876, 0.4639565325988077, 0.7333116187259631, 0.04719967545380536, 0.6096358162277113, 0.35899446263371815, 0.5829180022034457, 0.43255124972489795, 0.5020996241131661, 0.6022527540375383, 0.6614310395702079, 0.6265343649046279, 0.40178024505516113, 0.4697380232211039, 0.39396197584250164, 0.7684812286540009, 0.5171311459372906, 0.3699161677682495, 0.5588362539394328, 0.3906387142973566},
    {0.5453846947545021, 0.07328815669571787, 0.5734417363648527, 0.3453225072229997, 0.7435015206184287, 0.13709533406514143, 0.5470193166098127, 0.8306276444704949, 0.5453127829144006, 0.8297671625125298, 0.6560266648621857, 0.3240092896779447, 0.7487439628395061, 0.40067657614012514, 0.505495410159092, -0.007460007721912934, 0.5783679497987045, 0.8682605334732791, 0.588404245765964, 0.754351254446819, 0.5579459895448363, 0.7139205296673536, 0.6016635326944016, 0.5618525355987766, 0.40331802012587264, 0.47026103035373834, 0.6788964917946538, 0.6926259435939408, 0.53990295145101, 0.5836594312803418, 0.5401671113725366, 0.4671602180205399},
    {0.38118554897962165, 0.1994867336874464, 0.6280436314206139, 0.6309738866131908, 0.7577166425884574, 0.008485774238694078, 0.7221604854076751, 0.5559868597963941, 0.69053671923922, 0.42819985461210835, 0.5381919095473782, 0.538247069078388, 0.3700108119189789, 0.400714191919338, 0.628163833925484, 0.348930685288315, 0.5126970310326631, 0.6606569273436593, 0.6195213615596524, 0.6260237961214085, 0.4621139018553693, 0.7241193773520505, 0.6373960673600235, 0.5280134945709507, 0.6068500448152332, 0.6431375233895589, 0.45044983236421676, 0.4159364838959737, 0.757822016672985, 0.473470087600508, 0.4709719609210434, 0.6141837605777968},
    {0.4367554036677927, -0.275833990511093, 0.35617253675034477, 0.5671639207200848, 0.42801492243268985, 0.16464127660158967, 0.4893561535203619, 0.7096081044933853, 0.5844715527204811, 0.6683382208254228, 0.7283675300175885, 0.37680461035865187, 0.6835785227393755, 0.2620023201683509, 0.7982188999494896, 0.3659464264308539, 0.7736910929508738, 0.4979657732900245, 0.45420478876835013, 0.609129486142322, 0.6630119353998883, 0.7444772396338855, 0.5373870599104296, 0.32953001363332207, 0.4670089930901088, 0.7549488377383599, 0.846163573256462, 0.5965508145436313, 0.50284100768085, 0.6097613087133346, 0.7768953506009201, 0.44615644569655266},
    {0.5510109047985181, -0.07793125067871373, 0.3474128668017422, 0.5013148036248725, 0.3815862599417528, -0.018120195509454408, 0.6773950832569632, 0.591226043180131, 0.4592401209709241, 0.6471393938661261, 0.7950961627933133, 0.6128605070892196, 0.6538220602763778, 0.6316947647237201, 0.6967516535425587, 0.17404198540519433, 0.7331308705948253, 0.8737911013330609, 0.8531114495438971, 0.42688503112146003, 0.4995734293964793, 0.4911060342994232, 0.37207662684975923, 0.3868477173399959, 0.838183375065835, 0.46899084796816737, 0.8694823244492238, 0.594251588082572, 0.733646010283221, 0.8777122416449167, 0.8167064117819707, 0.7072571352737901},
    {0.8409441895575279, -0.22442153226658917, 0.7177699022127133, 0.5709425337736392, 0.7574581228670761, 0.09216606585938077, 0.7709060116184654, 0.6485408071132148, 0.7532224875147906, 0.5660586348864264, 0.5818251511818211, 0.4138969535181255, 0.7307766145510943, 0.3483280699001682, 0.7524570616951368, 0.28640772367451967, 0.5408145002061447, 0.6478063158253676, 0.3880760979506353, 0.6204611399243444, 0.6676438488691844, 0.3677763885975224, 0.6276362758118343, 0.3729702548859907, 0.4014937660545056, 0.4214196617773678, 0.641723383032124, 0.56246489472496, 0.4852640007958384, 0.6415906545813044, 0.6822440389245882, 0.8531941826712733},
    {0.526924398024695, 0.16072134403150123, 0.7746487304948463, 0.5173109191691958, 0.8010236830920547, 0.03290053193099565, 0.6831329717744334, 0.8381481353006126, 0.7150391180442031, 0.5981927425215267, 0.5875205640954666, 0.4601990105776868, 0.8662059248511054, 0.3402958226275301, 0.6184992774304809, 0.4171219438804959, 0.8414426965051894, 0.7118831782366581, 0.40514135168420673, 0.5775270036019992, 0.5173458637350257, 0.5451930975890222, 0.4019293863475093, 0.6709272881542143, 0.8710120829738434, 0.48950329743733195, 0.5802381275454643, 0.646466656783839, 0.44204604996095176, 0.6937071562756608, 0.563245264507559, 0.8408980688181169},
    {0.522176551063893, -0.15646768988566312, 0.321075988836759, 0.5613915234247262, 0.7220225152972101, 0.12706763948746377, 0.6009080235421199, 0.6753105762380132, 0.6864386010820817, 0.5057499638024736, 0.6151090414911617, 0.5945701766151128, 0.7737129595358769, 0.5944640579411875, 0.6021648672065057, 0.31225571483427234, 0.5720078644411051, 0.43726218240114295, 0.8033713001666016, 0.5661264454165512, 0.699483367441601, 0.3574514360162121, 0.7748478225334141, 0.47763971323002063, 0.36777388684367945, 0.4026194614626097, 0.8596244550632077, 0.6968537936922439, 0.8863802293014615, 0.8147500016942524, 0.7545746018894607, 0.564659945673662},
    {0.7628453374040308, -0.08301567870384129, 0.4861322611041169, 0.7261083571798023, 0.5205807669936239, -0.17888066681202835, 0.8350924192556338, 0.43119985935181965, 0.7993626071350898, 0.6503933076668656, 0.6316824719020283, 0.7272962477313416, 0.8168601988347437, 0.47089658405929447, 0.45636368844318415, 0.44414383174811084, 0.46484624434027977, 0.801017796173439, 0.489950891470924, 0.3425166371158771, 0.6690902274994457, 0.7287673934001394, 0.6922493814763654, 0.30317556096715875, 0.36119035667629557, 0.7902110593376674, 0.6689011011650534, 0.8021806440157347, 0.7073265425633685, 0.6099845294101794, 0.32967341180133747, 0.7249176460372536},
    {0.5424682902166919, -0.027396410480855813, 0.24467716445705878, 0.40786541389904635, 0.401387436240713, -0.03451838843469577, 0.43312234720830783, 0.7410066664194315, 0.671072337426674, 0.7286580017749424, 0.3397970060566811, 0.34970477439580916, 0.801538555255938, 0.10206895314914047, 0.8112542900952855, 0.35082640896644623, 0.7303661425966005, 0.458817586468258, 0.5201275895642792, 0.3975626260476851, 0.541297353641624, 0.4944673646364579, 0.3783543277018845, 0.5682989515283768, 0.5049321088629583, 0.5709511175867198, 0.8145430493407783, 0.7115249943946623, 0.5482173532725914, 0.751765287051508, 0.4625902443194191, 0.730268560326802},
    {0.5677945865895567, 0.017550818573287944, 0.5355895121861469, 0.5788827201089137, 0.681436760518969, -0.19646411451675064, 0.6587811890592902, 0.6097886866615931, 0.6821295332034805, 0.8252059314734226, 0.4106617418536596, 0.8241208945010792, 0.7119349462759667, 0.4739545969763719, 0.8090064483191427, 0.03880552103780763, 0.7268414430291917, 0.825205880459698, 0.8572494381643873, 0.5014333312411008, 0.41713049967539484, 0.6492132278630506, 0.6668116058364056, 0.5095396155339, 0.8095542001565326, 0.47096123144401125, 0.8075344615247401, 0.6415019279559337, 0.779665756931722, 0.6189856594286507, 0.5037641757387495, 0.5599062419813519},
    {0.45659433968140684, -0.003577900740640937, 0.38819803907138256, 0.5880488802983544, 0.39991689665386565, -0.1975798415826919, 0.5107181666988917, 0.4522527706753853, 0.7862154866301261, 0.45098534482613817, 0.558863046355344, 0.4832563901722509, 0.565631991126678, 0.4245966870325169, 0.7670093083790014, 0.15395119372269994, 0.7593088090484785, 0.8411398559067788, 0.48482298263585444, 0.44390623561836645, 0.7982129130911796, 0.32806838533718863, 0.6497423571790195, 0.670754660899038, 0.5075820171268599, 0.487751161296602, 0.531363731348992, 0.60496789824801, 0.7067315764211767, 0.7818915007690522, 0.5834451224650239, 0.6748018603392155},
    {0.47431808380964635, 0.03853187119682623, 0.47633386245684606, 0.4654729331704476, 0.5005860784762758, 0.17607321307151505, 0.47095503364310926, 0.7562566280076333, 0.5835158889396512, 0.8019119313216166, 0.5345596465965696, 0.3584123812044139, 0.570588621121706, 0.27811341578393484, 0.6363576560471714, 0.1851005472012055, 0.816991119471483, 0.48680808784452045, 0.4201361239122636, 0.7503795395104055, 0.8569370893275332, 0.7428202738448554, 0.5898048199223068, 0.7197108591054777, 0.6755961611067408, 0.386786321470436, 0.4454231386107652, 0.8683925985583839, 0.8182663848672701, 0.7790333008701089, 0.36317570857731585, 0.7558787993033992},
    {0.6221960211417433, -0.12828036516319957, 0.2820109550902415, 0.43059811651185087, 0.44199694587884336, -0.2859308209492814, 0.4526123626913314, 0.6098879479809526, 0.43045793243029296, 0.8008616303509407, 0.7349930710001856, 0.7043238789072623, 0.3601101362045356, 0.3349925139335291, 0.5409950061137344, 0.29737110509011877, 0.5723901455919981, 0.4825503796938569, 0.4255053982884704, 0.3861174102563485, 0.43026935673195077, 0.5485867467347186, 0.746356593681792, 0.6563690325950653, 0.5968988221986091, 0.45530510961643844, 0.615989917422574, 0.527695182418102, 0.8123181028096123, 0.5524358055809789, 0.48161649680335145, 0.39480051462048094},
    {0.3296553349714192, -0.12742950323647667, 0.6617293642427221, 0.4298238247321015, 0.7818086014326628, -0.04399716863594586, 0.5562494556743404, 0.404444156883399, 0.6632125423462916, 0.3693910404596633, 0.41662196337209134, 0.34415678786583526, 0.6902720528310272, 0.3902828958676608, 0.5368589186233149, 0.29979796575058604, 0.7490807938116559, 0.35859650989018194, 0.7638044113983932, 0.7103971211713475, 0.7542449432580431, 0.647220341875032, 0.38596893869788435, 0.5730127638172231, 0.3385604238465049, 0.6740428743904958, 0.5608136617282234, 0.36852276363099085, 0.5172919456952948, 0.5481305858471958, 0.6957443713632598, 0.6858744871401375},
    {0.5562248648553795, 0.00678907430499726, 0.4461128785330316, 0.8366777679922047, 0.62225062819697, -0.12949766478743113, 0.6754693822273018, 0.6196019503193009, 0.556238633433282, 0.7398282437326733, 0.4308123719955352, 0.43237352841231547, 0.5992135474622259, 0.1960100938930798, 0.8160476627879065, 0.09476778193191943, 0.5480177521291826, 0.6743117072001064, 0.5843437154276591, 0.5491225383222581, 0.5341364142221241, 0.6381820036635535, 0.7133266024618338, 0.6178874049988725, 0.7767551175028142, 0.6321962855521172, 0.7203854148478871, 0.5239227120157266, 0.8598287314320631, 0.7756431295276691, 0.8649428577848023, 0.6865564415188823},
    {0.4335197609472181, -0.006974975701850254, 0.3923337561659014, 0.7341589734603521, 0.6595817373290283, -0.2653669848732612, 0.7455877104606842, 0.3836601123921971, 0.41989676451656466, 0.6301557815834414, 0.6058336057532907, 0.5483380070130371, 0.42160858067229773, 0.37330769669899216, 0.5097256632373555, 0.0524185236538733, 0.8629784001383691, 0.603313838525193, 0.4800834737109847, 0.6465273092545957, 0.73446194551945, 0.59204533390643, 0.7946311362466228, 0.4705571747500048, 0.44257171652282357, 0.49874653657658696, 0.564895178113718, 0.4323229788255422, 0.8219810701728452, 0.7904944571681333, 0.5992986983215834, 0.6638996404007542},
    {0.5840700331349661, -0.13792912919013617, 0.32234742556528617, 0.2767991980740585, 0.2849044640589546, -0.0766903788568471, 0.4027733533201057, 0.4332118318485367, 0.7499830575120237, 0.7072031304521018, 0.7112664219000039, 0.4606528233490788, 0.26514734266414614, 0.2356293376933562, 0.5368809305609676, 0.3186536562748011, 0.7848649765773609, 0.3579201893937569, 0.5856208722729085, 0.6005332136968232, 0.44210681655235873, 0.37423512157885896, 0.5313419663168403, 0.4124508738144465, 0.7486691783939061, 0.7391453143259179, 0.6010596288561854, 0.3592691417315564, 0.5611940195802768, 0.7748356425882017, 0.5722270142225366, 0.6495859208868041},
    {0.6718974916137763, 0.16495183696027735, 0.6791054851861156, 0.6014615510208883, 0.42767477231350864, -0.1020807490429771, 0.5276591723275108, 0.6653822032616928, 0.641140456318539, 0.533176159059579, 0.41861561631856076, 0.6917627099857583, 0.5372708255733947, 0.27308342236242944, 0.5744805582753434, 0.18169137726179876, 0.4808458003460874, 0.46917916792230424, 0.5478838052717369, 0.4985971954467068, 0.844301586025214, 0.7204397728596226, 0.4602832579711771, 0.3808135771203792, 0.44683154192813584, 0.5269375895442818, 0.4739157638071402, 0.7429009340093786, 0.8980718116516189, 0.6261595326711399, 0.7099924999119374, 0.4802165095050124},
    {0.6374791795047755, -0.03633002084589303, 0.7275873037857737, 0.7159251169188645, 0.7864261391980454, -0.09135365327246361, 0.770712124638284, 0.7954406442882967, 0.693764295338342, 0.41001914692996344, 0.5102091084887342, 0.764706828215744, 0.3750548628122249, 0.4344227938043237, 0.5461740895645534, 0.3807400904721099, 0.455698368064992, 0.4459238544462349, 0.5232864319421966, 0.5179352998119022, 0.743300529104793, 0.667980227227713, 0.5241231609322234, 0.3541759180159999, 0.390601196537221, 0.8233883282360255, 0.47276300010279926, 0.559509894029614, 0.6242245798130185, 0.8284984793059769, 0.7330668814028972, 0.6369401805005869},
    {0.5933750067160593, -0.0009196725219754126, 0.689003987498183, 0.40963652998759964, 0.743470041354052, 0.1191501722788689, 0.8676240134487891, 0.794077806159941, 0.6585433149990633, 0.4058291650530852, 0.4032692980905856, 0.44679172950116147, 0.7197382273282479, 0.5517819858491628, 0.8314687380091631, 0.14548064521755932, 0.41640938056873833, 0.6481380340536778, 0.479337256765449, 0.7146137351999622, 0.5771872827408248, 0.7574896651064684, 0.40102801674670285, 0.7313077376763517, 0.5638676551127297, 0.5912315528734678, 0.3821374790609554, 0.4219184371480812, 0.6803965235174579, 0.7711654419624735, 0.6470514703361997, 0.45531160403456783},
    {0.72842107346182, -0.2218831332781193, 0.7204195126099714, 0.3034890585376656, 0.7350192478663036, -0.22947420706811572, 0.4772706982739052, 0.8086553826496556, 0.6024792224528198, 0.5047667189938874, 0.3800055393891164, 0.5083167751688212, 0.5109739154257515, 0.5204032946607987, 0.7649885664185441, 0.05623746081267697, 0.35952641941634494, 0.86248896687621, 0.8341326845942383, 0.7776300303396447, 0.6329123644396586, 0.557320104487748, 0.5316007239248819, 0.4815357142981282, 0.643125336223723, 0.8255803199451188, 0.3782239426099323, 0.6671001682144987, 0.6543395713696005, 0.750434989282835, 0.36922790133211963, 0.4945580703935546},
    {0.555008185396049, 0.006725512938951691, 0.5563444499443865, 0.547925124849449, 0.7277513949126139, -0.10446105659056511, 0.675363383282327, 0.6997369400156401, 0.43682706689252165, 0.7383758074700063, 0.44450740114746995, 0.634450511079773, 0.7091937011105325, 0.10011996061975927, 0.6039461730755138, 0.33497467024837524, 0.47850718004880954, 0.4606986355962018, 0.7201090477980833, 0.7221412184604582, 0.4593587114590942, 0.7950306324309632, 0.4988953096494552, 0.28475513108353195, 0.5739904758320649, 0.7568090511748389, 0.7111145012253686, 0.6099799215704202, 0.7296104829980825, 0.6673411381046687, 0.3884880823022439, 0.39781571857958165},
    {0.6988190812033306, -0.2570498785042986, 0.5359440518561797, 0.6262180712515281, 0.46749709172766485, 0.0060888354617105785, 0.6344257812675442, 0.8715836823233984, 0.6771565100523094, 0.8430702205838286, 0.4339766410231863, 0.7099828458098506, 0.7668834552569137, 0.5701197294742001, 0.622993336896554, 0.21835928398766472, 0.6066739859245999, 0.6271454306664317, 0.350032594394436, 0.6554486260757821, 0.8404527987737568, 0.8164535258825725, 0.40333052684525605, 0.6240151494000633, 0.6319225192713166, 0.5623338929127941, 0.6494844501648331, 0.4000004090760055, 0.7822533659026041, 0.6623755938539234, 0.7810357665246045, 0.540190868976123},
    {0.6215400943974784, 0.1322402556155354, 0.39651880125797667, 0.4030368143586624, 0.797061551337502, 0.15121745846252896, 0.6724512143851239, 0.42748699998133266, 0.5446526415031592, 0.3596097406406959, 0.5967544536790557, 0.7858393466895742, 0.7203185104240983, 0.5545160176374315, 0.4917303780302953, -0.010578403748146285, 0.5129611974526669, 0.8801244383043018, 0.7960888651847856, 0.6226047295336625, 0.6001570631582581, 0.46869875305304276, 0.6594820585042325, 0.6987726318870192, 0.49602325950488424, 0.5869255623726177, 0.765959812938086, 0.5854257752043899, 0.8000615586797555, 0.6681881578345752, 0.5754607866382414, 0.4420048054693187},
    {0.379722530553019, -0.2104680617905081, 0.3454670551240074, 0.7418241883138271, 0.382704708249514, 0.1390045027306566, 0.691767547154672, 0.36678823984403225, 0.4320516475270002, 0.6022138294921032, 0.7129203495940408, 0.5512930922213336, 0.498293900650453, 0.17956887755165948, 0.32715045149146954, 0.31670584221226294, 0.41085047995115015, 0.359205865534572, 0.5812971458914045, 0.33964335999539186, 0.6368095987415608, 0.5254951934455063, 0.5311720374444899, 0.2894510629559114, 0.48438527841477524, 0.6156172715995499, 0.48407748257199007, 0.6597278913536081, 0.6641787584142447, 0.6539184271350638, 0.7112086678187767, 0.6153655899499508},
    {0.6616789563039489, -0.23361166943821907, 0.5796262982178113, 0.5066886994921679, 0.786097888258544, 0.04568422600748307, 0.6632510178531535, 0.3969960523375522, 0.6036216548688685, 0.44037813917483626, 0.6617914880869445, 0.5293053389069454, 0.5054176148667764, 0.3142197734126817, 0.7923742714218601, 0.033168840599398626, 0.5444662044383015, 0.5394237487189031, 0.6161908556307328, 0.7644119966215656, 0.49647536331785874, 0.653270479503822, 0.6397174699311977, 0.7566582518581748, 0.5427326397969283, 0.5898043514308092, 0.6342471174247738, 0.6299769713611035, 0.6898062058945145, 0.6779919161347979, 0.6474968708916268, 0.45661446456788696},
    {0.52104097514521, -0.16666389101799922, 0.310072488888485, 0.5630768072396986, 0.6475742691886145, -0.17217147003480668, 0.7480749496502922, 0.44039005244016904, 0.687445734302992, 0.6890045485550186, 0.5905104304504933, 0.3274204525620709, 0.7935046244208828, 0.5221381982546222, 0.8156019680645753, 0.1565621301437992, 0.44226096078756316, 0.7254550192315686, 0.5515890435488048, 0.76152196227909, 0.6197109919188359, 0.47922940422825, 0.8009593362848711, 0.658395157142502, 0.7786599558631415, 0.5855552501615608, 0.4316497684682107, 0.33846724159627456, 0.5907297233389517, 0.5825372100393357, 0.7923552437447845, 0.6055291666153185},
    {0.35355553323470473, 0.1545162137867397, 0.7004715557820144, 0.4433781501574627, 0.6198779768811487, 0.08720722417051657, 0.5491953444037073, 0.404159383810126, 0.5531782306868646, 0.7584180347029266, 0.7358323021999672, 0.6058855262888401, 0.7647336725642079, 0.1878673358573387, 0.6661399139632758, 0.265366783764811, 0.7508356801616272, 0.6425399633413439, 0.7614430993969576, 0.5241972865167346, 0.3685310726585434, 0.320964727589118, 0.3940005717369693, 0.47566066854313704, 0.6061470357347619, 0.700700195196213, 0.4822078116972041, 0.6042788098559185, 0.7939917346858655, 0.4778139936879632, 0.37449750929489783, 0.7303787449497862},
    {0.8166008489480233, -0.03673124848051931, 0.6820429336721849, 0.6703210723829565, 0.5457664184735641, -0.02340213747946601, 0.5630373081607362, 0.6834755586483968, 0.38952764819924085, 0.5869441549615398, 0.44606825025164737, 0.6116061330377104, 0.5092849254477334, 0.1499016497566652, 0.6904991892030838, 0.26631358910850983, 0.6484830910917474, 0.8325509739387392, 0.510118633856404, 0.6521865954014788, 0.76041847115521, 0.3967992194037664, 0.681234538505588, 0.5742095053096969, 0.47954622236308825, 0.7737522515346926, 0.8542710235446107, 0.5213060528897034, 0.8328103774915964, 0.8071016302246964, 0.5874364214120146, 0.37058751932701506},
    {0.7061739196376622, -0.05095638484847207, 0.2803011225256427, 0.752517383454901, 0.36041809075641124, 0.19567008932721816, 0.7479059237126979, 0.5048259900578954, 0.7052502723294142, 0.6924177667290992, 0.804944473904027, 0.423223059548124, 0.6679171608995298, 0.3193496245109773, 0.44764544444976084, 0.4273134163897378, 0.47808785207325943, 0.3911673305206225, 0.4399272367258756, 0.7263000857732875, 0.5407599461667179, 0.45301683578020757, 0.6297006394011612, 0.5226847847756418, 0.5462507993321221, 0.8557517569921791, 0.440445150664557, 0.590439318731093, 0.6654663634120918, 0.40350061546008065, 0.6242641901942774, 0.5952398249890721},
    {0.6477109050939053, 0.15673926229550997, 0.6484064204724872, 0.5121669753186247, 0.5084424763549423, 0.06285151181877194, 0.5160920325421593, 0.7287322538272004, 0.6305477203962421, 0.5284597569197588, 0.5079248667452644, 0.3652261458860516, 0.49771235678518566, 0.23508999531164826, 0.5018214006294952, 0.28352527676216727, 0.7056700181135971, 0.8148688438493439, 0.5743738259861534, 0.7488318963196542, 0.5628979335394738, 0.5103077503915435, 0.5957675939142736, 0.728053577801231, 0.5048576470676184, 0.4171519828814346, 0.5529638665430492, 0.3980964347073133, 0.3904495038654582, 0.8510169202394858, 0.6798454341581567, 0.5816739926383764},
    {0.5634310614029016, 0.01828941904635631, 0.5655964867550798, 0.42006069412001695, 0.46758242529680616, -0.0671924473764786, 0.42526508534117025, 0.381980504561186, 0.7631091952543076, 0.4788785030418514, 0.44235240583280205, 0.7436808206209155, 0.5139384024636903, 0.5031220109929725, 0.7723181311187629, 0.2375401863175447, 0.5841825625614118, 0.4415918750765185, 0.5566875831257067, 0.6725309241732693, 0.43093856449010737, 0.5150969370255418, 0.5680916254972271, 0.42691348016558195, 0.5002915600396884, 0.531717348023273, 0.63933794375392, 0.4433314440521912, 0.599360882637859, 0.3469246063682928, 0.6162053227559462, 0.45540201643918926},
    {0.5799020846064413, -0.22499122333931593, 0.44030142898691865, 0.35433970230267525, 0.3826362043982565, -0.020199984600167243, 0.519388478734028, 0.5059199194787211, 0.7948523892723103, 0.6553165011382096, 0.7108927177388324, 0.40350935910300767, 0.717498418106567, 0.400931078305631, 0.4396872389505393, 0.038322980738602956, 0.4457950582846203, 0.8362385133414313, 0.6215728953161036, 0.4179068109642919, 0.5033896237511793, 0.4755390392581085, 0.4161900632605866, 0.7079538839758904, 0.5244966044428955, 0.694359370351324, 0.550918492084257, 0.5126689608681835, 0.5139905950492567, 0.7687816270556546, 0.5931752237097222, 0.404181260749501},
    {0.6706637385358127, -0.18928924203262665, 0.5851874447994144, 0.6070069340810557, 0.8033554778555508, -0.19653672653880816, 0.4997834210708974, 0.3797401499751035, 0.47255323093149826, 0.7387382563866255, 0.5227607379272186, 0.382230996095925, 0.7745810493220195, 0.5161565265924304, 0.7183843538285141, 0.3404598647363925, 0.8083141558059973, 0.8590611417367524, 0.8136152409032809, 0.7434571101555335, 0.4750863934557818, 0.5249790542410536, 0.3665718667290718, 0.5943580308463141, 0.6577613102954335, 0.5099415423707866, 0.778539475936532, 0.7679681677422046, 0.6735992369446762, 0.4269546660825761, 0.8177709891588361, 0.5625451764916867},
    {0.728503937711346, -0.2637523471616333, 0.64562622646597, 0.6609008303974181, 0.3202439706808042, -0.07292824918405667, 0.4985433477341106, 0.4123143476176696, 0.4619509712959772, 0.632285789490746, 0.37514964910955195, 0.7008430812342215, 0.3091127873731354, 0.49117895412864787, 0.7494452731569624, 0.02088996330041327, 0.4670546583378269, 0.49188949389236925, 0.5362829979790799, 0.5440328183333001, 0.3341227436327758, 0.28710518768071963, 0.38496994542062557, 0.6705227907252234, 0.31370854334627857, 0.7468400327638832, 0.4351946304914719, 0.3704926290603497, 0.7589757875722453, 0.6592331693419295, 0.6449378404956492, 0.8029563255533444},
    {0.47636551032854557, 0.21920453331495085, 0.3900835279557569, 0.571334742198902, 0.5841898377539737, 0.17534719475240745, 0.5311409790174966, 0.758808973353197, 0.8633533963122195, 0.45990712859198873, 0.3672306314689617, 0.5634872301826844, 0.8052325504848522, 0.30634218772147453, 0.4057043497660032, -0.05718483912523059, 0.4683683625343685, 0.4758721111880473, 0.40470316940019935, 0.7986059380954847, 0.518847830380947, 0.47825914008702025, 0.5953807870069538, 0.38211248962374544, 0.7671973389388455, 0.5861757225291333, 0.6158677965582843, 0.8452661440586073, 0.8703763766318101, 0.7500584891952772, 0.5749209447964005, 0.5043219501571924},
    {0.5213773783255159, -0.13610340957929334, 0.3864895704618846, 0.4763027579337072, 0.7790515283566082, -0.22451649753291797, 0.7458083020040132, 0.6166962428089386, 0.39426048467219427, 0.3776799013526006, 0.7952327479208819, 0.6018980423983178, 0.5541970211986744, 0.24721712635134066, 0.6467218338452574, 0.08539733977957371, 0.8655242866409233, 0.673092998578066, 0.7160132380913191, 0.809485044211675, 0.49103158113572415, 0.5508915929151668, 0.34917570012724386, 0.3425833678385356, 0.5086958724750609, 0.5123798859827915, 0.6606388933673673, 0.6782541883446007, 0.62298492670451, 0.6816960857708021, 0.5406225291648628, 0.7806870094344349},
    {0.7417707279995777, -0.26070843883417544, 0.3620025958261332, 0.4236050103882585, 0.5531856408295439, 0.03082517028988577, 0.6499224139199912, 0.45625138229619533, 0.8063903788169998, 0.7109411806216036, 0.7062849718418368, 0.44574057342340406, 0.5016117811598582, 0.17448421296386, 0.4315169998180161, 0.29315218943619414, 0.6748270464906957, 0.6061813903629274, 0.4736247138868207, 0.3830847552657926, 0.6583246897387912, 0.5070453493496765, 0.7435763463755627, 0.31488178910533415, 0.5972038482444746, 0.40045842408478705, 0.7726006457683069, 0.3751021104685734, 0.7570846685516859, 0.4499300304191857, 0.6231347204962495, 0.5483440428645341},
    {0.6934189728352623, 0.007749997905790145, 0.6814657214259916, 0.6223594094727264, 0.4022008964616687, -0.26663431643394514, 0.6393219443828716, 0.6579857033749438, 0.6036932822073909, 0.7407778074631833, 0.32306450457130964, 0.577528451679287, 0.4854019764519386, 0.23067288697194818, 0.8408701570769093, 0.3462545049865116, 0.5948965906782656, 0.8209459360188328, 0.5240040056197431, 0.657657002137791, 0.7375557357642959, 0.6973075377912107, 0.7169648965840962, 0.3791573300671504, 0.5541693943978764, 0.6637486508143648, 0.6457490984662725, 0.7697094490849749, 0.4538169503604558, 0.5186673122131242, 0.5462037634227238, 0.7621480758868386},
    {0.7226301812778048, -0.24712823881642554, 0.5445755540997301, 0.6099766808986957, 0.7882705357799342, -0.0503302110272727, 0.5477420749573658, 0.47554974778876424, 0.8647139739372507, 0.6094113578809129, 0.7380258142721869, 0.48080659154802424, 0.42666128336799425, 0.5136097403444209, 0.4904265599679882, 0.17397227459046796, 0.5810288466060504, 0.8259042938149039, 0.5670637008236139, 0.5623180297875817, 0.6783822610946595, 0.624366974332446, 0.5964305364678351, 0.29653192188024524, 0.6353323959092267, 0.665616189595142, 0.7949770874196549, 0.3603331505847503, 0.5356809641341825, 0.4961955802707086, 0.5962886323415135, 0.695766826291377},
    {0.4000704490465034, 0.11189469031714028, 0.45991504278997564, 0.4626883687158723, 0.6293966730367618, 0.036657676038823396, 0.4254331051526106, 0.506232747458022, 0.6932992924131577, 0.7544900808254172, 0.32074903050114323, 0.6910602073991328, 0.34559279237819585, 0.09820646532204468, 0.81680402131447, 0.06440321573497822, 0.6311142766541062, 0.6984579579882676, 0.6019178637882961, 0.797413038393221, 0.3704345164134364, 0.6849527094692281, 0.5171670168094453, 0.530270608400553, 0.8203726811705969, 0.6660791007584327, 0.6186617475708268, 0.4178308704647138, 0.603000969660014, 0.6171108721309408, 0.3746587203346717, 0.38196055921601063},
    {0.685917975419914, 0.1761530361941695, 0.378199963658608, 0.6641714458870787, 0.7562941514871447, -0.25160191581764635, 0.7887301942695888, 0.8176443368392888, 0.6299180542042809, 0.5602994457699608, 0.5002067216592855, 0.5107324774841362, 0.6213209011228183, 0.11071621744319483, 0.6362214466796804, 0.3818843507965757, 0.591173117878682, 0.5352890312130557, 0.6878348049608894, 0.5471533119122254, 0.6688455896858299, 0.5622143587474815, 0.41925059730571285, 0.43533876469742677, 0.8689510108834162, 0.6621037351884802, 0.4667887415048789, 0.4761392489841384, 0.5350390662297333, 0.7023047180739505, 0.831472032571469, 0.437898715155401},
    {0.7659653621953382, -0.002583001206296316, 0.5071829789792102, 0.7996852651517428, 0.788670955341416, 0.12202817343720138, 0.440829974412523, 0.45931548709231385, 0.8428471336734811, 0.6073617349237806, 0.3954669363767846, 0.7142953370264811, 0.6625485476736288, 0.17786870949351752, 0.5440730519025911, 0.2894711814166121, 0.6884084439384829, 0.45104468524457614, 0.5653592862153621, 0.42069219642790273, 0.7831437229869979, 0.5308518738976881, 0.6522146433356464, 0.619033867576276, 0.7540459918982193, 0.6757011294308484, 0.5346649858482103, 0.5693841908927632, 0.7880262941642721, 0.8448918059196296, 0.45983804593932226, 0.6195963316166416},
    {0.5073293014182264, 0.047636167880625566, 0.5180291841434963, 0.7953865014655745, 0.42789930387471287, 0.004146822193379929, 0.44265919112667274, 0.41340990860608134, 0.7344401207134013, 0.8471088070788726, 0.41666131171853305, 0.6552697183854257, 0.7481901169470967, 0.3171198087396017, 0.6608598674378672, 0.026601130997994205, 0.5066500491349771, 0.5249538079764263, 0.6431263192045239, 0.5296914499055241, 0.8254976695979465, 0.5689768092395447, 0.7566887593072334, 0.5160527685614236, 0.4375142653583134, 0.48746490242117524, 0.7801961232955764, 0.7491446439854993, 0.41785294402025874, 0.7043437528977134, 0.6011198402586577, 0.8278818552156704},
    {0.5380956388425797, 0.1967070379012746, 0.46605679821569646, 0.48955349336146214, 0.8299705942537756, -0.06881902195317048, 0.7786769705899448, 0.4708430394319923, 0.5378448222393373, 0.59579236573607, 0.3925707458703434, 0.6060328336615377, 0.6072869243295057, 0.5161051198335249, 0.5862117352304516, 0.0961100989444857, 0.4104570840010548, 0.6618977072915613, 0.5136978051327676, 0.8332918244479907, 0.6113211398467245, 0.6953470263006332, 0.7294183319444305, 0.38815138473465355, 0.49196766750842935, 0.39133440894040833, 0.7132924074601419, 0.5137477032721741, 0.7519723475104549, 0.4755173589641506, 0.3559842032222845, 0.6803230859110542},
    {0.8295955398524306, -0.20357393867807153, 0.7025032435313744, 0.803447864641132, 0.7950211818275535, -0.2698780266414627, 0.7268036392704155, 0.753445903406932, 0.7499847466072362, 0.6044012367563255, 0.826316754960107, 0.6478726924327491, 0.5002692174552704, 0.45247480662708867, 0.8779715740375773, 0.4000784151446454, 0.864957040112138, 0.8051713889553791, 0.5442120663337227, 0.6306198024905154, 0.46823318657327195, 0.7304074336533416, 0.48925009810967157, 0.5333704303158366, 0.6534594571056679, 0.5076763574662329, 0.48713152125145615, 0.5529065803241271, 0.5925921036132515, 0.7612991796392954, 0.6615699249324339, 0.7453160394129578},
    {0.5286613248447372, -0.19494968334999313, 0.6968502274558345, 0.6320681367177088, 0.8152390313410625, 0.01885805864656368, 0.853515624017609, 0.453021297349321, 0.5142453269816597, 0.44971295518425947, 0.6974900030618076, 0.6339249458732875, 0.7300382465353145, 0.3935108172508624, 0.77338458976834, 0.04865960989318121, 0.7120324576598476, 0.4800932427041659, 0.6830125014696117, 0.6000285597918338, 0.5824153817582849, 0.5557005757969192, 0.617786726026519, 0.4818735015076231, 0.4248157947238082, 0.4676819544724228, 0.5918250122570451, 0.7275920574550547, 0.7556907959073125, 0.8244231797644271, 0.5344545087672831, 0.636562593380387},
    {0.5663465273234446, -0.04723144921818948, 0.6170213383260625, 0.4701568223180895, 0.7840573162333767, 0.03689683125658227, 0.7134457355290662, 0.8169030873609207, 0.5320872776343937, 0.6168201971171986, 0.737827581555334, 0.7460703367269479, 0.7828859317700412, 0.28187604676349515, 0.40734875309878077, -0.06100595654597009, 0.4979102729581773, 0.7591742891529842, 0.639579581018767, 0.6199144976345798, 0.7558829267304712, 0.7126902092207947, 0.6904561565401165, 0.6143156243110633, 0.82282056329007, 0.6621444713412099, 0.4605511291263511, 0.3957049209050402, 0.5903242781983351, 0.7111048406459491, 0.7632924519311864, 0.41885058447016044},
    {0.599287424482211, -0.01532976443998235, 0.31480552436722237, 0.711665271607541, 0.6789438439786689, 0.061134994133420065, 0.5296833877544282, 0.862156871085277, 0.49903416752082425, 0.7093963334692183, 0.5152213177864128, 0.6232673991120372, 0.5737124473737234, 0.059991853521801176, 0.4269472920878809, 0.16285636502751066, 0.5144863854010105, 0.8457890522301071, 0.8506646021995939, 0.7683426912203163, 0.8440467654858768, 0.5646301152580996, 0.6431530545783232, 0.6164646447134767, 0.7467889741591139, 0.6653540826899667, 0.4539360954187711, 0.36147015246045533, 0.7961582235287943, 0.8176645661714126, 0.6050417066399304, 0.7747359004381628},
    {0.576904025465683, -0.09870538664086959, 0.6731205422502216, 0.6533625442355174, 0.5255044112561187, -0.08039717065959658, 0.4335279317351595, 0.83463271288988, 0.6305687118907806, 0.49376670013287804, 0.40858779217575725, 0.4814003123261916, 0.38452334366981356, 0.5040360511610532, 0.6776238550517012, -0.006691182819601105, 0.842089003560207, 0.3817876016651493, 0.4034905822599607, 0.4774582492789344, 0.6472833523622918, 0.563437091496996, 0.7463314733704924, 0.7139818051077316, 0.7808919277113173, 0.4100180746604512, 0.4985804615589343, 0.8147728054085288, 0.5388256533661616, 0.8190225066903484, 0.8250751816131427, 0.7342773013094219}
};

static const float b2[32] = {0.5957512350379895, -0.043648702804493233, 0.5626119872476368, 0.5568926754112825, 0.5762102654337586, -0.04549673744071972, 0.6392381095898939, 0.5955451233283229, 0.5835319838787197, 0.6145871874772125, 0.587204393914193, 0.582138421167537, 0.5746509318279047, 0.35055777975830804, 0.5757758911765509, 0.23701876403479377, 0.6087319747587403, 0.603321654216275, 0.5938682528528321, 0.5570997130742992, 0.5951202299506287, 0.5379981489494196, 0.5622155363399498, 0.5047722423438336, 0.6193963588591112, 0.5876124152226828, 0.5837489062527497, 0.652721365421854, 0.6134739063729282, 0.5770237900894175, 0.5973605838376433, 0.6070363985745604};

static const float w3[32][16] = {
    {0.17956501480203987, 0.782568154420256, -0.1537398975792946, 0.3233484471064177, 0.6512892903189003, 0.6473961925824956, 0.5966337078587333, -0.1815742635718442, -0.18250676792195378, -0.05440138483253991, -0.3554316888745994, 0.9251536803102065, 0.6027039684553656, 0.06578358019972778, 0.8806508151377305, 0.5141917000268185},
    {0.09202666657504883, 0.06750855480021982, 0.1455679005176783, -0.11247371953347232, 0.08849904988896952, 0.23480177087324722, -0.1388653106292895, -0.0315841157194809, -0.048318508804264006, -0.3400631238574223, 0.19147432909003143, -0.29654006304069436, -0.16475691804833298, -0.1372442863526861, -0.12493468520368399, 0.16283769841710538},
    {0.3497791934174953, 0.5938944250782521, 0.001036650586849016, 0.931249048826371, 0.45735652320299547, 0.2929588203131041, 0.8420705248287306, -0.3925178104458428, -0.30760915078643103, -0.22305301523118368, 0.26114037275896906, 0.3209725170316007, 0.47371485081249265, 0.24133773060719743, 0.852994811740776, 0.3960816394051624},
    {-0.08678355664493949, 0.3011991719470131, -0.22133718452712575, 0.7347708720052967, 0.4075444349388079, 0.33867190613967724, 0.7699211174309121, 0.0019162366970596739, 0.22110771629352152, 0.1975583259543973, -0.10648024832228824, 0.8185124257610903, 0.9081096736117076, -0.05120872622090842, 0.9196694221426813, 0.6731280184866111},
    {-0.29491938937822804, 0.38480413673163283, -0.033335967205373636, 0.7930576919888271, 0.778779352921604, 0.48728201305962643, 0.4987322633789017, 0.0940984001969882, 0.055088441830494966, 0.04178160174060172, 0.11035611313410201, 0.45765452201755447, 0.6683962978082962, 0.17324200684323166, 0.8627397943061551, 0.8213332142435695},
    {-0.031212255026607405, -0.10822466170040056, 0.014588249510363178, -0.19505599599810217, -0.2920237985878689, -0.14880948215603254, -0.07977843232032385, 0.13965344549170727, -0.14184866947654645, 0.07982653458939609, -0.16232714283494057, 0.06714769044802878, -0.07879825095829414, 0.06571817540678199, 0.10316443877974749, 0.0430928621250049},
    {-0.261495270081949, 0.35136418141396286, -0.1485764394910801, 0.5648432401172105, 0.8666795791380366, 0.5986862928535625, 0.7534944045017035, -0.24073537599238665, -0.0603106910166072, -0.3459398153207963, -0.33052386600857814, 0.5375985317918922, 1.022290462092605, 0.31856418060592423, 0.7349508508943795, 0.3901608882597324},
    {-0.16818282186126554, 0.7994142131405568, -0.04774668576923231, 0.6618746035027799, 0.6978260795413033, 0.7694278323396091, 0.9376784548978385, -0.13967754643988625, -0.24238058832646892, -0.3231332218744568, 0.1693097519157764, 0.7515648672606015, 0.7959646722158681, -0.07603544989974291, 0.6455148793666275, 0.7807881880743216},
    {-0.11171496100503657, 0.5077207585375578, -0.036295730524908566, 0.7529523549795377, 1.014357242830864, 0.5428552502030519, 0.6119993394185606, -0.009733431997922088, -0.3183568655941249, -0.08298025520639046, -0.23010412469857275, 0.6383419467653103, 0.7799108557393657, -0.15576547717249747, 0.6158984563282339, 0.6535908436785773},
    {0.03178351479976554, 0.5953024512406384, -0.12667389535582638, 0.30083303473547346, 0.9351689228671761, 0.529719109989407, 0.8929631975073935, 0.13240001937840604, -0.1466210433884507, 0.1758313463575957, 0.28141021107919306, 0.48072807598174044, 0.5467343485594588, 0.2835512624542345, 0.618018465317654, 0.34866118289186265},
    {-0.021263998768508603, 0.7416679716816815, 0.10259187036898827, 0.920075962586548, 0.5791099716748084, 0.8234245810424021, 0.46236254501670065, -0.33253714430626047, 0.18347539666581997, -0.3493799346564516, 0.08825972696893529, 0.9566927446075587, 0.803468357699424, -0.24519279625997192, 1.0408486754581372, 0.6442111803813978},
    {-0.27497697479582384, 0.5423487021756745, -0.16802442025072417, 0.4406265601086384, 0.6000296188201317, 0.901638709746028, 0.6114421653478795, 0.28508223118576503, 0.13943367188790282, -0.36122076060068065, -0.1258957302443553, 0.6615330255119736, 0.6703366238473342, -0.20427108862139676, 0.97529945109282, 0.3600077911448955},
    {-0.27657227698796666, 0.9581668490056612, -0.16871199153146976, 0.9050764423743899, 0.6265338411898876, 0.5244499882077731, 0.750351343233628, -0.21644313198629575, 0.24240243116087815, -0.24457660109273363, 0.3066479975709534, 0.6553899406774182, 0.34858167896886255, -0.15047955386122425, 0.8801281954199487, 0.6744256551340402},
    {-0.1875302284695734, 0.4025649915915202, -0.3617575844491391, 0.48208754485793, 0.8238491646946109, 0.7823310523989295, 0.35745262119443716, -0.034277403864664394, -0.26522678500661717, 0.25720574896895304, 0.23549569334252626, 0.21902421743423028, 0.486211367381146, 0.3106932770863787, 0.23858341421676024, 0.8479583286312605},
    {0.05706397976607796, 0.5621647136073155, 0.04006249325882392, 0.3365813787326747, 0.7258644284562484, 0.8927567998436522, 0.8832120905672753, 0.2136265202485943, 0.11158074865325801, 0.0373334641744328, -0.24437030660176431, 0.7827652660131328, 0.48708148055070727, -0.13115172779735415, 0.4079461689306662, 0.8551526999384854},
    {-0.26597783392830654, 0.13247749198746236, 0.2794718777206296, 0.2595100639166977, 0.41880146369587257, 0.5660893263215614, 0.06459011457761712, -0.1706148944436609, -0.009253118259122811, 0.021238963681462185, 0.07649240444800806, 0.5945945836821815, 0.17900907317071074, -0.24482055367648387, 0.3126576729530719, 0.5016723928557946},
    {0.1990360704747483, 0.3643186015615143, 0.12261995172784955, 0.7772654363280959, 1.0127154577225543, 0.9534775908738021, 0.3592234287334381, -0.27253309019355143, -0.22981233902573286, 0.02492432570277456, -0.26324417789410237, 0.9357366737368963, 0.6274085105876069, -0.26824209176157143, 0.8415102002487246, 0.6161139225338131},
    {0.17563822503602777, 0.4808755258554903, -0.06649095547870466, 0.37238567328562444, 0.7365308660850582, 0.6274001280591275, 0.9811415950226295, 0.04556672204170825, -0.08503378624330674, -0.018156232930990456, 0.02198204229065828, 0.5309374596097125, 0.7143255805180996, -0.2748606476070364, 0.3143535117419137, 0.7526071003473106},
    {-0.11889109819213588, 0.5214752442758742, -0.08273883017599103, 0.45156095567538246, 0.6036577577273455, 0.8146277427342119, 0.945313850985093, -0.20746961646585982, -0.11189744886884287, -0.1372775373577724, 0.14242769341515904, 0.7147206590085926, 0.3828720825043645, 0.2434236529487035, 0.9838670752217298, 0.6339774933552839},
    {-0.24160965178688523, 0.2917804130619726, -0.21968759063988452, 0.8748252846301419, 0.6146456725973743, 0.4859152080227921, 0.5184769314522837, 0.2874927274153259, 0.15627530503636955, 0.057365553052277946, -0.23330923483004998, 0.9043256311112825, 0.394860146287433, -0.227208339675632, 0.988427407287642, 0.8630869691691778},
    {-0.3595354863030766, 0.5564287313244654, -0.12243128681683495, 0.6978019600302126, 0.8789952270119402, 0.8413022258369065, 0.8453582813134513, 0.03727246587518189, 0.13182707431949117, -0.04034365051228097, -0.09238871068312067, 0.5263397129125277, 0.6594128561969211, -0.02070793250570455, 0.798762504964908, 0.3940614042868958},
    {-0.3228966221979172, 0.8115562414769308, -0.1320956668650429, 0.6370654129034603, 0.4863958111271642, 0.637484275550968, 0.5782428889903074, -0.3403690024818619, -0.11197727474551547, -0.05446034385705857, 0.21577793525572292, 0.9664086768035471, 0.7396732610299593, 0.32605589612760305, 0.8369690725643016, 0.6880830187454401},
    {0.19451648372941632, 0.2670889380463974, 0.1992784909046261, 0.601637986480216, 0.6789800385362422, 0.9517694242795344, 0.3323386331274907, -0.06093984689203741, 0.1382595194064693, -0.31217182992445225, -0.37331224445242694, 0.9119135759873713, 0.5147423460089097, -0.3322726064441178, 0.9265550091537688, 0.9553884903895093},
    {-0.02865612146801347, 0.4250799057108431, -0.28809909914895887, 0.2656331399179399, 0.517747451516317, 0.6086069018882228, 0.5316889090509169, -0.3172938267912815, 0.14103605855729068, 0.17610130291758827, 0.15621170186642402, 0.7203336924427755, 0.8638436574126294, -0.1975764071195149, 0.615884734548797, 0.7158701383320601},
    {-0.22114765033170575, 0.5480437007534277, -0.20298189242135342, 0.5346744192954958, 0.6596864380034032, 0.7801683929715282, 0.7190935086385728, -0.0972486284453068, -0.23299282416222816, 0.03419689999528573, 0.16723347966705657, 0.8800655118300748, 0.681987677175429, -0.1933464060714588, 0.42719441584001994, 0.3102735339489934},
    {0.01828292694422637, 0.3215200881454532, -0.00494016141989912, 0.28000095564464245, 0.6193805802400507, 0.8249815651327552, 0.8882193652941173, 0.16095758584741113, 0.008218607236557809, -0.0494565691250707, 0.019303808070094627, 0.7128020685872186, 0.9149780371702565, -0.11026772220389412, 0.8926223214144468, 0.5029236894637774},
    {0.20726645940213137, 0.39074857765086435, 0.031098548794688517, 0.931869664740842, 0.9177674727110571, 0.6701916177121808, 0.6251618330473266, -0.16260002881688135, 0.15228245635564625, 0.2119037296589838, -0.08265337895119353, 0.7100943438760615, 0.8972422584629465, -0.18094276116704577, 0.9718386416129275, 0.6946131774363714},
    {0.2762206782721049, 0.7361655792052141, -0.23276840841509228, 0.39440491455715404, 0.8885592153305524, 0.29095484555892914, 0.6055742344871076, -0.024655416502667803, -0.13991863537732135, 0.16799304296180845, -0.3051120477148633, 0.8398094674463601, 0.8921729736786088, 0.10614571809207404, 0.4157994080947439, 0.5483957921595671},
    {-0.25268407295540274, 0.8237640548875742, 0.11852391478179536, 0.5231509560454474, 0.6094150644079724, 0.7259147332412585, 0.724068613611856, -0.33423009977591406, 0.19228405253260686, -0.15235445126755245, -0.22067534195815772, 0.7438914747970236, 0.6707875631581498, 0.147308514502843, 0.6570524226684549, 0.41266743142095147},
    {0.045871704957160475, 0.6042353066934454, -0.1861114192134983, 0.7578516884098061, 0.4738836546945566, 0.8385459782796845, 0.9590326136191576, -0.07590279003632527, 0.1137729060048178, -0.05272955064598166, 0.016629705835059374, 0.4742756055868366, 0.8752065850280867, -0.009197065446762192, 0.5453243517959131, 0.930716302218091},
    {-0.2177282967277925, 0.6550321268119432, -0.11762693012022402, 0.7878802159927358, 0.48428939809697674, 0.6194064640736429, 0.7473019556359694, -0.058625617008634355, -0.15445528794038071, -0.32396498147818137, 0.24757953733944824, 0.9710144320205492, 0.5132533239829518, -0.23962563442284218, 0.5374022535114674, 0.516120219319658},
    {-0.3214540222544655, 0.8957808478555552, 0.27910941270542466, 0.9371341478605513, 0.7609166691812941, 0.32478205817414313, 0.7070509907867749, 0.24327830523455785, -0.35147897442411935, 0.09371448359959988, 0.17623184147590687, 0.7507771385991218, 0.8933434260748538, -0.3356256538872307, 0.5139447987196095, 0.6528642729281846}
};

static const float b3[16] = {-0.028191369870229636, 0.5240504448135334, -0.026860139560448294, 0.44858981590912894, 0.3831065769104904, 0.45911462940687486, 0.38296943072494755, -0.050115459442345266, -0.041694838585067326, -0.04662731965860621, -0.0154095557916814, 0.4324680980217688, 0.4499843804114247, -0.01262920605652591, 0.46943143204258797, 0.4243440101816569};

static const float w4[16][12] = {
    {0.29922249790734656, -0.024583038125279455, 0.25601918792218503, -0.12525358225024724, 0.3452357713544925, -0.3663121313620463, -0.022248103154111246, 0.20134945014980643, -0.3202998110120727, -0.3748391038857272, -0.270821127712685, -0.03971277990319683},
    {-0.35693043467673224, -0.05436019567852504, -0.49574548525816164, -0.732859497272592, -0.6887842432667777, -0.6316771645497861, -0.961164845645378, -0.4224463269226521, -0.5205291078462614, -0.7663825775472396, -0.5863799082029716, -0.18112795835116527},
    {-0.3553847623753481, 0.3520823714222371, -0.3877919042590261, 0.25204971157182793, 0.2631586306432465, -0.4306789564767766, -0.2432110918195373, 0.3003214540304317, -0.41189081673586286, 0.08888363072044307, 0.17289486841956261, 0.24575978541171584},
    {-0.8485199614342497, -0.8264659863263497, -0.4062606108722865, -0.941589134359188, -0.4980671350077307, -0.4598268873136158, -0.9006529989754283, -0.2170272457134525, -0.3255331307919761, -0.21486345976409035, -0.7597224571084913, -0.5581670007269107},
    {-0.8317538261025866, -0.5187813398813059, -0.7363484521173919, -0.28305920514078026, -0.4308678563641691, -0.902101476919693, -0.8987991978086503, -0.476086286511567, -0.8825750014399583, -0.7554531115085451, -0.6952364577559396, -0.8457754535090699},
    {-0.31711890534253084, -0.6000759504043068, -0.9324901891312757, -0.6911097157789226, -0.11320667861320696, -0.7490770662851145, -0.626304013089463, -0.3386046182647265, -0.27089726601607067, -0.7083812154470662, -0.4536765385252767, -0.9058277008711235},
    {-0.7780090052504324, -0.9262953880905794, -0.23914770594368728, -0.5241268118694468, -0.9486046576759418, -0.916904050545675, -0.3351468227239176, -0.9117861507759012, -0.7108766497607205, -0.06439268204651521, -0.6988087677136829, -0.3368923997051755},
    {0.013190435392469968, 0.12298510230736934, -0.34407883051890575, 0.27503783216247235, -0.022529320448726114, 0.17885699400547755, -0.4068029174766794, -0.11604740828364647, -0.07546171382776605, 0.23626765425967938, -0.07223674903864012, 0.18775471572796773},
    {0.18200773177603424, -0.3499520346729149, -0.2252104118655031, -0.2015510726752779, 0.3983736945454366, 0.22324787687430064, -0.15372220212490897, 0.20779785760362232, -0.44861682452061236, -0.1386086665735799, 0.15697388274974525, 0.12409720180433627},
    {0.06512970117603499, -0.04463626081288286, 0.12184653247615675, 0.40757404485051846, 0.06489832250504338, -0.19920619544630894, -0.20170374870391383, 0.029549856700700206, -0.111822458177975, -0.43570567684187017, 0.2711537383073794, -0.19168678217338178},
    {0.3792673080418001, -0.12789755797429753, -0.2727018240803481, 0.41031800009413105, -0.48652427385531644, -0.2212663221412591, -0.07026081844318505, 0.38501857595388916, -0.29855987110469717, 0.2557434785305708, 0.3970032001234736, 0.1950897768171746},
    {-0.49125544498719664, -0.2926291109406951, -0.11554312438657695, -0.3045669306195764, -0.8194854543791663, -0.3584267332783542, -0.25321548817445216, -0.8986886297186303, -0.9330799432508556, -0.33121447753684685, -0.6697936485753749, -0.31595215784670444},
    {-0.3883167178764747, -0.6066599901383068, -0.7619164568600261, -0.5792615063742985, -0.4169410266931159, -0.9226101539736888, -0.5894358079292051, -0.3094142608810126, -0.03446660235942666, -0.9021940490769224, -0.44721718965911944, -0.5269730490873176},
    {-0.21959058936849346, -0.2075026590240038, 0.09998049131281676, 0.16579453352988183, -0.2574832580414752, 0.4288254268032027, -0.4240688784340955, 0.3455715181376523, 0.38364198945646755, -0.3893895289325224, -0.17721052248165245, -0.13533858800889154},
    {-0.5674436756209245, -0.8230646460468558, -0.44181738580606394, -0.6305989025430766, -0.6742887326846579, -0.07561999677031794, -0.29790285872083133, -0.7144081751100434, -0.49324866493939395, -0.43741292261600867, -0.28646762659708386, -0.7585402418900675},
    {-0.357988475009608, -0.2729722003526232, -0.8789904249765225, -0.3076142337401354, -0.3580914781351824, 0.01704296948026437, -0.27341588168531616, -0.6609454166724479, -0.8436918314165854, -0.9257809057466391, -0.4533831980600045, -0.6149937516435509}
};

static const float b4[12] = {-0.12262008981390829, -0.1421130838028974, -0.14836648863858137, -0.20840244762727092, -0.20353746486767027, -0.12967502800160638, -0.1558799349503165, -0.2751453645052235, -0.17252501169441942, -0.1594194301334347, -0.25057433660263817, -0.13285870835716942};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
