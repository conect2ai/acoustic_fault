#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.3950428156472593, 0.46505342664697963, -0.6893775978806508, -0.12127762678674807, -0.7764477025773803, -1.1712761072189528, 0.7925178266958794, -0.8174546026152365, -0.9069911792540439, -0.783913225530341, -0.1423013698951242, -0.7875298508132885, -0.8874304278712634, -0.3788634261772584, -0.4669026166482271, -0.7538339172614311, -0.9987240411985887, -0.25351275804711076, -0.6248730205966604, -0.5195857544534411, -0.19321195642305342, -0.8556924979852752, -0.1540557666966916, -0.9201224445867849, -0.09759482091613565, -0.11359076517913082, -0.8332820884680623, -1.2580911398280634, -1.013582746395175, -1.285754963899569, -0.5793904472096723, -1.0051817840619837, -0.9640935222278398, -0.16195930711486883, -0.010842513804215363, 0.0038079455320627277, -0.7489978089398633, -0.5904318859378926, 0.47337941432304764, -0.7973404464954734, -0.8635881891382908, -0.4251199760301975, -0.008754467164916358, -0.556085889488592, -0.5394130759192864, -0.8700877263842596, -0.956592160099239, -0.6905593067602029, -0.8207156639015859, -0.026843772710433287, -0.8399156269346405, 0.24626502678171186, -0.7170989998944491, 0.33652005177242683, -0.7823545118846917, -0.31694588168409443, -0.6714238252952083, -0.991695428817358, -0.7469710199792537, -0.3818806077949681, -1.0549162922109852, -0.5481077838299052, -0.7900610143666288, -1.0314833755882182},
    {-0.24171452254861428, -0.7290933648663028, 0.7942880315405701, -0.7157818775336858, 0.7217367983563517, -0.03314092118667199, -0.6851707525960444, 0.34212293477282146, -0.4970642090134363, 0.6665600546062159, -0.6250601388444768, 0.9884659452705961, 0.6671368485188583, 0.6088913440285484, -0.26078331036757024, 0.5972108616422824, -0.07276955198571856, 0.37955373127995323, 0.5207444106730157, -0.6686681389688892, 0.26856635342802276, -0.5342397971815627, -0.1003882390064308, 0.2717612431147103, 0.09186492951323315, 0.44184742687323514, 0.6239962769119366, 0.5766315556516547, 0.6351066670127689, -0.5315193099106319, -0.9124655817773313, -0.27893203642608494, 0.9747981676020138, -0.312503843115965, 0.7389820189083306, -1.0559302750152586, -0.43456741224617695, 0.5303276841290202, -0.6107445378719609, -0.2673604627616535, 0.42755621474342026, -0.31322524864714046, -0.6224816301105521, -0.30573043950779666, -0.5796909912077751, 0.42706427367716576, 0.4487971992789765, 0.48388057873256923, 0.3755468194223244, -1.0549264213310765, -0.13989241518198658, -0.78272272199742, 0.09947810724442434, -0.4547858804290758, 0.6548375554511423, -0.7357604019038334, -0.04878453772669456, 0.6726356982716777, 0.57303610013149, 0.7145706333922449, -0.4641792005901582, -0.4071941115027605, 0.785548598871051, 1.2642152559258966},
    {0.20802808348004884, 0.17001642044577506, -0.022336117385812145, 0.4888633213192008, 0.7851236550513057, 0.9092509873262277, 0.06975691883438703, 0.5516847889368051, 0.16393444244800146, 0.578499811562241, 1.2464574067393765, -0.42619433764000725, 0.6720419394234771, -0.050613669359477406, 0.5819325473918027, 0.6511704634857485, 0.9324779050451941, -0.08962313451297746, 0.1396155490763962, 0.30185444158468033, 0.00440067721161794, 0.5010021473817763, 0.4561823224354348, 0.3120608988978124, 0.3246145315523671, 1.0228028793508346, 0.24439917179186682, 0.14823592399639976, 0.5629798068502456, 0.7712943442029838, 0.5353115624053356, 0.2622165839193555, 0.2132627391059505, -0.05542374079486148, -0.7535219513159245, 0.52398431338961, 0.6955102328081161, 0.781003787510224, 0.46944434274950236, 0.4822772164189591, 1.1132750179830437, 0.3328300669084642, 0.41029731896084964, 0.6698305947062567, 0.7092990253498164, 0.9485165137322581, 1.2017695595055164, 0.5711527745058075, 0.12345136941196355, 0.9816128276420272, 0.20760073016047464, 0.344585048400131, 0.40321356496812855, -0.1331396956459521, 0.48065553384817744, -0.029334222289647018, 0.9174184135735659, 0.41109388000151253, 0.7365388062985477, -0.6719655505112812, 0.5009507598810188, 0.4545267907842951, 0.9067519166995033, -0.2301824347418148},
    {0.044335185020717253, 0.5325298645293443, 0.09319216017930851, 0.817589641589556, -0.3059922226152681, 0.7481985293369949, 0.6346813503134004, 0.7084789195516115, 0.8661717845705657, -0.040980549131419804, 1.324330152332973, -0.9251590335331542, -0.1501672591419018, -0.34329043853047925, 0.7183231188876923, -0.17829803114380205, 0.7918198004392355, -0.569993953778828, -0.7012570603514281, 0.2741686287893171, -0.21820753243754354, 0.5667271767043353, 0.337219039253952, 0.42842147268569614, 0.3141073278141318, -0.22091007843658328, 0.25484308725708027, -0.530172002112713, -0.42443170654767043, 1.0101689448843936, 0.8789444725035751, 0.4339851931685402, -0.5616359587867148, 0.7082901276452418, -0.7663909947508689, 0.9699021897819712, 1.1345742099625444, 0.21738401384261696, 0.5884995511469902, 0.8626905981999076, 0.5001332507309383, 0.2522647209657185, 0.9317476632877435, 0.8807308503932856, 0.8464136102737775, -0.3169106366245154, 0.41301042195158594, -0.8447970363424949, 0.1444640763068195, 1.179630025629986, 0.47395659368509857, 0.8195877236949615, 0.39337887677943945, 0.1209732871697325, -0.16413134161144233, 0.612754481561573, 0.03125703979849402, 0.5330447516560957, -0.05408965198634693, -0.7728094252545085, 0.4748379238552044, 0.4907722287681425, 0.009076848756859927, -0.769267503325509},
    {0.05044301527067141, -0.02488802292876646, 0.11670925764936173, 0.41972163265279316, 0.5179106380427264, 0.8195551824875822, -0.3022840739590394, 0.2197421325099622, 0.7849836316140084, 0.4914953940106178, 1.0866181577816587, -0.7708468919799414, 0.6488887602956235, 0.3218343679377566, 0.7845712664861173, 0.14828791760896257, 0.8503454408131295, -0.40197402864711557, 0.16880442549670607, 0.5256035290846296, -0.2792626197726769, 0.5008028667295058, -0.1222671009112134, 0.6400744072421188, -0.4069333331731614, 0.34477588030993384, 0.6732546324466148, 0.5981261213507003, 1.0724330411840657, 0.8856295927415545, 0.8970322839356284, 0.6043108342395489, 0.3843226642560092, 0.27711063011427917, -0.896095276611061, 0.41901056988032903, 0.47391721072131604, 1.0867066250538673, -0.019574500951902135, 0.704772858505175, 1.0872728208137772, 0.5154965233469301, 0.17488416409561178, 0.7243882816640956, 0.543895323011923, 0.45520925423121855, 0.5751840348527959, 0.7016170187004177, 0.5756513121365867, 0.5981538158255241, 0.6287275923893128, 0.5829432807891914, -0.16958027204261045, -0.31767354667847325, 0.6276601541204144, 0.7061460442866336, 0.9218404700568043, 0.7720536966849901, 1.0130730183804666, -0.39958986084764064, 0.8297689591698376, 0.705922557187272, 0.2570996331556296, -0.701071533397569},
    {-0.13569429602289426, -0.19163260709840121, 0.05071908166413421, -0.032861017388482607, 0.5230199528068703, 1.1480180937244737, -0.5665811198285912, 0.1697042611096062, 0.7837845167853462, 0.5612944887529903, 0.9199568545556474, -0.7714514949953928, 0.9529102461019288, -0.3859838162719306, 0.7972986086766503, 0.6948583143916063, 1.1834848115859298, -0.16799485992536736, 0.02474916308383172, 0.5547766701693468, -0.6581051501022178, 0.8964613274392303, 0.494886749341682, 0.22833872855932724, -0.6865371223604453, 0.514154244316306, -0.18135725596502106, 0.9055123451470346, 0.8412747635915766, 0.9901882111445901, 0.9660735300801763, 0.27616669137821154, 0.3422489377107286, 0.2910555416775253, -1.168054330697766, 0.3956977049176953, 0.8218680044729932, 1.1686895206104584, 0.42977676777400287, 1.043553424159815, 0.8713985586369771, 1.01336866671684, 0.3080073830587302, 0.37034749101350295, 0.36629636811544614, 0.8727458653524569, 0.9545140908987008, 0.7433077913824384, 0.35390158202103783, 0.8113820336944473, 0.9086505645510555, 0.6815033798504258, 0.09282573565532119, -0.44586074635629785, 0.9841796595515462, 0.31221640999084027, 0.9307500224576539, 0.8855776516697453, 0.8845104691142571, -0.025459866327888585, 0.9576685513811255, 0.43736174593210453, -0.0755906677944676, 0.09169966747300969},
    {0.05026198048670844, 0.13433797560540203, -0.2094739938164783, 0.4906940816192537, 0.15796110991839002, 1.093771799203084, -0.12779435334888636, 0.4858359855543057, 1.053256029889828, 0.4603521373996293, 0.6548006951205009, -0.5991041398923559, 1.0761728201605283, -0.6891665845057012, 0.5723345976460351, 0.6414784942860574, 1.12007711244455, -0.44317115327776274, -0.2628627187429461, 0.6381268645571868, -0.9785738309118724, 0.893832090075511, 0.42049988314551656, 0.34932288528200917, -0.6810098080556841, 0.4493461331870078, -0.32172469493806116, 1.011392426228435, 0.4797989848894623, 1.0306409919425292, 0.60707221046821, 0.5635826678942863, 0.22647937250248606, 0.31943472354798247, -1.2500995691255996, 0.5040341479318582, 0.8227334645660688, 0.7369292712950722, 0.31035343152770795, 1.2466396576138608, 1.1158718421288576, 0.7636815413072625, 0.3071039563893124, 0.9791929141287242, 0.37098670843569925, 0.6850772291355133, 1.1207117058582345, 0.5713506060307034, 0.008800811487912976, 0.7820352756847356, 0.6598263331495362, 1.0638246630238148, 0.22697841988291548, -0.624110979829529, 0.33720121680209764, 0.12395783412791139, 0.9455138506229888, 0.9792428995737618, 1.0633898017259362, -0.1659082824062072, 0.959382515858073, -0.048691510751053824, -0.07386594826146423, 0.14838946362958852},
    {0.29182594228026093, -0.3440286542936668, 0.22514592981379555, -0.11938122435779919, 0.11157852511862307, 0.3215308535228537, -0.47558749022240443, 0.640706723685576, 0.12359690438075675, 0.8986189152187315, -0.5046872490001171, 0.2668298972329426, 0.444030450950925, -0.15873041340303307, -0.5857536255211309, 0.5084555054519605, 0.10938813944693183, -0.12459885501941131, 0.1249239820724763, -0.1682275183022912, -0.4060782166900812, -0.12420148948611909, -0.16406505065970878, 0.022685225543436282, -0.4455488167956762, -0.028234819722376882, 0.6310704554162244, 0.5782259544801827, 0.2601147990840507, -0.04563229409784596, -0.28284485450250085, 0.20544667065931602, 0.10926454318307216, 0.13387452535873695, -0.6173221237848368, -0.9353605350048785, -0.40256833083123517, 0.19731040661048105, -0.5965961856831361, 0.07568280353347473, 0.5644396430849332, 0.019116403109194498, -0.6087570720997156, -0.5555165613859241, -0.6122317929589467, 0.4749814092865515, 0.23874447383785777, 0.4150714170834998, 0.34987011703385595, -0.04653901501708991, 0.15926158276852587, -0.19377383345657517, -0.31818295100586164, -0.28066104384038676, 0.15355457155497806, -0.611357801103408, 0.4348824685616167, 0.4909687771337901, 0.7167604378547494, 0.12170991941613352, -0.20223814292603742, -0.3756483479328059, 0.6156848422424478, -0.009085659228300806},
    {-0.37884886635110226, -0.6731897248425771, 0.907890393002568, 0.19857496756194135, 0.8488619934731632, 0.4045799375220713, -0.2412125932295861, -0.2226371409900817, -0.07490485683755196, 0.5639996685624361, -0.3684214784876645, 0.23331745718545577, 0.8523532352773889, -0.6313108094182448, 0.14656980156142313, 0.7656094534662752, 0.37989736276941666, 0.3392864594720744, 0.12264206190879413, 0.13050407978730127, -0.5121201152588204, 0.21434981517943155, -0.5293788978661531, 0.24814338487988785, -0.33572803146546776, -0.02977637495356981, 0.4446772410054639, 0.5251649286406583, 0.5550316217018197, -0.23174483489395806, -0.6212392497179537, -0.438539811641316, 0.7396857506272125, -0.3368342049973256, -0.33807498849609197, -0.8193869404823185, -0.2775192064456533, 0.7824830498354529, -0.11800277354881811, 0.19752073292025474, 0.30119690769375, 0.1631602863652496, -0.3426790533030137, -0.17266202731248587, 0.18641953475913456, 0.5349452477433715, 0.7104484045888542, 0.2839040423031745, 0.11799209730150938, -0.22108285900402108, -0.007447660529820832, -0.2214462513113401, 0.475624660589455, -0.07784871122962017, 0.564028629127974, -0.630566861860666, 0.5045033075840359, 0.6051664515266819, 0.17206901870003105, -0.4392862744119148, -0.34905393049837247, 0.031830734672274257, 0.29807806996539404, 0.20738495977937307},
    {0.16947421994784903, -0.38949727141509904, 0.01622479012290206, -0.03096157818189809, -0.4413830928600612, -0.2213739590908007, -0.9598078993243374, 0.13377004588507393, -0.6803873565759767, 0.6796957418465928, -0.935345165228591, 0.611391353075855, 0.31009344487527957, 0.7634323886389272, -0.46341704645140175, -0.03142600428066583, -0.5731322914623754, 0.8553233384540103, 0.8581476658660968, -0.21848431357057868, 0.48177899470529617, 0.08113829319815806, -0.14543610659656706, 0.1162005379666389, 0.8237071214359514, -0.16943744694743038, 0.061270249856847175, 0.22689026983069133, 0.45004673399340217, -0.7545828574623533, -1.038189238796817, -0.21513025942231095, 0.8272007421859222, -0.2960025758048102, 0.5580829147710116, -0.8030835915886997, -0.34023043402750835, -0.10698051333779714, -0.3060808971086778, -0.17824944953766803, -0.36463776240777807, 0.10824083202973579, -0.6951748993286605, -0.3811753355548238, -1.041770163728945, 0.3309437562172031, -0.3010869576491613, -0.08833319064348782, 0.6067275555045055, -0.9279486967449843, -0.1864151296093835, -0.6017359004669329, -0.18457644459681558, 0.1971619096473007, 0.2396641179136985, -0.5904506835892098, -0.3429008900690823, 0.5116070009954022, -0.05283951933959112, 1.0137108806631594, -0.2347333954324181, -0.7206750520805079, 0.3919656874419475, 0.9912461701632735},
    {-0.1360509859980614, -0.5328618702467491, -0.4549227820171758, -0.20438467422280282, -0.35832518020580784, 0.023504454066971846, -0.5891156777506035, -0.46108364548662695, -0.0982511657590512, -0.07082067928091666, -0.6180278139770856, -0.0009032063134665932, 0.2670978619469597, 0.4897621379969301, 0.12793495210379402, 0.06062837619447444, -0.14831888191903606, -0.0253512622996107, -0.41686857231887525, -0.3387211775796665, 0.46929540845346013, 0.35194779682231786, 0.1435639364178556, 0.08452761036311505, 0.6002394970450703, 0.2012370191606727, -0.04586014222921901, 0.4263836427615346, 0.3823215551352375, 0.19635798326269144, -0.12172738327880064, 0.0508278123073011, 0.5662794757537324, -0.08158638833552234, -0.10327374863585773, -0.039285172182563916, 0.320726895974537, -0.18638728678623834, -0.19148252814773806, -0.22748890143087067, -0.7014728419217908, 0.5570803130356237, -0.46058421784090325, -0.08018710771197682, 0.08753299684589713, 0.2533922945727777, -0.46475282763029746, 0.3502415163557168, -0.19966440219919457, -0.05528404546631286, -0.0990171036929762, 0.11049771678923649, -0.13452749775898246, 0.05484025700119577, 0.2511337456519647, 0.1549741054934525, -0.4133199391056516, 0.18219349403154733, -0.22188121932040175, 0.4577272328037738, -0.005994292472379108, -0.5546292350068067, 0.12685533456521908, 0.3431706203994225},
    {0.015880982225330787, 0.22564246721304923, -0.05620940067366105, 0.45851070143707706, 0.28602066099307416, -0.17420425136085393, 0.6300794618730496, 0.4851486847066302, 0.09839560900779586, -0.22990418225896497, 0.3540470279517479, 0.13638335399737755, 0.5372028408504061, 0.007922354018041387, -0.3166994257412589, 0.1820087644737178, 0.20292335135160042, 0.09525602774596725, 0.48492319929096733, -0.10011352655259151, 0.18564227271780723, 0.8630895194809716, -0.10862991861371117, 0.12497910604396018, 0.18409769027530276, 0.20104667498846887, 0.10426076779191057, -0.23625349238243426, -0.21577051540552206, -0.44672110198421117, -0.002896761597808741, -0.864557557048808, 0.15938252847863493, -0.09538445551713756, 0.4050020580686508, 0.32598878419186433, 0.31019306769893695, 0.7101279143010395, 0.2764712654571143, 0.3769977351534593, -0.23905794426304627, -0.09620867824014889, 0.4354716497030294, -0.5230436061595412, 0.6203278637680448, 0.025964446751678177, 0.8714598651034422, 0.26456440842446083, 0.28231817232493933, 0.7964514530110479, 0.6753035735004048, -0.3244233113588674, 0.5479645287448274, 0.2540313775753182, -0.002360175977140929, 0.10000835417128649, 0.22418567045652782, 0.5580382986690096, -0.4726957177115555, -0.6050531615618638, -0.3918945298034908, 0.03839774186434548, 0.7141928683223067, 0.11505070287634253},
    {-0.1403736508007804, -0.5882556673336229, 0.32774003900024945, -0.6666462354211664, 0.6392656853678483, 0.053057589804906574, -0.8260558707557459, -0.5729251235747406, -0.3714609128882481, 0.2876257825231658, -0.44223398535458563, 1.305389431655995, 0.662635293007614, 0.232251545229707, 0.25198896823066047, 0.8514966030167099, -0.11427638855587853, -0.11031456869950236, 0.22898030793646204, 0.0003550362203228688, 0.0072982435041370804, -0.05440055759934376, 0.24695745510943298, -0.094483923021583, 0.0691404828891579, 0.6484576266090578, -0.1859872545810686, 1.1751546818264618, 0.758495324867121, -0.35414919955294555, -0.5891966076382381, -0.29710319099143345, 0.6006915434801592, -0.8460920130370353, 0.23879649594498237, -0.805951088853938, -0.2166270016833404, 0.628772041128763, -0.6982366954306201, -0.1982286717439526, -0.10640274362983558, -0.036749791820494815, -0.6983810148782198, -0.7687961310594472, -0.5280342111659917, 0.6065467063873388, 0.43964126537376563, 0.4970104744762115, -0.1482524631750328, -0.49586878080645863, -0.26531048026862175, -0.6551893064574702, -0.2803553981117372, -0.7135973617618149, 0.6851413830544305, -0.40807212124245557, 0.22123714952797502, -0.7304458112759608, 0.4482473097877171, 0.5865547997010095, 0.11259374257516849, -0.20773782827029816, 0.5925937776307851, 0.6529579650427743},
    {-0.3906531762101907, -0.13662030753109605, -0.49364471521050785, 0.1689429048676057, -0.8013845699056986, -0.2229785722007393, 0.6278839309230598, 0.08088950132988602, 0.8687689425067596, -0.4473654028580271, 0.35545196282147096, -0.6044486056111215, -0.24521095021726205, -0.524033969949241, 0.18744787773119556, -0.4213142791814154, 0.4296918534898297, 0.05108808586483737, -0.46286367067408807, 0.01653313502538324, -0.7408871396861492, 0.030456523123306725, 0.10392478725667362, -0.2577961196042146, -0.3856503396761809, 0.08115022189557836, -0.21132978789826296, -0.38136581825602955, -0.3587764576815748, 0.6987031985270513, 0.5161940761698509, -0.20183462723863643, -0.31976169264585225, 0.3160656479232431, -0.5247161380965539, 0.5520708728178854, 0.4148902901823144, -0.17285415077242822, 0.7857129138205419, 0.380650667045238, -0.7400343977297934, 0.7086280775949324, 0.4646041125347618, 1.164825397964813, 0.7387278133585664, -0.5613035595424901, 0.3779903397115485, -0.6161615772030081, -0.2718795346345756, 0.7349540278923493, 0.8577210301878467, 0.41203093458465917, 0.9991737956185537, 0.2760078072351913, -0.6547646334531922, 0.6867624813646234, -0.6400118176628922, -0.050703321308997615, -0.6176055157031003, -0.5134323044898744, 0.028261191481404255, -0.3616001065510124, -0.40335854586218933, -0.01838991298129697},
    {-0.4609928171779788, -0.06040086029567131, -1.0128726456327224, -0.11521209627884106, -0.8680137489470466, -0.2940026798637047, 0.3771873606821576, -0.7945182539482318, 0.7689616713359487, -0.7364797044855844, 0.5343553603698534, -0.7083767459816886, -0.19429686426310555, -0.7906965216752602, 0.2229667282489059, -0.27559177346861835, 0.34574472918556304, -0.3471465659482157, -0.8818111566768098, 0.6079597262312456, -0.940546322114576, -0.10978874804706064, -0.7416836017248252, -0.7906168856080442, -0.9920365639383754, -0.11124970555337331, -0.42609715144507804, -0.6139581004232265, -0.773448110955646, 1.098586189966305, 0.7128754521090201, -0.28375578537675983, -0.9051882095838409, 0.055308362998542075, -1.0668560064089356, 0.8666970133530411, 0.5624636356362348, 0.5081353553657153, 1.026568442334779, 0.06229732137949971, -0.6865339580819253, -0.09701446422657099, 0.46323608153710705, 0.8216215617400849, 0.8490540010818455, -0.829682382883377, 0.6085299951959687, -0.7030806503499593, -0.8472499048371371, 0.550267897459618, 0.45088130936343296, 0.36349775088926706, 0.20969223533398326, 0.03996189271021405, -1.0508359998689965, 0.07659892796741198, -0.4766537937106003, -0.6415091853932633, -0.8553824995595748, -0.7402177185732474, -0.32430749840895884, -0.2573538317741021, -0.9097822836136603, -0.6580051914363981},
    {-1.1327251074442308, -0.6557898398941059, -0.2276037413732721, -0.8374704621132746, 0.2816444605210091, -0.8619983154609854, -0.3647634842956841, -0.736067799191228, 0.1346981153580108, -0.5499141442711849, -0.7097665447749825, 0.3779492919448582, 0.14303803344206706, -0.4580014829781393, 0.2849951447310919, 0.23212944513203496, -0.17827732583899977, 0.0696842865070928, -0.288541428066374, 0.2630474366260146, -0.6605134553465198, -0.5982301786522365, -0.7897377461025579, -0.5417666765235083, -0.8406487113975335, 0.7133384246707926, -0.44978027375763907, 0.2292242972563817, 0.11378077235032273, 0.3980008212414007, 0.06377799371539145, -0.22225899701659682, -0.09323489409834189, -0.5629673049823791, -0.5470417321859777, -0.1868250892183336, -0.035120959663357265, 0.37722564498869765, 0.0342556011569218, -0.5597046222384924, -0.5116055113302904, 0.021118945876885623, -0.36322647109763045, 0.24730823969933394, 0.8125480349022898, -0.1591624817033954, 0.4806662102787707, 0.027674916517309866, -0.7918066259405745, -0.6831906070861608, 0.06894225934893146, -0.737838803059935, -0.15548463887499941, -0.3708640414812641, -0.5589394047770814, -0.5081955217499692, -0.45583428757080435, -0.8453401943363116, -0.45705264907644094, 0.5729252117023151, -0.4123551080782455, -0.057863348567575114, -0.8983293776736612, 0.23191370646304188},
    {-0.38791026417610597, -0.363172409641425, -0.5865929265531387, -0.3280206604937737, -0.49590346619443293, -0.20416756109578812, 0.344827373910399, 0.4089364694173163, 1.0561051695359471, -0.589491155399796, 0.43552493401916337, -0.39161877930881134, 0.2525717075940558, -0.8146834767835739, 0.33186983319680763, -0.504533536886803, 0.5389973155311399, -0.44458223781013645, -0.5991935321411833, 0.3358640304317668, -0.9214494759293522, 0.6326203284413887, -0.3113722402596052, -0.10571195925197006, -0.8295675898677852, -0.15499870610405317, -0.2587078660719623, 0.05177877793694288, -0.12350758651750794, 0.47944426090923664, 0.20730062810016772, 0.38525248053503724, -0.17783189618235015, 0.28117072625612677, -0.6832381082478598, 0.5857190698691928, 0.02526210316426434, 0.33995459063009725, 1.013300712118503, 0.6381819110135599, -0.22838343995653448, 0.45271194201459575, 0.8652072972046548, 0.7583621901549197, 0.5547721788117951, -0.50522473088363, 0.7079339153059078, -0.8882919124897709, -0.16442014751927056, 0.5087366091696778, 0.42868702202297115, 0.7982652687167968, 0.14823783471427324, -0.11017761872955611, -0.26751178034458667, 0.1035864115290563, -0.19482933256899812, -0.10804564276994066, -0.5264625331164646, -0.3703983615074986, 0.14162612570624067, -0.4336818567988585, -0.406237845922805, -0.03843367456838811},
    {-0.34497470162598676, -0.3523576508817091, -0.8307931514893852, -0.3167103052235084, -0.6530079472828341, 0.08164289097415721, 0.20924926529562912, -0.38440612284019415, 0.8015683638337862, -0.6156636710425326, 0.24886836080871702, -0.603670530561805, 0.236089386761956, -0.8296842269464284, 0.4587472309501792, 0.04503895663348649, 0.7331992101666659, -0.03307026127490752, -0.37983101180769036, 0.7136567368232177, -0.577882264768424, 0.8119887980692727, 0.00803784851211038, -0.3691382839530619, -0.8967238148113461, 0.04282991141548112, -0.649193043520119, -0.03280657939172101, -0.03587290546825651, 0.8676268740899324, 0.6877272737187284, 0.12910746262850734, -0.29126283353079985, -0.18009397374934835, -0.8444112975756657, 0.4296201549267921, 0.5537851176599308, 0.6425407961462251, 0.4828730484267975, 0.8249271153152801, -0.2663199823723258, 0.3804493243399439, 0.2510725147504624, 0.5985261418074881, 0.7651550615180872, -0.09208851989527007, 0.46078151604728274, -0.10056830750906942, -0.5816953761606928, 0.6332585011543244, 0.6858463781482149, 0.1726290342497352, 0.045727702655372016, -0.45447996514528755, -0.2784838685576496, 0.20829410209587035, -0.07827209283216194, 0.051387680250188514, -0.3194325642264761, -0.20129958099726114, -0.03510011239607146, -0.47671588428217926, -0.7019867701292434, -0.03407586921541039},
    {0.016374315734107175, 0.4234185244941255, -0.06281206147593878, -0.17858784240212455, 0.05456238221324749, -0.11831925931754414, 0.1544902932336801, 0.3234923779733146, 0.8856188228980001, -0.41307923552969433, 0.5660717515782806, 0.006731941923306523, -0.012598212859147395, -0.5969145545584003, 0.13217250268242045, 0.005766041668047206, 0.2897299431224601, -0.7400305758798709, -0.6969630127520309, 0.5271803135264874, -0.3943852638430262, 0.3186585704442513, -0.09755586616830213, 0.012254352433556178, -0.6653471200723912, -0.012326135815721293, -0.03237858549090106, -0.10727860854034571, -0.028466728989237546, 0.4440938171134445, 0.42078625851827955, 0.19800566688091137, -0.24428513613528813, 0.08725073434998144, -0.8219429662005718, 0.3347544103397511, 0.23658237527930961, 0.5105889784585436, 0.19085780807056493, 0.3457631234156982, 0.22070609413435432, 0.07904455017048329, 0.4967456210147214, -0.006866691901686728, 0.8167274757878696, -0.10732808389705237, 0.9103417325042427, -0.08928722695313249, -0.3229520867435742, 0.7826023918092095, 0.7131463213024051, 0.25994272672920726, 0.5662834665960257, -0.577636338069441, 0.2423065427558204, 0.00434631476695923, 0.7136631698354134, -0.051587724822501554, -0.2943099800018365, -0.6669779452586427, 0.6581333209229769, -0.0385553458631649, -0.4195310598792457, -0.13763917972771325},
    {0.4294944534763093, 0.34841657144266586, -0.32011765696427036, -0.010440224307509308, -0.3778176366735628, -0.5031241654561838, -0.038731217759250314, 0.3062731562039846, 0.19287727795272894, -0.3271631657972438, 0.6333210938335502, -0.23160028532372315, -0.45353924049928995, 0.10426393452462929, 0.267701604784502, -0.16743677460797418, -0.27689706644874873, 0.15689764077112558, -0.7406598531472381, -0.6190907049790303, -0.1338413735142265, 0.11797828478278627, 0.3267530661802491, 0.179187331746669, 0.3616673524199996, -0.08220468664364876, 0.48666870237795756, 0.046848180755000385, -0.5431771771621952, -0.02798237045553819, -0.2672199531671675, -0.0029449215159236077, -0.22117202380405468, 0.1803082182743781, 0.22280798904982307, 0.6189204282673049, 0.4686054510490216, -0.19301422290290768, -0.4467277597822897, 0.4001652905982618, -0.9085416521206789, 0.36368479207966425, 0.26939114692033944, 0.444061272548008, -0.1278662929959662, -0.21829062473304706, -0.10010588190317586, -0.4696963009144904, -0.37246188550093534, 0.432702814033981, 0.07622228765018405, 0.5738866830921898, 0.3093317344331936, 0.39039974768916985, 0.07856441842903876, 0.5628410490534156, 0.003420106920725369, -0.3337533695902147, -0.23676374020718383, 0.16753907076974978, 0.5169603395788178, -0.6688321323415191, 0.27711234395740686, 0.05046596488172611},
    {-0.11985732796698133, 0.042261402049835486, -0.017741174650662966, 0.41881638917258085, -0.638716671177829, -0.8020526945182878, 0.5601331040032015, -0.02379846307105058, 0.7733326032555612, -0.5134982284315636, 0.6971878761131276, -0.41114040009879627, -0.9865533701852319, -0.6247561473388129, 0.20338067049967423, -0.7043991340429145, 0.13905914626177754, -0.4745312765784026, -0.5661382211590865, -0.02214201091115845, -0.1949895033379332, -0.20586901653851822, -0.3077962042754616, 0.4844358901067727, -0.44695162477121786, -0.9999310715282115, 0.6741866881180377, -0.567343760240864, -0.6612795563904481, 0.27273359376319345, 0.5332485728205866, 0.43540355378408957, -0.8727599695106356, 0.026236772735658043, -0.4376056245102653, 1.1641314180675868, 0.1817787359804372, -0.8781679249935825, 0.41577658187376504, -0.17930066180419232, -0.12919575145663922, -0.0751717521774202, 0.8854961245463099, 0.7745152740600696, 0.4746338766498303, -0.4918191339455532, -0.5772661389964294, -1.0173495516562996, -0.5641893973645004, 0.876626952758747, 0.0007496106503409239, 0.7606043263147156, 0.21889311619953739, 0.26724014623553954, -0.6736312629807063, 0.45765303413617253, -0.583925591757643, -0.571029362477112, -0.7742701334224819, -0.28251523999412914, -0.28262561855259233, -0.020489017450071405, -0.2892436831283869, -0.30887181556057225},
    {0.5381770233220549, 0.3176939008980464, -0.8569341873813728, 0.2947424369177053, -0.9361582096273117, -0.38404568737519224, 0.649145441985882, 0.24075265735767842, 0.7680086651109983, -0.4969175301623295, -0.16189643491701125, -0.348296196704412, -0.7758951641409894, -0.49221261127260274, -0.0651509567877206, -0.7891540163433115, -0.39486813134911375, -0.07633834978668466, -0.2910978601649574, -0.3013612343495588, -0.016426978379988477, -0.21525607772232755, -0.09739120437477523, 0.10631466827459812, -0.02044907833714428, -0.7291125794942184, 0.5375919780589911, -0.6529118267302959, -0.7524981818390005, 0.5485472499232928, 0.5049418340531301, 0.9271211391285118, -0.7052654979266858, 0.26989071350582705, 0.5269076002413535, 0.5104467610909481, 0.2968874744641427, -0.832640518556415, 0.49237678079018576, 0.1160722787150357, -0.8065972878629141, 0.2040909250575091, 0.6189242178972989, 0.6837232445041007, 0.21285264212785338, -0.742484515393061, -0.6474833979047165, -0.9896959251881854, -0.27728446871582724, 0.14687869105541654, -0.0685958502176557, 0.523826604974718, 0.43628254106104924, 0.3175516925943511, -1.513215069980728, 0.5169886179206683, -1.1350768894637202, -0.37865713095985065, -0.33855147063056357, -0.003670249154942496, -0.1830600590063063, 0.04088809250903638, -0.28899364649706855, 0.16735243184280463},
    {-0.05416007604650412, 0.5744187590375477, -0.3118177448366043, 0.521361473820299, -0.7622138061156838, -0.7241036088909902, 0.6457199128885999, 0.517192433942949, 0.2924999455896257, -0.6812831514732948, -0.1911958312235163, -0.09393139325441843, -0.9238481259750937, -0.24282995338030294, 0.07801199064454593, -0.9528114117942106, -0.3071117446517952, -0.08827838214660952, -0.47737420803653774, -0.0561678095582789, 0.21344196079090066, -0.4477463320695836, 0.12769934345979733, 0.13526674967446417, 0.35874650758402976, -0.5712013445697812, 0.6216486727921721, -0.7619327697605901, -0.7265898026431161, 0.012556874890449153, 0.4369354229732147, 0.7050734773555478, -0.9213017350360491, 0.42060368084321564, 0.06802548710678484, 0.9442300524015592, 0.3392634748150953, -0.5591494283363889, 0.27518571349318505, -0.1758321307497245, -0.17405161506787512, -0.22001880295460494, 0.6235039176403572, 0.8728723764184388, 0.4700802214201655, -0.4135880802064084, -0.22598418805629542, -0.7507035563757449, -0.24819316069144168, 0.44664716993649556, 0.11095618243329304, 0.47733839765487585, 1.1062816776921012, 0.2681501744504853, -0.8551686492597266, 0.538177833101141, -0.6361888370684995, -0.6820452255415631, -0.43637544178982973, -0.41153093426051507, 0.18066185737013501, 0.3406799255692187, -0.28450420852429886, -0.17298695958022697},
    {0.5292230561452472, 0.37131173607477597, -0.0239572179325476, 0.6559821531243419, -0.5394139270802317, -0.5076009591863995, -0.09159158761368306, 0.792624619128548, 0.07736591937108243, 0.09661534577127834, -0.5569265147545712, -0.2708936720783489, -0.782096035584135, 0.6185331310911782, -0.6142913697144663, -0.9602901489164455, -0.6091404570771982, -0.201951211420977, -0.49241852579551254, -0.3671101057823597, 0.6163228827547367, 0.3352818399737461, 0.3643507603796295, 0.4212487947948866, 0.5888737379892472, -0.9836856488816642, 0.8202966651997416, -0.06575201998861716, -0.6595613528366512, -0.5711681698547741, 0.41982027227223284, 0.7012706253079222, -0.4326813610551592, 0.3613066713302775, 0.8258558049323966, 0.06276505758692356, -0.2243557488458924, -0.7723787575133372, -0.19154116790313555, -0.20685157339257884, -0.12794691243510467, -0.08960818564659176, 0.2285091455953052, -0.1341886867002404, -0.8271316833441403, -0.2436708213905077, -0.9364232869404912, -0.9503388329897323, 0.6299141574338122, -0.01824538359952915, -0.06442593393913516, 0.3671793850089841, 0.4342625102062202, 0.4455740542486243, -0.5541395857133127, 0.8140543327417609, -0.5500390303440053, -0.03284499563202295, -0.1681080309067009, 0.4608526193598944, 0.1460594933196341, -0.05334304757726573, 0.23481973634780304, -0.21155647414748543},
    {0.5801297752548, 0.659427902818856, -0.27142727782075315, 0.9965148174434295, -0.4848214121322384, 0.08199916407476684, 0.9386028737710985, 0.38507488469987633, 0.29987408590872844, 0.21930701206715786, 0.5986387854366311, -0.7432497250918727, -0.611840951773018, -0.007605943528123514, 0.15652769138718453, -0.9040749541443458, -0.3459238401520752, -0.40780545740081964, -0.5003338093099242, -0.0028278115463690684, 0.5797845531587162, 0.5819343704369199, 1.130725827713496, -0.013891617782258468, 0.8494795268517971, -0.49166358623593154, 0.6188588191622665, -0.5492638563514739, -1.2256948926405418, -0.11379454969916221, 0.3392668676636991, 0.6806769897560794, -0.23654642889078095, 0.15877758717265641, 0.6109811535311664, 0.8471829628317886, -0.1306741835012403, -0.7148550237959951, 0.4407513276319692, 0.29759840372563207, 0.09943134013968274, 0.10393090920506136, 0.8335792025608258, 0.5915557272644107, 0.10583955500912434, -0.5610515730707067, -0.43920561372740013, -0.6293521567394378, 0.12390456187571713, 0.8993903610056482, 0.1333788240582789, 0.914959130439396, 0.6451315665989079, 0.37090811199092705, -0.5745017964726625, 0.6655873983778832, -0.2783200955680645, -0.0096558979659994, -0.18263901926378515, -0.6140944166071552, 0.3992713917568253, -0.08658690254095883, 0.4019741081097745, -0.5835332312857194},
    {0.8226024717798762, 0.8120968004223905, 0.04126643428042764, 0.6186149251963404, -0.402511240963105, -0.19474276925858927, 0.6179754547429002, 0.9405153038481958, 0.14456687831266257, -0.19149625872628917, 0.36401423503192804, -0.5872835217960003, -0.8462988459629857, 0.31906004580097375, -0.09389998490127911, -0.7323301621054221, -0.43447441531750974, 0.15955348602144076, -0.20078843833055465, -0.6035004654669319, 0.6677740514352253, 0.4619774805195253, 0.7071616905007289, 0.6056421222703194, 0.9092344593705313, -0.8163195732626579, 0.46440848180345334, -1.0466578341704682, -0.7161664495460074, -0.8671639376010302, -0.006476212775861362, 0.3474646213040008, 0.08214732205525495, 0.7214930092146938, 1.0259319895133092, 0.7310636096809754, 0.02377646673045387, -0.9429326486094664, 0.6980489992201454, 0.22845543866309462, -0.15846288921001053, 0.15288568699312427, 0.7610045511304695, 0.23932296877313808, -0.0014240760241234643, -0.7243408944873154, -0.5488939840646605, -0.7287200637122699, 0.21135787213908855, 0.6400903401355426, -0.08412276716828863, 0.7090339937823013, 0.5367108890268208, 0.6393281531984295, -0.43581388073327604, 0.7986788762311646, 0.3088539817683505, 0.041051276518574015, -0.15472928041699618, -0.20282427827312635, -0.14872843389968707, 0.3036505078440278, 0.40653177813232366, -0.5004776270289246},
    {0.5807874144476612, 0.5935039976190326, -0.4866491205972566, 0.7528694064962373, -0.6627819271085462, -0.8731159408170241, 0.6050701936129708, 0.22950595927762993, 0.4200188910671374, -0.883930873191961, -0.12737803151604446, -0.14666390656665984, -0.9506780968684242, -0.3413758538985604, -0.5955180125510826, -0.8748890816144783, -0.7042033515381828, -0.35479466944863547, -0.25724173296268266, -0.3147466529552981, 0.20775961510787663, 0.1879049443197923, 0.27424613170550743, -0.01171666351084944, 0.4106926165935056, -1.1422850721551252, 0.4827680805239922, -0.9440921882411042, -0.9028181791669782, -0.5125497105094877, 0.5723697013227552, 0.2714164781249461, -0.6170439601846396, 0.7953528723830483, 0.6184336816492417, 0.9511675176993898, -0.22782803102572066, -1.1859854085363766, -0.013821309696109655, -0.35417226446877215, -0.8111325634167907, -0.4346373785812813, 0.8868338586530342, 0.18702789214525578, 0.3400977464796143, -1.1334118762884993, -0.8041045540573167, -0.8763915137445076, 0.21830365542444757, 0.22505473823464758, -0.2117021975470939, 0.6424776896671173, 0.3927689725278543, 0.6591380378345595, -0.8194709396733804, 0.9106961381571462, -0.8752531486234799, -0.3815884238446628, -0.9426433674362731, -0.34194805662430144, -0.10966313265364862, -0.4071686170288836, -0.3609229818696725, -0.3361416142949127},
    {0.6475803686581832, 0.7997108915959064, -0.19700833832357675, 0.8892765113249959, 0.4627789292810385, 0.36063878048413067, 0.13217506322394768, 0.6482729837846344, 0.3515710515311808, 0.3649251168569945, 0.4082927586942062, 0.28443288025725166, -0.5604013052291653, 0.7596769783272278, 0.6125565058579081, -0.19446244471666072, 0.17918363076529278, -0.1568668396812208, -0.26936966899603637, 0.3326893713392801, 0.6761079234908424, 0.39589834890242237, 0.7451121153816586, 0.4677245473557239, 0.70292341983595, 0.15523970552973645, 0.3133436359143119, 0.00950364193623321, 0.36300088591297097, -0.356796323441049, 0.6983077137857504, 0.991227673133415, 0.08145564102303418, 0.04284407198230563, 0.8441972061674141, 0.7452874389955779, -0.14644716846711572, -0.3098675765766376, -0.4337345906090743, 0.2275853504598053, 0.923216718659492, -0.17281990099987612, 0.604380971827498, 0.329638845353303, -0.12342034440274888, 0.0020554177102342455, -0.19321070879407554, 0.03996672591704781, 0.5668923246467917, 0.32850138608289936, 0.2761387730700379, 0.7148654212915467, 0.3162841404247251, 0.18848095057586337, -0.04180909877753103, 0.6888670073105623, 0.4593978157858318, 0.24176526542516932, 0.23184902794646225, -0.056905623316954944, 0.9039096086678516, 0.6150498439941893, 0.49180881693612377, 0.48126885194750907},
    {0.4463034696746728, 0.8160462891002922, -0.8626508936788223, 1.0338424506927903, -0.8193435721840383, -0.21850804312063674, 0.746923598726547, 0.4546808253567984, 0.7140446284810363, -0.2953550415600836, 0.20961873359518793, -0.8397692782274857, -0.8785313655969962, 0.033974434755087705, 0.04292879827190742, -0.8934492952800852, 0.3013334753411692, -0.7030037856513629, -0.6758988386316604, 0.19462105001420354, 0.11082484804421966, 0.701426979390386, 0.8587901018505275, 0.2662463102314593, 0.5641225556718369, -0.7275018502175996, 0.30254832061993986, -0.522121689867451, -0.7956063628056096, 0.369021535942975, 0.726105742610208, 0.5308983441465305, -1.043709744404607, 1.0990535206965204, 0.3703092730552345, 0.9625830887156831, 0.46617074910002304, -0.8266594953052678, 0.40628578870416265, 0.29029954934740837, -0.286083063686508, -0.3378655105474525, 0.8868388703944907, 0.9070292720316407, 0.3477786255065778, -0.8764646383132898, -0.3395328322961986, -1.3310199617008482, 0.119443429285049, 0.9904561546483651, 0.68810761640647, 0.7119421792747466, 0.4053776675770741, 0.28838351050274386, -1.0178652507035617, 0.782038925986784, -0.39981874861758626, 0.26943913328859204, -0.5314738480316809, -0.4930757916943277, 0.4184558664727022, -0.002697013077693786, 0.2035093319247655, -0.5928625677086299},
    {0.09311889254399196, 0.8982742260115496, -0.30933215812783627, 0.4401599125245559, -0.5540649176978836, -0.3474836435321987, 0.4801945084646284, 0.2541779293082958, 0.20257101292799135, -0.5189335927401054, 0.07928269206265132, -0.9817142968194799, -0.470531091300215, 0.1428846696606795, -0.22146954777497957, -1.1009260203059907, 0.246874533533172, -0.4451118574254916, -0.4366292116363217, 0.8332932150288425, 0.0883724875656732, 0.4412853669921871, -0.10756680722109294, 0.22954475128419752, -0.040692429341667204, -0.6031830364639579, 0.13530938979746973, -0.17761660804898993, -0.2037087265756296, 0.01145026903871332, 0.6960727273203663, 0.49206679826454547, -0.33634460760850005, 0.5205974205077384, -0.17421411338168147, 0.6061760955222355, 0.14803099655832827, 0.232587362946145, 0.6245813924047523, 0.2416930654625631, 0.06592329258422219, -0.42619053075083346, 0.6182136090885618, 0.7362926020060827, 0.5414527770493671, -0.8256394011702538, 0.46747238423915577, -0.6783547836861326, 0.12827537431923033, 0.7137376114617514, 0.7697228023969065, 0.6224187427929493, 0.5033150140992327, -0.2775313066629091, -0.6099468178285887, 0.7920462964624155, -0.28371745899664585, 0.17887267962717499, 0.008579666660648059, -0.6623089179220543, 0.5789583548648142, -0.14238667969429997, -0.14032594064476148, -0.6483066615951201},
    {-0.7481995886846259, 0.23738297448207887, -1.0193755709384942, -0.1001689425120216, -0.7292029574089257, -1.1996407904392505, 0.24184272724966596, -1.1969707291344776, -0.5678645704997065, -0.9501839318473151, 0.30566541254423235, -1.1770174295035762, -1.2251793321133468, 0.11854826460347509, -1.0707944697759242, -1.2566582960324681, -1.207636249597073, 0.229324317899762, -0.8403736120599832, -0.6697126659233906, -0.004536339666714442, -0.07701956050740101, 0.2445972038831679, -1.056752005278705, -0.02013427819818509, -0.008413363922069856, -0.69490982103384, -0.975473797247941, -0.970030923698508, -1.1217686550196686, -0.8708880468367242, -0.618760119432192, -0.9454698609036748, -0.008093705876194306, 0.03351493915807799, -0.13416575025293026, -0.6643260688222258, -0.7796077423118466, 0.4653943830684666, -0.8852322144236289, -0.8354987492412365, -0.3658171031591344, 0.36495055596926707, -0.8782502260417562, -0.9105117561073328, -1.0869285686292192, -1.1027480216069518, -0.8327992516129934, -0.6059924486987406, -0.8058963873557491, -0.5507689882139265, 0.34890832687925866, -0.7421793991879476, 0.49767870255820845, -0.2778643551653009, -0.3934353656118111, -1.0851164545482994, -0.8039073704976029, -0.9638351657416194, -0.4967756025426114, -0.953263026365712, -0.9077269237895438, -1.1206469906429228, -0.8961085818782645},
    {0.035182363717228375, 0.5766104074008133, -0.9888873946245793, 0.5062665876888238, -0.5272898399057507, -0.9320397456714833, 0.8241004353636927, -0.6839409485231587, -0.44796227571979336, -0.9513740275921773, 0.49504495155513445, -0.10024786116518551, -0.7675147220306264, -0.07181599290859789, -0.804480743302444, -1.062980570774081, -0.7888569707902524, 0.4084942388137651, -0.7694221051680904, -0.7308680673758868, 0.20757323252060658, 0.030656903015539753, 0.5306761680996416, -0.7848329915914478, 0.8230318161617084, -0.07681078110715185, -0.4749461389950553, -1.1598231551671303, -0.9709767720507119, -1.0536624971468609, -0.4596810239405651, -0.3287426234475043, -0.54441536482049, 0.342861474243418, 0.4372401388204816, 0.551286287117468, -0.5997037444841915, -0.7574516170092838, 0.5981114938774229, -0.4444934706608059, -0.8644928769516513, -0.4144566921452436, 0.7657403843406155, -0.8286436037571516, 0.007958708573789688, -0.47603742299010504, -0.3999750359379645, -0.7123232160196953, -0.7927698883170988, 0.2514858047467726, -0.5774180185102161, 0.45057449251561593, -0.07915831275788231, 0.7887753593641563, -0.46844021504780003, 0.008990468151299308, -0.5805770937660364, -0.653738284540444, -0.7909160887292973, -0.6409482748126539, -0.727475237753354, -0.9223816948146144, 0.1080032455991075, -0.4098270468053527},
    {-0.32488537005941837, 0.5102888350681681, -0.5901127342041389, 0.20753719530324816, -0.22581285551317049, -0.4748733089362716, 0.5513408444719773, -0.7206953300765082, -0.8238016252224203, -0.16971677471261085, -0.05599880598403181, -0.467043744134483, 0.19727259828133914, 0.36977844778860786, -0.6130756616639429, -0.7684788046439489, -0.49336252850248524, 0.662888760235692, -0.5481481797853688, -0.4894602145441944, 0.5856960604587352, 0.08241496755362007, 0.8089827863327589, -0.6998589336296425, 0.5844244281109228, 0.28145780634864753, -0.28548633678641505, -0.5799652788344393, -0.9167845536669418, -1.0145312915010205, -1.074680956396318, -0.5898793015866131, -0.5195424023795, -0.16885453460691338, 0.4114316312936433, -0.05550501683691813, -0.24217041912610401, -0.5212180067851911, 0.37271452661661203, -0.7131581305726592, -0.5928404961271033, -0.6106347902753223, 0.20570796584261888, -0.3180250944111632, -0.7425365301175432, -0.11839202520678839, -0.2765453607088036, 0.09851140742541446, -0.30638893629548564, -0.022749261564333528, -0.7155058511397777, 0.08370633078495214, -0.29086806652176456, 0.44619060239174624, 0.2920452296257616, -0.013542064243888667, -0.4071105619455928, -0.3752027060599937, -0.09951606156322408, -0.5344723929887718, -0.2425051081614236, -0.23492691509613378, 0.31848618782642435, -0.30217709458342396},
    {-0.503838732990531, 0.6595713695247157, -0.8434238723929934, 0.5145931945270025, 0.12454555928155438, -0.3788242616694225, 0.9780721690466545, -0.41094577351202755, -0.8735101878429685, -0.7664286792883731, 0.06569616637887804, -0.5657075212367164, 0.23580885423451078, 0.07351688328717458, -0.44842476895429934, -0.3978130199423193, -0.48825134740977444, 0.5949251437930474, 0.17960966122459504, -0.4737012843778654, 0.24420892801055838, 0.3766714848605653, 0.2565511147653416, -0.5262294388648604, 0.8008453476471982, 0.15138841610663353, -0.8798829198016812, -0.38256187664080826, -0.7440832838766693, -0.47789551800082025, -0.12371469854661413, -0.5221501632835084, -0.5777045134971991, 0.23298718100736734, 0.40257248536705464, -0.053408916549716356, -0.58031961063295, -0.7700415839535335, 0.29836554076786087, -0.5085976393793539, -0.4013958321537705, 0.24978228502026217, 0.08376345176459192, -0.4369791571993221, -0.1502667822028362, -0.4548282532294092, 0.10449259271357736, -0.0880009004506302, -0.7055924874818027, -0.16694003265119617, -0.6582374656235458, -0.13957322120654211, -0.5804419893155557, 0.567101097254611, -0.05252628880472748, -0.663118056396959, -0.6239247419509601, -0.3532654808485441, -0.10914836715165377, -0.042362513015049286, -0.4491154036673101, -0.302405840599928, -0.28764682689407295, -0.5116767114554372},
    {0.06813741908471573, 0.15910487863874156, -0.3907609879781604, 0.08644003479934755, -0.31511256522761966, -0.17112723633487623, 0.7092665233350521, -0.07712841818317678, -0.6160360845977125, 0.32979513917384595, 0.5335596321434777, 0.13243147463504293, -0.05999047972966414, 0.5071045418121658, 0.08299904653640179, -0.44468858566391717, -0.3573987574948954, 0.6178911965800519, -0.7682804531318599, -0.8705260602646565, 0.4528500890177128, 0.6633548229367486, 0.5347075739140048, -0.25613373565000414, 0.6685394143839861, 0.3135323258271767, -0.20566685264748746, -0.08681290534888586, -0.0368104637762957, -0.5468975874716816, 0.23573207555887954, 0.3796240254607205, -0.26776634378544767, 0.657145781260627, 0.6342143371447526, 0.5012316437255372, -0.49013271799708713, -0.22645899321425372, -0.2770038221771338, -0.5418324445616975, -0.14676156208293623, 0.4665115161628817, 0.314802899206549, -0.38991801826697536, -0.7122436719715479, -0.28390493802921535, 0.12668377503876518, 0.025536407597995463, -0.1448115366075873, 0.3473394223786005, -0.30555696337175386, 0.13341268559919242, 0.011121211331134922, 0.2805951811338394, 0.7082945044956471, 0.04884492887574054, -0.019189690913398432, -0.0384215464769592, -0.5302786786834766, -0.37834054436221515, 0.5384624497824616, 0.07788099381556479, 0.4268709087759556, -0.015001863709994458},
    {-0.02317380588635442, 0.27338595052021514, -0.44149029108339394, 0.3034029454351905, 0.0424311654906057, 0.1963513273675069, 0.822391084758483, -0.38430344168169467, -0.776041011401526, 0.2950326756390757, 0.056655080516550764, -0.39537622888023277, -0.012762484355804304, 0.7924715874460104, -0.6043100983238984, -0.1846052990562262, 0.007537197873569877, 0.6392638065512425, -0.164989757007278, -0.9326118995695611, 0.7927754525469259, 0.20994966074915403, 0.8014658082666264, -0.6258502764076195, 0.2505067218635678, -0.1262849726392311, 0.3882676600485541, -0.15269382225970246, -0.8769178710610115, -0.7984314721683933, -0.3253591973202023, 0.3753278839077695, 0.14969716294764146, 0.4089352574526773, 0.6388582105812071, 0.2088292562200395, -0.9657796148633945, -0.6656205860000379, 0.32481322964333276, -0.7119751463121273, -0.611566422761429, 0.4791685835944262, -0.5394045408244007, -0.6651944641646899, -0.48970511389621824, 0.037560380015909105, -0.002158095239151596, 0.3607616606621998, -0.3767693970288043, -0.29857286871418753, -0.2092592319715591, 0.18956831078988737, -0.6810323159640788, -0.27675774086350624, 0.8605324067025929, -0.5996909638074027, -0.569906034267415, -0.113241869168955, -0.448614488004502, -0.21245157607095538, 0.12568990734459046, -0.23693266292245857, -0.006550078160558807, 0.12606241743413935},
    {-0.6093925352511329, 0.5336132728115682, -0.7444366966975694, 0.4787777487849301, 0.13095140606514188, 0.13746378721026975, 0.0929418268335117, -0.559138388377031, -0.38464432385069075, 0.316872400337807, 0.29730279951411376, -0.011442228800585479, 0.08764518484588762, 0.2811094296124715, -0.31624556349288463, -0.00589627604082734, 0.04844901065971419, 0.6800217780112375, -0.1660117908806468, 0.599646037339274, 0.2369550158803532, 0.8025433467167065, 0.6829741339556797, -0.4447583954293276, 0.5982449209345683, 0.6030638577425464, -0.2990897104344906, 0.04588481343194017, -0.23329495631687608, -0.3991273823014978, -0.230920743419469, 0.22366159425679794, -0.3678917190739335, -0.013117302906102088, 0.22291704398718143, 0.4994669501380182, 0.30652726979487066, 0.10576737148150471, 0.25261478870193727, 0.3410822151946764, -0.2681479351218667, 0.3497421207795565, 0.8575344890262552, -0.20095455419901948, 0.012478784768843223, 0.22114263848727858, 0.12905111233384042, 0.006457696825901752, -0.07761743498295842, 0.4661013545025111, -0.46732617732779047, 0.5114911133982616, -0.12991561900119192, -0.3958768871095616, 0.4791904291793934, -0.1743254506310978, 0.39805618656248987, 0.20870971276580194, 0.5313926886647022, 0.33609674351760715, -0.2639075849970234, 0.09930236900186508, -0.08058031383061881, 0.2646117961857519},
    {0.07621241748365976, 0.39050841134817077, -0.5292132127354209, 0.7968394228811145, 0.1552966455876948, 0.3734078796792482, 0.38597192974057626, -0.5611072440804672, 0.04341654253745715, 0.10266653455871057, 0.48416985247334837, -0.2603075190539619, -0.0720825936415626, -0.3184581674783781, -0.2637079984983292, -0.33938940582646876, 0.3815661821285484, 0.49361231357612195, -0.6407042967397246, 0.4497145566897885, -0.08507542129908822, -0.3424322926481848, -0.04257136870752629, -0.30924925838243644, 0.25567180990765115, -0.48980549575257476, -0.17596824749494347, -0.21184760692371102, -0.5817688524974385, 0.25072490997758257, 0.5011279822449966, 0.5077508396686381, -0.23408932029974575, 0.4561075248074953, 0.017081417956933433, 0.049968799147055355, 0.4239993178498417, -0.2714686991296403, 0.5961968556458361, 0.03705195119085021, -0.13125756172400807, -0.15199056848668793, -0.2200795627344496, 0.5828025032431787, 0.1978618923448279, -0.3479031323844438, -0.07374573159049382, 0.2136940113529713, 0.028700374008669875, 0.439762101213946, -0.3393373165419982, 0.5115783172181744, 0.5934038653677133, 0.29049436580350857, -0.3042097240353494, 0.3099543219122754, -0.34883609563027485, 0.4181105150600948, -0.2171917106206524, -0.7212199743763259, 0.5590952705805253, -0.06382031416470148, -0.5713783676107913, -0.10929214854125471},
    {-0.14875850185868356, 0.21169927975371527, -0.2161627985273801, 0.45952527288804607, -0.5477443340506447, -0.28237037079833155, 0.7008515375344957, -0.711433640126608, -0.41473435261108466, -0.34438733709556524, 0.23816840586610902, -0.3304257407960589, -0.11488808933952255, -0.37920425210479325, -0.25213439233087226, -0.5767837060929519, -0.3090658885568853, 0.15286909614349625, -0.6114382707706594, -0.03668789109979135, 0.2585108973514403, 0.4442742836325582, 0.5362841803512302, -0.2782761483313696, 0.24619996641906086, 0.6051240677965534, -0.1246564399560905, -1.1033540220017617, -0.04552819969307772, -0.4685046772620967, -0.12123707048836148, 0.2561850997711852, -0.2778390480995703, 0.2791746012768204, 0.2664713370570622, 0.19495950324734762, -0.11718084887846537, 0.2980280662155149, 0.6949899376842783, -0.4690347429763581, -0.1480701258074955, 0.05577272969467479, 0.1491705915103336, -0.20796478662461, -0.22090288615056244, 0.18992741468095958, -0.28488747864631114, -0.18551483658325213, 0.3066147132521949, 0.14391471879205361, -0.1513074315652157, 0.36907615547512834, 0.27324137128341486, 0.42797122199087456, 0.12564008025620277, -0.6822905527337623, -0.5492557426338072, -0.48296267365432277, -0.988867883668706, -0.7878824531936564, -0.37117431098091125, -0.3883744042960596, -0.14244848105097618, 0.0016845766138324863},
    {-0.2651581122023746, -0.07467234293953387, -0.10357184053109562, 0.5355227445865435, 0.7939658870686928, 0.12664842648252309, 0.5732777769841183, -0.20255216554166355, -0.2598195893032788, 0.3049003548616824, 0.12191905470960308, -0.41294727268438636, 0.3051367129052858, 0.7111593009152203, -0.5994458013883707, 0.23572749930648318, -0.3453620741054469, 0.5642413175148463, -0.37867839479052023, -0.6234525511180898, 0.32421354459015894, 0.04165322727320702, -0.14942297399555993, -0.31810680693360444, 0.38101855005679613, 0.251312805901611, -0.5560661366437077, -0.0863905109634493, -0.13345764386227443, -0.21845455843144662, -0.595769724084525, -0.16769168814275157, -0.11489404580345321, 0.4580982738699648, 0.16030607230835758, 0.3766575287849439, -0.21839081392202472, 0.1553965750806951, -0.2561672179077592, 0.10595121433764058, 0.26339033974173964, -0.2718050834113758, -0.2990979313946029, -0.09531838572434484, -0.4753264856520264, 0.08325807129991529, 0.1367134152544716, -0.3019126895855054, -0.22786305705764992, -0.3378377428488345, -0.011628849244000282, -0.0673035062753633, 0.5762340597965607, 0.23966299101654953, 0.2194271561153396, -0.8202357997198939, -0.634625279226397, 0.13252481452924997, -0.5235932646157951, -0.2169295457196092, 0.2492065225443344, -0.49829649701197976, 0.400032040050395, -0.03899277083698945},
    {-0.5481330546908163, -0.2788992935181804, 0.09648485112986836, 0.32984105839257855, 0.4584269284229691, -0.1330895051586826, 0.2357810202456107, -0.13998327620419865, 0.24706598200394786, -0.14960924656737573, 0.1660745800149437, 0.8090224752081553, 0.3603094121821084, -0.2961234111634077, 0.44617292645631096, -0.28290759994263937, -0.10413530394363461, 0.3087697866396421, 0.6056658868811476, 0.14979687323116012, 0.16794397910583503, 0.754828536623111, -0.40015300499221834, 0.8181425728716356, 0.3022863306804851, 0.009281738699921457, 0.20998640244980454, -0.13369074123807462, -0.21875475366028418, -0.3458905553600039, -0.394699899133463, -0.45126940038369634, 0.16045899187257348, 0.392748723598519, 0.4841413044319915, -0.5455239998897913, 0.13146407141561664, -0.24408565217012962, -0.4754429130042134, -0.15661794837875057, -0.3794349716853188, -0.14880543903148263, -0.0020246515074758198, -0.30816793148114296, -0.5376058695941669, -0.14314461311404397, 0.13229201843007038, 0.24645346897453682, -0.6080606796275263, -0.022704083491566007, -0.12109719075311155, -0.15953782310264328, -0.037529118190711745, 0.8128337520586981, -0.10197304533450212, -0.25270418399751343, -0.3193151395431081, 0.031012648082536946, -0.21838276170654067, -0.43901625659043575, -0.023675637140991336, -0.06110820069680186, 0.8075650638326222, 0.23554251062073556},
    {0.5555036033147012, 0.16471032650317716, 0.07753827583789251, 0.27541796638892097, 0.557258161814069, 0.322218520290387, -0.04776789090223045, -0.4351239649766745, -0.24740915219980844, -0.06698387495460242, -0.2594700742826971, 0.12322231978543295, -0.11959705711126391, 0.3383660993945092, -0.07173015941544614, -0.20682814730083002, -0.48167165992659744, 0.19438277557271744, 0.30633431735333044, 0.20761333275266322, 0.29161900045982153, 0.17588939007102838, 0.31341043850908396, -0.24789249929983437, 0.5046834961194321, 0.4840808399815816, 0.0798248534187302, -0.08489432608087721, 0.21947706738516673, -0.16132318048569436, -0.1906992887657628, -0.10777618850437447, -0.03487033521545948, 0.6703333036400931, 0.4524005850882697, -0.23355238092846983, -0.31836935422916646, -0.27323808783042386, -0.07928455419904458, -0.17214187164252825, -0.26964447002413094, 0.3497055028272197, -0.4210599711412264, -0.12950433505119519, -0.33842745187422757, 0.32273506260762624, -0.36515756866418836, 0.012979214563368329, 0.2843746628443563, -0.09782001671307831, -0.49190249011390214, -0.049993196265959675, -0.2100270682731062, -0.3561742960958127, 0.6243516999889903, -0.49456913850326517, 0.19117351178145425, -0.3848800966328492, 0.00568978525935792, 0.13981248841520466, -0.21735513263452144, -0.6740904230242925, 0.494435485199627, -0.016504578948541827},
    {-0.0008379963187292041, -0.017762657780590125, -0.32867893975848894, 0.14902898318057536, 0.015909157592422302, 0.031204632789796172, 0.5504337811021426, 0.43793990029931107, 0.4281823179817126, -0.381744664738299, -0.1803596647637959, -0.2804852537047072, 0.3194959252226895, -0.34160771735224144, -0.3510447251139357, -0.15202107680798393, 0.11511292051675703, -0.0885142865556173, -0.13977846807276023, -0.2672763401026394, 0.08424753501916717, 0.2823240568957073, 0.2139909569205291, -0.49531962201285684, 0.0720912117946614, -0.12393374899468085, 0.33096853855790237, -0.7344732504384812, 0.23192645131836437, 0.4082273749082085, 0.19716317739984954, 0.15298879569975074, 0.06121602802110341, 0.47174591214648987, 0.26440812874578723, 0.13108609894046, -0.15189865340073969, -0.3312022917927807, -0.006202301800022235, 0.261607850254326, -0.32219601062228387, 0.1315871697804585, 0.007594377737277945, 0.2906101423555577, 0.2999287362619522, 0.14396542883911276, -0.08647411835112266, -0.04677457210713028, 0.08318976051857419, 0.4982706920840764, -0.3175407332069767, -0.09118103822312597, 0.8483019014950527, 0.3256163806526758, 0.3847158855646537, 0.12499088020624549, -0.346270360945602, 0.06078482358351935, -0.1687574297781555, -0.6824069876090753, 0.2565270232122244, 0.09920133772048222, 0.21096234920468696, -0.8915078970292878},
    {0.04263953879180947, 0.5886379779878597, 0.2634619128677279, 0.15097665317890666, -0.04707617390849114, -0.23050232824441833, 0.18383502405655766, -0.3453650774629799, 0.38070550403497544, -0.17975578093759864, -0.43555720369897993, 0.17700233784895483, -0.19125285171674983, 0.23926362565380604, 0.47894589575475177, 0.23277453338318507, -0.7920219436924427, 0.33507227725259053, -0.23414186347245497, 0.055516666512344215, -0.3249526429515016, 0.3675610404896189, -0.27080179330767745, -0.35505125430362805, 0.013805879094754404, 0.4018886090255632, -0.5812397437645259, -0.2927235113020122, -0.1895736524598713, -0.3169576625585539, 0.06999625283996076, -0.033154779864994266, -0.038178593648381984, 0.07048523132498682, 0.3065441643355687, -0.1590357244412784, 0.33947149058105913, 0.07022181929942017, 0.5660090264585043, 0.07346434917024561, 0.262522879322043, 0.2694687711035783, -0.07430337103249304, -0.5325268058218353, 0.42825494816665477, -0.4517259393459228, 0.43383523763869813, -0.3110971946296877, -0.15671568166488317, -0.662311741603132, -0.3771717684802519, -0.27165760901738667, -0.07388545214884926, -0.14480265590345984, 0.21347590803965616, -0.5162805529852956, 0.757065820233239, 0.7474800680541475, -0.2960872165020482, -0.2654087680961454, -0.562658647443908, -0.34119234581137015, -0.2710727828650639, -0.25360052601260813},
    {0.5696249105471098, 0.5047041729053293, 0.31031555600179916, 0.652237104613832, 0.1549451855366441, 0.4333948340020018, 0.07978310129858023, 0.5545292161757616, -0.20688341276650055, 0.49576475406708637, 0.7352550324941893, 0.3765430242663283, 0.2506588980578154, 0.5328809310424695, 0.3461830739828207, 0.4207156558020107, -0.06324179568180133, 0.5294779205005171, -0.12338791732156179, 0.32830703735836686, 0.1277644377956967, 0.31565320819074605, 0.16257101052961112, -0.8432538566088787, 0.37599645617935096, -0.27210528527536326, 0.4453296308104441, 0.3466780066389753, -0.1794046833015668, 0.40102979566606756, 0.22509541136160788, -0.11134279169336073, 0.0620098092778705, -0.7036278134790688, 0.025418834184133977, 0.10427558011391569, 0.08575021579949049, 0.32339616849031555, 0.3096976796124641, 0.9263248724814893, -0.26427586219471394, 0.6595803500722575, -0.4458635526549283, 0.2668148247680413, -0.5935295127923965, 0.4625772072976743, 0.3358168555980293, 0.633774194534958, 0.6752324661990623, 0.45178306311963656, -0.35460362187837785, -0.22480258952250798, 0.010220931682533253, -0.13607395623697285, 0.10037088004902404, 0.18425861959153747, 0.3585865211763234, 0.36757338412227214, 0.1252037395415529, 0.024483844555560984, -0.11267703772063187, 0.11347027417320663, 0.41372035398853935, 0.530309059490598},
    {0.04047308759674565, 0.30145817568951333, -0.13902478506170593, 0.17274532622915686, -0.09267588140478433, -0.5618875543010122, 0.4589189866404986, 0.6547190475870944, -0.04140464563305377, 0.1670520056972636, -0.2706734924961968, -0.5648175303960373, -0.5355841039807313, -0.043829905648370304, -0.27372611948719683, -0.5250567729477988, -0.4708137053161358, 0.35513232954341467, -0.3003116891766585, -0.10386620492059753, -0.30369543695016665, 0.06781314821932094, -0.22785400906016595, -0.32206962536880024, -0.24700134064358406, 0.32520652868007455, -0.4286820565058917, -0.2016953887558488, -0.6005246963804831, -0.4808258274915347, -0.6743317210498643, 0.0849603380912087, -0.09858077666620237, 0.3470543496015967, 0.2943572894855353, 0.3411321260913502, -0.3580425153088101, -0.35437771982801547, 0.16313855072682518, 0.5879187713587699, -0.2372100419239406, -0.6830162477170607, -0.33750903513870906, 0.48204892986817366, 0.3057918417601255, -0.05764296223090175, -0.33883881508441815, -0.5528375355270335, 0.20924505345947167, 0.09025305373918933, -0.7955013135210398, -0.660000756728188, 0.1606443359931343, -0.20022843958477846, -0.03667064085121743, -0.017772411929187534, -0.7364154047072838, 0.38180454946680253, 0.004266039410940314, -0.29110506022156046, -0.6786107606513015, -0.28699154207796773, -0.04564936919322284, 0.048613611292988586},
    {-0.027342032114284837, -0.41665460541998456, 0.4496062897084451, 0.47286952817130595, 0.3214359989028267, -0.41797429785789586, 0.4889191594318116, 0.21431656544449132, -0.18478487846325847, -0.14020096747796382, 0.20008614570133487, 0.12431528949005348, -0.024489493196701274, -0.07356046357637981, 0.472806259489368, 0.22852987963916543, -0.16260099627438687, 0.3354106506240873, 0.1741720224722202, -0.19780321950511373, -0.05134453317877438, -0.06740288716508534, 0.09185418678756765, -0.07486836643596084, 0.2875525899208428, 0.21867760226979988, 0.6558812711761219, 0.09979274014221608, -0.06786900192490357, -0.45372480484965694, -0.5735776326631176, 0.31324355804493886, 0.07531076812211107, 0.5141609219052488, 0.15865900320061443, 0.12059970574581531, 0.49784041728838396, 0.11465202831950153, -0.04239505443569291, -0.5346442009933002, 0.5612853158602086, 0.6739487567274137, 0.24412360483592976, 0.06474965084759744, 0.2899064045437489, -0.15406184582341126, -0.3068241943809719, 0.09633378092670296, 0.468581522254544, 0.09712381831159528, -0.48231809820867727, -0.35530332147567306, 0.3405061896497067, 0.06581763111016703, 0.26707421241138446, 0.2727146401394684, 0.13064425500338517, 0.4198082109951352, 0.20513388306946528, 0.11582189017721273, -0.397737495404472, 0.0957722082740825, 0.44344947204006235, 0.04204193475021614},
    {0.5104133357602675, -0.3973496567345468, 0.6178189323016172, 0.22871580721306436, 0.660327084172587, 0.010026670793456368, 0.3815816328137471, -0.4293377454382794, -0.22543506424754683, 0.4416415355607087, 0.13886349013852384, -0.3386271198836436, 0.45196918931879143, 0.2863343560393479, 0.5028786815761199, 0.171068747941429, 0.20029901492041938, -0.17121597568019853, 0.06909662723676249, -0.5080831271769695, 0.3944994934112446, 0.35005733965921276, 0.16492206985620914, 0.23999194102621782, -0.11625995232031437, -0.0064561162667741406, -0.1749716420044994, -0.05598914942060748, -0.02439652002644142, -0.3111455901579089, -0.4526710209226867, -0.4151439837250699, -0.2759649891518843, -0.25107299724460336, 0.16749945336123304, -0.17606210019155621, -0.033474596541108285, -0.23124819365117544, -0.11399884277403498, -0.523780753618372, 0.2509799599324298, 0.7305863135684264, 0.10789790388394364, -0.08545202231296156, -0.15138418548133703, 0.4438468131338054, -0.14918154645801382, 0.2673458192750346, 0.2751707055117669, -0.028857418121664393, 0.21025349000094307, -0.8357669487845245, -0.38145221792185297, -0.09964776446351291, 0.19015624937952785, -0.5801050551972956, 0.31202434580851723, -0.018013003532272844, 0.09119970403573938, 0.09519708205144126, -0.6055383974447293, 0.34437273872667457, 0.5836948275843903, 0.16332992516552206},
    {-0.5544721374740906, -0.030733333340524818, 0.5448968383578804, 0.26984388958141775, 0.0743654358517369, -0.22468849778868222, 0.7178696356084551, -0.06954488133917355, -0.48391841207349656, 0.39694924135262094, 0.24019443974872262, 0.11891403604815011, 0.7729960136565274, 0.6577907227026385, -0.5448816778431109, -0.09263990238124899, 0.2641171191103092, 0.574665530507613, -0.22750295578470267, -0.37500956970074145, 0.1627324643982799, -0.08106501044357546, 0.31464370341859593, -0.33938312587955294, -0.009411515788957695, 0.9580182197869057, 0.4880921347910301, -0.3946862429900015, 0.2097439777679738, -0.1988298560204328, -0.6097535960879602, -0.42952600525671625, 0.3062646368981416, 0.11922992272760993, 0.48234959836023533, -0.409921130429972, 0.07337567638084308, 0.2579084957903275, 0.4544613759400419, 0.1450223864613872, -0.5718978568705302, 0.2890230115470643, -0.1876758100949647, -0.021104391896745005, -0.470835499088814, 0.8368211306628044, -0.13888841108119726, 0.40822442959205685, 0.10093036481407755, -0.14701440491139048, -0.4423881369841913, -0.49956826329742515, 0.27014761224176875, 0.3220927289483154, 0.1477246538765114, -0.15141733746662456, -0.38999856159941804, -0.000759814568093822, -0.19758251662761425, 0.22432487454236258, -0.018728208203076076, 0.2118818070908663, 0.26157113206497995, 0.8608874336627214},
    {0.5982998122404544, -0.1461440130248166, 0.42216208115607345, 0.03853004380433936, 0.5682010064592389, 0.45464909726705083, -0.27092857966375394, 0.4151272937499548, -0.4230082989122989, 0.24384081037247302, 0.2618088756878586, -0.22344507121087456, 0.7574654841297346, 0.22671198635110973, -0.9411521985386151, 0.2130230280177064, 0.48481772435716064, -0.1381513057210449, 0.08798751475914757, -0.48346959084187147, 0.1844311557897208, 0.15739146472556984, 0.22993355244942787, -0.8755829147247987, 0.3860793422236825, 0.12986132318673685, -0.1331574767853959, -0.42924715980725664, -0.11353717579632064, -0.0015357357167392412, -0.23123875084583942, 0.007036307483598067, 0.26601348682117426, -0.3062274141592221, 0.3696547521365338, 0.004412575782860113, -0.31841939633099303, -0.1355862751793111, 0.0037371223109649685, 0.20210230262818, -0.06857587001837882, -0.14933049341517537, -0.1819377282944296, -0.6499526956848011, -0.1724243023925118, 0.5655090517689757, -0.3807734954090749, -0.08458887483742021, 0.0383321987170109, 0.1507648913333708, 0.2998484291749049, -0.20841582646813528, 0.011883671025040603, -0.6338827973609464, 0.4561417947996752, -0.2943990041406166, -0.22406257940513255, 0.1750060819216892, -0.07995054128526465, -0.4112264233025014, -0.5825954680268164, -0.14275460908851081, 0.2793783750366104, 0.27289265914418037},
    {0.48524033746457323, 0.2748500851439249, 0.5961478473134865, 0.5405049896430034, 0.4271727150447009, -0.13732523231919241, 0.32908197771600517, -0.40689554065008976, -0.13340368284695897, 0.5383612820073206, -0.07228113265782185, -0.4684923215546476, 0.05438614353028647, 0.14095827741622327, -0.41998503393154374, 0.04531929104406269, 0.45546823109342655, -0.43894948467424566, 0.3158684191983885, 0.2314760642164389, 0.06741851329495821, 0.20920215463825165, 0.04831504956614114, -0.591545603547163, 0.3061488793899673, 0.0342569349448743, -0.40205865713099254, -0.3764717957088533, 0.34062841177396974, -0.24246427096275014, -0.37506574791825703, -0.15500784175693413, -0.2703509915242152, -0.21088082450487197, -0.13612320297194005, -0.16373331187936954, -0.1978102750792245, -0.039193225518678064, -0.23938671483830468, -0.42073266029181594, 0.09727250849163054, -0.22243874546656592, 0.14946313803107406, -0.42518629706948535, 0.14594294733683705, 0.6520561915679581, 0.6362930445086743, 0.3484364367488045, 0.41902359554748364, 0.04670263189624654, -0.061921903059505144, -0.37841270176593883, 0.03107498439561564, -0.4637337608311526, 0.5111432735987732, 0.4194183579754973, 0.011310443698110979, 0.08838466003619316, -0.5590361870010635, -0.4669337640285141, -0.23429526627193795, 0.4857387012724723, 0.6882151240832649, -0.6184902633955209},
    {0.5310974177216663, 0.40297489290465505, -0.03766392243445215, 0.08297356905995763, 0.1714463740660875, 0.21948010304068793, 0.49697279336152367, -0.02035588473967116, -0.24468941063435792, 0.5606814611592547, 0.12697677265570131, 0.022375487939898617, 0.41244044668783325, -0.004373809878790213, -0.29784179676053546, -0.16882542394859917, 3.440964957926077e-05, 0.15661886150956705, 0.4353326325469735, 0.29826697102716637, 0.43966613973846425, 0.03906139881159005, -0.005315271653877358, -0.20299751778784803, 0.2996644310625546, -0.1864266979931468, -0.015011873270018817, 0.3183060230951065, -0.13740792527249857, -0.10864543409919603, -0.3103190716537105, -0.6427655481995607, 0.44456557958867776, -0.48606298969760775, 0.10232246480515327, -0.029410959661928124, -0.5354781881618158, -0.005354233810767238, 0.12217346184519569, -0.452608074944721, 0.553529043150644, 0.44876411826677703, -0.013071269533803406, -0.06388063437660244, -0.24508220889686738, 0.26349296059211547, 0.3929643283466279, 0.6581840898115829, -0.344261400067548, 0.25770704308873177, 0.32318007838196927, -0.2146679148006168, 0.34345913928359906, 0.032003747203267055, 0.5230461404655916, 0.5950034353874462, -0.0013476714952473639, 0.5354459593337837, -0.4890533608652646, -0.1117249747654875, -0.14364288864919186, -0.5223958436068079, 0.7836954000312711, 0.42110907184567625},
    {-0.03898050886282635, -0.6511568492833529, -0.3417376166794228, 0.5270410430840932, 0.4091296404111982, -0.009039248667803809, 0.5513662705161584, -0.3706594799609796, -0.1437116248278302, -0.4980442495153508, 0.633257179561503, -0.2150294747083459, 0.3906347219006789, 0.13459410897760568, -0.4266024099419232, -0.49456095309483195, -0.19433549482786036, 0.8702653487147705, 0.4983051478044275, -0.15480526719970844, -0.4037450041478582, 0.18518335206881872, 0.25383943891668526, 0.28033962166139553, -0.25428090578942886, 0.5852184534066288, -0.12162057259804897, -0.5590549280639427, -0.06855521100136357, -0.5259302586379893, -0.48057519341905847, -0.18650966902168475, -0.4914973176438575, 0.17595745982057323, 0.47663202482673117, 0.4339819534827369, -0.4129771497386189, -0.10817200719945305, 0.12362815074183832, 0.19995053780305658, -0.025468098655122437, 0.7204283926531119, -0.1915126281631305, 0.029124200570798276, 0.6666679709055701, 0.10271645262368545, -0.02382656750877408, 0.13891945065839356, -0.25425007895509355, -0.017714155133814663, 0.02103890076519588, -0.19239819015442242, 0.6265350515348934, 0.4902858925721138, 0.5701957969522372, 0.21093059676118253, 0.20240010861534782, 0.3489834633298259, -0.2432437152160314, 0.040836725233545305, -0.061073052831048705, 0.0788094217870258, 0.8290656238972184, -0.23360128929146703},
    {-0.3111805801226533, 0.26610073135055834, -0.055874316302903064, 0.6069599244470387, -0.13052687588029882, 0.6101985041910803, 0.3546263715662483, 0.04496113569114901, 0.4016210897820634, -0.40529485081314476, 0.13778497230904907, -0.490113018114148, -0.14367853906368475, -0.13087480023276898, 0.1610318645292156, -0.2983580815222602, -0.3852277599503816, 0.6350462388646293, -0.2153071410250422, 0.4672818117893285, 0.015510000129738492, 0.6100773127958206, 0.3859787627955552, -0.6412499156467638, -0.12895335235390357, 0.033902633912650984, -0.7186751442913524, 0.010378027652585026, 0.10919999559840673, 0.11230513208079802, -0.06771333109674561, -0.08646378595810837, -0.4412518851770963, -0.026951116730766812, 0.48004992519838097, 0.8250610751447125, -0.20558138616523347, -0.15534678022491305, 0.31212298060225274, 0.6603677122862565, 0.14084836878277152, 0.35003281789880103, 0.526461037002034, 0.35630407168524186, 0.6282958588178089, 0.283244801547075, 0.7353618410586771, 0.15147547360600777, 0.7349976188386742, 0.2865256523279243, 0.12032483731171953, -0.20006055848271614, 0.2627685778241345, -0.152093091874053, 0.18421118421891677, -0.016201733632575935, 0.42969441232706107, 0.031318272013181395, -0.5337096503247946, 0.4547138637527671, -0.15110038060613326, -0.34766397804877974, 0.20950094341236045, 0.27046089938088846},
    {-0.31321019219076673, -0.030667448275576464, -0.2162312455442139, -0.41364749733624057, -0.2616926269697778, -0.4452332590843704, 0.2353256081128808, -0.3649394845295796, 0.2811236268266489, -0.11380476999237896, -0.3559831417484329, -0.4035208263846378, -0.04141263840008693, 0.07184087225916098, 0.39609847152055955, -0.3960308405975088, -0.02556395311121332, 0.22222206221947477, -0.5770432935456099, 0.6824037148184074, -0.16809148276820515, 0.31847162593441597, -0.047527854307502344, -0.18917666931162644, 0.17400169462213758, -0.4154033139038463, -0.9237073918683107, -0.26783807694627565, -0.19322828662600747, -0.22903691204697382, 0.42588443940084586, 0.303176120711321, -0.4708002330832543, -0.07852414458431214, -0.2043017682092142, 0.20822823806674062, 0.0668909956776131, -0.1993962790395538, -0.09429134521844897, -0.026410740444985165, -0.3043809091998141, 0.09855758508470079, 0.485319942808693, 0.2251369287974233, 0.2332954674622966, -0.4368998997476603, 0.24258529982968938, 0.021587712040820838, -0.6161887969881723, 0.40055536946754255, -0.2550110644991134, -0.31974538602471786, 0.002084635085813818, 0.36197012790713357, -0.1600734595374661, -0.06478084674028543, 0.040011950952039015, 0.002866560463436453, -0.14466101473156343, -0.6642135796401513, -0.09578488153726739, -0.3409951570190269, -0.20964118934732778, 0.061725056595554384},
    {0.9371583105944612, 0.13015936962244645, -0.33883869380095405, 0.7679212606400552, -0.013341433875584311, -0.018428012532365836, 0.21896637957831042, 0.31491831924488417, -0.13644511359727887, 0.12700021882864343, 0.09011898216648287, -0.4060023254993309, -0.12416463418988367, 0.30107314774622945, 0.2609478276001007, -0.017099744051011036, 0.15213192740005518, 0.18686491020128837, -0.12913503210992164, -0.30205554513173866, 0.5231660470953655, 0.06356399467025411, 0.6880842825250905, -0.009548546275209865, 0.01948871973854841, -0.02048990981134036, -0.10981039215827035, 0.17255526632997378, 0.3913449406284663, 0.23563444100932743, 0.28725732929121806, -0.24874054380023378, 0.005646644761127208, 0.7253003901200034, 0.10747599727804175, 0.3007482025785955, -0.10328161395587349, -0.26749964502614315, -0.2532184295079987, 0.27288320977181496, -0.05622025757826169, 0.17447659489521714, 0.2947474299441103, -0.06791551263439635, -0.1968401708277992, -0.06018363570962325, 0.20276095298261781, 0.13425105901580534, 0.7434533349194696, 0.04834820378938787, 0.4258280306749371, -0.680414010653296, 0.4417870153250997, -0.03450247085424209, 0.10409104701814309, 0.2029587914250393, 0.41137702675502763, 0.4293495537488408, -0.34818304491487573, 0.13489711093233742, 0.2965005207820037, 0.4578966543156823, 0.4230999928833045, -0.6273665837075459},
    {-0.0389225630330748, 0.6638907465348778, -0.4764799923542153, 0.669690907967935, -0.24675906826400212, -0.5730235024139616, 0.13169066406937735, 0.20533455341888598, 0.04422127148682326, -0.18848440722322032, 0.3002923666191734, 0.6211385987544745, 0.12314798803243639, -0.037109593484521086, 0.4969730862655627, -0.019414670056115812, -0.16459649633942125, 0.2862035582873233, 0.2964586743540757, 0.40859413396217753, 0.10427865003099988, 0.38511484431868626, -0.42289414121639995, 0.07648865589349751, 0.3987650086244979, -0.3047359566592134, -0.016398189765783645, -0.22840914632098522, -0.29662468280150034, 0.3008735339881858, 0.30575180752490966, 0.3460745527020541, 0.002634854421852353, -0.3467209740016947, 0.06061742442816756, -0.14731722132367736, -0.1503050243281344, 0.019986147486988227, 0.2368032312971911, 0.08810511569037024, -0.3203836959525624, -0.22153994488665235, -0.15465149454166605, -0.019743347433328232, 0.14047016475814236, -0.42170687859336536, 0.17904308401240485, -0.7724003318813337, 0.03511179246575259, -0.0666226848348664, -0.14932055487839693, 0.05929732936583629, 0.22035867163453593, 0.47174131088904103, -0.5669975231753543, 0.05906292080861355, -0.49835008631450334, 0.06087037537472896, -0.23123663897739874, -0.2608300716892961, 0.38873378182328455, -0.9216256640792261, -0.10496624581318927, -0.6126858903497615},
    {0.05911460941459379, 0.1592550954070742, -0.1506690617994253, -0.1315369859793665, -0.6459311221551627, -0.23373204642191453, 0.13439050770500655, -0.6210509305596951, 0.2725971049077468, -0.5966930748385342, 0.2568188589209341, -0.10806529754841501, 0.028360407613080844, -0.35540435232229256, -0.11688837858012203, -0.6652544074517226, 0.09866020532489035, 0.07332456471035818, 0.014678782703206515, 0.6295625681727035, 0.5308308183602264, 0.3503291343144309, 0.18676866516490592, -0.12394319772583787, 0.01998324445650807, 0.23597119378078624, -0.6927253135128637, -0.3734645249237187, -0.38126329123982455, -0.13558888008025094, 0.4787846161426905, 0.19909870922239067, -0.44872236248740704, 0.30291634817002133, 0.27810659328768234, 0.4513274660384573, 0.09374507475540833, 0.47587165093236067, 0.369611976625169, 0.12833380184399132, -0.08807854372761176, -0.45091561070744196, 0.7016848907316565, 0.2784250152240101, 0.5632886736708573, -0.16022858991486583, 0.17168643240730336, -0.3998428843656438, 0.20278226206766298, 0.7528062827666473, 0.411224981527096, 0.1418927901984933, 0.11272238433629421, 0.15233463250001367, 0.1830526213187767, 0.5735596151672518, -0.11393427670286634, -0.3170143928041844, -0.6835449328325381, -0.163171616513308, 0.21476948648770466, 0.059125683638693284, 0.2554775886391019, 0.33582122638571504},
    {0.05280482199564013, -0.3749541687657902, -0.08043565421087394, 0.7885345639085626, -0.30569516282960135, 0.13451678503204875, 0.223794936196304, 0.18815763625025253, -0.5541991702627402, -0.17379834276001743, 0.46398653454290023, -0.19024642315358561, -0.5371911438291805, 0.2110235151261849, 0.33989869584028737, -0.5243098473882021, -0.575618258320656, -0.38650719771247277, 0.04465869823456735, 0.23504273830577715, 0.39855104873635966, 0.7236152509264498, 0.6572015993090616, 0.0683891442672298, -0.20379469446418444, 0.029527178644795538, 0.17968131204132795, -0.3390256171050068, -0.3853892195570525, 0.09488403780577426, 0.008880007799680097, -0.33877310846337366, -0.2421795022892211, 0.14190973918214692, 0.415496632028214, 0.750835109455662, -0.07018505937067028, -0.013829416606369887, 0.25585607492516566, 0.3454094931194597, 0.24096323919688678, 0.4107037360034842, 0.2615755988249033, -0.5395664791984571, 0.20684018837964568, 0.039299298920454216, -0.14365217130659597, -0.11230365896745362, 0.3271587249463265, 0.2733181131264311, 0.12372936237102318, 0.27907360958689303, 0.9620333008667353, -0.3047380781181274, 0.11438674185178675, 0.3180596908973517, 0.31303105918967034, 0.22527643899839186, 0.037680408277633824, -0.1714001727237827, -0.1928266334618902, -0.3016871215244956, 0.3341895073660605, -0.5937506799914757},
    {-0.4213550374240913, -0.24839840888503087, -0.08252039520456718, 0.8550360309194157, 0.3222248135657275, 0.15051426625315814, 0.7421351489613314, 0.8102364001184028, -0.31238164410335884, 0.1449831144965663, -0.4014794732954134, -0.08032227874980877, 0.30283933991066964, -0.6129154880755542, -0.04512156242621125, -0.252957119007257, 0.595427557055471, -0.06599017961344356, -0.14264594457322397, 0.13525928361632827, 0.7101054227769299, 0.5709437997158898, 0.5876629490726508, 0.39231537610817274, -0.1549684874987984, -0.06041371512274907, 0.14161082675058737, 0.4688755465700672, -0.628978831497018, 0.0028027854750683197, 0.15892257235291335, -0.3327582877696334, 0.13175972838052277, 0.5259960990331747, 0.44412463895070114, 0.11356676918659792, 0.06644502148445165, 0.11147057743542407, 0.5116184989602917, -0.3455900036346664, 0.19964965838971527, 0.17798527474419984, 0.3928464237686932, -0.002475175401141534, 0.20939898704879284, -0.6779799922516774, -0.08781309430356307, -0.729882446593101, 0.30288351981830264, -0.44174616548796664, 0.22453581964869715, 0.4527452576062195, 0.911344381447602, 0.5650464810559234, -0.5283887796950095, 0.6253689953142975, 0.0268106260316708, 0.3475852548250623, 0.11207048846180293, -0.10526291593817932, 0.34241900515890217, 0.012299730384713818, -0.5063039811056492, -0.3267306422548056},
    {0.11153391434727349, -0.22510213718414185, -0.42821705969655915, -0.12476456892692019, 0.16048091526486455, 0.1705129285098314, 0.08435864820499031, 0.1852661762232114, -0.10472297046529078, 0.1825889962187047, -0.5617157158213794, 0.2519792890448923, 0.2142654814532973, 0.12331638502705385, 0.3370423697876409, 0.25002964213484274, 0.4816916772073209, -0.3191026319430495, 0.7086783667869611, -0.1056684210131358, -0.12926991528943974, -0.20350564632781976, -0.5226734994547904, -0.06582034768393298, 0.07426621894568806, -0.18223248730658795, 0.23504519893688902, 0.3588207421979013, -0.04400129110599346, 0.011699435415587938, 0.14420929097819235, 0.2703875673793907, 0.6603441178990245, -0.5006105689951091, -0.07887274627437761, 0.3002591401776636, 0.07707695066011755, -0.024885118199199183, -0.44369348312930257, 0.033023371963028056, 0.10594069863144608, -0.2262394084996771, -0.22368399041432077, -0.07520384708272912, -0.018930160338682816, -0.08542628054093294, -0.08259002283586914, 0.16648624184384345, -0.047777671051180984, -0.07755567114558615, 0.3885504387230198, 0.03407157159688426, -0.03704825491304663, -0.10268638084731906, -0.12051392687544278, 0.2737978564861623, 0.3925325906742928, 0.24357377056078422, 0.1157953368424575, 0.2247175352230559, 0.11135821690526533, 0.3663165827909322, 0.372146073121565, 0.29689679727353113},
    {-0.14991834416680774, 0.2269522052368434, 0.2166828357239195, 0.2612726835915731, 0.033892317026144314, 0.3094885179449279, -0.19226996556198292, -0.47384048766534237, 0.09363380922135013, 0.2374588297390677, 0.24083072351608176, 0.059589631487051646, -0.10480029640789709, -0.09444128562023808, 0.4776958962287599, 0.0645651452060591, 0.25589809975302114, -0.24204418927238333, -0.0036477858119416994, 0.4747987315913111, -0.23577558886805347, -0.6075921975413571, 0.07732272876203865, 0.07217457165160503, -0.004430776560588886, 0.12941088885394694, 0.2812351563075458, 0.6172130698773987, 0.31817133047652957, 0.19012953067573388, 0.2025266516625982, -0.2927820548126018, -0.509166492163504, 0.5322949259728479, 0.49797608498609985, 0.5281786127973045, 0.045682916970746, 0.45478106482269526, -0.2548024210264649, -0.07461742138656068, 0.3159315598976008, 0.06004371613963056, 0.23032470261840496, 0.07249092021524972, -0.03867920574986073, 0.2474554570643734, -0.025765733463418438, -0.48385841221982734, 0.6722232706418972, -0.11580257028719312, 0.30205934522245204, 0.05490696832432749, 0.414302811586126, -0.15630651005977028, 0.14506671992530415, 0.396966938039381, 0.24703669086967073, 0.06400001289140458, 0.18462007471525255, 0.3188118006618385, 0.5640253953621518, 0.34438341895951113, -0.07902371441676642, 0.14370226647601522},
    {-0.26534747388577, 0.03992651001784763, -0.3300901511286945, -0.016770564952755324, 0.05711716006497787, -0.4147099853226631, 0.07836795313026783, 0.23100273819969439, 0.5048561666680417, -0.46107157027683277, 0.31837169197518256, -0.47431513914511436, -0.13007954707931788, -0.08990431068060653, 0.41492747638143584, 0.19268082460790403, -0.17019441168020796, -0.02018085060699137, -0.2741301949027501, 0.08791302919052085, 0.34770926186799134, -0.4222027075052686, 0.4455949778521087, 0.5453479627378509, -0.07572675590988998, -0.04579164321408719, -0.11523162355943094, 0.16269219681580407, 0.17465023880452618, 0.12010824529704464, -0.3069695462647845, -0.15103919662138074, -0.29461288236647215, 0.14406358272275258, 0.25502192412116714, -0.026486431327580606, 0.2432756523092234, 0.41529124100924103, -0.49648037046671434, 0.19750210973703486, -0.26374503655792336, -0.026762533067833813, 0.4649821933537488, 0.05768425226120678, 0.29141519082472184, 0.019112774764888846, -0.23045630524188265, -0.05975411001259595, -0.051056743956487044, -0.5737522298911871, -0.2075060292248132, -0.6450093922522093, -0.007812844504656365, 0.004122029665293556, -0.035783734913246074, 0.565924346447619, -0.21305019450886795, 0.009141845712099637, -0.33978941512433336, -0.4959661928925197, 0.5310346519552739, -0.26467885619030335, 0.05225464407521562, -0.19406576553888336},
    {0.09890381899702402, -0.09515468979785878, 0.22113506815034198, -0.11935248535805672, -0.26449198349846664, -0.34859767259097557, 0.3787415205626551, 0.27326838388622543, 0.4357721136483528, -0.6571354067312191, 0.23002442448127292, -0.35534207669574447, -0.19615156182216922, -0.24735974167534996, -0.20053043952170685, 0.2815721700114961, 0.22961980522691505, -0.05339674216257019, -0.01636850976496994, -0.3053025579784804, 0.4861898785954041, 0.2618667155073075, 0.40817944164914466, 0.2727395976105804, 0.07230666857048101, 0.06969795004633628, 0.010846319855793814, -0.41879527272835926, -0.23821949602041598, 0.33555120467412114, -0.49552012896920655, 0.12693375260687387, -0.054045900141311456, 0.24021428974344322, -0.09177037010384692, 0.1239827499978411, 0.18843128222854252, -0.30860929410511895, 0.23916415417714346, -0.049176531617028695, -0.3820971683626172, -0.05836923738585905, -0.10556602196581316, -0.1371486384678435, -0.25177324323380174, 0.1496091150921308, -0.6387681084930102, 0.8069469003538875, -0.296823840244178, -0.40461974974639503, -0.11601283352467391, -0.7684198910756859, 0.16110537008716833, 0.34225293098465265, -0.28694405631267605, 0.49108770858154827, -0.13645063805925084, -0.2252754332403483, -0.27539816695281294, -0.200449650159021, -0.13237838645792097, 0.15355481340607025, -0.11872239712440669, 0.5250516309335507},
    {-0.22090919253169253, 0.12259763080341719, 0.30098691482274775, 0.17415247691691335, 0.07854784273984465, -0.22678030784514622, 0.0148211771398536, 0.3472986630801826, 0.1979280454535315, -0.256530545575981, 0.2033181993633449, 0.0867835426150298, -0.24518304222957454, 0.040378244808731596, -0.5637425310159824, 0.010731838618464173, -0.0013559176233410187, 0.39132889788911374, -0.5124894130746558, -0.19627602565743804, 0.31893664457606585, 0.45466938335286966, -0.03082046233167876, 0.36059084867627683, 0.05172323085519947, 0.46306468104140125, -0.8680725536643361, -0.5574459953422123, -0.06675652707370905, -0.21411439599638116, -0.1762990039804859, -0.27318805933027046, 0.04344759637196197, 0.34788188879144116, 0.34195589072252996, 0.10483832467642915, 0.30894235291649946, -0.392822846075787, 0.4800718812706577, -0.33985799742841505, -0.2500517349373812, 0.5572335640891999, 0.02755127714067269, -0.019626596054608054, -0.3744635852726727, 0.07993081294086501, -0.27455944132805776, -0.2636166856394389, 0.027936983962769665, -0.2398675053709487, -0.3421147628554021, -0.17279370164313534, 0.28151460035935877, 0.8065292222738899, 0.27154276778755937, -0.5041833083227323, -0.40244374580861125, -0.3810475411249096, -0.1335471380081128, 0.03728347714915905, -0.8736668318575028, -0.30321095282804306, -0.2434694737763392, -0.27095459962900104},
    {0.333803396604592, 0.10748570877845597, 0.15928663064647675, -0.034687908183212345, 0.25015852353181317, -0.06378590316644135, -0.16963483551282907, -0.012225412253781874, -0.3538586472357411, 0.16179924512785263, 0.5043496924975492, -0.31853220875444416, -0.04686019559061747, 0.17501849039247613, -0.17858758959735826, 0.17148370120034798, -0.04524057062072256, -0.17003924341220927, -0.3574776704427488, 0.52141674620969, -0.447626101418532, -0.04672203770935467, -0.1383108017404091, -0.21764024567749138, -0.21945004147828198, 0.06050362360817462, -0.7009751463170777, -0.10756203470931675, -0.39049074366240594, -0.43105782144389704, -0.3571618709990283, -0.03742098583439951, 0.2138914104524798, 0.25041532218956203, -0.16668233811166064, -0.03506860776081509, -0.11117805602839163, -0.555482627994275, 0.5817149190860286, 0.004415180117093938, 0.023554613688774616, 0.13093375215199632, 0.19846204141407917, 0.3529570313102973, -0.031709750872298256, 0.035028737867305634, 0.21676873333108146, -0.21579768394545182, 0.6054064835882613, -0.23558335655579096, 0.2694228335401718, 0.9400864225407204, -0.4458598896612929, 0.2996964448567487, -0.2152404012230361, 0.12324792793140395, 0.2575230729634963, -0.28120445444232345, -0.10250983149765368, -0.2465583954100514, -0.41431574473930305, -0.6904960936822804, 0.044620602197564516, -0.36344257043460143},
    {0.12965106650279917, 0.17378367892323346, 0.11410269790142448, -0.06926878759590552, -0.06574212041785235, -0.14877834311094898, -0.04005400508898267, 0.69536051180857, -0.5845664885355449, 0.6354318552466147, 0.11847687893246693, 0.38629495108384443, -0.11292224608660575, 0.16781564895456552, -0.288433220238187, -0.0016073237773592162, 0.302765143015224, -0.20620091074686467, -0.15456323447896114, 0.21866763589747534, -0.22768108138618387, -0.2502390502573211, 0.20178609462652008, -0.32196828458348886, 0.10742272233718819, 0.014499720477404334, -0.32866893049459656, 0.13680803759019627, -0.5142616076172614, -0.1379319032747629, 0.32297805913183547, 0.03323434975897792, -0.053445239031170794, 0.03172471971018824, -0.21363871174804652, -0.24423961435382477, -0.689121625042948, -0.10098596220367914, 0.3726929294210998, -0.48943512965991, 0.3110572745478596, 0.18746410113004974, -0.5340827111999313, 0.4738298821484197, -0.08386688285218032, -0.25354515367047353, 0.1400629894246245, 0.3762626536936606, 0.031184419173953433, -0.07736312352401521, 0.02731431912564813, 0.7755212802640334, -0.3657639796804322, 0.0589079736192234, -0.33697861904811993, -0.3325261352690504, 0.34507323236263326, 0.15945537663173245, -0.1585439414803122, 0.12313067280897566, -0.2207438632326642, -0.16220064562661607, 0.055124766816453244, 0.0021342046306091467},
    {-0.5979231843202729, -0.17415208349123953, 0.5981132371510229, -0.012250339622440418, 0.10113398806196429, -0.3361863048988629, -0.1381175238850135, 0.13653166329809682, -0.20646143843964163, -0.03594218684829378, -0.09998002977012399, -0.11679990396270083, -0.28693818977408125, -0.0120337697278448, -0.007730486510075881, -0.3127341664808497, -0.44723529005929, 0.43153625650437133, -0.12375698830376966, -0.36429386981433204, 0.04131457245856872, -0.16369840804897431, -0.07637836718719632, -0.0969583300693704, 0.4437607511028018, 0.021848371637627772, 0.33972001928444373, -0.23623201447576167, -0.46185370428277195, -0.5761982445575201, 0.2253458330930156, -0.11106516664921638, -0.2380382199894213, -0.3596677199973478, -0.3889498709319887, -0.542523041177674, -0.66058421963824, -0.5716183674912303, 0.25593606615390213, -0.08113335485984298, -0.44980230177486885, -0.3651557731768515, -0.017855775621921272, 0.1855268649067266, -0.4085041754561104, 0.08840089609898297, -0.43307536642614225, 0.31190278934395366, -0.2858757928900156, 0.17345211239772296, -0.02484421969635449, 0.3599674244442242, -0.01725281055613134, -0.02333025889011766, -0.5718929140798955, -0.8431869531380437, -0.06521938570048871, 0.5501104801491461, -0.13285080301299507, 0.15059176010869427, 0.13749774147928054, -0.3296900197157357, -0.29478891966198906, -0.7326944985627978},
    {-0.10586594549106981, -0.3830591193561112, 0.07922860287648995, 0.1522939911741482, 0.015336985449095805, -0.00361077811631158, -0.02267799721140143, -0.14222803680566512, 0.10073633594678125, -0.18283527469553532, 0.54751435775853, -0.07279080902508199, -0.05346840449813797, -0.06549850189906921, 0.14323002078850833, -0.26504243552158413, 0.3503569329497544, 0.5281210071302285, -0.18114482195218265, 0.18616239223305583, 0.6657552389245491, -0.08626283483215967, -0.18518764717799138, -0.14049000285733845, 0.1462146163892827, 0.08812079917221975, 0.23292346298061567, -0.48507471163683413, -0.3095222185836533, 0.21563492662935413, 0.4203984720414467, 0.19149098476651022, 0.0025994202921020416, -0.4394573652931944, -0.2917856306719457, 0.13429725895621022, 0.27467851906364515, 0.14195003082687246, 0.7777376426744892, 0.3994564209705569, -0.28727703924339126, -0.2830358178103255, 0.7704485886569243, 0.030948417199899575, -0.04153733913156501, -0.010948280046038289, -0.07680622206981012, 0.022621310230460014, 0.04207925043569038, -0.012287355249571096, -0.393482935967143, 0.09022140154905453, -0.1524823953464591, -0.16686050145069745, 0.3217464559577616, -0.1967770440406673, -0.30451252483518165, 0.17859468372296067, -0.040252298144507107, -0.050883152029504795, 0.17073937174755718, -0.0755753386167451, 0.6445044985777058, -0.32366979956749503},
    {0.2379769550561537, -0.12889457420034622, -0.4374115693972409, 0.40402823540855487, 0.02245189722104252, 0.2902692507206139, -0.1278750997115758, -0.34554576827538885, 0.30929596470966664, -0.20365001502794017, 0.01590947774033853, 0.1562177178216442, 0.35892815364391223, 0.1727970522723286, -0.46861506174281303, 0.014319484193293359, -0.22734347357794593, 0.10683542595857834, 0.17001832249767693, 0.3916164684367815, -0.1435072807485422, 0.062200704069471785, -0.172067513324789, -0.3979680366059871, -0.2293265943431162, -0.08165204221889653, -0.32516551209857114, -0.03346808702527073, 0.34511884366679485, 0.2956845876961058, -0.5122967250296382, 0.21087400088425337, 0.07068715751765903, -0.6669331586244817, -0.2579972112141658, 0.5094779956652974, -0.009533506977819937, -0.2608803462622678, -0.13508786037034365, -0.3219892739204854, 0.17584901641385406, 0.29782336496757006, 0.05691857316560939, 0.09391983291005461, -0.20224144342029415, -0.034324244523769955, -0.003797684672665227, -0.5246052375416987, 0.1567734779085505, -0.3342158736497142, -0.035561179294974765, -0.3745264531564378, -0.4008385779383506, -0.04150160575559503, 0.5709665393456256, 0.3705658836459306, -0.08876282128712587, -0.05877647767423557, 0.3803442713903269, 0.028041787955390276, 0.10878727227430866, -0.04888943965826519, 0.13277766017125617, -0.05261521529905404},
    {0.3434812205114733, 0.3178132122635558, -0.12515390120688039, 0.5125693511640154, 0.09409946312698245, 0.5458263762523212, 0.125409846536611, 0.12312327663371007, 0.33723028253413445, -0.1657204137636936, -0.3774936068994209, -0.0063915977142400176, 0.16977910222959508, -0.0826726261416755, -0.10232258647363779, 0.009947229568886834, -0.22159288408226088, 0.192593464910589, 0.7908223576797794, 0.3498596432063924, -0.3324087354003228, 0.5036769088958416, 0.17462612945414718, -0.025154098975669108, 0.31697557049636826, -0.12284782139266825, -0.008314377106004757, 0.16773826775324954, -0.13172711153237204, 0.31607314118051266, -0.39544385328878523, 0.3630548251746169, 0.2504989256626892, -0.7864928648178675, 0.31363183021324553, 0.022828501888789706, -0.1752340929892005, 0.4199076844664256, -0.3476888410741615, -0.18663562944640044, 0.5354624822072165, -0.06508544013298471, 0.2568692827034535, -0.38112761471903234, -0.11937290126423143, -0.08565707658676991, 0.10750652542398888, 0.054672833457162034, 0.017193453121766296, 0.18068273460620293, 0.004893774713674447, -0.2819239897094598, -0.027930648812639184, -0.16729005535995073, 0.50738390064858, 0.20957301465569572, -0.012150753652734401, 0.1516490405295992, -0.12237913997825013, 0.2822080212340212, -0.4507045280738059, -0.29959466077639496, 0.4194529157819807, 0.3346444731556129},
    {0.06362651555811569, 0.4109831927683261, 0.2822285412917412, -0.09620607154670861, 0.30162511899359085, 0.05126293269400072, -0.10734275506080986, 0.5965277617482982, -0.023481040481701593, 0.037992241541952354, -0.39729045735379176, 0.12601565520335048, 0.1959155878605281, -0.14666907482573135, 0.30881759437273343, -0.036813904677976815, 0.47959088272160305, -0.2742660606321897, 0.3448835361035493, 0.4778593792983513, 0.2237756960414301, 0.25157834087860315, 0.04319958748279641, 0.2886507505537784, 0.5394120113289474, 0.4529868626156373, 0.38244935333715724, -0.22472386101812877, 0.19075673042054508, -0.2149614624372515, -0.16377156860434192, -0.21326113172095507, 0.21503687010849812, -0.5228440157080702, 0.3163340816482345, -0.21940677402829553, 0.4194561991329912, -0.24169874991749482, -0.0822374845660876, -0.13571072469276307, -0.3932466477533017, 0.4543418792951285, 0.2272696654863233, -0.19229573353127558, 0.6293519454054128, 0.14197015123399573, 0.45734742344310364, 0.09523866661232012, 0.3529444469690554, 0.2245500631281405, -0.004226286037818349, 0.5195396748348382, 0.08173163134941747, -0.02775760979892737, 0.23987824044427972, -0.3876637779573535, -0.1340108883205928, 0.31483465561306817, -0.2578915372351056, -0.19954858676719323, -0.6334602753389255, 0.08683027220892732, 0.49766477165165507, -0.14818450866985258},
    {-0.21457960591389763, 0.038905767227013784, -0.013793747135480872, -0.46516156359830496, -0.37198201205916487, 0.09297275268410538, -0.2446695416096968, 0.045608730584155724, 0.1980851338609308, 0.3215198533721244, -0.005631664265609785, -0.41371616592542193, -0.3428624355010938, -0.11726560479088341, -0.06330050114375019, -0.06967721300491285, -0.43218232385491673, 0.3923155657505741, 0.3881494866662349, 0.10895533407529384, 0.24178463536330486, -0.2158849223235178, 0.2921048494817083, 0.042849282638680035, -0.42456939358120543, 0.12668578059086344, -0.03763458150082726, -0.1065460838071828, 0.38491169409153186, -0.33504535060025137, -0.09508811554062603, 0.183652561190249, -0.2726477193302129, -0.09604646751216218, 0.5303585719332454, 0.22159269183146393, 0.5182098016918995, -0.2911574225952785, -0.11894838946663303, 0.43706522342590154, -0.08965813401647954, 0.1914525865421825, -0.35387785078243383, -0.1502535109322994, -0.24625154326327364, -0.12121152680611381, 0.057397270016364715, -0.21947973041714486, 0.556496704977325, -0.03932071277612093, -0.2755367512740956, 0.09420159961053318, 0.48933195593222745, -0.3703424004566677, -0.24139326211458773, 0.3085604167496987, -0.3146083105514376, 0.08028744197632642, -0.028947691656065443, 0.2725405956324133, -0.42527266028271155, 0.3638021041729685, 0.09771516517339039, 0.5052630140590992},
    {0.31723980509507665, -0.030737304954775158, -0.053673620138100626, -0.2947269548964268, -0.4022325043443953, -0.18640525404331362, 0.12692485145222968, -0.5837225380300788, -0.686284774645959, 0.450499130361387, 0.5191930528977878, -0.024673939430995825, 0.3602020209965553, -0.27481766660805307, -0.018105252671880942, -0.2964115575092823, -0.5079812550833359, 0.5115608800946371, -0.05362874201227253, 0.1020549814412066, 0.5357453433971564, -0.23791885604518515, 0.36926347364904116, 0.10716422479075847, 0.19381406044205896, 0.28648955958123834, 0.38936727328631415, 0.08948577223487755, 0.19979093067910564, -0.2268734094543329, 0.039739726194531345, 0.11224619648674003, -0.38383723481207804, 0.3954697704348748, 0.013974067849298184, 0.16494613670145591, 0.0977874545443912, -0.07329240169526761, -0.07603815821901054, 0.4683477878192551, 0.19945281750184485, 0.0028210958444287535, -0.10329079793429671, -0.16143568185936863, 0.1683020642259862, -0.03347442282797859, 0.1976824677113206, -0.3471926610502072, -0.2856133057670305, -0.6265090453793593, -0.3056314626572725, -0.2199220037530245, -0.1343273433944842, -0.18620664867651987, -0.43169802544742286, -0.28011952346801644, 0.11957380308781024, 0.45193073390768973, -0.12183280130358642, -0.31749985648653073, 0.29311807290613523, 0.20598771206194116, -0.8661611485180927, 0.630192670499591},
    {0.5489184302423433, -0.35519588843048416, 0.4100969929529732, 0.14066609050651763, 0.4634466722738565, 0.2387734951230481, 0.31543494999288924, -0.19525335979883837, -0.2902775787272336, 0.22439070203375797, 0.3553790912766187, 0.09116103716275498, 0.20936499916600165, 0.5246454272346324, -0.037167261483252126, -0.05027933760724112, -0.286235569750291, -0.029660841972824974, -0.5311128502469319, -0.4506376130116816, -0.17861798757298944, 0.13373214757027738, -0.7621142547994585, 0.34324955407787905, 0.05298167824652096, 0.4757750832523159, 0.17047548036169485, 0.2324320223645368, -0.11884502956189714, 0.0549294116608067, 0.36234357972082004, -0.2909388051341202, -0.04108761382062468, 0.22222569700369238, -0.03864182046189734, -0.2610462321448792, 0.10474699254418378, 0.1927891439891436, -0.7393334680327694, -0.004291856616026629, 0.20853610405528678, -0.34791524789521094, -0.11414211077451811, 0.19247390058162275, -0.08319685861509468, 0.3002113359530539, -0.18531670207833548, -0.08735367900569851, -0.5223501742183568, -0.24731738808853565, -0.037355710133272726, 0.1290461140811513, -0.2405271838631063, 0.5907821324306778, 0.05380537683594468, 0.21055341942675254, 0.5512719117184293, 0.1386020309789348, 0.009477153460119478, -0.03152431307935316, 0.5247079854784874, 0.3948000377224323, 0.6528676756520458, 0.03916819344168033},
    {0.2799157225809719, -0.17752193695658022, 0.2680627613450761, 0.0045162693520258475, 0.7611488853316773, 0.408695419243506, 0.3601006642181319, -0.03756555580714715, 0.30588450621931124, 0.025756492683454597, -0.31146267093952257, 0.43657575630772577, 0.08613118668203723, 0.6188468379160939, 0.16732640081163877, 0.23248296720880765, 0.019338937559823414, 0.25767442265482116, -0.3923806954940398, -0.499836990566596, -0.16563962384949793, 0.1861181348738307, -0.6639055015923514, -0.29653814274447904, 0.010244038498486959, 0.5609288837503111, 0.05214982778916858, 0.25884351315715914, -0.008620762679437913, 0.19347536787374744, 0.10116228289268103, 0.2052348289055794, -0.3760561234760627, -0.27733214332367534, 0.6035744492608325, -0.3176163229517232, -0.2473654978707168, 0.1375073229547753, -0.1626955294407724, 0.2687739798283865, -0.14459283632890632, -0.03118988078280087, -0.4539121407476178, 0.48237902359242085, -0.14171040638215499, 0.1838277957316034, 0.03395219264342645, 0.13172713241269685, -0.16763403915771724, 0.23592045667397338, -0.4186094030191404, -0.2577310746827066, -0.16727378894455552, 0.24286094348837778, 0.4616773960301197, 0.024749150473422726, 0.2786124874630843, 0.02208510612025865, 0.8591016590660449, 0.3346608266971709, 0.2641815191384769, -0.8133320905489996, 0.7615033304124341, -0.3340281874768052},
    {-0.14810299174772618, 0.09674401545166304, 0.4340781062987187, -0.36548667227765286, 0.029400733236001408, -0.24766565283873432, 0.025520733544745315, -0.46335328792119157, 0.4448728181140497, 0.16647564233732703, -0.42717053676685035, -0.04784454619982792, -0.0006786910203985367, -0.09309709090561397, -0.13066669141972148, 0.493784696237437, 0.45279226077819673, -0.22788685323579702, -0.252385977618328, -0.04620250409658602, -0.15638855019919018, -0.37915008541769646, 0.21668034974654582, -0.482583973655805, -0.08274246876015476, -0.3410540689828809, 0.36744334913521265, 0.23305614258810087, 0.09529851284563705, 0.1432241661296919, -0.4935766503090303, 0.2076514900649844, 0.14764102398447698, 0.08352413509942101, 0.10917088256925331, -0.5318871554787648, -0.4430878094217523, 0.10212292526445042, -0.13904152506762768, 0.14008220369379368, -0.32014214725515444, -0.2224073826070945, -0.19628264386071162, 0.49313314004997744, -0.2491036896087568, 0.1400132678240782, 0.5353039989256495, -0.16848675828834575, 0.5894929226746568, -0.42308527945664787, 0.1898629488961652, -0.5775800198111011, -0.3079405994846448, 0.028428262644119826, 0.3320781085227274, 0.27885406013843894, -0.2747952287361759, -0.03903030476534218, 0.16855251240724753, -0.036175476285302065, 0.41202052504690845, -0.38933948015379305, -0.38427624720629017, -0.5072333852759158},
    {-0.27512581718142115, 0.05013162614616571, -0.15391761466782417, 0.2716965447872618, 0.3579410564200657, 0.03634011314892, -0.0009970142035877637, 0.41902977844018513, 0.03984737221020153, -0.1223351014915826, -0.21115612775682122, -0.1817758105976143, 0.19991622106212947, -0.2814402119399915, 0.13462659223907023, 0.04758884285024539, -0.38858838410876684, 0.30870343225397484, -0.36821229171254344, 0.24125736046209031, -0.10051664387814616, 0.2675587292506838, -0.22185857727037667, -0.2738856157722455, 0.2544616292840695, -0.2373111954247769, -0.16008490086522745, 0.22361634707117392, 0.32251117929168005, 0.2403557542908938, 0.22520434030534828, 0.12940934615285538, -0.3645085717517415, 0.17497108555912416, 0.39868424637253963, 0.035686326910416455, -0.3371642466065424, 0.17617854431284935, 0.19931622380229377, 0.1279494121913054, 0.04347539995348796, 0.21617844964386687, 0.08495509923651068, -0.4246307004887131, -0.3005119477653422, 0.37605640736504586, -0.0565923702180075, -0.15265504679133268, 0.4913510621846147, 0.2732865336679994, 0.2826078079502418, 0.09587024957081783, -0.14334203593276953, -0.3147771015125021, 0.17150924214207694, 0.5366904662306629, -0.49112442045784865, -0.35067436679211883, -0.16087554156090686, 0.462942950748963, -0.2787941522132415, 0.19443891674855257, 0.05726070143396377, 0.24624438249411154},
    {0.06327631768893033, 0.6681072429127434, -0.3229028187100578, -0.4580442489187589, 0.09154780331939948, 0.46545722424151886, 0.18243188680618802, -0.11239426382265984, 0.0881374201437539, -0.49238510455242696, 0.1863951673291492, -0.17330453969331908, 0.5037890954723401, 0.40628395107149917, 0.09430241586979224, 0.01520578743038268, -0.17088534939459826, 0.4943473960125597, -0.6981458663006654, -0.12183613104122387, 0.024107555532575334, 0.051379993886056415, -0.23629704819096942, -0.05701421907304041, 0.4647131734305317, -0.32061662871279034, -0.09901283653035037, -0.10142245583038666, 0.44101755575859286, -0.13343434529296314, 0.5102558410257075, 0.014569475372397214, 0.27045302781654357, 0.06124561225291335, -0.13279855779083338, -0.045559949528897525, 0.09704471640783469, 0.0388287854093659, -0.18236822522360896, -0.3163453077148765, 0.4080989613509281, 0.0682327600587935, 0.25735934652668696, -0.04984294511228803, -0.27407780258568193, -0.01917096793460947, 0.20164683897901983, 0.24107193284495623, 0.00611682936901947, 0.29919846787152155, 0.30371599404645494, 0.11793756533364032, -0.2755143811997717, -0.40368526713905767, 0.2023054520834604, 0.16708541373551758, 0.20973264474811412, 0.257435481356191, -0.17491246308903147, -0.29106463146959627, 0.12282252835816741, -0.22332693834471526, 0.36933676029633555, 0.10659854421360844},
    {-0.12414843508726275, 0.48773944660901764, -0.25243780621659023, -0.41246762393664455, -0.22115098549954715, -0.42676267117839256, 0.15345825096669866, -0.015313759920103146, 0.13328149293022984, -0.23644605955000972, 0.15787798970294398, -0.12716519576980137, 0.11988234527312763, 0.5096960500152581, -0.34381215882755134, -0.36290251101525384, -0.09911275423078922, -0.3561589169847037, 0.43361178250540594, 0.01605837208820849, 0.6452733759350142, 0.19408598808009225, -0.2507802476674096, 0.11759868635340608, 0.16099379219461316, -0.2914747981577508, -0.03860540571673948, -0.5733559389489702, 0.13201746465650463, -0.6570481739374223, 0.41421061871110715, -0.6470912910140301, 0.3977643628265852, 0.41378055730746377, -0.13890943379658185, -0.27546137533606413, -0.23974119173226396, -0.6672684728891045, 0.3945985961058114, -0.563408976690533, -0.18385056379329917, -0.4652279664387582, 0.005924176465568258, 0.22045402317327115, -0.12872052058901925, -0.7205331675673419, -0.19469389045650123, 0.32600335980386247, -0.6026464025487602, -0.12514330843375, 0.25129183516124204, -0.06608730101602879, 0.2394683128175067, 0.07896658402962069, 0.132856130756903, -0.12141648005749721, -0.5408332284613345, -0.3095592407776644, -0.7024164913313151, -0.5305274448624353, 0.4927135186195977, -0.18068355916706946, 0.05711122254188838, -0.06011484826421974},
    {-0.22207250247405486, 0.11450536321802145, -0.17846201202020853, -0.0450896733314457, -0.2909137513945569, 0.09332082901949032, 0.4050334793963494, 0.20803862324458053, -0.026400533683760795, -0.13068993235793896, -0.028966370087110078, -0.05271209776092476, -0.3624253145607243, 0.2957741543732018, 0.028140959060039803, 0.006046149428452379, 0.2996190092975995, -0.41635653027013364, -0.11951887591452633, -0.07575322040900982, 0.6033091329360118, -0.42916041458778803, 0.34767228068420014, 0.217638290018691, 0.08987254210320558, 0.44645374392342535, -0.11537494880379655, -0.06270583120878655, -0.2960414237834601, -0.4103060277811669, -0.38846899282478703, 0.16989684072520098, -0.49536800499531564, 0.12021889449101962, 0.02865100074425099, 0.1314889218951047, 0.03610703683556798, -0.13455826985708033, -0.16181630986042356, -0.559062209638371, -0.24410543909912838, -0.2594297664704493, 0.46075430967525954, -0.21495473374624735, 0.15150387470466056, -0.06367491636183484, -0.3615460327306451, 0.12148245194133687, -0.12023087162914949, -0.4852096133596063, -0.2432440504724135, 0.21161504840046055, 0.42742526422796223, -0.6752734873489489, -0.006226871164228785, 0.12155246017119319, 0.19582964735099906, 0.27539652765297057, 0.20432361517674855, -0.5246917206250583, 0.23649996734889808, 0.1651218265048184, -0.4607213148203877, 0.013627477687649334},
    {0.37302541748324636, -0.41714604434753677, 0.43385893430203554, -0.541500247132125, -0.6090864518319918, -0.13148854610268312, 0.1874847130739023, 0.019810716433097574, -0.2003327793889549, -0.3668054984193636, -0.18260432425815512, 0.221937886644308, -0.41539341856724005, 0.35665374056508237, -0.3357461107392389, 0.27232273907647453, -0.12660418501567852, -0.7330479530019646, -0.07850132115839263, -0.5665735708171932, -0.004463640321621263, 0.0189245358631442, 0.2639532552598892, 0.026428396924499564, 0.46142691823399923, 0.08496762870875679, -0.16556494345941322, -0.3520137020272228, 0.06471144626792896, -0.15420915967997836, -0.550482497337469, -0.023165804691853198, 0.3181841821566987, 0.6912099059206872, -0.3623778811327804, 0.16935869994669842, 0.44119205234183906, -0.5586037599746401, 0.68624225183723, 0.31993789270141376, -0.41831386419644184, -0.5974763361017261, 0.298174214252747, 0.01923083955377876, 0.30107011281746915, -0.5313629000809533, -0.11233719872818693, -0.21779114830554253, -0.056508753838764504, 0.008917706286184981, -0.5585610433660282, 0.38214305530494413, -0.23661141377474768, -0.3113345565288843, 0.031170195985821464, -0.348455074902234, -0.05536153227306603, -0.13667822848919994, -0.1822932207459328, -0.5838014191941382, -0.23539819180697774, -0.33803418214052977, -0.24143992883486767, -0.292134363118852},
    {-0.21501419721294068, -0.14686534363010906, -0.44531431292712226, 0.027452378844531007, -0.3457609940256746, -0.19387778456108296, -0.03186919031647723, -0.39023603772331084, -0.36425032187312284, -0.022509248105120963, -0.24924019432083006, -0.1656851637710979, 0.2699476802828381, -0.307567876294512, -0.043898082509809346, -0.3289011727673853, 0.05021294807240842, -0.5343284992818155, 0.0766029071121347, 0.20081322324605097, -0.47218704842509557, 0.3277214337144613, 0.7080694904871496, 0.01907811204575767, -0.15533227691802395, -0.21205696301263263, -0.4562475664840962, -0.4982796052437587, -0.2648540776718271, 0.11238212872651546, 0.5940589747399192, -0.5298265147042039, 0.22109643121878786, 0.2293572845500974, 0.020893181790368906, 0.14096758483958857, -0.19575931712945452, -0.13752329655971907, 0.2711163699377514, -0.09547274216320288, 0.07528338811547232, 0.09882463360021405, 0.43228000916921033, 0.24393618057835673, 0.24512906578347193, 0.22754722828182256, 0.010593284630663209, 0.16738386523791912, -0.08155439663969644, 0.25687596834081183, -0.37142735816314637, 0.42941748504711025, 0.40317884220932443, 0.34337968022412957, -0.1412423095543658, -0.6419746237455096, -0.24386881431914173, -0.005374524772557415, -0.07092055306891026, 0.43358272714634505, -0.33876095349517116, -0.2547164487981957, 0.07080473008474375, -0.18422484563856925},
    {0.05201279550845523, 0.08848347779384255, 0.2199023062078904, 0.20438244470170766, -0.004646165273235848, -0.05994232395339538, 0.21162309948435892, 0.14245961956557218, -0.31739014132506616, 0.11267663570379194, -0.1345780129973323, 0.0067448250731187796, -0.1491770534690475, -0.3910802179699266, 0.6127676687635419, -0.06856904790112389, 0.2065776607425491, 0.15961309352978353, -0.04790099484657269, -0.05113372704158378, -0.03693560790048622, 0.282515642028007, 0.5673306269322264, -0.01855994059145316, -0.5736429906395826, -0.022004606830471642, 0.5070662269107602, -0.1707420906906861, -0.5452436703591678, 0.1820659562745773, 0.5477443679110012, 0.33296070233606206, 0.23970090731818208, -0.18595857792981016, 0.38427439464462915, 0.3614183985211681, 0.42959604745812574, 0.2777979516866422, 0.2415596131504323, -0.2619131036413853, 0.07102879494810725, 0.11633246095723924, -0.6571371122358807, -0.14827576384333857, 0.2640916975790387, 0.004492740434119664, 0.4841291363746687, -0.035176279678869854, 0.4530319632237806, -0.19845589295023597, 0.6211869028536693, 0.021018509436733397, 0.5920465566438563, 0.1470031339083304, -0.03750762436086553, 0.33130749650382146, 0.8411618628109889, 0.29327100795719624, -0.20347891299736315, 0.1325567050686296, -1.1924192250075523, 0.1388034267989535, 0.11261581125719801, 0.24435158425242845},
    {0.03017574148463846, -0.5547498865353583, -0.32281434927307756, -0.05059189332750474, -0.2736543861605959, -0.03531572314231431, -0.007060151117666718, -0.1537668389764935, 0.30107724149522536, -0.3414276098659339, -0.1542621069422946, 0.06275851834795887, 0.30813352904114805, 0.1568444198530967, 0.0035413355403143528, -0.23274351383031397, -0.2104339256675409, 0.07363477557162351, -0.016568470340798013, 0.027743382959584697, 0.31916517915486564, 0.41070054754012897, 0.17060540732564256, 0.35222075629774974, -0.23898903557005, -0.2363682122904204, -0.007754789004959415, -0.4243482237831039, -0.25293816061145574, -0.13765705780906315, -0.0023649005035262824, -0.08074217111736827, 0.3809091699454217, -0.678554217636636, -0.15281257001569207, -0.26086242770492185, 0.19177034190100073, -0.11126803101991468, 0.2577138249412883, 0.0819087990522928, -0.11226041837576053, 0.682465953606827, 0.060057199737298395, -0.2793245437825739, -0.14272238478111288, -0.23426494278235405, -0.0645494318515582, 0.07513572117619031, 0.24237031084785352, -0.1544735443219105, -0.08752587648452279, -0.3397847802690085, -0.5290955538934021, -0.046331453951480465, -0.04586141693173278, -0.3744581189911533, -0.07083082031716154, -0.17086609983983603, 0.1060591427651721, -0.2820690164025688, -0.5029734860291845, -0.45885222715149193, -0.2915189698041309, -0.013148614496617519},
    {0.06723937902711752, -0.6015382903744908, 0.12264325976977364, 0.29116041765329387, -0.27648656876803357, 0.0067996977972329875, -0.2598947629459753, -0.6539530066183937, 0.03944054962147387, -0.010923079361427316, 0.46937036427011436, 0.14055497784298293, -0.07286649277444804, 0.4365726776944897, -0.3274380510702915, 0.2371241760565231, -0.5171330195672583, 0.19430573402789453, 0.22369733476222076, 0.2673354597393223, -0.09217363097870615, 0.28994995416101105, 0.13197912980265003, 0.5599471528129333, 0.24611871363020663, -0.1109778136857094, 0.023226864947864453, 0.05406514352496329, 0.16160187933349107, 0.38480874552004746, 0.22735667771845913, 0.46902310405609654, -0.02333555314785579, -0.5275357102983551, -0.0010317275430594328, -0.08164930817404355, -0.1880827672413668, -0.13790463160316585, -0.07066028728804433, -0.20236877384126248, -0.1598581904879755, 0.5364783591042117, 0.36203145805614706, -0.19814146262663135, 0.23505709679879253, 0.0905414346579622, 0.42994651125029104, -0.2593728653394624, 0.1115824409318181, 0.23447761635068443, -0.4036353940439579, 0.0435298909010957, -0.8152941594046673, 0.14491644265055972, 0.41446996377900025, -0.328481950413182, -0.04661470107090083, 0.13834756489948108, 0.2509827210263785, 0.07919868809672051, 0.2864515223758312, -0.3783838139735455, 0.7005283102527342, 0.08386185795504354},
    {0.3787381630895954, -0.6602013673601109, -0.10902594935467638, -0.07906294732689022, -0.013181499254710651, -0.24865475655655583, 0.39216447907075247, -0.4254801498668741, 0.35697225547165784, -0.22229741916475143, 0.5182781278737936, -0.2956465925217951, -0.11579317243743366, 0.4948768905280681, -0.04729082762992045, -0.261266783587881, -0.3327062859705323, 0.20848819692629955, -0.026062872084608602, 0.014871132476178085, 0.656463175000844, -0.501470151945307, 0.01303274727246261, 0.2820071628647952, 0.35941182438977054, 0.21611888869286958, -0.30993969453333226, -0.12417384259839526, -0.0010483956467424325, 0.024915200574556772, 0.02568947334314072, 0.17049714562514637, -0.2600184347266031, 0.12040926218450222, 0.3072990294323463, -0.2297542086382948, -0.10837161749954867, -0.15448397849341503, -0.5348039150997672, -0.5393117137156567, -0.1773065370796775, -0.025064547119887214, -0.4468210866651823, -0.19531694567330835, 0.3107688604607289, 0.0832445069585703, 0.03042925619537451, -0.07203975407772613, -0.020115971837095854, 0.14719479442314462, -0.14931404742050225, 0.050510687110633404, 0.16861516132506524, 0.3189581904469885, 0.0566821076363165, -0.21940327956780753, 0.2220186484580976, -0.5918138147919426, -0.13684428176696048, -0.27871462919550716, 0.27610176265444536, -0.09384520006207667, 0.0643961613622392, 0.2709558997263699},
    {-0.15616740450024105, -0.024274188292024906, -0.6328945470185139, -0.24969405354731297, -0.034910750834602614, -0.23041915558811307, -0.003410995592808114, 0.3437831001414364, 0.5328136948978683, -0.37387819280449736, 0.03633928695188922, 0.6377830988783023, -0.1505213651994108, -0.008842395266884961, 0.6311788805140897, -0.23000521960979634, 0.5004535736276299, 0.03601702712113106, 0.1998692942810568, -0.02059491065379074, 0.4706680292532558, -0.3863246875878166, 0.16172673355204856, 0.3837012134724885, 0.5587539380718581, 0.2892930803911037, 0.059513265962420965, 0.3130247784292814, 0.09670182312551816, -0.2797706534994989, 0.10681181888196001, -0.1797205277800144, -0.10981581508431441, 0.3846016509516727, 0.5948177309314492, -0.14443173316342672, 0.1917923187069282, 0.44906477567234643, -0.4881892137998664, -0.2895772776022071, 0.07305895616933747, 0.06898991147474458, 0.015516871029054724, -0.04508057097834699, 0.1888148277911371, -0.4864047913795561, 0.0892883086046066, -0.4277958050729236, -0.26573233723956036, 0.2040694327829429, 0.13027046450873223, -0.25088107520609004, 0.23137791047126383, 0.20458524751043825, -0.008277044208989927, -0.04769482690096261, -0.08452792610637055, 0.3449452475908951, -0.09737140311334297, -0.0013447633893839796, 0.34663171021172706, -0.12427006414007279, -0.2576007367886962, -0.22785670430435662},
    {-0.0029798520344258518, 0.3902995533272468, 0.35393200986659856, 0.056214747651066765, 0.052532986474576236, 0.19190413140673027, 0.016447385211369188, -0.07655004649655989, -0.30078892421103265, 0.06307681220307187, 0.04152430108827671, -0.41747127016453156, 0.10347706830050896, -0.3363886537670715, 0.16262187370130143, -0.010066538635084265, 0.024235744498701695, -0.1473198544540401, 0.11879493124894394, -0.18910870009169528, -0.34886493415334924, 0.12795413352864873, 0.003729474737231853, -0.37619011723516466, -0.056211396742330604, 0.2437139021887191, -0.022651138796271408, -0.40544913293747986, 0.1150375313060131, -0.13446982519460024, -0.17310493788552056, -0.6765522204693478, 0.20201604787826044, -0.44989938679809005, -0.22307250927037725, -0.140425502664116, -0.37616884944183177, -0.1900731964513431, -0.16443437695592636, -0.21329427748115035, 0.10587650132443976, -0.2836800984003095, -0.31112722765805434, -0.4267364389874657, -0.1647551943049774, 0.6259841190946172, -0.2719108059639044, -0.009667081723878406, -0.7046857935735534, 0.1918716366776435, -0.16813607847506756, -0.5263448202437134, -0.3647982989231896, 0.23855034181947143, -0.07724490906240883, 0.22960238104379624, -0.5331245837245596, 0.0823730751157681, -0.4631459781349126, 0.23549653786835373, -0.005825287843230299, -0.05871164213158188, -0.2060758936027217, -0.3936320194776131},
    {-0.1831905944228081, 0.4967525349178622, -0.22955602341049983, 0.6288426747093342, 0.5122427847647736, 0.028920059548496222, 0.06212753880601266, 0.16973423720045283, 0.28966339693340676, 0.4352291831142982, -0.2426495060149745, 0.007501260653728655, -0.4888088335857494, -0.31598843967663226, -0.5107196443978468, -0.1786960500893671, 0.12002898040647719, 0.14736330845496093, -0.1833289060276497, -0.30525063070192004, -0.2402002227419986, 0.10643038256249339, 0.38219841111432523, -0.4268928108001837, 0.37565626011580094, -0.28192763246503955, -0.018594195952408358, -0.4354219524783473, 0.394411753828075, -0.5326935661495317, -0.03115403351978799, 0.11782172708933389, 0.5001968675128317, 0.23172764599554416, -0.01038846415857541, 0.011537881364119911, -0.4949608023392478, -0.141003473040081, 0.37595525003921365, 0.31735301950364675, -0.3451628856582314, -0.5827368618488722, 0.3125341995809323, -0.022145256997062893, -0.2758504141558315, 0.14110833018642815, -0.6356096742777272, 0.1768816111415107, -0.045954864468842255, 0.27588998390043307, 0.23770008521957264, 0.3853330876146485, -0.23986558752632817, -0.5748563513554895, -0.07197153697770847, -0.5531229020640862, 0.20581372137763707, 0.16372393620231002, 0.11926778626022808, 0.17028896779525965, -0.06102556319915146, 0.2905940180986676, 0.43994163344827536, 0.0044423865936716106},
    {-0.3122947782449485, 0.4954771212801515, -0.996107160851145, -0.11507931687131222, -1.0896172444055516, -1.2526220750164467, 0.22145925655622395, -0.6017077537763638, -0.2520281574932548, -0.9995173907914128, 0.307879260114287, -0.6550402060842259, -1.1377733107135393, 0.33393522975247036, -0.9931311299585596, -0.7875794410042327, -0.6045854199863411, 0.33692009467570255, -0.6292663831200053, -0.5983320832264934, -0.0586193160968694, -0.0014298495143947525, 0.3331397656812385, -1.1458889899872025, 0.4153620080607081, -0.0723569835258127, -0.253734688702394, -1.0581378286471361, -0.9825765084986784, -0.9224037877005226, -0.5308308250338998, -0.5580429681865767, -0.5582894518242223, 0.2451472409415693, 0.4069333267290417, -0.3769207597143193, -0.7865741111065546, -1.032253203548925, 0.378588381312924, -0.8665471624547237, -0.7056418426249077, -0.34805485984313483, 0.6507059607356978, -0.9652371869995501, -0.8078749335236847, -0.9742682831558563, -0.763104306085704, -0.36812187230279375, -0.7036848716201723, -0.6079878820393793, -0.6124380970171605, 0.4090856740642278, -0.567067940706766, 0.4285496573559112, -0.28753722882357763, -0.593158915244791, -0.7179001132541646, -0.06729976420264087, -1.1264954431794196, -0.12088406918755344, -0.35072151490583114, -1.0774502606996759, -0.7101455211835525, -0.549581366163586},
    {-0.15983932436896645, 0.4914734644345327, -0.851221449412002, 0.5038854042081501, -0.8710638012754098, -1.0987687959853925, 0.43351331430063883, -0.35079289537921665, -0.20729284720005092, -0.9467382039608886, 0.36012414564858447, 0.12662588866578697, -0.6052406946532899, 0.32592569469575605, -0.8250412047526606, -0.45380350217388693, -0.9257930494336366, 0.21792901039700155, -0.7363532656964218, -0.6786131762586327, 0.44973393539365436, 0.0010643667457495118, 0.2664578611068154, -0.8793465189836477, 0.5252981301972971, -0.15143364859364086, -0.1854516884453775, -0.8405245457736529, -0.729220662706771, -0.887759465289123, -0.6882674028734062, 0.08304594890896819, -0.4813572531810162, 0.18382757104020506, 0.5194771626394729, 0.4239049283281701, -0.531146252066547, -0.838885813749583, 0.18228514554426817, -0.24500930767413434, -0.4734375855556468, 0.021502889682699044, 0.666375285545006, -0.38036557969697943, -0.31430713279671674, -0.9004413663974408, -0.4214887431573988, -0.6906197147434898, -0.6893855317360071, 0.05534656911413705, -0.5894980874243165, 0.44211869063874376, 0.21031564988710397, 1.032977286849567, -0.49202383948568884, -0.5246637730335134, -0.6166488438118699, -0.399095854634742, -0.6783647447506558, -0.2920114237892322, -0.7375797684471982, -1.1401224694153695, 0.4225939480657192, -0.5364633303804696},
    {-0.11789874159964765, 0.7734193441979704, -0.35069887540826516, -0.1692555246462898, -0.29091355938323943, -0.6263735332818186, 0.5386671002424857, 0.015249447355742005, -0.229964921392139, -0.05141266866237007, -0.022222001378179125, -0.1757010309086895, -0.04296301354088511, 0.32913126466375886, -0.6883519563435504, -0.5026132369198165, -0.10109584784854318, 0.9286246566849072, -0.7887047695167833, -0.29407224228385326, 0.44505437661973385, 0.3606067777718282, 0.4482190745184153, -0.680920846170017, 0.6050723758904741, 0.5398530499220753, -0.15178618527852442, -0.6806602526302286, -1.023173766419127, -0.8776314875637284, -0.855941617794512, -0.5802390681064266, -0.38489703370423733, -0.3110934889808714, 0.5561078805853159, -0.1561538683411926, -0.3762684055070478, -0.7668957490665691, 0.6851790233219218, -0.3947279765228802, -0.17398555653872672, -0.09557604947834339, 0.3786907140778722, -0.1444910380316984, -0.6890349708178958, -0.39384467315217564, -0.6242247995177694, 0.07422652066023147, 0.05341829876011294, -0.4515703839860975, -0.5854827450229634, 0.06162855307468779, -0.17465360475604855, 0.3236100881710421, 0.1597421595051362, -0.005817141947295205, -0.7224917318073207, -0.02963826339117524, -0.3340001307165994, -0.44937627827663634, 0.3675519954838702, -0.06722872360159146, 0.07084464745823858, -0.1194494259146235},
    {-0.19419000416630408, 0.5389421444308417, -0.29705390159770995, 0.5151294563100237, 0.22616176317537084, -0.34579286903545475, 0.4920565999571476, -0.48488724287112406, -0.5538440059631518, -0.08771426745004537, -0.08602929765107502, -0.2877422253528185, 0.024145718594381395, 0.40041513862755107, -0.6821022820895838, -0.40481387037244404, -0.5981250177900439, 0.532494829716744, 0.22050475714250567, -0.03574800145253305, 0.5789350567359519, 0.018322512376306558, 0.7829554860294183, -0.7013709941809881, 0.39579475372510964, 0.37481139600152685, -0.7350397060347705, -0.07007681936672536, -0.8386630200843374, -0.18066641034939823, -0.3258672715862863, 0.027284397739391127, -0.7182997977486711, 0.2519453153967798, 0.6782692219816978, -0.3851187580718164, -0.6053023960461884, -0.4545826799817024, 0.03696421698065776, -0.45819001592133934, -0.612225819873069, -0.11747057196070428, 0.07903386143904699, -0.36776495141090165, -0.1397674760462369, 0.08181869684765325, -0.05311888250098505, 0.10479416798786935, -0.04180080552061464, 0.060257584847933934, -0.5037184768172271, -0.0033937505325776205, -0.35558787431704714, 0.8451482342276744, 0.36892855638955974, -0.4623656870501187, -0.2891026101757496, -0.12174249094612276, -0.020253446121284092, -0.25924160342634517, 0.35428967574317477, -0.4608647229187188, -0.2657256552509601, -0.49674974944498534},
    {0.0700185297302961, 0.301022471192644, -0.9341009675276073, 0.42676674077940924, 0.014438306684920908, -0.20813331310092104, 0.5497926956062956, 0.27306837011710533, -0.6515254555719346, 0.27883750519766554, -0.04779522222665832, 0.22860062871289763, 0.004683072495722976, 0.31537408794685207, 0.30693664865529574, -0.1337949812036785, -0.0339616830444417, 0.643992885800582, -1.0571968937816854, -0.5003789673226022, 0.18299812946189853, 0.41249090420749496, 0.4643044687096067, 0.09297783293527453, 0.518643829053672, 0.2491653824445334, -0.20942311073801778, -0.3124743738074832, -0.1722493041587517, -0.46152391611653626, 0.32720447363312843, 0.509028070288141, -0.34891096157788604, 0.633751906413928, 0.4293797691294896, 0.40094458370768227, -0.26876543509835105, -0.15766621739371678, -0.14976511047335514, -0.30104931033435034, -0.5151900230237538, 0.10665484064106102, 0.2571731388065449, -0.4640864244003393, -0.7579826398649098, -0.6566356630047155, 0.12835608024613732, 0.2631313052052738, -0.7035879923613635, 0.016889973549526403, -0.18497177804581938, 0.10116722959291156, 0.2750797039611136, 0.28760179143210735, 0.5202363165215607, -0.23047894918882247, 0.13246328031652865, 0.4690094349857362, -0.1495144169109754, -0.6789372961908825, 0.3869770638625669, -0.16500411710250923, 0.39532235898586393, 0.05739909329684988},
    {0.17185669731503772, -0.17102356909628527, -0.3654277390287864, 0.18320834330758995, -0.13994311164299095, -0.003240811105399196, 0.5097604513173732, -0.42053774140735445, -0.5427097404216482, -0.32687460240065747, -0.10872901565879341, -0.1459562255135038, 0.003164388798549629, 0.47398548413672154, -0.8321802450139528, -0.11144086047333195, -0.17034014585172408, 0.5720875766971213, -0.18793422692966855, -0.4432306117544974, 0.6724284294415959, 0.21914320595483405, 0.6354354230602718, -0.40870471017468063, 0.17506871638631613, -0.19591953151292502, -0.01013969620745064, -0.5592385034136466, -0.8112901021024395, -0.35212031995154824, -0.3487156653963981, 0.25479856200278084, -0.19642756266539102, 0.18868039667945596, 0.44486913591884997, 0.1190108370790662, -0.9781486934575842, -0.1624329636540218, 0.3782887001793234, -0.3770383345728393, -0.693669359602945, 0.45727593726184745, -0.583395153139514, -0.7605037835297963, -0.37265476088646565, 0.004804703652542286, -0.13699382002817162, -0.07161452355986926, -0.7993787132274028, -0.014642914211782902, -0.26983837888921286, -0.019835138849969566, -0.4004801551459016, 0.09687111667380316, 0.47001183737122676, -0.49116411008379124, -0.8840745479402967, -0.06961996663508319, -0.47202899474829096, 0.25716663279696983, 0.33935787361200137, -0.5452192999895211, -0.2418853491637368, -0.08055541209511051},
    {-0.6560136869065789, 0.25605322965289784, -0.7328801042088136, 0.41758562849144193, 0.19634636382782117, 0.199693093079526, 0.5157957579833353, -0.5316349203961431, -0.04202584371894111, -0.279258481521855, 0.6067736426253286, -0.3021863763434171, 0.4763717537995004, 0.2772700390382772, -0.7105103496306986, 0.28777550772300164, -0.031047821566240256, -0.1400540886938545, -0.5899697047213547, 0.5775529595833663, 0.22987730504548715, 0.5722379523980899, 0.8250819768289841, -0.11630788358084157, 0.23356333579076452, 0.3385659090939224, -0.48822329026239303, -0.17217576018647976, -0.08131245113818446, -0.22841403757907536, -0.5514988225187144, 0.47887281926260106, -0.3894973304563886, -0.13585510557096592, 0.14810256142415332, 0.5022794688503599, 0.011954493222173177, -0.21557119488921073, 0.3937264240554696, 0.4938749353563234, -0.09611454928116292, 0.34676194049062803, 0.5099455693670368, 0.0934118263331637, 0.33721313738488956, -0.06937257621570062, 0.2583833929996182, -0.015178060503102041, -0.1897868726244852, 0.3684186025114785, -0.11627296263682455, 0.38031978692900825, -0.22951450120405756, -0.4814724184472123, 0.4986300519448057, -0.11541653378717825, 0.427681757022261, 0.129094725115423, 0.2088672874743641, 0.27598974874789706, -0.25134475963172986, 0.43194809950555035, -0.2672216046275087, -0.07548195242085508},
    {-0.39592497417396394, 0.29437041064858555, -0.5712280147686246, 0.6535177272872786, 0.03196991453987808, -0.3740517287845865, 0.37213056175929077, -0.23578674608233355, 0.03715194229975826, 0.05465770376991777, 0.6699635358629692, -0.3699346484914002, -0.5269642453984196, 0.06386060461212563, -0.447554717961649, -0.09687238843164694, 0.09825735692681092, 0.29613584610912025, -0.25490214095753344, 0.07900256334337885, -0.168036933436448, -0.5294781260295448, 0.152011746380012, -0.3258793953375583, 0.20775233348086164, -0.5257096566779489, -0.09387123143401957, 0.10920711123367562, -0.5226781194021043, -0.2836677849057685, -0.13881586003165614, 0.5789359638230066, -0.8832074378482734, 0.46914872232015065, -0.06906716583677172, 0.39114944369257926, -0.012465537719669953, -0.10889915367702513, 0.32245784126888843, 0.02307893050083795, 0.20906027262132565, 0.08203880248705558, 0.004293196498566759, 0.07546854663522239, -0.08443472393025216, -0.40229033890647803, 0.10806892548693421, 0.0009349115523614143, -0.08154179819498672, -0.03466953216248859, -0.4983219756943974, 0.3731552132602697, 0.6317596025887294, 0.18991051839892975, -0.15377382519077493, -0.1422883218524869, -0.18789605268213955, 0.011712754505902832, -0.319902548434819, -0.5063589362408748, -0.33024827732830203, 0.22340586575674598, -0.4847381981620777, -0.12918641772890385},
    {-0.5189821295963074, 0.32902596341052787, -0.18015174167167966, 0.16199295939313163, -0.5694440212387013, -0.19393954150574125, 0.6989598829093564, -0.33005593291412777, -0.33414238954987774, -0.5251494376324742, -0.10770512757157226, -0.15430150823431873, 0.02863817849982511, -0.5471693243415477, 0.25671983436010676, -0.20843249081940418, -0.623460228699492, 0.25556345676866726, -0.8195677525126214, -0.24771194612185315, 0.3640736102823125, 0.47772332467996126, 0.38690430970197087, -0.5490606618518903, 0.15496220792550727, 0.2699107485633695, -0.3233806253133464, -0.8932967759761774, -0.3135832469855003, -0.7272992668012518, 0.10574604628933122, 0.25588066300010304, -0.3387365234400427, -0.07565518314657672, 0.256200722206318, 0.34457782502902196, -0.03737708103572436, 0.29727370371973505, 0.756951059353466, -0.5062642610109904, -0.23395607405738897, 0.16036219383905884, 0.1714494219823219, -0.13872123581192228, -0.2624769392860447, 0.32087813973058377, -0.1527097808803405, -0.15911782850199271, 0.12949101946416888, -0.030051844979372015, 0.07770939356957031, 0.3235062466008283, 0.3076092127773659, 0.2787702806425851, -0.05132631991536433, -0.583892471812621, -0.7491060714047371, -0.39626653655019267, -0.9917572225251785, -0.4872121466062938, -0.4229264672529517, -0.8717458736176058, -0.23975042635568766, 0.1737375242493923},
    {-0.09453120849240068, -0.5018186915029884, -0.27556175312219405, 0.30184699271203824, 0.1599645166149807, 0.23279584241616483, 0.15474107312023125, -0.23778184659380663, -0.3173353332029224, 0.3761903709520142, -0.16594084923472208, 0.12854327181205052, 0.45328286558938136, 0.3376406195937985, -0.5290259599723874, 0.22216013635043713, -0.05140316055557837, 0.9092458877764209, -0.06688098507228768, -0.4177090276561864, 0.1810476620462289, 0.1178498399200225, -0.10441645303564556, -0.9935598081655675, 0.3952959707655916, -0.04295499774713918, -0.9538918034343092, 0.24443908572995304, 0.030224080624125082, -0.40988353279426637, -0.7114126037707564, -0.19728712977935697, -0.3285507628422233, 0.558086299538778, 0.47547558184847705, -0.07112483578192298, -0.434723773326582, 0.2552580229996451, -0.3232311708580915, -0.2697476672504479, 0.17165439965538343, -0.2889783403912872, -0.29925097904555303, -0.1211733716385527, -0.44083781794092863, 0.2756873501701721, -0.07154887477968402, -0.5168890205251649, -0.2971248486052384, -0.041777176258105016, 0.18168200328976683, -0.08280163482166, 0.07007027789629255, 0.2988476720736657, 0.2661073122590621, -1.0327371286352778, -0.8557812080239998, -0.08153200638179685, -0.6594237029476147, -0.17186587044022186, 0.09862502478468974, -0.5062163708484564, 0.3893558020043905, 0.140544110383043},
    {-0.4221080905753023, -0.05149738104360284, 0.16693010402152603, 0.34774591117159204, -0.08735831278255876, 0.09315357866665258, -0.20091139564130278, -0.03714625543570876, 0.18126966881407788, -0.3786571632567333, 0.5296680131953986, 0.370521361635182, 0.08785205683936999, -0.40540992781302865, 0.2827914830127784, -0.18278822765442995, -0.4369590181888373, 0.1378532858382262, 0.34198165616697407, -0.030700077999784737, 0.13895345167939585, 0.4532065054268563, -0.5239764825036471, 0.4332835448657625, 0.33849266700069836, 0.22838609570688811, 0.029195611926384053, -0.36121715437423507, -0.060180445652403526, -0.2849873199424681, -0.18148748590318547, -0.54491409457653, -0.12274594049730411, 0.3102414287254423, 0.29014946625825316, -0.04520823745290586, -0.031632588904700304, -0.05566986889237885, -0.5585672676188899, -0.0366993127261551, -0.1302919354759996, 0.21165103391383597, -0.03598310388549147, -0.2621644048451501, -0.6158024855731316, -0.07175932217870595, -0.04469486480246701, -0.08942767738394712, -0.44247285154107835, 0.17218756959629106, -0.13484121522080686, -0.43617580867180206, -0.22708508105229624, 0.6066983533567892, -0.3427079359389779, -0.2703602578702817, -0.09360189292518918, 0.08245718663792302, -0.45456448707115765, -0.47023142363638926, 0.18349701006032318, -0.1160700817931515, 0.27178701636154046, 0.33246410438235785},
    {0.644998958322173, -0.06459702019248902, 0.40321764386618164, -0.03590153567629993, 0.309405520792702, 0.45978537754441806, -0.28757270130409807, -0.2414588630386742, -0.11265419751585816, -0.17873790661261033, -0.22424859280234344, 0.17405866421191282, 0.17566567808624495, 0.21710736582508883, 0.16414504907756539, -0.3728142469820821, -0.4523112121777967, 0.209737460484486, 0.1988800385658946, 0.2872403825164233, 0.18510536443673198, -0.09044950202338123, 0.2746834697041918, -0.1429554632838452, -0.16135884912370166, 0.2813511723708379, 0.11141844828894158, 0.3785083004041111, -0.2737786644829869, -0.19997837420064363, -0.09005507904070219, 0.18925237055969374, -0.17310188772558477, 0.690083294663016, 0.5554405495400319, -0.21848271873798747, -0.49254547353362516, -0.4455212072218134, 0.024850305670742857, -0.2928500901757033, -0.9031336467463359, 0.30741097115743676, -0.20705526233007765, -0.36644918345177513, -0.6802423654645173, 0.33255222060409617, -0.303306309709007, -0.12125321564878885, 0.3935627128768307, -0.36656132326943885, -0.4588593985271465, 0.15425041202050574, -0.5449226181612756, 0.16022185721153354, 0.2361688524334829, -0.5072185135297951, 0.35669578240348, -0.22695885405921484, -0.20561503619860205, -0.25055087072950577, -0.5526942015974153, -0.4292651270374669, 0.598912252187483, 0.1733607933369517},
    {-0.47195866774046624, -0.257370408423786, -0.48176410146995285, 0.4397542921636111, -0.11467043141977662, -0.12746006969915358, 0.8788348805998214, 0.280495753748998, 0.134646738767163, -0.3216742968639574, -0.29195645474897747, -0.2056212509672739, 0.1913300039771543, -0.32101063492211224, -0.1568308110853165, -0.044029294775730546, -0.46927528237297295, -0.32061476751441836, -0.29437071826927724, -0.12287231363035249, -0.20537363305063577, -0.1763818243922372, -0.019833901956607884, -0.6243801759090859, -0.0034022036368879984, -0.4577980963538475, 0.17731204692043687, -0.628714353987045, -0.33821751273449013, 0.060339722766952444, -0.2819696060402698, -0.27743226032165597, -0.47608749593782623, 0.6443396058967803, -0.1590117355898375, 0.06955036378188195, -0.57467291182177, -0.24820538377716747, 0.058487405054796646, 0.35720222271480234, -0.5469129365830815, 0.01258141305473929, -0.16232677266459597, -0.15008893830071143, -0.1376464909815914, -0.1269968164588987, -0.26305509862800014, 0.11120737905613379, 0.07958598853029954, 0.17246221148979, -0.21736959168560654, -0.05015048449307412, 0.6676152583073828, 0.2730423024287221, 0.5438991953369882, -0.052272598529157624, -0.19550338310991536, -0.15344016130130897, -0.05656566970157355, -0.407239775934713, 0.13967057426625082, 0.16888003691809958, 0.07438576971010816, -0.8365988326322589},
    {-0.34767617218199853, 0.37152237006152833, 0.4494012558947708, -0.19712110624332543, -0.2959089856986099, -0.04906640213381281, 0.14722349741119972, -0.41849091705552477, -0.3110743261711827, -0.06864611690090688, -0.5166349046376428, 0.2941178116027118, -0.026836583550449506, -0.06397833584198455, 0.3279206326430671, -0.18221600182215375, -0.6000349992943508, 0.8686597991523789, -0.7845423322795625, -0.14966063353091028, -0.4048772057428106, 0.270334583390432, 0.2651519478362006, -0.1349819703662559, -0.2519669103859676, 0.5817515442153964, -0.520959974207322, -0.3057868659634764, -0.23402674562727527, -0.3984940335539112, 0.19682119026120806, -0.18848053782203683, 0.09707773186051835, 0.22335520860436017, 0.46652974721660306, -0.08844633525964282, 0.4980456428069054, 0.18764356897582582, 0.4733728787542018, -0.046243053640520185, -0.05353893176089752, 0.43217699605619353, 0.18924821092728744, -0.4055971195046805, 0.06724440012064123, -0.6060052746014345, 0.23934742333431633, -0.0887776668258387, 0.15049429957311078, -0.6718904069439111, -0.5111200624120847, -0.2734643222696081, 0.07554221369822264, 0.1295170705568335, 0.06822485655131323, -0.06385953689064186, 0.23721102847958775, 0.09040522675085687, -0.06347040186776995, -0.32486532937849305, -0.680865518853705, -0.2947223476745327, -0.035779145435075176, 0.34241532095186866},
    {0.2507117881058781, 0.27299102674474857, -0.07170069254803188, 0.3153020914464511, -0.32773975536561745, 0.14915520490874182, -0.2849644575735996, 0.17020187875374, -0.20041192461305957, 0.5736185253197247, 0.6493285424259675, 0.010223732067164527, 0.2220017381410766, 0.06799233730574566, 0.43061577757359903, 0.16121374188517845, 0.1561993988573458, -0.14007895708459125, -0.48719845496413694, 0.10679872891603952, 0.32549987151291715, 0.12054459563828596, -0.024071166411616676, -1.107994083863862, 0.21070342469634393, -0.3590130914256493, 0.3904441662515625, 0.45958239346800045, -0.6416227945434427, 0.40116227551772665, -0.11311973014502087, -0.15967132707836781, 0.1827412962167714, -0.5890141092369606, 0.23340830906264884, 0.026272753147151127, -0.20590401173866446, 0.2934004143224349, -0.21301453919195498, 0.45138185225093286, -0.4034448703134396, 0.501186669494064, -0.4702087855966748, 0.3356771087925722, -0.40770737100934235, 0.5762860721383739, -0.0364103294052363, 0.4294665997935272, 0.65839075358951, 0.22994963413464076, 0.11102502861161465, -0.06751130284247901, 0.008916810980044432, -0.5264684083421594, -0.26721414538440635, -0.01824584521349311, 0.162241287025941, 0.4815161941280954, -0.23623696150355453, 0.24355106689303382, 0.3087534808643539, -0.3722732121450213, 0.5957890614658369, 0.6744218327102606},
    {0.00033440306674773965, 0.22673824844634705, -0.1667412024978164, 0.23811101899047088, -0.46264079669199726, -0.7080372986565172, 0.13560554379290837, -0.321422738601885, 0.06904942060014926, 0.13489005354309266, -0.4489234935306988, -0.311793895193205, -0.5170169954619298, 0.2848850463378943, -0.15207774845693017, -0.7443487503190807, -0.45018039883785427, 0.24770857192018028, -0.9323860147960183, -0.31316122947779806, -0.23670966157665957, -0.19252608922043596, -0.3641554046995539, -0.41812213811081916, -0.29907871151023874, -0.0645853552402443, -0.6691953818271894, -0.22816132532922845, -0.744606335323586, -0.3340835022115543, -0.34326648626369866, -0.051127271717020466, -0.5583683918540288, 0.46613592422532674, 0.391497756212293, 0.1727671184561888, -0.5506221900597816, -0.23944340921328983, -0.05139931015152477, 0.3565230429331187, -0.3635232378131369, -0.6644249499518787, -0.42813225908616886, 0.2362918869390784, -0.1985828607292302, -0.31255411095896746, -0.7294420427557713, -0.3559237968032964, -0.3527661603748457, -0.14894602542750826, -0.7507937893758667, -0.2778763904833879, -0.2514671892031684, 0.17093159001090347, -0.09988092359499055, 0.28611244678937275, -0.8078639179001753, 0.036844198094927845, -0.20075280176683857, -0.5793225581846727, -0.24726177060112958, -0.5718760738257974, -0.323301873560376, -0.1957074541000282},
    {0.12077325859072774, -0.27269403712577783, 0.07116055584614149, 0.21801952949445585, -0.2916279248434969, -0.44860375084918214, 0.3265823944517059, 0.2522398529745178, -0.386283976698231, 0.2742463718173926, -0.06780746318820086, 0.2763570975549759, -0.4300166906178011, -0.24566530932074332, 0.0384620966882188, 0.07847935532269543, -0.457559838239811, 0.7251845700715586, 0.2971352295640357, -0.08011806131977621, -0.2723046812077861, -0.1433983227258296, -0.22981469076622751, 0.003365369429081637, 0.2760325320056184, -0.0682851061874581, 0.5455346930299786, -0.01826239549450866, -0.17797067852119483, -0.546728799296965, -0.5473697442395755, 0.5127992905998423, 0.07015462592275265, 0.8850135942195382, 0.2952126371087144, 0.03887607475793065, 0.3527220595403784, -0.28614466048601667, 0.32300399256347756, -0.33687271335953234, -0.02216719625319731, 0.4515725832542595, 0.4731520281013299, 0.2395580505171881, -0.06098265691417392, -0.18409239803315156, -0.1602302493156409, -0.055502172128901114, 0.2166838497587401, -0.365309206079803, -0.7458859044401379, -0.1922955837580339, 0.31977306065602584, 0.4792626490948706, -0.2668751206235665, 0.2247037926039912, -0.25104776974826887, 0.7636456278353708, 0.1911293861737477, -0.0402248701384095, -0.13853718818593777, -0.40564359677760725, 0.5330083204258171, 0.3178938693552072},
    {0.31634956566921074, -0.4702937906377749, 0.4894594599739747, 0.5818467985193341, -0.08579183108289774, -0.03375394205476948, 0.23244167899489182, -0.6457105522879608, -0.07506023614262539, 0.1465499446998576, 0.25476517857118264, 0.12234356179682358, 0.08711715155461258, 0.02152423729434909, 0.014162058603651332, 0.08537023363861046, -0.05258833464614156, -0.046275966844929815, 0.1684590513688293, -0.44488839749070624, 0.7043761352815334, 0.6920096542912848, 0.15676857452343224, -0.10412054231112498, -0.07764673727706134, -0.03323870646934846, -0.08706779028848156, -0.38538508997377036, -0.1044075142816042, -0.2796129792576997, -0.406814402657365, -0.6805192850418148, -0.5661675000225458, -0.2676442498744566, 0.2853038694953935, -0.0266917233571544, -0.4154095024903899, -0.443286121845497, -0.21913609831674144, -0.4219544658966471, -0.04286898097267476, 0.23233485785163177, -0.05505139474326161, -0.06966940992239269, -0.3734762213916405, 0.40523364113592947, -0.12483384928930893, 0.37133777159592724, 0.13298326388366385, -0.2448812554082745, -0.256081347219637, -0.40584402210022724, -0.32046116090765775, 0.5772013128366013, 0.06081146965509538, 0.023147632749510257, -0.16254697848870617, 0.12542232220225122, -0.3393666599942573, -0.19318482329264522, -0.6989306357070254, 0.0986950863047809, 0.08888060724052722, 0.3928570268160114},
    {-0.5347911365379633, 0.023652201396729453, 0.5257841560508382, 0.8415116027826046, -0.1431799515862027, -0.0774751662195243, 0.698248546103736, -0.34332408930972264, -0.39279247760936475, 0.289958873645864, -0.06409885060754844, 0.37655569929057414, 0.5187260436050363, 0.19116469324496793, -0.5252140190876015, -0.41020681670993203, 0.12081283959878418, 0.47225870798770386, -0.2389071521115721, -0.4352704666164283, 0.02266273002133939, -0.01687637875853324, 0.5087647484686992, -0.2567476309715614, -0.11343711600894373, 0.5790330934201401, 0.2919175198098067, -0.6210919360579971, 0.03336846776045918, -0.6261397020080556, -0.3487950544009088, -0.281057474467043, 0.14703741791548774, -0.16037747454754406, 0.4400384360418216, -0.5238597915383758, -0.22595732096811535, -0.2756870579099343, 0.5342404440627281, 0.2778119718007645, -0.6671860507240156, 0.2778073067186546, 0.0395732481315046, -0.08798327259471066, -0.7243401268158832, 0.1710896256011289, -0.37847795245197907, 0.36370975593068994, 0.3309703701812626, -0.43303811279355103, -0.6013076387785639, -0.23974873396947283, 0.007649213644255973, 0.1006633451773638, 0.08783651822168793, -0.26051373793687826, -0.3323666427370934, -0.24690071407258388, -0.8563335248027586, -0.23603329325735725, -0.08983782132181364, -0.09402422222271653, 0.397304655953562, 0.7313831239799706},
    {0.6518747377081832, 0.15109365884754597, 0.13458494073153823, 0.3591301626089761, 0.3432781110355533, 0.24987653074388494, -0.504444383007724, 0.24918144879428972, -0.22787287651221858, 0.2136423688948321, 0.11824283534125987, 0.028064915591087952, 0.5115802761871274, 0.6337569646559673, -0.7227800124704378, -0.005346645108743355, -0.040517139102142136, 0.0591660418629583, -0.1792583930205459, -0.8007554290184437, 0.36220323270613414, 0.2078420618396488, -0.01879990039654685, -0.5389190730490387, 0.590982482667902, -0.3630371621189122, -0.16096306762482102, -0.3954906963617367, 0.013110403567591569, -0.689856290878246, -0.5354636169306135, -0.07598750129580323, 0.13197699289238055, 0.08296653847925006, 0.44913681501546493, -0.06286773078444793, -0.5406872971610517, 0.07511685689897318, 0.20410337452583938, 0.062356461050120174, 0.20550728186443595, -0.30371023723455254, -0.05958535278691143, -0.8174182747948883, -0.17139227777636742, 0.44245143500281214, -0.43778277667457854, -0.2536714641600002, 0.3282474948778062, 0.0024716401313234406, 0.060759159798881496, 0.13618126095989144, 0.3103872541628915, -0.6205872308900763, 0.0075071566780950194, -0.3946293515145538, -0.6112696512720456, 0.0922917933147838, -0.2907005349689679, -0.038565083168912724, -0.32676073105948156, -0.1631017258603253, 0.2439571843198492, 0.2642657638125229},
    {0.13975384188271417, 0.15708703729923998, 0.40591247134096436, 0.2145776440318956, 0.3446759035287639, -0.383415532783912, 0.338143561964968, -0.5270835953579581, -0.3154910382285069, 0.6707688428995598, -0.19601729067922538, -0.16398903020711253, 0.10679013007018874, 0.48615054053877055, -0.31496184492647794, 0.09114370132108605, 0.1287979367722188, -0.4879434433774318, 0.19639900324681178, -0.23953871109618466, 0.5526654581736339, 0.3238257940326393, -0.46179551090080023, -0.33311043220636555, 0.43208997130274485, 0.022361674402807452, -0.21220455330599614, -0.40406487899826116, 0.1449666123528542, -0.34122047596517396, -0.6672659919425105, -0.329310776727879, 0.014601070007543543, -0.0196420374510637, 0.2542734908257267, -0.14877460470191328, -0.6415373161679152, -0.4823208441725019, -0.3981187352311736, -0.2363764265451492, 0.2187024412235803, -0.26920181724911735, 0.17024831606644225, -0.8035537482006634, -0.006138956681124471, 0.07905664266195253, -0.007429677448720335, -0.09431673560933296, 0.17206218502653342, -0.08191002614292918, 0.18590417317237135, -0.21437728360118438, -0.32287718484358174, 0.033646104537668114, 0.6932291955694441, 0.5667292254297293, 0.015481514246157077, 0.03373207729828173, -0.5697103446524509, -0.4176274204027781, -0.44578859172562785, 0.30275165930600867, 1.0124843022673815, -0.3763159077762309},
    {0.2994414508414219, 0.22420466042424542, -0.005908487713684021, 0.6044548352798284, 0.24016174704482723, -0.13682012143230923, 0.4233821469476958, -0.0748875327718371, 0.12080842865756324, 0.5016935763732936, -0.11979185971642359, 0.4079679673116751, 0.2731248665285589, -0.08092571716971583, -0.3057065895678426, -0.4891854436780296, -0.20446296517254295, 0.4938300094196803, 0.9528655662417, 0.1884027766359557, 0.44954649770933136, 0.46503974461455483, -0.02008682010133953, -0.4268344477532109, 0.09952312303239504, 0.21857334630211608, -0.30825686663774227, 0.17528012493116207, 0.23814850473560206, -0.5250878187086632, -0.02515640205491112, -0.7576359547062583, 0.30802058960300305, -0.24089011017610346, 0.3772129493786156, -0.21817247979106422, -0.8358201986066056, 0.08262501451824661, 0.07305838198365704, 0.004548089991578831, 0.23423974130408662, 0.49353481857107706, 0.15083576027497442, -0.39285113369771163, -0.2798293722298532, -0.2663901849812936, -0.23437886991469786, 0.13315256345731874, -0.44330965937233024, 0.12048769395265338, 0.5135501919953226, 0.03729628775577655, 0.014727703562550053, 0.31091965125165216, 0.3667871350905019, 0.3438984291800387, 0.051292616309991296, 0.4241503996574984, -0.20803368473715375, 0.1524481083387434, 0.3076959483790003, -0.4991490034702813, 0.4632034254547447, 0.4489975226160153},
    {0.15448955144200105, -0.4619229001015345, 0.2614173156799137, 0.573666723272825, -0.005878066735942847, -0.38899199638083515, 0.026596579975765745, 0.08002494546226108, -0.07859207962881266, -0.46584845076405823, 0.45364950276410065, -0.009351698465886257, 0.1135326990586254, 0.23402792548312576, -0.8337968676569495, -0.5161691255191762, -0.13756785693730966, 0.7047972171121196, 0.6319424973270732, -0.5961562652950406, -0.31452058286654233, -0.17331187337765366, -0.002355348644911744, 0.18294462385284757, -0.24319623552268269, 0.6410203879389877, -0.3163738428711962, 0.0971020694809747, -0.18921874836922078, -0.4835716880317352, -0.4867905011333088, -0.25669348101868095, -0.3921612886555121, -0.2675987110491965, 0.6603458196648938, 0.29508775442859053, -0.33881253317947724, -0.40732188597145674, 0.16242740575641204, 0.13458512891389143, -0.23814440026941128, 0.6863312879968079, -0.44144510174148044, -0.1362434318973498, 0.22531576153642352, -0.1263933722709802, -0.4575357886399001, -0.0422912284537439, 0.08295561278641642, -0.5085232512055762, 0.050671827918755755, -0.05747609343212946, 0.45808148281517447, 0.2608259978599442, 0.5893935071840899, 0.32358856336655534, -0.23859035686296312, 0.45834554329124644, -0.43677653330011607, 0.3588787708964707, -0.48760475102879547, -0.006876359624977066, 0.4662523945976342, -0.5073315117594684},
    {-0.31249028210445096, 0.2585449487857236, 0.23183429540224218, 0.5521050850909452, -0.3985288055476854, 0.20302885113264454, -0.021025320103313126, -0.5659367143823125, 0.42915970071088133, 0.011926752029725466, 0.11054047392178011, -0.4376031438436125, -0.09690246802766775, -0.18603723552782353, 0.3859849411024646, -0.4212521210083392, -0.44097340368436255, 0.3490774432374781, -0.3585405079491612, 0.3040942956965079, 0.23635568313917601, 0.4056351949706592, 0.4503404408118873, -0.5748934760192134, -0.23635934681848975, 0.6255784481964631, -0.6257354740007228, -0.004455491469219206, 0.1060597261130276, 0.22224497456015285, 0.21526836010179676, -0.043223449820903106, -0.46113688697503374, -0.2733922033438103, 0.2833799346903249, 0.31042675476147963, -0.266390307112054, 0.07865789125119645, 0.1193498420892855, 0.362535747836792, 0.24782345133356096, 0.3444834419623659, 0.2251180676536098, 0.24502495803585234, 0.4799947709626996, 0.3233978655795036, -0.07666089909846623, -0.1482548335165578, 0.27907369648504243, 0.1004143196587916, -0.26338533554216526, 0.21239009544128495, 0.1280387947658519, -0.6740790345543684, 0.011507291928524777, 0.14640165230574317, 0.2542347055475118, -0.011808515519237076, -0.8372496099879023, 0.3816400477090033, -0.014552214891116879, -0.19414979969149837, 0.49072069295166826, 0.18072621753011042},
    {-0.2168040913331253, -0.01936768461428025, 0.17996384326706907, -0.4148535552443188, 0.007979760460074268, -0.07983282938331138, 0.16025429875426567, -0.010299157429649333, -0.07711131571762679, -0.10470738719410701, -0.44670123980779847, -0.5848710695319266, -0.037825827269881096, 0.17047183185896625, 0.354711773852539, -0.6346365280321195, -0.07044309273128811, 0.3730546178346402, -0.035290342585361366, 0.44438658325318303, 0.35123462785635057, 0.16189816128526746, -0.5869168140780749, -0.1696042537626325, 0.26486628808696316, -0.188532054837695, -0.9206858905170229, -0.4125382840052908, -0.0627002856309823, -0.0923161949988557, 0.4152958192664074, -0.08501525978740586, -0.6204422379769794, -0.2147509052608279, 0.10237376048024732, 0.08055228603731154, -0.07107270352958911, -0.479707162917441, -0.2202473051295505, 0.07177287941107191, -0.12860514492066166, -0.5002412782736827, 0.6042715852033095, -0.208363461103597, -0.19306834321642494, -0.3107076075982214, 0.3089776252056197, 0.2485467384668674, -0.5804253115434247, -0.11647452250009674, -0.29788868003459257, -0.24711716142894696, -0.1603086349221556, 0.27706130794214046, -0.1281544505514452, 0.07586085644169965, -0.10809558222091983, 0.2911369971791984, -0.047460327983263044, -0.7188360950519268, 0.05106478338672805, -0.22803499847075256, -0.20784190237051875, 0.44525224509544475},
    {0.7328678427748434, 0.058190233669439935, -0.31828891026252937, 0.3456008676564962, -0.15570580978779708, 0.127152189722536, 0.008565210602899354, 0.33803884156192826, -0.13746109025046402, 0.272679644649613, 0.1037128023270748, -0.1824112889336029, -0.5594697474967933, 0.407879609023788, 0.23464162196807498, 0.21191822151998863, 0.20986612711437658, 0.13720371611898466, 0.08750499202903672, -0.274321100143708, 0.422632831243553, 0.42782263410748855, 0.6282178393396676, 0.0419827519016977, 0.12887711585039124, -0.1352110853185641, 0.002281323823969127, 0.19135517674233787, 0.3377957585668515, 0.3048583224798154, 0.25968783237945403, 0.0064201741066793, -0.3972238662140561, 0.6709720426049905, 0.4153421657184673, 0.19478763223011297, -0.38611516804508755, -0.32539765978495483, 0.10949017522798052, 0.4554899600048159, -0.29746883731101553, 0.3084697315712684, 0.3395288680728719, 0.0685870633726136, -0.3603841460737917, 0.09181808553015995, 0.48006940024176664, -0.0025513464767237515, 0.4373475052748094, 0.025728448849202584, 0.3583306162655749, -1.0248047348811693, 0.5915770925346261, 0.47037064690538616, 0.10219094407915037, 0.4705039867249805, 0.5370143011580862, 0.3793954655276733, -0.15588645095549222, -0.3170489741657914, 0.2745021469545178, 0.3049800454019918, 0.7695976064615625, -0.6773805599095871},
    {-0.5026543611623516, 0.37762797238510165, -0.6306789350182759, 0.945383328170686, -0.5807246868122046, -0.42339333265306717, 0.11625657541263924, 0.0497911462500263, 0.12216139286680405, -0.2900124348349694, 0.3279276149819457, 0.22897944661777672, -0.20189512984038935, 0.19314362324106515, 0.3140009647462683, -0.20885042204538878, -0.7555608183819813, 0.17766911142764144, 0.2222335409125081, 0.15957907452968992, 0.06930216336872956, 0.6086573699797904, -0.02249974140895304, -0.2490939034264747, 0.12132073704121857, -0.1289348101028809, 0.34401440708877307, -0.6858679030829264, -0.5304018555725956, 0.47009821242722183, -0.02030843038900207, 0.11240823744243354, 0.020905112772252984, -0.2692148309009709, 0.12291261640073957, -0.47740172281672566, -0.20482198089950993, -0.1905558254937405, -0.2427661265536093, -0.19979457059215766, -0.5165412776383645, -0.21870138229695651, -0.1080807510954947, -0.03214472463696002, -0.06784248977886419, -0.6117470911452987, 0.0647194429953946, -0.5154910057820347, -0.1846940469233397, -0.4177882254407104, -0.30265841730244947, -0.030083874809876072, 0.2855182975496707, 0.6773433055750596, -0.5619729447138507, 0.05721012691870908, -0.36429051378646754, -0.28846618336437485, -0.044285706091431475, -0.27655429319457453, -0.009214760731543757, -0.6713934522551799, -0.07275511390992412, -0.3142883624328369},
    {0.36764947162407435, 0.06043886248153893, 0.31303434787828005, 0.04260190503936914, -0.3945351934800177, -0.18440402900392558, 0.11566552096572634, 0.02058603310428219, 0.30004281620366824, -0.3410199165565552, 0.691094708600554, -0.1183959362403636, -0.056383531194692235, -0.05263735698192543, -0.22812731776218056, -0.2868024853942537, -0.07364212789025705, 0.10458039077658328, 0.2723867952318466, 0.4529585350530315, 0.5943172662440339, 0.3012822210668017, 0.521971981748852, -0.2680467980375266, 0.1441790195289302, 0.17901813420090656, -0.6799565687360305, -0.41907898809360866, -0.15347156335524526, -0.05179761766472883, 0.020118113745010074, -0.46367623751260206, -0.3420423483409177, 0.2623750561211059, 0.42064043238420634, 0.2784852202977568, -0.1356308948626978, 0.3017061451152338, -0.17504924706360778, 0.014072415179906598, -0.03010816480843742, -0.23013603375381517, 0.6971789853839361, 0.16992172711133705, 0.44178519761206, -0.41436887792981386, -0.01646175687633471, -0.4207300481358223, 0.451627457640589, 0.4460671896598204, 0.10841988214029208, -0.12761834092086072, -0.030082920852820733, 0.6177579106257384, 0.1294889640311288, 0.0964681315602911, -0.344927378446659, -0.6001468343360139, -0.4290159654722595, -0.06781355836044294, 0.23984340540050936, 0.32511318267394523, 0.5491094915481012, 0.39629325690130496},
    {0.08898360880527417, -0.3657132421598281, 0.1390591241102083, 0.3678338600068902, -0.3643365197903812, 0.07214747294874173, 0.023312053441886478, -0.20677324100198247, -0.37296686018584574, 0.3089562234789667, 0.09824434593757571, -0.28395337166466644, -0.3178885769481189, 0.21022547823651183, 0.05928169533419994, -0.8561252606375448, -0.6009845898764465, -0.2906605364076846, 0.351238819069135, -0.02963993522443697, 0.05212774886563346, 0.5967877721814842, 0.29827648390448036, -0.140196837476613, -0.7437012749095403, -0.07800765761448075, -0.004645080341462982, -0.3092493449192728, -0.25179368399417174, 0.22240694075959402, 0.2593632655597654, -0.7150551212591112, -0.2861101335245314, -0.2506719018323902, 0.19909380110989872, 0.24967603724680815, 0.20350925012862833, -0.12508240761930448, 0.2352889226779371, 0.28680048253568036, -0.40623893638892217, 0.39887643757712454, -0.018195091892151873, -0.7479654678921426, -0.2860912258417722, 0.517585767420885, 0.23084290764442142, 0.010172908230588482, 0.3674724106999638, 0.11771882815733098, 0.025979169028598367, 0.5873592174482909, 0.4678389724016137, -0.14305650095918543, -0.029234214569359727, -0.09685872441457062, 0.5426785088236384, -0.14517811469256228, 0.18906657926324838, -0.2825595803926832, -0.49360187881479456, -0.2660119394807532, 0.4003553292729176, -0.13056373813940053},
    {-0.011370685569392788, -0.38604110913802014, -0.19984550073324162, 0.4723700563184156, 0.6109945150833052, -0.391954527656746, 0.411623466313418, 0.7535513857695941, -0.3283742492003441, 0.3056551281881265, -0.6808349067142739, -0.08894898442573261, 0.07709577653245721, -0.3332178801458708, -0.27236390860553683, -0.5859784016612499, -0.03759864298750349, 0.03051865145446617, -0.37019847412774315, 0.3058574732105512, 0.8844880877834661, 0.4216398055571095, 0.5682665268021814, 0.1740077719313944, -0.38495417266550536, 0.3703575153339714, -0.18439916664760456, -0.012975343453802895, -0.11061402548948485, -0.45730943903993293, -0.4394312722012348, -0.14423822457162452, 0.5084839382323323, 0.16986116797785222, 0.18886894538961996, 0.000554934970596665, -0.25987672315116517, -0.3263541472656941, 0.002432602393648181, -0.24649696930067597, 0.14755123038140727, 0.14377661521816015, -0.14511588168598996, 0.13160026348567916, -0.28523108661332286, -0.5873706599078041, 0.39140522695028757, -0.44362926311090134, 0.22271684171019793, -0.5637089337072808, -0.1891704754747233, 0.28355073923813545, 0.8274651941191599, 0.4516212170323997, 0.19965442102070177, -0.13961723622208835, 0.2025005671340424, -0.09123659722515194, -0.1570177956007674, -0.07350702068341851, 0.2149541168221908, -0.352340937508923, -0.2811648894949263, -0.3443489079336024}
};

static const float b1[64] = {1.1565796218225315, 1.1575471140391056, 1.2322933736400536, 1.259154677707302, 1.1633628727830172, 1.2682869730474222, 1.2304634205327827, 1.2469671550076176, 1.211689696030851, 1.2252458491470513, 1.2800724352983888, 1.2119047572644863, 1.2482523336464553, 1.090108493472405, 1.2752881642339164, 1.2118192275798252, 1.2353844139301635, 1.2389131319660402, 1.3134436398767912, 1.0909609012276564, 1.1903216136014625, 1.2182889049717989, 1.1440374344284723, 1.2636287941388333, 1.15840384136919, 1.2034724074407965, 1.1078324405234432, 1.3000294961428172, 1.2759484968309487, 1.2858817778902785, 1.247147511927954, 1.1539648143338956, 1.1593788169037662, 1.2805343217255005, 1.2432522313320262, 1.1590732213927533, 1.0641705296879327, 1.2610724251811067, 1.2084655760309204, 1.1922987425854725, 1.2183095021665118, 1.1331802569487015, 1.202244137225359, 1.2518994869703317, 1.2067938605101947, 1.2101266451553223, 1.2047843525207504, 1.212268608155373, 1.2527867356696534, 1.1405685644814476, 1.0816787464785826, 1.2773035314441448, 1.2867786755149198, 1.2404669049266783, 1.2094379077814166, 1.1889756204402882, 1.2337284613782706, 1.0973034555883088, 1.2240369350247295, 1.068685123303106, 1.233069725567065, 1.1238499399060788, 1.2905639503380166, 1.2275738841903008};

static const float w2[64][32] = {
    {0.42303807881895755, 1.1066906507347531, 1.1393527848670866, 1.2559193441023655, 0.8087693520544915, 1.2057610508367547, 1.2166085387666763, 0.8853161872696304, 1.3556608403575674, 0.978853149637994, 1.0082962580599395, 0.7410012946882185, 1.1779196335258268, 0.8786453078460918, 1.0876267935137964, 0.8871168317220478, 0.9308421006961503, 1.131615314108689, 1.0763537980761524, 1.1999791770203998, 1.0708677900475152, 1.2144597146964218, 1.084163787451095, -0.02454859383188961, -0.005314511892509331, 1.0304343048161049, 0.14275892514515268, 1.0789664766036324, 1.071864610960612, 1.048922108184061, 1.064436188413323, 1.003423434013792},
    {1.1180936112798334, 0.9290934183591467, 0.9970493580095982, 1.4370312177288715, 1.3064545664608391, 0.6979603568176044, 1.2192849878567882, 0.8961553764046514, 1.0481842387899754, 1.1523241842237648, 0.7849775753745437, 0.6471150787084885, 1.0474996154401324, 1.1396469112799845, 1.0473805027119283, 0.7048560685596942, 1.1909150873060577, 0.6790719264505402, 1.1176795627437666, 1.2070399541269743, 0.7481461306316685, 1.201312231465765, 1.0945808557332504, 0.337899552994256, 0.10618138930754681, 1.085761454646591, -0.02732797900788725, 1.0877906420640453, 1.1695893262000847, 1.082037591735427, 1.4320870044247573, 1.1432735090109953},
    {1.0388117658401712, 0.923382943911209, 1.0155765632251417, 1.102962393097318, 0.9736895055766889, 1.0334812364967803, 1.1382408806722897, 1.4035892861705126, 0.8607915335235897, 1.1637680695299037, 0.8041122687289578, 0.5774894704074743, 0.620623992831981, 0.6468699517755597, 1.2937846973678075, 1.1818664574312796, 1.321979106446855, 0.33956426834707154, 0.6752298934241895, 1.1444192594444327, 1.219885704729302, 1.4990351782814584, 1.218551647565751, 0.05829808787116827, -0.09697852732768929, 0.8615186106015966, -0.39913883810387296, 1.0066501346806902, 0.9924270781505893, 1.2013691865438911, 0.9554738915789376, 0.563158924854656},
    {0.9842919988925481, 1.2324979316221256, 1.093760575105055, 1.2186105577438995, 1.0727347489172407, 0.8388554500758674, 1.0636587864001235, 1.0909256145729713, 0.9898779837507183, 0.6544728213000891, 0.9450354797132913, 0.6697780757721659, 1.097699709851736, 0.6489842938836119, 1.3038779654682817, 0.6060767256208857, 0.9623569402096104, 0.6100730996892801, 0.8900613419457722, 1.1776646492909075, 0.8208693584830773, 0.9853293972975777, 1.4503271561980757, 0.28623087122708446, 0.07363712865916026, 1.0512944278177883, -0.35048186509568274, 1.0544607497923817, 0.964897590971394, 1.1001665068831632, 0.8468579632271571, 0.85731478545152},
    {0.8192049939545342, 0.8975020102430807, 1.084755827686475, 1.274295789308768, 0.7780824381093157, 1.0939954381805175, 1.089758218617755, 1.0988649187684698, 0.8371975092594349, 1.2773927596815375, 0.6719346213035249, 0.6850423477485776, 0.7591693385491523, 0.8843883799075808, 1.1359394298234686, 0.6675356056207388, 1.339927316078477, 0.8537239889278014, 1.0886905701008023, 1.09657773742642, 1.2478025705520017, 1.2498434934795375, 1.1570164371981932, -0.2756430519984312, 0.2127518099338159, 0.959171518171527, -0.35537198115158286, 1.030536206368639, 0.8887958592657593, 1.0572662570656872, 0.7980526113084788, 0.6266309604113316},
    {0.6344600181244084, 1.382598060651426, 0.9022041187996936, 1.1415505424734773, 0.9237298243317108, 1.1064041350762575, 1.3338871758515707, 1.3936797158221577, 1.335031104570351, 1.2113204808524956, 0.9161959091506833, 0.5542253775909474, 0.9949106441649036, 0.7499417780208467, 1.0388065657839787, 0.8149783649731818, 1.3025279418917255, 0.5768833695419155, 1.1017222991825153, 0.9827018653313493, 1.2565212327805857, 1.0424497882394663, 1.1403537559910786, -0.18846058650322514, -0.5610337810783008, 1.1934178198101502, 0.22240852316500948, 1.1483449001493107, 0.8370820349789369, 1.2091001931645153, 1.1224691116499093, 1.0239938830188688},
    {0.9882464347710237, 0.8277759300565187, 1.2379673878963715, 1.0995091869408369, 0.8427318829591408, 1.020045989554205, 1.3585243303075925, 1.0524522409332895, 0.7376845453577129, 0.9747521617459287, 1.0919171013110904, 0.689267660475468, 1.0328530160218576, 0.9905610161112268, 1.2295723995976053, 0.7286210895393406, 1.3035466166999399, 0.71647914181553, 1.1277510474853663, 1.4331604866902188, 1.017097747802659, 1.0689343709360053, 1.0046154884443765, 0.09583285220512312, -0.10614231063401723, 0.9291827974286696, 0.0027801079731899357, 0.9334109002975991, 1.2114701306477405, 1.1980957921363864, 0.9653166989052145, 1.1716302131457341},
    {0.806862814649792, 0.7763878665440602, 1.0592976720088583, 1.2170777315722403, 0.9798243251487297, 1.0689831387916495, 1.2570112824301642, 0.9991389194892192, 0.8988039459977697, 1.0302496689668175, 0.7636409005936755, 0.6004482461594759, 1.1551747492557416, 0.8239367403553979, 1.2014890465228343, 0.7948978501161136, 1.159950956952087, 0.3385060093482645, 0.8719150980235432, 0.9490738606606249, 1.1489619300538023, 1.009427024399529, 1.20526897188005, -0.3975395827476843, -0.261929586527971, 1.4967954101163643, -0.15570625765408103, 0.9011686252851718, 1.1486980992603637, 0.7794651145926991, 0.8082984917716729, 1.3243090394866937},
    {1.0288275756026737, 0.583217178348747, 1.0447855554570318, 1.1455536693583837, 1.187467743822741, 0.845618916700094, 0.920610307594121, 1.439525448614002, 0.9605657018310628, 1.0326018610941212, 0.5378301684085787, 0.4465705995108511, 1.168358598897939, 0.7195184639386718, 1.0445765875272601, 0.6299966016194015, 1.137899942636974, 0.6815856319494868, 0.7370098976016228, 1.138970835516862, 1.0929127237644662, 0.8590392362888344, 1.1884146159567945, -0.41412801742054367, 0.15877501023362714, 0.8672524605659679, 0.049362864696326586, 0.9336596125708505, 1.1335976393198741, 1.0742655730858983, 1.315162469763648, 1.0589934777957497},
    {0.6696971022140098, 1.1115337521661184, 0.8888810460208182, 0.9813665687647699, 1.2184721046336244, 1.1119922895766365, 1.1420695678758237, 1.1930899384675488, 1.2214481076890416, 1.0187844930649461, 0.6635118691719339, 0.806239365171674, 1.2456730815357442, 1.2027561251579932, 1.0741073620765758, 0.6939025746783692, 1.3263843893670346, 0.6779296337633512, 0.8189265792666888, 1.2046855042144016, 0.9092204597621354, 0.9475704781464942, 1.326563256086945, -0.07754583883303011, 0.09575920768619192, 1.2615501492035683, -0.30252279854581027, 0.8915251891249523, 0.9402319979635075, 1.1551733284862706, 1.0627020987483313, 0.9885727910567983},
    {0.8768980634929404, 1.1099830839284293, 0.901988053784603, 1.1693208269857556, 1.0413402151945517, 1.076496386330703, 1.1582062088591036, 1.2735538741051842, 1.1282806659444435, 0.9591278090641265, 1.0599882024042024, 0.4936701173397321, 0.8127185344113912, 0.8397015892086536, 1.3197581194638655, 0.8076003348704635, 1.2493441244105075, 0.6791010336823464, 0.8570632147503608, 1.0771576642170893, 1.0383497204650622, 0.9288071208566053, 1.0685266809227794, -0.14683113586167704, 0.0848460103828272, 1.1665733214326035, -0.18230188697570074, 0.9523329633721133, 1.0750478286400103, 1.0891885769359433, 1.0216505892256529, 0.7499528139925254},
    {0.6766382402690727, 1.389945373432223, 1.2462091415935908, 1.1594573147618674, 1.0261203364666172, 1.1324396213489945, 1.0170491245394404, 0.9231522715535107, 1.1752621875067168, 1.0967308832295386, 0.9222677467135942, 0.5539646400998697, 0.8110343629980723, 0.561806613350314, 1.3431964490823396, 0.5224262309519103, 1.1433395091305878, 0.5129381550977622, 0.6222680578431167, 1.2799538120285778, 1.1372834107851837, 1.4576876172894733, 1.1109743656782114, 0.04261239887326341, -0.11088872942628206, 0.7849043926374542, -0.05072869221115614, 0.7104259639924996, 0.8128331058427141, 0.8894180129161474, 1.0048581694112566, 0.9836318509063131},
    {0.8353257422703373, 0.8708798582955516, 0.7428096305436148, 1.0637699919864263, 1.196893204101355, 0.8006097096082653, 1.3252447433940573, 1.1186947661752227, 0.7764447351074153, 1.0023475441722307, 0.8884463201552236, 0.33640087827808046, 0.8544652645833688, 1.2436787875724165, 1.3452033524189326, 0.647416261676946, 1.2191090408559728, 0.7973662447071896, 0.8964242214400105, 0.7310569727082388, 1.1421833265311083, 1.2333264471326615, 0.997112854405642, -0.020225699089844694, -0.20037205558436763, 0.7961376452579713, 0.0022521387470268773, 0.7208140078030973, 1.3981826575963117, 1.1164264378087765, 1.4747794121117777, 0.8150842095629113},
    {0.7116191384829292, 0.727934372630966, 1.221566087159573, 0.8614786934648345, 1.4584213582356114, 1.0735199958620192, 1.2406155624543669, 1.186564757250504, 1.2530027510690285, 0.988596688267609, 1.1019151973922137, 0.6255011051265451, 1.2217919149659848, 0.7354692319049101, 0.8747496637413367, 0.8319163495650675, 1.0172479835444628, 0.7683591154013629, 1.0046275218758416, 1.0535414848673303, 1.1481544684367837, 1.1339626042197233, 1.1690013401467785, 0.3031058878014036, 0.09429346647625156, 0.8792973915447293, 0.2701734019130899, 1.0544219870639242, 0.8986254201135722, 1.1129836135308822, 0.9982199545627021, 0.873890628201804},
    {0.8146724622681474, 1.0254709668297453, 0.9967079089504405, 0.9327474683135518, 0.9637728223788817, 0.7494918264980427, 1.4866066951249493, 1.0343808191369364, 0.8911949816564347, 0.9547059986221903, 0.8795499950737, 0.6172775608943589, 0.9848849472484938, 1.3309904125612533, 1.17854745243535, 0.8636904673226483, 1.349038034659644, 0.8031838187363948, 0.8664504282153749, 1.3762989508719958, 1.0226628243970597, 1.0503617332597015, 1.2089532218588186, 0.3417263282441384, -0.31135410974384065, 1.0373100157610922, -0.06405268052303195, 0.871520052377856, 1.1659736307325865, 1.1921565238095428, 0.9425478548698545, 0.8704955104539607},
    {1.003262821092115, 1.1593644953477977, 1.1898547719162351, 1.1452231423476882, 1.3608923308572372, 0.9938188698587219, 1.1703446219557878, 1.248946440883622, 1.1607141347027725, 0.7251156295061244, 0.773787457051438, 0.31826085850844615, 1.1441812690016273, 0.9642305046459253, 1.2461196301626132, 0.8286357418497724, 0.8645279950560967, 0.5057498553318307, 0.9422211377880595, 0.7569988224669916, 0.8763572687987801, 1.184777668719721, 1.0697614029247444, -0.14923919982465778, -0.11299755362331174, 1.086038615542277, 0.036818234583205836, 0.854982959592119, 0.833760826629624, 1.0107748113562687, 1.022076772934528, 0.7852666280774695},
    {0.8426816869368252, 0.6745766135490738, 1.3278060000184135, 1.3929920140852496, 0.866241921963905, 0.5575122320157976, 1.220966091112401, 1.150023074733157, 1.0563155547314602, 1.1331703751865851, 0.7188240614563571, 0.46782670376201146, 0.8470495094726344, 1.2244868266841271, 0.9866732396183034, 1.1568193830450648, 0.9313075204818184, 0.3758279647295181, 1.000129486709995, 1.2859042708470223, 1.0144020661370319, 1.2756595286049428, 1.3114396312876015, 0.23042128072528006, -0.1413191898543402, 1.2755304760273145, -0.11857589991328102, 0.7666421400061563, 1.0894055943708396, 0.7921838307188382, 1.1396209441148504, 0.8984184521255076},
    {0.7169836281344493, 0.8553764400092791, 0.9144066220308237, 1.0859158448703867, 0.7869589393036496, 0.840461589949467, 1.4071657530505173, 1.2279995474311445, 1.2159920396404342, 0.953114213233434, 0.8956190562843912, 0.6439348008928875, 1.1980341440683504, 0.8436282618433062, 1.3198622709419858, 1.0325860655510883, 0.7876219434158508, 0.642740477032096, 0.9840325330709732, 0.9639646257158617, 0.9436163655466578, 0.7820995790003584, 0.9932100181164429, -0.0001540297068037541, -0.3474127930675099, 1.4531887142920779, -0.2267357014497919, 1.2447888414528332, 0.7474525713904362, 0.7048061095362064, 1.13281143109016, 0.9198276568559709},
    {0.6755088353132969, 1.1015491286228987, 1.2675060151323443, 1.202483872377974, 0.886067871106073, 0.7986121662770146, 1.2808839470176119, 1.3490505661528538, 0.9434534571782205, 0.9136907427018157, 1.0242658113493497, 0.4618080548579167, 1.2317877480829642, 0.7529363775898735, 0.7680945644161029, 0.40515578045648226, 0.8319070967544794, 0.6729381519309932, 0.9402729627404168, 0.9818511715135637, 1.0406436658606997, 1.3171560949152696, 1.2804789560366066, 0.09368935384801008, 0.0031623707689633794, 1.1779486561019679, -0.3811805674816493, 0.9034200056235098, 0.9570853717599387, 1.1374415676519571, 1.1230411340405293, 0.6977183460453106},
    {0.9207223410155256, 0.9712801255144944, 0.9525919006050072, 1.0454088100084442, 0.7416183719938846, 1.0493957927761386, 1.2015732335438782, 0.8797981788139181, 0.7027020498235628, 1.2168383488154164, 0.6711433365769167, 0.6409119883353597, 1.24604537228357, 0.8686406017879396, 1.0731837797777448, 0.8547509004220356, 1.1457321265012461, 0.586831570152014, 0.8905425243157274, 0.9525959127991843, 0.9289624620324671, 1.0874832356821003, 1.352608561094682, -0.4945137452430792, 0.09639972881215593, 0.6850524064152332, -0.15347264711875258, 1.1303248487431425, 0.9312415688398774, 0.6484457900543161, 1.0810782425483625, 1.1743758239067217},
    {1.1826701750245103, 1.205148160274608, 1.0804891811957626, 1.1349377480002576, 1.126939182613659, 0.9291489657414279, 0.9156411973746956, 0.9062404331699927, 1.0767631879672197, 0.9483955302888057, 0.8338316448261095, 0.5743702130682306, 0.9907048213903732, 0.7157890092508163, 1.2294919362717671, 0.7524965360788738, 1.520630440669984, 0.9308379158448614, 1.1095565054222343, 1.2952575355473022, 0.9060435153361247, 1.3742042209257852, 1.1874743331240416, -0.48401429652675865, 0.032414359611302616, 1.1548213834142227, -0.013948243877781067, 0.9979581973325528, 0.850119730571177, 1.1276126729738738, 1.04966064167241, 1.0817244037696503},
    {0.6787926850280263, 0.8125578093214805, 0.9410512099622366, 1.1899524454471135, 1.1066836439583354, 1.1491328326393606, 1.0537256653135672, 0.9980757412170453, 0.8882960302976503, 0.91375837567581, 0.9947252054853692, 0.5449054105410439, 1.2076822997323762, 1.010335761401786, 0.7985657841961685, 0.6757386014694523, 1.0324695407327393, 0.4489845330282448, 0.9945003994192249, 1.3225276795209473, 1.1330136210685042, 1.1978337168954059, 1.2897364445926722, -0.15778511008751697, -0.1562533540273572, 1.1279221220030438, -0.3175236081584322, 0.8528983654437493, 1.0726285609265074, 1.133204939051052, 1.0794873331476003, 1.0738771808793754},
    {1.1437060671444714, 1.022407854639231, 1.1220830621111222, 1.0871587641952516, 1.166080738628171, 1.0593713956217068, 0.9800243801467119, 1.072229813592498, 0.9636097536756035, 1.028312315785822, 0.726183498629818, 0.8325417276994567, 0.8504420273010653, 0.7794639210555965, 0.9742744440532448, 0.679225867296895, 1.159328637864417, 0.605538226262968, 0.8553995790853904, 1.1317879604841228, 1.0302551821655312, 0.9462273582226564, 1.1466443219156335, -0.0420433026453971, -0.14408989575115733, 1.1295812037860689, -0.08702070931011546, 0.7796220654376141, 1.2031602743302148, 1.3029447923184079, 0.9006595285082202, 0.9797925305954109},
    {0.7663324809909178, 0.9962375301284121, 1.1649931147567094, 1.337144041755798, 0.7481563417996269, 1.2025655721295367, 1.148883569379496, 1.3587887013976876, 0.8528247848297316, 1.0705420310362148, 0.6900846905668344, 0.5911205498201674, 1.2553690102868131, 0.8046082555578192, 1.228305269619019, 0.6115408503690719, 1.014794112514688, 0.6683082539716595, 0.9118463175669203, 0.9561977006494266, 0.953834377506779, 1.0515014438770618, 1.26794504351119, 0.11401922614145554, -0.20284147081607576, 1.0342262614002165, -0.003852450060888164, 0.8675751368897224, 0.7965777209372242, 0.7636982879817736, 0.9093985565494062, 0.6162988878204507},
    {1.044754011251092, 0.976976256386858, 1.0364906544023242, 1.380836276968963, 0.885019787572268, 0.9139740784064115, 0.8860079297359427, 1.1120431402646906, 1.0804040551761864, 0.9175271883831093, 0.8208070386245896, 0.704571966539668, 1.235829391196756, 1.0295220723294287, 1.090141583745516, 0.5771839720330194, 1.0102608484515185, 0.7478686943417455, 0.5516357045312521, 1.168548225314868, 0.9820144695781043, 1.3443414221295347, 1.2978136263120708, -0.08559160475551983, 0.035363232584953185, 0.8670315082778935, -0.053692409168291676, 1.297117706674174, 0.7919498815233084, 1.2163358191851277, 1.3940759086283245, 1.1862533762847591},
    {0.7652734722657845, 0.7356867507444822, 0.7957577497989317, 0.9282764875156149, 0.6450892337489775, 0.9092953689718506, 1.139887099775845, 1.249606430443718, 1.0807596590736988, 1.0559003971276835, 0.7163099453297818, 0.5842029718199884, 1.033268854334718, 0.564992916481664, 0.8050143645486336, 0.45895926885252764, 1.0914422323783095, 0.7607575414488507, 1.118285630928078, 1.0936113880877039, 1.1510842862652313, 1.099714861427858, 1.3597519118950965, 0.05861974124383575, 0.19013939391281298, 0.9228966115483812, -0.09852254459510416, 0.9721391388496838, 1.179466351784332, 1.393268369605203, 1.3983088134004937, 1.0957384825026064},
    {0.6177846885059378, 0.6932505409472004, 0.8270733456119793, 1.1918697757869114, 1.0047003653616713, 1.1563386338398745, 0.8122583340163098, 1.0558893061801125, 1.2719580521093443, 1.0630419242691727, 0.9504023620927564, 0.8003279637169357, 1.011488982462007, 1.0980223321839047, 1.0136502833487782, 1.1027167665182516, 1.1789305062441502, 0.7519679959360238, 1.0895957668601879, 0.945944254198218, 0.7816287556532453, 0.977581012216434, 0.971706622344262, -0.20416290623460648, 0.008216113620169007, 1.3148782026183727, -0.3052554171966242, 0.8337033201208327, 0.8366699553912549, 0.9149273843216923, 0.820954302883837, 0.7285285017294454},
    {0.7665441473800636, 1.0722525888828456, 0.8705871361783839, 0.9342062956772813, 0.8159015900607791, 0.6073536196673694, 1.1752139967908648, 1.2649765231342152, 1.1099175887674837, 1.4510199963308348, 1.0178364881018571, 0.2634900754708413, 0.9471933779000045, 0.6677528748837313, 1.4398485567182897, 0.7458514533447761, 1.0776090863350243, 0.48899068996544165, 1.0040245400518801, 1.2215836415976273, 0.9355658037023811, 0.8542779775240883, 1.1447267734134596, -0.06247940016154758, -0.1488238889145715, 0.7858525582816187, 0.08805877927358055, 0.8958922161779904, 0.9026472942529494, 0.8283394769045925, 0.9849964336400385, 0.9185629689713796},
    {0.8400584031324092, 1.0324445811468963, 1.1594675903326594, 1.0845403157480338, 0.9535047334628147, 0.773468521662389, 1.285581144525631, 1.2781392259699142, 0.7402785052731624, 0.9759883233099158, 0.9327192066520905, 0.48573956165348525, 1.1374815204385298, 0.7680278652852134, 1.4058543230668774, 0.8674065966325978, 0.8181840200563774, 0.6642407153071969, 1.069470666548111, 1.1795124478625827, 0.8980281047842631, 1.1764044891113234, 1.1535556326708198, -0.38881417299477594, 0.0031951066037140775, 1.0746155158649302, 0.02696997515214196, 1.1663917070502712, 1.0221253808704889, 1.3253515874323452, 1.0815833921149078, 0.8762598443639608},
    {0.8093943007852351, 1.1206892496677179, 1.2453856693987881, 1.1711861029799446, 0.566549403778493, 0.8260388766959459, 1.130649201579171, 1.2324898521305563, 1.0112444705890713, 1.0884321682922973, 0.5997763137889734, 0.6346445586963416, 1.0011554001482286, 0.8797872468218156, 1.3480426446827465, 0.8761109669272859, 1.0557284258544588, 0.6722895427753125, 0.9682820648932634, 1.6523706891465082, 0.9514523544981824, 1.105149536104413, 1.1573263230653867, 0.04622521336678007, 0.1008359878866981, 0.9255618676731926, -0.04480138648018124, 0.9502512802099692, 0.7355241186884095, 1.1444368408569097, 1.0805302490405915, 0.8112496284200154},
    {0.6166950882799849, 1.0060550960232122, 0.9086820339673655, 1.0989402520174851, 1.0909493139340618, 0.8483947591776062, 1.0059766324250237, 1.2219906387199233, 1.2940556389879643, 0.8022561911038893, 0.8464779887875101, 0.4325857450167303, 0.8270016786828958, 0.8646438631358067, 1.3187257374012267, 0.6699876258724783, 1.2286747649317813, 0.6773429078517045, 0.8102314971933123, 1.0547961690881984, 1.3751566351746407, 1.0969533295198457, 1.2502576259439293, -0.18109682310368616, -0.009273083580893848, 1.2575562368978443, 0.23956318442596783, 0.5556602274215082, 1.1289959166061467, 1.0218672458515177, 0.9139656910810726, 1.000499601410148},
    {0.7594895601141595, 1.2383258058579225, 1.285088401479157, 1.0876774603330515, 0.926195424334737, 0.8594476730430101, 0.9119402302610914, 1.1657924518817098, 0.9469067859158711, 1.326524545052439, 0.6855111885598069, 0.7269224041583876, 1.2480757938256222, 0.7243510287498395, 1.0210256254343617, 0.7760825566537003, 1.0748924859223785, 1.006035331613745, 0.8088899864481337, 1.4145623601638693, 0.8697657599480635, 1.196800837264926, 1.0603081118768236, 0.05171492360030938, -0.08802454512983467, 1.2348242374109841, 0.04662145537570948, 0.9305938060895744, 1.1249301019931017, 0.9310613160902056, 0.7704272055481839, 0.7064309004872592},
    {0.8252644396556287, 1.1757044240468888, 1.399751773547469, 0.6997257822793791, 0.8468669125045123, 0.8830283529713254, 1.082795874267128, 1.3601209590790828, 1.0434331163503225, 1.1715693500094446, 0.9762017219563973, 0.4524847373191324, 1.2592373237492942, 0.6619546612261189, 1.3123477199630795, 0.6710082358229029, 1.263904500153111, 0.9213723399020177, 1.065060402314222, 0.7831882849586753, 1.057083752302239, 1.1653465942498233, 0.9507909012978738, 0.09613999858417553, -0.142591361620933, 1.1115672694318193, 0.08828130622391704, 1.024345005891311, 1.0706770502923286, 1.2488966521242681, 1.0869973463135285, 0.37190858869241394},
    {0.8171053990489601, 1.0289888490588468, 0.8767559659249345, 1.0558180926176068, 1.2851277717354224, 0.9166549882720247, 1.4543997035206115, 1.0793417800596463, 1.3734771237235117, 1.2402441311743655, 0.9278998548543068, 0.6553741637956294, 1.059633100827294, 1.039638125966843, 0.8115638467963517, 0.7077694674809291, 1.2272322820327688, 0.9814841103551311, 1.148670990703965, 1.3203260981758425, 0.8857616367695403, 0.7698460406178484, 1.2889996799446468, 0.04409528504720763, -0.12298204882509238, 0.8674826895477469, -0.054500769942439506, 0.7174115461946988, 1.168739696960993, 1.1254596659901661, 1.194964604263629, 1.0051275581138572},
    {0.8177235698707808, 1.054514467018729, 0.8204231704708504, 1.3444289901309414, 0.91800252213826, 0.8313807706257531, 1.2888516746040264, 0.8859349579589696, 1.2105579988815847, 1.333704735461657, 1.1122650389279434, 0.5314363596790348, 0.7261897134233326, 0.9437728346207971, 1.342889694080654, 0.5850279597116931, 0.8889299976438774, 0.5785560561651724, 1.1019315244401116, 1.0092071580952438, 1.1195809950640268, 1.410587034675542, 0.9564656492035049, -0.5266552491039636, 0.0680632010112399, 1.2334782446610475, 0.012783416393488237, 0.7951812106637878, 0.9079193669716242, 1.3928877113823597, 1.3106413567313864, 0.679823255991101},
    {0.5529258312053262, 1.091539751766655, 0.9562440202141181, 1.2817007716759878, 0.8264920473234112, 0.9394876277906096, 1.0827869536713624, 0.7920196133262762, 1.3638710154283666, 0.9996718568891291, 1.008319234807207, 0.6670821102517729, 1.4076452506120016, 0.9818993543378147, 1.0152074085230451, 0.6158454754296059, 1.2781401335866363, 0.6783714083769637, 0.6831543470122593, 1.150443027993488, 0.9669634977096156, 0.6999934085557684, 1.191078802790983, -0.046306353918974974, -0.15570125913850147, 0.8569827390138679, 0.282037032862453, 0.9519352984507092, 0.8987371174741607, 1.0616762863912534, 1.070048677950827, 1.018006030974099},
    {1.0813474840301867, 0.8073255706187709, 1.2025266051082149, 1.0193283124597663, 0.7932909431751396, 0.8117510285185875, 1.037160022250162, 0.8540607255768919, 0.8773772869720602, 0.917483713690955, 1.0632661292234107, 0.8204146252893063, 1.0712752829777854, 1.1172144626744192, 1.1555229303935743, 0.42622374005933583, 1.1393527302844857, 0.6682235895009877, 0.8767565023254325, 1.0623747234649263, 0.9765250366849961, 1.1009475324952447, 1.0314836709998207, -0.27113904288214596, 0.25027574353184695, 1.0550938825797442, -0.4213279740097917, 0.7366888379803316, 0.9006713419027742, 1.0779160709811353, 1.0504796797416718, 0.9193156672406552},
    {0.9688329343290022, 1.1089773981112703, 1.115666894720686, 1.2570500205280324, 0.9191947190353867, 0.6206251733006686, 1.3351166304228828, 1.1789416515248756, 1.0712002574018202, 0.9296401171043708, 0.7978838406794916, 0.5035673543646542, 1.113693363311561, 0.9640625848153513, 1.3368716680655741, 0.8012272184084398, 0.9803801541064298, 0.9322519694089214, 1.1419550402311323, 1.21820072199769, 1.096158517393308, 1.2147116799207056, 0.8543090801812888, 0.03176954134804614, -0.16150748399722056, 0.8765635160034593, -0.2036121284295959, 0.9886900442357724, 0.9053131181113678, 0.9266067959352839, 1.0649329640581728, 0.9256835808742347},
    {0.7793556404961953, 0.8575842510371237, 0.7928336661173706, 1.1458902147756498, 0.8458074716646483, 1.2239747661973404, 1.1714605736859394, 1.1643291158283127, 1.1430562526775883, 1.0843804098514618, 1.014869846243719, 0.7467787075411452, 0.9549636583849771, 1.083776358273715, 1.0025282401371547, 0.4642693813058271, 0.9067995114386624, 0.6716413140562687, 0.690095795425395, 1.3101860686106015, 1.1365870262198303, 1.1272768823519508, 1.1836612672344817, 0.001283264558238849, 0.05641978730656857, 0.9161078170439468, -0.15039397424230846, 1.0765926232114984, 1.03713188201333, 0.9963283185635132, 1.0130255778473838, 0.9940522882212084},
    {0.7415163892537172, 0.9138468795902498, 1.1815391098435106, 1.047076631634759, 1.03921350683326, 1.019328056382371, 1.0579648239964703, 1.146051419755807, 0.9478151489098963, 1.1825943682446989, 0.8250203850189712, 0.6520985990641243, 1.0418494260874718, 0.7331373256288106, 1.2548737407098163, 1.1337555500218355, 1.2903309272296637, 0.44898019389698524, 1.0485546093547597, 1.2060820157777252, 1.1520622947434096, 1.0846579233677942, 1.2811771237099496, -0.12953569336012158, 0.27566264009361824, 1.018267013412434, -0.056754119402126206, 0.9009006595418781, 0.9586954068569369, 0.912726502344421, 1.2530645953577026, 0.7916659697966811},
    {0.6764712810702102, 0.882425157425097, 1.2505928136752862, 1.4863503650696228, 0.8481830405799659, 1.0621115571014639, 0.7394550280849393, 1.3951768751786797, 0.8472904465159169, 1.1200716431004318, 1.021179534449779, 0.2973966576882345, 0.873300327371207, 1.0550032453531912, 1.1582576982060486, 0.9262976682119934, 1.1382087108923846, 0.9283398724511019, 1.1626950277457395, 1.0817459776099245, 0.8873246193701863, 0.9208595805304997, 1.269207696626578, -0.2803684818857901, 0.014929078929129064, 1.109117472409534, -0.48227900733695245, 0.9079592304133174, 1.041802091338663, 0.8964854349754167, 0.9087199835223374, 0.5999411571709975},
    {0.8275552930070811, 0.5949637774453134, 0.6608994784002927, 0.8290941527484909, 0.9912196968176153, 0.876868806024373, 0.9892089377167033, 1.2544965188158523, 0.9167670343119195, 1.2488337313552131, 0.7863120531685918, 0.7305602041694887, 1.008814069889254, 0.8875240203333205, 1.0630324086290834, 0.8484268267316857, 1.2411489377052294, 0.6524908988458908, 1.0975711861762778, 1.0673214217651656, 0.758061629440657, 0.7966626724400605, 1.0909644072957188, 0.18617614952656575, 0.09725228613883126, 0.9040686960468924, -0.10535022572067486, 1.1598162779752526, 1.0732093498347237, 1.2477284263277226, 1.0782654844965924, 0.8992118021363592},
    {0.6143588425141934, 1.2005114962418748, 1.0461041980653305, 1.1523995541184995, 1.1673509146616674, 0.8093185292983475, 1.1000891937954669, 0.9402409054104633, 0.9916247112137885, 1.0281871698302396, 1.1297338360182774, 0.5052495206598874, 0.9788158967269394, 1.0156299868125618, 1.0991724940830487, 0.7523716769990965, 1.1773895521949453, 0.8200266417677662, 0.8238298279743066, 1.1108527491313156, 1.1742984137153492, 1.0215619625429577, 1.3977814864713942, -0.1940732253679956, -0.03327002418710858, 1.1336541273227767, 0.12495886212637831, 1.1755388615462778, 1.2131139795440622, 1.3508365607592416, 1.2816071282385795, 1.1748557014202043},
    {0.8947249769107816, 1.357950587200866, 0.9081104244284128, 0.8831281835701527, 1.025758286925099, 0.9274126385154682, 1.2775280643394662, 1.0522750619402335, 1.1027323174915153, 1.2155165685525622, 0.9103036283442029, 0.5402496200586882, 1.0565453124251236, 0.9373722794806165, 1.2376060975263767, 0.7474065182127012, 1.4800086923074942, 0.8152876611043973, 0.9599016607344424, 1.1332431313859515, 0.9537718086205532, 1.274313750832248, 1.144419007147936, -0.29392316449813005, -0.5445882644287068, 1.3300056031390195, 0.14362933078922455, 0.8797801116092089, 1.0029023207128813, 1.1554056565925455, 1.0200289376744966, 0.7370994728113789},
    {1.160150676954555, 0.9542218268903845, 1.08758930411414, 1.284527021983872, 0.9910124200439183, 1.1412143455088997, 1.0429486221089892, 1.0924763867405891, 1.025921074149412, 0.9014601844125787, 0.9342179395374992, 0.48028676613592436, 0.937374667081141, 0.8717494072050006, 1.2345586612369026, 0.39615861894991056, 0.882854601270338, 0.7864641547515165, 0.9407610819781537, 0.9414389456084863, 0.6910120413739489, 1.0955367083599246, 1.1669482019426174, -0.08438278681073323, -0.4083922562830939, 1.0151137799640542, -0.24455180662121584, 1.0057410208376945, 0.8204243737699896, 1.4227968874666985, 1.1812001622217119, 0.8813081510113234},
    {0.580399454802332, 1.102691581014828, 0.9645937883426502, 0.7693048923508099, 0.9477920055914469, 1.1517488712957613, 1.168552265181785, 1.236596555181136, 1.0684153771868508, 0.9428511802528627, 0.7678848590457569, 0.5213798089119751, 1.2699095242196916, 0.9676623486245794, 1.3343682167609823, 0.36043983967474524, 1.0691337955877651, 0.8193646365198396, 1.0569179150059451, 1.0768985430406954, 0.9729335430862286, 1.1128753260125268, 0.8887157243178535, 0.07484090858207307, -0.4053606040017627, 1.1387069600635846, -0.0050872069812659725, 0.7613497196158364, 0.7631815996443025, 1.2643083044295744, 1.1076376238825631, 0.9691984347442916},
    {0.4837490783319837, 0.9831443060767485, 1.0544773562906729, 0.9562421945564907, 1.0697444991152663, 1.088296241007932, 1.132207559522714, 1.0103692509439846, 0.8849240533332171, 0.9415298030154196, 0.5807928272164307, 0.40926373061943855, 1.2249641385149275, 0.6866375963919005, 1.4677652060414992, 0.8289713943089719, 1.2224933187943923, 0.7903067245494116, 1.095787775859629, 0.8743381373239493, 1.192617778694753, 1.1293809047493273, 1.1803391149029463, -0.011839768723180912, 0.1306063471108066, 0.9336328349934754, -0.034481280735726684, 0.9404782156961018, 0.6603577356014548, 0.914085782433205, 0.9553808351783157, 1.0865908942228506},
    {1.0367687152882357, 1.1485095846245492, 0.7517122205218173, 1.2381984303471425, 0.7398099812337636, 0.8896572917539989, 1.2575391813847683, 1.1047934102297277, 1.1184605344003733, 0.8419082469275161, 0.8075039734082947, 0.6213099263775311, 1.0369551032606579, 0.6712972139398705, 1.0340578457647385, 0.8432084193807641, 1.4732395339854825, 1.0254099533323218, 1.0408586290120465, 0.8310038690567425, 0.6651942962637138, 1.4249657246108811, 1.1740360148586348, 0.0019863583672713285, 0.0608402048243542, 0.9790000949406881, 0.22261870310140938, 0.995247169997741, 0.8669893911503026, 0.9809767354268677, 1.2022789537588967, 0.7793174428353153},
    {1.0106434255863663, 1.0331575441625147, 0.8398800647645014, 1.0865641828768102, 1.0838426236288492, 0.8661284875721129, 1.0938278836564324, 1.2183556740172798, 1.2381377300041059, 1.1103730311664994, 0.9886475353530548, 0.3550719884627319, 1.020844636749682, 0.7379421760737788, 0.9031174204701894, 0.788764058984674, 1.1987285137224157, 0.6130942127941738, 0.977644409422675, 1.3477652255343906, 1.2559326649025118, 1.2183998339778264, 1.1904621604929304, 0.12799914290982353, -0.16166901518216423, 1.0677309529391636, 0.1761123565690558, 0.8058060803517262, 1.1822064677675468, 1.0514992291866383, 0.9536583618241242, 0.7164968993075462},
    {0.9240232797886553, 0.7967539031746035, 1.1398577245143935, 1.1435638230168879, 1.0237362049566454, 0.8343725102656412, 0.8902979054018516, 0.8785507038651734, 0.7178430014054048, 1.1444823710725414, 0.8838166216589156, 0.3966281839954661, 1.1149960171410107, 0.9778438646449191, 1.237772075634755, 0.6900304692035677, 1.3350563848769699, 0.9909656760827711, 0.905944503955756, 1.1881121187645611, 1.1818436056370516, 0.9943642024450001, 1.2168195807352657, -0.2070292293446766, 0.0749814092816641, 1.1761323049030625, -0.15849181563106554, 0.9472185189605067, 1.0721400987202285, 1.057003310748732, 0.8944011549453831, 0.9300034018158303},
    {1.1659951726929065, 1.0203568139078552, 1.1460597433154402, 0.7346029162421126, 1.0438037530231132, 1.1719383140732584, 1.3436537679217082, 0.7636112247188808, 1.1548360492178187, 1.161365466154075, 1.305436506101977, 0.7724058073698844, 1.1347082772122976, 0.7019284919302535, 1.128926857330708, 0.7876467396218905, 0.9169669075804374, 0.6528070601711454, 0.9778124630248255, 1.1132589654935252, 1.1305336137645658, 0.9887166499740265, 1.3057179677730049, -0.010841083845892925, 0.3829595003887593, 0.8706500055150436, 0.003907638964327536, 0.7170714768498981, 1.6080457546463118, 1.3195795734824112, 1.1384040337800962, 0.7414695030212419},
    {0.5860399588675068, 0.9991032254769038, 0.9514580142727408, 1.2905545678092007, 0.8009193149147842, 0.7507219298952066, 0.9774495489717462, 1.3946835144410008, 1.3024518767392186, 1.0088249536904044, 0.9504850264282867, 0.6756116877356656, 1.0643491579996343, 0.8588077155332327, 1.4067635649899317, 0.4864704322321527, 1.1997188692822616, 0.5529914349952247, 1.1042661103115297, 1.0025282983298773, 1.0849075752033757, 1.0539711683574455, 1.2697801409983318, -0.02272930687005666, 0.08527634153635634, 1.0796627227320217, -0.0579028349952998, 0.6655826259702832, 1.4360429277831857, 1.1125593260641773, 0.9802670481995216, 0.7558877900194242},
    {0.9273068108736204, 0.7480514267647834, 1.5932594816443117, 0.8995070249179634, 0.8151757390759917, 0.7619150405473725, 1.2313685228811861, 1.1840188952499369, 0.769814011582637, 1.0323706331885276, 0.7161590991278319, 0.7013989288621627, 1.0485409626725697, 1.1668200670273987, 0.9584391682475606, 0.7851137987324612, 1.3055619950327877, 0.7789908970613327, 0.8223412525875143, 1.1636586460002778, 0.9015983642161992, 1.2410177681945609, 1.2934609252902487, 0.07739853888288993, 0.01952350711291207, 1.1210010634821526, 0.08525971306326881, 0.3760911712933347, 0.7597674493931393, 1.0217637767729817, 1.001733542333464, 0.8537008135180724},
    {1.0952137093278325, 1.1170733829894197, 0.9343374603820672, 1.1977645159087207, 0.8593477066389624, 0.9392294290580675, 1.0100703584999144, 1.177755159401397, 1.0907787839625789, 1.1438890257347465, 0.8828625621843136, 0.9053519119732668, 1.2254622569455766, 0.6710486393392988, 1.3231595732511958, 0.6346793946004406, 1.2431245751276225, 0.4157065103499558, 0.7522610502510746, 1.522392207552774, 0.8652361930456385, 1.0784124260885135, 0.983680758792843, -0.21923926936528215, -0.11429337964312197, 0.9321436012966708, 0.02152429050385674, 1.0348288823573708, 1.1186154261365169, 1.0716111356208995, 0.8657874577069562, 0.8983478283499663},
    {0.7412517898801433, 1.1466737460917282, 0.9562702879543157, 1.1268412100624878, 0.905904033529445, 1.045641812049132, 1.0031776476999719, 1.205971883254598, 1.019512332975375, 1.1335098533488994, 0.9767945943865965, 0.6800449281135724, 0.9514390764743618, 0.6691988319246388, 1.2263041963722483, 0.7415532523887445, 0.954438675616238, 0.627440766598347, 0.986339983176665, 0.8785988308336709, 1.025423033446292, 1.2552875240931303, 1.2302365895512029, -0.0023977665188623576, 0.11761783590818942, 1.3929303879779162, -0.07607111899124047, 0.903861582351258, 0.9708317849369638, 1.275084951762857, 0.9543171659439583, 0.8054373493506611},
    {0.7907523799716192, 0.9614097398739765, 0.9846656229121117, 1.0893991324725536, 1.0831821932186796, 1.203506595759179, 1.0316260446984595, 1.1356012276648384, 0.9654344123802122, 0.872055810767393, 0.7876188807413573, 0.7584824576775423, 0.7239895514806199, 0.7941133025319019, 1.1609141956505837, 0.5043211555238146, 0.9851699085537157, 1.018857977043836, 0.8218665477936881, 1.1737167797781698, 0.914463218935212, 1.1186510892391697, 1.307165778816955, -0.12961785851649654, -0.05273399772992366, 1.1989473303689773, -0.13270570076812543, 0.9905657857010229, 1.1404001500525347, 1.3929896613511068, 0.9904884825944497, 0.5480010909548465},
    {1.1195599395674822, 1.0198060140334646, 1.1672438774793354, 1.4091086343992982, 0.8086008510255861, 0.7780059282330513, 1.3558422803838888, 1.077679379145206, 0.8773466358332376, 1.0845423725213175, 0.7712489300255669, 0.904181420640772, 0.9261438576665516, 0.849946810489533, 1.3910652861017085, 1.0231357824357206, 0.9319259402830048, 0.5148153301745685, 0.9759948014480464, 0.8991144310296395, 0.9966440431097645, 1.2564736554834661, 1.103967501625829, -0.038767904589267974, -0.33755244496357373, 1.2038234568369666, -0.2505253020841038, 0.8707017264199827, 0.8063837526991573, 1.035820097969128, 0.7791956966428164, 1.0815602497676653},
    {0.8437225488769032, 1.1449259290422544, 0.8878557626016976, 0.9365511548390993, 0.9620126136224885, 0.8480762319079832, 0.8893898283429037, 1.1926019529483383, 0.8170236098603425, 1.1129477277144335, 0.793228511466349, 0.09637765450739362, 1.4148771119494634, 1.0263260470426407, 1.0117038522367232, 0.6241171394499488, 1.2667236570807614, 0.617289036777665, 1.0701186359935795, 1.130057278947486, 1.199321734540042, 1.1497628976276335, 1.1157085346233042, -0.1384730960036373, 0.310617420899375, 0.8853673756184122, -0.0032858422580045498, 1.0995296114101285, 1.1568693074850558, 1.123436459194875, 1.1093210881412066, 0.9614207101509692},
    {0.5670676600162939, 0.9693839214349376, 1.035083517027947, 0.7454641361486095, 1.0521018504436164, 0.9701787141856453, 0.9313320519939537, 1.3802098639685088, 1.081488705571984, 1.0711633520259696, 0.9785074387127578, 0.5398123231303323, 1.0794478087745156, 0.7620448628146257, 1.1337918268241012, 0.7971361898025776, 1.1230079957767511, 0.7501596425800917, 1.0364881300618072, 1.3463884958466303, 1.0471446981447834, 1.1512894045762376, 1.2002916096815066, 0.11037653638994009, 0.0828025181859912, 1.0213025659021828, -0.3024320348822247, 0.7806200750595754, 0.7807199976873683, 0.7637565657116404, 0.8544333523939786, 0.8483071068349602},
    {0.7541137539939734, 1.1200033836223187, 1.1334890917599652, 0.8331198169644112, 1.0532885130372265, 1.007703819319633, 1.216195359556734, 1.1166922846052298, 0.7907380351897558, 0.9565522247112054, 0.5441517765734157, 1.0348117955665415, 0.9560072165340251, 0.9739653603270365, 0.9320650037873522, 0.6804259713758298, 1.0698520525626942, 0.674806249864098, 0.63343092132601, 0.9600912263216732, 1.153525647512747, 1.1481415402108657, 1.0765459232986951, -0.09546949008979438, 0.17370078380359988, 0.9550281045556498, -0.1817862605446947, 0.9031547684308932, 1.0014620151653102, 1.3974398287818515, 0.9821946582629317, 1.0092112357900713},
    {0.7094178759856478, 1.0180410391088035, 0.8535297221548162, 1.049221184936598, 0.9338756694008354, 1.0184857305134933, 1.0736921519085814, 1.2627632138851708, 0.9054965647113422, 1.3777852472985732, 0.8315259935526672, 0.7552364738030628, 0.8913968477791622, 0.6601169015068613, 1.36747791995787, 0.7813013443744861, 0.7592043447561948, 0.7011572580354051, 1.0827130949979076, 1.2271973268557346, 1.0558119509899657, 1.221186682245587, 1.288920575771881, -0.12932224262486985, -0.40671619675434895, 1.2114343309155104, -0.06166160734712951, 1.0570627347287538, 1.0190903965791709, 1.1786889642270062, 1.2736934749966211, 0.6167224906037593},
    {0.6255077830483853, 1.4752981961510914, 0.9149610170811371, 1.278037342597744, 0.7132946687141125, 0.8796836382372455, 0.9092929458483285, 0.9557795921110404, 1.1535777462831802, 0.8179078906822715, 0.6639157599029898, 0.5772638979115488, 1.1664953242125284, 0.807370302101048, 0.7247987725276464, 0.8618965227199769, 1.0527199553691697, 0.76740701727024, 0.9655373688864745, 1.2395325123184817, 0.7391499382231994, 1.1763243108286872, 1.1384616969860935, -0.10932502973832706, 0.12223999348526267, 0.854244198810979, -0.29245722769411137, 1.0745872232920264, 0.49416089755714904, 1.3006529137598037, 1.0229612248675044, 0.8795892874060878},
    {0.9177589915634996, 0.8944369381605639, 1.00495045991988, 1.02235121671623, 1.0081352823431688, 0.9666279145324755, 0.9169009340035751, 1.5672430302834486, 1.2726220094812017, 1.0109193292881726, 1.0379893969762635, 0.5500506301816875, 1.0686916522764636, 0.9762305989374269, 0.9926723762850109, 0.5107641414464493, 1.28837260131585, 0.585804337624557, 1.0431581423184828, 0.9460440913524013, 0.9124977658938722, 0.8785877967828754, 1.1826542128886288, -0.179708305358121, -0.16091352813506618, 1.2418441242424587, -0.057944816634218604, 1.0467156567373517, 1.0090884290229678, 0.728410451149985, 1.293043435302332, 0.88595580020884},
    {0.5935040602286175, 0.8815958048147451, 1.144546468309986, 0.8351679981136494, 0.8490936629798186, 0.7645284010224978, 1.444995663468665, 1.0514665833206565, 1.2161748499240523, 1.1601532813746174, 0.8990045251201634, 0.6709291400482532, 0.8382582545005027, 0.6958676117857239, 1.1332331037754573, 0.7306811613792662, 1.460425649981537, 0.869695664929871, 0.75675995341392, 1.0940979171143537, 1.0754508811142387, 1.0044041703036817, 1.179988486467483, 0.0025502316002692853, -0.08596491433504613, 0.8343303352394849, 0.013752300030069334, 1.1473044437455817, 1.094434606877056, 0.8240183855539229, 1.2804234766587343, 1.2584978423118505}
};

static const float b2[32] = {0.7683969985383059, 0.9699864575401406, 0.980963100363536, 0.9997772305217092, 0.9707582101589355, 0.8555615065162223, 1.0686016548239643, 1.0824261576737852, 1.007282239368959, 0.944443676507663, 0.8639033787561291, 0.6457889633493916, 0.9987539243276828, 0.8610753578901857, 1.0746186067313948, 0.6633424200397704, 1.109635809088624, 0.6824926742304885, 0.9281066556121245, 1.1226910919365187, 0.9781235061276286, 1.0453219392149535, 1.1198901970696749, -0.08144170360038397, -0.04674535062918825, 0.9870140074629293, -0.05858109085092594, 0.8427160910557114, 0.939883474889405, 1.0426250275425193, 0.9941399141403509, 0.8891924195968853};

static const float w3[32][16] = {
    {0.8445618877882184, 0.30147824785984895, 1.213395675745184, 0.9851769007934968, 0.8366075136891273, 0.06799300728126835, -0.2131770798219372, 1.127215237203406, 0.15611073799176778, 0.8745668551317329, -0.4470577677164593, 0.030767636541502552, 0.44739401179701344, 0.3628361292842054, -0.13422520800109736, 0.7096534917435388},
    {0.6577631238674844, -0.20710743676577434, 1.3701608068917424, 0.7965553217222887, 0.8955201377995048, -0.053448353345482424, 0.2598171266725017, 1.420033097556338, -0.04280339091822961, 0.9879412682875413, 0.06464174973292648, -0.6543482420400472, 0.11353857805997296, -0.21275310637780595, -0.09867015652671704, 0.7553680409846759},
    {0.9926697273790823, 0.09326352988995072, 1.3490115982810706, 1.6542739576331438, 1.0772614271414196, -0.09692681369092761, -0.2596979206339595, 1.2695935669191212, -0.014609748317081533, 1.0241725055845952, -0.12824279984391196, 0.041912513648391735, -0.09414763349645794, 0.012914146936706386, 0.21893476675234763, 0.9885581218772914},
    {1.3861234138093996, 0.009169234506052462, 0.9862232908701699, 0.9533841017635779, 0.660175816920504, -0.4732415592205971, -0.2303336359105935, 1.5462064360794858, 0.06368797610394364, 1.2941591449599328, -0.07536963572064889, -0.01948514264230461, 0.0894508677345561, -0.2043276230106315, -0.03996062306930684, 1.8144541794416083},
    {1.2490109976778838, 0.2297771613418233, 1.3103444073871937, 1.1822890269452313, 1.0279439662005698, 0.047431077815352156, 0.11287230061770437, 1.0989929522337887, 0.08430739353586615, 0.9139519998806529, -0.3337211995905667, -0.19898311197356022, 0.32047860470798256, -0.047795961763933935, -0.31453537372173834, 1.0763324842143231},
    {0.7785501141737604, 0.18153308497376805, 1.2315314887644686, 1.1342277063134132, 1.0579380056941725, 0.22639596472845086, 0.3224566448012333, 1.2777825649326104, 0.23730700141351013, 1.2424788627130907, 0.15496888684681848, 0.022765385092191896, 0.26654611921600474, -0.14317434569665832, -0.15747973161412773, 0.8728522157734591},
    {1.1359730388429548, -0.2950490569818553, 1.6444787170638029, 0.8805062440569457, 0.8461212482354874, -0.4058139111626513, -0.21141863741750136, 1.6301737845603368, 0.30244219096656544, 1.0231992662896083, 0.12740086385857932, -0.1482141440812305, -0.20878302507956237, 0.04388296962076164, 0.06978026550924969, 1.2890478129036573},
    {0.8483901433365351, 0.19955824819498227, 1.2799369512894505, 1.0729048622840018, 0.8117001814318959, -0.26230442799932346, -0.07443132385773321, 1.213538713142756, -0.2580637557234968, 0.99868577658419, -0.006281868271329688, -0.17704433638154915, -0.4638508153503501, -0.18499733153325715, -0.6232261539858339, 1.630774399056553},
    {1.1734636353247043, -0.3268491579487504, 1.1454842875688693, 0.7840434094615311, 1.0510966457537487, -0.2347465956484943, 0.0035524282671804516, 1.2645494266514665, -0.3921392983233083, 1.0792614723872131, 0.33694119070948925, 0.15474035476747797, -0.033613785792070826, 0.20045682845367638, -0.08172482333796391, 1.1131790099653762},
    {0.8423413993735654, -0.23369114386543138, 1.348863967021714, 1.1516475311585874, 1.08623095683071, 0.2364814793261114, -0.06490856527145929, 1.3240031829919885, 0.054386127070341066, 0.8673204584065574, 0.09337000915683978, 0.22814480113834265, 0.4058496548272457, -0.06999759366845694, 0.10860262292051118, 1.2212819662733305},
    {1.123810662003221, -0.31507288841984443, 1.106807912643538, 1.0940894607573435, 0.629513656530532, -0.04860805399619864, 0.027076393579097927, 1.063523190130567, -0.13750189877912797, 0.892532559750368, -0.2535054056591725, -0.4281732226809189, 0.017111143850893053, 0.31210233852477487, -0.4726264828304793, 0.916951384702046},
    {0.5781606474965578, -0.31433751547774635, 0.36621226803661855, 0.7907785512884908, 1.1465112485083504, 0.009119951213076781, -0.20220336101732847, 0.520418675360107, -0.09749113129319759, 1.0237249283239072, -0.537870869278056, -0.17955701206240338, 0.2621298744614695, -0.2985973518497836, 0.03204178871421033, 1.1489315316928586},
    {1.485867842296985, 0.007418450893332338, 1.2544176060715282, 1.0249368366598843, 1.0182716193479662, 0.23287109111317988, 0.06383408392632457, 1.1354154013003617, -0.4204722126187389, 1.1903323661741834, -0.03341223716162876, -0.4949203306992896, 0.07608734962733603, -0.3032133588433733, -0.08962183033705812, 1.2840384544206742},
    {1.0060889063465577, 0.7872463142743709, 0.6189821099754543, 0.7516521761827064, 0.7262690359108351, -0.3538323065323915, 0.4474073986271045, 1.3971456115104561, 0.06643485809515115, 0.6088764578460197, -0.049904298518691236, 0.13029612351527023, 0.025587736663072704, 0.17886189819366458, 0.022445278504656052, 1.148702754208491},
    {1.2074979691035579, -0.1595499000786452, 1.2915430476080516, 1.3896373162334963, 0.8973124525537715, 0.021564815863030933, -0.0025039444659904733, 1.3262492229855007, -0.4713271056924389, 0.8026004820741534, -0.1010057798074515, 0.03802815110982323, -0.09989565822971594, -0.06458643298540079, 0.4101369576249212, 1.3154535183148546},
    {1.198250436352032, 0.1867379359313604, 0.5125503681684423, 0.6340536555981076, 0.5498263304137433, -0.10627250711195314, -0.346597658032247, 0.9671059472689092, -0.2168112501125399, 0.8144134426148218, -0.4999383583158907, 0.034353819450626634, -0.14785578417396592, -0.06242087447708873, 0.0030332722685044644, 1.3162067358964329},
    {0.7505699422098286, -0.005786765400032507, 1.4105818148858744, 1.2267238056001923, 1.1354942574408873, -0.41575678435776414, 0.19215235570249847, 1.26787005613126, -0.15574429499807924, 1.0112058025611792, -0.029375314545195336, 0.10237614248900846, -0.3152098117246265, -0.016762700343846443, 0.15098464779249215, 1.379696652132389},
    {0.8127057621696753, 0.11664448831150308, 1.1281748825475142, 1.0294294505250594, 0.9116890131409389, 0.09165546427199221, -0.085225268975455, 0.6695822344190031, -0.0008456642791634515, 0.6731962783346697, 0.36233645999755654, 0.39533511664624277, 0.11403683176568014, 0.30290085057063015, 0.3963807273020877, 1.1817250667089094},
    {0.5856158769536429, 0.011002962008895216, 0.9835511050889315, 1.0633401859537246, 0.72554229937991, -0.5542117702536258, -0.5689384804317072, 0.8345719530916693, 0.1474413332260778, 1.4162737368817262, -0.307250483673943, -0.4858126850685433, 0.19963747024433606, 0.003701121802720471, -0.06467852297358444, 1.7134038621402492},
    {1.2355453329769204, -0.5139213351770412, 1.088493635239294, 1.0928116207751186, 1.1544097349168632, 0.08092343000957022, -0.21787554829493355, 1.1922413186127132, -0.6043726733445661, 1.2555622047687063, -0.34017825240880517, -0.12197334583917441, -0.39629744064061845, 0.34068489758260584, -0.09523954647425516, 1.4230639186376206},
    {1.1794685555607853, 0.14019128583933374, 0.9860151293966669, 1.1564450842960095, 0.9931551675444354, 0.05664363425601714, 0.21639119420591973, 1.3816377402484818, -0.7147847276780503, 1.1494267726791596, 0.29379105668315314, -0.11433609694000084, 0.23885479491734835, 0.34236935566421434, 0.30591823212231734, 1.2162495453924906},
    {1.3762912201164597, -0.036246921856084184, 1.2949970016072292, 0.9530787707446383, 1.0598567755201285, 0.17025181169904566, -0.19436297546768444, 1.3942975351747726, 0.15104299220204523, 1.296548327271748, -0.3223002352426288, 0.034653714860900756, -0.4866026515069705, -0.18578443238626133, -0.31067084137403744, 1.132160508138564},
    {0.6059688354137752, 0.0934886025256573, 1.3963796259740766, 1.0148292713276639, 1.3004674340709304, 0.14662201553522858, 0.18109360009964992, 1.3244976336888805, -0.17910731012203168, 0.6776476856365411, -0.18642593756091444, -0.014988545077339096, 0.1109901003697173, -0.4733610124340057, -0.3901596135760414, 1.0941536832606023},
    {-0.22579803319545363, -0.07064234198848296, 0.14651908277664868, 0.1027547772512377, 0.19729944301951086, -0.5493247945780692, -0.5966526018546593, -0.31192425613720015, 0.33586600561344615, -0.2900962187867123, 0.237464457823431, 0.5172760918599529, -0.032105331086340935, -0.26337511075927844, -0.46099590219354175, 0.10343274011458782},
    {-0.03448115211985673, -0.12562202557894547, 0.3558545965709983, 0.0717777187314113, -0.3059374018503, 0.16368356133810816, 0.30694758987779897, -0.20126142054706678, 0.16467647974722943, 0.29891354028144845, -0.09642759558982103, 0.45021583758888223, -0.028641823719391602, -0.03196424727846706, -0.27241442442295033, -0.10118688495936629},
    {1.5275776664211798, 0.11832497370939034, 1.1686287031739475, 1.6376577915333277, 0.9810883931909472, -0.3231309077909742, -0.45640052204101755, 1.707104277031179, -0.1494860499469023, 0.47777727478999826, 0.24937986137229023, -0.14269823435982884, 0.3789770543983499, 0.11348464259462272, -0.05796974220364403, 1.2634383692884077},
    {0.10832308951357901, -0.12490248875441361, -0.1715810595331129, -0.04357448884850245, -0.03372963696242366, 0.1696140872389167, -0.03992813173648719, -0.09427696077100764, -0.28881322595867676, -0.1556295538910897, -0.2348702211587279, 0.41592015826575324, -0.06608508862207707, -0.21003142330245975, -0.13400420122057727, 0.19150827880332236},
    {1.062029841886988, 0.6572557206165739, 1.1231199329888448, 1.0369241788754335, 1.1261265691563156, -0.1622972390834477, -0.0690907283519214, 1.2559014153956125, 0.13540278527430116, 1.1492206623721102, -0.328334167107062, -0.16979724421499875, 0.597526863325076, -0.23624657329595775, 0.18756227614335008, 1.01972672985815},
    {1.1740124437056378, -0.15672128952934503, 1.0131023936129253, 1.4922079802101844, 1.4582566963016057, -0.23091704535699292, -0.2588291174499649, 1.1879058966555076, -0.013841766478707149, 1.2847091924762375, 0.03432476575201866, 0.16047525760427944, -0.4652470329265655, 0.09119237817691983, 0.32269197264606064, 1.1858254228543215},
    {1.5418147387633152, -0.28041038531179324, 1.1494044820024958, 1.4007159478723423, 1.1315671320833747, 0.04931759681431798, -0.31953415189719825, 1.526264337632407, -0.13036171619466835, 0.940272888439395, 0.35534830530472694, 0.00448159075565117, -0.26554365985663186, 0.08212473366795962, -0.08531197869935768, 1.209756033703901},
    {1.2663994035892188, -0.2761350857342332, 1.5067654339686125, 0.8981494355316609, 1.3316195610467765, -0.010591515886083409, -0.09307256911003231, 1.416497955997638, -0.006206011205007568, 0.8372134252299857, -0.437553735457662, 0.2822073326158595, -0.07898334733842292, -0.25742988019653235, 0.37257228645011436, 1.3431989152134463},
    {0.8374451282458739, -0.3871422596195271, 1.0704810920305394, 1.380945432606989, 0.9071573362278949, -0.21596116296234824, -0.3814783410228645, 1.3300510788131077, 0.4920255844085525, 1.029251863155686, 0.12505502810267288, -0.3271243780453113, -0.31603541102021465, 0.11676807264421238, 0.38087031555531176, 0.5638923890130336}
};

static const float b3[16] = {0.6150086798080519, -0.07724379183469676, 0.7618968808368415, 0.7116899649563458, 0.7498472212430211, -0.033245559388167964, -0.07743379230488728, 0.7815219327293977, -0.033127740161482545, 0.5788065689496459, -0.052166007911423805, -0.05198002210500984, -0.032207882380407254, -0.016930390823135258, 0.008243324461114422, 0.789468631337447};

static const float w4[16][12] = {
    {-0.6913908861200856, -0.7306191804649627, -1.1809252517918438, -0.5901504181811776, -1.1776530946937318, -0.20515669171041656, -0.9706600559093891, -0.7997145127392884, -0.18635079604595353, -0.7409680368250865, -0.3581601736658726, -1.0145284898913238},
    {-0.09026345258584915, 0.23564609068938408, -0.1267449837542659, -0.05019660498440492, 0.4231142400125635, -0.22284685599181087, 0.17437318475131333, -0.43400054572573027, -0.4800867090705868, 0.10357682273007988, 0.07953136988492865, 0.1539256657889991},
    {-0.4880324157477077, -0.9351206862529788, -1.1224568426034105, -1.557751181061187, -1.088708745479844, -0.7190651728226721, -1.4644884415791262, -0.7348016341152241, -1.3467751164625006, -0.5521885904337636, -0.7994029370961416, -0.8901768881592285},
    {-0.5820589266454308, -1.0965250352243134, -1.1139251009177797, -0.40945345077945383, -1.0764650086135417, -0.6520454547868064, -0.7739903958823968, -1.0662514846966447, -0.7628398029027751, -1.0609690283116477, -0.9307332367480563, -0.08608356022519531},
    {-0.9593539540722261, -0.3191973456730405, -0.7204181312109688, -1.6805760591497498, -0.5893885963080885, -0.8985348715887066, -0.8954042204467452, -1.400579818749915, -0.49887634871651904, -0.5691826752163295, -1.1496940705560788, -1.5599838878483596},
    {-0.152701156858064, 0.17124983320549453, 0.28500358603765635, -0.10602157259122157, 0.427575996243811, -0.08420989683216584, -0.07674900990833189, 0.9361429965822584, -0.5098221386379985, -0.0843341501132671, -0.0550875043252396, -0.17456490654108087},
    {-0.1827911849371827, 0.1356456318422982, -0.4686851601923446, -0.0790200605548464, 0.6056828931966506, 0.5528059625344932, 0.5068377011473686, -0.4518743244968808, 0.20071044128386484, -0.529302699130181, 0.3887786847350176, 0.0022597553860761958},
    {-1.0451174348434, -1.9101169273399616, -0.6221530952373142, -0.8312307584388196, -1.0387462641226837, -1.276360580397972, -0.5585367254677468, -0.6171284100300889, -1.1506837771972738, -1.1508303531668413, -0.704143475155489, -0.8919135174981416},
    {0.0463613851377958, -0.6048166686926965, -0.12803467345302869, -0.031182913197574103, 0.2590041254894354, -0.23790294390804448, -0.5547711619945169, 0.24474179726303927, 0.026852233333060173, -0.02012717063996879, 0.06961894189456229, 0.5752132242960823},
    {-1.526416049417698, -0.4094455624414602, -0.42638165445802717, -0.6918422371000322, -0.7721482260661428, -0.6460702334994674, -1.0552295983047184, -0.4762251773891581, -1.5047705130103644, -1.4514991857068116, -0.9567014293973227, -0.7981947590374383},
    {0.48131997455367376, -0.07911829647541783, -0.5952454652896055, -0.4000454180130906, 0.08328993047793624, -0.6624092847409773, -0.35598273147853277, 0.20930331411911898, -0.3883468040662981, 0.4642872418663169, 0.1254617657128681, 0.2705829064677583},
    {0.6433607791169768, 0.1338256549044777, -0.062313460651922496, -0.48808163478190175, 0.19794735386546916, -0.7402734612683317, 0.25603679391340606, 0.779520865669791, 0.06164932529597676, -0.06578674112017356, 0.5512254080594154, -0.22704996177317383},
    {-0.4573867585589131, -0.008001860205591528, 0.20687866723770984, -0.7758619197454324, 0.12400480025200167, -0.08412425417524694, -0.25306972059678784, 0.2881131705942059, 0.03643865825912674, -0.673531409457255, 0.489588999507174, 0.355208841015742},
    {0.216992252305511, 0.09514725529611459, 0.024307106149496077, -0.031583372454441073, -0.11050704438640112, -0.3695306028317487, 0.099802929574448, -0.2996063269540079, 0.0029969418649606816, 0.2343178926639051, 0.2321718643584828, 0.10296657908404595},
    {-0.08956165180627645, 0.2550635985028103, -0.6794967920257882, -0.48502757167860955, 0.21464155759648856, -0.3803428475385456, 0.43104516889816563, -0.24115377988525638, -0.13503070865355515, -0.8500428341018857, 0.453668615286206, -0.26538856838841757},
    {-1.1587974113737438, -0.6971465957926721, -1.1310230072815033, -0.659185772967437, -0.5777116515704704, -1.8173315411864597, -0.7099040785861163, -1.3377992150981914, -0.8566159879728513, -0.8731699830964172, -1.4617226816657132, -1.1808585349186462}
};

static const float b4[12] = {-0.4060098381089103, -0.4663472248649841, -0.19843790835430952, -0.2739579578451851, -0.31810449883207037, -0.32539441838429134, -0.3284183940852094, -0.2882589680067636, -0.38848220271385314, -0.32394432357919956, -0.17542740193985928, -0.332012850231202};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
