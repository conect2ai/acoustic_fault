#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.7465523611001846, -2.75245960265465, 0.8216363477229369, -1.8884322628259183, -3.2423362383269527, -4.404145792727889, -0.47401088038592776, -4.883950246237859, -1.1695181881047048, -3.913790543953212, -3.6889034124257427, -5.037915737849911, -1.5974532077839023, -3.08539774645538, -0.9482311591749705, -0.20703571507265436, -4.678160642514172, -1.460032556609515, -3.1384180309409118, -1.031603685636232, 1.5143622481289885, -2.5224448951824883, -0.027581096805815844, -1.3949457544715167, 1.4412489930470702, -4.428689605018933, -3.778433181342427, -4.572280532649337, -4.215817239338048, -3.7592843490313013, -4.335376109806872, -2.8849163174840875},
    {-3.295932344323042, -0.44960975712428575, 1.8462155132653189, -1.222345879788881, 0.3156164896882324, 1.7852907058117613, 2.7135726104211444, 0.8770761597752552, -2.276300504335376, 1.1090575839993897, -0.17188600701006956, -0.13629408933794324, -0.35116633624070753, -0.08531224965400927, -3.168110753136303, 1.3789837738754027, 0.08405198289241082, 0.8224113256004665, -0.5968442168747893, 0.003824666255885401, -2.6232323900459464, 2.130644530864791, -2.626763986788147, 0.5718972201238041, -2.174280156211097, 2.388952096526218, 2.090547926625344, 2.2275428274411215, 0.961528660351084, 3.299685229890165, 2.7968483146525913, -0.5575687368586466},
    {3.4481620939429583, 2.0594233706794722, 0.06531304037869916, 0.05130783674972363, 4.091667684570074, 4.229187601546072, -1.1189175918309968, -0.9000878801105955, 3.8681388327114674, 3.7186869265011295, 2.5553558980696263, 3.1920306561737997, 3.7791797436698493, 2.3515355592557325, 4.057878933659726, -1.0937926778804319, 3.82796157138554, 1.5206154498166424, 3.539345089813922, 1.4753931416204447, 0.6761018417391512, 3.9721801795874225, 2.135522973141644, 1.0926196136480404, 2.7400546048159486, 4.244376729928773, 3.366999112220169, 2.5549291265186787, 3.32196685924916, 2.754128663618646, 4.476674294123684, 3.630063516573575},
    {3.847387824480654, 2.753453948418674, 0.5660414748453829, -0.37302350653000776, 0.878876112834813, 0.20204560803764013, -2.692794209946488, -0.2745262742563061, 3.2884526991299965, 0.13560115849999316, 3.6661711771714827, 0.35155150634678406, 2.6650458235357846, -1.1977323557311743, 2.9676534591220776, -2.483671922049564, 1.5773599991798055, 0.40884267561550824, 2.315216377517973, -0.20196611532166844, 0.9877638114567687, -0.3500396802255129, 2.288503552574862, -2.03888304575402, 0.9656522399646584, 3.012946761982875, -0.05091518608683543, 0.008343879444349509, 3.1726138273053204, 0.0771316895493522, 0.05238713212168076, 2.578064506667009},
    {1.644654336525979, 2.313620274107915, -1.4805263691532222, 0.22342324951239861, 2.7149698015544543, 3.1269157907237908, -1.6111752170145925, 2.735042715363013, 2.763854083130322, 1.5842691991655975, 4.638086402508015, 4.963925525148713, 3.3657818140549165, 1.6807933783705478, 0.5916656156362693, 0.3804772819153553, 4.6712577721079525, 1.7401331724183577, 3.0792169731088412, 2.7387054519121112, -0.904527231535316, 3.4974141197200352, 0.7328308668954651, -0.1731000637079607, 0.9977269423352026, 1.2034445685464492, 4.634643796611699, 1.4836122702883274, 3.8113981134873205, 3.62296825092068, 3.337306867529229, 4.07400255467622},
    {3.1832009579290146, 1.6493103769241708, 0.773676349637536, 3.1917564538231256, 4.324966383981333, 4.0241385516749135, -3.4205620509801107, 2.1632440365570362, 3.657967297656153, 4.154028824901716, 6.8848480901433735, 7.018247375168211, 2.95891929917977, 2.3566105866252625, 1.9716688364836241, -0.5668584857708624, 4.387852841344958, 1.8247672224473348, 4.447973935166748, 1.1237715322307744, 1.9927910689578126, 2.2798666752592367, 1.2928297556229174, 0.579654210362295, 0.23078467597394312, 2.9927253287492994, 4.916222956696877, 5.349496108447841, 4.994387164658107, 1.9069507104764025, 4.678705861479803, 3.2078421108917246},
    {3.365521451711486, 1.5525014599672573, -0.1551531386027254, 2.024999996507486, 4.495048946983899, 4.013922999373396, -3.0203528694042965, 2.1222478798470163, 1.979157100879871, 4.551848010980403, 7.0175016579312315, 6.158872420912533, 3.4592676315393756, 2.9499481138726553, 2.9817408564139525, -1.0205560908283355, 5.2303157294315685, 0.0223689184600228, 5.8060687395937585, -0.22762497685194089, 1.9561771772275343, 2.730396762397185, 2.7593367867076375, -1.0673859815215876, -0.25622212913764714, 4.836842600975565, 5.229080521213747, 4.2823631728440965, 5.088346266757544, 0.2511815674065842, 4.819208952267753, 3.64015319004028},
    {-1.1352500885953167, -1.7460218886053132, -0.8766849260459427, -2.1882612958947116, -1.4566327412882285, 0.7339419384213358, -2.059563968565492, 1.7642432154350642, 0.5996212032347867, 0.7780795584734002, 0.6402392668290513, 0.9110873185903091, -1.3375318472172473, 0.014057261362210277, -3.175272417209943, -1.2679139409363323, -0.31903489628099196, -1.8165450586638956, 2.551415381496615, -1.5487851151912266, -1.2272715030733015, 1.2370657972589147, -1.6202404648664854, -0.04639085109361207, -2.037784824251479, 1.8224978898198223, 0.803538795098779, -0.31832976862632206, 0.5106011025908808, 0.6434633427274362, -0.17733885314324982, 0.27532938188158845},
    {-0.6537611658501099, 0.35487940958235437, 1.3539546486743554, -0.774295720563808, 0.6751226225662664, -0.7935470786193003, -2.2980569337523917, 0.2502796177965687, 1.2257930876869032, 2.541930437434082, 2.8220626729084812, -0.43221912708175475, -2.1335671774808365, 0.20416266537414285, 0.274235017485988, -0.20913332559751133, 0.6660309567829527, 0.8347149701238264, 0.11366062478886584, -0.6847661359425605, 1.609370250288619, 1.2728968876266116, -0.7783839121434039, -0.9127500531630474, -2.1628101983350985, 2.116172731067861, -0.27710810528167756, 1.9722378534217444, 0.7537292405413254, -1.7127739294987603, -0.13144908344573314, -0.16914318761699831},
    {-3.7398034308100123, -2.179418589836598, 3.7382232027433693, -0.7030851930723218, -0.33166987446824303, -0.5366417208526354, 3.760650086716429, 3.9725453927120564, -2.049322021429857, 1.0395271482140016, -1.6374288229792209, 0.7142174845452339, -0.9893488952900673, 0.5876449551824413, -3.2462291543613087, 4.179459296595117, -0.9258075010504905, 0.9311111557843021, -1.6655522701356362, -1.5671305685558505, -0.3303467442312011, -2.756109754222541, -1.4231024592442576, 0.4892903453323083, -1.2513023767429439, -1.1976318907537409, 1.2272084635916758, -1.1812317401070045, -2.264625860515375, 2.313905366049614, 0.7598654699016659, -1.6961663816467283},
    {-1.8777397541612337, 1.0375480230799397, 0.47986063439007015, -0.9158886312230862, 0.08517744830604082, -0.6936496069234251, 0.5389774643524239, 2.8149630790063753, -0.6625105770203888, 1.9933880251208174, -0.9616569761760678, -0.4944469506990367, 2.52369712717761, -0.18206369863117183, -1.6071268831068528, 2.1106713929182503, -1.5209484340598514, 1.078594067413349, 1.7755177456235833, -1.523411565770105, 1.2684463939895483, -1.6793773008418351, -0.5401115327722315, 0.5992032782624688, -0.7805508601580254, 1.7054805698932993, 1.194679623452461, 0.9603730841124198, 1.4938367851431267, -0.7316232392679158, 0.30958530636209497, -0.6795995600214121},
    {1.3690878783393226, 1.392480128908427, 1.6351797741138325, -0.8059712220950714, -0.6582335951248051, 1.0977024781080094, 1.8186595546620627, 2.150214392357146, 1.0616244582964862, 1.6678763545608095, -1.3237016496357377, -1.7432320011015197, 0.9059840104833405, 0.8455796603527811, 3.2274068891996146, 2.764678260721251, 1.7482922502366982, 1.0111128956177635, -1.4904545510268727, 0.9598722552622284, 2.2027160300734363, -0.4312137416990097, 2.9206093821836956, 0.47823768640989844, 1.512572411520257, 3.118748145937715, 0.9548554131810083, -1.188366204702561, 0.40466069749071365, -0.6996234117106129, 0.5949102339748289, 0.2615980158238376},
    {-2.361890945110613, -1.7632029614052502, -1.359426051327791, 1.9897117410157465, 2.4253347423720175, 2.280581573360361, -0.16344566257714066, -0.3819322671253402, -2.2175136596102947, 2.0784346645491554, 1.0038831547171194, -0.5609782293257904, 0.9462038731433915, 0.8073450663990933, -1.155199698509783, 0.6425450582712015, 0.4460339155036919, 0.9256621462616241, 2.112915165355656, 0.26196139762790766, 0.25845896548002456, 0.8993511009037989, -1.3432264215251715, 2.431686756478012, -1.685860218698306, 0.06254463906646925, 1.9341858236249176, 2.2628424370108116, 1.4627157669997093, 1.9922067607548934, 2.9776694915264774, 2.626464039059532},
    {0.3088836110667352, 1.901926808689715, -1.678355227421601, 2.0041498848632546, 1.7369692977941658, -2.4860168810530108, -1.1766361377248011, -0.5588661626852116, -2.524859837264054, -2.1874710595263243, 1.2764675720661394, -3.047042145345756, -1.271917127078789, 0.7893498246220688, -0.18370168024082636, -3.350191395900947, 0.40682032350150793, 0.8287862979355822, 2.288037809757349, -2.3199635762408946, 2.802065532954267, -2.3672459712929004, 0.0807368248208117, -3.1022647923129667, 0.18708778679792018, 1.5074166631710528, -1.4743262484212134, 0.9503330653298356, 1.4777831385781708, -3.982877768582425, 0.34558625975663276, -1.9522186030770563},
    {0.5201483820656394, 1.7294427812028226, -3.7171633685208247, 2.599728004889408, 1.7003182206207421, -0.7906524836399108, -3.6977322619061046, -2.8634547352836335, -0.18765707424507153, -2.7478196075666377, 4.5736844231371725, -0.6532223784017955, -1.9382473201078994, -0.6903637720063992, -0.5495024449793842, -3.7633237360194123, -0.11470707820158484, -1.1129077646604728, 3.1408088925874376, 0.09048451767431967, 4.066636806499085, -1.0836904180212266, 0.5926811110308505, -2.9109703493967394, -0.7666523668791995, -0.5205365783433137, -1.6568532247361458, 1.5299738071990314, 4.2010949188673985, -4.665806754760322, -2.2472653695159632, -0.7306825572036454},
    {-2.6090976369241323, -0.5717554088649646, -1.100336719958879, 2.613648083499706, 2.4752295009264524, -0.6294456299380258, -2.630929557253347, -3.474130010590269, -2.4339832877116825, -0.596292139664076, 1.999466740873421, -0.8836525116008185, -2.7942069370173663, 2.3490145827478086, -2.135385795532599, -1.5979283452998079, -0.11298489311847552, 2.9908391957561493, 2.789176508814082, 0.6435644859305456, 4.075273911852533, 1.5724524346148194, -2.822750646735316, -1.148355252486675, 0.4716477126443828, -1.3116382987021702, -2.5141444646728477, 2.894032711807229, 0.7000787292153486, -2.8569075108641613, -0.0952126968870586, -0.7569537174641506},
    {0.03928461914741942, 0.5779854458290901, -1.9287317936477995, 1.3071566543032203, 1.8180054899244624, -2.0311711325090385, -2.1511134930329283, 0.8917400155008719, 1.5254835604149852, -1.6084408950079685, 4.562313471517037, 1.4099807315381696, -0.26970224234809204, 0.355006985787268, -0.4240340999921696, -0.6802349024598375, 0.30192317820579173, -0.8715824505500375, 2.900361852263465, -0.7600376619290018, 0.34222923824636103, -0.4111294958840761, -0.7514868943575681, -0.9636868218058963, -1.8843476999541136, 2.808787758418041, 1.0128903340654858, 1.6064960365472933, 1.576341736967429, -0.7547600462374071, -0.08860677928482256, -2.081109380628775},
    {1.9932479875985205, 0.5523209794175467, -2.56016448970566, 3.641207068084021, 2.289727722501028, -0.6993345006235011, -1.1025088058606434, 2.1773222117845, -0.7906276506571356, 0.5295771885972392, 2.9975399869672397, 0.16294461619121142, 1.0296764265719878, 2.1639512719038128, 2.2421754219606878, -0.181904960965381, 0.04339556329904631, 1.7172527433881157, 1.9695707489299992, 0.3871796454217021, 3.1343288357822603, -1.2746668159952053, -0.3649043274838061, 1.036851502015052, 0.9869544942222429, 0.04368547527843392, 2.0153192863163185, 1.47476971593876, 0.7044713502830561, -0.051276372249197164, 0.31391304017062216, -1.0642965724685711},
    {0.3458833985763929, 2.5088094709601365, -1.9016772352720304, 2.7496970242373373, -0.9362168060517182, 0.2596221410048855, -0.505999484618926, -1.1355048095749547, 0.7915477984570114, 0.7981481902444589, 2.9423767085672052, -0.04741072110762197, -1.9480753214739188, -0.726951799585294, 0.9147572186561466, -2.998542594711699, 1.6208607577065361, -0.7098267514094009, -0.3966527668083651, 2.0416080455658148, -0.3603841342386844, 2.269263831975458, 0.8401126236998219, 0.328931951461973, 0.8693290514958945, 2.9422481387679746, -0.9471066441487748, -0.10768218070333482, 0.4540762028175274, -0.5480270836979062, 1.6954718405123157, 0.894315209643256},
    {0.9904708419056683, 1.806176451894182, -0.06299923052338542, 0.18345687387527834, -0.07647842639363665, -1.7364737933457899, -0.347606190194699, 1.6806700803987058, 2.0339559577242885, -1.1843806455044381, -0.1313634393888455, 1.0383102736706793, 0.22972694849722441, -2.2732460285043046, -0.8669992605138221, 0.42382892160184416, -0.6225141844061051, -1.3651336892060646, 0.19100690531454326, -1.6987957214814147, -1.8993300270376257, -1.8241623574417463, 2.4669874839960717, 0.7687066600524218, 0.9842352954711933, 2.5395839917440934, 1.5390845271339242, 0.1268539132972611, 0.7415320348808888, -1.1518711659370138, 0.14610893081789825, -0.9259898592793258},
    {-0.1169137412611953, 0.6776691838701508, -0.36894445993424213, 0.4659449377905267, -2.2218947109814104, -2.434706876430793, 0.3660921072280326, 1.1575159621878808, 0.4986351738851315, -0.6577964665096034, 0.8376000977990755, -0.08860906148310269, -2.134565310137095, -0.08211936544693801, 1.2983871029617757, -2.8932260196163377, -0.07260272136549951, -3.2904770738069424, 0.2517454166999303, -1.4357157087833503, -1.237243254516252, -0.5118508595575616, -0.4389767643886088, -1.2351726643318148, -0.9056829923027695, -0.9391870053802376, -0.42601681387885876, -0.26586102070057605, 1.9277093593317398, -2.9024068442012156, -2.737099857293084, -2.3770453152805344},
    {-0.058287831678267094, 0.05654253180264867, -1.5532695135572405, -1.8329668571744686, -2.7549880065650285, -3.66427357537897, 0.23728885735630567, 1.285421600067252, -1.7476793267594386, -4.59631468630643, -1.6367608400559652, -3.289029100851616, -2.8038163436983883, -1.9835422052874832, -3.133683990009215, -3.3612965354394846, -0.7804079334590139, -2.5397729672522726, -1.4896356181441932, -1.5443406964262323, -0.8935893039666647, -3.581531445651547, -1.2758423552117937, -2.010875733246891, -2.3079868559667602, -0.41735138648380143, -2.2185606424968856, -3.203697941087503, 0.6239315673896351, -3.3103678899009283, -3.8437672523992306, -4.932191427694786},
    {0.6498198006276598, 2.1027664176734584, -2.210228915028494, 1.6065653387900927, -2.2256733458703972, -2.622987589452456, 0.13614453294616327, 0.022073559790796896, -1.0753959966796505, -3.5111815344627533, -1.044673426524275, -2.038120929589031, -1.354043547218153, -0.76037723255888, 0.8465651290528392, -4.058949786656434, -1.1770742116276698, -3.579295123019792, -1.029572328850981, -0.4618692973701523, -3.3048960240160143, -2.97274603864751, 0.006805179103666544, -0.45554138051190385, -0.7332169052587231, 1.8390885131518926, -1.6999493701947033, -0.06643699951917971, 0.8522942558312769, -2.317667656597025, -2.8162332829764383, -4.008912559934427},
    {-2.070576727992732, 0.8832577849497352, -1.0037730426338323, -0.7227130518404344, -2.47236076778013, -2.130168686879044, 1.6750839855340398, 3.32760344726683, 0.2616551256843457, -1.7929426315053623, -3.646659729715742, -0.6224210778503878, -1.7861184478429777, -1.8378517162487003, -0.8667734527631606, -1.8509535347839798, -2.487178719035057, -4.865944944582533, -1.5034298927551208, -1.3193599827903775, -5.8703259098175105, -4.067841127823078, 0.46433326494468863, -0.4890415711924625, -2.496617672079521, 0.7807989954872941, -1.8332889686631928, -4.218772511271089, -3.197167651839744, 1.6541468691808954, -1.661624143459809, -2.705747086920328},
    {3.350300834488178, 1.3723590610714123, -0.1694320298418973, -1.8271398236576688, -2.232465211704299, -2.0373084592422335, 2.9448534284041648, 4.1086591137161514, 2.760246412118797, -0.01592853294656364, -1.7841565253370577, 0.6273068150188865, 0.7893772518789662, -1.9071354173497193, 2.5679116795517456, -0.96396466300169, 0.1419953063979686, -2.8839575577122862, -1.5312047764565517, -1.9022936939717305, -1.0749013339039617, -3.2699648254032487, 1.8234280217026233, -0.9212120732640073, 1.9586404553877745, 3.09852559364415, 1.312841274765291, -2.884247253309506, -0.9109003819831952, 1.1882357816643974, -0.9712170262730832, -2.9379089194435766},
    {0.66647040744389, 0.46052241583776415, 3.012371663715571, -2.9552332199819626, -3.1731075043462074, -3.1229020729635497, 5.03600418919242, 2.853823424459227, 2.226074535364205, -1.468066696658869, -3.286705614381301, -1.9336969623597615, 1.5181806314229342, -2.476048027736371, 1.542649378734956, 1.9677717436519262, -1.4310647812965878, -3.8464670941615284, -4.118418014027981, -0.35303929421337227, -4.831913873442637, -3.0656455807525793, 1.0430291733191823, 0.18764124287737627, 1.4452279168789108, 1.06075386821764, -1.6970176334101796, -4.773285627798796, -2.8491406140235567, 1.9800835278329412, -3.2119386680034583, -1.7051168754185275},
    {-1.121295128852536, -0.9117019684384408, 0.6325573564068644, -0.8493693702596053, -3.215820973336279, -3.7435049399308227, 3.110330844387846, 1.5017490139870053, -0.5319227429248892, -4.755176285250926, -5.793855927730859, -2.3908717440360356, -2.8186476572333006, -3.2370350496995512, 0.876549667335493, 1.1466083313897526, -3.8402231158264537, -4.134731821929208, -3.3417069275024596, -2.5134883257133374, -2.0064326215897714, -5.541060760473818, -0.3928194919315049, -0.161863878822079, 0.24852251717543067, -2.702718402106238, -4.503312401301776, -5.420488678796245, -2.6238983051896936, -0.609498039200826, -5.008861726895899, -3.919507131393546},
    {2.633591691886488, 2.161159918441688, 1.0616996827408536, 1.0539888098747516, 1.1005490535378284, -0.5940385584270345, 1.36209021897436, 1.205632585493576, 2.004949479597297, -1.0292499005640838, -1.7702826478382534, 2.749100015939839, 0.9128291463223691, -1.506608709210316, 0.7815992674516816, -1.5151991833016323, -0.9461375644494483, -3.2167520397150358, -0.5537958538782236, 0.02866500412274764, -3.397617227519509, -0.8810440184215077, 3.1006783084101874, 0.33213795677767965, 0.35675291654851804, 1.2730262196802338, 1.1763728068449764, 0.6673858741872415, -1.5988540719344273, 1.093793172749007, 0.051653102494472546, 1.0488037072128495},
    {2.5014668684590937, 2.209048406118572, 0.27283856051486294, -1.2298626053087975, -0.18646042853773503, -1.218210895460038, 2.6079097382954286, 3.7620669673864113, 1.522792250312577, -2.5743073976090676, -1.8744385366918217, 0.793401651352322, 1.5188598042362011, -0.22867187808394546, 2.0008969156288208, -0.696044320979918, -1.0379338881568692, -3.6047977987695567, -0.7541618973755444, -1.5123292965647597, -2.7259688823426442, -3.8617916960655654, 3.0740133239798113, -2.487397175639561, -0.44994904519304857, 1.5944382831660235, -2.144973451739268, -3.3548612639754483, -0.1906418821769645, -0.7015452636498072, -1.5397405589575146, -3.409792364891072},
    {1.71296227941818, 1.869246757824316, -1.4645505716668081, -0.2920400635107203, -0.36145822161254537, -2.420229338583633, -0.29202348149138485, 0.27672578365332823, 0.142313471688873, -2.335530890313974, -0.7114519485659797, 1.6072468507953888, -1.0246187237168771, -1.2129038192013852, 0.5379939991755655, 0.06552305460380725, -0.7693450901230203, -2.5575705003909333, -0.4684287148215916, 1.3039634791336605, -0.517248214970589, -1.6149770143554896, 1.3440566916407068, -1.7220673793321815, 1.2853162343439055, 0.05816813247693236, -0.6090937753233058, -0.7450579192798852, 1.7106577182141387, -1.9328924666301015, -1.8305777874864078, -0.05774563718031144},
    {1.6074149230158234, -4.342064418911559, 0.6425902919807669, -4.518903069281166, -3.362176169782742, -5.791065813547152, 1.0720157581207428, -0.7433718532781103, 0.6095069084730517, -4.470154539946121, -5.430263401844197, -3.551828961824109, -0.3615588049775124, -4.405155525128237, -3.351406297694133, 0.9025896274587588, -5.664537605881474, -6.596055175526071, -5.016278351603792, 0.08295270824036895, -1.1825868322106978, -6.498875225638671, 0.46244007879088234, 0.1474185616363364, 1.2730254218831494, -2.013152640023707, -3.3549993843805557, -6.005823411340003, -5.361959859716829, -3.811707920552283, -6.688508539817083, -2.656398329227288},
    {1.7819813152982358, -1.7052763804907969, 2.3975580400935375, -2.908822882755531, -0.20493149733694183, -4.883276464885779, 0.8536299969719946, 1.4141040211777562, 1.7513791587649028, -0.917998393135502, -3.5008649997942354, -2.7568382936510476, -0.38868356777597846, -5.065283769667338, 0.20648216895395766, 0.45509866140607336, -4.469020604339556, -3.752223290484598, -2.6196775267550105, -0.2459630606518928, 1.601340170695844, -4.780960138220356, 2.203569423850945, 0.4290330226738504, 1.6962182477859593, 0.6204084157747165, -1.9599497872096734, -4.848487142533659, -3.4388472765339966, -1.821022327183699, -5.227780448138917, -1.2852898415490777},
    {2.0824797507447426, -1.6721811939100355, 1.1566763594809506, -2.758279448761584, -0.6878322713094832, -2.1294727460506837, 1.512793046229416, -2.2459443114908857, 0.8014786382826712, -0.7962019015892005, -1.5287200643641106, -1.263975779037199, -1.2049237866663882, 0.09523592184138031, 0.7719474948257599, 2.0608823543883874, -3.304707867685324, -1.7659846226580702, -0.711218413933993, -0.13882929053648563, 1.8264477156291976, -2.3553708147446275, 1.6257393472792168, -0.18910522401451663, 1.237692841117386, 1.2774563050497536, 0.19815066466287856, 0.16969237668541964, -2.8501477837358467, -3.001152959405358, -3.1626856099162817, -2.64661446541784},
    {0.6171967381085729, -1.5195216873958164, -0.25690217064089044, -2.770908599676377, -1.3280939466978774, -3.8166817672473368, 2.0812165060536536, 1.1529418446557176, 0.4301020169531989, -1.9237198379107128, -2.113633450200997, -1.8490498608033632, -0.8609741811722665, 0.4622172448687555, -0.6277027386525497, 0.3012165909744234, -4.410321479776894, -1.1895865436195965, -1.6059851623561694, -0.21638755031888862, 2.3929063321002455, -0.18307499716841405, 1.7970830932960216, -2.1419364190576133, 0.5623405619781273, 1.1513307387290064, -2.0752030597756836, -0.49490802004994217, -4.458965700844225, -3.3418142168347478, -1.4731892972576401, -1.502362426257108},
    {1.831614560765257, -0.7909908442238792, 2.746861589512216, -2.097580817614976, -1.1108122322537115, -0.9051295586919884, 3.2144095179526975, 2.7905096439230475, 2.4586335662826224, -1.4015182238948045, -1.6475182467217933, 2.1899225687235577, 1.1933561963193875, -2.448185491992248, 1.3813465268420775, 2.1013977883551958, -3.1255496614102403, -2.245570280615663, -1.9942007575041532, 0.9385537851716107, -0.31489295286714547, 0.10047777454044891, 2.8694927916028683, 1.4840534271625687, 1.3618197263024157, 0.4843236555289926, -1.3290403556606665, -0.44885526514702895, -4.066759561444855, 0.8095515132407406, -1.9825485378962149, 0.9142874232954276},
    {2.203978802258188, -1.8502689215097583, 0.009767586017503813, -1.7070817856219045, 0.7561753809151818, -2.3414617608522876, 3.059315725632994, 1.736010303207392, 2.5144458132348375, -0.8980063729766875, -1.054302601513359, 1.3191763541713624, 2.305967067178774, -1.9744916082635091, 0.805237222090377, 2.5805632463667796, 0.13636483135751143, -1.0084359335785797, -2.494261007621078, -1.5666609940705793, -0.8877249870865236, -1.9728182438613373, 1.8817339459887445, 0.6625857189618108, -0.8071434223101427, -0.1055740373919965, -0.5611404937610524, -2.949776957582881, -3.375128322127182, 1.9971369064642588, -1.3126803767500095, -0.4591830354298259},
    {-0.20808181752272473, -0.5377332916086572, 0.7214398421169597, -0.5833003191384013, -1.1674141724100147, 1.0289439176012902, 2.1279447276608217, 1.4614920717393691, 3.2254388383682997, 0.9582929601160084, 0.4010617880738204, 1.3549244356225814, 2.6112756992129467, 1.7126260442179284, -0.4312984537955575, 2.2653589645980725, -0.4782403913522879, -0.04126635355083798, -1.398504147158735, -2.5116688507224367, 1.7398851800106396, -0.3627555373166152, 1.5458258718218378, -0.16442581767714895, 2.7620779394807773, 1.657967568829146, -0.08418384212006019, -0.08269759744899653, -0.2095418719592193, -1.375228170974647, -0.778462607438084, -1.7163097786681296},
    {-0.11549224626827571, 0.04049330061270981, -1.2788650908103871, -0.10640680835473126, 0.3744742450396035, 1.1704811752946787, -2.291102613868739, -0.4861287465623858, 0.3536889748370016, 0.6887755259298596, -1.6238638593563197, -0.25078012270899547, 0.8605028043164753, -0.13576240300666687, 1.5033014787669488, -1.1593274331697925, -2.644128857464844, 0.7750336035778852, -2.470500406615898, 0.1720090657302188, 1.7152492130286625, -0.49604657333521596, -0.2049255665911514, -2.932382105441918, 2.2118498756494134, -0.6318412990416548, 0.4929685441469357, 0.6214082752624285, -0.838459645159763, -2.640965758329576, -0.8488556331927188, -2.408847988083546},
    {-1.098693413143451, -0.6865078637360481, 1.18484591285435, -2.999835547047939, -0.003335223288911702, -0.31388028086599673, 0.15820584029514195, -2.526383658355266, -0.9074158696845276, 0.633176520812249, 0.02539446433127275, -2.3343662654604107, -1.0724684463810048, -1.6395080169413767, 1.4169623981886093, 1.4707308827508998, -0.9256823063348254, 0.14849375450100205, -1.9810450269591382, -2.0827634344791073, 1.5464795322144271, -2.1383810900054643, 0.1867059686196403, -2.194491349586905, 0.4791585555222654, 2.6695765150565136, -0.0631052407552874, -1.3860640505281818, -1.4580862477176477, -0.9399957123365651, -0.4888433550460103, 0.48263799044183125},
    {1.1804433221439468, -1.1075908865797477, 0.9690877472678718, -1.2828025135811891, 1.678347646738166, -0.6221907028584606, -0.3037055468895908, -2.0121325349560912, 0.3612446716906541, -0.03660084023403445, -0.08566665759369278, -0.4833264520925748, -0.20799419594265328, -0.036790633410491526, 0.5086315112040554, 1.1408882002674272, -2.181162194482748, -0.5247842570751792, -0.9958069419418393, -0.4895392890857073, 1.543055819403684, -0.11231142200425207, 0.06429269739501901, -0.40109204662548154, -1.115164314388376, 0.1810491615970831, -1.9122026304595399, 0.24420546376833727, 0.7669148628220965, -1.410215810230494, -0.8538643085850305, -1.5288245468124952},
    {2.256575229104919, 0.9870426459710576, 1.832507138537293, -1.188762961501235, 0.161532666175255, 0.20212637676225825, 1.208643454821307, -1.260474177323122, 1.7083586594248032, 0.5215826033694017, -2.36965239117155, 1.4575792817051272, 2.778576606988995, -0.806370795365682, 1.7587537849313142, 0.03530950033020404, -1.3973449545450662, 0.2405814673536757, -1.161902819893637, -2.4601935865717266, 0.04943227654397548, -1.4857627941884834, 2.46241738904561, 1.721759609046519, 0.23181003978149908, -0.5400379041341079, 0.5501357750753457, -1.4521614686263997, -2.2718212956559887, 0.3296694572629929, 0.024238841187979643, 0.7131746909644298},
    {1.4182579485703672, -2.208615875787066, 0.9807461920213193, 0.6626513954118886, 0.33531102032961696, 0.6955281319246078, 2.85787747288394, -0.5590286922644714, -0.24962812489805603, 0.2037576838125006, -1.5971298312378435, 1.4458255734521186, 0.00550790232828931, 0.1453777758887383, 1.0361334091978645, 0.472394910822476, 1.1222947720895269, -0.31979236043563813, 0.4051119929368301, 0.5607918301427449, 0.5239847858235133, -1.705100892593217, 1.440936539427787, 2.3991253213100854, 1.0206302968665057, 1.590214324342044, 0.7085062455021055, -0.2719673873703432, -2.6904484172985423, -1.1661064878973004, -1.5142303874605874, 0.006829219154253496},
    {-0.9390787190329515, -1.0991522517793564, -0.730278194979087, -0.3974445569520454, 1.6458826178253663, -2.5820162830758733, 0.4167015892578618, 2.0326616893822043, 0.388865461184159, 1.969929629290439, -0.20744088123347912, -0.06735355522367864, -1.364688264225152, 1.2322902966768357, -0.23543354855674367, -0.056545644838733866, 0.093593414719789, -0.9843160687024021, -1.7982533250435018, -0.9981235758845836, 2.158130929225576, -2.3524281378046323, 0.05250421662560811, -0.29129287143528204, -1.6644674576918568, -0.7900934035064489, -0.44008288386721495, -0.9470176738180172, 1.3211703040852036, -2.4426220599363773, 0.08908447457462343, -2.4954097912169058},
    {2.4875687006987866, 0.7795248432267939, -2.3977410905480805, -0.30561801661501914, 1.0564787274480487, 0.6222841532759433, 1.3235983980420496, -1.4673843591290703, 1.1696217614270619, -0.590013002013163, -1.046448148891532, -1.9555242718045358, -0.7665527962704172, 2.4109248889579598, 1.030980659056818, 0.6862217570448156, -0.936207719212383, -0.8113957177346417, -0.2450451579667436, -1.7986458675585308, 1.1022639111790005, -0.9312980690190623, 0.8304307619899136, -1.0215075091344628, -1.8357668078665785, 1.9635647577925834, -1.6787331781951416, 1.0946201009973742, 1.0241897548550007, -2.085230257409257, 0.03965894028744907, -0.963440537464039},
    {-0.05996993692001201, -0.12891694785406724, 0.5205226088065312, -1.6441619338685252, 0.5110152715646478, 1.5127340395731852, 0.5773013438722523, -0.9362050467898825, 0.10273653370242132, 1.0193474156867908, 2.006399155993361, 0.5603589991783174, -0.8027279383798073, 2.188699621248931, 2.2669544927627623, 1.07125603419493, -1.0903403912373049, -1.1917407487736809, 2.25564988211306, -2.4647730158235444, 1.7611069108215687, 0.21181297867966895, 1.4684473890731673, 1.0131178847526023, 0.7349204065100428, 2.436182587185353, 2.2476177293374464, 1.846648052677748, 1.5532678907924866, -0.8341152777614723, 0.03306030385423953, 0.9106448526490576},
    {1.1694844348578428, -0.09605429617299595, -0.2897538790261489, -1.5382108044909246, 0.34666493855595504, -0.4024737187356599, -0.08354747456956685, 0.3541734443939953, -1.663925952599515, 1.7866567195527447, -1.074308312333486, -1.6676568335303037, -2.1067820419125733, 1.3279569910047258, -2.2634977770843356, -1.3016938239238904, -1.462920660827644, 0.4531663822985428, -0.9213109876793889, -2.064809497071301, -0.5517118072561497, -1.192155563290576, 3.0132612483423857, -2.153875823330849, -0.16281147381991937, 1.9238754106071676, 0.5679461697925201, 1.0377437833195524, -1.5321635072799955, -0.7885444604642124, -1.3057584720625217, -2.030610131422032},
    {1.7287415759799776, -1.3456533471340235, -3.1303358460520565, -0.9510095149972295, 1.4935902444679843, 1.4291108062191606, 2.1741241498600283, -0.9227069285859256, -0.6718986105061299, -1.029469251981269, 1.2388971665677235, -3.2529240627789586, 0.33506207097471624, 1.3984438047316565, -1.087564497503465, 0.8491881919252915, -0.442482309887861, 0.22490078462201876, -0.6518408169950238, 1.2454261592213611, -1.3246224901950225, -0.986541490403873, 1.4201055198935366, 0.8355045834356843, 0.843012115118864, 1.2168622116339878, 1.5192134438038574, 1.0075612854441502, 0.7079716701575649, 2.1184124418247388, 0.7648856742222003, -1.1368643404917904},
    {1.4322134429321318, 0.4548781273615617, 0.061523800644754253, -0.6392719657341053, 0.4223528067500319, -0.9661300271528861, 1.0859384388480613, -1.6733699983794816, -0.5233850205321025, 0.021518152210112367, -0.2703736132596277, -1.3983551564542707, 2.265705795235927, -0.4664440204575406, 0.26336166913186454, -0.5132933098712243, 1.3988710928808965, 2.088388116525591, 1.7744084056418823, 1.317603492187999, 1.6319993713618746, 3.001162837677054, 1.6894259308865744, -1.785462711275794, -0.44879752422847896, 0.47857418571426413, -1.1399857320849802, 2.4564952211839253, -0.17508634787420815, 0.7693156606028186, 1.5112631536487973, 2.77142205978352},
    {1.2599600430411972, -0.7428218626536339, -0.6671784902116203, -1.3139638634904134, 1.0317580215329532, -0.08486424302309134, 1.6282820776206675, 0.48266220621608635, -0.7303638828046839, 3.3075053131748993, 0.09467792344966203, -0.63545615955083, -0.8932913817874482, 0.2950351335754621, 0.9239806486733045, -0.6308400934206415, 1.7508574952944727, 1.8143681737479587, 2.177440186634695, 1.0648977183153048, 1.0381186896237993, 1.0113772011840556, 0.736516144744356, 2.2978347299729736, -0.6649470923607117, 2.7745298952399717, -0.28174151512179396, 1.910588510817568, 1.1611107939739815, -1.4303146064290944, 0.9030122811701843, 2.2185981706244924},
    {0.9660441732630844, 0.5463353302267158, 2.527497563841146, 1.565751144757301, -0.641074775522746, 2.5838467004649703, 3.0034192152170944, -0.14898032184148283, 1.9588547811034078, 0.6340571769043949, 0.16593028437183904, 0.1615137525541693, -1.087154214893695, -0.005976253276869707, 2.6269730102176467, -1.205846426748785, -0.6408140993281338, 1.882110173984631, -1.1322586962257215, -0.7000210540044114, -0.9448507642415779, 0.8750739265785106, 1.0506233581909825, 1.9416346077956268, 2.070656725055462, 0.01551891553355413, 1.8336732103908624, 0.23912892846792286, -0.8315159523917796, 2.4309709258332686, 2.1275852140814866, -0.08518041352497632},
    {0.012277701931292857, 1.5585829938671392, 2.8453315898477527, -0.8956151227206303, 0.44392658515366923, 2.0101573215579367, 1.4030370539434287, 0.11940729281018712, -0.7945252788031796, 0.82509647559024, 0.7152666321485023, -0.07527577859528721, 0.5527118788264022, 0.06729311757325768, 0.643431673977878, 0.7555789256924743, 0.19718786242189063, 0.7847366182011295, 0.13671081763613294, 0.5558394134633057, 0.9159539633748904, 2.452337489599216, -0.6695102136951101, -0.04926103230747693, 1.8655926980066835, 2.0639314538754543, 1.7539275803981709, 0.08450868882148567, -1.8796265375114631, 2.0179473611495484, 1.9661993030133829, 1.8349564935737388},
    {-0.7107019263537816, -0.4152287831114487, 3.8837754416778045, -1.599554543475742, 0.8848048957911364, 0.7858766901618082, 0.5755579533253949, 0.10460969236249955, 3.3850543188720343, 1.6794361710542849, -0.1851164570525459, 0.11905831053959502, 1.4801306620321506, -0.9529425244358766, 0.6046318197127242, 0.9000745361313777, 2.1679885409708293, 1.9234483461883167, 1.823732497823759, -0.34855902133104816, 0.029537137894718388, 0.5647271280456249, -0.43771624123481073, -0.2862460315567392, 0.06140945795358785, 0.4809489927851306, 3.360747602506292, -0.19191114027520007, -1.6780686750105664, 2.257936099456563, 1.5845975541070616, 0.8209200840422932},
    {-0.3426532426535746, -1.9316560831856475, -0.48998298309061256, -0.43081449129224386, -0.954212878435332, -0.8187003640602777, -0.11740636104499548, 1.2287572439742622, 3.552053567120396, -1.0595089245639766, 0.2576411774862584, 1.7388878831389813, 1.27062718490566, -0.5029489417592279, 1.8187284542711188, 1.5485552053003877, -1.248840925784378, 0.7114809175378985, 1.5868541820240127, -0.33972753168512254, 1.5777864624008378, 1.1460340784203238, 1.3824274263935932, -0.9284373466495149, 2.177857925039392, 0.583368941651298, 1.9945981166160156, 1.9067598658340388, 1.5680120932571577, -1.2974470258118884, 0.9029535322904904, 0.376915537804266},
    {-1.308080923038625, -1.0074029501153268, 1.6913809198350933, -0.22639213248399045, 1.7880419024286598, -0.5804007863368249, 2.2375650420405826, 1.6339727083389963, -1.0512723534349766, -2.8594251244527307, -0.9006311908688189, -0.06109022155259716, -2.207810924588469, 0.07006301374137633, 1.0150204295845449, -1.537766451106869, -0.5246860033902645, 1.3909965705988294, -0.782432692559098, 0.7604007571134874, 1.7727047906346585, -0.9758150163320897, -0.06266300801456634, 1.5289917115752547, 0.7793891905922602, -0.3364977574978757, 0.3911042793333931, -0.21016766618805588, -1.8937000052183104, 1.9426712794148242, 0.46107931461159235, -1.4347460494632842},
    {0.442163148611637, -0.8129265657364838, -0.40363136850491377, -1.3381141859798473, -0.262876509492683, -2.2642823228155065, -0.5995852277696011, -0.5189256802341987, 0.28953967193387303, -0.13368637284441048, 0.8413385721438223, -0.1018239103523777, -2.5838676637755955, 1.2521113822662646, 0.28412150454580587, -2.0528945743643754, 0.14230266083860435, -2.2296753617277028, 1.31899953534289, -1.930940833827028, -0.240401742065421, -1.5328741279704299, 0.8994092678880713, -1.0347138822494828, -0.17357425945871358, 1.2791833838811661, -2.7949100338771937, 0.49861255095781937, 0.7008727486203108, -2.0657174195783004, 0.9196524863849976, -0.9714298305174343},
    {-0.26764086718754687, -0.6126768674946753, -1.5138803075345755, 1.6433866569992985, 1.3268357305947833, 2.22119985073145, 2.067294481865357, -1.1973480100304752, 0.5139139212989202, 1.6297064033196211, -1.012391987071567, 1.4916171693035014, 2.7534110022452234, -1.6483683936402023, 1.050620884846565, -0.08201649643170689, -0.8948705583763658, 1.0279393775873094, -0.47187997767933076, -1.8352392981073424, -0.1705060773036536, -0.45487259163110516, 1.2128276980033064, -0.7032427737059826, 1.3734314473099924, 0.9326494938440714, -1.4080789315477147, -2.145673427889393, 1.4903474217100676, 1.641760804466522, -0.12095077357100674, 2.2237402776753505},
    {0.8520814821307481, 1.0577376250312989, 1.2150791528763154, -2.6510363185702106, 2.233291482127205, -2.1126031376945544, -0.20552244755018087, -0.43281546049892067, 0.20521774888088404, -1.1418895120793577, -0.6749675008391356, 0.6031599716555146, 0.23365336710062734, 0.16144020111617197, 0.9290012617142202, 1.6441898483713515, -2.409353504924076, 0.7983928346561183, -1.374534729554385, -0.37919947702472534, 1.9374198753323104, -1.5607434192134693, 2.2590427835824256, -0.42963902095157497, 0.5785801407884584, 1.2161538347437353, -2.1769508027729745, -0.6777135412607549, 0.5420985583093357, -1.8245686799969614, -1.8753097203577889, -3.1065547389948587},
    {2.1040688768731153, 2.3932520043583243, -0.322292447877145, -0.7688299833729009, 0.6384701835222175, 0.4629813095626713, 1.7489776636710177, -1.2952301530416375, 2.0884926291426487, -0.17410809861823137, 0.14405767977043743, -0.4450473492815669, -0.36788559105303675, -1.0409863223573064, 2.763422337723334, 1.7557862749271251, 0.9746723688902753, 1.0000557924517468, -1.5016809115125054, -2.4839143177820437, -1.5080954955650183, 0.17628446318473034, 0.1968552396255325, 0.7835132253905391, -0.2354133714795505, 0.5001530888758017, 0.6526172900832231, 0.860834513552902, -1.7944927269169149, -0.43994432644341236, -0.8707570492956475, 0.475486300707982},
    {-0.7285989386892564, 0.5081556749318701, 0.7194048587174366, -0.52384024422331, -0.9363434965175509, -0.7254490211766471, -0.94577043538566, -0.956298372769545, 1.2213979636162504, 1.5382594124440307, 2.573778669327813, 0.8347599695391338, -0.34501905642066255, 0.30882560683657445, 2.459869359076375, 1.7691015373433931, 1.2969268441337773, -0.011945198229106883, 1.5591058510819547, -0.466021627721415, -0.3914905476168355, -0.4618554744913456, 1.14886899430672, 1.5932165015173914, 1.6268637414705354, 0.12765465248874763, 1.3239810792206588, -0.8657158392852483, 1.9213533393838809, -0.030246635968673954, 0.4476551028464423, -0.9039042846841027},
    {0.20844751991659424, 1.3965983921567977, -0.18658997928527857, -1.4561540364687697, 1.2818108879201635, -1.5422667818581732, -1.3686300571539711, 0.6396458998349719, 2.4740336365544584, 2.022599924207238, 0.6053030404891548, 0.9138122429225428, -0.18089032287378276, 1.234723478239991, 1.1193187425717537, 1.7062071562843286, -0.20837574476762072, 0.35082849150423584, -1.6725234836468277, 0.25985255438331345, -0.6985228811331898, -0.04303053745367978, 1.1153171620633977, -3.2471691942321064, -0.38805177645439787, 2.5356587650626157, -1.3425401530695547, 0.597143245323707, 0.298491629789631, -0.07317361577431471, -0.2163122297743561, 0.19129204467072033},
    {-0.7854707712119036, 0.5469256607315476, 0.09088652024566989, -1.4134687241217867, 1.53222334286592, -1.132390073606463, 1.0703021535950428, 0.0876263336584632, 0.6618402174366605, 0.5618583597600526, 1.208896478698295, 1.7346904527841727, -0.8539361337018639, 1.275869376493921, -0.7349785149931274, 0.7047978874743912, -0.21825301786051865, -0.7160851997199238, 0.4603435807982477, -2.5210660195940537, -0.019703018680403424, -0.26174062246616725, -0.9106112820447487, -2.1098514830607207, -1.7870356397513203, 1.9711652459841742, 0.19288415203456477, 1.296732863011761, 0.9808361506385326, -1.8833783074447603, -0.6450235960155657, -0.21176148023074845},
    {1.0992383369938694, -0.28694068061568806, 1.8191748052869559, 1.7878614582012733, -0.6423248208245003, 1.7106651037478986, 0.6214586950731437, -1.4625755930999353, -0.7422228406769503, 0.8192746954006446, 0.16072178255838182, 0.704014683165107, -0.4729910318828393, 0.13630008461962576, 1.1607626687164125, 0.15091614061595748, -0.028370987597326053, 1.2824623962817332, -1.7200296327033586, 0.5557040910670252, 1.4839669413713668, -0.9047001329435995, -0.6393957116448962, 0.11438595950292199, 3.244856837429531, -0.4133922052573417, 0.17047892195232572, 1.5938465854740462, 1.6690481017127634, -0.7520076031749148, 1.9613600757095213, 0.5214990794175416},
    {0.6367717294876536, 1.5386800374430925, 1.3319307899429855, 1.2465597204097034, -2.373795275988009, 0.6101684537708472, 0.9788738412152851, -0.829384676504226, -0.8403497188617177, -1.1519841415394674, 0.6151860333493947, -0.4345408050721184, 0.09245197090304756, 0.18286433688715154, 0.706698065597601, -1.5232608231719977, 0.10586230441299652, 1.1603862882086604, -0.5009750335051927, 2.1259037342468363, -1.4703389553793735, -0.7355981352472708, -1.1193296167901101, 1.9382746118622551, 1.2188584180997566, -0.7680750492053268, -1.201640923826471, -1.1887571722945456, -0.46954110118622355, 1.952027492486472, 1.0390758127984132, 0.44047993850154193},
    {1.292713003655782, 2.3223181299093887, 0.7583640731980421, 1.2379215501389487, -2.468357187562181, 0.71312232834686, -1.6962652938507323, 0.6093551932840272, 1.535689715512265, 0.25272175855576107, -0.6406779875578331, -1.2897169971224318, -0.6538166591514527, -0.7106752794498807, 1.0193642127737472, -0.7136982760880057, 0.6332057167606219, -1.4721546635279628, -0.6651918140309557, -0.6793441665559138, 0.5754106912238748, 0.8972603893913956, -0.12307513623091366, 1.4456514743034226, -1.8286998476452125, -0.015365578929744543, -1.147868249069931, 0.6259626002421286, 1.6252447687767064, 1.6705533949156204, -0.2505890732788028, -0.43278462202523804},
    {-1.1387158811877343, 0.20672720558606014, -0.0348699610842826, 0.5654117950870137, -0.48787500225088387, 0.3954637277074488, -1.599857380969797, -0.35044816174723853, 1.040785881481319, 0.9745629590153803, -1.4140607649158325, 0.13391705895170367, -0.3247522024247203, 0.17175062280134862, -2.100820934842235, 0.9605434124711841, -1.977597035595341, 0.43882491605618906, 0.9718895695866636, -0.5383557796175533, 0.2747117320279023, 1.5477001597236655, -0.5159305304436135, -1.5928239715551427, -1.9036377677590093, -1.618155222341229, 0.686745974343201, 1.0274150746798816, -1.3840938475981683, -0.9841436454643769, -0.2350606081158165, 0.57444316016536},
    {-1.5605742635059179, 1.2037092151668434, 1.2814937653798917, -1.3248002486138666, 1.3390000714240788, 0.22776919010570784, 1.335699196893615, 1.3200294627370939, -1.73004399535444, 1.3781058084794235, -0.0120130408717222, 1.4828546401603007, -0.9610866525560876, -0.4562882448807258, -0.5888557856877593, -1.6904412392648691, -0.4869844643713892, 0.20257671951043613, 1.2385590633508947, -1.5744700107989043, 1.0797602381064955, -0.9480672193986691, 0.5391217981300627, -1.1826643995554915, -2.4687933557293538, 1.8172030829194303, -0.1097978744167503, -1.8849973540093399, -0.7230329950880785, -1.6272612309148173, -1.602947692796623, 0.760845744698278},
    {-1.75186563163444, -0.9821403186478751, 1.7030830150623661, 0.9943625297025096, 0.36521422817735355, 0.7628213872737529, 1.6828776152912297, -0.5572952389167569, -0.7027336866559312, 0.9463681849054222, 1.2287090370265912, 0.12376381026466006, 0.004904485937346493, -2.1130303788228724, 0.4551413398009848, -1.8998575970763172, 0.25841151668802936, -1.471778441107205, 0.4109116123723512, 0.10880850882786834, 1.2275844789539836, 1.2954073706174885, 0.39309828284484793, 0.9566373039335594, 0.09671645832758755, 1.7900800603757936, 1.632457731006852, -1.2171720940299464, -1.574071547920213, -2.3995530605769337, -1.5767962971694818, -0.31443778016046087},
    {-1.4825902765406014, -1.4507915374827953, 2.02992018092147, -1.702342846170887, -0.12306091139240287, -1.8417558695133485, -1.8674105806832522, -1.0659939681521275, 0.7628557151898198, -2.1603604837926604, 0.20957606428185324, 0.7182905191610686, 0.20222878217418797, -2.0867238536879413, -1.318244259072927, 1.883898519323338, -0.35831115214764714, -2.411859066455616, -0.7409546685151922, 1.086242053285808, -1.7845797417789844, 0.5889466677052841, -1.4501802928738738, -1.968744275522641, 0.47252486229767654, -1.6455963447325421, -1.2674265845327197, -1.195716881476133, -2.6082848164343018, 0.48439359226957035, -1.7406114128966912, -1.209259092202376},
    {0.8653599945488345, 0.26301125878006143, -0.13629869744914036, 0.5757549791298898, -0.2976180222835395, -0.767466106072586, -1.274940233655335, -0.32075886983263024, 2.1102495188801558, -1.6386132016111163, -0.8150436524293834, -1.1699972548891162, 2.2483341178183065, 0.9235662444824346, -1.3731877515521322, 1.4693789025792987, -1.9671670667283219, -1.9302474187138925, 0.8149091997850857, -1.6439825145784501, -0.48484478280886706, 0.3288757433185679, -0.34415803788909366, -0.9327900052598438, -2.452361986059637, -2.058169657877378, -1.3364092703475718, -1.7644089068658995, -2.1221430265050802, 1.5792574820770593, -1.548946357204484, 0.2976767752490559},
    {1.9305809747849245, 1.311313398156418, -1.3329156678756031, -0.6214978398387971, 1.4052021161818458, 0.4732898795576911, -0.24292835051454964, 1.0919740533023263, 0.9736826705598541, 1.0085170608294283, -0.222191384060257, -0.7658772898577203, 0.8627357771831474, 1.1637208817573523, -0.6688974879574887, -0.6377084374640484, -1.1666348457746007, -0.034951453724640334, -0.9560052441299192, 0.815397689427443, 0.21231860782100453, -1.6669586161016778, -1.828123912013582, -0.7398945119610619, -0.23819687607980786, -2.264216783849374, 1.1881288384036317, -1.6764687153633107, 0.35665737920908164, 0.17202881434159098, -0.9140612925996859, -1.5448666234821575},
    {-1.5279144267396705, 0.7316971072956343, 0.3938435581867522, -1.7088787677442183, 1.7220409593573314, 0.4262953430529493, 0.9011621174862671, 0.9164492851711687, 2.0193104373858355, 1.2967420798605906, 0.9676704603730518, -1.5117994493908706, -0.21585789897050264, 0.971554855737943, -1.233898168134157, -0.3703730088532824, -1.9645567390979326, 0.8160344694238817, 0.8982319139705006, 2.0546382421772407, 0.7609368045925756, -1.1217782223796613, -1.6381094233335116, -1.4521651795840111, 1.089983511781176, -1.4993866240036713, -0.02418504200202477, -1.2810848478928314, 1.0662798911284646, 0.8084054107017639, 0.5784046108179592, -1.8407475899174448},
    {-1.6480299369069271, 0.7838506940663363, 1.2038335213389209, 0.6380919094445844, 0.5476345691002282, 2.091901768807876, 0.15504234284996754, -0.567750566692454, 2.192212223044721, -0.61686850371591, -0.46861141475799484, 1.074321358032482, 2.479186835731743, -0.9978103060913345, -1.2599219304566391, -0.37327174272506014, 1.6261434291911057, 1.8192856238459831, 1.6725075019414666, -1.3200805099977146, 0.9253775394783834, -0.6198903744058001, 0.2363326411573037, -0.997394738956425, 0.6601917384256438, 0.9060466034945406, 1.1344373800406933, -1.2897399536501795, 1.6575713056714447, 0.5393026380263183, -0.4628691739610271, 1.6843161483901496},
    {1.5154973710428221, -1.7621662308790897, 1.3451137475882025, -0.8475167380335533, -1.966779192197423, 1.207542531684476, -0.9804807072057153, -0.7263497799148826, -1.3299917699262365, 0.27305554130348114, -1.074827348857717, -0.6607102126602354, 0.5793273704454842, 0.35452705115468475, -0.21897778689809957, 1.2709456659461353, 2.0237051122901013, 0.27740255233250816, 0.7099664024424626, -2.112669866577516, -0.4547045973379587, -1.0110919759300026, 2.3923750854613144, 2.7068392856129218, 0.7288526458983762, 1.9237434800195647, 2.6445967231543004, 1.4706139677598808, -1.1025482277424188, 1.192671221812062, -0.8607376475184709, 0.86888320556401},
    {0.736120596697118, -0.35042280262659226, -0.49362624716743314, -0.7278494568566805, -0.19477410545057267, 1.287218981711823, -1.8274713444816681, 1.4905729254003124, -0.5295230972612809, -0.44347354461010424, -0.7116075122310377, -1.1703445672387343, -0.34118720263970886, 0.07279641635196736, 0.6465075428490248, 1.2970940564031086, 0.0981567040165926, 1.4526520079841, -0.24139125015889945, 1.463024774741122, 0.23493643740818623, -1.118610938380929, -0.07348167094992564, 2.2651554630899997, 1.8527982369667255, 1.3508598712017716, 0.40584648687063934, 1.8969419565453658, -1.6183377152481917, 0.06016331662160341, -1.1138561651048988, 1.147556256001661},
    {-0.37709023723082397, 0.718197322857861, 1.536843548780729, 1.4531314631837389, 1.6522575552156844, -0.21456637131707118, -0.1636139738004446, 0.6118601985062275, 0.3968025870908438, 2.2332308002199697, 0.5616060990891883, -0.40917280992045874, -0.16511856235777644, -1.25051846534145, 0.9067562369374754, 0.4910924901416534, -0.6173739008966619, 1.572634070481863, -0.8261693353100173, 3.4000309960460777, -0.3073674457550795, 1.9962670322248075, 0.4493026340164528, -0.7861176398272758, 0.6355736239287609, -0.034717383995703385, -0.2988760713574988, 0.9137099752142862, 0.1863317205717616, -1.0345754897391726, 1.8553739783072207, 1.601607256577336},
    {1.1988885033441354, 0.5449102017834256, 0.511830264578816, 0.47278194638683513, 1.8166252459834988, -0.05072875355064742, -0.6619851501549114, 0.43465906846110464, -1.901982196119048, 1.8684535958486805, 1.1231631099708286, -0.1839676710377856, -2.0069171452423133, 1.3072660293841092, 0.33541962749985044, -0.5370874931021292, 0.4944368476986443, 1.4793536957551936, 1.8922854386857482, 2.4152668161257336, 1.7314693259879728, 0.3881962095120815, -0.9073601459964824, 1.3206658043969932, 1.2729271314957278, -1.535763398921782, 0.16157407736964974, 2.352945321530215, 1.4286796775995778, 0.8470271578581416, 1.8554290995782543, -0.13282782630134604},
    {1.0527250971389714, 0.9793347149412402, -1.2154295693287889, -0.8605456231046581, -1.2738537739034557, -0.9838772542208953, 0.5076949912398356, -1.0648353620008109, -0.7669213572547319, -1.4010891058833788, 0.6166908007732753, 0.22645222342712165, -0.031821146665053826, -1.0389894152728878, 0.06836046404600366, -1.9730648228211847, 1.5550333783659636, -0.10875228228695917, -0.393124206472404, -2.3308146073227918, 0.27626357538774776, 1.3749774143615492, 0.8546834897094358, 1.2000994967081178, -1.3668419291436036, 0.650200797795479, 1.1225595822805003, 1.7943145973654966, -0.3202494229929627, -0.9945256535498007, -0.9037424782398024, -1.0094790725336669},
    {-0.6784333787098107, 1.300709300580075, -2.7437856039579107, -0.1045118310452153, 0.0447430830521406, 0.018323217659352593, 1.527093269715677, 0.01889307703750954, 0.03050655108468696, -1.558323691324757, -0.3408116847413063, -0.26756847728992617, -0.37025597948224165, 0.24748780544041285, -0.6549934893537376, -2.1646705864454576, -1.1747406752056966, -1.2448669723613173, -0.3908598914156119, -0.6446286464280416, 0.506844023884, -0.5704435118254239, 1.4831411900817821, -0.4065574120859393, 1.7905076406801237, 1.2852026032376103, 0.6042980385431606, -0.31070874708275303, -0.31939417485098004, -1.4063608651208606, -0.8633814402549163, -0.4753357224559743},
    {0.8738092057278308, 2.121068317413393, -0.46984629042950066, 2.075139858777424, 1.071389497211112, 0.6812397869608655, 2.03298833857194, 1.636730132756756, -0.19965916355856886, 1.954287585332399, 1.4669066900013161, -0.8540210772243737, 0.053918327461413826, 0.29042378646641914, 1.0831365416127567, 1.1956678518549222, -0.8392444154097167, -0.8561509249722478, 1.4750816180787225, 1.7179392946926526, -1.4501195650727383, 0.4553700476764279, 1.3200751004609295, 1.6455287747388347, -0.8257442645233521, 0.16932895289668237, -1.0521636456968824, 0.02813968515763627, 0.6410668281081396, 0.4416176496286005, -0.8927269075876534, 0.8526594492642117},
    {-0.19118571506548457, 0.7255754470496719, 0.4877972555674631, -1.9165623862007248, 0.6950176236252422, -1.1396748634110607, 0.3119047582360625, -1.0963963086802249, -0.3382789333293514, 1.3046831746264445, -0.007749210209615953, -0.9665452217766213, 0.7925131886640588, -1.9352074657975677, 0.6272610727206271, 1.1296443540644272, 1.5825470989785446, -1.6968629073454253, 0.6862785589261082, -1.8670273099226067, 0.8101107426622427, -1.4627121420871942, 0.41412847222419663, -1.5139042064792387, -1.6111054757234864, 0.6236217815628036, 0.20998308710258587, -0.6297976217295165, 1.0882065285347589, -0.5420366191586357, -1.3203501359939838, 0.7970469249329215},
    {-0.19387320446065678, -2.086735502722526, -1.6922656370004296, -2.255186636373452, -0.7725644305430911, -0.6223531266421121, 0.9666486560145476, -1.4212888313738599, 0.7491730116485402, 0.970990577802679, 0.7733233563522834, 0.5860783056956361, -0.08894008902263464, -0.5873132130263741, -0.7456219096166, 2.3107703059451357, -1.7501316042843928, -1.2430288079130742, 0.3415890503535697, -0.03928547004597073, -0.9518166303367362, 0.4172808034365963, 0.6613761539963855, -1.9347091557944038, 0.7724458564715373, 0.0065324144773756705, -1.405488013051696, 0.9640842083146282, 0.8496582451518205, 0.06731452858267913, -1.4802403595424811, -1.0361706771283463},
    {-0.5530861715692732, -1.8675693297942002, -1.3660787831575179, 0.47858808451050594, -0.5893842140368766, -2.049176264587514, 1.350197815812846, -0.377640769045637, 1.4228585872070179, -1.6630115129028515, -0.09356042508871956, 1.5434584439354286, -1.2064370189345053, -1.8207670248499124, -1.770902336484451, 1.3290693516513075, 0.5243872679596849, -0.48743829180064335, -0.8900616402391435, 0.19709321959162404, -1.6085255447857345, 1.1688441133478502, -0.34813387640396815, 0.4904106457018914, -0.016635092259183776, 0.16449654512254824, -0.8389796480540165, 0.22771254394808307, -1.2040462704204735, 0.19643649432266866, 0.8106997918849929, -0.4298642352453978},
    {-1.1282207853823913, 0.4496576868792339, 1.8975153921229504, 1.3813563964995723, 1.3732049628137837, -1.4832298968767914, 0.26405233693582014, 0.32272289325344955, -0.47249100859765975, -1.5087304587555874, -1.5505481135260908, 0.30153833613042014, 0.47359181753035345, -0.10945539837023861, 1.2895204232310327, -1.4585872261696313, -0.36779465374384185, -1.457540847482564, 0.3513714626505654, 0.21611205228452413, 0.9276223284563786, -0.318338442103552, -0.5207512929002726, -0.3901161986103256, 1.9102917936981922, -1.3584697305296096, 0.5817768092536707, -1.4641017122427629, -0.4306014873213681, -0.7709919293933911, -1.2581845413494488, -1.0189383372632876},
    {-0.6266691765972529, 1.876318900645327, -1.0824298699191393, 1.917018294462841, -0.6486212861115144, 1.7329399969282204, 1.5896432909914608, 0.17536775151114975, -0.4195201203587591, -1.2740985735804138, -0.7143779274258965, 0.19289747852297268, 1.2438407593520175, -0.8353197874593428, 1.5805927128641906, -0.8565540613778433, -0.7705951657786935, -0.7348955884577695, 0.9062265715569622, -0.8244573381021166, -0.4636922161581615, -1.2446251903034424, 1.487742536401222, 2.0609967182477114, 0.03200178936586519, 0.8485098836757068, -0.13985558458859626, -1.0054418111813315, 1.6824281554179168, 1.1857148321437168, 0.3036758328034059, 1.7462515637007059},
    {-0.8023718656666265, 0.17906399935891987, 0.637799638865377, 1.0678789726130853, -1.1743004634476375, -0.4102083432989095, -0.17468124538249516, 0.6391659583133406, 1.8250995490062214, 1.6724944263712667, 0.5237884875665394, 0.9363207398604466, 1.2597666444004016, 1.1139900412363228, -0.7559591792633357, -1.090451636155675, 1.8957787469780265, 0.22363569871671415, 2.4088964489482367, 0.9064342830510733, -0.44801506475408415, -0.29718620164806914, -1.2106419835086772, -0.36354903904394664, -0.30163019934993973, -1.0277664256824457, 0.29634270492132153, 1.4890864348576873, 1.8140948216710806, 2.3512297059344696, -0.2025597445972064, 1.085364982088449},
    {-0.02894731479234039, -0.16993269694764748, -0.3743813697657331, -0.022722550241688625, 2.470636005012234, -0.5021024438779773, 2.0565214058023984, -0.0005972621963999715, -0.33885572849737755, 0.27231913620088777, 0.1696429077724899, 1.6962936007616805, 1.593818146283867, 0.2789811967186357, -0.7610364666983, 1.860193542529214, -0.05550818127987476, -1.2984602956831095, -0.30312220090450726, 0.08835187187855821, -0.7425878068410369, 0.2613315083736062, 0.7512134712781234, 1.2994355459942604, 1.3216928123828997, 0.44238026840682826, -1.0658008305084836, -1.7184820227917081, -1.541779571041525, 0.35273578510460446, -1.3659571096872845, 0.6639846129774668},
    {-1.5499625787072007, -1.0988614047857983, -1.2932239400024643, -2.589753811680774, 1.1519717658589392, -0.01808471407612425, -1.2309448871371387, 0.649834472254609, 0.9952962433528, 0.1611700596145814, -0.6275837249406967, -1.8544677732514654, 0.08190866456337606, 0.14480230487893744, 1.0291834633118306, 0.312561735169331, -1.5606235758331883, -0.8897196967204228, 0.7951329941241927, -2.5742679174035348, -1.4355916518968488, -0.66587048529076, -0.4992766506007268, -0.7351008370634261, -0.9333677671304913, -1.2114118677375925, -1.9119664181416147, -2.045403584306837, 0.8637330820496198, 0.6536043893654132, -1.6293113087180915, -1.841460965086184},
    {0.5935537134602852, -0.7522076132288767, -0.7767876028779475, 0.8958667221358063, -0.1023050456519115, -0.1136382967494704, -1.3037226492814398, -0.33278792933989015, 0.6153589830071629, 0.5386022181372977, 0.4683708604292208, 1.247373655100064, -1.3013784300061364, -0.12812753005047858, 1.1667528651043866, 0.028727009521696344, -0.19206991638396326, 1.353246990784128, -0.744668255488335, -0.8171895665940981, 0.8150717441452239, -0.8851014344318335, -0.18673912340292276, 1.260342790410629, 1.042356051398249, 1.7107481443621129, 1.2485599690203542, 0.38816134097309407, -1.2642940693962987, -1.0974668413103514, -0.2576121522655308, -0.9763257010157717},
    {-1.1277927497406426, -0.4533257639879006, -0.3159876916388851, -0.741959111132381, 2.0480786061839367, 1.9934349857859899, 1.1236096106303408, -0.4432282396455523, -1.9166928838487916, -1.1325302564228346, -0.8952702518420177, -1.8356673720587617, -1.4513188450936723, 0.4667594997667683, 0.5010527604283801, -0.4156950068725096, 0.09568350834582573, 1.457722073036003, 0.265140482267929, 1.7351841048755046, -0.25361323885814074, -1.1042508508031055, -1.807560841061388, 1.0546169416442126, 2.0336086272941762, -1.8012660099244817, 1.5054032060372307, 0.7941421325628238, -0.9277887002396571, -0.8781236335169248, -1.081632567902456, -0.7354856675962368},
    {0.11110512857672418, 0.1457810291420437, -1.6100653190620264, 0.8224101393279977, -0.7714240348990884, 0.4564803098053371, -0.2578497867225291, 1.2102663670919283, 2.1240516658538784, -1.5956490892587638, -0.01244599659073684, -1.6110951219993814, -0.9439162333691935, 1.2733032755661362, -1.5129743462249492, 1.4202006687626683, -0.12754735805318634, 1.1699208046460654, -2.246960199077285, -2.1938441570897065, 0.5508766044815198, 0.49813224386400945, 1.2732455892434438, 1.829742888257284, -2.1287156455654546, -1.6299778936457197, 2.0215237750809765, 1.3941491994691129, -1.5578787725645515, -1.2341233079718066, -0.05716805708655416, -0.8730335556752081},
    {0.9781102224995922, -2.0020244158582816, 2.5908381470946793, -2.441359839235519, -2.756343717915556, -3.927189823672496, 2.2346488703127405, 1.9306394440814614, 2.089466844048741, -2.6360465968028195, -4.334965934830425, -1.5139078366278493, -1.2510696504108414, -5.046008214222622, -3.3662813564636545, 2.933324014287232, -4.762525344848525, -4.677123858872365, -4.384606699323709, 0.4276083918163963, 0.2486221692132513, -5.113416054310176, 2.3158043887706414, -0.3636596292188031, 1.2562280956342688, -0.8056456723153529, -2.520199999995597, -4.312308329399293, -2.4718341569977396, -1.8563393793209768, -4.781101945282809, -0.7001694567361556},
    {-0.3179127828546813, -1.577144573830323, 2.4448603340835398, -2.3313356682135438, 0.49717867890295264, -3.3491230447329645, 2.3978165981640154, 2.866700354109414, 2.4492386030987205, -1.722591309307418, -3.538186063137834, -2.257742827072163, -0.3669183632701604, -4.813235840824784, -2.206218246950415, 3.056647823141075, -2.946813487826124, -2.5003850469021476, -2.887457939417332, -1.9070455195606666, -0.5168084072518517, -5.413723430554164, 2.7997140956512014, -1.053235734095644, 1.0495229128763897, 0.9400383803161628, -2.273412224235975, -3.3446329829394674, -2.124481012108115, -1.003579922357971, -5.306033818563727, -1.1482447151104576},
    {2.224126764435186, -1.7209718738759523, 0.8855715497546838, -2.9427784631078726, 0.644975759032868, -3.5884350467207122, 2.314963847012668, -1.906682763979337, -1.019923116974615, 0.0811366110713923, -2.4424589779333954, -1.3299663645986242, -2.1190219684222265, -1.4943250967137214, 0.2281488131733466, 0.34354127664137835, -2.9308128337470487, -2.8428575796100115, -2.793356734739687, -0.6442969550594974, -0.7823836250741527, -2.596368511347988, -0.14052157583335118, 0.6028930513133974, 1.2272917742234197, 1.5506164516997094, -1.8901735484083133, 0.4451483380599405, -1.6898934748553318, -1.2706307007571422, -2.763920550657666, -2.374834831599572},
    {-0.47973565094645576, -2.3060743731833484, 0.006781591021827197, -1.5871397467734514, 0.31474747344820303, -3.0167736859204615, 0.9847339307375245, 1.027048151862324, -0.5411306354188787, -0.3944251812339181, -2.0760494626815382, -1.462215600367057, -0.792162213592319, -0.9911726127800751, -1.3705895848053833, 2.2986814549044365, -3.418480594941596, -0.07640342971502928, -2.1175312436667455, 0.4747615980944787, 1.1410236015961177, -0.011655185828251905, 2.0200167824533857, -1.3663760463551458, -0.975868415051382, 1.8596384923613696, 0.3710420393548509, -0.5008229823184193, -2.725564373214933, -1.4374771155750201, -0.3106932468228106, 0.8001318266904354},
    {1.5732822009826262, -2.1030823757569417, 1.9416786373407406, -2.0108533608103905, -0.7591835743092412, -0.9557159175536466, 0.7365089030664664, 1.711285041497374, -0.4325801114244073, 0.9707626137603799, -2.269192588297311, 1.192693789941313, -0.044149273581755105, 0.3783270947929722, -0.900842690795308, 0.22028917735134307, -2.5041971267532324, -0.8960473441668112, -2.1803039963275026, 1.038220837129495, -1.058694640303281, -1.517956014655064, 2.931812399519953, -0.23419803382732446, 1.0457463582015447, 0.7747410718483579, -1.2206800178156925, -0.5123255922616166, -2.7442168828457456, 0.03583784935547519, -1.3861459026322236, 0.8583162522031126},
    {-0.5650853785921759, -1.1396259865888572, 0.7446597677951058, -3.1220532539777928, -0.5505729041642312, -2.181992997239581, 2.8366783367705257, 2.6704719330034776, 0.0930808655553806, -0.1549819744071072, -2.6580999427361336, -0.7483936915840973, 1.0698063282443095, -0.8379368598788672, 1.2587606610055693, 1.238444254859648, -1.5526424590163523, -1.7417368969581475, -1.5933710625771293, -2.5018205538716813, 1.129592979051204, -3.1973244397513585, -0.464733424524353, 1.4389491465629458, -1.390441114388994, 0.8933729009311107, -0.30734134888931935, -2.691220762711788, -2.9051465774796768, 0.713127452970998, -0.6014230146275016, -0.49460549291753264},
    {-0.854474593907017, -1.5402621058401327, 1.0771632245706904, -1.4242853637644701, -0.04986221620344067, -0.15107020896863652, 0.29850285662192566, 1.106876983407215, 2.114035465245739, 0.46697197757571257, -0.42628798036853965, 0.7683139744765238, 1.3618493924298019, 1.4964982968275264, 0.21429928348481336, 0.4760646000710204, -1.9824581745297, -1.2313865834514102, -1.1815597415862942, -3.0000258185876247, 2.5701759319745427, -0.936824816599162, 1.0030412457183602, -0.4950094230241162, 2.3204496507870824, 2.286423429560242, 0.020647540538164217, 0.3483952856879592, -0.8180896318396638, -1.942349818340523, -1.3542195494882323, -1.4979741011739434},
    {0.4491156173884568, -0.566650607882818, -0.31259987638136527, -1.7746698657045048, 0.7428514863890404, 0.6543690194879357, -2.690625537952685, 0.00966761757146845, -0.461724800314281, -0.9931800112411415, -0.0037222262164881897, -2.1247823182859595, -0.3533238843133209, -1.0041537075501619, -1.6047386894879747, 0.055332397710846914, -2.9866722014583686, -1.5303648751747434, -2.2955747579012447, -2.969057798858012, 1.2684239061529017, -0.6959488910895084, -1.656792639105021, -3.243072252056697, 0.7292525483340392, 0.7391378111243975, -0.5919310357783137, -0.6061016499845047, -2.2254914217048487, -3.021833222628715, -2.131111681040326, -2.7926472809100438},
    {-1.7715234026040743, 0.3145303246090826, 2.1255810806095705, -3.5888995050444805, 0.9122554498623291, -1.3118092149252265, 0.528502549076765, -2.6802069228222085, 0.24339375143213057, 0.5064659651761189, -0.23240926321590963, -2.3834624458722735, -1.0416367882593673, -2.0128291797838336, 0.8291878624162791, 1.0978862093534043, 0.019227532955858197, -0.2279613106509551, -1.9801671733256707, -1.65794593425881, 1.0536812054525202, -2.8459877450567177, -0.5496086711544019, -1.0011816780934562, -0.6130390821133133, 1.966981558482781, 0.8684855087418067, -0.9915167702649121, -0.432442839045606, 0.5579616915989474, -0.5210851743880189, 0.30736680360013896},
    {-0.4142178875673849, -2.4390468473241067, -0.8491308583665441, -2.2890196137849057, 1.4739617549632953, -1.6997064363991115, -0.2572121557041816, -1.923515459763886, -0.24358272462548508, 0.13163717265519695, 0.25447856066531094, 0.2721823555283258, -1.9782563860318942, -1.1356821535802988, 0.534706677368628, 1.7871136549132636, -0.9495500615787573, -0.9227636620699066, -1.0038970125321438, -0.3916158297972971, 1.230577436728426, -0.7167505867866735, 0.6562373247341097, -0.04404850327591153, -1.2954987577633705, 0.6356995171560158, -1.4404809469195587, -0.5684565210875778, -0.4751016906338665, -0.949732727273049, -1.4347576666656539, 0.13277335003675525},
    {1.0542163399189117, -0.531659216524691, 2.5543732810062645, -2.0081145426115032, -1.0196266953022537, 1.009102320823721, 0.9727862260196276, 0.05428899857037734, 1.0549920194820268, 1.406587570841307, -2.169568787511217, 2.1278994276984977, 2.2071966785443795, 0.3645314724028722, -0.18677870465726404, 0.9926640522688855, -0.6926219625264609, -1.502151495751215, 0.2074571551740046, -3.1676582221166947, 0.11820256704504722, 0.11344189228383636, 0.8725784764726431, 0.4511852684909095, -2.0371049461642867, 1.1867738405533468, -0.5437782525122798, 0.23645153589780823, -2.6616897168826212, 1.4568972676043657, -1.6801925639791235, 1.7386499477374753},
    {-0.3998648664574809, -1.8543796401746615, 2.2644180809496834, 0.28048326448554156, -0.5295029623207866, 0.09675841898696755, 2.855956411417855, -0.11296295994832017, -0.7224514242489954, -1.6340263230455923, -0.2648520056510448, 0.9998215069830105, -1.6095829494139082, -1.1672959393497289, 1.8417599573218568, 0.5027695406089158, 0.8767684288911597, 1.0976536517625088, -0.2960269162024919, 0.013001700654842022, -0.9188492844822523, -1.6874268613512176, 0.19974176532117324, -0.029174575551719824, 0.6590258353847384, 0.515738760405265, 0.12357405970451008, 0.2653239113292131, -1.5575591195065952, 0.6689385087813119, -0.3809323771541872, -0.04930019044100097},
    {-0.3996168707072602, 0.2502898049916189, 2.1375826836842524, -0.5847598919685315, 1.9312002350607655, 0.5329493776043285, -0.9721962874809071, 1.5460892289851031, -0.2564522865879173, 2.2194763663187316, -1.4646039592938296, -0.8143139475767774, 0.575989163322743, -0.07008280935415101, -1.051456928960276, 1.67761374368214, 0.8715947244479436, 0.050056159833553965, -1.5801171858773924, -2.42594708177497, 0.9960580772658497, -2.3498738346533106, -1.200999821754898, 0.45763987284101604, -0.4311446885813248, -0.061013308046884804, -0.46784521980501703, -1.2698461444629858, 1.6529521758076857, -1.8600224384780073, -0.15751633668027337, 0.08055591374625229},
    {2.0466220214060606, -0.9848738638191453, -1.2064167588540415, -1.9613242896104883, 1.430329734115141, 0.4621772223152714, 0.8619649064945357, -0.8849472468538851, -1.5011017158807125, -0.8393084851669524, 0.140776922077297, -3.3122198602648196, -0.8756882132284495, 0.2919128251826923, -1.6867484061090467, -0.5631004862347462, -0.7313077298869903, -1.0395723042454172, -1.7826356879235163, -1.3757236968199296, 1.8507888606468654, -0.8462722941327593, -0.2335494780488456, -1.7503175592053175, -1.786625253396414, 1.7666870374886539, 0.005999047400921198, 0.18106365162387972, 0.5586053489853545, -3.065363613225049, -1.4906900136935852, -1.3591066491223485},
    {-0.7137793596327661, 1.0017972035682228, -0.34961641689904793, -1.72067451433394, -0.13890590861553026, 1.4315288996769175, -0.2000214420512217, -1.2019487561034379, -0.8468847922497169, -0.6892209003778673, 1.2931263036286507, -0.39677607566252654, -0.6058277570754997, 1.7401917523799295, 2.0801313629223506, 1.6221066505928792, -0.7491500718364114, -1.904968169093678, 1.4241357086502784, -1.8784596776674884, 0.5395204989228947, -0.8018735718574139, 1.4232936494564965, 0.4109826489064293, -2.1663786005975934, 1.3305793064813316, 0.12243691251808929, 1.2841571099289564, 1.1416585564393298, -0.15502751720887517, 1.2485284162350627, 0.03103087618167486},
    {-1.1795998723834726, -1.4306879602515512, 1.6128778417623844, 0.3677936955709269, 0.07188399929576389, 0.9666403769515549, -1.0933990498998196, 0.9973049283384235, -1.3843921094725355, 2.0489047869068315, 0.6785506912845622, 0.3834773601929922, -1.9050252927376894, 1.136546107982673, -2.9376835658728204, 0.24008653560469462, -2.396193441437467, -0.1598269765881064, -0.6476850411984222, -2.6989398996043663, -0.14953429802740856, -1.012338857944108, 1.8540674537750617, -0.7041790129302515, -0.9772109790296508, 2.7549679114795596, -0.7869059950159727, 0.19052791385628345, 0.2552440512483989, -2.9462209183110355, -2.585838827031638, -0.6690959363504834},
    {2.132555056285222, -1.7136331347550489, -3.269905086567208, -1.9356681949359968, 0.32376761689162487, -0.2342341432206086, 2.28467219079036, 1.2442201073715147, 0.8684756006255043, -1.5230579746433295, -0.6865186960215139, -3.640721191584106, -0.43715894291464397, 1.1816961081272892, -3.30085833125051, 0.5086651293198641, -1.1702534198814303, 0.60730516495069, -1.59805201071425, -0.22908496414627827, -1.2975924045110696, -2.463212710311146, 0.8177285206311493, -0.05493809205321928, -1.8726357042534725, 0.8407350689608137, 1.384163019645846, 0.7824582508119999, 0.6115519022893893, 1.9118889184774246, -1.6711370884734453, -0.5768313224925231},
    {-1.050859116112172, -1.5337062873673306, 0.9476918822266727, 0.544268627765372, -0.7275576157746599, -2.2970371264868636, 0.2607068439778689, -1.8571282213733478, -0.9943361148510257, -0.04317075514235117, -2.009218387740699, -1.1918009210551126, 2.360579628818204, -0.8682086647573586, 0.6093853396535698, 1.273777332731665, -0.06925638677297875, 0.5634037726806836, 0.006176144117509784, -0.20669370304847234, -0.23037329765187076, 1.9736616916053937, 1.3875080062465623, -2.030976161152058, 0.9103061891595802, -1.5346458106839085, -1.8864518551923422, 0.7845373721717549, -0.14280707586123603, 1.3525715779305496, 0.9128168448977048, 2.121436286615728},
    {-1.6379824596545995, -1.6478810410857474, 0.06609041848199945, -0.7069308394345618, -0.04893272975786578, -0.864113019803635, 0.6163376039095931, 1.6324859249486232, -1.5714155216815027, 2.2395214011710505, -1.782185235710043, 0.7340687025263656, -0.5388681311190922, -0.8752401159377874, 0.9797953281378324, 0.8404258964643325, 0.686788911656314, 0.7246577740773337, -5.81263820048626e-05, -1.6296398594801376, -0.08068326611674283, 0.6806710160847538, 1.8279114752118129, 0.8974030339543457, 0.8157856954005678, 1.0699738755715804, -1.2733481689351092, -0.008976656001209208, -0.22634577568786718, -0.9689424723702342, -1.050700629026993, 1.9273715576761088},
    {-0.6145653483963172, -0.6680366170761457, 1.4793783326593195, 0.7190765376926196, -1.0573206757361064, -0.7215620407848421, 2.677918309471947, 1.1876155968846922, 2.277663167800065, 0.6339425269627862, -0.14337731136884838, -0.6412676449122799, -1.5045027320026778, -2.530687656906495, -0.14674462937934893, -0.5943149933108892, -2.2158970594189307, -1.2977208640944078, -0.4893981900730178, -1.8156862919819317, -0.7151191773706096, 0.1914539538952478, 1.419832165682355, 1.4571197991913525, -0.4156223243606841, 0.4343314290640911, 0.19061187368872232, -2.443932832163821, -0.836697351101862, 2.492201594254442, -0.40476750351355745, -0.2625338157456209},
    {0.4761095310719386, -1.139864928333539, 3.2230507844937004, -2.8737091199972324, -1.856281797333903, 0.9196963667135591, 2.1584159293087715, -0.6017772055809012, -0.6960421154929045, 0.5206855739239309, 0.364796123110121, -1.8441887474987673, 1.3072205553423248, 0.8741131122288986, 0.333698454960034, 0.9165090577275322, -0.5467878648641871, 1.1337868296281228, -1.8702222683658596, 1.744321201917713, -0.4272321870243312, 0.7910083777960292, -0.10878141907234291, -1.3377317159123672, 0.5293379743578782, 1.4660959712895576, 0.7872687587039996, -0.6236352020004413, -3.244725564761939, 2.2139566641245843, 1.4135402573514542, 0.36159429889213934},
    {0.4111778406051183, -0.5955467428125539, 3.293568481812885, -2.2090398841555485, 0.9516532087103107, -0.13819867698189864, 0.30512746112233957, 0.07262656740716104, 1.7160579197477162, 1.6785072560260799, -0.24880585815787107, -0.14893848542847737, -0.04236687761551035, -2.0227730904932373, 0.8012798161577758, 2.4026274257466267, 2.584900784256696, 2.460737633612182, -1.0257106125620656, 1.8012176793635637, 1.1886564191901854, 1.7592533030456892, -1.4790594564116728, 0.3769065157724451, 0.17592195665848848, 1.6243952564632986, 2.8257549706193656, 0.7425709993187067, -1.5321273000067355, 0.5244277506825786, -0.08607666760990347, 1.5733163531424919},
    {-1.4725083618234929, -2.1264493312363797, -1.2720536479135083, -0.22588132589089965, -1.1609440544454919, -1.605715863871784, -0.07207810250878195, -0.24998145099216876, 2.333851344419878, -0.38543915054228517, -0.35559954978060293, -0.829007225526953, -1.2775273120360682, -0.9787646690564148, 0.9635707737478301, 1.594493963556688, -1.2709559843491582, 0.7530412042464489, 1.9575659916379877, -0.6717036917024493, -0.6164730820647283, -1.3179975102767199, -0.19227204304124432, 0.6636094668912274, 0.23587263644932532, 1.0064381912195846, 0.7844122299611294, 1.6603059386944194, 0.07471112093741974, -1.9362575048719284, 0.7179640431068742, -0.21401720195412668},
    {0.046179403297477516, -2.1727388845357853, 0.0742311724793338, -0.82694303077631, 0.9495996975651712, 0.7978287012897188, 1.8317448879843505, 1.6330700667886018, -1.5775455165211998, -2.0313718607625844, -0.10308531721112368, 0.47161083620363936, -2.1659904542313475, -1.7458225307505755, 0.9407076461069993, -1.292554522592157, -0.8619724992923223, 0.3153630926705114, -0.8854938045989822, -1.4557869146559121, 1.5407006271306778, 0.402956138486688, -0.561609113482672, 0.9377685698409902, -0.5110014315398425, -0.12264744875566072, 1.117988178541075, -0.382052675179276, -1.1242382268667126, 2.0193730617157346, 0.5002776819911932, -1.4432587524561653},
    {0.5450106424692662, -0.5908329952423405, 1.1667505332366535, -0.8937755276839673, -0.5383714212858217, -0.45848205194136954, -1.9989932156461365, 0.7146457700993915, 0.36287886372847744, -1.5920234608153432, -0.5114953669606178, -1.905451053484616, -3.853379603320678, 1.2276988720286848, -0.41750328803629616, 0.26347458358339504, -2.0177285495412076, -2.46536771105655, 0.07863732188189453, -2.6804073434979627, -1.1971307774635642, -1.679810778611488, -0.2319971229182192, -2.8206625614648217, -1.3378503200072323, 0.4975594526246148, -2.424246841810332, -1.8561199019022874, 0.9260672546163647, -2.896987476545908, -0.039028799671351325, -1.37198710900142},
    {0.7631438098655521, 0.1630465995622832, -1.5444738899132293, 0.16737629219833158, 1.3116504697102151, 1.9260521726890003, 1.0752697208008928, -1.405276398001312, 1.1152822039780819, 1.38324692680788, -0.5521469753316043, 1.424549963361124, 1.909291008058155, -1.6535673851995198, 1.5312767264381306, 0.4860032827184488, 0.43952472409715126, -0.7103076943914517, 0.5394176626605536, -1.2714517328551014, -0.7013014707528813, -2.493205999004823, -0.6087404160746008, -1.6482121221142223, 1.21536377133061, -0.7604704224771606, -1.255586797806151, -2.6490421357957277, 1.071972697358137, -0.9558196118864487, -0.2444915088693964, 2.1053610386509862},
    {-1.7599308375782945, 0.4022991150874459, 1.4907827977544839, -3.055022148140753, 1.85474573016834, -2.8532726503886745, 0.9017029136263057, -0.060274387626422135, -1.6029572031636974, 0.5790641243243712, -1.2545117266409367, -0.6972498517067142, -1.4122842171457044, -0.7644921061403464, 0.4788112971141947, 0.5056236280800798, -2.192055729768795, 0.22442766248236862, -1.0209460967745774, -0.20061143725858077, 1.939747733381935, -2.9368566372618408, 1.8935334543447957, -1.3244742048788272, 1.662234012245755, 1.1381380322922094, -2.7782020617972076, -2.3614980569978385, -0.1670077196720721, -0.06758476294528622, -1.4185821414969133, -2.6940340754034056},
    {1.9425947459316701, 1.448604084545053, -0.9121397422563646, 0.539597064635981, -0.3336744192565277, 1.1360974456421806, 0.47042203277439987, -2.0183258343649744, 1.1003606733569982, -2.1700484579045507, -1.6673392041055544, 0.9652861249298987, 1.0375922453811497, -0.8758427731767771, 2.1463951641624015, 2.3745758186958517, 0.04036083605457394, 0.4262457672709077, -2.543909465367639, -1.3264598516055282, -1.8753175806464213, -0.7279195847772145, -0.37415264292047734, 0.9101211791872118, -1.739218171029872, 1.1272184474654334, -0.14740455792024976, 0.9936634951851859, -1.9425876842933407, -0.15565153135644322, -1.990945070954905, 0.9856331882206142},
    {-0.5363225949092741, 0.8328517073427242, -0.8530478688768413, 0.822271111003131, 0.03169045474557774, 0.11143394049403549, -0.19954319571462042, -0.9115023908517722, -0.7970046274923789, -0.2837752954263258, 2.0665945684409213, 0.43825996806970335, -0.22057690070357538, 1.152076419952316, 2.7075702620057265, -0.719555144471024, 0.11352619038885549, -0.06656989497977174, -0.05657417866990275, -0.8778112024124263, 1.642602797031265, 0.33501392608851505, -0.8680509929944835, 1.9188930361833638, 0.8878660878037294, 0.9496799383733863, 0.9521692690046851, -0.40953181405039685, 1.9005829599051947, 0.984804124398129, 1.2054541946200699, -1.8520995535493308},
    {1.2559672139988052, 1.5039170589995101, -0.31327793346266963, -2.01712780076798, 1.3881986533622261, -0.8281285744181912, -0.015520910409841323, -0.1261092367101239, 1.6370532859445088, -0.18745958565772114, 1.1854507118431605, 1.0187615400573307, 0.4786824718712453, 2.1811246327160307, 1.6029324435356465, 1.725052772344438, -0.0033816891427264945, -1.5980322561453204, -1.442457278083246, -1.661895940715695, -1.3850721689049945, 0.2675345349966221, 0.35263328579659664, -1.9436991215477577, 0.5521059777227647, 0.30469526787228884, -2.021651385208424, 1.74140569147749, -0.3903210874805546, -0.9180406402263852, 1.1295422456160402, 1.656951108356054}
};

static const float b1[32] = {8.075303216781974, 6.842036455890812, 8.225498900542386, 7.748834961824879, 7.853258109950861, 8.110003016847745, 8.338721937448545, 8.162056304471246, 8.023105068236225, 8.366420484510044, 8.221346283507865, 8.632073633880388, 7.827475749927432, 7.72044274596526, 8.21546931192978, 8.01516824521682, 8.221381538281983, 8.158130917885549, 8.0315376029463, 8.194466950409142, 7.6381761219103295, 7.897429184512874, 7.18726470045429, 7.942314015508869, 8.063953058408602, 8.351715518085193, 8.304622735061738, 8.11267930519102, 8.51298279776234, 8.144677987475733, 8.12759146619816, 8.072671552216706};

static const float w2[32][16] = {
    {6.873054717305256, 5.4011743072487395, 7.0928609480728575, 1.2942319812802963, 6.0635520770408515, 6.99917052773769, 4.253373290394881, 6.7012879654784685, 7.257685443356145, 5.305496963779695, -0.9259487362469764, 5.575668325791102, 5.930038449317836, 4.338730942756703, 6.02968254898877, 6.302956886418197},
    {6.317755360705695, 5.910193718554177, 5.778082543852211, 0.6576120815358469, 5.4641894493261685, 5.967947469244237, 3.735384011484027, 6.996117041867312, 7.027410607800364, 5.535484864921813, -0.9630179111062098, 6.886375937542009, 5.967199290489573, 5.8845234394151404, 6.500316142374241, 6.136284764280369},
    {6.367356340227048, 6.048157183294707, 6.972914452938853, 0.7350455675450256, 5.419664940716575, 7.547621824030518, 3.707285461923977, 6.43123355598837, 6.041571796485888, 5.144210900291422, -0.5969746229094192, 6.547690511998457, 6.2259033418456085, 5.007749578914058, 5.928773164691355, 6.9445956985816295},
    {6.586487361962163, 5.912444908071316, 7.001744828209203, -0.2773756157151641, 5.064347737350983, 5.9096345718539895, 4.357922538254386, 5.755984972819783, 6.4820019005586555, 4.972056142694941, -0.15435638080552233, 5.82163886262305, 5.90819321650325, 5.449627094217362, 7.023268108293168, 6.705653066814641},
    {6.831194836422802, 5.97523606332624, 6.789290134725373, -0.5297092033999333, 5.898035280823831, 6.155983716706337, 4.7442434340539625, 6.5806644585908165, 6.493517491889523, 5.97863294786542, 0.7929744437223704, 6.517122579583335, 6.552599098997721, 5.994352948381144, 5.74046243123908, 7.089038689952848},
    {7.767476921755518, 7.166549859608936, 7.38328283285337, 0.44399997382149736, 6.323287308337947, 6.207911066035371, 3.6788192102584394, 6.033204867188567, 7.509197847793296, 5.704508521863725, -0.2719819155346052, 6.5909555663342045, 7.393822762888463, 4.710961290532078, 6.396340444054728, 7.168218098845727},
    {6.824200496079236, 6.448635691459692, 5.5051576646231135, 0.7004510089170987, 5.609053953396293, 6.746050375871728, 4.388435470254839, 6.279207386301634, 5.6654330777810955, 4.686482982632943, 0.8239211605800245, 6.8769781286999585, 5.9466712392280465, 4.451732824997023, 5.167485693509316, 7.018448414819198},
    {7.806402000297772, 5.828114215656967, 7.360373402194655, 0.36878481743675434, 5.726266306323188, 6.975069977047726, 4.871672686912688, 6.411229873868588, 7.309544415544305, 5.74682728476493, -1.1185926886919766, 6.413817318434819, 6.249701417569473, 5.892821559753321, 6.79246105641084, 7.717957108685787},
    {6.099811634233946, 6.647061541121941, 6.13857950921344, 1.1559782145556097, 5.119631552181102, 6.569170071857388, 3.9643889311067784, 5.941284314507942, 6.207401456054073, 4.947988683938047, 0.019518238999307668, 6.0683380820622626, 6.8746130974251605, 6.29102758425922, 5.832186743555742, 7.920761850073444},
    {6.389222537952159, 6.560433352721278, 7.155377913312141, -0.4144077028656508, 6.4765883782507325, 6.003388095383168, 4.495395666626567, 5.715811653255617, 7.034198133547978, 4.648693064214962, -1.1133097027260137, 6.4109263269530254, 7.266351992641908, 4.994471757617026, 6.016840095892278, 7.839024056221543},
    {6.935656247371575, 7.591314231747102, 7.794503773617355, -0.4286177769044265, 4.99932599706687, 8.034042979729445, 4.182983303090808, 7.101204279480778, 7.965298165116356, 5.046472207340222, 0.22282105556972465, 7.370415379006595, 6.911614432455406, 5.392014078824145, 6.419973533690838, 7.096519094701398},
    {7.90104200568578, 5.8000211093746215, 6.729234758878647, -0.37931917406885096, 5.82570722960318, 6.575537578119964, 5.553664662257035, 7.154097766402289, 7.351994120939045, 5.411045437869899, -1.022937874400103, 7.320741100321749, 7.127179033055322, 4.89082630081905, 6.505013979541116, 7.066000967546257},
    {7.501388800402235, 7.277215289651134, 7.664262211454467, -0.021574200285804826, 5.579968902204128, 6.3993418556664645, 3.6051530178545477, 6.489578688549859, 6.892000808506682, 5.885262720953309, -0.9482070773805703, 7.649641574610818, 7.034084328795062, 6.1130558739804615, 5.622787287299204, 6.28754704297357},
    {6.253060073440498, 6.714483738069609, 6.654285152980041, 0.2020118263155582, 5.478977854102192, 6.062453570803925, 4.687072933064198, 6.923241662214038, 6.038899256335517, 5.857894845689441, 0.2157442008615543, 6.558496259128541, 7.236012415682175, 5.700608259553105, 6.483044237299684, 7.073228833343326},
    {6.95870102762058, 6.880228859379698, 6.195202780727759, 0.8149669134611357, 5.9704911942099965, 6.34592567932791, 3.8694765025676903, 5.4309911867717044, 6.192292775691935, 5.610480877935689, 0.19714330735608118, 6.220487603573239, 6.5461978969528385, 5.741188083931757, 6.3467492855533285, 7.372362657536828},
    {7.749430066111503, 5.835709694461736, 6.0799163582650975, 0.05929296793455172, 5.804835018595013, 5.934834389154401, 5.119472310947078, 6.649414248978122, 6.9868806158835595, 5.3277696610705565, -0.2441088354855296, 6.101615083742804, 5.914310474840014, 5.830545009031675, 6.298013176469078, 6.3399778250673995},
    {7.169237693103696, 7.409337574717023, 7.502982874389889, -0.16673642932524219, 5.120305253816809, 7.5334252232266925, 4.25490392580049, 7.561549344470244, 6.04496179748111, 5.130886915108248, -0.34687846968829633, 6.01800129204951, 7.787983797421138, 5.65789910123501, 7.157065029434886, 6.895709106321506},
    {6.042943116121503, 6.24332227891297, 7.487954955706313, 0.1702623901450445, 5.638238507606769, 7.067380611483428, 4.81057246058108, 6.413933195606139, 7.325872801220138, 4.59576137526065, 0.40925763953901373, 7.294387064565097, 6.428484747281361, 4.683819905777104, 5.597283021841028, 6.492113879772465},
    {7.018275149391889, 7.0433678762743055, 6.401703527879495, 0.551013622316363, 5.991159709640982, 7.7223541877146475, 4.267276693092569, 6.935796151814216, 7.603881725231461, 5.509512899667882, 0.09535937193359177, 6.018553370098461, 5.9446082903716855, 5.8437263621853655, 5.921467384050589, 7.132348669384546},
    {6.672386880049449, 6.3490143924856595, 7.106485895640002, -0.23613000879765506, 5.783015046135235, 6.562801592270622, 3.852878744618346, 6.2042712423467465, 6.2793430643518775, 4.9861726619196425, -0.7060678884573828, 6.07004313589215, 7.51137903834474, 5.600566468508721, 6.835146467163319, 6.337757853735032},
    {6.8146291624453115, 6.9666797206568365, 6.33273457512927, 1.135958634542464, 6.1932000556209355, 7.0353318143379315, 3.4783519385851496, 6.512521721297307, 6.246378625659639, 4.618988774037286, 0.8817217904800494, 6.705503914416181, 6.739033103686151, 5.975899798759631, 5.63133814876451, 5.853224715228195},
    {7.702916541869738, 7.036813950107026, 6.448066369315469, 1.2288129311542653, 5.174114505797993, 6.783100368354781, 4.846853972652953, 7.082287726299869, 6.682279456952259, 5.724340330100682, 0.20696558803549714, 7.372401210690205, 7.376381549493064, 5.27694414933572, 6.1010672199319265, 7.192103589180137},
    {6.069766479613632, 6.970923375428324, 6.128278911527508, 1.0265153498127781, 5.433806350998981, 6.481461877638603, 3.204809040564133, 5.864292572655692, 5.825434487701098, 4.105630130447351, -0.02188217713148927, 6.37425682782198, 6.5434649051744715, 6.034966587360831, 6.455543639113362, 5.982524706937391},
    {6.003734103219664, 6.750737297332646, 5.7573941265873, 0.747426788752711, 5.7506158647915875, 7.5095333793627175, 4.23015160892889, 5.555384971178798, 7.0154276226942, 5.383046238410768, -0.025825702433147076, 6.803250889104793, 7.16608594458165, 6.2269659796427765, 5.325706492526337, 6.703212168583915},
    {6.83102987975518, 5.30063708430348, 5.667680879004115, 0.6944239544455281, 4.818826307490146, 7.290483980775283, 4.206579333644144, 6.216057568784074, 5.909458399362028, 5.116197365790459, 0.43518313943888737, 5.488636895421197, 5.875022066385945, 5.336846174186869, 6.797850012191721, 6.139930953487236},
    {7.632549984300798, 5.925150460155379, 6.983132125033954, 0.9941356192411044, 4.544109145402767, 6.795139310553817, 4.880414654351107, 5.827214510696744, 6.794558460578296, 5.2488010449361475, -0.7040896707686878, 7.0022389188766025, 6.309968717745627, 6.064738028328461, 6.208098606813465, 7.742737363108863},
    {7.411950702409361, 6.103132861678187, 6.7296755519846565, 1.1894342245286973, 5.758757118066981, 6.997278527146657, 5.240150367562671, 5.7575382957858965, 7.884815934255523, 4.6414466723930605, -0.5161434746773574, 6.9310520298639595, 7.4015919441153795, 6.338976389809284, 5.699119300210137, 7.806577020586964},
    {7.834710827528185, 7.300358433638071, 7.563619444471463, -0.3581174282380156, 6.410835611750677, 6.552340789322413, 3.9105626022719133, 5.658824445387193, 6.522989406188521, 4.451736124925147, -0.3831204663562114, 7.144012465499792, 7.413493105009706, 5.635146305470948, 5.821198538621107, 7.72892665192396},
    {7.5418431194348665, 6.10889279334513, 6.105304717058622, 1.4282883683899974, 4.91354858632285, 6.946201154942577, 3.8848609352337187, 5.77768268551107, 5.839694874341269, 4.787303058490474, 0.27716555503618073, 6.91077565494058, 6.772901127962553, 4.882631437575543, 7.033868482467035, 6.466134454790612},
    {7.1072867386987335, 7.000406876501656, 7.137473158844993, 0.6635514449243847, 5.5769300523154435, 7.054288850931718, 4.2810382259579365, 6.768139780057505, 6.01749049703091, 5.215291882024985, 0.6294639877302065, 7.332781365177112, 6.588604840686765, 5.218000898738329, 5.694301637447385, 7.77099490982795},
    {6.853041388307049, 6.384069503358565, 6.729388795042988, -0.2169201891122989, 6.4855011207437565, 7.458540630436348, 4.928866854236451, 6.868914331516589, 7.4452470444721595, 4.337144801832102, -0.597743095244187, 7.284670215291763, 6.502932678822307, 6.267191810135035, 5.607073559674629, 7.415551990350471},
    {7.468527290334697, 6.69420920051508, 6.292161872527856, 1.316276771002764, 5.89503671624234, 7.5194860701692825, 4.341592222432455, 5.652329882003747, 6.858080539202765, 5.230755863723954, -0.07191815846163022, 7.410075054204403, 7.160776847330173, 5.506923358918481, 6.287579990408572, 6.6184871651639865}
};

static const float b2[16] = {7.189406698167363, 6.687807857540234, 6.936301549396152, 0.8377912079369276, 6.1465770927629295, 7.231477997764093, 5.030084435441245, 6.902954887960794, 7.142860104044216, 5.714516885495725, 0.1660587035093576, 6.930650533695737, 7.116984874646964, 5.825226566171918, 6.846823438735324, 7.273053149836473};

static const float w3[16][12] = {
    {-5.135839937409849, -4.86186161579839, -4.682569317285941, -5.273273930529753, -4.329940170750189, -5.250117114379657, -5.519048642838256, -5.577727029881325, -4.939466937491855, -5.467111543083992, -5.420466205672406, -5.158999434566717},
    {-3.8900333604340913, -5.559084782443265, -4.866108389997481, -5.837524486921864, -4.320766344937544, -3.9027252235280177, -5.005759395900106, -4.391392965580428, -5.179391375184479, -3.8260901994897507, -4.738894276076155, -4.104319539202474},
    {-4.01310834516372, -4.9581588272765265, -4.74836078692094, -5.6358320482299105, -5.3068217989442585, -5.396290450948637, -4.591791525610383, -5.7261220983140895, -4.6748258802613485, -5.133618130843431, -4.902486372564312, -4.498984217481057},
    {-1.3639108174906083, -0.5846935812352069, -0.32724073581364993, -1.4812265194556842, -1.8418323567342565, -1.1571743823680543, -0.9711745466904775, -1.288306388775321, 0.6423829814767094, -0.4424838707020139, -0.5657133154869305, -1.0668877853276506},
    {-3.6760342594217494, -4.180194675107029, -3.4672326420495136, -3.2420173903733396, -4.916128690496374, -3.994602562225458, -4.2520819382432, -3.4670137628763333, -4.478456668031641, -4.552038756112368, -3.8377145359591136, -3.7266236963850186},
    {-5.4305571883831325, -4.353912099496482, -5.614028372475189, -5.290678728440172, -5.084855351898891, -4.695511525012801, -4.396024922687399, -5.044168844031298, -4.649608954103561, -5.239851761859188, -5.56573987753157, -5.3838699393821585},
    {-2.6827037875962145, -3.0084708042594666, -3.6557094513896136, -2.636748146009555, -3.451890577869439, -2.7211597281671787, -3.649643990594986, -2.961790009640122, -3.5132781400669293, -2.2308326740714794, -3.366417753062911, -2.5615939018602676},
    {-4.368700114983283, -4.248330607935948, -4.312403834378831, -4.201707382691303, -4.3843328419113075, -5.317990496471769, -4.859020882209869, -5.476563233447038, -5.443216174433316, -4.418688160494969, -4.3023389186288945, -5.382720701926321},
    {-5.198999732821421, -4.240967063981621, -5.190318282757877, -4.481992503973505, -5.251099265362524, -5.117454694615687, -4.406085059770185, -5.038124715817383, -5.655283532642169, -5.2039488181444185, -4.526664710217752, -4.183066762514501},
    {-4.930032724358556, -3.4994057719524987, -3.301367666252697, -4.920078288993751, -3.518281261026163, -3.3287227528115886, -3.241059650137884, -3.120544055984483, -3.6827013097226478, -4.815878627573493, -4.920688568388058, -4.665267960722949},
    {0.592991738844339, -0.45583944968165196, -0.6196703183230484, -0.5588822828318994, -0.8007466387740375, -0.5265786023052835, 0.500438011130201, 1.0795689919702374, -0.20269417638737236, -1.1722840018055511, 0.6783349499344478, 0.6650726732379092},
    {-5.301788500188733, -4.4760376816470595, -5.668553221253921, -4.046370939226114, -4.467989744524601, -4.18460064762347, -5.1108813152333505, -4.495351076065554, -4.027800177212051, -4.901196744585921, -4.913550441531293, -5.29783706295637},
    {-5.861414088369297, -5.614566475645497, -4.940166810801883, -4.057228598142036, -4.607678015302198, -5.533796560573509, -4.811711214332099, -4.021819576516111, -4.899094878140425, -3.6742854775861478, -3.708421600006476, -5.397794985758004},
    {-4.029175149374838, -3.482917020056235, -3.530808612296642, -4.216758810939322, -3.247998516911115, -3.717294509587976, -4.649489625956812, -3.5729105000455363, -3.5998357571886594, -4.674610296077661, -4.085174093846123, -5.012593717200241},
    {-4.383956448808224, -4.791973563532848, -4.104323342965063, -4.728232923909699, -5.175671477910416, -4.122151984100909, -4.382944446711801, -4.544272349402644, -4.526340823870437, -4.716764968154321, -4.172748178355595, -3.7921372078920887},
    {-4.405891739131933, -5.940471675304838, -5.161896616298147, -4.767609179357665, -5.325669144343878, -5.689896282131124, -4.712226207940825, -5.501239791825151, -4.393391073268974, -4.662121528697472, -5.1822373768369685, -4.327825814996813}
};

static const float b3[12] = {-3.08204155856172, -3.016016120856381, -2.7464242789396938, -3.195194825364954, -3.368466366958381, -3.4565980665515634, -3.671681969516819, -2.802326760567727, -2.462038822596847, -3.1796560464536663, -3.3505966708367927, -3.3101740517440374};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
