#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.6719695217213049, -1.1764894400858783, -0.954515603278272, -0.7410311495581803, -0.7950656404201825, 3.2828633752246588, -0.6102968395151551, -1.1954374818057574, 0.0912950711602361, 0.32645215359103635, -0.9868501900996848, -1.773732053451898, -0.07909690768116664, -0.19515547355036125, -0.7875000727728201, 1.4665746218652755, -0.20293245468260432, 0.4549017700692178, -1.049063358816895, -0.3793647802858784, -1.5347320825925912, 1.83278625072527, 1.537035161397675, -0.623003758524379, -0.09781330260780341, 1.9082014355481487, 0.6051797282203213, 0.3962760878198662, -0.1620896529361594, 0.06822806640348103, -1.6702370545598562, -0.10216227474295919, -0.138376726823657, -1.2914957582196571, 0.5701809220175825, -1.2679533366917177, -1.5710730052914503, 0.5615547511797792, -0.15683469200836164, -0.9693075733183835, -0.21798629718059237, -1.7399650841179306, 1.0649027103077624, -0.32015436355041677, -0.10414649798299365, -0.5712216509430593, 0.39550580230665344, -0.3652571572808356, 0.9713828069053511, -0.14192638915630854, 1.5463932224157748, -0.4789299115336405, 0.15501474951047078, 1.348433173377475, -1.3504793907155042, -0.9858171658729157, -1.3759463047576879, 0.909258737884064, -0.31748757629404767, 1.3352995517760282, 0.7162501515205286, -1.2319405138478763, 0.8028166939625414, 0.07582830123330359},
    {-0.9770973306003982, 0.7827729222350633, -1.0621898528561702, 1.1987559129755132, -0.6530829143199636, 1.447013447841131, -1.2823055799074636, -0.036165247431246945, 0.4428788925107983, -0.2918283755296424, -0.664727055127946, -0.501209695777004, 0.7033904970241549, -1.6291720665878195, -0.2775792141450134, 1.024805448720477, 0.7387386329050387, -0.9238031356628816, 1.0531811289347048, -0.05167892629772002, -0.37877303141711044, -1.0444612829192972, 1.786628236707031, 0.0830876702485123, 0.8599461895192076, -0.17384226377121925, -0.019273938979365187, -0.24798428681002216, -0.6383140559031459, -1.6916378790518998, -0.05403353532304596, 0.2526225735781763, 0.6644224418125327, -1.1121701452908224, -0.9611554789904235, 0.14879196615799517, -1.4069583917781405, -0.7478117652584023, 0.046984390083603916, -1.417066719614883, 1.014721453112642, 0.7810525700805513, 0.1387932983357986, 0.14911694541936463, -0.6401350179810695, -0.7344705582342124, 0.9767444364546541, -0.03262188568141364, 0.07351718459512606, 0.11183525669127475, -1.2658499909405727, 0.7325792770856792, -0.66471447992167, -1.1151206269712939, 0.4490050269403441, -1.7228632979600131, -1.5580398474942807, -0.2879608861985168, -0.363705276834886, -0.55975803708307, -1.1664688897599718, 1.0779400622011948, -1.7897831472670318, -1.224999231587292},
    {1.0916316354185913, 1.3758299279847404, -0.6542558669825423, 0.5882674851379975, -0.3677508760339923, -1.7340564486011938, 0.29543055484722874, 0.052553987150648115, 0.17876856161289414, 0.80999756928238, 0.15367401169308564, 1.1729824956779598, 1.3304783345644509, 1.5325590072778266, 0.05938828042777543, 1.8829353135959646, -0.06452573597537638, 0.648260162651725, 1.1197846468683668, 1.0171118542490876, 0.0810750116900111, 1.345711367157781, -0.5913038081058896, 1.4440733304502604, -0.8693730838099014, 1.8802879075289667, -0.18484198132671648, 0.29572108826007004, 0.32391547857699593, 0.4299228430983775, 0.46933461338778876, 1.4017414356215891, 1.7093436391866463, 0.3139466093580085, 0.3894489329754646, -0.5580357546072576, -0.24410768912693612, -1.0767794429985604, 1.4431318505407034, -1.2230800135980435, 1.9103137070925806, 0.9491629797483102, 1.1054538269688297, -0.6130384041212358, 1.0572634559674787, -0.3537435240085793, -1.375792786458297, 0.8720608009493128, 0.2375142694021745, 1.2695518297631558, -0.5597746643905727, -0.1383138124519938, 0.4317247353813238, -0.4449462354881131, 1.2262402113616908, -1.328465221873294, 1.1712104059603665, -0.6481414259227385, -0.6243498231229737, -0.6292438585961683, -0.0016796942768585402, 1.2497888668889225, 0.6046278556217426, 1.4468249329118554},
    {-0.6291604792418417, 0.8533622073092413, 0.4031336703127551, -1.4697981209592108, -0.8211308660788103, -0.20886452265890754, -0.7528768406573924, -0.4116947004432007, -0.7112914971098744, 2.380390457058016, -0.8503053264744218, 1.366599887710321, 0.9802165277685084, 1.4862809104208123, 0.6292785495235507, -0.9511746459130209, -0.9832667019908609, 0.05986620280666202, -1.5183601359881505, -0.4087761330275954, -0.1782337106272012, 2.1029541925359543, -0.09700905209745189, 1.8136831461891387, 1.1883628173874832, 0.07860470139171982, 0.25788221024405017, 1.5755446177291863, 1.1208593172451897, 0.5624472527019332, -0.6928223243003947, 0.37364542608116635, 0.6631937139653815, 1.6417484909103779, -1.0502457901225821, 1.1168339710799726, 0.767383052136263, 1.5233018003262786, -0.609616118090752, 0.5800260711967069, -0.1871661245595448, -1.3575682087376622, 0.04729387518426457, -0.18985557103629117, 0.9290112337441637, 0.05441200699116852, -0.3832160618299792, -0.7087405401212306, 1.0579097845877627, 0.022948835188214074, -0.2905989453229618, 0.28052363603799535, 0.6779726437208521, 0.1721966663967023, 0.6548888300879198, 0.45209757544463275, -2.014540686922049, 0.15271438433262538, 0.7221706698383669, 0.8202533622050607, -2.143005682450118, 0.6135468414420681, 0.29224248725574115, 0.572195501884128},
    {-1.0531622348943168, 0.17629335836607274, 2.8123811833614805, 0.2591258117325923, 1.2766386106454528, -0.08627808803136011, 0.9212405784925857, 0.06961574164825629, 0.9544550042045952, 1.1815365955999408, 0.9036838052252757, 0.9476639772732706, -0.9671529860618702, -0.7470375344907211, 1.054453307375952, 1.2671343021131822, -1.2479262629661758, 0.3899996510850224, -0.4636633672811079, 0.4903485185178418, 1.565074425829381, -2.4091308195367604, -0.523620458000376, -0.9129056327701883, -0.3659870369548382, 0.40754023100095854, 0.7245927972671637, 0.023544683346181924, -1.2223999046850347, -0.5792430251448863, 0.6441601520243749, 0.7482742709899208, 1.3124926802335417, 2.0116218029990636, -0.09890564338093942, 0.6422389357880111, -2.1146986325902826, 0.91099421465481, -0.8496957643934581, 1.2643935461489666, -0.7729164892943428, -2.165459598538382, 0.7235610776496715, 2.082203094816347, 0.855168213605549, 1.5101116774266679, 0.39201684108054524, -0.6362662214412178, 0.5263425063406058, 0.18534146617591923, 1.5078934493227498, 2.1805800485538485, -0.6059365588308215, -0.7807419883648141, 0.814280545279206, 0.35031310046129743, 1.2980814582301958, 0.4510724374439333, -1.6624062516535876, 0.6442273710533476, -1.3910658300964853, -0.2828590808687144, -0.9767114524985386, 1.675550418896867},
    {0.2859424421557772, 0.17441457129798632, 1.1284841861674757, -1.730094203583411, -0.24919032495935484, 1.3378425024168223, 0.6243770132731651, -0.33059974724609453, 0.5856033343546542, 0.3220894501130761, -0.24795311936672312, 0.2436477939106892, -1.0730663938987008, -0.6674068799780448, -0.20303170950723115, 1.9481766763440003, -0.13089589512927774, 0.06950293389221682, 0.6407294009118274, 0.008511546372057385, -1.2092290712046367, -1.9418849821803417, -0.6298329927727995, 1.3166128117388438, -0.13693928920608367, -0.452995754331322, -0.4132457928088459, -0.61915142953136, 1.1959934151872473, -0.029539915083353442, -0.45454617593674124, 2.5984302157176016, 0.877357083451777, -0.13160887816985117, 0.539562963237708, 0.37462379159426684, 0.7770110614348387, -1.3105946585607406, -1.0648607490541393, 0.697560211231012, 0.5013573771953697, 1.7464856471409846, 0.2245397022982536, 0.907631477475234, 0.3342559758320427, 0.338941467632235, -0.24183149314695299, -0.6687750735610811, -0.23373344073689512, 0.024987592909933614, -0.26685937332348775, 1.5179087882630833, 0.08783565905302312, 1.1125297228791555, 0.9639144917463328, -0.9490763223858878, 0.3451306864251581, -2.079850824691702, -1.9592526138534854, 0.8790173228253918, 1.4173127206195784, -0.5472982453140636, 1.4105687004608851, -0.7545445790910639},
    {0.45129864183634955, -0.6176689931920535, 0.722807734402364, -0.04135031929411912, -0.18767052276375887, -1.0593813132484955, 1.5636983702176963, -1.2052072050603453, 1.2182192095063609, 0.7029547540325001, -0.36071514963458523, -0.3614438505130786, 0.7048451975699496, -2.4810333456851996, 1.0187579705350995, -0.08744621263005656, -1.5553206360656315, -0.6641019637265141, 3.806927472869693, 0.9284605674921254, -0.25225652061749637, 0.3319265082078289, -0.8597175063812563, 0.47474020022463354, -1.2694718861085283, -0.6420979779553594, -0.35238754132071387, 0.7414770201402305, -0.4124849555612741, 0.6112494285018932, 1.2247773497397276, 0.007626595099244612, 1.1804430309236433, -0.2325775553302718, -1.0968628379842642, 1.3274155883406495, 0.8353819291194179, -0.8335641464079425, -1.242997522378109, -0.5773304966803077, -1.1641991665088132, 0.3395663169978912, 0.8504335584915855, 0.5094523411388439, -1.1021587828751074, -1.7049679874457213, -0.3825167060834473, 0.1688139772697116, 0.9239399246303078, -0.040485051153447006, -1.2710711627893188, 0.7593559996521233, 0.7429638686697945, -0.7781503127126912, 0.9904586208335174, -0.6762754008357855, -0.23975522667584243, -1.8710535706935139, 1.8221978225326885, -0.029458475524001215, 0.6571104200184928, -0.41881094550282455, 0.2701507212333702, 0.9181973032855009},
    {-0.8411868690720298, 0.5789082785163644, -0.11376382299371124, 0.9206058424365133, 0.7775586461534373, 0.0489331774236507, -0.06745935473700533, -1.014526028684135, -0.8842999240062346, -2.0799107851472782, -0.46479694550182654, 0.1257714961369331, -0.5755365510380054, 0.5249591201474006, -1.0349029015485252, 0.8223147866526992, -0.2378959130249873, -1.2268433992294758, -0.23832050831163556, 1.3587400369747928, 1.4149567818415703, 0.8527154476633463, 1.7833553552643004, 0.4398940431808912, 0.061910172989874765, 0.06576320103566485, 1.5594792720973605, -0.22789703406229025, 1.166252414322053, 0.30079286968266916, -0.16165610388103852, 0.4432057088054742, -0.6321862454298202, 0.011885851986604867, -0.018225107709740347, 0.10476495580407816, -0.9909934876538777, 0.3437819888410382, -0.5944411763274202, -0.5354546765057132, -2.648898071317338, 0.10253326367182894, -1.5694845267854831, -0.6290986304961332, 2.236045120980821, 0.3049972899160416, -1.089651847311277, 0.4427101873306213, 0.8941604283480064, -0.735889668119758, 0.6641889398797544, -0.1590631255825938, 0.5064702374191546, -0.11973298379844641, 0.3890999259084986, -0.2970762743292441, 0.19928985760057677, -0.7956221595906886, 1.6990413746210473, 1.1542036724832574, -0.6917485015293875, -1.487131036317162, 0.6069271913700798, -0.7627604935608019},
    {-0.1458174687642558, 0.4134662440785414, 1.8137082758964278, 1.156294692556396, -0.008785232952848923, -1.2061885676400852, -0.15672567512254623, 0.11048112973736281, -0.17702294341287106, 0.05685921377913848, -0.23224656804456154, -1.1513285882208435, -0.5054204367868949, -0.6972090572088492, -0.07151132937499823, 0.6279260685378834, -0.3575751707267154, 0.35382414080451613, -0.12939633964006805, 0.4724890100401485, 0.055541443292650455, -0.3208397816712899, 2.1812458928074037, -0.23262141734795372, -0.6914824122046539, 1.2522866092552618, -1.567620190445584, -0.8663904361555146, -0.9230061766998612, 1.2280817939570143, 0.5325811071751595, -0.10763201726108246, -0.5068406209260932, -0.7423811604365351, -0.8707461942000738, 0.5373168388817523, -0.47606725205616596, 1.2681851824707866, 1.214693539898962, -0.8991253755657864, 0.7880022467073722, 0.2333301257448537, -0.2259674839749514, 1.29363024724153, 0.06320634317905471, -1.1772300510422355, 0.05438858626130653, 0.5099078284107977, -0.3998676421999156, -1.2344079416735285, 0.1023707494347064, 0.4093834492622293, 0.8581714478202875, 1.683244339133023, -0.34039433266556696, 1.4036802438036642, -0.5612754186532813, -0.7517608329392697, -0.7113046002517583, 0.1829253641358808, -1.0150609809027584, -0.013382713396352783, -0.45370945046064626, -1.6514437650078524},
    {-0.9113988559023304, 0.9706706545075469, 0.5534511470151071, -0.704765079381513, 0.43349678373157086, 1.4114226606918412, 0.554857013382803, -0.5508567875169585, -0.2903113358147368, -0.017184061229639128, -1.502159077314902, -0.8924083016638319, 1.2539080588159386, -0.8985936327413674, 1.4539704218395555, 0.12691267785007324, -1.070637187262386, 0.0696998369799702, 0.24250280718401127, 1.171615368696926, 0.7428294142602931, 1.4436639316346682, 0.16299759848518405, 0.13294145661311393, -0.2728504124298049, 1.4141852551407752, 0.4830570171777784, 0.13934748434626235, -0.2702777133890733, -1.2189880275817948, -1.5477528343162903, -0.14770260620443754, 0.5218193536550494, 0.24198977378111913, -0.9746728703722652, 0.5050357450876864, -0.2694746488702275, -0.6951991281424171, 0.9018717146850153, -0.7359864290592237, 0.836187894440338, -1.2069764805777607, 1.7273970806581747, -0.9506195952724864, -0.7909676914736493, -0.9339133776387928, 0.3419902453918498, -0.2980030663468576, 1.1263932648394157, 1.8441538478474053, 0.25637960584853087, -1.1585728084663662, 0.9711247524616698, 0.06543301177721259, -0.08971679496345437, 1.7880520428053714, -1.1659047671441727, 0.5301239241124591, 2.1031205078710515, -0.748832159884632, -0.4919022419211578, -0.44542317495375133, -0.8266796366211399, -1.3788342649933338},
    {0.04258978955333258, -1.3764262178671407, -0.32592536619142337, -0.014830243526871381, -0.9450037169629444, 0.4607492662257712, 3.4244430989304835, 1.0845524886641251, 0.10045059403129845, 1.2572589874576867, -0.7644860676158384, -1.6981454316037077, -0.013502706107945236, -1.5918119230639736, 0.9247524225542333, -1.2082869091789732, 2.5455521933734095, 0.21003540532978318, -0.18392765338624073, 1.1230282407662346, -0.028297775778926976, 0.4520769792818639, 0.9239374372565522, -1.899821378935803, 0.7079896014452717, 0.989154470649233, 0.20706296269128954, 1.615239571305327, -0.6975395063864165, -0.3441131615053159, 1.0543092077530585, 0.9285105610210821, 0.1959996485190401, -0.16541804998784515, -2.2392210099388685, -2.127151267592789, 1.8553754458655716, 0.9747162425144419, 0.8056060970581783, -0.8672390965274922, 0.16431566537357936, 0.47030875682738094, -0.9626850522641454, 0.3303714197931105, 0.5437257771857821, -0.06140081683997077, 0.8140427656026196, -0.5173989427763405, 0.7853758967259842, -1.0845430771079132, -0.7763257843177911, -0.10516523387713116, 1.1472962026453544, -1.6156782556749723, 0.4694369077726034, 0.0598764002482924, -0.25309054629823224, 0.006736738606124013, -1.364784983174395, -0.48432081358219975, -0.40072082739808484, 0.31401793957075347, 1.5217409980290375, -0.2094499977236559},
    {-0.1969020518448278, 2.1267065285219333, 0.8862521179391784, -0.04999700174963371, -0.9542690235610096, -1.2731244921274532, -1.186397610782951, 1.770085769026289, 0.5113283695933005, -0.6168622548042842, 0.8629373602559808, 0.9044651684748234, -0.08714055253718274, -1.1304323085128243, 0.8151931741721508, -0.3686888880050277, -0.8192819172212628, 0.3695235089430936, 0.8052377671864182, -0.5155072357651284, -0.3650343381096034, -1.2795602120924867, -0.6706214058274603, 1.1485760736186534, -1.3073932966448372, -1.3775857479440479, 0.6670337221519591, -0.5949814591457957, 1.7802027534691087, -1.219100002663953, -1.3802651824714744, 0.22930175452585463, -0.15643996150994013, 0.41273205211965613, 0.016013725532748352, -0.9069735323797036, -0.4651764598944752, -1.704702676362725, -1.426675690931652, -0.6725553149721697, 1.070056876303939, 0.08962230491858393, -1.4507332967099342, -0.12896040268460904, 1.2793530836189653, -1.811818405213328, 0.09315397780141607, -0.44131962078860804, -1.2668997191114122, 0.6015193027200836, 0.19088466374193266, -1.7882707787490855, -0.4783401085675433, -0.3887760756620435, 0.3249844936696446, -0.12675776782079676, 1.4404340637615112, 0.9912353470009958, 1.2484064664712373, 0.4410301923680256, 2.225890164152449, 0.5415339934864507, 0.7465022178645625, 0.34702953687490723},
    {0.38497510151896785, -1.0169870157468321, -0.7182069883290733, 0.0649880753487123, -1.7228664186630922, -0.09429754851426439, -1.072517203017779, 0.9707810216353859, 1.5712335821768473, -0.8466493097607317, -1.1682062427460995, -0.2838423976715484, 1.8113311980275466, -2.0248441296632147, -0.5680254908492781, 0.29544800254148756, 0.42780051745169295, -0.48743616041036564, -0.7590817193985764, -1.172046396559437, -0.7497410074032343, -0.32311930791863097, 0.04350084890774524, 0.6862034972230502, -0.5767610821793766, -3.1159704169272495, -0.005126372955482599, 0.22071356708794312, -1.643965562199738, -0.21325818508621697, -0.5280201811693267, 0.34502037804831986, 1.8410080535978097, 0.12244869535494872, -0.2683442746566321, 1.1697264468567734, 0.5263495532775995, -0.9364697499017082, 0.4924482587212139, 0.9671087751444214, -0.6656035937522968, -2.0831522625005237, 0.0506695122624079, -0.7680304767721776, -1.1501504400467084, 0.7771128306447044, 0.284930653537253, 0.6411072922284472, -0.4967368389779303, 1.8349751364319882, -1.4790370838177156, 0.43510924384634553, 0.24648742886540906, 0.09110917005349602, -0.4006220454570073, -0.09357630306390424, -0.2004542950577878, 0.4578790760861907, 0.04104936643785467, 0.08503033155007887, -0.9349826266920096, -0.41793921425486774, -0.585714385190397, 1.8188969548302742},
    {1.096272787393596, -0.4700594658314361, -0.47046756583303195, -1.8000479166660168, -1.9908678702442437, -0.5523331524321206, -0.041736204980451524, -0.14683843036445876, -0.08325988554096654, -0.18590741467393376, 0.5933683360835881, 0.6870481147100695, -1.344529271935804, 2.043295178209288, 1.5848191849122177, 0.7772618386726319, -1.6750171792484605, -1.040136931921408, 0.9105143978848744, -1.1685425167790673, 0.3560222501841895, 1.6492127318692258, 0.0402897426075219, -0.23675505902313954, 0.08856876431014288, 1.520202293589654, -2.4238099844977654, -0.9722037262180222, -0.782430797790976, -0.3229373957397066, -1.91203842412913, 1.7157212170722806, -2.038292547401214, 0.47028408847873593, -1.8910338263397686, -1.4831816513971738, -2.013308502784878, 1.0280826843127273, 1.2278231411498899, 0.7519927786976263, -0.722051308167178, 1.2077711793415629, -0.8583425560249117, -0.2002239790673615, 2.3811911491252924, 1.2504336483421608, -0.014056020106280504, 1.9247386602247663, 0.7179301203165634, -0.06082588323344454, 0.26035062882676396, 1.422204623995038, -0.47077051705406514, -0.9940793600863996, -0.4923990896877414, -0.02534545254715661, 0.7036723708295104, -0.8285782405794673, -2.2501892010356617, -0.776774384464349, -1.7033614183565684, -0.8228970350450604, -0.23455895537307486, -0.936934915865497},
    {0.24834444203149758, 0.959263810520636, -0.6659868117007604, 1.816604520648611, 0.43138826660903407, -0.28238173626542684, -0.2214601118753371, 2.1816472514895384, 0.13404019485514065, 0.816364167934333, 0.8899765538592082, 0.03392579526450429, 0.8686427318542596, -1.8419357628889277, 0.49739440533597806, 0.9354567225845782, 0.48155750578022216, -1.2020888321721448, -1.5748330318613142, -0.9461609327784277, 1.1987928730313404, -1.828130729983787, 1.3939765907310817, -0.6451884027210323, -1.2509514348497672, -1.049510032335549, 0.4591189685908752, 1.436564262105011, 0.4990154384101115, -0.3561019258805132, 1.1297611972251123, 1.462117059407917, 0.33793778887880827, -0.0843987891856658, 1.442020115125358, -0.7401011502707407, -2.044590424878636, 1.3442756671474798, 0.11389117279096625, -0.19719762197739574, -0.9202873150368709, 3.7033330065576715, 0.797560183824319, 0.32788738694399694, -1.4507257591087805, -0.7699696695659797, -0.2832825225304723, 0.519259783539732, 0.003354975956957042, -2.3940673454107997, -0.24868511834842671, -1.1320041981775288, -0.34982381537686996, -0.351408068940589, -1.4284060940460015, 0.6358021914939428, -0.0734019743009139, -0.20059472002413886, 1.058445133184404, 0.37380345063069204, 1.437341186187525, -0.25630984604758034, -1.2928861398356928, -0.2831705310749791},
    {-0.07612606528918181, 1.439568121390765, -0.37745920048643483, -0.45691147451079506, -0.879111022342963, 1.5566908412828027, -1.3972456482956708, 1.7593802561414364, 0.9341701659650812, -0.7903118592066153, 1.7442037155197851, 0.2776876100809012, 0.5107327053042647, -0.8197000708582991, 0.8974731178394391, 0.5401322112287466, 0.1685038039978562, -1.0640693428451156, 0.976348556833032, -0.29201217773748755, -1.220710412766103, 0.7168796153909464, 2.206284393055636, -0.5587712932653545, -0.968704597145562, 0.9553132745049602, 1.6469030944523981, 0.26380281479735285, -0.02314729427232061, 1.2963074574106914, -0.6818740021023011, -1.4803082178769442, -0.8608865874200416, -0.07364642642125246, 0.21306697349934728, 1.2766672969511776, 0.2891817661959133, 0.3569444192551426, -1.0477782395977169, -1.0614272093655055, -0.7181650029644171, 0.27302350469887554, 0.9197289170180523, 0.9925692149234867, -0.20147134869121408, 1.0964274697712477, -0.18460166928156033, 0.5847681945166616, -0.7803883873301355, 1.7984211956307714, 0.16357386030759966, 0.18033548279370296, 0.1488624496812692, -1.4080582607540728, -1.2009449822047422, 0.028685414505829114, 1.0448581661063752, 0.5514834079782467, -2.692981961548626, 0.36155554473348234, 1.0281803463284627, -0.8799274049307886, 0.37095688263089505, 0.18117912617463386},
    {-0.3339621773183492, -0.21929551203787373, 1.5291395914294192, 1.126886575070394, -1.0689040847840627, -1.4399659353682248, -0.43624645864099476, -0.16518575896435042, 1.4433077567833827, -2.964935038958886, 0.5531236974904501, 0.0008402878452250689, 1.640373331437558, 0.057920703974304585, 0.6640701193724359, -0.6867241056835274, 1.4123381961375976, 0.04426224115730212, 1.4484925898497016, 1.7190475412307646, -1.2418847095506904, -0.5093578847721191, 1.259844017067542, 0.2082414959279992, 0.6011224636950302, 0.1458860376891165, 1.4530687702691696, 0.08433854696185225, 0.726818231730324, -0.4391590507455833, -1.1141199594058422, -0.9313428567022604, 0.8715065747769088, 1.4872461483027772, 0.20386644448444152, -0.636108020593053, 0.8101657184331872, 0.4468629607947209, -0.7245325727446091, -0.6061628424460462, -0.22309803552612065, 0.6543816184034064, 0.4202467664863327, 1.4171587021531562, -0.8383754834818626, 0.2312272619814481, -0.08555545942196119, 0.04789377234241539, -1.8378009408342624, -0.5039442339920005, 1.477377695722335, -0.13724430397574378, -1.3958125481846997, -0.12821597282176683, -0.5151587553576379, -1.7266540600430669, 0.5900868129908582, 2.1707657638638356, 0.5224593541316082, 1.2847936028224247, -0.7233766917743445, 1.22853294653946, -0.23719097042412368, -0.5581082157523206},
    {0.8253490547481185, 1.7596624918246182, 1.7204113817888473, 0.008843352608290275, -1.9864831079500838, -0.6981749444680517, -0.5958695708246821, -0.7419196398451814, 0.2896664386572592, -1.480992405910907, 1.2652658294058035, 0.8073363516016808, 1.5754590342157861, 0.2700624568420178, -0.5753523203200478, 0.7358213521571394, 0.20009317562463957, -0.010887891585519843, -0.3931792689211571, -0.347618712470071, 0.22943345666240528, 0.851953602919959, 0.013932724453992164, 0.08755684348530719, -0.6354598385240193, 0.17727323711590337, 1.3760357569537727, 1.2898038673065164, -1.411185845300616, -0.42507403696306456, 0.1786298822590896, 0.36053284775306405, -0.7901284345133137, -0.8235347869966375, -1.7575833629902633, 0.3895208745880532, 0.968376930658841, -1.5823946130739424, -0.8491509050965969, 0.7766159794629086, -0.23769440690158958, -2.5003832161116257, 0.9581687636108439, -0.35963451516988726, 1.1640456726359125, -0.7892833838419402, -0.958201344322982, 0.046039899219148736, 0.23095451563809818, -0.9553463966565003, 1.6337771596305335, 1.2674139121940937, 1.2594834390729261, -0.0480697000542773, -1.913858583842468, 1.3970032165880175, -0.011451525749147587, -0.6737364447113136, 0.03522812479680387, -1.2244226071289606, 0.9883147792148136, 0.5913678918537477, 0.24961589077828752, 0.5799692257967283},
    {1.6814500233262455, -0.1775498477237451, -1.515148604241508, 0.2298935204720945, 1.3173046425008836, -1.042344931634503, 0.1713644833865185, -0.7556803376486662, 1.730811983295443, 0.45427002127807303, 2.066712891191853, 0.2992403165272683, -0.5180410154151978, -0.9151783164221663, -1.1440204443130109, 0.85668657065713, 1.6946208922557864, -0.8627423363056411, -1.9800769463220234, 0.059247471018384894, 0.5072357995933751, -0.07410303754560733, 1.064609291731857, -0.6407065045667433, 0.0073048228500434695, 1.5273122407952582, 1.0615657021472322, -0.702731229112625, -0.987738424632871, -1.2461786545194393, 0.8564262412852455, 0.18066285457539324, 1.223234732550215, -0.31241625113725924, 0.8475501017056778, 0.12592426232198883, -0.7808078605915332, 1.7018618055583892, -0.025329422886704797, -1.0915039552379517, -0.944643370974193, 0.6688653727091822, -0.9715851280269627, -0.5268455671361667, -0.6907067306344414, 1.5580498187791483, -0.8470561662979088, -0.59060927369137, 0.9596026231242835, 0.7604650700384415, -0.6976145013828882, 1.2367602957512118, 0.4514173012491137, -0.2500422942191189, 0.24122393367231926, -0.378787017151066, -1.9061765852926134, 0.5232299864694088, -0.23438575808383086, -0.1011046615613, -0.18059604602805382, 0.7514117682285308, 0.8699848046931351, -0.8270831146133785},
    {-0.249914021066432, -0.24557803457107216, -0.17731974136025622, -0.8554007343084995, 0.30488512165338977, -0.04901860536315275, -1.3344723118061923, 0.5000782015884505, -1.5199447164987734, -0.6255038078336985, 0.3969831583042522, -1.6469072654861752, -0.5113130561268228, -0.6498440947477498, 0.05489389263697573, -1.5378090673853844, -0.6670206087890631, -1.7791805394674838, 0.24441492642287008, -0.784961870091025, -0.28141625378964624, -0.08543892793679891, -0.2931137250519396, 0.2577484201402463, 0.2577913987003097, -0.5166228651960628, 0.9431926499349031, -0.12378467038314293, 2.603029629710004, 0.5902165019201623, 0.5715218959087457, -0.5378993641021204, 0.24910678905891176, -0.5752303207538609, -0.07957553937856447, -1.7562742956473862, -1.057144063752414, -0.6820244705648659, 2.822762051914051, -0.19363621576536327, 0.190167851936112, -0.9430580962228473, -1.4796288560701336, -0.1943504795605504, -0.7017430004660784, 0.8474704435911214, 1.4213205847838057, 0.8002246344185252, 1.9094851172289435, -0.3178834883462122, 0.1962773198966622, 1.5089736537328622, -1.0403616509336595, -0.5030128878946041, 1.303216785173902, -0.680861858923869, 0.8903439520465981, -1.1487363645237405, 0.9717603933157335, 1.2448221138091222, -0.7683191463092927, -0.788581270444953, -0.5725805960397671, 0.2387407608561921},
    {-0.5526612042394913, 1.7226779701512573, 0.06725592335703519, -0.9419919681341792, -0.5320425735394079, -0.07043437256771622, -1.396346632349911, 0.8251179588058597, 1.2850964586822613, 0.15446471935113598, -0.14473748999338876, -1.2211281050649807, -2.1760131261298947, 0.09360132762301679, 0.9243117545829457, 0.30440641796105916, -0.08030548271243007, 0.2054167649866242, -0.4735045250994653, -0.6647069553453828, 0.10573265234286185, 1.0948548351298992, -0.07122128810838547, -0.7698521234329702, 0.4517959348809905, -1.0920988666684697, 0.630635129210006, 0.4527967708134521, 0.047930231797238404, 1.6031039460585927, -0.2826543576939303, -0.31037355538813416, -0.3283316033838084, 1.8701308540878723, -1.0909084345105737, 0.6659167474838154, 1.1509797306993534, 1.3123790212225908, 0.6406629487309118, 0.1898530399165828, 0.08046358211880923, 0.3994240355092541, 1.48536640643365, 0.6758754434148693, 0.6796223428495581, -0.5491629176009588, -0.5569147244270239, -1.5417193893519279, -1.0127480425427824, -1.6213186767145333, 0.8662016922946645, -0.12667116064061357, -0.4304395306474732, -0.25559395758706266, -0.02256666610998248, 0.5983522151457309, -0.6515578064004345, -0.08488819469027302, -0.6816338962080952, -0.1521872833273381, 1.4501560988402056, 1.2814697003757478, 1.5276195704923872, -2.0932236676538953},
    {-0.3260603468855365, 0.0002097222934254274, 0.1386464814400787, 1.4308796134704815, -0.35481831095924316, -1.364830813096147, 1.393596287982823, -0.06944473681434747, -0.39449321968047013, -0.5714639439633336, 0.46490643293272294, -1.7453062466299927, -1.773936557667472, -0.33911072471156384, 0.2799840832272968, -1.7554798305964812, 1.3818734171359446, -0.10586570610877473, 1.0665148787371777, 0.6414845200247039, 0.12033455967067476, 1.7223944426012092, 0.46227502435465634, -1.2040017771986098, -0.31600354346030235, 0.7753383683346077, 0.2768411130199517, -1.8437691014687043, -0.04405114771414667, -0.9901736283807836, -1.3420654204212636, 0.3984106024452292, -1.4167567506689038, 0.7739313416508473, -0.24122569515339362, -2.160449833187536, 1.9120880731721266, 0.39748103927055317, 1.603759436103034, 0.7064721146033363, -0.44323782591817684, -1.5946632200019306, -0.14804742098135795, -0.5537830004708711, -1.3715262216347015, -0.2543639175303396, 1.7617513113022718, -1.3383931391967216, -0.9248266452679831, -0.48803639110472297, 2.33495507883587, -1.250011397681784, -1.0734175768162573, 1.7222091855976525, -1.1577415161374183, -1.162877384847079, -1.3132426866418554, -1.9640424019252463, -0.014141854017143003, 1.962839945903779, -0.6349313686256878, 1.047990887606843, -1.0484480866607848, 0.8898983150009155},
    {0.4996179251686526, -0.9906826994137521, 0.046407293914633815, -0.1151481002793412, -1.5180391754003921, -0.24206854109085374, 0.5937047803948152, 1.1525455684872723, 0.2469816058068729, -1.8817939527964629, -0.2449349817812261, 0.1048235116374964, 0.48328957372131354, 0.9488875274191176, 0.45191356468673927, -1.0249958011548952, -0.46299228278743637, 0.7248370271230303, 1.7063516913539276, -0.43740327273907464, -0.44277547152856744, -0.3823717095690953, 0.49078111677343633, 0.08831135480774929, -0.49298597960443236, 0.6794956073404305, 1.2983635675471314, -0.5061326086651976, -0.9764273382045027, 1.5678211474104555, 0.8500805229788357, -0.03149026768938781, -0.896649531179166, -1.2447395482059014, -0.9050436501140452, -1.2417906271521866, 0.747837637859763, 0.30148867136498547, 1.280694202406832, -1.9609060318765024, -0.4626683226617646, -0.5334923603245237, 0.12331690579512486, -0.20458269826643213, 0.7753422685497985, -1.8815341997229418, 1.1197327281952272, 1.0842005266619086, -1.1402083595714625, 2.0732941779142853, -1.8099328772190397, -1.236154298517047, 1.159443810029953, -0.3163498409122835, -1.1508400161547643, -1.0217032737318226, 0.5296709085263215, -0.5825940756913213, 1.251801019033084, 1.3117525350789223, 0.1362570842106515, -0.4864102476321063, 0.16129400241915537, -0.47199151102337406},
    {0.6756960819147391, -0.7742974365743832, -0.11683969230418859, -0.4955943252945601, -1.5517627320985985, -1.5325132164047672, -0.25387035489443466, 0.5760994638787835, -0.4082138643990408, 1.3367706523874725, -0.9391613256949577, 1.1796977540915203, 0.5789574885641564, -0.038466045188326733, -0.7925466352973856, 0.15224973501904396, 0.0951003382292943, 0.07247076848040221, -0.4928561516872174, -0.09410981027968389, 0.3472885324440382, -0.46181030964768965, -2.4659695780489215, 1.1178795133860364, 0.38439423164704833, -0.7809198700843144, -0.9878118486289664, -1.535313307397197, 1.0661682480638048, 0.8747353376903325, -0.5563639658998469, -0.347085790520372, 0.9890271663105749, -0.9871185678424711, -0.5529500920006961, 0.9873998502433936, 0.9237802953118129, 0.20197065239374015, 1.4074641363955704, 0.31644701624329763, -1.7462871661408192, -1.0985349581165762, -0.23747023370698694, -0.22923727465032087, -0.7083885651770421, 1.8059881862131946, -0.27404064111250703, -1.3348054254061277, 0.4044727294406248, 2.206036006258364, -0.23894381842624293, 0.3116023241915196, 0.8529598667384266, -0.48913038289923794, -1.4472664029378561, 0.7049849774918666, 1.3866146754473405, 0.862781289324785, 0.4192205416906312, 2.1235831000149763, -1.7862323019853712, -1.2762673583718147, 0.004408051359435774, -0.26331205927430495},
    {-0.08922467454627049, 0.9854058282254408, 1.1375925682661863, 0.40393417142761273, 0.03992777661914026, 0.6729678865997144, 0.5221762662744579, -0.8846339870570283, 0.3818169727566163, -1.6172963486349605, -0.4126823345041702, -0.9890228605929282, -0.5744638598194249, -0.1993706588666951, -1.3076377533963497, 0.3141110679486104, 0.027191059858345114, -0.5745014406933926, 0.23389752230176913, -0.34804082642860473, 0.9292730710073411, -0.30985351550642865, -1.7423082061347235, -0.5296779219483914, 0.2913059856416545, 1.126921914046372, 0.4991960683661861, -1.3071102763205198, -0.928422164687074, 1.4560600434758013, 0.17899074626067765, 1.2029460603876088, -1.2286374237151414, -0.6084365001346203, -3.135578870556882, 0.05939707532831868, 0.04177039567351312, 1.0927209846008148, -0.4571049206050442, -0.0882632191793713, 1.1864417435275816, 1.195286439205806, -0.18666047419120488, -2.1615280346049874, 1.0856082857597253, -0.5867115843836234, -0.37691603135039103, -0.095164011502198, 1.2661430723035683, -0.5505216510647634, 1.390622023846626, 2.5052330550911917, -0.5551695528343706, -0.016303212796990253, -0.13304539779893335, 0.7974668598876351, -0.43915506257567094, 0.8544349365568552, 1.9862567146882046, -1.0403538995619321, -0.5647887963168436, 0.6056592665323648, 2.2041136266172314, -0.005895263409631188},
    {0.769720912648077, 0.1790086967806871, 0.5925367740593229, -0.3837767146419487, -0.3848208063714681, -1.4124226192304354, -0.28732791138688146, -0.10233378593811591, -0.08745319743037286, -0.8385581396994065, -0.1382355322876039, 0.48438886459042957, 0.36615970319859714, -1.1336001733805718, -0.3319675559799645, -0.5268869962009975, 1.331816789255705, -1.4540425841364812, -0.1336929678581227, -0.6853774285878431, 1.029783458463106, 0.7222841273109688, -0.8896365623987569, -1.050276257858355, -1.788895750935751, -0.5807311132837236, -0.43273333922053764, 0.8867679148419987, -1.4791433832083611, -1.6278968487512997, -1.2869912436836444, 0.8591772984986082, 2.020227756846739, -0.6633193750838898, -0.1863903000344318, 0.9152883488012563, 1.4554639123189383, 0.7034002933027035, 1.4132454896718585, -0.5329853421741233, 1.301001809446768, 0.17727456643837702, -0.6764256639657409, -0.6271916306456568, -0.19151660166879364, -0.6087516325825789, -1.3479381342472563, -0.06498259620127278, -2.096220426374938, 0.09055370718573916, 0.6956706484101598, -0.28931561165561376, 0.09733064689960981, -0.5019160960993833, -0.13858195243894017, 1.0939242518052699, -0.5907453806342614, 1.7728510678562128, -0.1298841200963326, -0.8905115072630784, 0.8668880726516696, 0.37130699017875446, -0.5445563564405304, -1.3173211107570553},
    {0.6060367156024536, 1.1635721955577876, -0.8496510828010772, 0.33724928087880673, 1.8019515457763553, 0.5731705693157977, -1.5439029539680544, 2.013345783298099, 0.541975739684555, -1.2251067532327289, 1.7263747605787896, 0.3394909345525557, 0.0027249723646189158, 2.53279603270215, -1.08201910634793, 1.206650537927584, 0.791500634297294, 1.8523437624938281, 0.5130820300271308, -0.8500534914425497, -0.39817819065842547, -0.4073490776656648, -0.353003094677219, -1.223888081429385, -0.07800564540675452, -0.1915439134292492, 0.5969862162062739, -2.2368887132957904, 0.641012381439901, -0.9853367541937638, -1.7854021777988744, -0.12781960968466693, 1.0406420226210529, -0.42774790409846497, -1.7613851100517692, 0.7235389703478847, -0.21010036041929187, 1.4864856695018733, 1.3725618441421337, -0.5908694784943461, 0.23113689158435824, -0.2745795984246899, -0.332494123247341, -0.854779395150189, -2.0910070369769307, 0.5780232008400709, 0.36571150812146463, 0.3528198942808933, -2.2500578493363825, -2.6146768728101963, -0.8846403314731822, -0.0036438081946085048, -0.4522057007689552, 0.3396519471522855, -0.2460751515825296, -0.785579524031213, 1.131676172053312, 1.3208232049302817, -0.4660104985818261, -0.7891472771721083, -0.6897919653678082, -0.9394725665606629, -1.9614067268734812, -0.8042849529960069},
    {1.54126926203674, 0.028980910469369365, -0.4232969401772853, -1.1205795637939606, -0.6494829098811654, -0.49650190589939946, 0.7352840882197795, 0.5635479428465887, -0.5836652528619894, 1.5010251361786084, -0.7086871267530533, 0.23545722882243153, -0.3569769351496794, 2.0329586888960325, -0.3227410666132171, 0.25668717268463176, 0.0538923402906636, -0.38305877135647837, -1.46841143658701, 0.26478270978247015, 0.5335499439844048, -1.9351223173354226, -0.40943571850211335, -0.0909352279065656, -0.613353321037209, 0.7724106984408972, 1.2307268111521668, -0.2616301035344243, 0.7885509650704544, -0.6692277971269569, -1.3579205579438802, -0.22027130922439495, -0.7435536034534461, 0.6954040802178248, 0.8988761188133623, -0.9020498458746833, -0.1047370337955183, 2.389148674478254, 2.422542944714885, 0.8077405420743129, -1.1249166519171916, -0.2354859805312154, -0.26768657661691975, -1.2990732859415304, -1.8991028473662994, -1.923652773221956, -1.5583216550899488, -1.2221404744607673, -0.9286531304986263, 1.260285482683283, 0.3298045749884398, -0.1913611019693983, -0.42192395979395286, -0.923064172178228, 0.15805160622134834, -1.1394098498869774, -1.0078122413554476, -1.6634562308756886, -0.544767170511406, -1.1722593096506135, 0.24669296453816564, -0.29280222686035745, 0.12006972732374042, -0.8308869467116934},
    {0.02088389548146752, 0.09829073155552795, -0.5054853622518298, 0.13992013632934855, 0.5375998270070191, -0.5472114020763049, -1.0447637788968431, -1.905490272715379, -0.8393916593023028, -2.443387080471443, 1.7205468268584958, 2.9759020313366484, -1.154196546798141, -0.23506936395314953, 1.081792133899647, 0.592025995712252, -0.5898499976857521, 0.6890275229879961, 1.1134926746581209, -1.0541866998732077, 0.12288536179064648, -1.0479169779830875, -1.189057501237219, 0.9107579371807607, -0.7093352180057899, -1.4583590334444982, -0.6878546640637128, 1.8484807264537089, -0.37901591430967635, 1.2151842879846795, -0.7397692715087105, -0.7306151400599069, 0.9345290166373038, -0.7445145268593478, 0.7292093743693958, -2.012707419516043, -0.7099801118330539, -0.1297111749170715, 1.055158713346607, -0.14008603926990654, -0.12165311706418726, -0.025771695926546705, -2.9423459849493465, -0.6363515694444338, 0.1037891525459904, 0.9354764458876661, 1.1467954895692964, 1.2877295534428896, 0.37383970475760714, -0.041047500228064665, 1.8559563161338675, 0.6389482624588515, -0.3552146496295336, -0.18105506277701508, 0.41497745911998646, -0.09951752325265661, 1.810649185935255, 0.3670750512125102, 1.1620948489285274, 2.2679796403396413, -1.5212280311527209, -0.08694519672713788, -0.051664286857684885, 0.7613773378750668},
    {1.0040549168135855, -1.2995379235930378, -0.16998732050407123, 0.8406811138296222, -0.038123953364981956, 0.18600306930886493, -0.06667008307911729, -0.575454330094798, 1.7246686064178751, -0.31331020708415014, 0.5036327789284359, 0.19018431448906775, 0.7913488267776088, -0.3108035277394029, 0.6437989785239568, -0.18832495451245873, -0.029171098776482444, 0.9837707811630287, 0.46560374644037056, 1.5684790238222084, 0.7281482976115689, 0.010144908166417567, -0.7410935411494463, -0.36587583116619876, 1.1923993013908363, 1.4656537461000183, 0.6872804419995755, 1.7704304943509326, 1.6910805159718518, -1.2253609371094443, -0.6948493343040207, -0.6460535876948046, -1.5205368649945472, -1.4352538747651087, -0.9568092714501822, 3.316326628340185, 0.39569768996617954, -0.2513122327616545, -0.6097938769887504, 0.6659760502077995, 1.0893641926065567, 0.6105505689391062, 0.2446939927385813, 1.3368878650225182, -0.7073828986465476, 0.4770424354375473, -0.9383748494532069, 2.5863881463717657, 0.2833104160221192, 0.0895240713102914, 0.20956698540709848, -1.8664186806113148, -1.9206887503330212, -1.0659234816107583, 3.0817970172154623, 0.7941143133345198, 2.862767377613906, 0.039188613950995474, -1.903944225012914, -0.020745339721864636, 0.8223153039798006, -0.4584844682688352, 0.5843870633792276, -1.79795379371366},
    {-1.7419163940210511, -1.6496108700100862, -1.1997108163338992, 0.808393171587985, 0.21834036387705405, 1.517108037938954, -1.5249484394237476, 1.58871742692585, 1.8635980245201382, -0.9572290398924077, 0.6329974601098837, -1.0427211074025426, -0.8399047524978747, -0.24256941694364245, 0.31215704101359715, 0.07395894532337409, 0.22286232572962592, 0.2959780901448703, 0.07910715159423753, -1.804342539685811, -0.6956332622569373, 1.6064349481462443, -0.5719146547110123, 1.8644200313713082, -1.119370097640063, -0.9067471973710816, -0.8071303325386363, 0.707391899405089, 0.33571807315219593, -0.180934516882382, 1.5355928868955928, -1.1766009122711172, 0.668487783046171, -1.3905673968121497, -0.7943480840528074, 0.019405700050064294, 1.5338557197153593, -0.4198045850202566, 0.8645909735205902, 1.2388528959275467, 0.2893255646494866, 0.41937211742469593, 1.4259938809627417, 0.6215412796085152, 1.2800960912862358, 0.34977727880743564, 0.7574339381666184, 0.14481906408715828, 0.03480966448237164, -1.0213351070856265, -1.4101301698064461, -1.8142122554132878, 0.43808547783451474, -0.05256059791567938, 0.497324585090719, -0.8254922335352436, -1.6699208477172656, 0.8640330443589652, -0.9577979808418104, -1.1816867352869764, -2.2081111506451467, -0.10019669325002557, 1.4878902080436611, -1.0487189032120343},
    {1.0111287560134523, 1.6913451813765077, 0.19458831550062775, 0.304427335969185, -0.37018852409111397, -0.03806235774943306, -0.5332795279165795, 0.878229145854626, -0.8710304615982083, -1.0804166755084996, 0.28797334268862446, -1.0625497950746612, -0.7568704672392561, 0.3557466698297861, -0.6449429261229543, -2.3905619195938246, 0.7955601522624007, -0.40165079242611756, -1.2512345747010212, -0.794128717200732, -0.10084613087442845, 0.1317206292886974, -1.756072522370167, 1.003412654331735, 1.530828751691576, 0.10345032273529828, -0.45381250907706633, 0.5013104364212044, 0.7705264520088295, 1.6540536618912627, -1.1850777984369667, -0.9688890366602277, -0.4314472995401767, 0.2986086712591014, -0.7902430706056148, 0.0066625666044857305, -0.26087879059569435, 0.24204340687458697, -0.009554711122374443, 1.0276145047106586, -0.004291256411901579, 1.50632028539957, 0.173462660671142, 1.3295243872956253, -2.13450406513658, -1.9430014912863072, 0.3594729089456994, -1.1208913527541606, 0.914520058987427, -0.0646736892183415, -0.3538591816757756, 1.823062279684006, -1.1465895115672577, -0.02793507656112709, 0.42087710217281576, 1.7618142698407413, 0.9932943975515607, 1.4052529120553687, 0.31947969925133796, 0.7903706339481863, -1.0933049869421692, 1.9366675220444285, 0.03232787578841791, -2.09910394655972},
    {0.22261248652089058, -0.23164371328652594, 1.0998856540893256, -0.12997717740933473, 0.174807356909944, -0.09910722642134427, -0.31327117256336734, 2.0595771869436525, -1.1845101168474066, -0.18110137479549326, -0.4223524755405293, -1.0543378697096393, -0.051683492235673756, -0.17903778071570298, 1.3607974012776325, -0.4937405514937166, -1.1440064515845572, 0.4974626145254461, 1.2102010267106056, -0.64234857503114, -0.8653713555215855, 0.09794402223359848, 0.8250430773613159, 0.5222758344012789, -0.557353127352858, -1.0252914605208963, 0.36059444311062794, 0.12804750111860982, 1.0719173390327779, -0.5392128196896151, -1.5181329353277837, 0.9261608559256673, 1.144737525128539, -0.438208397894907, -0.8029238064412979, -0.7900877722151883, -0.35287869627156554, -1.5498052419995558, 0.0248756334445417, -0.39377557573519567, -0.5722139942973914, 0.7195305246478334, -0.031320692899666706, 0.061361363929287885, 0.5191123996291449, 1.4905261593981443, 0.17752121517774322, -0.49108024603575934, -0.15063241410212178, -1.7228241933590724, 0.18479761827754132, 0.7053532132872572, -0.6682228509191666, 0.6730715799714139, -0.46863771062725607, 0.7541355559851277, 1.119830283356934, -1.5565226386050361, -0.18331494391038186, 0.0692631297872814, 0.599423873901526, -1.239654039094044, -1.2918170569298335, -1.5959408356506894},
    {-0.32342675995269976, 0.7732017688939803, 1.1633804535205254, -0.5613594205029577, 1.155783924108509, -1.439470663127486, 0.9265928037951466, 0.0185735806385577, -0.5880599293768736, -1.3111810270903443, 0.3897238549881822, 1.7661697958290417, -0.7537743932797254, -0.6491547311339383, -2.6128664235674233, 0.7814492192144096, -1.0775006663472595, -1.2168776247024011, 0.6838459189047112, 0.4921156242341858, 0.8681743425016514, -0.08549227776789495, 2.827989239620225, -0.9672072178390378, 1.2515613606018057, 1.0870961252747662, -0.8152119345419796, -0.6503933290034194, -2.4844476672129026, 1.7169882927909694, -1.776041023805348, -0.8359280082235668, -1.1002923366805866, 0.41440889470697073, -1.9595683690629193, -0.18462179460531095, -1.8734406619917028, 1.84197770520248, 0.9533060821524784, -0.17581722425044602, 0.23733014197555546, 0.5239553287147144, 0.5046912957363517, 0.8826275054877004, -0.04282896378910936, 1.506419137783988, -0.4891000541754975, -0.40631759192568967, -0.5556054094102202, 1.4462551008516684, -0.5195289287578512, 0.34915588938500136, 0.8661435587437963, 1.5951712480475229, -1.097768365788701, 0.2630258930858771, 1.109924569726209, -0.6751760082894386, -0.5548103754391465, 1.8564602723900248, -0.04305866560141545, -0.4720340654870841, 1.2552895639834658, 1.0171601127358736},
    {1.0296848561484813, -0.5852898260156153, 0.35878586021358316, 0.03995081319946434, 0.4337131944702193, 0.5534392516945773, 0.21688855510284885, 1.541619160891548, -0.7050192099910162, 0.16977916694986842, 0.21856595514430133, -0.6308948449492, 1.2348394699189644, 1.0493746462234286, 1.4448561042970705, -0.1272468605092129, -0.25540638673717, -0.5767230721266159, -1.4757984362046053, -0.5903134747640819, 0.9770289553147188, 0.9284822133257711, -0.24564505062029718, -0.011780917368319587, -1.3363650661029363, 0.12486668142229405, -1.073260299232983, -1.679345380887603, 1.5890466993352221, -1.5248739084471226, 1.191293776185772, -0.06181366072599997, 1.0886873658620144, -1.1585462968396238, -0.7205423122817631, -1.7570048418088873, -0.9917478904102545, 1.7270976658523471, -0.45483332197011705, 1.6077112616338936, -1.4987517740849527, -0.894411521618203, -0.0056418157153156, -0.34984184441421884, 1.3074259586053183, 1.689126511056495, 0.01734940385226045, -1.0786349962101804, -1.1379291779840572, 1.2520179204802153, 0.0008535818950763666, 0.1666507295941044, 0.11848009545202642, -1.5359210868761746, -1.4035053684553478, -0.9408022476605341, -1.0214613262074794, 0.3889523854033539, -0.7393227812764593, 0.23609997792497572, 0.8837957534588812, 1.2443591326917793, -0.047332185371656364, -1.3342200824234527},
    {-0.1639990831259872, -0.7630743365292162, -0.9444760306354536, 2.212845549246344, 0.5129990701736158, 1.3743051442698841, 0.8672388055783902, -0.4202402716824567, -1.488445514290901, -0.08850195978098617, 1.673644151263069, -0.04169129173623528, 0.4022012983833213, 0.7149852547463643, 0.7430266231465555, -0.1701922306838926, -1.022726015041024, -0.10448736869712535, -0.5985157039510719, 1.8667399057734582, 0.18613996562370608, 1.4807119608186223, 1.3106015847127255, 1.1446543533380442, -0.18490107768330016, 1.557894344809346, 1.2334531859335447, 0.0045547265415596715, 0.9262984105922435, 0.3584440206177811, -2.1378658826079224, 0.43858815600731305, 0.19456946086237065, 0.018895994106850597, 0.017414225234460807, -1.015327071351812, 0.006385278069402034, 0.7395779690535356, 0.09688341908097262, -0.6997697138263429, -0.3767478094708393, 0.9019007559151182, -0.9559015983233775, 0.598709194932581, -0.17915708274967967, -0.70894670381054, 0.11582504709799307, 2.218109930584112, -1.0217909369563523, -0.28123448192781647, 1.3040516233402697, 1.75127776323673, -1.2968955577762684, -1.2697534037689486, -0.7298088276456429, -1.0314517400966114, -0.4800325919824352, -0.4639339615194406, 0.5947240493443579, 0.07545116909531949, 1.4729984780328333, 2.25312299383956, -1.8788819881881202, -1.0846318788758558},
    {0.31545283790029216, 2.202196460626517, -0.0013603131044515077, -1.443055643896207, 0.8876234475751908, 0.4856705858273705, -0.1574883995092951, 0.045773851443529086, -1.9530015307493669, 0.8617348897097237, 1.2925694695891974, -1.7308198795657015, 1.1000783371796266, 0.6388739302259104, -0.6081857017325993, -0.11133672899261732, 2.324856291629577, -1.4710597242718333, 0.194693606021304, 0.29792668087319757, -0.3575656451578579, -1.3414265629850006, -0.7044098519831269, -0.17913154382985008, -1.0719006282518255, -0.6330637808798442, 0.9664817045472727, -0.26591522793895966, 0.428266866101511, -2.51554027542872, 1.4599212315270387, 0.1251643995496834, 0.7320376056719907, -0.5178431688741577, -0.07081668329004043, -1.8406807341685263, -0.2343547491083627, -0.04767174676410844, 0.5193361052499531, -1.5415228631406204, -1.0632277814542834, 0.1207621780496254, 0.19616571398246146, -0.5212857103545485, -1.5086944758719498, 0.7988386607660848, -0.47541549949805584, 0.6773910372395088, -0.5335970289309326, 0.7017799088345013, -0.046324186677280506, -0.7428291438086325, -0.9838295831163291, -0.05817780927780181, 1.371151871264832, -0.18248384859009759, 0.20065364850894157, 0.9456537217655016, -0.6262974031229558, -1.267254485392634, 2.036560530319254, 0.5373421483758994, 0.05011273774592426, 0.11534623263932084},
    {-1.3882234312455195, 1.2739979831645971, 0.09382521952068558, 0.3273013608723122, 1.2982963397995153, -1.5435481148495263, -0.26708981518287095, 0.07579826499678673, 0.9239441553533217, -1.1828719711902227, -0.06285626252040909, -0.06987599027321194, -0.6962076227292464, 0.5726494048764194, -1.4350617655168174, -0.41407210813076023, 0.07759990183630842, -0.7145104101269449, 1.0783868323342607, 0.2452328442728042, 0.3123947404963152, -0.7431243066723335, -0.31237914507861303, -0.8346472090434139, -1.216893209597245, 1.9264949613753664, 1.306733376292655, -0.14829327655074573, 0.8900058797414252, 0.5695144983295662, 1.01669062227169, -0.9520081782298364, -0.23247074609010027, -0.36963128181316035, -1.408502228830117, -0.1611643776266586, 1.2451432736206711, 0.12317578475869621, -1.1047318534777468, -1.3124397603694462, 1.5687161342721687, 0.9606522928041219, 2.3909484455659347, 1.31541142236255, -0.9066707585681882, 0.2570488403192432, -2.4030613302361132, -1.5745956355045763, 1.0687072688877355, -1.3008294288643059, 0.12081602337899718, -0.1699941815790664, 0.9775995307154113, 0.025981349120232946, -0.4943244471771816, 2.120660258191813, 0.009300844479405535, 0.2952903870002417, 1.22549247429469, -0.3221141891303593, -0.33162360952366193, 1.7538778623627604, -2.8209684733330125, 1.3932454379489496},
    {0.876227200607841, 0.9913368587991978, -0.28580760967803404, 0.05545562318128291, 0.8441453499041788, -0.6939435095098472, 1.7141439922039314, 0.21437015188037115, 0.19451531179682352, 1.0320035794947513, 1.4098054622591405, 0.14013736689976133, -2.651933102431994, 0.30881198871110066, 0.41104158418959597, -0.6130995338056086, 0.8684517170783431, -1.0439875918642965, 0.3700390324153629, -1.714223263512257, 1.663163066798227, -0.16775869003061675, -1.757102039525081, -1.3999632556696848, -0.0382580005384245, 0.4678730470089218, -0.25017789799306395, 0.5131532404239322, 0.8446774166764475, 0.27470021424630875, -0.5566326295871142, 0.6154422508810414, -0.3496964192786555, -0.01272062113612006, 0.3102143976916603, 1.0714916740898832, 0.21799112205291588, -0.058573631040949814, -0.02149221640838286, -1.0028847793488107, -0.44051312366426293, 0.006847149859914895, 0.7827983775490945, 0.7400352319989602, 0.26421773459751097, 0.11441088213008184, 0.07422349548727647, 0.790287292441081, -1.432970134688252, 1.1801833877092862, 1.048800916262536, -1.0743152685775004, -0.554051785931807, -0.8420542174007026, 0.31681836011477127, -0.5776725138730159, -0.9326893113886604, -1.0627012806039189, 0.7257189001745326, -0.019326889805001905, -0.5968100443818954, 0.31256264211883084, 0.06477938811502332, -1.3581378974093619},
    {0.7750640021245084, 1.2656241481010815, 0.21805671823748127, 0.4594134706387921, 0.8096858704555588, -0.6770132448723121, -0.12134961737865278, 0.35365299026716845, -0.7163108471402739, 0.26454118163933943, 0.05072189654173919, -0.501495964996473, 0.8875311055936108, 1.0084556211538007, 0.26117346318956564, -1.327703061136776, -1.8359309824919123, 1.7729170447604352, -0.05158649802062814, -1.0914203759980843, -0.15093434968986763, 1.5715182010681037, 1.5433898668408013, -0.5712800270370662, 2.1721140500941463, 0.015035932103051104, 1.0887367972070916, 0.23655626718179246, 0.8017141676865641, -0.13934734551375821, 0.035932922926606055, -1.0899246198514227, 1.0937134358837317, 0.8779572657148732, 0.10768464654637158, 1.2817776823405636, -2.6320903749595943, 1.150914585197097, 0.24876641914867234, 0.567738051231821, 1.5966547028743638, -0.8762128413625511, 2.379173503426314, 0.7382063991696873, 1.7208056548072386, 1.4496366554194358, 0.8006062436718625, 1.1475743909604579, -1.8431173264252398, -1.8857272750126248, 1.752865910726232, 0.04937512665994373, -1.289294861549973, 0.23839954433134025, 0.9341908932638463, 1.1867514543349265, 1.0692105902277043, -1.000863296335546, 0.8873065784310197, 0.21723384862450273, -0.946268841797299, 1.1974109737254255, -0.1268004000717067, -0.17941460108230287},
    {0.34251623059792496, 0.49645496724782984, -0.21086531253715787, -0.010115764591853984, 0.43959065384801804, -1.2232701551170566, 1.360771709482443, -1.520760480568487, 0.7603452796384326, 0.2229286846156104, -1.682671046123174, -0.5141414865776521, 0.6056535565057489, -0.010781776655863972, -1.6045980528668147, 0.6896842317245256, 0.06744866551081001, 0.7205288421997785, 0.7014109550638096, 1.765543628564054, -0.4018815213928092, 1.2484965922696976, 0.8871837993358093, 1.6080536565239836, -0.15311461617482577, 0.22254054692809655, 1.2902642114725078, 1.3771745401643145, 0.35638306996600644, -0.427714831925826, -2.5990772668466176, -0.7389810588038992, 1.8438708018300478, 0.8508680263988723, 1.2806714745862726, -0.5209510832286478, 0.730174962869513, -0.0029063816794640653, 0.05789779245565807, 0.6171671031234257, 0.8263357445033731, 1.291941160736747, -0.7618422058813158, 0.6181799807174756, -0.18244079684675685, 1.641284821754562, 1.4520799296615274, 0.7995124918424807, 0.3067634274457347, -1.1701112656418826, -0.5942517229956344, 0.6227191071250083, 0.008787833493160006, -0.16644767719565468, 0.10767480993576366, -0.7195602597997856, 0.029157371418466103, 0.3941049545392722, -0.3599684505013959, 0.6809831208953087, 0.14389960033582785, 0.5403162659157416, -0.21390888602618452, 0.7780508148430044},
    {-1.339848799474942, 1.1772358602670459, 0.9781705312591673, 0.34031534482663084, 1.75376040421599, 0.7960101553997075, 0.680995248441409, 0.7508638233477917, -0.10161335278793893, 0.007554047933122411, -1.6771110362125434, -0.6382883862543294, 0.44598840474927814, -0.6000164698193822, 0.5261527609825037, 0.7009150355037326, 0.005500228158050385, -0.5241639527085008, 0.4725557249351193, 0.43008468937862215, -0.9232645572869556, -1.1283238160883038, 1.6153068967031603, -0.5695369588311436, 0.3185608034544972, -0.26641798916486903, -0.5683429899728463, -1.1429911753113948, -0.6691886444703894, -1.795329350489593, 0.4031927807842314, 1.6513035433834231, 0.027934223019382625, -1.7360673171825622, -0.9589416139296773, 1.0194025321351234, -0.37581782951511156, 0.2164593736327558, 0.8750442914818123, 1.000155937196771, -1.7356666324273449, -0.2663236955966455, 0.6235638605136676, 0.5417996500465525, -1.3718026762651894, 0.901661082834762, 1.3630625744094471, 0.517838586264911, -0.6799912385367815, -0.5975936050418152, -1.04869999668906, -0.1347589462869316, -0.3905553409869408, -2.371279014700126, 1.1925938405639143, -1.7894092859071034, 0.042704110842610936, -1.2725328792813453, -0.8007480354056232, 0.2919809961249005, 1.7465493921433566, 0.6067399681714893, 0.054129533118496574, -1.179377692562585},
    {0.45180362976622973, 0.3160463265575783, -3.1041273193428554, -0.9252093697320801, -1.3519859175823776, -1.0567957103650827, -0.2913404803797098, -0.2997672044065693, -1.3170464028685593, -1.585408286261651, 0.2321276775041444, -2.4373056167848066, 0.07370069727630049, 2.14604265528402, 0.2813814081902506, 0.10634513629828864, 0.29480706010821417, 0.9139733188076039, -0.2551501899155675, 0.5980048178753603, 2.414605196253574, 0.5034438928379513, 1.3563417911299065, -2.0665639696687768, 0.22571042137093422, -1.4085937373974873, 0.6338029613549507, 1.645208204706308, -1.1443526798734491, -1.4381640560581876, 0.708472420750891, -0.6303061243508034, 0.41309401711501975, 0.30655539009053817, -1.4847058778049325, -2.237103993145245, -1.6749895534194787, 2.683902851794931, 1.7794860919612772, 0.7509344873310461, 1.3358387609635196, -0.19490885380974807, -0.6661128937353641, 1.4038921052266327, 1.4914765493197493, -0.6557671239953142, -0.8798820968348593, 1.2842869321137262, -0.23175268664790463, -1.293262457640185, 0.003351113131139205, 0.24156462377940988, -0.03792581560764215, 0.5976231519078168, -0.49345582918561104, -1.3598417122959707, 0.2909900118999484, 1.6917878650413174, 0.9634578493797854, 1.0811165375049456, -0.038485282439771326, -1.4411692594091625, 0.030196321072556136, 0.24076826661071624},
    {-1.7466776920447191, 0.4322120158402534, -0.1582194111517248, 1.9699434973021572, -0.43171639750293395, 0.8360157031119317, -1.0383089063120414, -1.7232802532010059, 0.578549803750614, -0.790044471917971, -1.80598856865352, -1.0043723075034305, -1.1602315943715824, -1.2490836912516683, -0.4854327879815646, -0.971566750488663, 0.018099956841853188, -1.7411203938724729, -1.12830571805207, 0.3873004516596995, -1.2957460223971304, -1.0891056475770506, -0.5286999915428804, -0.3211003974650603, -0.8143918809790999, -0.5643401434888029, -2.6180598757307076, -0.21678816194678688, -2.5982531327144427, 0.2745002473163798, 0.1598136004316647, 1.0034896959254935, 2.0492774109948204, -0.04529532225420092, 0.5165689299173886, -1.005539953506007, -0.26937093757726216, -0.641478808581259, 1.2628695749437444, -0.12202319803265964, -0.6799441295098027, 0.5809298530112444, -0.6016772082435624, 0.42808867976843845, -0.24944014987843152, -0.9570441202556528, 1.0746141262069866, -1.2506303835464827, 0.5069906500874597, 1.188099261677894, -1.3687734224934094, -0.25249666689534883, -0.39505301255799347, -1.4241554157711462, 0.2035381461939226, -0.7096698495043143, -0.3471412685428548, -0.37289140958488226, -1.0827956277801165, -1.8940397689658708, 0.6232684420982468, -1.9730492496044527, 1.0619987942863776, -1.7319112560666134},
    {1.1559858883252212, 0.4107182999648306, -0.5170779876794098, -1.7873709752095577, -0.6283639484536647, 0.43706310647118324, -2.118640001009499, 0.5549079802159989, 0.058264056159687626, -0.9534062521277621, -0.04083375887988676, 1.6839102991230606, -1.4840732486779455, 0.3416478583055998, -0.580240867458411, -1.6555013015446205, 0.584903808745791, -1.0965087782471912, 0.16203092965354818, -0.7435878083158074, 1.0024341450963068, -1.467269029662047, 0.4440139130074243, -0.4089707577490907, 2.6167403525243715, -1.1389795317571234, -1.2005690560125868, -1.5386442936056932, 0.34335635265150377, -0.17705758058563378, -2.819049081026012, -0.24806263201890488, 0.31420255738615777, -2.2770026159715218, 1.3247556373672262, 0.8055475186927767, -0.43284511681258536, 0.10115644002623009, -0.5932730327447923, 0.780533771261834, -1.7556041234103006, -0.008667293238902748, 1.571205683101121, -0.18400733567827007, -0.3699894950662198, 0.482055129528938, 0.48698441984462143, -0.9328002389540997, -0.5768732353875154, -0.7806595335888639, 1.5361665517278618, 0.7060076941586121, -1.1165655234471952, -0.7660158603432102, 0.30050314261185623, 1.2902466749387018, -0.013980786085674764, -0.7343165348986735, -0.024074552202765696, 0.32330901865620976, 1.877274076251115, 0.49274845428903125, -0.5757010522701558, -0.31905325952109154},
    {0.8628771413282758, 1.007510645663581, -0.14856355347699854, -0.8460493664029493, 0.2995479352990483, 0.6531361214440197, -0.1851963647590513, 0.14863951410693374, -1.3745556512714727, -1.2884188729135047, 0.3366507234732895, -0.9264219066750788, -0.9330839768453706, 0.981125696738026, -0.07794325087968815, -0.1409795137752601, 0.8503712338711862, -1.1616074598696051, 1.4501303546663824, 2.1438106130384544, -0.27756509376401434, -0.30850039290248604, -0.4254221463369011, -0.5360108666655081, 0.6684725182620503, -0.44355981805323713, -1.9938911422345191, 1.283645730153556, -0.9101472732105219, -1.708311850732204, 0.9801260545681978, 0.1680280099083693, 0.24698791567108783, 0.5753249219775259, 1.1535586937886901, -0.42257677521193154, -0.012358974346334465, 1.2879638487699685, 2.4253707899583103, 0.35104102181198915, -1.351827384471585, -0.575138095795358, -1.9331789946972293, -0.48165640207282695, 0.8773741947982016, 0.36557197473154435, -0.13697706735287848, 0.6439707644203213, -0.9484048464245414, -0.7350890549707971, -0.7832328830934129, 1.5910543703390712, 0.2985407080822041, 0.7905130237894474, 1.3927505369025304, -0.3407529787115064, 0.9495490279963626, -0.9220503239715306, -0.44310316975663805, 0.13138904925569742, 0.18641518675815114, 0.4900407567585042, 0.4548372395569855, 1.4721251535074804},
    {1.5608638633817622, -0.10988070764170962, 1.9295444913474333, -0.8651895171493068, 0.6843772055922258, 1.2834625876359995, -2.133351481229631, 0.18736546798589712, -0.030311972083683175, 0.4898011644773321, -0.9964095426791372, 1.9481842135991956, -1.2811760119450712, 2.3183334306749934, -0.3144606893847171, 0.7015574274795688, -0.3723059166272126, -0.8325095654709126, -1.2483925329605354, -0.3949024384353605, -2.3376086049355287, -0.2832485285565587, -0.955600616776439, -0.30118036462588194, -0.11931424772109443, 0.39150371818775437, 0.1310854481501787, -0.16527864540697249, -1.1462692731932005, 2.466209330867485, -2.0273867172305113, 1.0537872730766638, 0.6437376048030332, -0.7066575171587056, -0.7453451475490102, -0.5258687952401448, -0.3448020757550471, 0.5188008818390809, 0.43930325300517825, -0.31524053484083253, -0.7227448595899439, -0.7428751264214591, -0.9927221981503273, 1.2262190210949035, -1.6221180364468766, 0.3111060551656704, -0.5205257166280552, -0.36016945157533975, 0.2083194902707392, -0.4639707913908801, 1.371220309176574, 0.5440161401977058, -0.482842035048241, 0.6463911551343228, 0.33479651407528993, -0.479211834118174, 0.07099680481208827, 0.36838969532084953, -0.11145079189160449, -1.1521115775955884, 0.34344932350969004, -1.2818204675398033, -0.8601632325516348, 0.17991930809028867},
    {-1.4299362363178527, 0.38331658336434, 1.116943733757943, -1.6975699849425825, 0.3663669353017828, 0.06028916402076891, -0.6973427212460611, -0.6513692628911494, -0.4347260031785725, 0.10359632376302291, 0.8760499094296088, -0.09450629611786701, 0.1398236088037862, -0.5663411268812751, 0.2696800056228541, -1.6706245002373405, 0.6323830562903591, -0.10762862490652897, 0.23935811509637672, -1.9072777584767353, -0.20202704481309902, -1.7451627644061272, 0.5235409986643463, -0.9701563272483844, 2.627616455137902, 0.8857699877292463, -0.5948595316236799, -0.01518281433808412, 1.1578669987187566, -1.1045201452650748, 0.035468061248609135, 0.03503269219370293, 0.5432415157140401, -0.18944126486938626, 0.012455041489871444, 0.8525085240142495, 0.5867458874656076, -0.807062477073776, 2.3731889594807956, -0.2577179444924937, 0.1887649381562872, -0.5973948773903484, 0.41709336949237935, -0.6593298239406168, -0.745012832313962, 1.2024010911623415, -0.5136118947678787, 1.087979570458214, 0.11736941427753216, 0.31765859412105674, -0.3451796701332135, 0.9501636248388257, 0.08747834498853939, -0.2033394934951938, -1.634210154100359, 0.495852423541289, -0.5602632146326374, 0.6668167630642031, 0.8560545615936961, -1.3541646835976189, -0.8313352704090099, -0.6307552318936912, 1.1349423843265947, -0.15167780549658594},
    {-0.6266660181403382, 0.07431481408857704, 0.5192840173758831, -0.20088618273875794, 0.8617139177129127, 0.5128613600130919, 0.19763756355475906, -0.755831652929326, -1.607086804349832, -1.1567636069958431, -0.17905857167930114, -1.1170335955959925, 0.18084041084362906, 0.9076541644685648, 1.0513724457481688, -0.2769272759607485, 1.5804155291539108, 0.13837027920656603, 0.6382479711314414, 1.2629760347434122, -1.0464893704510954, 1.0900413692760333, 0.9645948633872299, -1.7084617455278825, 1.1349923852932104, 0.9342815728552504, 1.0163864742394781, 2.320553118600631, -1.2897493329885699, -0.24803831209190574, 1.078837307055094, -0.665660253212209, 0.519686093195715, -0.14892840454209633, 1.483021879557134, -1.3820489921117967, 0.4889330193028312, 0.926035877817013, 0.08445309793735854, 0.0681966483822748, 0.7900181627809406, 1.0590663043237791, -1.3354070822742181, -0.10048396407406306, 0.6394536831837117, 0.26654955101889727, 0.8639209365498627, 1.0184976836965682, -2.5001712352718277, -0.9494010313896152, -0.0951688285511771, -0.7638451853903356, 0.40720224368316643, 0.6825003530783236, 1.3075025709348338, -0.9160824757316478, -1.5987950235313004, -0.9188132553123104, -0.485366112207359, -0.5188072936845523, -1.0609461429888531, 0.323238236681561, -1.0334636665567267, 0.06351741734093665},
    {1.0853360017279279, 0.800788784895727, 1.0823749770021367, 1.143546699089879, -1.8669167279446348, 0.6881282891746463, -1.4118076551220855, -2.070160062682919, -0.32690878311612714, 0.16676385029872529, -0.0873730249702411, 0.2812290863969832, 0.0668404463127103, -0.36503804455430294, 0.6557741328230765, -1.025112252074664, -0.3483197420630865, 0.4203652573932832, -1.0460425771308741, -0.4479339964775333, 0.149352441237557, 0.6989168313067735, 0.9828798083507585, 0.5076904164037644, -1.4830655847857834, 0.33068583971628657, 1.3010393015054789, 1.7915987504724342, -0.9063864987520142, 1.3129505488898496, -0.1007144104703161, 0.034398647634053446, -1.3235544965806574, -0.5851159119896394, -0.13557788421962344, -0.893708846601643, 1.2784549826714717, 0.5647308019503465, -2.643324120532209, -0.05312611135690494, 2.2311237313467838, 3.119476432331382, 0.8516717648403745, 0.20392403324715452, 0.6239051311169934, 0.8064871409220502, -0.2028098801720188, 0.3465916199911797, -1.9246619795189785, 0.9656275009130268, -1.0753145646489273, -0.5254861047403637, -2.340389119576525, -0.9464881719787045, 0.9689737137563513, 1.596541088387936, 0.13749497618872353, 0.572174183505571, -0.3484821349821404, 0.32073921123292704, 0.6468709316007913, -1.87717025265385, 0.27800288441701565, 2.027033709374682},
    {-1.4449088194328057, 2.142337497042231, -0.8291290281365687, 1.7449268323559943, 0.31388892537210783, -0.590677020216637, 1.0585146288854759, 0.9801407468961724, 1.376573117729361, -0.057977372316381164, -1.2532465344933996, 0.46875409804036744, -1.7078812909222176, 1.1986453767499556, 1.3802934650213392, -0.019696299956437128, -0.08049994655020751, 0.3165243804067165, 1.8069687639914513, -0.6936002385765734, -0.3296631786222062, 0.16752263926173, -0.04022992660583005, -0.7537681466027758, -1.1881824914383459, -0.3584961912164605, 0.7568302209825644, 1.2264869486593726, 1.4583896968485213, 1.8225335341516729, 1.1127197889573461, -0.09307524695793191, 1.4579668624343431, -0.1310705614245653, 0.1472520395662838, -0.5023870563975067, 0.022665048141389046, -0.9547565805317033, -1.2781746685693909, 0.9372568456601899, 1.3166175957948392, 0.7331401978822775, 0.5903205285565963, 1.2541954460269231, 0.9076766359739492, -0.2060633310531075, 1.3979706132916565, -0.08998482262005003, 0.27784484857578734, -0.465377318086521, 0.08875742225761717, -0.5730844795434644, 1.8797747434836733, 0.7041037161332994, 0.6300898454783287, 0.21741733543419617, -0.7589076888281955, 1.2694163507825573, -0.4921931376990216, -0.3183865136513875, -0.8349806447766674, 1.7024868718042503, -0.29580819383685064, -1.9380874167124034},
    {0.904761940710881, -0.693675026644591, -2.094824175022661, -0.22112166025764032, 0.972555699577806, -0.43689483980568905, -0.26445891082940065, 1.077552414418585, 0.15844476884571196, -1.0590749963945616, -0.5048840339979922, -0.07016643992230474, 0.19802465837821906, -1.1452217243320866, -0.3835698092051154, 0.17478035285675406, -0.5761810056711749, -1.3279239791594002, 0.9483307021843415, -1.4504735227815542, -0.8752955308851291, -0.9049146125318781, 0.7450943166882145, -1.0943104405076018, 0.1431573374977281, 0.5447950386659188, -0.5039263196384812, 0.7798442761186429, 0.35907852565970166, 1.2677771892165608, -0.06392323551528528, -0.6398554608281303, -0.23225139866392272, -0.03927022066241503, 0.2890068802062575, -0.6168397512011068, -1.0421638263000557, 0.03786067936148681, -1.8504420918372866, 0.8074507402683077, -1.2602216112088647, -0.9243659806226864, -1.5788081950383286, -0.7779130365681775, 0.5540837133806547, 0.5649613755862036, 1.3186979691148353, 0.04474684798915095, 0.4415661687259516, 0.41820970459123274, -0.36531829879505123, -0.41257198164186754, -0.29105015355889874, -1.243433174741103, 0.21378189019342167, -1.0273843757655559, -0.982866634929289, 0.19262336229337004, -0.9828594761399605, -0.5012976025414881, -0.26081752033722483, -1.0028223149634141, -0.7883078249992744, 1.2061718270379742},
    {0.9353542076182535, 0.5957327232958265, -0.4377962412531025, -0.6050575909494608, 0.2775983312203104, -0.8454234379569067, 0.06536656346774297, -0.6264839151094006, -1.4499130199097707, 1.204525611993669, 0.1793583183266189, 0.06700812216313738, 0.5648908573391083, 2.5139994919462936, -0.7474288288071531, -0.14266543793205003, 1.2198975874145612, 1.57348192655597, 0.9179552480450857, 0.6265456966056423, 0.6065009288878209, 1.153743269997355, 1.156904089347187, -0.18724730481535462, 0.3184118382591732, 0.33470740919774855, -0.7144887210771547, -0.4273314644846351, 1.2546312276029405, 0.17915392119004944, -2.4936061675671337, 0.04443117828667678, 0.8803845984969304, 0.4729247355841603, -0.9921015468514648, 0.26588526552833464, 0.3445049394948726, 0.7791280165144006, -0.13796241952631363, -0.500796759936577, 0.943283466106096, 0.8547879094181093, -0.9571604982324461, -1.495984200588502, -0.29739708674346355, -0.0636230665873667, 1.3095218691295252, -0.018273635296611447, -0.01771061461507169, 0.8069025418253907, 0.9739077875169395, -1.1747508340173096, -0.5419782534148996, 0.5761627711265899, -0.4707367230753668, 0.634049739633398, -1.345615660777259, 1.355422518171022, -2.3125222662806952, 0.4299291244057334, 0.7185163844583304, -0.3392713359482626, -1.3267727949318333, -0.4218465218018441},
    {-0.46252643588121395, 0.15367999140593513, -0.7694724453063209, -0.03655974540067655, -0.31823415649548015, -0.6840945428734229, -1.5153158831666695, -0.13013446845269652, -1.454058098430858, 0.1358562020181787, 0.9149791885418588, -0.46981045167919544, -0.31292969491783307, -0.29811663171946046, -0.13286478188012904, -0.9053447210815017, 0.15712733006467894, 0.4004712839191917, 0.878954853186481, -0.160739547278628, 1.6316025802149468, 0.3557670508662631, -0.3461067486360944, -2.5360624092599307, -0.7185558034142888, -1.0646058381257262, -0.80440040432085, -1.0751998914061218, -0.40391954854953344, -2.6565723348603294, 0.8866502859423082, -0.68441747064172, -0.21939721634277753, 0.6528901176914086, 0.860861595762766, -0.14566770793192516, 1.5714873453147333, 0.7717861102830439, -0.7594568360821884, 0.7812706937325353, 1.190332987645958, 1.7902768864920553, 0.44006749060961936, 1.1640192643327598, -0.518263645138045, 0.41325087502264857, -0.3511684396138771, -0.013727392338457342, -1.283420227823242, -0.027952826226493224, 0.13803000597183457, -0.3597002825415536, 1.5261303615431778, -0.9170023840791621, -0.022169760603398897, 1.7267490958326608, -0.030762604194843845, 0.9178495600982198, -0.41693443592434737, -0.6151525311258178, -0.40922157811035326, -0.657018545930912, 0.081764531540438, -2.364220483659862},
    {0.6229376015681961, 0.082134101911936, 0.7576310128529437, 0.5198641345718085, 0.8202388829446716, -0.38235878943663093, 0.18667776100539457, -0.2800768307641721, 0.1433115417314247, 0.09293555135993617, -0.8838976526571222, -0.9480933923725916, -0.13372378383743558, 1.043852026816915, 0.5960601117850821, -1.014786254273409, -0.16111048002846143, 1.882148759607441, -2.3914276638659544, 0.10051171254494858, 1.6314029915497485, -1.2571577672841896, 0.27512925970693985, 0.35790307943767585, -0.4794412958480527, -0.10032327625201896, -0.9487931573755995, -0.26621837544386173, 0.25905771266928634, 1.495643321388677, -0.1598485437701271, -0.6013477029029313, -0.1827880780042248, -0.290249005846655, 0.27982702778413093, -0.921061533488456, 3.687132107457892, 1.883309497553609, -1.8491932300537168, -1.939133348587748, -1.4758387958808579, 0.8257388813307849, -0.44536193326615725, -0.440168044697552, 0.7846218852442381, 0.3949992337909457, -1.1860580168633752, 1.9437047787150552, 0.40727732377138826, -1.8135685754922457, 2.498884934002294, -0.9894285626052989, -0.08669188617146577, 0.4786906866465696, 1.0296855919891603, 1.4193249412810625, -2.3445193903755146, 2.253776457932321, -0.02411266035447064, 0.4595539111311892, 2.1399518974943947, 0.4620265223962753, 1.2547871490589018, -0.9424490800706589},
    {1.2610158271686471, -0.018532712503414695, 0.9456175071309625, 1.142935385494001, -0.5779541137886806, 0.24203391678512323, 0.5593870525403953, 1.0363875466654908, -1.0291681791027474, 0.5467571929591102, -0.1747407285455026, 1.1922641964807972, -0.12618602813145086, 0.8734103110838363, -0.5431553935406082, -1.4061021451167048, 0.16290236339291317, 1.0628305855789817, -2.163239909809168, -0.12731990233394544, -0.9349677523929782, 1.217014242417808, -0.026760156340822114, -1.2753593897057645, 0.38863728764201266, -0.7179968325518776, -1.2177167797399502, 0.10615602918089156, -0.8813613956035017, -0.0931109346557576, 2.4709017962564634, -2.420806035169032, 0.7600766171939932, -1.3846867197434176, 0.15713619332986184, 0.8977112107570653, -0.7450687533801821, -1.8998176810890042, -1.308034458125163, 0.9353751615398475, -0.48279255423453404, 1.936267249032984, 0.07676414017226789, 0.9057451933963986, 0.8578683592626858, -1.8006247071057375, 1.020038481055519, 0.19109763800980548, 0.48341547624306147, 0.9021402536101257, -0.6055302707115091, -0.9064645969871654, -0.481364193149755, -0.8306940846442993, -0.5663483901502503, -0.924020376128749, 1.4924626628017288, 0.31022307280124967, -0.7347039452750028, -0.5646998464493171, -0.842659618083829, 0.5998836076543448, -0.6437233308762695, 2.001711471959767},
    {1.226588335890244, 0.915964134211587, -0.9008460624227339, 1.6297853458560168, -1.1526690752656568, -0.2242295617416346, -0.15119918305739458, -0.08913017840101832, -1.1072855333397942, -0.13739700587107517, 0.4343480499425733, -0.970916512757545, 0.3376225548040954, -2.219060284531316, -1.0182728267946382, 1.6032926177332107, 0.35106724460747, 1.5063630056777504, 0.645656283111507, 0.023853950390553814, 1.1557436459150958, -0.8135388836258087, 1.3417433249255313, -0.6206808187790942, 1.284316241927507, -0.04765777006939392, -0.4692354357325875, 0.09720227362073659, -0.15078441704887527, 0.7679706480075008, -0.9625930344863147, 0.17710092568836336, 1.3123774239139547, 0.6814084358251266, 2.0808822472888964, -0.8774374224268147, 1.010537095976224, 0.17796725120940873, -0.48451228773825, 1.7832865126205633, 1.0963321450646626, 0.8906400317655331, -0.09484355987113062, 1.6948302981344041, 1.395500948198839, 0.9371320861781977, -0.9898042840866054, 0.10738570840901167, -0.003894351963045076, 0.5139644771444914, -0.26145331715614034, 0.26730412977647283, 0.5109552830088122, 0.1266831572841897, 0.6617229882198071, 1.7560234610332106, -0.2960402821128035, -1.3776322217071344, 0.38396792329878704, -1.6060982994329647, -1.1977171578111414, -0.10684054348918011, -0.4175261242375662, -0.6689262658621234},
    {0.36082360702189564, -1.1733664958569419, 0.3688750520788949, 0.5256777887930001, 1.2410490623491595, 0.8386669895126662, -0.636046004980063, 0.7688627539008265, 0.8075189455267471, -0.4557035345382558, 0.46816208038064816, -1.6126669406899832, -1.1739803666482025, 0.5588744088909927, 1.0576863804429066, -0.9686673966811138, -0.24979348553857314, 0.557300327615046, 1.2014701122183071, -0.019216350296645274, -0.23983248929276352, -0.13604635182661268, 1.3563848187934648, -1.567990223687158, 1.421533815213797, -0.8615565244064526, 0.4830452761118378, 1.272392753352619, 1.394006911005897, -0.431470764990914, 0.09496793679591373, 0.3618650167503144, 1.5796518484448503, -0.5361119154253603, 0.02709666019730961, 0.3423790848408577, -0.1640594085901154, 0.29490995423776367, 1.3116674283207237, 0.35527841478058725, -0.3788834066534374, -0.498985152911113, 0.3003044260254733, -0.30464535398115256, -0.14382715236073537, 0.2791431153644065, 0.5285701154843168, 1.8541132666083888, 0.48945284258933763, 0.7715698115008714, -1.5726228686428578, -0.38490247743548184, 0.4656169437133951, 1.0825189507943458, 0.0014028308610387896, 0.27818476641810785, 1.5488659985531472, -0.16016066793975803, -0.5246837031232895, -1.0063675739052012, 1.0037019621679066, 1.4064647239347672, 0.14906524788480385, 0.6037804743792924},
    {0.8321564257369437, 0.10277869736338736, -0.05566594070615286, 2.2019383478704477, 1.5563649149588168, 1.4073200436887645, 0.05658628866620003, 0.19304240023211316, -1.7942541060187338, 0.7240682029281305, 0.0898041107661132, 0.3476027986212526, -0.05885649562938269, 0.07236306247581065, -0.3777864571454587, 0.27075546918895976, -0.07228130935020398, 1.2980037933139088, 1.2579913586371771, 0.48069711451165914, 0.03621182231800239, 0.7856315196162044, -1.3093967223221026, 1.1323091412286606, 1.4273152731203924, -2.515867171982768, 0.7776669984315331, -0.43776489162359494, -0.23322873974113717, -0.3845686008449382, 1.810379719776506, 1.7318873332902431, -1.2890577216008328, -0.28445078281869113, -0.6292225834708017, 0.009933819616636586, -1.2733322853505333, 0.7174506003467876, -0.582762743728888, -0.8340984641434901, -0.09868686930584565, 0.14807306071747117, 1.0821458490415705, 1.547751336981598, 1.3457173950033308, 0.5705740202809106, 0.39400748044636824, 0.0015247870578633032, 0.2617326773872166, -0.0867077786399782, 1.3297884767343848, -1.5128771237579761, -1.4778412788726798, -1.1091013584522518, 0.7788307399698271, -0.5897335208732768, -0.5897666964467592, 0.401403641770236, -0.7072326004406518, -0.2946196500053294, -0.9597604737990182, 0.500750566208663, 1.654847907385478, 2.326968570646002},
    {0.33557275887085564, -1.7750918704534233, 1.8900341324535581, 0.20300444723430255, -0.008481348321366896, -0.19257938573722735, 0.6755611702041278, 0.19308486148466, -0.7992416338825082, -0.8868270991095956, -1.9449096943622701, -1.918649100579749, 1.1260081003195337, 0.28644609104303476, -0.5378504920112871, 1.9661299941636659, -0.06256423650951749, 0.12706845717277782, 1.627091247575491, 0.5633740238760963, 0.2824100512890394, -1.2810290165730747, -1.4090516081834505, 0.5179159499525995, 0.9761388176843165, -0.41620271484571986, 0.6784293576854687, 0.5042989834402142, 0.3974674240443496, -1.5162945883546353, 1.142790693629377, 1.008751106170733, 0.2246518827283848, 0.00994066692736495, -0.6508466865842834, -0.37887272551517603, 1.2791056148461641, -0.5195280043741173, -0.874132568779407, 0.11469436625824898, 0.1791125349998172, -2.213087180202743, 0.7888522988239377, -0.5039103486977368, -0.485374866683485, 0.04156358271836831, -0.1554366460503452, 0.13240682726232259, -2.1054396391232917, 0.523231610263654, -1.1326986804044532, -0.0007113376282805617, 1.545072928797187, -2.4202848956646097, 0.6790817925137621, -2.4144658979302167, 0.8384570648630614, 1.8905569908705326, -0.5942979220563324, -0.8009887456610773, 0.42053594853421417, 1.5476650936309313, 1.5528595221633128, 0.6041434590402261},
    {-1.3107465881172318, 0.24972931326013784, -0.2926227627078157, 0.16673980970121385, -0.9600681351717891, -0.458899336992719, -0.48355168448144026, -0.12327590865584728, 0.04539681980917663, -0.4413417564339539, -0.6511045674838306, 2.578411922495329, 0.28190226167578397, 1.24769020650985, -0.4178312645303716, 0.08063693802132713, 1.2194057123215372, 0.09778216729648134, 0.5024950629987337, -1.3370713919892894, -1.809501071236649, -0.8005552173417029, -1.4279327216747761, 1.2411492723367996, -1.5367025337072153, 0.05428155160422487, 1.3766038264565166, 1.0708708475556805, 0.44211196628070226, -0.7504841411464808, -0.5814507462574331, 0.046287651182939496, -0.012151768897595724, 0.32856748676894965, 0.3131502887547634, 0.5421687752333376, 1.2074050567720391, 0.0761508049217974, 0.26870745070033436, -0.10606030970099395, 0.5226483863185845, -1.3481238297601024, 0.8741744095419663, 0.6870214249712167, 0.1746965450815978, -0.24485595198470841, 0.7884021750388228, 0.238507318401515, 1.016847586395292, 0.23485812664055228, 0.7467447869614715, -0.611958705498612, 0.6835060588181034, 0.20162184489061646, -1.3457217613496877, 1.1311808386267188, -0.1671033996080553, -0.7841147453143724, -0.8039119628723279, -0.15428625546148653, 0.39019785187433953, 0.3693824578180836, 0.29274464915207915, -1.7249739651149072},
    {-1.2755850393173007, 0.5399132541035051, -1.5787221507741098, 0.2715053626070729, -0.2232146056460691, -0.8263569244688619, 1.1515819342638198, -0.5463215096879644, -1.1051091109870215, -0.9092551316191613, 0.5726420707224134, -0.5627375196229941, 0.6067397941989263, -0.32502188365956647, -1.7961422944664633, 0.5240619696310767, 1.084083283096344, -1.3235765262579064, -1.2249358845909761, 2.524522461118503, 0.19089815467049334, 0.873411098882265, -0.6392817300539445, -0.3399203281896783, -0.061552454125673624, -1.5219608864088356, -1.0454455949551698, -0.09500019156828964, -0.9907873971216018, -0.31453484630391876, -0.9536678860059012, 2.0671927259458105, 0.018613227694918588, 2.081222477808606, -0.22234218053140234, -0.4564819774086277, 0.6764978876336275, 0.3985932074822079, -1.3803405550441843, -0.6989316098727206, 0.19117737687840453, -0.20290846326789186, -0.4629427401719336, 0.34804903182889085, 0.46643287897990804, 1.7700305779963477, -0.6876102341065893, -0.5528746859880941, -0.7432066369255702, 1.1889982110669286, 0.026046560193899754, 0.5425099886091688, 0.051692110808810365, -0.687707336069443, -1.4041804508560032, -0.24670588369782484, 0.6346072247626926, -0.5357994713490922, 0.4649595478084904, 1.1515475070537233, 1.2911659745659696, 0.8483469425995287, 0.8115517347344696, -0.04397059064033117},
    {0.4081358222042197, 0.0693095252987494, 1.1351070996263966, 0.6724148579693733, -0.20244542854006117, -0.7165872514476694, -0.4143262842853334, 0.8510449966644924, 2.060470830150205, 2.224878593247244, -0.37851061704608135, -0.10316730872832465, 2.0601831184602486, -1.4796834102455183, 1.0157461556262608, -1.1293280770425773, 0.12144908425871821, 0.482960903972083, 0.07750813292152232, 0.22972964312285313, -1.2591118056095134, 0.7343272905302679, 0.6285379527701976, 0.1578225859086973, 0.06835940424281642, -0.034107209317048304, -0.6812083032142673, 1.7419744513356685, -1.414569664641863, 0.8824302482531662, -0.6540998929181263, -0.532648446097087, -0.23142439481068314, 1.2383867275976326, -0.5699250893516763, 1.8076089332762935, -1.578588454374701, -1.4108547367584197, -0.4979575204461097, -0.15177823712023666, -1.9720083347283106, 1.0344585722804795, -1.4584272003907122, -1.7373898019032639, 0.3356407486926243, 0.3607644871154303, -0.5079289903716341, 0.545670744577599, 0.3431675821663035, -0.515565134883278, -0.2254728190340384, -0.4221330483769723, 1.9828897797799616, 1.2539217472252635, -0.03029028240507399, -0.9445931269955301, -1.6557133933141628, -0.24491488553153898, 1.3318840644130774, 1.4486756362410278, 0.23851454927752014, -0.6857356503193074, -0.142379859578702, 1.077453824959332},
    {0.16617643184604702, -1.1412454399342635, 0.683469808410492, -0.37536385158757485, 0.9509938891547868, 1.051138369138923, 0.3778630745439243, -0.6149032019173842, 0.6727660895209201, 0.8209057763012072, 1.3027016635053448, -1.3287616672063918, -0.6851664573641738, 0.9352194980774552, -1.4611066421609484, -0.737779908306541, -1.175168516809212, -0.14538104887959666, -0.5886131135551728, 0.9507522305898805, 0.4066726570144075, 0.4328639744097425, 0.24039742106695106, -2.376821047260367, 0.38889970483973607, 0.5844917570463398, -1.7529760325827508, -0.15528534000507266, 0.14016996012900385, -0.08772259938593611, -1.1795559066691212, -0.395472184384506, -0.6025486587877518, -0.7091819296221055, -0.6258281888293395, -0.08592637741833133, -1.1100664465537882, 0.07856621731698425, -0.29662289224975513, -1.0057006801310289, 0.6379070597519039, -0.7245305243493108, -0.506181667139571, 1.4173992038517451, 0.8188159051025666, -1.7509210404206477, 0.017298584896619035, 0.15707344099834267, -0.6942992133178286, 2.2368153554520824, -0.8099929728001379, 0.07504145251593686, -1.2191614400209758, 0.17712693049048348, -0.37745390186013367, -0.13974704193768606, 0.361456691009384, -1.0068893506759196, -1.793711403323926, -0.5721730257457603, 2.1656350780103635, -0.8988429475524733, -0.3814471550464051, -0.5177426897224351},
    {0.4267720558839643, 0.06361666965576099, -1.62364088596718, 0.5654313925363877, -0.796663224893993, 1.562717486910904, -1.4257588649802975, 0.777157422282429, -0.4333896105325759, -0.41637122020814904, 0.3795728873365739, 0.7152373903384037, -0.5331774992559017, -0.09994522465213361, 0.8638225224979883, 0.5395737684621529, -2.4052092895783304, 0.8341428492151752, 2.0734547350916523, 2.056723861810284, -1.5254023744492082, 1.0846989114777308, 0.5267174564708402, 0.3015887209714142, 0.20434501340481187, -0.05732294267563876, 0.9909628692189681, -0.8633519593798074, -0.5850272930242418, -0.6214744153549869, 1.5879003396663007, -1.17408152576967, 0.6210587759451413, -0.6880928886616597, 0.6210418020026325, 0.17344737624950413, -0.3606970193753039, -0.5272997736433159, -0.07796158663357469, 0.8766293016898203, 0.6594812199779819, 1.666796748881041, -0.9904074832379895, 0.4125504425704161, -1.2803035307012234, -0.4331195626462841, 0.7878125930846964, -0.39879681942585676, 0.59727246239882, 0.3218725822953542, 0.9940311978021474, -1.2874995393850435, -0.5958161272026405, 1.1296762928022468, -0.2094128136128003, 0.14805187816572213, -1.3620231728356618, 0.06659215447143335, -0.14708408555478064, -0.5081447272975474, -0.41039810255728165, 0.7811350852852891, -1.2538659526938263, -0.962471499658497},
    {-1.2138216992223068, 0.127358122639162, 0.20001371935575024, -0.7758638617838963, -0.06593471503193289, -1.500766793536812, -0.7097940984671439, 0.3937792229978655, 1.6054589217790232, 0.13788598046981132, -2.1217093309103405, -0.0473226361968532, -0.3151861658270111, -0.5168543880945596, -1.3607517768579416, -0.18845366013002335, 0.8106929285793213, 0.13127417758712195, 0.5626520063102093, -1.2580872144026718, -0.7205235989375799, 0.1899628669227298, -0.7034359196639576, 1.3543070535590835, 0.6380604859457759, 0.6335218030062827, -0.2774532842577534, -0.8480552936887269, -0.8638469458997773, 0.6375944159469031, 0.5999271199202094, 0.07850398995182177, -0.26226832861677585, -0.9120403996158205, -0.07393299974292417, -1.7570222945006382, -0.4394201275927091, -1.5083352567934454, -1.2613650455987904, -0.02375264051784421, 0.44830032933286523, -0.1429294994419931, 1.4582035057310618, 0.8659892057058968, -0.11498276218539631, 1.693288754256064, 0.6029080002646608, 0.24088368251276918, -0.36874465713158144, -1.003652780712871, -2.3329328670216714, -2.601511790764469, -2.1760178546439293, -3.45296082454475, 1.0354843804100127, 1.380045908744986, 0.3271878588528468, 1.6741022159389432, 0.9537932075184, -0.27125515210717593, 0.20468190473342618, 0.9047276435022295, -0.15691955536945698, 1.359601061220241},
    {-0.8207041289931521, 0.986176592374921, 0.10823656444009323, 2.091514580503914, 0.2780679997521709, 0.6163792492454935, -0.46701073711556107, -2.0473255994707085, 0.5709054424370612, -1.3838299418542959, 0.8401416299116221, 1.0471035260900972, 1.0087187471490158, -1.8659575529033432, -1.1156598365121486, -0.682867805611518, 0.2718271617418588, -0.9378531194430115, 0.833216293986348, 0.25758894660901427, -0.4169785214891539, 0.31045453336959156, 0.2607396801729226, 0.6035608821851215, 1.8414329874743156, -0.3434595766235086, -0.1844572355871454, -0.33293640512877576, -0.9839297116883131, -0.1547576160317524, 0.33334578973578277, 1.0154331676310697, 0.8363841482202851, -1.0200397670069805, 0.1452147802084041, -0.641189857540129, -0.9893989868651077, -1.4558003153718064, -1.940792445875092, 0.8069615119201523, 2.7793620270192374, -0.6833575424337501, 0.4994465211009706, -0.26628448631978374, -0.9634227881439058, 0.26110107145109857, 0.8176870728531231, -0.1553924400947818, -0.7532540303840021, 0.1174573722915833, -1.1105357203915094, -0.1624728024329023, -1.4464750455364428, -0.40535218898531694, 0.8314628335612193, -0.04960862285052794, -1.3221927843077266, -0.8386168391777408, -1.5347530998999386, -0.7758054123278294, 0.49444858747408793, 0.5603224168243908, -0.9639765218723352, 0.7308148419415885},
    {0.8048273653914886, -1.219899885627853, 0.018022118028611974, -1.2427512437987729, 0.3318080981796336, -0.09978557417468516, 0.09709336458273418, -0.0001835761154629216, 0.5531699740524226, 0.4702003742911174, -1.0228955593952214, -1.505563290017601, 0.2452632936616303, 0.2558460844494419, 0.35192260661969843, 0.2530962522637267, 1.1758939361612932, 1.1109562483219122, 0.8546684148906457, 0.7171773251612252, -0.8069239868835311, 0.09088971934624113, -0.09778318187624081, 0.11679676325174008, -1.9548706362344352, 0.7897602557820879, -0.8417052201087816, 0.30563629181911434, -0.48030587582695283, 0.5257381869128663, 0.6515743403103044, -1.075243070671189, 0.5453371582091769, -1.0574862511171295, 0.5239683196485888, -0.5071662422757296, -0.4544220850583494, 0.164427265041393, -1.0237770338649794, -1.7021153434995036, 0.8154802354240356, -0.11305183365268583, 1.3998302781637648, 0.49639647912884977, -0.8742026784979792, 1.127555436176365, -0.8784063473456069, -0.1361379733244077, -0.15674494144033407, -1.469266609812692, -0.4256999426705054, -1.9298804785683175, 0.7303614810251143, -0.33315125210389684, 0.2817889793343594, -0.11111632241098654, -1.4806985361705318, -1.7824704354287761, -2.1334494643328017, -0.9340448153990806, 0.5798100641798606, 1.8552176775006788, -1.5143457263539557, 0.7723377550337752},
    {0.3184966164658028, 1.2648626701183336, 1.31562434752472, 0.4272843730658694, -0.41752742057028175, 0.13429544454613743, 1.3114455182543512, -0.8002757574229158, 0.2310633520140813, 1.1232954669159663, -0.5800817546879378, 0.6843432047926666, -0.6025007070855283, -0.7101630562086252, 0.6179560460947076, -0.3222302341020075, -2.1522137353530373, -2.0151099980575804, -0.7829484374819079, 0.047958945535537624, -1.7126437001958186, 0.04033247005668946, 0.17283493791784807, 0.4556777627807194, -0.5897137153910731, -0.6367418457022721, -0.2445220267779252, 0.6411213424417413, 1.76871710785975, -0.8228835157477646, 2.229369516511946, -1.3659407918576951, -1.1513451755031043, -0.7114560225931373, -0.07102956217401757, -0.02717537209326143, -0.4549488675699373, 0.1916105264854613, -0.3957797811014428, -0.8874906718743326, -1.4424993695983481, 1.095047437897987, -1.8098831933020052, -0.2536956731507929, -1.0204910325197345, -0.617662295422638, -0.08363321986318732, -2.17981204885379, 0.4372608432505129, 1.3878176214773768, 1.1461232864377446, -0.23929795832645753, 0.8063275724957838, 0.45893766785456364, -0.05969145151567805, 0.007947289177134383, 0.4965201671094326, -1.9238100576329829, 1.0405650032731755, -0.896938142085321, 1.323534428915418, 0.007793700557491628, 0.18864526442705484, -1.0097507056426838},
    {0.7130119285081351, 0.0906452582862543, -0.8780861603124699, 1.6410610697242654, 0.857308653183431, 1.5839576188117384, 1.1114100293181104, -1.5489579678221759, 1.0782813965689957, -0.8115421895867033, 0.599681297276151, 0.6718891342040416, -1.2857520010558294, -0.14854076959402565, 0.13529697558793002, -0.9316525811442146, 0.001032564928611436, -0.5600977037456204, -1.2794193071472688, 0.058602061247673, 1.5529172474692594, 1.0561077439346367, -0.6218847976517513, 0.9252096261745812, 1.1529196296670245, 0.4879748830903706, -0.27266398423565696, -1.389180694862508, -0.5153790808877606, -1.4384209118084414, -0.026570021999604194, -0.718585791252367, 0.9858417519831288, -0.32040453929555057, -0.5955046179234567, -0.95920641120542, -0.20598856451926237, -0.16859804227283165, -1.0477342388697977, -1.0607158880014673, -0.8255140468557138, 0.5939088752925004, -0.15890127443288868, 1.0357470940540694, -0.0914104189296065, -0.21637933351524305, 0.6718543313521248, 1.444393315485358, 1.1722544250552718, -0.36160618493005514, 0.5863188052319294, 1.0740776500895302, -0.3719484502605139, 0.8783773979728542, 0.5958708512959907, -0.2885455513275262, 0.33146974522808326, 0.3216603592999453, 0.7609340287025181, 0.6377310394058304, -0.011682523494618497, -0.3764574640991595, 0.4814416186044128, -0.27608919643571295},
    {1.31759246493148, 1.0276053652083026, -1.1781261998987838, -0.32274348859100144, -0.23364110605435165, 0.08097787249167818, -0.16691544216263854, 2.0667437733185268, 3.366945961141202, 0.656948805300754, -1.150449989549427, -0.7169465798375034, -0.5025587457613823, -0.601974930029476, -1.1627635253954112, -0.36113646326906473, -1.0784495451712213, -0.29102402613094025, 0.3139215421344497, 2.071463263572697, 0.5872903547851237, -0.43039329987143565, -1.003935722291501, -1.2168675161529285, 1.1120590891056623, 1.1687708108547732, 0.9810103012471444, -2.5412566660712246, -0.8356348847464837, 1.0482390994213415, -0.9052637623076829, -0.5123274589063502, -0.5206571855265841, -0.5314798407036927, 0.8708547258296522, 1.1104390501318613, 0.25570917620594047, 0.33670373720051244, 0.5580096397297517, -0.5396563214651499, -1.1373329185623586, 1.4871693290201138, -0.8288395166459969, -0.20201888957029132, 0.8448230558757929, -1.1254443178522604, 1.6152682263387237, 0.2840697198622865, 0.21404199674411015, 0.7932250785379952, -0.2344650618257719, 0.5754038412351445, 0.5609396799419303, -0.7772674682102226, 0.742441668000216, 1.2653764106928769, 0.8713139910282196, -0.45744943638579416, 1.0849894464986964, -0.8202776761050375, 0.3241491243490967, -2.448477574763318, 1.549128366304099, 2.8331533126946566},
    {1.2856577359187302, 1.1387309558093361, -0.03229904187028162, 0.010297294729117916, 0.750537614034746, 0.42651263457252325, -0.30388995344823605, 1.330553798227248, 1.2979855441552743, 1.7550988685932989, 0.38743994073747895, -0.6953655051953764, -0.6952970334774558, -1.007170528699735, 0.14628208602901652, 1.2331685185868067, -0.32962234042018457, 0.13744528168051368, 1.222821779701531, 0.5154673944876863, -0.4501008570219501, -0.5971049958229574, 0.17221693476770508, 1.1023956186040718, 0.9459861247189196, 1.6987955379750417, 1.4347657536923386, 0.7593451317980493, 1.412765658383863, -0.4655537948051022, -0.16145392357238783, -0.41248635670820405, -0.6877394029960403, 0.8500968210922649, 0.6139902569693901, 1.7424642290600099, -0.6857602463828374, -0.6147096657414367, 1.3418185822592115, -0.9791280954251157, -0.7726869251188742, -0.06860586396597823, 0.8495799460826406, 0.5489085322108275, 0.18393910131467495, 0.1502620561441875, 0.4815552365305682, 0.8798753918871584, 0.6705823023887799, -1.002804064952846, 1.7338595907120116, 1.0833833014558432, -1.3471794575012743, 1.152248776695975, 0.584420945371729, 1.6571138007319832, -0.1065971494949469, 1.7752337313191722, 0.4776494716026588, 0.11567687188733333, 0.9799463593757972, -0.3228256205923045, -0.43866565065551516, -1.0101108283372615},
    {1.4633309681806146, -0.393333914687599, -1.131821998453658, 1.0588168170217769, -0.0811727134373545, -1.4558945494304343, -0.32239415825821605, 0.013870858309683098, 0.8596685363898814, -1.1428396556096545, -0.5852570303469676, -0.9488718910893884, 0.28739632197141085, -0.9332161936285555, -0.15104720367268776, 0.15146230279926423, -1.1482656214247535, 1.156408502578173, -1.438587328576042, -2.3846905516579344, -1.0923886001308376, 0.7155319646905518, -0.3336215988556266, 1.5182272767824283, -1.2887140777369424, 0.6544757114440573, 0.4472838321403003, 0.9097078196636892, -0.9802696936176974, 0.4621327015474068, -1.5371699582549507, -0.40497927808832146, -0.9275318245556519, -0.9844373791399893, -0.2457607200925884, 0.3695731186006967, -0.4560744249595338, -2.062611385848611, 0.10876059221420113, 0.9612411472762448, 0.05919779173361159, -0.6266569930602001, 0.9030099122013686, 1.648046191342754, 0.7677029574379172, -0.4757690504529838, -0.577271964836337, 0.8570524519599957, 0.1428716583371666, 1.1164760727037844, 0.5724173621634729, -0.7367556337852242, -0.5999612170382159, -1.0565300827608723, 0.3913040786670485, -1.4699048959777528, 0.9566728478445196, 1.2497668165191274, 1.1547506128855634, -0.9249982855710813, 0.8113897697851838, -0.48731858525830724, 0.15195346009547125, -0.29810414824674225},
    {0.5747804324753201, 0.8296501955825852, -1.4101540681461537, 0.20803042455711412, -0.7557870784395038, 0.9533837866785264, -0.2711144775032335, -0.1522207166394732, -1.6805423870964675, 2.491594535259426, 0.6903024628973172, 0.993593743341098, -0.11085189109728111, 1.2155301456655137, 0.3306199510035089, -0.14479932311262703, -0.06797842334979079, 1.7534400443774256, -0.08880733167737419, -0.22785134184664205, -0.5805084910148922, 1.2311796886585968, 0.5858533495443351, 0.6025265907215914, 0.5047701724384164, 0.5127483858520928, 1.6750138552362959, 0.156124980515088, 0.09531725045590946, 0.5117363103506427, 0.19411927807206586, -0.14253718327187845, 0.21949066112069873, -0.5389315691216495, 0.9189304178766563, 0.9512329268163346, 0.49399361653401164, -0.6824463205940717, -1.1524087324355463, -1.6107679881009875, -0.8580232573358586, 1.2889601146330398, 0.41674558835748055, 1.2404320293370348, 1.3547963420702351, 1.1146080067674216, 1.657295940139538, -0.050587526912053725, 0.6436192461821375, 0.003222214130349144, -1.7131294958740406, 0.3100853217568299, -1.4440397084527128, -0.07790685497272268, -0.38446315406251513, 0.3366195479478799, 1.2182146032199652, -1.4507568602823244, -0.008707331171134886, 0.5124539113273079, 0.3224215785369427, -1.1876038166131164, 1.5698704739115992, -0.0313295475966859},
    {-0.00907610560675383, -0.33610819382096946, -0.5847075846268126, -1.2784860213060913, -0.5164583841766158, 1.4686794155292178, 0.6660655599671069, 0.8983256939200848, -1.0443170642261501, 0.6774399714176769, -0.10284865279767798, 0.9742220638145044, -1.1022660557719035, 0.5001875983506532, 1.0196459110642504, -0.6746196339374657, 1.3997310564775929, -1.5530245266753362, 0.6286634846868365, -0.1627982173945596, -1.203066728915232, -0.38217631054101503, 0.27429656004418346, 1.2403176998883596, 0.8657064885096156, -0.7859322966228873, 0.2374406850760799, 0.3217293274076395, -0.348936724886055, -1.0901429955222988, 0.4158604228589238, 0.9190190516462672, 0.2946963612745141, 0.33094563409508054, 2.133726823451329, -1.3372559754258417, -0.6147234029524367, -0.9961799179695232, -0.22687363987358708, 0.7152891631863755, -1.0305657671387445, -0.5743064780523994, -0.047037294791772225, 0.6279083095822571, 1.0191283185239421, -0.9962038655575933, 1.1991181749463538, -1.095561708001989, -0.8982283603493565, 0.2315322066497412, -0.6221269622928466, 0.5413772216204752, -1.0827438063710084, -0.19385016251515966, 0.19780547564376494, 0.2757821378341242, 0.11994400125548077, -0.5781233514829526, 0.06548531672917769, 1.0387942099716403, -1.4784590790719148, 1.343884654044516, -2.116081155415845, 0.3967619872421206},
    {-1.2181259580605261, 0.18737152344615593, -0.7164030776919934, 1.1993550845496803, -1.0389159820033027, 0.41978971356456274, -0.3460415772385744, 0.22121058268007474, 1.4224973515151504, 0.0866361623495866, -0.14175480950559094, -0.2667091390789826, -1.7545890980601202, -0.8074431097323441, 0.9719690440611807, 0.13279032805701732, 0.2974757073509959, -0.5428455994437233, -0.6417747942160756, -0.3231901548490905, 0.49526271326578053, -0.9220726926281235, -1.040380015310015, 0.32920632911253994, 1.0058042435938075, -0.6808194660669115, 1.4511888075709012, -1.1404511727620195, -0.00860882404667822, -0.9974579313598895, 0.9620230088054122, -1.7555753280504627, 1.1400265899092628, -1.0083420619216141, -1.0181256424621823, -0.6993225202650624, 1.1272090217281225, 0.11288384167062991, 0.28627413643082456, 0.7013539776442776, 0.6944179230869271, 0.8910496581871781, -0.15199980752217718, 0.3420085865422799, 2.8435705552045034, -0.35900587418449775, 0.3257136609836245, 0.5915786877164396, 1.2686425358338145, -0.2836368674910526, 1.6193557059296233, -0.523234383396053, -0.3711564771165702, -1.3297364385916641, 1.4773403207582168, -1.3603257131318267, 0.5303746185632067, -0.49099107372830847, -1.208998127151347, 0.8271520503993415, -2.0092058579661556, -2.0118735377023484, 1.4032249547861064, 0.7092252448694132},
    {-1.1883474410277457, 0.5866705556987493, -0.39529824782709627, 0.03582999533309361, -0.9248365124070407, 0.8664375066851218, 0.9430198317418749, 0.21434726755174527, 2.162457356682432, 0.1427519826483557, -0.10873190820144993, 0.8122872047476455, -1.851085525485153, -1.3133748974229453, 0.7917878732828728, 1.698812145286302, -1.389256760893056, -0.6311695319360745, 1.0346400874953847, 1.3291768259579648, 0.38613006598612, 0.06882042944752366, 2.1050036351733827, 0.28186134912776484, 0.6108427093968114, 0.2623633960386184, -0.40188327242714134, 0.20673392825733455, 0.8291430891158061, 0.23573250815042515, 1.0328749942612379, 1.7625277972687965, -1.2803315874632657, 0.9075771586091421, -0.5765862958383425, 1.0502980906359836, -0.0980924175839764, -0.148284585220639, 1.8553234537919086, -0.1581550123046319, 2.929320133002148, -1.5815213285759908, -1.430964506892281, 1.034212065949916, 1.0411424696213591, -2.334318852973187, -1.0622206880565501, 0.28043129244030257, 0.037601127541568365, -1.0150193190011572, -1.4350052237437207, -0.2795698718590065, 1.232311381671654, -0.1014705698120671, 0.40068203873245334, 1.9410569627683056, -0.013500720652494656, -0.5117198776794578, 0.25707615984852, 2.332417060900565, 0.6823167141122265, 0.034398491993503054, 1.3350510059487197, 1.1872089977012181},
    {-1.0737943528009544, 1.1368505916756535, 0.19659663827905854, 1.4870443058026988, -1.0614509287142149, 0.6815406692800301, -1.4156726665275512, -1.1683411686538103, -0.0778663729586148, -1.1556359927542956, 0.044239024268862746, 0.3435013130846501, -0.16070961373034223, -0.5584086222690755, -1.6262668680724106, -0.9921142435820612, 0.859928565494099, -0.6794885858579178, -1.7141262296319884, 0.2398081821837618, 0.9625575743481221, -0.6517750945412175, -2.0111758475589028, -0.576494996150987, -1.392801395765226, 1.0013926778119622, -0.45168176831486956, 0.8505896495105131, 0.09309808278717811, 1.185180198046, -0.6501950848849153, -0.7088513115324538, -1.0950777828494198, 0.8747912087763535, 1.1445478212455351, -0.43384774374081375, -0.8546955590514023, 0.7505575855485289, -1.9905021082577004, 0.7549678425321958, 0.6987499104369412, -0.10091966364804136, 1.3175586812981908, -0.5157762923295094, -0.995845245797572, 0.22978471490909055, -0.5486989410735488, -0.8276884323933948, -1.383767653591253, -1.2955272867039977, -0.9019718943922128, -1.1188780028459049, 1.4321286838095073, 0.5644420488698729, 0.7502490480521629, -0.09029112972263814, 0.7858277068974339, 1.4035238875616167, 0.061880641727651675, 0.6755670594009187, 0.19983464517658864, 0.003713385821235068, 0.03322173210644747, -1.0494750053996549},
    {1.884360132650486, -0.05652911807729909, -0.30561055170513773, 0.8451477916903204, -0.04686814061294978, 0.7606389729654341, -0.8149787084620983, 0.7372590464432527, 1.6986996641144916, -1.7010545492966813, 1.2095680505149744, 0.8243255318829883, 0.2613795955979869, 0.9597485388054612, 0.7610703783667024, 1.014271074664957, -1.2971963806395137, -1.0918539435988284, -0.38899446468573345, 0.8901530372172125, -0.017632648035105926, -0.1431578352694307, 0.8381077479369472, 0.6524581997740712, 0.12404012158691338, 0.562111263188982, 1.8268084718684419, 0.6576850810251962, -0.9234229193560618, -0.536523478492023, -0.14554294839418738, 0.37590557663664187, -0.20147219596346436, 0.895462216439133, 0.9143378766983349, 0.6883236134888744, -1.2325741773201848, -1.3109957465725195, -0.838303112073624, 0.43819445240149824, 0.07624105408142538, -1.7344123794681443, 1.9089943658174715, -0.31291228667883775, -0.4764727639708557, -0.5162096572845949, -2.6535245614306313, -0.6648260979425201, -3.749402797271738, 0.3029122852272792, -0.39348860610251435, -0.0840616564022654, 0.6489655320615926, 0.3922701704008789, -1.4452104360526254, -0.6935889967533885, -2.5909485599633446, 0.5522167636501423, 0.6545467501330919, 1.2788684159357333, -0.37947530689268943, 1.7020633675440864, -1.5876641197772876, 0.4478860869163412},
    {-0.7820421368605017, -1.5327836942456357, -1.7952004626769065, 0.09736600856951202, 0.8545939445526718, 1.3254037425291907, -0.9774125268035868, 0.7054835325689481, 1.0260953106740938, 0.8848214758475998, -1.5450035473018815, 1.5448474729680663, 0.01652735763140675, 1.8202589498962107, -0.17764367562246294, 0.6206414020748755, -0.6233300710124393, 0.034449096893089094, -0.8509901450717189, -0.06005636385458087, -0.5280537355520704, 0.6380513798676164, 1.9087329741232253, 0.23004138107912067, -0.21490378766868434, 0.5614458630498679, -0.20183418114028742, -1.7610002649577936, -0.6247112946379147, -0.34066339510080884, -0.8572880397085673, -0.20285075069828623, 1.7575109740550678, -0.6398046986632451, 1.0874808187637641, 0.15287055942887878, 1.4290953190450328, 1.77629063057689, -0.8025658199343693, -1.2946848326480365, -0.27306396164180263, 0.34796043006101074, -0.015772274650706717, -0.15859670364034004, -1.0379292574479033, 0.044837909253398145, 1.3386049501780448, -0.8094827699335676, -0.4352756206237621, -2.4480461699540554, -0.4418640169221196, 0.20564458380646283, -1.1214560388510675, -1.5424962826261432, -1.7374819349817905, -0.43719897197747476, 0.3600362480501133, -0.13627342483237112, -1.2714981331992645, 0.6944867354942265, -0.6611753261640866, 0.12282522819756254, -0.6514152645897704, -0.7286104226459316},
    {-0.31729983988819765, -0.010264656710783103, 0.502382156388035, 2.2590859791577658, 0.7795668127717816, -1.5742074529025012, 0.8689383585145463, 0.261609482561559, -1.1166147665551067, 0.29071606363238256, -0.7778769576050413, 0.9183564096818819, -1.1014360270564427, 1.8284067950111995, -1.1168844918081402, 0.5140901987625501, -1.0655182386101973, 1.1332133076390731, 1.5644532902148525, 0.9506003268390402, -0.6530449174069267, -1.1728316171844122, 0.9417086729019829, 0.4057190201627694, -0.27795774101392684, -0.3300036081908995, -0.991148712286841, -1.0522944252555597, 0.09614896670403288, 1.1706736771377255, -0.5827008696114805, -0.04202178874398242, -1.2286710915702517, -0.3138638119310672, -0.04606121447026681, -0.6993445489954578, 0.4530433799525352, 0.9147643406216279, 0.5382546195049729, -0.010580123613697586, -0.6833213071489067, 0.7104457928897239, 1.0875351757650253, -0.40639787967688784, -1.1478905006616411, -0.3327440360155018, -0.8406677593354569, -0.4059192727498004, 0.8472160057689421, 2.374338875310515, -1.66027726067086, -0.5033832483186818, 1.1725411534738581, -0.4004854445317086, -0.994020137477333, -0.2586773619783432, 0.43940415803595934, 0.007219091131147233, -0.08557550554951565, 0.20496814669364294, 0.7238141394815658, 0.3564775917734915, 0.7412308054155601, 0.4747337218161591},
    {-0.5980961848484764, 1.2028856090896203, -1.4235296641253754, 1.7140303077905865, -0.3299782067184802, 0.7870251450479802, 1.6450669939836366, 2.998564155145232, 0.49979168631869414, -0.22650388168054214, 0.16608234118090665, -0.8327397983112694, -0.3771101373763712, -0.3259727266950616, -0.5083310792971785, -0.8848405545802213, 2.3910679555979324, 0.6911975784783465, -0.8039506351455025, -0.18021810288979134, 0.3144980273337479, 0.24907209253885668, 0.1092060715002044, -0.6782040966468816, -2.4903150665445297, 0.48762695238933673, 1.3915843383734894, 3.000807819887463, 1.2696778406559805, 0.46584589916259805, -0.6117935212280933, 1.0696593456994712, -0.7646465033438822, 0.4024525517426779, -0.022310661474570507, -0.15069268221020843, 0.3640312088057712, -0.1999632989700387, 1.177186156141522, -1.2770571066794787, -0.6493853768014886, 1.615756353418318, 2.993564263517303, 0.6273861861145437, 1.7640985899582757, -1.5826750821034479, 1.1407551822222413, -0.7842399855629524, -0.07738177148940945, -1.345846600843794, -0.44803135841882624, 0.5245935856056951, -0.027319544788178076, -1.1230660884937878, 2.135962504081906, 2.1829010604897645, 1.3375788951765644, -1.470688605101877, 0.34448458302010876, 0.5081137766857299, 1.5128408837045748, 0.1570678680121432, -0.6268389882550378, 0.2081107567223786},
    {0.5040294417140101, -0.6930889787429237, -0.3628047206533458, 1.9339679982096323, -0.4898672612075471, -0.500421000813789, -0.6626795404684229, 0.9062144732744272, -0.7122806723448977, -0.5913363960065637, -0.2626040972054464, -1.6715400830362195, -1.6091651878632964, 2.9338848741508268, 0.2040132084540035, -0.06709109329816272, -0.49307492486251525, 1.9916346247573338, 1.0045864317625435, 0.3818943657595803, -0.9712095935640274, -0.3538447311998568, -0.5765705778357587, 1.5240745204221153, 0.9859094474649918, -1.5410264156201343, -0.467918986056686, -1.2942483605056192, 1.6319535559601697, -0.4035322516202052, 0.7309284886828618, 0.30713651820978377, 0.5869259329121737, 0.37704827866198076, -1.671852065434136, -0.6220375028974969, 0.9597362536900337, 0.0498512430128538, -0.40887020117582357, 0.6006798714909809, 0.07863047526730972, 0.15842816329261808, -0.18170104109350657, -0.23905361858280286, -0.07212808652568713, 0.16273784116490853, -0.7376145189014374, 0.15956132804997195, -1.8370029250870186, 0.8937341970827272, 1.2148338801154916, -0.27179079228401004, 0.4615998709603886, -0.03706884716811131, 1.2526557683203792, 1.602486057603061, 1.1570148031022387, 1.9778126920650592, 0.414740169470542, 0.5184905574723844, 0.08609735510899133, -0.01618919505346861, 1.7921202134758387, 0.8419102887374968},
    {-0.2558879601073201, -0.05571386328102184, -0.8895258078864129, -0.426731423312075, -0.8169060351684772, 0.9547338364843336, 1.3823586395114764, -0.0035237732430645754, -0.14771007114744564, -0.9120899783780821, -1.885202676072062, 0.7390345930569014, -0.21057974246912453, 0.2519682750225149, 0.5279835972383973, 0.670441534061373, 0.09622402251580904, -1.4136182094988683, 0.3571238257461297, 0.18677331902520858, 0.1960789716105938, 0.013760411295429499, -0.9058859313409795, 0.0809476333895975, 0.47427720969923165, -1.3702561949514251, 2.255826607470394, -1.5677124413800945, -1.1290156707727128, 0.7111045988503777, -0.00329780132916654, -0.032114369840137706, -0.9492924523547133, 1.1080521287668412, 1.056980108547254, -0.6745224994371449, 0.7978274147959551, 0.18633264134905758, -0.8502249234197417, -0.323352422151793, 1.0853731758387504, -0.6183864970355387, 0.634537349118004, 2.041517538504295, -1.808170393021661, -0.7209866756921507, 1.1113202144227552, -0.7760025784171546, -1.0448620623273446, -1.7791607014243815, 1.991534937419845, -0.511650248034893, -0.5919983091843016, 0.4109366378746726, 0.29690830818101277, 0.20002894235171081, -0.505118411985264, 0.0742962594423562, -1.5089624304846259, 0.14700282470103218, 0.2570898026840214, -1.5175420849088241, 1.6123051223450184, 0.18914404249883152},
    {-0.13013510819984656, -0.5605385626610935, -0.28316399408361775, -1.706903905592224, -0.05644501193432577, -0.5755863617410488, -1.002344188851952, -0.8128605175361294, -0.3859623101599202, 0.7091282764543702, -1.222203268063943, 0.9601130619782792, -0.3255998966458975, -0.6094545938595759, 0.3157717663615342, -0.19905099741197071, 0.6499717373724988, -0.6468173322023679, -0.91136364230433, 0.03720570258571114, 0.9434007792622815, -0.4880871816137216, 2.6716315060075377, -1.071817458948986, -0.8231107747877344, -0.25790942388764326, -0.2676243669470147, 1.1107447336891194, -0.468728599491433, 0.7846008603070413, 0.09030245975008998, 1.3370912023039658, 0.13022956831689636, 1.2719401960425165, -1.4597946156201793, 1.5802339232974465, -0.1256079722793833, -1.2837716314254946, 2.0064787578947447, 1.3860758751237032, -0.47003146838618115, 1.8365282708374655, -0.3792103529134027, -0.2517245336992315, -1.9773434324837547, 0.10649093425830587, -2.3399975580305075, 0.2707366538645744, 0.3932803139776233, 0.3175459987492685, -0.8979148115874442, -0.5235671357439776, 1.0148094826767162, -0.5367258102279829, -1.01180595396674, 0.7210494698552453, -0.77962520163504, 0.03396306310141622, -1.0158121559674826, -0.06274925789459866, -0.024715972604384243, -0.34039009077717586, 0.8671091325319021, -1.0511553557949185},
    {0.6421284850420035, -0.013676933207462147, 0.13576991625059415, 0.5009653828537342, 0.6083518723204462, 0.2191627216877771, 0.8295543532574177, 0.25017783506691976, -0.6272011472782745, -0.0617972824145117, -0.366474774388032, -0.2373216459381167, -0.14241393554948378, 0.08317946487986909, -0.16034131506850535, 1.0350708815613545, 0.15746362731345231, -0.27058024198465164, -2.25600921239426, 0.055309648312037774, 1.715044235862145, 0.4391375740721727, -1.7953523159202016, -0.925649444606884, -0.17594780146169367, 0.6098531059093193, -0.5503238110809827, 1.21496936887142, -0.57262339253126, 0.14487454042737688, 0.48359756336581095, 1.1449319668694047, -0.8100839078074281, 2.1959942857354418, 0.5204703389185781, 0.7761521470030437, 0.1925589287201363, -0.4164847632418174, -0.8053370017989593, 0.9848528032289939, 0.012182574152605468, -0.3670298013130722, -2.6622247606207075, 0.7784698277451086, 1.4505862112073062, 1.441136971600464, 0.2125045966593563, 0.4791669384319591, -0.18677279501483882, -0.42429426164432765, -0.1469356888340927, -1.786141214506183, 1.5311063076234779, -1.4022505200281234, -0.0273984183049009, -0.6769142381662877, 0.7504049513475384, 0.473850742873795, -0.9248320604156209, -0.4457724176785938, 2.6264048365222266, -1.6407545887576171, -0.41890280405153696, -0.7548188259312648},
    {2.138738116222508, 0.7186938378470779, 0.5678985404796811, 1.3572980851377394, -0.24142885985482546, 1.911250432672755, -0.34374484655306264, 0.44590636816085705, -0.328970857453887, 1.148086816177898, 0.2649075803521984, -1.1228961346110125, 1.2873212269744156, 0.17525826572424322, -0.8036357019866635, -1.5411421206725198, -1.8803428391744454, 2.6066267172042994, -0.17754396752946533, -0.008721416608543212, 0.7069061724617621, 0.3395765561441158, 0.14957175524285507, -2.6801811860263736, 0.805272789749479, 0.6239746040581569, 0.1550711097984381, -1.3917941880410298, 1.2899803665342506, 0.2935287409724672, 0.8951234289100278, -1.4490664129792832, 0.11085627310276507, 0.3373844503320243, -0.7146879037585526, -0.012313777982352978, 0.8745976851517111, 0.7037724161827803, -2.317102782773103, 0.13047648525192904, -0.2752769342733207, 0.7494127583723464, -1.5012510291261736, -0.9168454034356753, -0.29679122507525724, 0.018170670870470557, -0.06881517185147099, -1.6721289795875078, -1.4947228983903396, 0.0409308698608585, -2.1773773602815854, 0.2179232622307528, 0.05675964919982969, -0.7537545529631848, 0.8422750513587978, 1.618247073579826, 0.9136088773613288, -0.014579709520861427, 1.3617061330204712, 0.6479517512094625, -0.9784551760347842, 0.2682605118311978, 0.9079436289949097, -1.5077701349948673},
    {0.7243167846542831, 0.28729391971188734, -1.1536769259882615, -0.8104288383646803, -0.6581028148334135, -2.2417853475333045, 1.0579168716799285, -1.3785668900597585, 1.3850939695587603, 0.9666837846011461, -0.7611271858715019, 1.8937891660993988, 0.6559725727342295, -1.6255634546617885, -0.08123075250542089, 0.48784014300825046, 0.1575522281202951, 0.007880969311086517, 0.6238635972669491, 0.6501344043155186, -0.42376150331232904, 1.7494313005118474, 0.32035153002556865, -0.1255575103478783, -0.7097769481657801, -1.146715314901998, -0.44275355985306897, -0.4142730295483719, 0.28795436911705835, -1.1536772132738924, 1.3299040699926112, -0.6669070094139118, 1.0011110262773866, -0.1927442609448078, -0.1409667393413704, -0.007931802059616685, 1.0497216099391866, 0.3844971048625409, 1.0167526650640903, -1.1962653043175009, 2.2359461355647934, -1.5337835617891826, 0.7874593682165125, 0.546754357522904, 1.2223237748070188, 1.8338128302919623, -0.30616209722245724, 0.8459513082330931, 0.8566187921473486, 0.5408011881812409, 1.1230446573360213, -0.6867977155791222, -1.9601153674213525, 1.1155776628799572, -0.49506952752140915, 0.617827923884063, -0.9346149874566382, -1.2958794968045524, -0.8305586865470606, -0.8473878814594671, 1.1010583234907763, -0.7973111622882885, 0.08411294461072441, -1.1637030428837818},
    {-2.0038324860744328, 3.7505560057551595, 0.7373471754478645, 1.862639509121639, 0.5263296160896046, 0.3887755287321104, -0.858979161581826, -0.21147169958210627, 0.4761513443451704, -0.6640792000690283, -0.1483258685203831, -0.30311141340472786, -0.1942694825297621, 0.4794081500431769, -1.0132936400633634, 0.3922686606436343, -0.19801846062828907, 1.3618229392698864, -1.7925631473282824, 1.7198200265987993, -0.43444220713956927, 0.5766558172733875, -1.4513764844660286, -0.3636157139112653, -0.6492927270185007, 0.48075390751759967, -0.8657580852884988, -1.3840191931165429, 1.1977022467240528, -0.08830325414791824, -0.16109210441659835, 0.8175641279859301, 0.08120407181977472, -0.052414865281098684, -0.506175123266239, 0.38837886715934494, 1.6184054174959632, -0.2783295438877282, -0.23709061985079544, -0.1417021376321244, 0.06314078590085903, 1.1123861906830201, 0.822276765582516, 1.7095912646303288, -0.5612464925933109, -1.792638626267839, -0.4599174835612359, -1.210693815141038, -1.540104643410258, -1.488210845789801, 1.6624913650153923, 0.5077143120162142, 1.8532332032951986, 0.6007184314149158, -1.0539480374187613, -2.1047113970527125, 0.20648052860327828, 0.9520954505516726, -0.8050160208625943, 1.0734861687954702, -0.25311200393994343, -0.953093820345869, 0.37666542400318415, 1.34051074574948},
    {1.4690157054367547, 1.4086417822528472, 0.7479898055102236, -0.827438845393296, 0.21794766857877707, -2.552999711563229, 1.148770702145005, 0.18369638350916645, -0.548478253532411, 0.41289284995352143, -0.30355583400739056, -2.293815684973882, -0.5555809005623704, 1.7652989479317045, 0.20733203870940864, -0.15407750188791589, 1.617031314705609, -1.6937312036271712, 0.143391189239462, 0.18097295402145983, 1.6480783253047033, -0.09292838951292877, -1.1664631020125011, 0.8387045271362652, -1.0226615239093533, -0.7309994079828522, -1.0572168112044338, 0.48466585027055625, 0.7334531273798691, 0.25324731741111267, 0.0011293947346326647, -1.6056105199671724, 1.866553857114938, 1.3970452785429455, -0.19943372011877888, -1.1517350843211123, 0.614189283208041, 0.08687433731330858, -0.5874763036573675, -0.6969000250736752, -0.3582345737957371, 0.11724107705029774, 0.8345837654287499, 1.0595727803133348, -0.76283823367071, 0.3728009060487708, 0.6235154750804259, 0.9126059944283506, -0.39096799389893194, -0.2840318097595098, 0.10935183274961888, -0.4491119784981939, -1.3432685764796595, 2.245562373636102, 0.5882424157506122, -0.10193227396976005, 0.7642418710474487, 0.36277857699809957, -0.539933748780956, -0.12936415923237488, -0.6391329289215466, 0.32714883019582475, 0.39023492987687475, 0.8358888280095745},
    {-0.4470723443728116, 1.2303272659852829, 0.18446374781801794, -0.5028852751428924, -0.5763413238179437, 1.658258929133931, 0.03727800352072712, 0.6686508686502918, 1.5857372623714108, 0.23482350858706383, -0.0601940193123615, -0.43169263296090354, -0.22769134335823718, -0.17743709761989285, 1.0023633815946444, 1.1495939666455155, 1.5386656882361616, 0.5756943608974221, 0.353609308769347, 1.500305918841723, -1.5887367159866388, -0.29639568253971704, -0.2774809128916563, -0.6231072867050279, -0.10444161227804115, 0.262404604140672, -1.649411110962704, -1.031445200661815, 0.42587709890378295, -0.9611945441310429, -0.6181243980901703, 0.12313993375531491, -0.7126549327726652, 2.3376410648489205, -0.24845250205969643, -1.3414629523605426, 0.2809644617621864, -1.3859287806893112, 1.1592787958416797, -0.7548424052009053, -1.3454682740373236, -1.3371079133196233, -0.054960229945575374, 0.9432511642526596, 1.1976335117665728, -1.4914867089800152, -0.08483589307812987, -0.6233486315842368, -0.2622986605729473, -0.31251487806866696, -0.20286867144689322, -0.2042611481655447, -0.9905078902984992, -1.0520002569606164, -1.2655731435472317, -0.39024172144808794, -0.6745949305977714, 1.640633765431656, -0.10713806657923737, 0.9416910863079478, 0.2175245375579336, -2.072876138843254, -1.5367219933904865, 0.7966215251416356},
    {0.5110026237496835, 0.9998934867121226, -0.9081405589785168, -1.035391618604495, 1.0142444459011786, -0.7066581208717888, -0.06350364384108582, 0.565009864411415, -0.19902029828927587, 0.20883179090154105, 0.06757505097085496, 0.26957960065779024, 0.41107479862032786, -2.1515812576178064, 0.6505880298172616, 0.07434352058117957, -0.7430148486737449, -1.9726798159598244, -0.11217248762129824, -0.2761058415493365, -2.11999164131428, 0.015228437734835643, -1.6900217304893965, -2.138709334190863, -0.2343751647357998, -0.22632633144075143, -1.8165481015120832, 0.9878162693610474, -1.5228184540285183, 1.7936244947960054, -0.41446957227915227, -0.6069469450535706, 1.489632548453125, 1.68474813553101, -1.4309785078471342, 1.0725728144485895, -1.0972888987676541, 0.5349481374263003, 0.09288161278672295, -1.1450454372934242, -0.5989179240043206, 0.0002740872922291647, 0.2836494838962652, 0.2756439134658055, -0.5338520080538582, -0.7792302440108242, -0.4802222592685876, -0.539946187190709, 0.45427698923950066, -2.374566615640831, -0.2656020453188275, 0.20633817546361538, -1.2100636944160834, -0.5856749109009287, 0.5954841574002949, -1.0189425487721635, -2.628822891510315, 0.5319265331429346, 0.14490866315504286, -0.04079083960765024, -1.2134270617190162, 0.7642237163083333, -1.3783500694371953, -0.06236986526072831},
    {2.655012839537399, -2.2382789566670547, 0.0380587448403456, 0.023003499428208955, -0.33435133191356375, 0.15156209959278516, 0.718720151497031, -0.010340642131208624, 0.169095984154571, -1.5384850433598316, 2.383091046031125, 0.33320271145171726, 0.683647645583205, 0.5489827793178699, -3.4547108032185827, -0.902044497287264, 2.0067986931536566, 0.8168770302055388, 1.0182478746056023, -1.7232011358535184, -0.2531437449131309, -0.6913760446635245, 1.7404292407882742, -1.3325112186556927, 1.0237120466376044, 1.7575964430692976, 0.698618756563233, -1.305113471797902, -2.1339919208121314, 0.24814561548554223, 0.2253420268100081, 0.8484868547008221, 0.3478328457493434, -0.27233540305231696, 1.3010532561378156, 0.934588904053902, -0.11799850565850514, -1.7524777586352538, -1.0950969542385653, -0.7161019845669865, 0.23742251384870344, 0.17469498082984242, 1.2914659348268678, -0.7674814279409226, -0.0738528584948748, -0.8355734842356181, 1.2245723259791381, 0.6016928193028229, 0.5500794262652626, 1.5587302709419604, -1.1205179116173496, 0.13740392768392706, 0.4083125663469304, 0.5806534251995906, -0.18693643763285275, 0.2637267637825265, -0.05925782267180543, -0.41124288398989245, 0.24155830561497219, -0.7874951427690746, -0.49517948531439576, 0.537969036590355, 1.1732452104926323, 0.026168539676198182},
    {0.2624484455234085, 0.6378008738778432, -0.8682918616130182, 1.596310598519756, 1.1346944561970054, 0.022314497418614822, -0.4074335326136026, 0.19947268910371635, -0.6500195201088799, -0.771195356538594, 0.10997300206307477, 0.07782427748121393, -1.2480804960784349, 0.6686743062518102, 0.5100892219294153, -0.3086866946697181, -1.9522476060200118, -1.1730296119400851, 1.6813866174923553, -0.3865107515772582, -1.2668269419746019, -0.41586348598643375, -1.5710652813082644, -2.0022736607721496, 0.7145652184792489, -0.013037975207673335, -0.4512620723414215, 0.29527249109365555, -0.3952604839925181, 0.9220564056086322, -1.702031369586041, -1.6334319494867566, -0.6002116690481111, -1.7478823357208202, -0.5079312881912537, -0.32321198474291557, 0.507122383503438, 1.6161782139489378, 0.3722439606101376, -1.3428877257897616, -1.0913555440509226, 1.1569022530913915, -1.4747605220471227, -0.8651419649487612, -1.8041830343933238, 0.5016725118162707, 0.5579263779297866, -0.6125306851417016, 0.003767801241448036, -0.6268174970672048, 0.8132438000135409, 0.3553665987022999, 0.9095639501009515, -2.198142115419733, 0.6773619342082541, 1.0285574835157023, -0.2148009177334649, 1.5575455439097459, -0.8004348192578118, -1.225218159831937, 1.5153007697775884, 0.8339071726234583, -0.5973434379263198, 1.8876435922551265},
    {-0.14880183307202224, 0.20979385818530685, -1.048799322421471, 0.1868223793181473, -1.1078796820008268, 0.7115948832025416, -1.8034256549758851, 2.433022723280203, 2.3701048975471783, -2.3810523470178677, 0.13804210994997662, -2.26928401787785, -0.3591438239080336, 0.9335100176681655, 0.5662995279251657, 1.3368948532657148, -1.3739865214349, -0.42338316881933413, -0.8080764074906807, 0.25744895699112574, -0.3336721997703127, -2.2392107299657527, -1.4353082005876128, 1.2533703157463176, -0.8865896637014793, 0.8979211929245415, -0.1840510916962376, -0.541285904095136, 0.31489474874427237, 0.4270507266825866, 0.03285480786759448, -0.6047978169710337, -0.47843759331368857, -1.0783768308922976, 0.5536012884302629, -0.1328785922111399, 1.4988662742183618, 2.2276837256288196, 0.9512663714958086, -0.6114076730766248, -2.6923167254775904, 0.4354133380924897, 1.286310508619835, 0.6625175225034288, 1.0267458098341544, -0.1469145935564219, -0.31154942622229564, -1.5145578095530432, 1.4831086243657723, -1.2886122312204031, 0.23842919000212928, -1.06114521008624, -0.3635686975531222, -1.734180407164541, 1.9770298684744094, 0.17620190495812083, 0.7575290779306167, 0.10157376291233404, -0.06036052290385858, 0.49194265216518546, -0.25522472058234674, 0.7592221270999889, 0.9018233158111256, 0.6866222969695932},
    {-0.7742569486414032, -0.446260450323978, -0.20960722558896766, -0.4835734657206745, 0.9473824400144463, 1.0807548545599786, 0.3735330163647029, -0.334539889323428, -1.054682474705506, -0.43791659734932076, 0.3404260899566119, -0.39122445332013106, -1.528248889374735, -1.0171934108135174, 1.0205099945892906, 1.9822151407025195, -1.0087573562272203, 1.0013024891937117, 0.07312416492614877, -1.8584797104750366, -0.2462029969951123, 1.434614523018409, 0.17452777585985743, -1.3925266632303563, 0.2920410288838406, -0.5263053462619296, -2.058259724399187, 0.014229439354898699, -0.6755973475417204, 1.3242292303475525, -0.0931366168519957, -0.8450220438522742, 0.7894610007025685, 0.14989490236677586, 1.0661309437250874, -0.15442334436698468, -0.07374316510721633, 0.21839851749126923, 1.0121870458532545, 0.1566858603556919, 0.6308910622222038, -0.9635263910250743, 0.7633476575607735, -0.9560604095791211, -0.012556534074406668, -0.48798084269734526, -0.9467527734950597, 0.9058842318577548, 0.6090679997996404, 2.263454742595872, -1.5993098948840923, -0.09007650564660999, 0.02278930314140204, 0.00125813267668183, 0.5545031773999574, -0.8204123974599106, 1.3449686644326189, -1.8617171667640509, -1.562557864875552, -2.032868099631884, -1.643467356135264, -0.13186770714572124, 0.9286137529154256, 0.3000736342869191},
    {-0.7735469979407568, -0.1403656278062488, 0.8540397723781553, 0.6727106836492284, -0.8946107002260495, -0.2816619893213932, -0.8288977524902611, 0.527813963671235, 0.0998151548322635, 0.41974050065126206, 0.19794586218509294, -0.40701993489460925, -0.9384312695636776, -0.15223629141598322, 1.3317737414817112, -0.805802522030566, -0.4986081111403323, -1.4653758498026095, 2.913268190344071, 1.070772572334938, 0.9255179560783849, -0.1553827102139284, -0.21863218779905372, 2.325888876724478, 0.3806926820454517, -0.43211371911318297, -1.322415338824568, -0.6921659448673211, 0.28294423157214893, -1.1879810431561042, 1.033874575155685, -0.39753409411560164, 0.5117505993316426, 2.145431746079638, -1.0449222220456422, 0.08827632632776775, -0.9509046707398694, -0.29000735913862524, -0.6595909579955491, 0.3858130219683751, -0.9974229421710736, 0.6643044718837954, 0.7317059392179992, -1.257576776787427, -0.86950862659137, 0.17083934848311033, -0.8313143589582543, -1.4567120573242531, -1.1935288310681136, 0.4121214711868262, 0.9151938187303077, -1.4570734275447244, -0.15937029285721524, 0.9196927651684884, 0.9367653979435235, -2.085881009315034, 0.3758282905644405, 1.013454835730057, -1.528392000363868, 1.0063421124783007, -1.3258535201640211, -0.11755760642269363, 0.09803224968919762, -0.2673204877215275},
    {-1.725343996736444, 0.5010957626017859, 2.0691374955860726, 0.9745558965271225, -0.23546415050430836, 0.1755650221087537, -0.4021471406238562, 0.48264892241189755, 1.7826705902372917, -1.6586566878708522, 0.21180849280645694, -0.3013243601157561, 0.3759759787584129, -1.7495525901557132, 0.47509716576254823, -0.05379333817385365, -0.31351489886903156, -0.047588428993311935, 0.09455257251299955, 0.3054255548601954, 0.36365310913656923, 0.2169828527892939, 0.3596054240860205, 0.9309159935371147, -0.15121211270261897, -1.193500560162188, -0.8027469150570392, -1.0874679796622058, 1.9212472830944567, -0.9244347412629869, 1.7198693857805112, -1.4825376090692157, -0.9164026290055788, -0.20487402827006967, 1.9994231836073022, 0.055494234431892164, -0.025455770600791044, -1.6609717377658333, 1.7327231478037357, -2.2085068529910195, -1.3283104362269167, 0.40362916282597916, -0.3049761594348671, 0.9509526809491543, 0.816355448098994, 0.3444196332446992, -0.0006740438824183756, -1.278597665893541, 1.5239435116093403, -1.4847912727485282, 0.31698656641464285, -0.5763808417301776, 1.0517031063348674, 0.7782086778766321, -0.33956019280677435, -1.1200665665318286, -1.0568183067987051, -0.4405641355047944, 0.5840342277470562, -0.19373085933799145, -1.4480900246244734, 0.20729195343088735, 1.8238836066760054, -0.7042785032172068},
    {0.6642551673272759, -0.6645331721463655, 1.461923460045997, 0.23512443539739497, -0.5873044214851718, -0.7968102493603618, 1.0043444123708352, -1.2424521874355878, -0.3270157529741833, -1.572998718891093, -1.6985127669000737, 0.4906467104054385, 1.3482267679659432, 0.09787364812820394, 1.817758816124008, 0.25567200983664845, 0.16604799011279506, -0.7411292645280062, 0.3309742240685248, 0.3781534255584225, 1.6048370072413596, -1.005150669441611, -0.5943807956592675, 0.05868400080224461, 0.06042905246814064, 0.6064513848470812, -0.009619206721805539, -0.3042844957326846, -0.43953261727370535, 0.3761749305777286, 1.3480568029737259, -0.9525906376720803, -0.5883542419887705, -1.266844616208127, -1.1610939834733642, -0.6424322352555302, 0.06547215709453016, -0.5229944541553523, 2.1867205764689785, 0.40403110504182743, -0.5108415198020704, -0.6865278575140842, -2.0856726445394522, -0.6202269763929401, -0.6424968171917874, -1.1657660900923903, -1.4940953275488085, -0.29034431092558305, 1.6781476221266958, 1.522972692351775, 1.277374973332216, 0.5002964320378929, -1.7361617103164908, -0.9983906556234629, 0.9969183885127113, 0.2972593791995308, 1.32158689394223, 1.2683591020751066, 1.089997753920936, -0.32600456961028557, 1.2322355116222796, 0.650637188867759, 0.3119449683231728, 1.0675564124918369},
    {-0.8749546857990561, 1.0990228918279983, 0.34972385412894724, -1.9288110339506443, -1.3354178642396821, 0.17182102275270997, 0.6485447396395206, -0.4480316567024579, -1.4679584634187537, 1.493008529923704, 0.45608686866875314, -0.8423215717081733, 1.2635937601632738, -0.8992823254778174, -0.41179735608720885, -1.7637752187961946, 0.6931367434799243, -1.673369953207734, 0.8125698278046307, -0.43257584997604315, -0.32247582609236175, 1.5171629021702149, -0.6645630949717909, -1.0186226230103528, -1.0334705011972654, -0.8571265022947538, 0.6072435757175415, 0.6585069818066579, -1.1701144820024332, -2.32276968194588, 1.1182597335360103, -1.814516618179617, 0.32891081760109436, 0.7414156935836171, -0.9192253473086743, 0.8059784907873844, 0.08446894647847036, 0.7040467869179794, -0.9914824935216572, -0.7855557428438402, 0.3723892877184826, 1.4722721074901297, 0.8796881838039396, -0.1395178136470241, 2.1090531862397572, -0.23749591137590298, 1.306890985716872, 0.2677452974341362, -0.7615270974983271, 0.3119363190102597, 0.2758763893371616, -1.2887234645348544, 0.9725082255877747, -0.20269935447178442, -1.7278165044613056, -0.8408058071989827, 0.3093596778678417, 0.7822506454376797, -0.45372172968112684, 0.3480407076386385, 1.0527142727672272, -0.9034497699112025, 1.652206796505952, -0.5687429843960664},
    {-0.7992276400097873, -0.02445592132035964, -1.278622614964708, -0.058839779552648776, 0.3263866102290766, 0.8876677098356961, 1.2106885997853363, -0.5387150449101427, -1.0606902244328085, 0.9386155750803041, 0.6888841753624804, -0.922538541110098, -0.7460549188786665, -0.9792179283655679, -1.2406851429072672, -1.7439670175716662, -0.2755091011934222, 0.08620934999804085, 0.4246010968503858, -0.2868171271380467, 0.4746590976573438, 1.4538597236987145, 0.421386248108906, 1.473725133335975, -0.8561914523747994, -0.7282422298831627, -0.8797861061869617, -1.5344223249188513, -0.6736132367902313, -0.4369113235949514, -1.2686768827207617, 0.575213037948874, -1.5469083618150745, 1.1450795172738937, -0.6044686328802015, 0.36848841494338885, -1.8581500552518386, -0.07471342886242448, -0.69073100101441, 0.6718566969038839, -0.30783155514452787, 0.7254365683014279, 1.1231630730589677, 1.3410373347751547, 0.2608490330906251, -1.4356420927838254, 0.0338057557650335, -0.2930982231957639, -0.9287806881610865, 1.1595500653922333, 0.520245386257319, -0.16640547851047693, 0.9167727171911161, 0.39737973757708195, -0.24729229455467489, -1.1715128632330059, -0.433014903066198, -0.9029561097079589, 1.0404183969014529, -1.162749278208092, -0.2846372724889608, -0.11293363510417923, -0.9876655877743405, 0.3259098033141037},
    {1.3292681540044617, 0.9685545475261044, -0.5858706133825317, -1.2057910823335976, -1.5641087282067374, -0.49757932069355953, 0.7338590885194348, -0.10631143127210403, 0.14501617227959387, 0.1866577103246351, 1.1071771430062392, -1.4592774885077124, 0.621040675031115, 1.644156803267208, 0.48283855867892117, -0.5093690695181394, 0.5269999472286349, -0.520718042599448, 1.6509701261257301, -0.49539948863273925, 0.6559299813772519, -1.5203051214423948, -0.5976836538986211, 1.4147504021844615, -1.0095620798623097, -1.3532089018146245, 1.866081221236105, -0.34550865803337066, 0.036487787517199895, -0.8056713842832179, -0.4988207069158502, -2.0222125418181944, 0.298951440178194, 0.8383448703549046, -1.6026237457176533, -0.5456562768680531, 0.6435414008079244, -0.9580705606339996, -1.2250035933273147, 0.8743191338736805, 0.5851527220478543, 0.7834175062475994, -0.2713837199960743, 0.8160950555202535, 0.8404277621482247, 0.2830457403081739, -0.11266329399756726, 0.16237778662720637, 0.3395344129709492, -0.6405066087102246, 0.4140000093400147, -0.6129559121510072, 1.1739821757338333, -0.18948547552406492, 0.1738460288051256, 1.9203432127348412, -0.8596416941774521, 0.37797781279082154, -0.03132197834285615, -0.7915086407680146, -1.2891008766099503, 0.30685212074219653, -0.5041165255443413, 0.8509629604326903},
    {0.7504646280684077, -0.8316400951870558, -0.1903368752163842, -0.6908409358908343, 1.0198206728765893, -0.2606974640078054, 0.8471796826497655, -1.009197006986239, 0.17955446105426195, 0.16277328287630483, 1.7176349683898624, 0.021855871281574495, -0.04473464785833417, 0.745650801582479, -1.0524124272863271, 0.8279116355256169, -0.34625767572708144, -1.443148601261456, 0.518226638413827, -0.44664664278649985, -0.5884062628439984, -0.7220513096021333, -1.4153558383864173, -0.06080767750037498, -0.570918854421967, 0.33828139415448205, 0.4448800978956733, -0.5331534456123633, -1.1585131446179742, 0.3351381965157764, -1.2851086973804138, 0.607012124520766, -0.8548852932512483, 1.839063801134515, 1.056424692409314, -0.36798698787364736, -0.7527624202692642, -0.21261391434153745, 1.232695021317974, -0.6755437832444903, 0.44822814391516463, 0.11393533296831801, 0.682565241463143, -0.26093210561634045, -1.5868404311402406, 0.33306270046650016, 1.0101575726385914, 1.9612058948880495, 0.77185183884019, -0.13812807351789985, 0.7403850067106421, -0.4561170875874189, 0.1377312535683864, 0.7105763232810542, -0.08520854572655961, -0.10721708091894462, 0.6341269483259997, 0.9070987195870736, 0.9179016872114196, 0.9710731341181834, -0.6541157985207281, -0.41434467254148694, -0.2943039646126524, 0.16685996369398645},
    {-0.6184784521800657, 1.3487130665431657, 1.7984225861893148, 0.5863810256045583, -0.25687417597199064, -0.7118402398190762, 0.16459741340801973, -0.6331199869699516, 0.12514600500093184, 0.2696836540308333, -0.956778714692917, 0.9651683448103763, 0.9101370622833509, -0.33412196119803345, -1.2039802828492578, 0.20571874857194458, 0.6453883123401256, 0.6786939722622628, 1.2197395204786663, -0.05030561764522814, -1.8786119754412198, 1.452731835573354, 1.06479095240801, -0.5419086478733081, 0.15736916470319726, 1.418405095173898, -0.38658023257051755, 0.37079486711416526, -0.24167463215624505, -1.2856994011580039, 0.6019800231728845, 1.5920489531973983, 0.46534773340334623, 1.1192933060813581, -0.11022777760090333, 0.8336836180777591, 0.6994608861144473, 0.15012148635858175, -0.07131790596882565, -0.38128730220398765, 0.42307729084113377, -1.2938671968144153, -0.5719350114371903, 0.025783963353032013, -0.05976136006409914, -0.7233405907418256, 0.2588731214695036, 0.009034363534861992, 0.1734899157577686, 0.07970735027659048, -0.11984219485005088, -0.6086183906952819, -0.33511386022787587, 0.6222888770999581, 0.5206779761168363, 0.2587292618221968, 0.8235182139728954, 1.1587466806913065, -0.5958020576612059, 0.6785354715549801, 0.5729280225371881, 0.009549701508650525, -0.698722390889928, 0.48955109365828986},
    {-0.007426018951858793, 0.2671809778460193, 0.8826979260666277, 0.05948416280282413, -1.3100195379613735, 0.17595609185857897, -0.44813721442722904, -1.6951820330303113, 1.5850737003305424, -0.14572865940880994, -0.7258513545668549, -0.811407265486908, -0.7445060613231113, -1.277249989794304, 1.9624521325148572, -0.4274283994964564, -0.3262723038828748, 1.428004353502002, 1.5451427720336748, 0.8778249913632565, 1.48855026514556, 0.6699751478577318, -0.7801646818711199, -0.15981717738471354, 0.5074215683968117, 0.5493059108768141, -1.6599755793197124, -0.3128525249427717, -0.8390911935214355, 0.5888257633923004, -0.3036964133374176, -2.6469088487754884, 0.6939741719079595, -1.3278614666022772, -1.1552278493777037, -0.21108794285631, -0.16394587549107342, 0.43288764977361577, -1.5385109138247934, -0.15274649946459104, 0.4349076720262253, -0.8598478405527569, 1.1845035632105405, -0.8736072868482178, 1.7006261609590911, 0.3968315624302096, 0.11715313725959671, -1.9395219028535469, -0.9571284740659491, 0.9971255843607582, 0.7860689211389305, 1.1547108631091763, 1.1055687726855077, 0.135596202904114, 0.4494244118398805, -0.4348863562199869, 1.664016500174545, -0.20822970702908622, -1.8994867369489656, -0.35872019966045654, -0.17334572394232348, 2.1978562754108513, 0.5446648567694506, -0.21390417809273235},
    {-1.7404068006537767, -1.4081822930426675, -1.6556966372047848, -2.4870865748277815, -0.5938185758067769, -2.134882435692342, -1.4328072480419238, 1.9486868165470965, -0.14968797834223446, -0.5335728798293259, -0.6103256814177196, -1.168854201686512, -1.4300702990798084, 0.40677417373306285, -0.7155943821422818, 1.4944989642208015, 0.12095855764234308, -1.1724187235634704, 0.20315327202239486, 0.42667321180824, -0.024684810809312053, 0.6466103990608745, -1.4463194317494554, 2.1659143439480935, -0.5609036529617157, 0.48834411714549375, -0.508666816216048, -0.5000670523499943, -0.25419510298158426, 0.24157722651452146, -0.44833226994540254, -0.17941255995044517, 0.8207612978966313, -0.6764460818116843, 0.14712019094032844, -1.1049352330147084, -0.15229627760090877, -1.63800292422689, -0.3529509416125537, 0.9606238677016721, 1.4114760977477652, 2.2168995436705474, -0.6152546032747769, 0.011980366251008337, -2.8671772335982966, 0.48516377230250884, -1.2689183954052328, -0.541097733748552, 0.4143820073871014, 0.10400893325167337, -0.725611285243497, -1.1959551891184714, -0.2509308626676654, 0.5618298173734287, 1.6941427995238152, 1.4588065184969, -0.7260278556203007, 0.011651196959984924, 0.3437723555924892, -0.5564651877884136, -0.1298589286621785, 1.2465092779883533, 0.8012012052204361, -1.0373759645084955},
    {0.4495286731996352, -1.3005882789352734, -0.4205093314579405, -0.3584493006543639, -0.6496977829950114, 1.5478430977156974, 0.5320470452522642, -1.0041571241206166, 0.6386671194544576, 1.2066423523252543, -0.38939801547436914, -0.3135675727363373, -0.75885349967535, -0.6922667065413903, -0.5610608612553634, 2.175417201242455, -0.19035931948560153, 0.5941184602445502, -1.2613731588658674, -0.35424040416970515, 0.288588048108648, 1.8600027597153495, 1.3584429308684172, -0.03577851191556607, -0.1673883365944636, -0.18522651962208378, 1.4151984318260353, -1.3386611779792728, -0.40633133398992977, -0.04021836700830082, 1.4392118028059204, -0.6904476019027688, -0.28628841167628655, 0.40169945071358354, -0.08435502080141465, 0.9030963281885264, 0.23513954603685036, 1.1303253173967043, 0.1781429411891132, -0.39077616517616354, -0.6939602713895356, 1.3745678927777085, 0.9294861476997348, 0.12178252548227657, -0.16982898467019816, -0.8260748545559268, 0.970928731991164, -0.06098408788442894, 1.4549169716369736, 0.15908491505137612, 1.623137301946056, -0.9001470489789296, -0.8017052227784766, 0.8129947568658035, -0.1378662825920387, -0.6107901845979499, -0.2789828126261807, 0.47419406435367867, 1.388522469804543, -0.0300487979894869, -0.4766162581476038, -0.46071228752009125, -0.03749029063113289, -1.6511306014495513},
    {-0.048167633158274756, -0.7345771690842847, -1.8570741033232006, -0.6834576267526731, 0.14001384190921495, -1.9534848887589598, 0.4055053535608457, -0.5359596313716943, -1.3010133926484786, 0.35470295605540975, -0.05666879885256634, -0.48246113450315203, 0.9415391976578338, -1.1691062121339015, -2.095267342584453, 1.4509831486194609, -0.36298353007101114, -2.1278141919497164, 0.208014088958155, -1.3611435166786308, 1.0553598537700992, 0.32924561207914854, -0.3351526105823272, 0.08562606667077595, -0.1314766773770589, -0.3808110172897083, -0.18288982058475708, -0.10929809907798926, 0.2788833584017478, 2.2649488804351874, -1.092223516218066, 0.3196339879361665, 0.7439232670309013, 0.4781273248692617, -0.6782416080671854, 0.062870881238206, 0.2351758869647564, 0.22502906934189046, 2.5113338937932825, -0.730822891164378, -0.9103504120185328, -0.45251788345565447, 2.1075349551673015, -2.2375004656435973, -1.284473214345861, -0.5612492699923065, -0.9197378966913962, -0.01377454037575648, 0.8815926036340067, -0.3617332895281827, -0.9331268080499248, -0.6304497260790534, 1.331291413023752, -0.12341245908517265, 0.7756742633082866, -1.289129135516915, -0.009600065251218969, -0.2564247842644579, 1.0651126935449948, 0.05103185141503491, 0.7036894479399505, -0.44163534103249313, 0.12212205826984414, -1.4944700114915355},
    {-0.7113550177023957, -0.8944759791775425, 1.0565277555850596, -0.514252476594364, 0.9163721613114039, -0.8107635514388458, 0.009255913635185554, -1.065615723965218, 0.1794220099712978, 0.7996914349695644, 0.377844783423595, 1.0897579387465801, -0.4127101297914381, 0.7119533691579002, -1.5138083568768554, -0.9413800490677096, 0.5028831770940677, -0.041609633125333716, 0.4891196044877208, -0.3934750621702792, 0.4356638050603265, -0.29046165137154123, 0.09524734740330078, 0.41193558428041965, -1.092881273785235, 0.2649691735975765, 1.8294624327323132, 0.22178726341672936, 1.0375226640827113, -1.0681079868768784, -0.6516476200476896, 1.055048390501238, -0.3332218227710972, -0.12273721778591858, -0.635807811949654, 0.6176135498786465, 0.4458785250851168, -0.1697695159083178, -0.15225574454599644, -0.556200622886594, -0.9580477628735838, -1.0230368709624755, 0.26147820721956466, 0.6031523349854865, 0.18898563849414393, -1.5550112929753874, 0.22969155620612036, 0.3963786277664867, -1.1192985036380585, 0.4417685346976357, -0.17076595728481245, -0.3547970134068623, 1.1091960985615832, -1.2330801911140468, -1.0226742767463592, 0.7656193873771865, -0.2949414818815179, 1.412594553068252, -0.5514048208532794, -0.3641184900421088, -0.45418231017451904, -0.45641856918336443, -0.34054024432877594, -1.4820099297871439},
    {1.5321210130640697, -1.240783828611541, -0.9562757049480648, -0.4388357403960729, -0.22422088572826773, 0.010118881680334596, 0.8350838013637131, -0.2876760986914361, 0.38938486903939273, -0.32278133160279426, -0.1273051758526228, 0.7617109335874166, -0.3326167550986068, 0.7647468381124009, -0.20856526590553254, 0.18951212940931716, -0.1651732097068939, 0.32301513884298133, 2.063838805695994, 1.4207427187473345, 0.6587533757617519, 0.18227470052971675, -0.14745382398432186, -0.27776596554198046, -1.7897005407794069, -1.0319667641209636, -2.234583185595015, -0.49705681949492864, -0.3639523077201754, -0.010759080458570264, -0.16254769485180193, 0.7974340623924292, 2.2902826754256145, 0.5296429758842386, -0.0244328553958602, 0.7473232761857701, -0.9432039505827295, -0.5449606926504287, -1.8196324839635327, 0.5373362530940579, 0.06336135277931347, -0.19611528912652576, 1.0432654010842923, 0.02511429726547314, -0.9973285590172501, 0.29962412713285336, 1.1030405712890798, 2.1633543525556074, -0.8653199878204411, -1.2157297600415518, -0.6137365061296499, 0.35967928954394324, 1.8254551008881073, 1.0279259252477424, 0.4635296153206766, 0.012911315840616375, -0.19293660321231162, 0.49289317846047304, 0.6833112404176782, 1.303609231876661, -0.3705260438449915, 1.0014495606093399, 0.02250557393735301, -0.5449661493119822},
    {1.5743887878811251, -1.1124485907885355, -1.4447354298444017, 1.3486770332776208, 0.30898617543548523, -0.5612890899782957, -1.3438082692426574, 0.7531867358681981, 0.08660593721231945, -0.9984849870153732, 1.3200734801077467, -0.3229736528882557, 1.0620497540981289, -0.7273350107715084, 0.42737043672387276, 0.536887944050326, 0.6077613987292129, -0.6281121790379962, 0.6179585893052796, 1.3345429087254614, 0.6113520267853765, -0.024771748675451098, -0.8780475462106674, 0.705261633169583, -0.7608726200632836, 1.6882599146431598, 0.025046088388462392, 0.49659978644989483, -0.3240794791582572, -0.14454646399280363, -1.2885892632795004, -0.6718424116161865, 1.7121061916714455, -0.44905838322830227, 1.8611283557258842, 0.03448271262090841, 0.4310269442386057, 0.18400888677613836, -0.08906963604802436, -0.3460547544692078, -0.5239601606847152, 0.4534065843350442, -0.4416184845524708, 0.15569584798566108, -0.07178986257148529, 0.840958222854133, 0.4687012978304863, -2.1974412357813917, -0.11313333408189645, 0.2759030319041111, -1.9557876818500708, 1.507755926537839, -0.39693457039610147, 0.7720728577320295, -0.9028011920100959, -1.6301615473164988, 0.21146401320226768, 0.18152056907640682, 0.4370423141861634, -1.5101732010000772, -0.6712977593438612, -0.44122026121416336, 1.3228505424406376, 0.20274554408102202},
    {1.2216424831947188, -2.7442843630181017, -0.2715466166031075, 0.44780660444613507, -0.22037539493273495, 0.8773877418513005, 1.2820480217372905, 0.8092209547961509, -0.22179834087944267, -1.8142261966296966, -0.8499384848053775, 0.8572014589234134, 1.292962073352773, -0.8916022983039247, -0.06290202690946264, -0.7439659362316671, -0.5390594665073585, 0.21179570131869022, -0.7238992611999079, -0.9061113950904011, -0.09776012763997428, -0.6353966512599779, 0.4230538426647432, 0.7740818582378722, -0.24536429753964745, -0.5522369046628317, 0.8738221949517481, -0.16557400014132673, -0.5137836974924707, 1.0790269545821003, 1.7104109567474193, 2.2034474404715305, 0.6393805793782761, -0.15222706486481552, 0.9730559099119848, -0.1424192215883794, -1.3622102036977513, -1.683865792924829, 2.453991406842625, 1.1510466241400021, 0.33833955737945776, 1.3298373586696262, 1.0175923413244579, -0.1715642603413752, 0.8155172100886802, 0.34393832785970807, 1.3808854694990915, -0.6240975474952568, 0.6420119121090617, 0.9340748857306187, 0.2617434207883814, 0.2005534412506568, 1.0913364310456908, 1.131998449440411, -0.4493024191379987, 0.6406231883154373, 1.776708241273095, 0.5669788546586713, 0.7674579327282575, -0.863541763677461, -0.21258945563415463, -0.834218990492772, 1.1564750589308903, 0.21625873656283845},
    {0.5351312045572242, 0.23759881112830486, 0.44682661783049477, 0.015036429100003761, 0.1923370008596414, -0.5716721165944937, -0.15115876400494804, -2.1832775145190464, -0.4692211076580928, -0.27090967153279943, 1.0390074672185736, 0.19654746589610414, 0.9696383181159578, -0.18606673864004858, -0.03917131772752566, -1.0316768029617283, 0.9565365418067838, 0.9825939398673809, -0.8799169478259863, -0.39994230370700407, -1.777417253469906, 1.4828242964611944, 0.9547841641766461, 0.5370467440576349, -0.6663204560511099, -0.37313551622778696, 0.4775132305897155, -0.8795839418814576, 1.4774845234930738, -1.3094236190256288, 1.3421840278845012, -0.3946697573307878, -0.41414666044666915, 0.7532808231024388, 0.5293114975649238, -2.141801396897697, -1.7354307451702151, 0.35424435509895214, 0.5121025758201476, -0.16237638508397106, 0.31601272965363447, 0.08065614453015324, 0.19463234339903115, -1.3468981888301175, -0.5775293376729161, -0.7579183595667485, -0.36700483188722355, -0.6662650821505629, 0.5526020741474711, -1.0057415589910066, -0.024182693513498412, -0.5776691506511191, -0.034901227787399264, -0.6773756690919812, -0.9619753819257219, -0.26284378267763825, 0.11951858745177565, -0.5040224273825575, 0.3821644785777154, 0.8259375550148373, -1.564405381455505, 0.8776193909742712, 0.7117573875188978, 0.2982255349513226},
    {0.5643377758593432, 0.1750344722068377, 0.7098054942720232, 0.24826649706481294, -0.21710932822710688, -0.3290782068036068, 0.13689902625503086, -0.2531459986049533, 1.125287643513228, 1.648215099529842, 1.252381175227187, -1.0968364073262236, -0.00139492979874431, -0.189119248587821, 1.6816879038323735, 0.31072431950726404, 0.3577763726075922, 0.0736721175980728, 0.44320123140310536, 0.3624931548514306, 0.5404528110849784, 1.2929374600367125, 1.2518956410758186, -1.1981729727628456, 0.21487811812522634, 1.6384806205736626, 0.3826330786168187, 0.5280301791709746, 0.2916799167476354, -0.4545285005359833, 1.1432057615345923, 1.1740825531118295, 0.46010585876510063, 1.5678075555195132, 1.2072869319503872, -0.4414917776836842, 1.3387878684942875, -0.42915349009789266, -0.2383050891727267, 0.38953616408178027, 0.7062097852187103, 1.5488271251086587, -0.18670587187707444, -0.4671608290111348, -0.3007453401989657, -2.1630836003822735, -1.1564981210830032, -1.3015745855501297, -0.6355110868161399, 0.8489274520264539, 1.4212351448974792, -0.18879056198177543, 0.5828156672563405, 1.765503707555656, -1.550200091124248, 0.22757675478240505, -0.5191200071982395, 0.06719796224863106, 1.0472843527628557, -0.11434174860125415, 1.02089885221146, -0.7348328600619353, 0.09964276614902579, -0.36274215855547437},
    {-2.2717669915374885, 0.2565276833894778, 0.0090419544779455, 1.5375300780429009, -0.7257737940459916, -0.3620752658848758, -0.2514940422891317, 0.6567269186047476, 0.7595758653001026, 0.9378208895260447, -0.3977678854861817, 0.4157671691634234, 2.078804240201415, -0.3664576546255062, 0.7558861376985598, -0.638225533309525, 0.15001188259496812, -0.04315600438343551, 0.23912332875696124, 1.5798801233300068, -0.20735072042349478, 0.03352699766273619, 1.2618313521633595, -0.43519653191369323, 2.568774103641491, 1.491079911022052, -0.6259559525612433, -0.013081547179390494, -0.604983595285819, 2.0181529379429732, -1.204981955043263, 1.508365010536868, -0.6781993204040272, -0.02454625902166384, -1.2491028264184618, 1.4182127545063008, 0.16573206416931366, -0.898749046854117, 0.9678087300606932, -1.1026338281684334, -0.8401054622443839, 0.5339898767471785, 0.6750079160730381, 0.5105250312115185, -0.8488770912563092, 0.03921825460320582, 0.5540865777853418, -1.739935567466297, -0.3135811247334267, -0.20630548347939842, -0.059217449385890686, 0.9045947385144473, 1.3054033191004568, -1.1362306574324557, -0.9172918156138183, 0.21791545039730392, -0.33352255640605843, 0.5077433694364301, -0.9595529807076058, -2.9079362851347548, -0.6714935547290986, -1.2804853480015752, -1.341201092388063, -1.0312913685186553},
    {0.05129592212314875, 0.49823654333619294, 0.3250083832950723, -0.7171024783914054, 1.1282239086883714, -1.9609419990512473, -0.8144545719346522, 1.153969492656779, 0.5438747424105277, -0.12773374741292587, -0.6790698796852606, 0.5649628136683464, -1.3924544182602476, -0.007917512385149058, -0.08277537274589, 0.31367601209217205, -0.07855925142547099, 0.6120135813672707, 0.04221588360283585, -0.08256966386695098, 0.9593964136132107, 0.23867613497912604, 0.7856719105635733, 0.40503291989801377, -2.3322590885948173, -1.478041964837307, -0.5401042566376053, -1.3507275688919644, 0.4129558917694959, 0.9764123476755248, 0.12667559949745785, -0.7828223514936256, 0.7243816078524936, 1.2182181137799055, -1.1368210854086607, 1.61069845387349, -0.5644456522611584, 1.1082112697451743, -0.5289916090044252, -0.13541799466115162, -0.04969817535449478, 1.3665951018724147, -0.40927512609199684, -0.11627429254328392, 1.0823984915112754, 0.8547047907018727, -0.07933360441935434, 2.0978679024269753, -0.3286786462900931, 0.4772879905782103, 1.2572705662018264, -0.13770797976190943, -1.19776296502969, -0.9011277497036145, 0.851731200679832, -0.07057725441083634, -1.4410978403547556, -0.9328792717296328, 0.860853901474237, 0.018010760510662603, 0.18413601648315162, -0.5512281454494099, -1.227544248634754, 1.5082860650695864},
    {-0.9517368510526997, 1.0614781478649198, -0.13949910290997142, -1.1063320426636396, 1.227847878563189, -0.006298379619472579, -0.9210805628714797, 0.20404423640710498, -0.30032288909488913, -0.5806640629960644, -0.12759663081066364, 2.230093694472751, -1.2843483082464489, 0.5304488757265755, 1.0968944652807386, -0.153467967350065, 1.5883141267856238, -0.5934077963155195, -0.4705108687065284, 0.04855658469255462, 0.33275359054916437, -0.09449231691712552, -0.4797443631578526, 0.7365792485359041, -0.3399228244892105, 0.435693888082944, 0.9271944037206211, -1.189143115408808, 0.3399293359151074, -1.562337386310716, -0.41762015107446343, -0.6317868661820745, 1.1674365200073644, -1.1812841396617852, -0.4814528848324491, 0.1433617094035837, 0.26480278426437687, 2.304735827287037, 1.077603927577808, 0.5601790937776651, -1.9430238613354192, -1.113201445628878, -1.8622957149384143, -1.337601334921258, 2.6540028306662946, 0.1916458869988639, 1.1275511905770446, 1.297150735066906, -0.38145726749954867, 0.8268847897766933, 0.1715718676480481, -1.851304751662145, -1.178853675734173, 0.7004659239498295, 0.7598500185628341, 0.931740704243925, -1.3084811681027826, 0.19839116166543, 0.2023357166701279, 0.4519874693486387, -1.3360776079592434, 0.4952404568156076, -0.8592411203896884, -0.7749212687130789},
    {0.4574077896742553, 0.3699032719981758, -1.2181650739495322, 1.1611385887827137, -0.4649471157392176, -0.2627089105229521, -2.121849579282276, -1.4318126433989165, -0.47082803439405446, 0.4450632344312846, -2.582202305779279, 1.256818161966304, 1.1291025759420084, 0.14846146941437896, 0.12344386156605401, -1.0228924616000084, 1.0374138152647219, 0.14460573443551525, -0.2621037065305719, 0.3890691677189041, -1.0237391785324474, -0.7367166607067841, 0.38903183891186816, -0.3136385067181914, 0.45271802889329826, 1.5141408993306, -0.4926218247290146, 1.1133096779272267, -0.7078413990718517, 1.9036118329550873, -0.474131637551809, -1.2841603478572154, -0.27851728517345115, 0.7162625690904165, -0.6220834172973617, -0.4709969771502819, 0.05815291380586815, -0.8616756289902997, -0.45799222628943476, -1.1037498193412205, -1.4171674901322744, 0.2840706283206958, 0.42334022464963267, -0.7633492402837242, -2.155548492227487, -1.350166440843378, 0.04295575386552193, -0.46843244863219563, 0.8086785253863734, -0.1330075397589958, 0.4742578579530777, -0.017330567386920983, -1.1771080767698163, -0.8130499610769367, 0.1546177244123099, 0.8134727535867398, -1.5332087857275543, -0.4205140012573635, -0.1708045902234403, 0.16869277331504215, -1.5329386792136315, 0.7497489341684509, -0.42400335610317647, 0.76788691894527},
    {-0.11672023010129264, 1.6905505136598014, 1.0705364351200974, 0.7999764369081538, -0.04495512407858704, -1.0561544912245304, 0.24433287222261102, 1.0190691026941572, 0.35999077613724334, -0.2529455237969467, 1.110211169294627, 0.16504109690745272, -0.05211683776332777, -0.8269094114076306, -0.5516918364993005, 0.15247358146748763, -0.7705529724739726, -1.163356597768396, 1.2979610389247405, -0.8106080596955627, 0.5257624888367998, 0.43332519376942064, 0.43916745405648067, -3.28383314846041, 1.380265947069462, 0.01769295918950426, -0.42134523111024424, 1.314256245569918, -0.4019124152610588, -0.51211386552268, 1.2816473725891124, -1.0824821472851527, -1.0705091833465818, 1.44241977474596, 1.4897015657351438, -0.7546772977008548, 0.9953163386084546, -0.22598050104616185, -0.3467150333704262, 1.5747939349248095, 0.8986076579710945, 0.45133383222722107, 0.26072749297244435, -1.1238441902541176, 1.2865836872067309, -0.8099694255587753, 0.6950904208813989, 0.45726400505436365, -1.4626747786893137, -0.9583852171496755, -0.9406470047027093, -0.9291555785925708, -1.2793868275745561, -1.0410099806893014, -0.023940515339618464, 0.640768792821752, -0.3869713376112756, -0.8364788047640707, -0.7783474511268701, 0.16750979448365833, 0.03332336299397905, -0.6654199409950723, 1.7039915425913206, -0.048896041661017506},
    {-0.8362567861155216, -0.915618276398762, -0.8709812665105209, 1.1840016326590828, 2.301078520568022, -0.2641861397235045, 0.551024892137367, -0.26574519643180744, -0.46553342911846907, -1.5907212596138307, -2.118437982973243, -0.8212284584387366, 0.6926242949807473, 2.124633363346299, 1.1476366466785328, -0.6971489697398485, 0.6141491103826139, -0.6597766802777374, -1.7074755085186009, -0.5568322229712661, 0.01802457603383369, 0.5422424891373905, -0.03913134985098149, 1.6626809900576944, -0.5601915794147841, 0.10004965745204215, 0.5235980328267893, -0.6803087058340043, 0.37078810042146015, 1.3901113490685744, 0.01652445128707205, -0.06134839023327447, 0.19901646638166529, 1.2509648906569972, -0.611491715164854, -0.4431397705902906, 0.6007881855773467, 1.7254740605223342, -0.8354950189450171, -0.17657126336361847, -1.1845144480612386, 0.20725900184315194, 0.5192838827383148, 0.495209396830408, -0.089389603605502, 2.7464210207888806, 0.7196983696234602, -0.13708258737765486, 0.01890070189713012, 1.8444872465874593, 1.2997833007763355, 1.3413558262457828, 1.2501603507943708, -0.0019784841799265563, -2.1467951303273347, 0.03418326327446015, 0.5659683897923109, -1.050607661628083, -0.09661126284366608, -0.9353677070000865, 0.7666637272593441, 0.6243703964284455, 0.8971415649649862, -1.3238337939832767}
};

static const float b1[64] = {-0.014894896727422129, 0.3911168655497047, -0.008658970688146486, 0.4604902270424244, -0.4006202774040574, -0.11786569536610414, -0.1682132241958546, 0.05092973029828571, 0.26338888736904836, 0.2606962042799255, -0.31804547682109063, -0.12070507604551253, 0.09665467375607187, 0.24751243691883043, 0.2072560725909954, 0.11456327370478196, -0.36675980171744593, -0.42554324098245916, 0.47080853964078256, -0.32999083939716123, -0.008731679357310226, 0.29789152692632465, 0.0029111556542019057, 0.4081145778579605, -0.24157537081780128, -0.31627624082633093, 0.47729439002453977, -0.22458617284565907, 0.01928453678215359, 0.3834962812253044, 0.30050312711328886, -0.0171716309018851, 0.16857633919154633, 0.0665982116424008, 0.07516240416643959, -0.2338090851233099, 0.5367485435231933, 0.2372612850129803, 0.5476840034012744, 0.1903317195063676, 0.2710603705192302, 0.547254404349152, 0.05263175958481319, 0.2574441608454775, 0.41743325643187934, 0.07179004331640693, 0.4275705308534777, -0.34823229859806515, 0.14037543821150486, -0.4490420302158987, -0.44493123896415904, -0.012603057664614493, -0.7116264122714068, -0.021643616569641182, 0.022142211929086417, -0.4169551951073033, 0.3747355111675128, 0.18923236226075993, 0.41978323181107347, 0.2824108153812048, 0.3171519173249182, 0.03722042108145117, -0.4357747856941619, 0.1742798099132971};

static const float w2[64][32] = {
    {-0.9165439904451551, -0.7716366580224211, -0.047320678771314004, -0.3924445518121949, -0.48883769973909996, -0.25874374426805863, 0.6126958355726788, 0.9127513580621784, 1.5305663459189582, -0.5683454668206143, -0.4319347439340812, -1.5419832027334914, -2.0957812861409097, 0.6455304684556465, 1.521477078297746, 0.3890795777242943, 1.7255653282592716, -2.712538907271508, -0.4038055641387293, -0.4248228635331287, -0.8245477833297303, -2.826187492133745, 1.0928950309012126, -1.4919295778016401, -1.2358293914791882, -0.5936091810759834, 0.143869184662945, -0.6291524926892643, 0.33005526427646364, -1.2106882304995163, 1.3887924564107108, -1.2737221776380778},
    {-0.894042392853909, -0.48840908789942755, -0.20281987716183542, 0.6460285788858182, -0.3219486371744584, 0.7553515680080574, -1.0440945432962692, -0.3126100273655336, 0.37657317597900064, 0.10541658317965738, -0.5691533772985492, -0.9430310166716017, -1.2498914503107126, -0.9171370891987859, 0.49283073098106334, 1.6838961574497469, 1.5451297054828614, -0.2497813933371607, 0.6372961484383404, 0.06031204353848832, -1.4878955154061728, 0.9216002538867647, 0.35461138648347407, -0.06654127969905435, -0.07664699185993853, -0.03318766807092716, 0.783007063199651, -1.108688293161539, -0.426710526087356, -1.2250443698056763, -1.1090638568134872, 1.4203604504402534},
    {-0.10417419978584665, 0.015287624775024393, -1.0640449306220647, -0.7239908127986966, -2.007990344809495, -1.1557464764458703, -0.7225458504340966, -0.8130889792807047, -0.2617149014643114, -0.8847367806386561, 0.7799966215380981, -0.6903062140629789, -0.5924523199993562, 0.46321883354658017, 0.8012257277942463, -0.8586746570073552, -0.8176693030377079, 1.0933021556981608, -0.5263259364453866, 0.18839977230292887, -1.6284283373767534, -0.4225803971226272, 0.31146334013302246, -2.206763680067961, -1.8622250212819573, -0.4410008220676814, -1.2832615247313, 0.05971790609387033, 0.21486213605403737, -0.6483655240161622, -1.2864889066588772, -2.197126685263504},
    {-1.0775447859256628, -0.12495090339023912, -1.0401879525709248, 0.7296498231022117, -0.3514518822649257, -0.38871723988235535, 0.3030293303498603, -0.7942685192543445, -2.2184241540718874, -0.8254355153474161, 2.0551094593591084, 0.3827677301015977, 1.5351626956516073, -1.0851196438652053, 0.19281567728189083, 2.7640265996279747, 1.6049119076525336, -0.6637610578056674, 1.113996399858229, -1.5152273247677532, 0.3769242017050642, -0.22127852084270222, 0.8944321720266989, -0.7869210656693705, 0.14345271545465446, -1.2379851362229544, 0.6570325995777909, 0.6454787645784414, -2.1869809825004256, 0.7439948876877651, -0.17452622165294215, -0.03794891575073919},
    {0.19920364615299066, 0.5619120066622862, -0.5839102704593802, 0.6349844764388163, -0.4008036429423074, -1.2371647214519537, -0.8514954584257525, -0.9716913062045146, 0.018040087895679787, -0.20619468908699176, -0.634558249924669, -0.1022599687434189, -2.4663005160137788, -0.12197917862855182, 0.8288082119887664, -0.18965468695556628, 0.12879697844866642, -1.7569661211247007, -0.33373736288112105, -0.4050032019413581, -1.522123290516543, 0.14257349023412486, 0.49707771577504967, -0.3470983265153074, 1.2778209504649378, 0.4206055072232227, -0.29281166714236273, -0.17674738850062727, -1.2917934012136303, -0.4871037830246632, -1.2281644382382673, -0.5810555702139613},
    {1.0866002770987528, 0.5984825193998737, 1.2214254012813002, -0.2396395008100381, -1.119961846631974, 1.0061264062418278, -0.5148428426279879, 0.9128944866052576, -1.1760589151850724, 0.5184629772536993, -1.9239116864574204, 2.146755820938782, 0.1859641269941685, -0.4258991044765642, -0.16995470007184688, -0.5091622701374614, -1.4511220922471837, 1.3350140030421636, 1.249773991734404, 0.5745585230390962, 0.5933714546331811, -1.505235815928897, 0.6724904389363046, 0.6070143834345357, -1.937222656882326, 0.7518497501001133, 0.80714560016506, 0.446464101243977, -0.1448428292943688, 0.47737810554225335, 0.41551101737787915, -0.31882289048667894},
    {-0.22257521680604675, 0.6243874168435345, 0.5458641856269075, 0.7235840616785856, -1.6614347466718413, 0.5459651761709889, -1.1806668776556661, 0.5192984993580735, 0.5245540006862087, -0.9446090377857519, 0.5132410842731827, -0.07280228235852465, -0.06805851917182303, -1.3705654373725409, 1.9802830367797413, -0.9825381616450566, -1.3684608288962459, 1.5284765949063515, 0.7484618591113014, 0.19565250044521587, 0.7965787248336764, 1.3642254485527683, 0.9739634185839566, 0.028197386101065043, -0.11848475358982198, 1.1289670438220734, 1.863767564675858, 0.014804234929177634, 1.4207837164843427, -1.961677000539795, 1.5461171165423668, -2.3696342208114163},
    {-0.29485563497898437, 0.0736239326372569, -0.5612804709271939, 2.270641408242885, 0.7868920777697265, 1.5358237914855157, 0.592091467738889, -0.9017605118782765, -0.2954353151870165, 0.5938463047810575, 0.027048984376696148, 0.25037081239982517, -0.057912463215876266, 0.34998403452400023, 1.1547887584622696, 0.62490581044644, 1.5008836863113957, 0.28413638420583304, 0.8143549752271613, -2.361968893118239, 0.793896939190262, -0.36745259718947404, 1.5763353340071624, -1.3914871321452378, 0.529551380532596, -0.4077877904730293, -0.739215803217415, -0.12076102016847283, 0.09679240127531945, 0.7959897713350914, -0.4411606371639298, 0.3218642662112303},
    {-0.335787485760665, -0.9926996287264074, -0.7579315259806747, -0.6002369133159461, -0.3128416532192893, 0.5693625538392451, -2.3603684709729245, 1.5964848266267573, 0.38843268355603583, -2.0182091137464817, 1.3545547432384415, 0.7085343072787065, -0.1512332129564729, -0.4249630046315636, -1.1412863367628867, 1.352214477690457, -1.323588136414543, 1.5947769940292598, 0.7713153609827225, 0.22959885661965498, -0.7364502360797529, 0.10065531037631308, 1.3268007651343998, -0.9470892053740297, -0.7424441898402011, -0.7868438596513859, 1.8538937369726696, -1.160594732334048, -0.19072940889265252, -0.4594541571717129, -0.809505486301602, -2.2078691104989847},
    {1.1764498991174523, -0.745326588819625, 1.180230851295498, 0.543993070757243, 0.23226805503936318, -0.3744816317389746, 1.2408209229190232, 0.189135073640562, -0.4787873537410257, -3.2413641724554423, 0.37733531185429686, 1.054240314247937, -0.15406242674960324, 0.6899334575414265, -0.9259188311687513, 2.614245027205247, 0.436975160325545, 0.9856420855656344, 1.4625357844347298, -0.7497197407521243, 0.7335652351663132, 1.4427990745788541, -0.411940053705475, 2.9550518095796865, -1.3207076246488527, -0.5775256721242036, 0.62376219024216, -0.04020437051095537, 0.13283942545317518, 0.007721784616775107, -0.43858692743983196, -1.141195607579112},
    {-1.1711422042926036, 0.3421375226547082, -1.6520619823117682, 0.8531631723159525, -0.06689985554605829, 1.0212924671507253, -0.6755440758617796, -0.42978530567982753, 1.9369931331793506, 0.21754413118370824, -1.1208719339916906, 1.1439580673950986, -2.1004040157752395, -1.3433056581089415, 0.3571386467919076, -0.0589860307107231, -0.46979154291237973, 0.5657698820511969, 0.605237413997155, -0.4145183555957576, 1.6270949283097897, -0.5817158279762003, 1.44318115829995, 0.317391587971247, -2.5210677600624725, 0.2346562618953989, -0.13536653167885743, 0.47396550592559983, 0.6790981464235707, -0.029141995269072282, 0.8784748780648587, -0.08738235854027206},
    {0.7857792084860789, -0.9526052852459913, -0.9516205427377171, -1.1446280976848153, -1.4244456869355995, 1.5135192615707198, 1.5041245884882992, 0.028480195027872586, -0.18344081146005725, 1.23600016190233, -0.8208679706174121, -0.7410248704587992, 0.059433029572442224, 0.692055776763652, -0.22632372527357286, 0.17680840271647327, 0.362427258154128, -1.1665727117837053, 1.0803982517612105, -1.449544790813897, -0.03280751602306251, -0.32686675205490245, 0.43829936635515215, -0.7103428561760455, 0.4932437219500131, -0.9321459216707321, 2.7038835279143694, 0.16863276481551465, -1.2721530730563984, -0.45971514278453973, -0.4732565708148466, -1.29949362781811},
    {-0.43578946144727715, -1.0408731471971964, -0.26368206347467105, -2.4052354895827053, -1.4595496274098916, -0.10594036021273806, -0.290084592782888, 1.5862957421396955, -1.6723434977554652, -0.16455743791010327, -0.23524636997556475, -0.49533220996115185, -1.5369667673810752, 0.3799596013507669, -1.6080842983039076, -0.2045934109405487, 1.560749773873771, 0.13308591435849165, 0.8400161136039599, 0.2963954040440525, -0.8310729064533205, 0.1333399949806957, -0.15747536884913993, -0.5446156112554432, -0.545643497911117, -0.5939232401459108, -1.075156363104307, 1.008709908448971, 2.063064272540509, -1.4072878136694225, -1.6760371171655022, -0.36582199723293024},
    {2.0776181066172645, -2.2948382755478227, -0.3777551290829996, 1.343270616367505, 1.4246804217122724, 1.1546341201414438, -1.6516277868231226, 0.9117405779059378, -1.1392786766676641, 0.8927832007042724, -0.9171809090869371, -1.4373146535086148, 0.32931408258085804, 0.9604419441455584, 0.09651941335846774, 1.0357282817889437, 0.7343954404629944, 2.5920929415862775, 1.0154914792482261, -1.1829983889276001, -0.31291282658937297, -0.31134549735207295, 0.5325241164321017, -0.29048207794983094, -0.5081603801972435, -1.6409339038144246, 0.15130134949056018, -0.9339954118661785, -0.6302926575260386, -1.0382541605360773, 0.14571786661754843, -1.5623815290821057},
    {1.1368980841126781, -1.257506724021377, -0.4483309442135485, -0.6764366108325386, -2.2852956606753785, -0.008345576609350999, 1.216315397181778, -0.744372689946814, -2.448030755276949, -2.531885784255059, -0.8139817942494941, -0.4042933427787589, -0.07082589230152044, 0.7189197425183302, 1.3043110263212159, 0.45548263236478775, 2.112759760725233, 1.236499315464236, 0.4685003245470968, -0.12289119153643621, -0.4880943554956937, -0.267222760544299, -0.3017490474777646, 0.9499506469378486, 1.1288322413182954, 0.5945531525651224, 0.04039574416253794, 1.6109570524311712, -1.4535608624212157, 0.2766467607536071, 0.19924497056314672, 1.0499832031899798},
    {-0.7625854400318157, -0.4404329533271786, -0.311291857346669, 0.5539871080575607, 1.4089568275570872, 0.5604926654351449, -0.6332899451207956, -0.24576582448847276, -0.7987383942938499, -2.3124933293171246, 0.665411663137011, 0.41591161257760106, -0.36717611170428205, 1.4652144560505358, 0.782920575456923, 0.7378261942001896, -0.2028580222937668, 0.4188447037101476, 1.3327914575820956, 0.08623455014339616, 0.010234674380188838, 1.202738609700458, 1.0629335497691097, -1.8027449117715972, 0.4195711221238456, 0.5983961046095219, -0.11838681609752749, 1.5726947403718547, 0.04542991603668323, -1.2039041952581468, 0.16613756066930305, -2.142159416568035},
    {0.8963503143474834, -1.2756619012281543, 0.9060818775796704, 1.1000011100967666, -0.10466479520531473, 0.19906671067652718, -1.0705416793537503, -0.9020771755180252, -0.2870889921632178, -0.007235970917113161, 0.2726498454579276, -0.7124173082740017, 0.862063730284091, -0.003928704147937791, 2.765923946551372, -0.8569526971508012, 1.1370116541243869, 0.23774235001920016, -0.8069016265564457, -0.5222494153560332, 0.2215500243589957, -0.6604804309382188, 0.39919044101866985, 0.15114656934351847, 1.2947354790881773, 0.30109733116020837, -0.06473900253970091, -0.8889604966697128, 0.016993947764773427, 0.605828292417922, -0.7877593388225592, -0.5080729933444916},
    {-1.3700931710994533, 0.11191146961891942, -0.41179970921964854, -0.4294617399688645, -0.585455217787655, 0.34692379783109606, -1.9731234177291364, -0.5698724070409652, 1.1497579548033054, -0.03637808214095608, 0.926017181412268, -0.4255175635883714, 0.949992040844167, 1.2149702338999577, -0.8986178435137775, -0.8994239328850802, -0.06807846995263336, -0.7730607870261533, -0.36216580439736074, 0.5510915497395746, -2.2398438184096037, 0.014879871527253733, -0.3538266433719463, 0.23929743906029954, 2.6052205635459056, 0.6333161914477762, -1.3136057626583915, 0.5034513478935251, 1.692723234119247, -0.9287162680295307, -0.2303580004594656, 2.214281318850571},
    {0.8496641689047976, -0.34737444567010284, 0.672562585176515, -0.4470952789186544, -0.8987828527155934, -0.48305869105147853, 1.220154727899077, -0.40405953550485835, 0.25034111659607733, 0.3776338910089614, 0.5745321959543923, 0.19610046427524083, -0.504331682559336, -2.106872593746168, -0.8063062346491374, 1.6617124899069493, 0.5042373633064686, 1.4863144437900169, 0.45930011521386493, 1.1064355115088567, 0.02862026014779182, -1.0081710660973162, -1.2192229850481373, -0.6947588059754912, -0.9101357935487198, -0.724402492936595, -0.4171495752444164, 1.702404214717629, -1.0648535208344383, -0.9869740096679818, -0.2739573644322344, -0.17958332965349624},
    {0.25243142449579525, 0.6821899745811982, 0.30351311594492986, -1.6491561726990442, 2.2344355644369784, -1.0378896655872194, 1.248491072992837, -1.0701175573841168, 2.325492313986875, 2.0735730864134045, -0.9811887388545608, -1.0377868948835196, -1.0494655931535655, 0.44129076348483526, 1.1692939493070067, -0.0318027788254651, 1.0774716779354363, 2.5180791723792826, 0.34460795354596097, -2.1272534146895388, 0.3131165789874332, 0.9219874200755506, -1.3732664458494983, 0.5398957947564854, -1.0572179075557608, 0.29527262104624824, -1.2398714619661773, -1.0983414357713905, -0.12434009238019646, 0.2091740663399337, 1.1365932941884391, -0.2377945196748485},
    {-0.3834895656824853, -0.743936579362845, -0.8474814630928896, 1.1568333817590695, 1.612442985248937, -0.14507919991060106, -2.0784333198256086, -0.3073473177915027, -1.3071800181953839, -0.5125719395705741, 1.5179982344338019, 0.4759832598259905, -0.3564672461106557, 0.06066535076537456, -0.2458148840393663, 1.4391939041573174, 0.4542792195605958, 1.0835528975439024, -0.12339088092026225, 0.48892395442450154, -0.5489389485653581, 0.40701735866636324, 0.8149779084261016, 0.8733428345712237, -1.3007977851886947, -0.10518179374036528, -0.5334250616466284, -1.3562815591768145, -1.2104615166489858, 0.091644937773741, 1.0011857645092457, 0.23707540192431023},
    {0.49400229334556695, -1.1201072198250592, 1.245044140511204, 1.7441729789318328, -1.0674979119659616, -0.11854681360379676, 0.05764707374272255, -0.9982618275275007, 0.5654711564124066, -2.280650697876944, -0.4911381553888247, -1.2153120605712036, 0.1420616812546404, -0.41199451111843194, 0.04915139663916063, 0.956984621069646, 1.7674004972920598, 0.35140302009507707, 1.061876467425736, -0.23421127586861404, 0.8828071913423435, -1.1345546192875988, 0.9700414611354169, -0.08668960465503732, 0.6447318790294685, 0.5131102134194272, -0.528093114707632, -0.5250393877345084, 0.7428076874320712, 1.0033554749565943, -0.36460700912945115, -0.0019051688307239428},
    {-0.22843038163225704, -0.22710523563273854, -1.2547404877381458, -0.22783065290108193, 1.4040462700671799, -0.44684282801328284, 0.04896820804680587, -1.2748711495854843, -0.4967552989271497, 0.9962613163463132, 0.5223387763510597, -1.265869124521634, 0.38477857591991327, 0.4255498331614168, -0.9185470606552072, 1.6174285665672499, -1.1768402311271215, 0.5835334539307013, 0.15958976710371423, -0.9285080206878811, 0.04298693903944451, 0.8160181447513573, 0.7341302002634527, -0.8832479269006747, -0.16757991255354782, -0.13249586996915946, -0.3011241995184097, -0.842716698084458, 1.0613518337532923, -0.05383320896809137, -0.03211180289782066, -0.2979088153295654},
    {-0.9805176718465938, -1.122094783460483, 0.6850087464389253, -0.4630452056255084, 0.41582624180163996, -0.29205386625649815, 0.6020646522878291, 0.7225740292147388, -0.9619347666747693, -0.6412870325369551, -0.29740384499440276, 1.0812624420856993, 0.17280382124058394, 1.3116656147350498, 0.1990629310120339, 1.682369771115222, -1.909014693331741, 1.2047899864786293, -0.2539998720819258, -0.09311412809978915, -0.11294373585611621, -0.49739876996488597, -0.7422724097203462, -0.4883371004420518, -0.560410545251007, -1.6175591320906142, -0.12002033630862385, 2.1263783251590818, 0.4661522235251662, -0.194758649185867, 1.6094813398866517, 0.634101970969136},
    {0.8361979421909882, -0.4345891749430205, 0.36340296032776065, 1.1652967711139919, -0.06281347648378871, 0.36377808007199247, 1.6032594907132611, -0.1665684360434923, -0.859162339044147, 0.5776753124692598, -0.4544816038043185, -1.0900866787375276, 0.15046389230858015, -0.6244683985455143, 0.27659765852320456, 0.37664245058181517, -0.2789226439947898, -0.22161811427441924, -0.1729999549891609, 0.5001459115626252, -1.4034204190610982, -0.01168197334812866, 1.9687075285834432, -0.6177741053517535, -0.6342729494132033, 1.5362134002765373, 0.5749867302049614, 0.9306657621426516, -0.018789673986442317, -0.5882789017409961, 2.3322278002257986, 2.279836946971604},
    {-1.8647080611602875, -1.47374831723486, 1.1430992175029049, -1.1647741394338103, 0.7415148362339745, 0.14110784764351392, 1.441116408208946, 0.7945363548435186, -0.6263781806145798, -0.8923830432192719, 0.5126682671297598, 0.01421939248213441, 1.1808585074021436, -0.4270159729066517, -1.9195160769650255, 0.2805234975224452, 0.512696432546268, -1.0086476741706218, 0.3115154012087338, -1.399159720066498, 1.4591030693380278, 0.5794225755908089, -1.9163923980679758, -1.6356455644813062, 1.158324047509055, -2.445106631520337, 0.6754643451889782, -0.20100174382068056, 0.3033373428484445, -1.4898227013017495, -1.0560939282734552, 0.6663600726997051},
    {-1.0879821632656992, 0.34644527143216736, -1.4001677090966202, 0.3778504078898924, 0.2630274030014775, -0.18640282562161067, -0.1415555263530829, 0.17645718646850034, -0.813387804782245, -0.4487861348338058, 0.24693475665802408, -0.778514290794208, 1.0687465487910854, -0.25070488764498416, 0.24951400535098417, 0.9341666511871262, 1.2851353179266685, 0.704975525647945, 0.5213540278476142, 0.16648639279813948, -0.04157595594957318, -0.4372528415322861, -0.5387080258028977, 1.0463595244314423, -1.0092495115086657, -0.26161094495552545, -0.21003253538075284, 2.025482651667149, -1.6301682499929133, -0.3833783869915176, 0.2464776939664155, -0.2722408872719279},
    {-0.6314841689866493, 0.5342020001568196, 2.365724217156696, -0.631187429621476, 0.2548249384894083, -1.8428477440381261, 0.9456239375774499, 1.2545657686128573, -0.20413990425048248, 1.4056438961256836, -0.5081044962487253, 0.5398262506300655, 0.08201311648196558, 0.9054402482826918, 2.5760948777785226, -0.23781786068065883, -1.9308162048945583, 0.3682012075976115, 1.1618462222257373, -1.205142916298062, -0.7497572547029068, -0.8252395500096877, 1.744660918737356, -0.22175241443020108, -1.872520839667762, -1.5669501133560388, -1.0536036747654145, 1.240019276160595, -1.9503635640076025, -1.3910892605785556, -0.03696734140429277, 0.957470187914994},
    {-1.5198343924623552, -0.08337594270314772, -1.3599913834115276, 0.888881095622654, 0.8657383521394091, 0.27063506273653043, -0.7632766781471538, 0.23656170138069454, -1.2693402360876285, -0.08046804057722969, 0.012011602569448415, 1.0244506754866092, -0.1067486174084342, -2.009745068685582, 1.723676968135424, 0.2200898287929246, 0.14413179407806445, 1.1168202024205227, 1.373658093808329, 0.9040380996003353, -1.3437923950251005, -0.6912554709224161, -0.21110813118090552, -0.016364143571475934, 0.324163887523801, 0.6281589097886927, 0.3452884759891415, 0.6622469030218561, 0.037154815333554476, 0.8013764077944596, 1.7097702945156872, 0.0195962761873582},
    {-0.06109500163747818, -0.3875186574104161, -0.9483627131653071, -0.13973657166554018, 0.40556549603388165, 1.2735002882068063, -2.534570595283334, -2.267438998468336, -0.5317040862877753, 0.6448392600487405, 0.15409196372407766, -1.2992479762596634, -1.9949848268843164, -0.7916254222729084, -1.2612740441787496, 0.9248099271959876, 1.9518989121969388, 0.8394045786243015, -0.1336406458487736, -0.3913050327443195, -0.690060227677731, -0.778383291010871, -0.7625860066996534, -1.46544411821947, -1.7968263543580167, -0.235335325233448, -1.057079782797386, 1.2000821430207433, 0.007506727973080935, 1.6004942668143285, 0.5340778674019079, 0.6182718960755879},
    {0.21093879046846664, -0.23612273434129277, -0.3562153359006638, 0.2815191984741055, -1.4474057759058054, -0.4327787604075006, -0.7199727231743845, 1.5134176423255228, 0.0053103681550251925, 0.03621281610531179, -0.07384533299959488, -2.1757130402209017, 0.9570963210000539, 1.0560136391884367, 0.8782549389311195, 1.0181401572474524, -0.3405671934661202, 1.371119927352353, -0.9910640013898819, -1.039083094712486, 0.55729441855732, 0.6815585732650192, 0.7657218635867474, -0.8709474467743176, -0.89215027368873, -0.6030529958162186, 0.7095877959541722, 0.16400710719142997, 0.23427493434211863, 0.40349860215822386, -0.06508136072636127, -0.7587282807005075},
    {0.7857119595717772, -0.5977881211354426, 0.5994104907528829, -1.3267703819957386, 0.5203076209308328, 1.184556006623839, -0.30030772076844603, 0.03170457131312082, 0.8859129343857699, -0.10401337923539568, 0.9901268126908894, -1.295315748792081, -1.2050423241043817, -0.8689536951550392, -2.8468845188003, 0.3181078417304295, 0.5590141495470707, 0.707566521917351, 0.7073222001118896, -0.6079250599226151, 0.5691947008860474, -1.1106651656344846, 0.43696064947511615, -0.8749827586001612, 2.5291558301062134, 0.04364008222112106, -0.5803185696968197, 0.6046811096133733, -0.5251430155019294, -1.3384226678362046, -0.6648389148699311, 1.1034744218962589},
    {-0.20470522448076736, -1.3015845734265143, 0.6719981815190552, 1.4759042690423245, -1.1770425625492982, -0.48616669076501123, -0.9361860102246067, -0.9008543721528572, -0.2669473102941125, 0.19353770778535473, -0.8047549508725149, 1.0037886642922318, 0.415002109828554, -1.7501351594833916, -0.14585039739951425, 1.6364909448169802, -0.6579517794773219, -1.292451465038888, -0.5200086450989424, 0.03134096317484132, 1.292676672739916, -1.137525387636681, 1.121615103961955, -0.11358223358675806, -0.07599436103925092, -0.3472333724510923, -1.4388892812045275, 0.6679144764142044, -1.2321298221866028, -0.6748891722938681, 1.0966840716069284, -0.7328260146553546},
    {1.8746206317230827, 0.1910862313730018, 1.77173766953848, -0.3980096904683124, -0.15653998695964408, 0.2725818752595431, -0.30337464131276676, 0.12929072863192773, -1.8310219563590253, -0.9667624205543782, 0.7156350952183101, -0.2364493102260368, 0.7368142905726796, 0.21321425931806012, 0.9144317658292928, 0.04674412061086025, -1.0163827034435449, -0.10277384990031554, 0.07637344190318118, 0.37066793237495893, -2.0241250371277695, -0.9286651871454111, -0.6772750395799274, 0.07469401565792685, -0.2655529971624104, -0.10901765468633703, -0.16362036175406433, -0.20425395268741445, -1.6010219137770607, -0.4024736054225218, -1.7753553274133171, -0.4749306721695583},
    {0.6684375172880084, -1.2087606257518824, -1.0016842172575553, -1.3143101837357276, 0.8520343670917766, 1.2089290336514784, -0.6462207357395218, -1.9228478549495716, -0.8477034370813337, -0.3371899440511227, -2.403110474575473, -0.6410496204878093, 0.0723035117754488, 1.1375205928241863, -0.2656566522945358, 0.06217598347704102, 0.979766286641964, 1.18313993510712, 0.19700635064380967, -0.7604204309144968, -0.5839097774060509, 0.5089709149514203, -1.6726423111878264, 1.2650642692148057, -1.1436458222224037, -0.5777227899509284, -0.5769623192152756, 1.3074031088181188, -0.49561110430576893, -0.5476774425464821, -1.3700392128164098, 0.17509133403370541},
    {0.7441226126324862, 0.32747660035925696, 3.096271567501067, -1.197354893194294, -1.5998680137006638, -1.5275439675578215, -0.11416194127094814, -0.3276876664130271, 0.9499435329867139, 1.1467314811788785, 0.4154912498783657, -1.2882530837576167, -0.2560875067544959, -0.8649119614701435, 1.0851181620183978, 0.17573120361026603, -1.7585039005336471, 1.001506698124999, -1.3049433488193407, -1.6600117250637936, -0.3904534912129059, 0.6222610307504589, -1.5046221896132357, -1.48214137252859, -0.06594754999274473, 0.6936958856723672, -0.04717955626037297, -1.422004357868575, -1.2732589808753594, -1.096659338945944, -0.7535825695074688, -1.8020745092072852},
    {-2.998662163577615, -0.9467703362686751, -0.5348582391110833, 0.5412558674273648, -1.253039240546433, -0.670884675138355, -2.1293360050858534, 0.6224725718175081, -0.9076205234470164, -1.4918238961202774, -1.2779019926680455, -1.1493756377453352, 0.46223726215728067, 1.1759487558857489, 0.42209914854205566, 1.7574850412669978, -0.19339020078666289, -0.9691816152271421, 1.2755399026234113, 0.381393741907916, -1.5286412728880023, -1.0581411984478573, 0.8382357220047123, -0.4013399940773308, -0.2951230799644334, 0.8195099376048216, -1.780658074716246, 0.341779601372503, 0.04608744642130019, -0.06933312518732906, -0.28942327261837686, -1.5688691434905107},
    {0.014766836218424211, 0.5241555591891757, 1.5398051895585054, -1.6516779855709924, -0.3309557303421922, 0.5243286943032739, 0.23787739709289737, -0.7595054518769764, -1.4918736269979094, 1.274820173990979, -1.7546914387152852, 0.5370604305306599, -2.20624675757879, -0.059017907550145327, 0.10333617825968054, 0.22632739145848751, 0.46333343887355766, -0.7575863358487485, -0.16527418244645872, -1.4123959946217832, 1.56197490393695, -0.16545996965909235, -0.3733668107450844, -1.1242611750397409, -1.92480095974607, -0.26737202372075125, -1.6666663834385986, 2.4678658651732235, 0.8363167433323329, 0.5660491799979331, 0.4462405700584278, 0.9098648945105519},
    {-0.00983868166378879, -0.8283819000923994, -0.06640935281737782, 0.09217874583295046, -0.24409048455138674, 1.1189178340635448, -0.16318989681311327, 0.08891691754603186, -0.6286216725884592, -0.8306437885035105, -0.5615723078363767, -2.5022600885043214, 0.01485725347073986, -0.4479965761375567, 1.774631827566034, 1.0788846618445374, 0.795627976287908, 0.37162994366132146, 0.3665488359649713, -1.4759897789281429, 0.2137596165312239, -0.7775047002526128, 0.8730185356160238, 0.7723301001713679, -0.6380841374000163, -1.1747061159451617, -0.6774608147601564, 0.8679710082489761, 0.6024951057865293, 0.5722766637698239, 0.9812417558028871, 0.034304263736233055},
    {-1.7550210536302415, 0.34106259689475743, -0.006118678939382115, -0.8266177930282542, 0.9548288427112976, -0.6371141628526201, 0.5406373484268746, 0.0072507870067263815, 1.1654630034233542, 0.09357726273624299, -0.20651599193185755, 0.3669463763353133, 0.20666315942266952, -0.7346086388579752, 1.18634655533041, 1.7930700271867681, -1.5498279515341817, 1.646073385237816, 0.6418244415076666, -0.28355488878018326, 0.4594081985219051, 0.11802197028520284, -1.1981030762884213, -0.2050933101556875, -1.3930251867594294, -0.38046419509150303, 0.1256928197753517, -0.5127342998854235, -1.4650673536078624, -1.4629518083671273, 1.2384714049751044, 0.43630427574510355},
    {1.1609754430041452, -0.3975693461753891, -0.3743479591698426, 1.9159666630290981, -1.554438394263844, -1.1744336252941754, -1.2092465821987337, -0.06042286416575956, -0.07727902332780653, 0.2434533756827262, -1.503482447127201, 1.1503932538462178, -0.38592682886437946, -0.06430361921672158, 1.0997347356590528, 1.4776453367506737, 0.40799148389078077, -1.0988548797907007, 0.03270709416281688, -1.579813006957241, -1.1988449437712179, 0.09559096776715786, 1.7594836662077564, -1.1923883961775665, -0.33715613088469243, 0.0560518111472514, -1.5512826871114942, 0.921756555708937, 1.5694080369153007, -0.09140093515162746, -1.249982712955716, 1.1029477723258982},
    {0.7217552789428957, 0.5105915982024681, 1.3102638475184551, -1.18192446491952, -0.9911481731130473, -0.8110799696603015, 0.6679667944523758, -0.6548559187193583, -0.24683878818797148, 0.18686261247159242, -0.8696513693266119, -0.12080948604371772, 1.3134664762117636, 0.5681444741156467, 0.8634302127845682, 1.232736783322958, -0.20814106702388402, 2.0270155669130645, 0.737011738423853, -0.5488455583971055, -1.7581753546289773, -0.9938500693057091, 0.18256236668931716, 0.8715932489559107, 0.5156999139098271, -1.5897200235958036, -1.4405961814355344, 1.3037282484951995, 0.3794116486557748, 0.6667764909864473, -0.8027831597636732, -0.7970049069858605},
    {-1.6932350909132243, -0.7482875861584984, 1.1016246637014289, -1.0733066995199407, -1.39133207433001, -0.17969371170155915, -0.739028580959559, 0.8660600411178353, 0.6517075580594955, -0.27300768691387095, -1.1748587698266602, -0.9385164882578092, 0.4860682182413444, 0.09805891822146486, -0.985712198595754, 0.30426790334614773, -1.0700448429318663, -1.7000349394213197, 0.3711059733511521, -0.577355918740613, -0.7788501722312224, -1.6113710797968945, 1.5546425860968858, 0.6227652150512659, 0.4413712474571965, 0.3085438766967225, 0.20716966345585772, 0.0470173718633828, 0.12792691831462258, -0.30332594413480096, -0.282476502410469, -1.1039991530113338},
    {0.8512300815424111, -1.8521653443804678, -0.6430409372655785, -1.8955409821231548, 0.08136286828038064, -2.1487960548941145, -0.24350647135802742, -0.3255061817764063, 0.6474673990468576, 0.03711488884560161, 0.34771105445205897, -1.0696738552203275, -0.7731769305899309, -0.8207123144037802, 0.04191075281644964, 1.7608870473324132, -1.2153499214138435, -1.532167376027177, 0.5395592236220317, -0.1523998760228985, -0.6718628639601965, -1.4311842721830195, -0.9122258044659938, 0.5699646261844309, 0.2600847243778301, -0.7883736831986472, 0.13745830501426032, -0.0072763948568299475, 0.9238339472637597, -1.3665717896841203, -0.9120792759609805, 1.4306669506238396},
    {-1.7434796882313157, -0.2637119527449825, -0.20103826817453388, -1.4641121739168141, -0.9805920896363993, -0.03263552589354276, -1.1385184463021525, -1.227236154490964, -1.5440833698546212, -2.2549619209323675, -1.0686109310705463, 1.0216158051310473, 0.27913097868526093, -0.8865582853346009, -1.749573588173146, 1.120996633355074, 0.13534016926066372, 0.280519768702531, 0.7258026609245579, -0.8114046398816441, -1.4221216373441052, 0.08331430667784792, 0.5464752288040794, 0.13626224924669852, -2.0498210184527226, -0.733494511539565, 0.7741601013787448, 0.5781297647261624, -0.668033258075752, -0.13289422771951823, -0.28543793575368076, -1.1261091426763745},
    {0.22897528021895458, -0.14436098415786328, 1.6063491811314508, -0.5664251447986808, -1.569284235370577, -0.2787619600014456, -0.4003431861920176, -0.09989035535667355, 0.8427214203982994, -2.1681216066254025, 0.01320034061426452, -0.14394881392087774, 0.17486918829932788, -1.9488229414932785, -1.9541154786574593, 0.0682727089093004, 0.41099741162793396, -0.2809528615786006, 0.009759230372020642, 0.22417719160617802, 0.10819686183365251, -1.8182574569069672, -0.389057545533236, -1.3675906830185165, -0.43599124888547036, 0.25139057211776294, 0.6922300363792715, 0.06220125729869159, -2.2133366334118802, -1.6072672544495081, -0.4934902049246557, 0.5748489647809543},
    {-1.0747621784947312, 0.5179908470205583, 0.14358340681344792, -1.4941583457348337, -1.2455439297160737, 1.8355667045845652, -1.235672137117793, 0.15615548352970002, -0.8115608508782843, -0.6986275044352266, 1.0616913149864389, -0.19241190081162207, -2.004036571292583, -2.2427724766364685, 0.059592622399119013, 0.7152293782461825, -1.3748910863283046, 2.445432261120335, -0.38054737563449226, 0.4554725519589102, 0.12021471806264813, 1.1175687452528205, 0.19097642445516644, 0.49276264885037646, -0.7608946870034649, -1.0912033408333501, -0.12462762671847043, -0.8624432315774765, 0.5773323008273554, 0.9909042798836953, -0.9047992508168771, 0.34427854982484984},
    {0.37311027474268343, 2.338756208654523, 0.2619250210189478, -2.078215711284287, 0.9825144930935782, -0.7367584974838421, 1.4716615344082005, -0.10615481388938905, -2.4860385459707994, 0.30013332964011163, -0.4650720754314544, 0.3313804487907063, -1.4183419529844283, -2.947802932284598, -1.036716130986195, -0.03385509968945361, 0.22138581368601518, 0.8166850850702747, 1.1995644615144048, -0.734239113011606, 1.5256039315017635, 1.0791230694284857, -0.08147640563448483, -0.39778594427199143, -0.27028181361479925, 1.556210419301247, 0.765768072764931, 0.8735298274787353, -2.329343180233551, 0.541945966244374, -0.08988845922412514, -0.6301528270493033},
    {-0.0031280470617014093, 1.040088685101151, 1.1678361929298346, 0.0597442029663064, -0.16210059711035915, 0.09582472355491996, 0.7934402377454439, 2.0632496868900865, -1.794340082997412, -0.06526180927498774, -1.0129485314782185, 1.0408240322159834, -0.5208982210077604, 1.0215354428893495, 0.3357098139871419, 1.6274539421000935, -0.7147437615879441, 0.9362076703340216, 0.5953023579083835, -1.0929562937026238, -0.6674985764234277, 0.20344893350584176, -2.1972197289901283, 1.0676869602705885, 0.8448970234494999, 0.9117986210306651, -0.7612685811920702, 0.31830424472975943, 0.1471879524244681, -1.2046547847949165, 0.4279372933020764, -2.2719050926497304},
    {1.1308183167652903, 0.2475744487990963, -1.4056082308296096, -0.40833205801675554, 0.7426823471889806, -0.8978036800836295, -0.8156249317444234, 0.6751963491911552, -0.46584642216820654, 0.4554787596132862, 0.8258776244887261, 0.3414979717445534, -2.0312029145387496, -0.18034255988932987, 1.3986197849925692, 0.9268528679746293, -0.563039902335947, 1.1208829396835591, 0.3246473285423289, 0.676804839387209, 0.7624493748622627, -2.2779782365619363, -0.5368674500188985, -2.0991966555221975, 0.5740251083764051, 1.4935193564333906, 0.22113201233654706, -0.9109917713165316, 1.1569029293012427, -1.041577596614619, -0.778949465558847, -0.039268271960952714},
    {-0.21631060208773734, 0.4357907029102744, 0.8120123553532524, 0.8262533168057614, -0.5416827106690606, -0.301133755028139, -1.5251688144216742, -0.21437228478791504, 0.48250985294031606, 1.730112939559614, 0.1883776076991006, 1.6756195589403138, -0.36009409389713876, -0.7952926512668893, 0.8678127440062866, -0.4589554053479608, 0.5113971855895703, -0.0497742774962547, 0.19358613502147873, 2.074928601630033, -0.8896918277066523, 0.3900786121596454, -1.4486483526937548, 0.09153439659540115, 1.436178863298254, -0.07215399951424784, 0.22190559398380097, 1.564671732332535, 0.06600047796156716, 1.20075951719769, 1.1756422065686167, 0.10908136410704204},
    {0.45333364387428376, -0.952131292873891, 0.5646051081635906, 0.04525739685498103, -0.17707337020235756, -1.2571846918479779, 0.32867693814875315, -1.0306846818071196, 0.6816097406050627, -2.923155979115543, -0.04902921012930686, -0.5229898950664044, 0.24979052264479568, 0.2681227382900589, -0.14815334668765964, -0.5244963067762627, 1.06930542604182, -0.3387367700298045, 1.7022969878150693, 0.44628433161788333, -1.1924783101013827, 1.0135605982390936, -0.39094415999682613, 1.0471721261738627, 0.26655835185707, -0.9307362723587714, 0.9273411436419411, 1.3881682243935782, -1.1057089926805337, -1.0545058793403372, -0.32995563643194836, -1.7173098080085503},
    {-0.1642950810848293, -0.8308204145469394, -0.3747071875142321, 1.2949217420871642, 1.1561245235140858, -1.0745125475753325, 1.7325122473607257, -0.5537029557314962, 1.1756504278317699, 1.3314565491403951, 0.7071921173607143, -1.728815748126078, -0.5966900172895306, -0.45227048203250386, 1.3272386265688905, -1.9594509828533873, 0.3352736924810685, 0.902665334824111, 1.001512054169971, 1.3516501344643446, -0.9981448645005028, -1.2677401688871235, 1.0314979553457424, 0.49057812809307644, -0.48320558507927514, 0.32550930670619443, -0.23405956375703263, 0.4999012547982574, -2.2828396051666537, -0.729585138765183, -2.5486875713708086, -0.8327777565479748},
    {-2.4829430236066323, -1.9439179386222005, -2.2541353225292924, -0.053378986090188756, -0.9008207005271854, -1.459923270115473, 0.20828278978357884, 0.9515228668283393, 0.715537631077338, -0.6647033609587318, 0.6660052599996601, 0.2621845823354015, -0.1628330333770389, -0.3655358427412364, 2.0132208742469193, 0.847487350073838, -0.3023266398120101, 1.8643263114076154, -0.05301048320065028, 1.7345080071312864, 0.23104055349575672, -0.48711225055230967, 0.6623345371480012, 1.4997689701117738, 0.42678975465055186, -1.5959221140714945, -0.5585004029178144, 0.35711492229371544, -0.9069449778483274, 1.6879573957932155, -1.1534213293952107, 0.7806669527208674},
    {-1.7951681650940492, -0.9764775870495201, 0.0031122490205552243, -0.1846274087664785, -0.32458550169957356, 0.2705543292060807, -1.0951705168591863, -1.9820401381807085, -1.4120476619603315, -0.07980659559645248, 1.2735167804867338, 1.0741670779836163, -1.392365032143248, 0.45090694368261414, 0.3259226889951379, 0.3543737636270288, -0.11604442406612585, 0.25639607280943294, -0.12668002612716095, -0.4398795013284982, -0.7517769289518293, 0.29553547970857813, 0.02509228456121398, 0.3731139894958483, -0.1541446435697645, 0.08883844573360186, -0.9292076010073422, -0.5691855474769543, 1.3993529455759468, -1.551187030673715, 1.654137741645136, -0.6043629212346647},
    {2.104886739381027, -0.5551992453197737, 1.2180668123178908, 0.04231449066095316, -0.18126511199621437, -1.1078115723508195, 0.7115487735980052, 1.0940339795522953, 0.06900020063165065, -0.37070532229537956, -0.19626778723649319, -0.36593093951186695, 0.004967553949791901, 0.8754912812915678, -0.47918066417822525, -0.538880150753103, -0.886953459151591, -1.5314570492990618, -0.47714079665586856, -0.05504625065204754, 1.0554076248466002, 0.0003756817674710293, -1.0029273538688326, 0.9168368980431767, -1.1419787550493883, -1.56091066738418, -0.259892038547606, 1.1650770048205366, -1.0079723542422283, 0.6902758148161758, 1.051834922555238, -0.302918281872952},
    {0.36629181066244987, 0.9275911101710398, 0.1857310013371144, -0.13679296848180997, -0.3456874208919482, -0.5533244700165253, -0.2765519116361903, -0.0525722474152435, -1.0381077969242758, 0.6911182986305363, -0.4620061200913132, 0.9172785409734175, 1.194335228143925, -0.9447620579001554, -0.27104964184149316, 1.708485609690797, 0.8631205318562224, 1.2777213079229923, -0.14498943115049706, 1.0842965601964454, 0.2678926839943513, 0.3727630562796903, 0.1381517358959622, 0.339155048756297, -0.3927058005792463, -0.9498910976024451, -0.5895821475415081, 0.8608410700849184, -1.2960489342049306, -1.3448034831567268, 0.03341922647009237, 0.5777305043779549},
    {0.5124393319233854, 1.6499889825755305, -0.6070661648813497, -1.0134117578456039, -0.07897622238684694, -0.9076670535830742, -0.8601604059329224, -1.0010367396040052, -0.6331817325358446, 1.0970298024619292, 1.2953784599496352, -0.2804368253524922, 0.614909663892868, 0.22281695883874925, 1.1709668582390713, 2.0956424349588714, -0.25501635838814785, 0.6889167323360584, -0.02316484020874173, 1.363008861592851, 0.28038196092451223, -1.8910601496076271, -1.5142518922698989, -0.5905833787792053, -0.6878781220097143, 0.2698980271191278, 1.0548319595201683, 1.7110829982182956, 0.3192848581989835, 0.771117417020627, -0.545386864107973, -0.24527852926375723},
    {-0.8326217154875643, 0.8514902246837696, 0.720170907248811, -0.25362175939662623, -0.33527476799928474, -0.2993339929126846, -2.018658331022255, -1.1369389808457415, -0.15923358674879692, 0.1595753115214167, -0.34831617925751523, 1.4697806019336008, -0.19238173728267566, -1.549590848891315, -0.11567566440271357, 1.2688477057270382, 1.4476255949777543, 0.27125115662969523, 1.2741268559690238, -2.582376413048112, -0.1876845354414655, -0.9760131530023024, 0.5619294494747716, -0.16889920192037466, 0.8481125373236691, 0.43550885339033046, -0.9212040722646495, 0.43557587800167796, -0.5065661034906903, 0.8388152407659263, -0.018036397454402123, 1.5761615182818118},
    {-0.04513962057945128, -2.2704316630156165, 1.1748859186576293, -1.4981334727286124, -0.2988231482145087, 1.8954214530498625, 0.8452121411401926, 0.3040332813820801, -1.4420483592051137, -0.2500627917509308, -1.3233810684207041, -0.3728303369474255, 0.8879642550038618, 0.6084150826062333, 0.22717174403980986, 0.5290086451520519, 0.2673905760898333, 0.03109734257222307, 0.49845795486856836, -1.4443324230178147, -0.736180541332654, 0.1745888346404988, 1.1706899230600898, -0.4361487390096155, -0.9515022674613476, 0.3050066591953107, 1.1467843563638984, -0.4406288477676727, 0.004298726743980955, 0.8701834654833834, 0.4757987686522589, 1.20339981131562},
    {-1.5844182782669656, -0.35107357811437656, 0.06949520933465751, -0.035645762539056165, -0.5478989992813061, 0.3287270583725709, -0.12215790441444097, -0.06814385752552218, 0.45642920869269593, 0.3709489277822734, -1.1115385519536691, 0.13171932866657704, -1.0740962270237884, -0.715384509034382, 0.8609985883551513, 1.0508193218395787, -0.19673063886121775, -0.4413389400591381, -0.030036353160980328, -0.3521795163611153, -1.0354819393072408, 0.17261214404168712, -1.527344804415847, 0.2940398659595702, -1.3268943976058232, 0.0035794229262795297, -0.5418862517455701, 1.265305846001732, 0.12846284980643802, 0.7349835749841818, -1.33902898549123, -1.7641962230397403},
    {-0.297047916125877, -0.4717529467037053, 0.17333008413566323, -0.8791358324801384, -1.2090465230097576, 0.006687284376801214, 1.624661311340901, 0.07549052298058717, 0.3247727441637411, -1.310173535114391, -0.10087816979196539, 0.40788251093608485, 0.8425599116914436, 0.47947865491890135, -0.5476836041470146, 0.5832366339549335, 0.9200018248036587, -1.192689349077654, 0.8272005800948609, -0.47438876892115867, -2.1817397903213713, -0.8958108512701836, -2.507110283536828, 0.5605535992253808, -0.7459094594643887, -0.1455317350789257, -0.16330051679889562, 0.6107454575145712, -0.29869341992275694, 0.3696927067797241, -0.718008218472367, -0.7822482082682188},
    {-0.4953238271521417, 0.6224969271965525, 0.12470363413853955, 0.006880416418594035, 0.45961340932347705, 0.13559063939787058, 0.2644363126654735, -1.0128476851605233, 0.9488732192984509, 0.33241986909859145, -0.45479791291676475, 0.5770712409685094, -0.0016349651965298843, 0.7364763546311457, 0.12252987420478255, -0.9105135473408773, 0.48672416577511657, -1.5137639937969503, 2.6974531047171153, -0.21015024070192395, 1.4126962143764044, 0.45125076753140886, -1.0170564313404873, 0.8412024290607177, -1.3252589066209561, -0.8766623154410244, -2.9572325934819674, -0.040656495399625035, -0.40094296937638274, 0.381066807426556, 0.036208910269358005, -0.7539309150422701},
    {0.5448258049121308, 2.464934111857456, -2.507981016277609, -0.32831025638883476, -1.4046105746031574, -0.13246429344209157, -0.7582653630410325, -0.32957342600291684, -1.4083994588532844, -0.04648255137786416, -1.5524415542389107, 0.11127790290790054, -1.913777940730814, -0.5103886746082312, 0.6877596473473131, 0.5904607078975805, 0.3924063178215657, 0.46576440731709945, 0.297965886437657, -0.2955876449228356, 0.7770554845664476, 0.3257940200249493, 1.8149734652471454, 0.35945264094326557, 0.5785104037063699, -0.12091403994672267, -0.22108380286751037, 0.4435526866554113, 1.1833453095626285, 0.9888690634677115, -2.1863781116372283, -0.5127255930962978}
};

static const float b2[32] = {-0.07303120013032657, -0.13753905873469835, 0.2423522772922877, -0.16851065084595895, -0.5721873393409658, 0.08012046088203666, -0.4373395693544644, -0.15677368913007325, -0.2579865893745597, -0.48716679565520715, -0.41834102691454594, -0.19828242575897884, -0.20365112932394236, -0.3162750122758947, 0.02285507850701827, 1.0206106408862794, -0.08448916835790941, 0.5025653198339574, 0.44803575252110966, -0.4270737188053357, -0.39587697221062074, -0.03000503860062101, -0.019284607978249206, -0.2366609383904928, -0.15358420788246768, -0.5166502043885831, -0.2193173442821296, 0.6117573227683951, -0.2084596811853675, 0.06861586902553579, 0.24571240007837314, -0.155864380691478};

static const float w3[32][16] = {
    {0.5716640874939329, -0.39422366251240876, 0.718142655113392, -1.0502421287201205, -0.4681155222702335, -0.09541858072042837, 0.11439435312453534, -0.2895510165089006, 2.054043484723797, -1.2861557269671144, 0.29757625547468497, -2.1270536331197336, 0.3959812814570505, 1.187329605006153, -0.7521574667968383, -0.02165709942788782},
    {1.3246260115877782, -1.7201650336840817, -0.9622895884865772, 1.0623945029639357, 0.7430954964919527, -0.48699425567422916, -0.8842074693875801, 0.8129099442444457, 0.40752599812320206, 1.8515676205819198, -0.027015194143289418, -0.04022276117705835, 0.8651800154033804, -0.37988001217610173, -0.7472534171335005, 0.569474256838985},
    {1.0869019481798867, -1.9306328996413922, -0.6875909950620797, 0.17256897910055924, 0.24315534358825128, -0.7738439497200065, -0.08326483332572557, 0.17559045422468858, -0.6458535451213051, 0.07831448234703262, 0.2594726691709153, -0.02069290673897641, 0.9925309073096323, -1.3554632839455603, -0.38797748195511095, 0.3880009548493304},
    {0.08409680473492288, -1.1998879398279287, 0.5335999522927328, 1.3733789981374975, -0.18329202696786553, 0.6503480421860826, -1.5532270288304237, 0.09961174400059948, -0.5726893670638791, 2.292550699492414, -0.06613552474520454, -1.1886203637394943, 1.1239377181740253, -2.3834992910853026, -0.053054391959826294, -1.6933893485455485},
    {-1.1964427985070756, 0.2089218926168881, 0.3994367858717421, 0.8250331224577535, 0.09326761458953473, -1.1516814299442988, -0.05415461851348857, -0.5824317964249732, 0.8229786125968727, 1.341221049934025, 0.14101505393212665, -0.14216367143267067, 0.13827458283455882, -1.0599029042842494, -0.850037360591686, -0.3180090809135821},
    {1.8820337863124552, -0.9982629432158111, 0.7205728299998244, 0.2934314141679763, 1.319378859137389, -1.2553469326498259, -0.26024797143207623, -0.6796357256469135, 0.34492164528849517, 0.28912927849728454, -0.012900869079231474, 0.6018697345212056, -1.265518616727437, -0.8220821106958502, 0.3599092281085347, 0.277246891094738},
    {-2.0441755227099168, -0.38355798706929634, -1.0289663749998, 0.2268752184446945, 0.3027339143747424, 0.839246634941111, 0.8313781256428564, 0.3751233689753437, 0.24889961286020568, -1.6204975290239898, 0.5490034717919381, 1.0445495914233982, -0.5655945795658456, 0.1792115527057003, -1.9193917349737046, 0.8543904042444633},
    {0.06946705880348947, 0.4600947365022254, 0.4024232732449305, -0.7367125109860236, -0.4625437043182184, 0.2559196023036393, 0.9474808635534722, 0.7768326278588021, 0.415815446595238, -1.0057138854680825, -0.55746884042489, -0.08981640899028692, 0.16927768134566618, -0.3085359692978664, -0.14437074044984388, -0.5181437223986727},
    {1.058537185012332, 0.07789270803930634, 1.2201858126547054, -0.5455104014799866, 0.12774929802080034, 1.7389468609706322, -0.341944043697399, -1.1157199251372785, 0.6567264367297665, -0.03465238187075409, -0.5057778595986713, 0.7679309527110717, -1.041261550283178, 0.6925334511432472, -0.09362874326355136, -1.4711367365494616},
    {-0.20355992910710358, 1.0702808096770036, 0.40157406795407297, 0.7567105198162928, 0.3336447847803907, -0.42640313435571614, 0.528112254398939, -0.7617624941731959, 0.28188688986994476, -0.8863804475083515, 0.906946439369242, 1.021363232105748, -2.5406979532217844, 0.5516661322342544, -0.5363994008100518, -0.29004289641651315},
    {-0.9437805240686856, 1.4792689988018206, 0.04638128626041299, 1.1015052539907484, 0.436899529360413, -0.41662677402777903, 0.21319350629060982, -1.6211576285284341, -1.0438106068130741, -0.37618559427864634, 0.86089796722958, 0.036615036065503544, -1.3501790271357839, -0.4681661328393491, -1.2573083389743747, 1.4308758953388265},
    {-2.261721242489677, -2.6073122994370603, -0.56411139058694, -1.7714003263224918, 1.411639105729818, -0.3453204606861666, -1.1343628649567032, -1.4490211173696501, 1.4469694789798102, -0.7342978594710821, -0.3195090472260354, -1.0560519586906951, 1.549262511051412, -0.5838886101620515, 0.11244458512410137, 1.3508414294079636},
    {-0.0049732511752844915, -0.35518869864846486, -0.46772859053001214, -0.6216178538187916, 0.9579850691381951, 0.5235895002553271, 0.27034353380546516, -1.2821159598748209, -0.29811778488372476, 0.8273256915640351, 0.8090148833033741, -0.7927024999372647, -0.12680244361115212, 0.8841297217111505, 2.2575935950415924, 1.5220125241556601},
    {-0.9404631999197899, -1.4684439301853596, -0.7900985659182297, -0.2004556971751898, -1.093755737867266, -0.7694868872747354, 0.2984369546145376, 0.406367071236236, -0.43333686431405094, 1.0813966962449262, -3.183935891281486, 0.6195194925691773, 0.9818734673309609, -0.5626844694344446, 0.2987811193629733, 1.0703995080223434},
    {0.9145198996858339, -0.7890207000411362, -0.32537336089264235, -0.42264854575990135, -1.6190649267088462, 0.5024948708754171, -0.0466441875419573, 1.0111751139413823, 1.4871628543715554, -0.7577704115142574, -0.2021645728252171, -0.4966412908316729, -1.2697822705379196, -1.117346069733226, -0.023050051159943054, -0.2015195319559576},
    {0.7068627831104692, -0.8680148365890018, -0.6529703601686944, -1.0288065555097679, -1.0992263834750187, -2.02262489676449, -0.3495706576410381, 1.0030025757000631, -2.938016093979228, -0.7381494192678731, 0.29791153318064095, -0.6314254809066309, -0.384553342259513, -1.5176226959045502, -0.10233987122816299, -1.1843096046000832},
    {1.1615801364820273, 0.3143317990743298, -0.17863030058821727, -1.3523478459144425, -2.35581605377256, 0.12266728859122425, 0.5769652845800355, -0.5037501031875677, -0.7149653047890336, 0.5209151022826979, -0.805665454170057, 0.7333048997380993, 1.5680539815716028, 0.3877849805105979, 0.11927732935002475, 0.03007229132371346},
    {0.025899868302716667, -0.51995545572291, -0.7877286637071351, -0.5489286137624466, -0.29655619106086983, -0.2745199731653872, -0.7059633549588722, -1.2056269660086747, -0.8495410536785897, 0.5289545211717078, -0.4633320082099121, 0.32022863221714604, -0.9119186973205116, -0.9901491306183783, -1.3821480453786736, -0.989544377793531},
    {-0.6017695478508011, -0.4734150711394366, 0.3698806557387797, -0.7023016264782835, -1.5720974213722851, -0.8573297563947853, -1.0956035706876626, -1.1705169724150513, 0.630037094993407, -0.5122338140263895, -1.0049169316492659, -1.0704285741346915, -1.0407720979419168, 0.9105940877097815, -1.6834027313879614, -0.41958670793995156},
    {-1.6650160915770278, -0.615978021646844, 1.1800127893258117, 0.13248657988765283, 0.22392095104479126, -0.10074037312256517, -1.0493278026463901, 0.5556438934782112, -1.1036625218692002, 0.5946059320442361, 0.9975986084934426, -1.781822517293431, 0.0380424365909645, -0.024670198776311006, 1.1719265173297757, 0.8826677350073235},
    {0.06287967022525937, 0.429188576462657, 0.1229163548169012, 1.7105809902948197, -0.7103949429280985, -1.1482360477923976, -0.10454513154810435, 0.28238320678041395, -0.2358334834328455, 0.6500007352868575, 1.1703119733565026, -0.11182871507554502, 0.1872997346909983, 0.1785567614712208, 1.148293584845173, -0.134911290472434},
    {1.4028459664716912, -0.41356841398658883, 1.1978975093356985, -1.019398554251424, 0.11543302579273229, 0.18169943741760214, -0.8103857115399212, -0.039482520658029915, 1.0113846759081748, -1.056446949135259, 0.7243413907931021, -1.0177412926940974, 1.4942050865547973, -0.11461641099973321, -0.24807857497384056, -0.5217829624288529},
    {0.024441732263271187, 0.8865974277975088, -0.9793703480764329, 0.5141860897675434, 0.28586400606357754, 0.5608508597324005, -1.4831356632741088, -2.1112896541750508, -1.6460255357758613, -1.225792443842971, -1.2998765539118435, 0.4711043058598207, -1.8011165225226344, -0.2741057631873607, 0.1274394950188823, -0.1560073819259012},
    {0.12621148103951252, 1.0229072890035675, -0.48221915920004804, 0.1355358706586392, -2.1659704624667784, -0.12305494091428645, -0.1666239373559747, -0.008318118194139554, 0.5623098659716876, -1.1197470065011266, -0.9023013118912495, 0.3305672170479874, -1.1792762584580636, -0.6642845782668994, 1.9333150535331023, -1.0440214653302546},
    {2.5425048030868433, 0.30441935352707356, 0.6934948575944082, 0.021762631730030218, 3.202792624302016, 0.40031168221504604, -0.20762239013965383, -0.06389739842951501, 0.49592391481857817, -0.5581944085206004, -0.8161387489657785, 0.4059858906399125, -1.95930735665628, -1.349406271580392, 1.2826322781280706, 1.9052303375969217},
    {0.032913304875679096, -0.6402597189374244, -1.2125346075402517, 1.5936790817594078, -0.2012478819732129, 2.154638480817864, 1.1931178962158497, 1.153717763576474, -0.01774891519682666, -0.643771080902528, -0.10755737119423923, -0.7328557592020624, -0.7394337897626522, 0.9885204159801257, 0.7914475482241511, -0.7123103545996369},
    {0.3264666590076052, -0.2725951957257095, 1.234464365020797, -0.4026739169396052, 0.5663118770904165, -0.45694090195464193, -0.0880832359421112, -0.8455725941626066, -1.3654615380585646, 0.5290974935804044, 0.5162528378401579, -0.8986064806749345, -0.2869928927395616, 0.6509357059490909, 1.5354940237309258, -0.037459165396193414},
    {0.9170233690058068, -0.15754908769468537, -0.9692690856884425, 0.4331769663708553, 0.3214768176554504, 0.5655327701195221, 0.16255766461701293, -0.43828412026909963, -1.2837877591488047, -0.7072461883026103, -1.284941416023295, -1.1468059467103453, -0.22974199270371076, -2.307431348716632, 0.6446496505071799, -0.47169218764402315},
    {-0.6192225781565979, -1.795888758102398, 0.34019486910105784, 0.3404405953965913, 1.197963174899104, 0.48475600199680186, -0.5460412916553826, 0.6010936265546871, -0.8662324531983754, -1.0827526986004734, 0.18897662430012896, 1.1204675562368944, -0.9462737677238857, 0.4108595936657684, -0.6614189086467706, -0.43305696970755625},
    {0.4990695526019273, -0.23762467503092985, -1.469649969292175, 1.7477690619013677, 0.5084990343515914, 1.3272735029782823, 0.21300988729690648, -0.9934396480705942, -0.17429320303731927, 0.7227625870715821, 0.2545979058102912, -0.22315714486968208, 0.8834985665327412, -0.3652485577840015, 0.751034819288351, 0.9076878489031905},
    {0.14217237268851013, 0.021116243677527347, -0.7530401933298436, 0.7939793846481155, -0.02823016208264657, -0.8174107367266519, 0.26033201873993145, 0.5867985555896835, -0.29706919479649857, -0.8087404289559875, 0.35055288703256676, 0.14555363858108875, -1.1907304872645454, -2.8134530408083225, 0.009924919859482106, -0.8548185856576762},
    {1.507405438369883, 1.1686540082961336, 0.7051585353871701, 0.711348975967349, 0.3284639983778799, 1.3383254679692786, -0.5767182917941327, 1.399630909243523, 0.013340562855420053, -2.401198899509768, -0.6303643990710939, 1.0437723725425088, 1.2527427788426273, 1.220340386895498, 0.5338957155628312, -1.3286573672135045}
};

static const float b3[16] = {-0.22948537911139397, -0.47719039066230207, -0.2946181947866439, -0.5781650811985451, -0.252492254414691, -0.578015679093767, -0.04519335335423282, -0.3757530339509003, -0.5798902742988609, -0.4649356221852532, -0.45313803692280213, -0.4510330691915087, -0.41694845448310236, -0.4800961800945733, -0.3565856469292455, -0.28632692033764146};

static const float w4[16][12] = {
    {-0.5587635970833305, -0.2893267214704135, -0.6405347575380479, -0.9068910431419396, -0.42002526585292277, -0.5171604347498832, -1.417516019572228, -0.3102653784399395, -0.005784758952031672, -0.47129674283610823, -0.40369529288814915, -0.6996852511400787},
    {0.0078097998141697465, -0.2542521470794124, 0.8435636371908507, -0.6118556198933829, 2.0061637366531713, -0.4162809813556422, -0.5279385635520206, 1.0770972157428367, -0.5907790464786382, -0.012457337599691778, 0.20236365641925827, 0.6600806662976859},
    {-0.7573107444367774, 0.6226300816550296, -1.1604935307234163, 0.9506582419943906, 0.6961995804052897, 0.970310136995977, -1.0901675024998918, -1.7932353767181026, 1.2060636440046337, 1.6013186011657257, 1.2975474588972213, 0.9903910191261339},
    {0.3887448586629012, 1.1891426845765156, -0.5362662154219078, 0.8028816502556938, 0.1801303151820116, -0.00965891435703535, -0.7533263657395131, -0.49972017935196406, -0.8505099109080511, -0.046646665330489834, -0.10543116310139788, 0.1928647112576067},
    {-0.06347889425128156, -0.78088086936853, 0.23720667312600008, -1.6841872343569124, 0.06432759599608968, -0.41568417142988556, 1.491261830555692, 1.4655788359374167, 1.8276236067599358, 0.3645037490443288, 0.11313619232662955, 0.7038809067990535},
    {0.5744720617386239, -0.9214655316985175, -1.3654300991561072, -1.8482262843121797, -1.6077513430385437, 0.23905084220252523, -0.1842579701317048, -1.4901202757011778, 0.7365348221336069, 0.7767375407084522, -1.477735130824933, 0.22319807093283972},
    {1.791346872758274, 0.44440461147457994, -0.9800020201334732, 0.7989463201471159, 0.559202518082501, 0.3798697271633388, -0.7840730525800014, -0.4022559913850789, -1.383702235182241, -1.8819153593235354, -0.018268723393899552, -0.01016567830080517},
    {-0.599882011293623, -0.5224783608913474, 0.570011336300895, 0.44061395555616256, 0.4559523800369807, 0.873133746503966, 0.7759064627187138, -0.5028534163286167, -2.1113854203499582, 0.5765713174152024, 1.013311232386346, -0.8621051541088582},
    {0.6925437978294336, -0.40893575581275565, -2.1633351749610537, -0.12033805426152512, -0.16325742959206727, -0.8237668462381008, -0.19429004809257738, -1.1010528129273074, 0.011936797589595687, 1.299249690289326, 0.09188900410967149, 0.3763845482100808},
    {-0.8725806361299719, -0.8419834492634714, -0.9920258749361134, 0.28497589582590366, 0.039114428515647955, 1.38399079262682, -2.2747510545148835, 0.009476243659296783, 0.16447167726632972, -2.0412233702760294, 0.9020531948427383, -0.006654289701460137},
    {0.41928740003519543, 0.7908919116353597, 0.6127363186143541, -0.8002362699114318, 0.4720087992858415, 0.3787088067973943, 0.1321197143689852, -1.2055013869153715, 0.08330698102035211, 1.2045439659577053, 0.5581002526569199, 1.0860393425821757},
    {1.6667425635072721, -0.6181937772902926, -0.11820356346691609, -1.037077105674504, -0.8025724831930849, 0.039574467431782424, -1.8754799354309815, -0.12489237846545218, 0.23231475764289994, -0.8192784761682471, 0.5644060028184796, 0.5271815402493197},
    {0.2881843406622713, 0.22523003620845397, 0.4764481338958007, -0.3351582019534542, 0.8907359042794647, 0.8205558468450034, -0.2922716229025963, -0.9062878988403, -0.7011562883253297, -1.6647753355509545, 0.42050547459968846, 0.9767561661840799},
    {-0.8152183971582276, -0.3996226071093157, -0.6224879860118352, 0.8727884805180294, 0.8160680586774776, 0.420913069265243, 0.4818954509675281, -1.6088966851918691, 0.9456380800041968, 0.26660169048743854, 0.7808731031866357, 0.3434148577947374},
    {-0.21702348955524153, -1.6936308201265844, 0.2507456025321712, 0.27796680058330153, 1.0115017600369154, -0.3844076843794578, -0.1534601038158667, 1.000186853141069, -0.7828993052588507, -0.5705597586664773, 0.812046977835948, -0.0742425659112472},
    {0.7396189166680759, -1.6877534465284791, 0.81941663920071, 0.35106747644778896, -2.5675235784014125, 0.057282928444212074, 0.6863043879362298, 0.1511715347567877, -0.20978885189113097, 0.6160963803229101, -1.0004784857781206, 1.0091111217790023}
};

static const float b4[12] = {-8.724915266272584, -8.831661120165998, -8.787849725795898, -8.758965674451991, -8.757235135603676, -8.76094025030732, -8.798566367460083, -8.789575373829043, -8.829130511865557, -8.700681557194086, -8.786051761899074, -8.651119563364366};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
