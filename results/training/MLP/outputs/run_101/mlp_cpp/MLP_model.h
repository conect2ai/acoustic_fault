#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.175061291439297, -0.03787601813829499, -0.264084073569246, 0.10778469157161179, 0.3651382382160745, -0.3073053361428121, 0.01735682051656855, -0.09397329976147704, 0.4388379076199453, 0.49545025774887935, 0.3653009111670936, 0.022396322280056558, 0.027562206773358827, 0.5538168983154506, 0.3023311334581856, -0.5801718775939033, 0.38553675289490763, -0.02477089703225237, -0.08931507194282352, 0.28187166916352685, -0.6879873693239666, 0.5154697739223183, -0.6423885489500215, 0.6460432064561633, -0.11305017746521831, 0.36009262819058374, 0.05713649111749351, -0.07653400349264149, 0.5968395306087814, -0.03344309199707569, 0.5731192277027372, 0.3720296598414916, -0.011274048501505034, 0.41171797429748475, 0.7506993850073947, -0.22394935540657618, -0.5580213765769414, 0.6654563493529463, -0.7453968417016271, 0.29250238078289464, -0.08423801588235076, -0.23060533965304209, -0.439442921203467, 0.22592666608686568, -0.36157455120227977, -0.22463993511897323, 0.27086435419916155, 0.03184559956826438, 0.10731054523053483, 0.6523556836952846, 0.5231400374409466, 0.6287092638433921, -0.35235662914809557, -0.6139379246726261, 0.338455677558912, -0.30544151106959205, 0.3697783233102354, 0.5088634248685056, -0.43531026803953904, -0.001937774448071232, 0.08418113626364881, 0.41712910228573186, 0.16482210116781298, 0.48480471530488034},
    {-0.09904860065184894, 0.17802093788077875, 0.11055386612492417, -0.5986099694068507, -0.642769850647236, 0.0968667868110384, -0.2419870569908444, 0.16162128637700476, -0.06469483889795806, 0.08430288668437054, 0.2065117350228197, -0.3051107498839083, -0.3186269054358206, -0.24199836400854047, -0.6741622317119675, 0.016332224205861813, -0.3326945335449782, -0.403510057010585, -0.2799760359040732, -0.2727068945951418, -0.19989161334395228, -0.3432709723737067, 0.4574735103037923, -0.6694965990888061, -0.10877909001227248, -0.7314891424134787, -0.3215896680975603, 0.24444897427205514, 0.27274283099758395, -0.17584359935073768, -0.4073860007007153, -0.30899434861129166, -0.5762663543215427, -0.13426341593295044, -0.24833676153015014, -0.2207856904083377, -0.312057258824549, -0.5530105014342357, -0.1763627379816579, -0.09984873653621158, 0.5703498941883252, 0.030158214416350655, -0.22762294243884168, -0.23117478052663315, -0.4746842261933193, -0.20867157254235005, -0.5312443917925935, -0.5793694561543024, -0.8650951622646257, -0.017649259932458687, -0.341399076456496, -0.6067830472891123, 0.29682737036494955, 0.7116689137418535, -0.7823302315056356, 0.4575514905759296, -0.3923630020536239, -0.2441929957304263, 0.3934155936235643, -0.790320267410659, -0.017844940366760334, -0.8177141754429952, -0.6348379808398302, -0.7867133878975288},
    {0.7049450670152673, 0.6067935162120761, 0.6714606483767902, 0.11919100053396857, -0.038105347310593785, 0.29228918989758707, 0.7590882746276413, 0.6864269118343924, 0.623385632602127, 0.31798871463143824, 0.3609535382554052, 0.6951638745142588, 0.8684748854401085, -0.38437096568001067, 0.6542316086952272, 0.8470351120696736, 0.33613498436176326, 0.3779125599768346, 0.7699666839214186, 0.8057948773656677, 0.5371731288042518, -0.4707298955375447, 0.7821929809313666, -0.0491020697726425, 0.686386412744332, 0.015135257665780109, 0.5426285346889684, 0.6177410969110515, -0.17551358243519496, 0.7979622196760685, 0.75340295988912, -0.3809454674849829, 0.8992433812628113, 0.7382594239458504, 0.19775724227981356, 0.8949027146726247, 0.3633873956873979, 0.4080375401199772, 0.6409514479606362, 0.06384613267084369, 0.5275786503683153, 0.45711977981517404, -0.3506188532425271, 0.42428173632645483, 0.8680181148621147, 0.8538284285030242, 0.8261581139946635, 0.3683891055642095, 0.3005359158744227, -0.22111848634127515, 0.6185174749462686, -0.31823160540465173, 0.5253356194649385, 0.37559091096551595, 0.26354674036901404, 0.5411235922192021, 0.6570827827305171, 0.5797548776942655, 0.42851721700088413, 0.6658354147508965, 0.711822614929267, 0.0345814442559224, 0.9804142361049867, 0.39492917726849036},
    {0.7104968069131603, 0.7899619458564133, 0.02898458264150252, 0.779281066623015, 0.34656639342041, 0.3130504028587204, 0.7242367470725181, -0.1190784858058802, 0.49900961947209227, -0.2431136132934352, -0.04536391465413935, 0.5203948780148812, 0.8031589788827859, 0.3244186923601414, 0.4579840357159212, 0.42174200117702987, 0.5409564315437562, 0.8809601652131477, 0.28308247967953465, 0.43310445024896793, 0.7095737258394501, -0.02046186432781248, 0.2836577183680343, 0.6415377664549909, 0.45775726224130636, 0.47810853440817697, 0.5798833062617066, 0.2998716847079923, -0.7411001339968663, 0.6853003412337707, 0.8609861874504995, -0.3260541508196909, 0.996373795100574, 0.6772166073647128, 0.23261957085551654, 0.8117376205839119, 0.3949914711195631, 0.591629102462126, 0.43110058665035766, 0.14390908072818204, -0.3240243562200467, 0.08283782214539617, -0.31286086148922143, 0.42197985477270894, 0.6561593665650666, 0.6618563883225885, 0.9808101512247548, 0.6218669209193173, 0.708018029725306, 0.24653483817439933, 0.5778136931167376, 0.30567559982501896, 0.46749713416030925, 0.16959509281031582, 0.5876238728823604, -0.029691432590328273, 0.829296988718388, 0.5664575562103149, -0.3873926124203185, 0.9283545793006689, 0.12932591294974705, 0.2658176567993684, 1.0286626908787908, 0.6831765137585566},
    {0.13295687875475548, 0.30723121465609743, 0.39556979221167476, 0.6538628494891854, 0.3620442573933816, 0.4721186397067121, 0.8829975621046958, 0.4244596178831686, 0.4453526652374603, -0.5287420220419946, 0.2337211389537759, 0.8963604852018557, 0.517863182080909, -0.03138516374180468, 0.5657183860713512, 0.9306762470043064, 0.7788156827010645, 0.6342644778510369, 0.45792784443666645, 0.5710553358000111, 0.47299832520037155, -0.41837883064426074, 0.6192134121482977, 0.3773909055246054, 0.9041041650439265, 0.14958250272587642, 0.7303750983089792, 0.328604162955584, -0.5676688573230338, 0.8656256646746595, 0.6882776057889238, -0.3908791284783323, 0.5006940007353969, 0.3824763175025149, -0.079744239924404, 0.8194600440242649, 0.8367046981843038, 0.3535439993133826, 0.7011899699396836, 0.3004811446210774, 0.11595458668201929, 0.5915893526243224, 0.5477589884951694, -0.03221096922199558, 0.806530681842146, 0.5594511084423863, 0.7668836920715293, 0.3870655910408862, 0.70363983391458, -0.4548516726850405, 0.5452829624434726, -0.38170135308259145, 0.7488776604903149, 0.07654950491471303, 0.6398326687670752, 0.3740533107148644, 0.4216259130711274, 0.7493487914659536, 0.4176419611438991, 0.47360832107859513, 0.38636919975192496, 0.43000426984964707, 0.5274834932244374, 0.29163270888589454},
    {0.3016235411319972, 0.43097593487904706, 0.9420570553392267, 0.7175176074483627, 0.4226955800460354, 0.49857616635082547, 0.8038041470061736, 0.5159994628906004, 0.29224243654680926, -0.3695050373082532, -0.27843206416391686, 0.9836591129445487, 0.742685515905027, -0.07110949678368558, 0.18241910560618305, 0.7895433441479905, 0.9480821276122564, 0.2004774565215857, 0.730769172704553, 0.4672788339982284, 0.9820081594469093, -0.7061742141404599, 0.6668002102842685, 0.0001194366727621847, 0.9250589370349, -0.03541685748318466, 0.48233025126338336, 0.28942123542105774, -0.40339854050500307, 0.8181312560883999, 0.4599482955271457, 0.030973365227640454, 0.35736380068193174, 0.5096540311875541, -0.5268666981726245, 0.9806892385280926, 0.8200838255573162, -0.11838412908526796, 0.7747366448791686, 0.2795484139369775, -0.14952279902747687, 0.40153411544205037, 0.26722765729328285, -0.004444420098774639, 0.7852380235473542, 1.019095246171991, 0.6637209737652927, 0.5300585425856439, 0.8486833295731374, -0.7848517948661665, 0.13746571455218534, -0.29124485436231573, -0.22157337239834257, -0.2774795517650666, 0.6178700746098366, 0.520822851187244, 0.07868129491223538, 0.5977571657290962, 0.3417302839038686, 0.5180816600617608, 0.43650985141230314, 0.5892502529068722, 0.7468833941429224, 0.37076226776006366},
    {0.6810558630351611, 0.32892843796979204, 0.6385223326877162, 0.7163618810870508, 0.5917556305728522, 0.38456085071326396, 0.5509716853483173, 0.3232245221868934, 0.4276688997533388, -0.3970948215686043, -0.43512423196221933, 0.9237125495458776, 0.5848717498611196, -0.36594985846442735, 0.36757088755890566, 0.5760160022585259, 0.6760124716121766, 0.356229863607184, 0.7579229109191757, 0.537085324239943, 0.8606900950938209, -0.51772960786647, 0.795070272463123, 0.1014808664991354, 0.6395800842756676, -0.20738024526323612, 0.7720444895627135, 0.18209657244045244, -0.7871828718405213, 0.771386637964344, 0.3558279195488478, -0.08915069807283466, 0.40252685099061575, 0.26152916325228526, -0.6829288888611764, 0.7345194508323394, 0.526039961531454, 0.13348682800673822, 0.6625637541075777, 0.16108694050328398, -0.23668937689833677, 0.4103105333899842, 0.12034544009308361, 0.005255785446856277, 0.931534497602861, 0.8899466838094579, 0.8790307785370993, 0.8062329562842896, 0.8879922254623134, -0.7569179433682405, 0.05168771951277159, -0.3635620772710222, -0.13288190465843797, -0.34162703189234345, 0.543697086211639, 0.30594850745924523, 0.4485423777583359, 0.4008477073970044, -0.08715398388107903, 0.7062147093662722, 0.2338499141104993, 0.3713626699091377, 0.8695977016822694, 0.636012891666546},
    {0.11019177939802839, -0.022802932427527484, 0.3245796881934366, 0.40212395367898907, -0.22491435173357138, 0.23886805186555504, 0.6226623628904578, 0.5229112169962534, 0.478106201033074, -0.2039741260803353, 0.4296849247522067, 0.2608532992197792, 0.06698169803930429, 0.17801959099958625, -0.18051319295463267, 0.6636921451040124, 0.7088743464113496, 0.047209178168778954, 0.6998362214507603, 0.4019210928802971, 0.2545086185736069, -0.600325802827433, 0.5586765507357796, -0.12291718399201515, 0.5572576746876486, 0.05121397726622001, 0.518125281467031, 0.559113476440689, -0.23226641512678153, 0.3584668154689964, -0.1307041357384212, -0.7102712011151967, 0.4939879602550673, 0.604503789075052, -0.5175144586210769, 0.4146073035971562, 0.4916712327190395, 0.0864306340865793, 0.6726676220572874, -0.008596242970355284, 0.626887564618316, 0.6282076152351598, -0.03994125607555339, -0.17037137344930486, 0.5257249051104311, 0.7052663078238189, 0.09392899752173016, 0.24243910144120778, -0.0750214244388936, -0.4568372967439243, -0.01933103330422216, -0.05833174328049096, 0.30429603088884, 0.6466272113954199, 0.15117208639824145, 0.3057840330953938, -0.07143641062189181, 0.5648213023826355, 0.3402023732646762, 0.31699121666229896, 0.6498017985823248, -0.35376371880907026, 0.48264779282132036, -0.05380901138678468},
    {0.22617298701475508, 0.06813124644305332, 0.5274603891604468, 0.2118794847553694, -0.0692929025772304, 0.6230464276861949, 0.559161542382192, 0.6101117331945038, 0.3543366434302055, 0.06281504493569923, 0.035980306412735766, 0.6185793323374836, 0.39114623409477584, -0.2658079877742478, 0.2326091075613442, 0.6669448356585878, 0.818757642610981, 0.47425114986773237, 0.5678154845600037, 0.5573655007662951, 0.43199685097351453, -0.5290650398683235, 0.13637918115419664, -0.09744425662443107, 0.4609359767593448, -0.21363249919195487, 0.7223677115853302, 0.5441361999591314, -0.004702555573144324, 0.21746884274850317, -0.1925480129458881, -0.41321347059017927, 0.41353571166116426, 0.6738254553701645, -0.09541259402379604, 0.8065335377590624, 0.41919872944260705, -0.43532703822893365, 0.7467791681794723, -0.39140270811771216, 0.7479435100494252, 0.4619409298953054, 0.03579815807215369, -0.6136712385809057, 0.25239517072441947, 0.8488207298514988, 0.5037604958534375, -0.13530227949388207, 0.042322054445334406, -0.5171998741797027, 0.49450088776817736, -0.17102591702449582, 0.16089619234850777, 0.44974806951501534, -0.20498458008668857, 0.24062967419729994, -0.3822374126655995, 0.6907025809476424, 0.3491823120350644, 0.018662279876496074, 0.5013029076878809, -0.30622753524342616, 0.4580042283620619, 0.15368558918960887},
    {-0.69313702296642, 0.14873282888820186, -0.31613707342236114, 0.1677186336838656, -0.04258185820600465, -0.33249011022270014, -0.5302335007825455, -0.19535873839817905, 0.048088483697678236, 0.18318369935886653, 0.07845906979130796, -0.7664280410113312, -0.7055205866881282, 0.5879319950633584, -0.2049845061875899, -0.09773663481701658, -0.18341779336022046, -0.011885933681306048, -0.15044278855674978, -0.1394036090711471, -0.44581224578909173, 0.28136309884913296, 0.01962742025477304, -0.5171275222341067, -0.28518581471480736, -0.2636314649123205, -0.22288160506941007, -0.42647166829997774, 0.46722665609412584, -0.7750424128953246, -0.20005817915893812, -0.052513204168105426, -0.3545350462347659, -0.6947375540924495, -0.028381120949117634, -0.6492280080302151, -0.5979414999373794, -0.12017802658356723, -0.10993280894923146, 0.3199692845565411, 0.4038714039478973, -0.3103272688668901, 0.18302099888235862, -0.17648345040883182, -0.7586818463724475, -0.2628629431271566, -0.7530608112711704, -0.5377099295576534, -0.43527842403335987, 0.3303610473805304, -0.6722058761378911, -0.19800294192329715, 0.28192010099031617, 0.3727411589714942, -0.452945447019887, 0.2862157953941588, -0.3623729760784401, -0.4605414720087227, -0.06737340002985412, -0.8325567334153798, -0.6104878185211545, -0.3377418980299005, -0.8142110767026837, -0.654702045990676},
    {-0.16414055903543848, -0.26120123120918154, 0.22063690733660793, 0.4138849398109135, 0.4883029565954359, 0.0563909058194144, -0.05098846115001509, -0.5377675435357305, -0.37554412571292867, 0.20787608842617247, -0.5855780773310967, -0.5194051784424263, -0.20932524583508952, 0.21476466688583087, -0.17101102154852332, -0.38546562516263483, -0.47283145748691263, 0.18890076267169167, 0.43606493825011833, 0.03800059645662053, 0.2620156537398497, -0.024972535951420814, -0.014467642752078853, -0.22270819013321524, -0.03716009238651419, -0.12996907708638805, -0.4355880797519992, -0.4869436119344543, -0.007606388441474152, -0.5734425071959108, 0.14205143769465103, -0.2898079202103127, -0.42991281832359135, -0.40464120073716126, -0.4123901044458626, -0.4569770415861182, -0.20604755060943988, 0.19585498034170076, -0.3262695803536082, 0.6483830552343635, -0.5558649286770118, -0.24042989847190624, 0.22820985331872362, -0.04133367535661094, -0.19582936073987778, 0.31601201564026304, -0.40707997604822077, 0.0026889485557834688, 0.2130500694219158, -0.3144369133782771, -0.7262986141279439, -0.4222420188308424, -0.07111199282530929, -0.2709910221970119, 0.22133087228693935, 0.34424809860902744, -0.18536289268521908, -0.5504593179568957, -0.06894893126157083, -0.09401808303505592, -0.5961811407985056, -0.37364505075924764, -0.1080774314790211, 0.09077555076764177},
    {0.4733226335832103, 0.34604897568363463, -0.3135128760545418, 0.282277672042281, -0.03479278640802346, 0.2947398223595077, -0.2793782848202639, -0.2520799448194628, 0.4426088143201461, 0.29298027925584863, -0.012640239288514616, -0.22747352288053793, 0.5597535567492373, 0.619100068659506, 0.05236160635762612, -0.2919160425730919, -0.43842141044644056, 0.25580978958758216, 0.06918810626083415, -0.07709305415018257, -0.11093669629409976, 0.507035181138966, -0.021297124827636457, 0.13000043966272187, -0.06081447411586473, 0.105670494917453, 0.25793013722131297, 0.08039034939747872, 0.4277343591182271, -0.6018617694437964, 0.4902003335165552, -0.21486764989688995, 0.3186512700533882, 0.31721643504079045, 0.5446286740055547, 0.4666616923102023, -0.4105207087826967, 0.022506810801668862, -0.3277659516678532, 0.14152279670258222, 0.41578679796120394, -0.4745114907544437, -0.4648104949377273, 0.4390354485175465, 0.1331442417891703, -0.23470808781441269, -0.027807548050571645, 0.4461500114174346, 0.08854303639332546, 0.5293916948247229, -0.1366232133538592, 0.38513075498246185, 0.47172789778151997, 0.8077855761651994, 0.06424607398749438, -0.3554011765198149, 0.2065640272102007, 0.0060578509123107895, -0.16335363685214527, 0.32854350693476025, 0.2695468912714684, 0.008289406388727352, 0.3752673772861659, -0.02149489056509644},
    {-0.2696102884791253, -0.6809925333596348, 0.4572056311666124, -0.7493199566817006, -0.6692174575503351, -0.1322122731710864, -0.33476129617346145, 0.40735193630149263, -0.40582779920713763, -0.18389422456025048, 0.15662773251144754, 0.2837748212607068, -0.4488675091906494, -0.7185513803015299, -0.7692390381503169, -0.239679903330314, -0.005646400799084398, -0.6500398225973082, 0.23145509286509566, 0.12390118397819072, -0.41578045226858484, -0.7907207021510838, 0.1130891791332578, -0.92932917723199, -0.3284955130484564, -0.4771230702707019, -0.3732329669889252, 0.07555323174594615, 0.5920390232744895, 0.46722886910757244, -0.4338548375486081, 0.5405847582753349, -0.828220541484398, -0.2241322121720399, -0.39636845092327394, -0.042994495977579934, 0.17637103785749753, -0.9211635296934417, -0.5984492181764045, -0.38227178436110076, 0.47357377838244513, 0.0931939201762174, 0.2003436673187085, -0.7234505761109999, -0.37839736606695606, -0.2671356900793183, -0.7809156459456148, -0.5569946448688244, -0.3062802472632792, -0.5751537830194337, -0.21240548213141153, -0.76672122289003, -0.7514841364066532, -0.4625222320135216, -0.6536997152713817, 0.10578304466724463, -0.8234379370889712, -0.1433098382106564, 0.6027448925244191, -0.6970429212392405, 0.3062612965045144, -0.3557158858175871, -0.7460100371577776, -0.8309221360413409},
    {0.47093250496127026, 0.40262997035181886, -0.33285707676333326, 0.23718472561131068, 0.4336185723250619, -0.5901815062228237, -0.39906342547563445, -0.7645501050794713, 0.09713863341345577, -0.05733422863157391, -0.8669280884548537, 0.03891462602794449, -0.21326514807101224, 0.0057166760323233284, -0.2108226740246161, -0.7028447614590032, -0.5432633025415063, 0.3619075315408847, -0.7047694867891162, -0.6195003530776759, 0.7834775364993223, -0.48588528398947783, -0.835150751980828, 0.5216827663557018, -0.5635517053540094, -0.3306178540437418, -0.5826627366542263, -0.7364907311717293, -0.8211718708415018, -0.7900534385585408, -0.028764347247667053, 0.10374292043327268, 0.01962160265377833, -0.21268573414013942, -0.4840935272506155, -0.2097810695481482, -0.22849644484367324, 0.016193927282449245, -0.3578377593405034, 0.3561220537167029, -0.8623977264361441, -0.5704426536690764, -0.4835311775627407, -0.3018450907719602, -0.5699322494781631, -0.3696459366836577, 0.5933164989940237, 0.6226686098687005, 0.6835991933041632, -0.14265836805230991, -0.5425702040574998, 0.23639039430357023, -0.5073921722876876, -0.45863526290437606, -0.04578588575904917, -0.739546454709371, 0.11202223205373868, -0.7167377000701035, -0.3726102675478713, 0.7784710307007516, -0.7238555912905655, -0.01134610532161561, 0.518580286568384, 0.25437799403861805},
    {0.4496398199335126, -0.38009211673851806, -0.41169434001339766, -0.020731066493475624, 0.19631679770962832, -0.24805954576664882, -0.2321942722411665, -0.5138280049134738, -0.09780539129995185, -0.2616786069430414, -0.8402922682072047, 0.6266267317955434, -0.11875208809693333, -0.40005475825269304, 0.047789954058605456, -0.7361106678632223, 0.3702978742970417, -0.4801687808197267, -0.6893102701050378, -0.1087863929958283, 0.8142845852228476, -0.39182935829086263, -0.5808515604200878, 0.6401278242449288, -0.4695805631262986, -0.1362357385772812, -0.4640962034539678, -0.759560084927412, -0.8348414683726743, -0.46392697552551376, -0.45388459525593805, 0.46349843810624747, -0.11672148307415618, -0.048452801771847166, -0.5436825980798029, 0.4361503561834074, 0.42989393466737025, -0.5722257376749519, -0.32871969307186555, 0.019068533143017513, -0.5761551275325453, -0.5715616383290096, 0.05980395210054748, -0.09727985565722991, -0.436733268696405, 0.03556159013752571, 0.877167615110097, 0.6958584355135371, 0.3267045934677627, -0.6127075975662698, -0.16492453842295415, 0.206079882830126, -0.8202690027057413, -0.716222329337289, 0.27196842487728323, -0.7642000764099236, -0.2917294965168166, -0.44885347430340683, -0.18376694730010174, 0.7069295641624666, -0.1926996984385223, 0.4670587357692942, 0.5529432406642265, 0.7125262054020711},
    {-0.34202974513925877, -0.25873943662492865, -0.4746208210719608, -0.4791479128856235, -0.4678909947158197, -0.4621514448499256, -0.6255104114306465, -0.06675519632224597, -0.6150673084570379, -0.23000629102005393, -0.5553745700761731, 0.264075310518934, -0.8219406010130254, -0.8602776890681516, -0.5603380728435752, -0.6655325999586681, -0.24321849078758737, -0.5948043313890458, -0.5705338413338359, 0.03321813447605497, 0.35059606596425563, -0.6236436416862912, -0.6289431830248111, -0.2135601651212164, -0.6123338280959615, -0.3041226895336745, -0.6396886458192891, -0.25296839873788546, -0.1312488644829589, -0.4828238239804602, -0.9191616738156891, 0.8003243258738646, -0.5603215089810332, -0.0820748714224321, -0.5790106249103326, -0.2459333736831781, 0.20371864323031763, -0.8085892565575742, -0.4948913953647069, -0.21870479085921715, -0.24634399881667793, -0.5218312928727808, 0.2895645761992466, -0.8486725765532056, -0.473582868102882, -0.16044242499105307, -0.46003715238962023, -0.6001069180685041, -0.5705481138107874, -0.6388592452409325, -0.37191047658269194, -0.15900743244563476, -0.8485060422596491, -0.6763553508108965, -0.7720421106867765, -0.5798708081829549, -0.82152961536266, -0.3772150850569816, 0.34147238875427777, -0.21129131798425707, -0.02696928728793975, -0.245352849294291, -0.7912437340804717, -0.47905873669973387},
    {0.6465722831381143, 0.3548629314833105, -0.10459295772090847, 0.6258730133531529, 0.8025865949643873, -0.34622918878174813, -0.4491357819855239, -0.5630042345455687, 0.02936142853582325, -0.053212097872485764, -0.8308117573477124, 0.021686834972432473, -0.03650275150304444, 0.27283226017517676, -0.10974766753425452, -0.5990015749648625, -0.0659337931205448, 0.35238972041058864, -0.5938920040651346, -0.4396270345186751, 0.8763172320786352, -0.4401878164251871, -0.6301635939669448, 0.5908148942945421, -0.4954718156211602, 0.04556198241773874, -0.2532721591800606, -0.767605244429919, -0.6781026051200435, -0.5716358571555049, -0.29583200262587894, 0.1948831709638765, 0.4631700887417178, -0.3271832851626883, -0.7161290658353466, 0.12473171175030325, 0.18829391051373237, 0.07918620397298887, 0.2906031397135692, 0.2704735106818553, -0.4743072188911444, -0.7573000704112501, -0.01359821490157395, 0.2798093611715149, -0.19572550556156923, -0.004184922963348032, 0.6748274441839824, 0.8314719088739606, 0.8995204127286985, -0.590747898471682, -0.8581488732960791, 0.4013769602899784, -0.4295364866814489, -0.28187564939958754, 0.3179980127429401, -0.6641265673374084, -0.25609414001805786, -0.5386385777488539, -0.5910524129239091, 0.6248823285439986, -0.4140196266425594, -0.021446422186673367, 0.4918048232828549, 0.7689777875203323},
    {0.43535857597484645, 0.18412536356894021, -0.10593985219452647, 0.4493849077408543, 0.5795050149018925, -0.1850990167728248, -0.2907037785822453, -0.3107036012912678, -0.19383432820849475, 0.053410942495736836, -0.7725151675404562, 0.01962336858542259, 0.021404887952581168, -0.309241543999318, -0.17046602413898349, -0.41446662750023433, 0.20823039122683182, -0.23587367985315832, -0.5314988328347549, -0.39010896984062665, 0.8159237099338993, -0.49425867520419847, -0.3240398160579757, -0.027337102870679197, -0.03715224367743436, -0.3137423909631225, -0.4629935523954026, -0.6194026207897312, -0.7296120774634384, -0.5911577045890886, 0.23679687657509169, 0.5634232416886081, 0.008066133202820626, -0.1801691871927028, -0.5829835932523773, 0.2172165275271173, 0.13475654730812908, -0.23666322154878394, -0.39887421495328257, 0.5786143383589235, -0.4791470840409429, -0.6291997454472231, -0.08647253010520127, -0.10041026214863395, -0.22115917638622817, 0.22797469683540666, 0.39333502325440384, 0.5100478323091804, 0.7353441145840215, -0.34391228730208534, -0.6579776303992797, -0.20348860276073225, -0.670596381378978, -0.3059943896248828, 0.01888888717383526, -0.5115879235511016, -0.3899662418999859, -0.5495469552496304, -0.14201189194439467, 0.6324372741285224, -0.45937881443378675, 0.07494562721125111, -0.08376062312733289, -0.005050313527714895},
    {0.7304097936142679, 0.2466105256535611, -0.33824970846767083, -0.28712724827856406, 0.3827361837468035, -0.0719669465388306, -0.41430688447030806, -0.3556735986611231, -0.30165098220089026, -0.2519909180347512, -0.005801215137813658, 0.46198062219066105, 0.3245717310452471, -0.30649372526122953, -0.11963008506830711, -0.21422265584825503, -0.03269305709643438, 0.32672808072798243, -0.37804192827618743, -0.6014642496848183, 0.13958811104829627, 0.12491298508485257, 0.07077479887525316, -0.25258200560346095, -0.31728397830529803, 0.3202417670580167, -0.20087990909967554, -0.06111300605553783, -0.0756371921701065, 0.06494462714894302, 0.27368057554846154, -0.061927584059691135, 0.27054699523819614, -0.2303869706059833, -0.21376094537342197, 0.31257441314378853, 0.07975285209621844, -0.3242476797351692, 0.052888366756008755, -0.2347847867202008, 0.018652413534559122, -0.09265641540051024, -0.18915696332232976, -0.06139929312204605, 0.17304084054542496, 0.0718301668490088, 0.4365016843757756, 0.7639113706931778, 0.6158413966997697, -0.13418368108108425, -0.09816040409439905, 0.21111743091989096, -0.3885504901147071, 0.11549149268941836, 0.15995360662935715, -0.5211302563489406, -0.16145720468920702, -0.08534286341224236, -0.4438853831550682, 0.41162008032135133, -0.019278582232769792, -0.175739931306195, 0.5947186846028659, 0.3099981231169237},
    {0.6309944069305817, -0.006516733919172707, 0.15624774198509514, 0.13545674800335386, 0.3059898444082332, -0.5998758406658575, -0.2891083425469627, -0.38739137031898224, 0.4607239004927948, 0.4735749007349731, -0.530824758665744, -0.6029706046837665, 0.4414424230421968, 0.518667777290746, -0.17985414339502018, -0.6284959700788156, -0.2288811875836787, 0.3605588194433495, -0.04396069927648986, -0.6044765511118937, 0.4326699700028858, 0.0700522045940527, -0.34535380722033665, 0.5232853717943612, 0.09282943069019878, 0.30854361185676177, -0.12030803612543382, -0.6712759358610373, -0.03237246266572992, -0.2279168960631735, 0.5763745797390908, -0.5031448071952195, 0.1528262753144647, -0.19669510899908005, 0.258802057213503, 0.14694355217394248, -0.5933147321702312, 0.4712667466346765, 0.46514055173426894, 0.7059032564152982, -0.3599997208378738, -0.42445336961329705, -0.42225201757012404, 0.39994855260429124, -0.019330645218027093, -0.28036542043531393, 0.3284421987427597, 0.8266516940684924, 0.7390031516444979, 0.28111940967975607, -0.7169794396466147, 0.3649899374430025, 0.24633751409301385, 0.4103066420071338, 0.47347793188847437, -0.34866673583926716, 0.2614925680044468, 0.01120318077008065, -0.4894137225993247, 0.764022058224261, -0.41873114978159026, 0.31205512987996964, 0.39766027752720806, 0.1951811656315263},
    {0.5023826446172689, -0.18007523443151066, -0.06446225589798078, 0.011361373603997, 0.5651610251262582, -0.6683499304686407, -0.09407035442056687, -0.5882358642006241, -0.11153657869067994, -0.12461015187477177, -0.43817670743695514, -0.05621437398286406, 0.07130957221559245, -0.041353926320897905, 0.5061331005857406, -0.5686574310506364, -0.3889414170925105, 0.6153645289622353, -0.5934982867112492, -0.7420210304364582, 0.6633960098789649, 0.279574099759879, -0.7619863018430609, 0.49124935651498786, -0.1373114017821041, 0.39796786316485094, -0.49318899648750475, -0.28056100068574136, -0.6359996110647751, -0.47851385594009815, -0.05254081589103391, 0.18210667839220432, 0.22979273727995747, -0.28927695192843816, -0.15510476480008653, 0.008338378152038237, -0.31914515766179075, 0.1552766995079415, 0.421898811186824, -0.11639324366383867, -0.5059258287877538, -0.061321062980175735, -0.0449600230016073, 0.4345422480047784, 0.05949150233776577, -0.3422351444178857, 0.6962125118892735, 0.5798079598167608, 0.4495256123492918, 0.3911023461687712, -0.02008119316015334, 0.7245585948222004, -0.08688265654245106, 0.0862439116186478, 0.5220124655853894, -0.6962478365348906, 0.17287678164195633, -0.3617469992771641, -0.7402911921563253, 0.7600667765815157, 0.026276871718163414, 0.3114833199800181, 0.32020915609868544, 0.47615169665397644},
    {0.10558303904927781, -0.1919680001953753, -0.8485241461950147, 0.5439850939172809, 0.2165167463508241, -0.6206147762714259, -0.6413048197945885, -0.9214184508800928, -0.049199141582391415, -0.42195863840811465, -0.6367466247626226, -0.7252283010273979, -0.534527167356099, 0.6363437442605235, 0.11816515841758524, -0.6767151941193346, -0.5035591451671246, 0.44530877153268866, -0.8374171365746657, -0.878014570504358, 0.5535291480287577, 0.21610284656968845, -0.713701889110429, 0.6061068908719226, -0.5444772103449088, 0.30919368308138595, -0.41582823259879276, -0.8729174245670009, -0.8005763754031936, -0.9384228168759853, -0.3370570304362903, -0.43474301801875365, -0.07401469611982825, -0.8228550054783528, -0.4507529429615741, -0.7190071330031554, -0.33378320957810664, 0.07469969754146616, 0.17326932192101854, 0.13925411703253315, -0.8903393171730967, -0.5650590004884084, 0.09178349834451537, 0.05946848896321515, -0.5421584847553179, -0.4367028181632538, 0.5471143129812641, 0.36296304238918176, 0.37400429481346037, 0.30171686263630393, -0.9171122272999124, 0.6911560460523822, -0.012367635511484662, 0.13288304864604208, 0.22146224554741575, -0.8525250746739617, 0.17993966581010246, -0.7919089964993389, -0.7268738678974036, 0.5162722936487908, -0.7165785981937621, -0.3548611920528371, 0.13731406656391154, 0.43203554526045773},
    {0.3859687910379097, 0.3448798335188345, -0.7626504965946169, 0.2660753323788099, 0.14487563295528488, -0.3698031183600316, -0.47724041393479905, -0.842647626638509, -0.24170683853698097, -0.3332967914165035, -0.6459562536335229, -0.7255339326872171, 0.30155987991707855, 0.07126531077994888, -0.05442432370187077, -0.27517571171378463, -0.8790218832223456, 0.1591674816048237, -0.693355922971778, -0.7090613371942256, 0.2746764391933038, 0.21054713433209324, -0.7603391184370457, 0.19445241800218777, -0.5804352167275508, 0.3225813578917196, -0.32097467038302535, -0.5205805683125546, -0.7426084958943582, -0.35140556234834586, -0.16491893711248118, -0.34981803041522286, 0.27924599065692596, -0.6681511695591918, 0.23805201340147464, -0.6654051108923824, -0.3379664541982948, 0.13111761729269894, -0.38036618484841933, -0.003329714242547541, -0.7104705900563534, -0.5041475207631543, 0.007179045631557835, 0.6380915655801452, -0.10403107476753011, -0.7577767242230924, -0.01577760447850422, 0.5608425661228776, -0.007868485123093091, 0.5269605022434138, -0.6769881734977709, 0.3713200424450867, 0.3028984596561778, 0.18130622278690733, -0.2840224522585967, -0.6977535750036494, 0.09056465548680173, -0.4816149116006706, -0.7508076501039447, 0.6057545855015822, -0.514235573319846, -0.5316316665292016, -0.2050918789744703, 0.43973546116980755},
    {0.35377203848158945, 0.01825026539625956, -0.36680475266650536, 0.13490197252258954, 0.24308571353196975, -0.7631025799620496, -0.44792763862402457, -0.8307524125556713, 0.04438245408160916, -0.5084094141537335, -0.06280544759665996, -0.9050079015835732, -0.021109118057780003, 0.5124198234106347, 0.2597810840351312, -0.10909071442770746, -0.7630533125417196, 0.6319544087447392, -0.7331667678762875, -0.8598414864749302, 0.008073027104803213, 0.7253699127936083, -0.3547339595977318, 0.34021940110359045, -0.2030426205172639, 0.5737735087436543, -0.40391157702754604, -0.190310919972101, -0.6569389087483625, -0.43711326506782405, 0.04827915018467273, -0.6508474312332584, 0.46266182096832176, -0.6020788949661389, 0.38338555459201584, -0.9331807491059575, -0.778624047259425, 0.6187183775386267, 0.20159362388238608, 0.07628886767044221, -0.5150184264017651, -0.4671434334606587, -0.0830972424000663, 0.7559047653312227, -0.23986656670701653, -0.942674691152131, -0.28101736611994654, 0.3170874482625759, -0.2682046238823681, 0.6125755613279872, -0.6907914206508039, 0.4988911143821805, 0.6115326974149881, 0.7978509379906182, -0.28190276983734003, -0.4873559889508366, 0.4562582615531611, -0.3687630484844352, -0.5554733666579327, 0.31679048713305696, -0.6269328033357685, -0.5008228647227203, -0.3340596575635007, 0.2858713205288477},
    {0.5951407371950531, 0.8668263748473273, -0.10613964255996836, 0.8905153372804849, 0.6505825115936372, -0.2709081824863274, 0.22272284020877717, -0.5310439462302187, 0.8196788152843444, 0.05732082636814406, -0.28766683499276063, -0.4684282806242742, 0.7691756445188797, 0.8576810601526313, 0.7234698468744608, 0.2988465283653017, -0.36889748672246153, 1.0040646145122065, -0.16404965592799356, -0.6916816779067412, 0.3318764038908391, 0.8887798598868443, -0.4434846928524508, 0.7731512073394308, 0.42702724863179453, 0.8350567832319641, 0.31876419211119406, -0.3149179302485312, -0.4610276456155853, -0.23606291319142003, 0.9076208790006518, -0.3621975730635083, 0.8158581708068106, -0.5285303810548616, 0.5292432616189824, -0.45034590653896994, -0.6777715178994701, 0.9986928071139436, 0.42420481958857725, 0.5381090409322271, -0.6272235205095287, -0.7106770433378355, -0.17445853237834433, 0.933020608613084, 0.623687446580573, -0.46855925728107756, 0.8486566647476986, 0.6486391325877668, 0.6657106767942829, 0.8680760620879937, -0.6423945058365016, 0.7541915343472864, 0.7916111880020733, 0.5846983530751895, 0.6041207874146427, -0.23692658089093982, 1.0206346390232417, -0.142212327882035, -0.5198564120865959, 0.6704916319058394, -0.5950606215099773, 0.4167497311419397, 0.6801737471085345, 0.8618813661092689},
    {0.3873880860766915, 0.5144316489546396, -0.5436869857552485, 0.48990499318749275, 0.6107625500461772, -0.3830360752525757, 0.12455940707954533, -0.5619357162958833, 0.6549687228390083, -0.054742495394739535, 0.07153414033014789, -0.602105820459639, 0.28138990793686625, 0.7108716470250259, 0.43288201259181636, 0.26751135851786145, -0.5810426502883002, 0.9322541640866511, 0.10143538229374433, -0.6688548315380046, -0.20002432023653083, 0.9972710063651041, -0.0695090928114122, 0.4370508449106648, -0.0879620533690453, 0.395327383480186, -0.14093442933184203, 0.10848798687175186, 0.39934353513586174, 0.02062692451328256, 0.8119379458118727, -0.7815269256892975, 0.611028791288957, -0.611876245256594, 0.6834146356132524, -0.6091196708899078, -0.7330103648708906, 0.915713918365178, 0.025185024432791418, 0.3831109333031342, -0.1379298029037327, -0.42683179055469816, 0.12064103480513143, 0.9916801107375259, 0.195105166725844, -0.6570610480770277, -0.15495111996570518, 0.5941805628805197, 0.5413495202701488, 0.8758120082763604, -0.34703881474392423, 0.46611474396623875, 0.6041695627520454, 0.8440492145053232, 0.3770604570797085, 0.11060377852274578, 0.7169102040233686, 0.3058000597456364, -0.554754269382159, 0.44700742642714575, -0.2506398300429494, -0.12980733814458598, 0.32555941112115644, 0.8347642250846423},
    {0.17052832717745062, -0.14561014358768773, -0.7520788202029948, 0.7426249248761038, 0.6397218200846141, -0.5150341067611736, -0.6287578309259783, -0.666816916132728, -0.1307049814068911, -0.010840039417965842, -0.5998537411473016, -0.8859561038570577, -0.28790917526021687, 0.750052520861839, 0.1280420610263161, -0.4913837042214986, -0.7119747419106004, 0.5967869319508357, -0.45546410857518627, -0.7830321358927836, -0.5208736875988123, 0.8768954933810515, -0.6417941996840238, 0.7593845534156178, -0.653665832857277, 0.22707057737291494, -0.7014016267945793, -0.6555981289539308, -0.4124568870048193, -0.683632618620226, 0.40561360173634087, -0.4841916305959102, 0.37209406635294145, -0.8863172392858113, 0.37022481780252764, -0.9243414299923157, -0.8508408065582257, 0.8033645283763734, -0.14986901991449944, 0.33436527495969304, -0.7168106918932398, -0.7761062389230418, 0.28671672026646905, 0.5164193372840156, -0.44866117272865097, -1.0056016136696475, -0.3667408623763183, 0.14784708142389574, 0.3718104576862138, 0.7024969828690392, -0.8113658737902263, 0.6735809400573707, 0.5381578187570835, 0.3959807129360057, -0.03339262475533801, -0.5918757350637662, 0.6245393218929923, -0.4699691325773377, -0.7633848135998905, 0.3800164899472245, -0.9051026014279623, 0.039868791317490125, -0.3001158904252362, 0.7787379494586252},
    {0.593524110970774, -0.024462150244458258, 0.14476638007715725, 0.5821147492655866, 0.24113786650433033, 0.07709336018899987, 0.1689995943043383, -0.32961114518027373, 0.3307084670044105, 0.08559029857629469, 0.01110557129555742, -0.2764285063001101, 0.47928472355201746, 0.15975688948418748, 0.21591722835891317, 0.5232726633877505, -0.5567308551269432, 0.6183635416309159, 0.010332696769337447, -0.46033808820349337, -0.3601539890675833, 0.4936946468715097, 0.3902784703727071, 0.18733650387482084, 0.507179233917836, 0.2188844755768892, 0.35986861142555504, 0.17190202899019835, -0.233872438087976, 0.5759760261342408, 0.6541743493704529, -0.5913832632918645, 0.7746812221116561, -0.5031650646945722, 0.471423532842822, -0.4279742191281968, -0.26151285154912, 0.6238407047108623, 0.13558635033410962, 0.07648813252220753, -0.059553025028712236, 0.20943501278462043, -0.08537253180745052, 0.7786895533013597, 0.415574051353091, -0.4737357378051241, 0.14052154947018, 0.20119432833181314, 0.11855599052512773, 0.2091431044212791, -0.031214355867842405, -0.10194284777906017, 0.3949057463255806, 0.2705506399640585, 0.11713785493871848, 0.12222130184558919, 0.714687867402679, -0.004588277001008906, -0.5153396600359679, 0.15776410326169008, -0.18298328518651752, 0.03915761580984921, -0.09797587632270831, 0.7485466512776866},
    {0.8633670618098683, 0.5542759584803194, -0.3034199883520568, 0.8195790137499271, 0.8154828403255592, -0.4097423024626813, -0.30951258751078325, -0.8809033202641887, 0.1349358561197376, -0.37749366357141506, -0.5620499841970501, -0.5554209291944038, 0.2749727504717167, 0.7519194345063424, 0.28068953588403633, -0.10972373188787764, -0.5631267099282014, 0.945339430990903, -0.20510680091145855, -0.9065135907238513, 0.12896218347610006, 0.7731319944874357, -0.48421101728584187, 0.7534745957060418, -0.27426592108055214, 0.2715086808919001, -0.35757019728443373, -0.7552210354053036, -0.6963206599181886, -0.7461857507241031, 0.7824692047012106, -0.33923327450107804, 0.8849746271893324, -0.6718391001678781, 0.2980280752922204, -0.4242900226210228, -0.7694718557840642, 0.7897480622187552, 0.01906991711314198, 0.46281385759498117, -0.5410043508373008, -0.8079704063959373, -0.050016369168100816, 0.8923752447529386, 0.4920967369645061, -0.43910908093497286, 0.2979694577171729, 0.8987744770191324, 0.6732060674416331, 0.6991716028224769, -0.7310588097220528, 0.8390567338668345, 0.4531010985835371, 0.47571149162836635, 0.4364822602507865, -0.6143547909873257, 0.8512593068554085, -0.25842352382340966, -0.8893494000257145, 0.7133805074917363, -0.5593529356590876, -0.02112416224320999, 0.3519325186976881, 0.8849177837879804},
    {0.39920372475615656, -0.15009601565854286, -0.6765149709288992, 0.25554159658985476, 0.6219596280689041, -0.02106545939247647, -0.10224742831790029, -0.889603563636367, -0.23643328601636524, -0.6687883150650176, -0.43074328280384483, -0.190376887329045, 0.25331103906418945, 0.43306788017980263, 0.2925261271628804, 0.10650372142858909, -0.23766592413986237, 0.6496986853038164, -0.3402552352032359, -0.5244873929194005, 0.5083713219552717, 0.1418655890961916, -0.6544807851523994, 0.23145323774213433, -0.2575066239342382, -0.0075406661413858255, 0.10089564096630822, -0.6171683657821907, -0.5516800541001605, -0.2545246331495319, 0.009085038480204428, -0.38815740586382674, 0.2984810623215616, -0.49443891074616514, -0.12062431859533079, -0.3603558222826269, -0.3295153083469023, 0.47840800535049316, 0.0921241004947477, 0.10614025723522408, -0.6200015235393943, -0.30928075667931343, -0.14656044425398812, 0.30547712380348985, 0.30661243912189023, -0.08328168270039919, 0.6358878543371668, 0.7171019162942834, 0.1875181211301245, 0.0693872109861839, -0.2847613153293114, 0.2846707361386197, 0.5138762349016719, 0.3969005807087018, 0.37482630738244566, -0.7938520664953483, 0.6692602267714269, -0.726339633789537, -0.7873894517995789, 0.6428235652779674, -0.4582397350127555, 0.1442898956442559, -0.034830481554386235, 0.7292874590879331},
    {-0.18485886117636763, -0.5297512427517542, -0.4153433955571984, 0.33808219982399523, 0.35862545351936953, -1.076794201817461, -0.03756714346805439, -0.7696469122561465, 0.5212000899170762, 0.4133362468534376, -0.6990591339501891, -0.24721262374857195, 0.09403494782322304, 0.6681987499734998, 0.238064074422016, -0.8213813622941051, 0.1267333970278204, -0.1298141246892948, -0.016342891334672566, -1.0109834556933357, -0.7280634824326097, 0.5449866822784327, -1.0250412138957732, 0.5474452098574571, -0.4461874245827534, 0.389059616097992, -0.6734515309941354, -0.9524389820583511, 0.10426697918761416, -0.8275127598813246, 0.32219790323856057, -0.28804093418850374, -0.611462857063394, -0.9573991223034757, 0.24135973002850056, -0.8078586329486391, -0.7704163322420823, 0.5934887961060736, -1.0038223858244668, 0.1903233181953493, -0.8194994637657572, -0.9074353456187784, -0.8358251967105611, 0.6243717078431233, -0.47393013698450087, -0.897790196253368, -0.15412785617662625, 0.3564450296629274, 0.35209955282470046, 0.4605169150590911, -0.7554117266778351, 0.5008026830746912, -0.8405957911664096, -0.5516419332234751, 0.2271540891406644, -0.7900638688255083, -0.49421011796833886, 0.1231659455641306, -1.059165263541424, -0.3344938534551712, -1.055546846542702, 0.17988252842613497, 0.02163519103515063, 0.4325763541896109},
    {0.3950125637451381, 0.05628063182851282, -0.40312453880047505, 0.695516205961863, 0.6264597071561048, -0.8817279587015191, 0.05658726551125375, -0.5205909805120856, 0.7472756838666154, 0.40880170570829666, -0.7233962520921962, -0.3772223162114183, 0.41460100318615684, 0.8300677149908163, 0.7546024972421274, -0.5756464965187562, 0.19096768072971948, 0.11157812139259544, 0.1156051213475251, -0.40573210600551407, -0.6228829633117215, 0.4034184991769775, -0.9729358390235464, 0.8307236656515772, -0.19112420168632632, 0.285763352708618, -0.05078029985825685, -0.6443985419312457, -0.004954992191326503, -0.7564563010538188, 0.5536391557540201, -0.7831767891907117, 0.48537387310010627, -0.12231438224320597, 0.6839300660626045, -0.581299348883664, -0.5663769836169742, 0.8010817445957442, -0.45213411822766725, 0.41560542519577, -0.27682869672914606, -0.7030998051040365, -0.6232085327378624, 0.5277267776593513, -0.4004381402162132, -0.5631044309233042, 0.2582553318509708, 0.4294273796232611, 0.7496142690233317, 0.49768002558593627, -0.5354501597734932, 0.5798393236858219, -0.005821704639360521, 0.05409974952968985, 0.6630910740738366, -0.7970187929202375, 0.23918889861532958, 0.2347032749877759, -0.5989771587320919, 0.3678663148717687, -0.9176195505336608, 0.5052602742978647, 0.5368538280546958, 0.5128395076513376},
    {0.08847154181697969, 0.0967044473002868, 0.033860565590288216, 0.03375528080700853, 0.46599963950263285, -0.537563441448529, 0.30778955830604293, -0.11583869744711114, 0.4858418769636687, 0.46238455966776343, 0.12265497403024636, 0.05013510401452624, 0.11105038321392903, 0.6517790136656102, 0.49558979707765494, -0.5988996640862836, 0.10243054145536695, -0.3216044769921067, 0.5541191188516296, -0.18003103332181591, -0.19122258012930052, 0.2103532105081331, -0.39427787904161155, 0.47672104416873284, -0.5573494439276532, 0.5775705486296406, 0.2357631196419458, -0.6812890791541286, 0.26229539189707063, -0.5705190839313086, 0.6150902021840929, -0.1988750469566952, -0.09240206938652894, 0.41949312006532957, 0.33330165203376394, -0.20967426499898634, -0.7520208132335151, 0.4067396324294761, -0.5133676447785773, 0.10556427604004828, 0.08825021080450911, -0.22888031253252236, -0.8017852698806495, 0.624657267650473, 0.0058276148459784115, -0.09801208970037907, -0.06548103764536152, 0.15954243432272755, 0.5879208179488467, 0.19376312496765427, -0.4502236990798087, 0.6590483019925676, -0.18292669867351535, 0.011587907038037065, 0.20369259875763684, 0.1759408357580916, -0.329456219593407, 0.01869755597933943, -0.7968936702277886, -0.44545860620096894, -0.22146288692827099, 0.20277810959520187, -0.021537679572591346, 0.06768894846319448},
    {0.41984916840124736, -0.036939031028735955, -0.5515382049702238, 0.4392792683952288, 0.08757870834294638, -0.3929982969241447, 0.20277049309989076, -0.5537888025891278, 0.5008238474943567, 0.376412730777611, -0.034363825487967986, -0.1275101727268787, 0.43225363673530126, 0.5486273367417454, 0.6763090434010824, -0.2785516108307547, 0.37095697721610005, 0.14728519357569003, 0.20010905531134432, 0.2232041089371126, -0.02119135535802229, 0.7270043424641663, -0.6820521497032436, 0.4455450706709729, -0.6318794742515512, 0.4197902293319023, 0.060964357016557065, -0.5895450485609504, 0.6554716785181534, -0.6037631344249283, 0.5564022078951972, -0.3884966716698489, -0.3001530125364198, -0.12619235357429162, 0.6002298466682444, 0.028306937707522996, -0.8634859107352117, 0.25104542432243004, -0.6640728174080875, 0.35548808553519096, -0.2561560397903019, -0.4128450672688119, -0.39038747123857964, 0.25465218039280674, 0.1418020551084865, -0.3273202938421617, -0.13331654129208131, 0.30520480712926756, 0.035705216021415506, 0.6555156065456055, 0.008324891021913371, 0.4567296750760823, 0.009815955656194104, -0.3364282937474931, 0.4938624446117058, -0.18876196524824093, -0.16577491486871446, 0.4789849803205741, -0.7150533764716495, -0.6773506382959645, -0.5077149850439034, 0.5552855931468385, 0.45767390400773295, 0.3279966834549733},
    {0.6152959649660735, 0.10771725789782635, -0.09293145390846738, 0.2750729141313865, 0.27518909916108236, -0.5683327684717765, 0.32548881944911373, -0.6507800902655113, 0.18771554658394202, 0.010287481868921025, 0.16304543866017837, 0.1016559136750083, 0.5830514870126697, 0.7040235964583722, 0.6696605358979498, 0.08342919386861553, -0.09124852461382922, 0.5689861863688288, 0.6822843621963448, -0.5391288190199454, -0.11845346350433751, 0.5642462069109896, -0.3022071463312698, 0.5803606308501766, -0.4212262843025317, 0.2592276170902468, 0.18640963166116015, -0.0016716244884550265, 0.2932621294248404, -0.5552971394973313, 0.6801247840854594, -0.6762521677546645, 0.30030538627320513, 0.19897631704288632, 0.4892081352909053, -0.4496140288221285, -0.5841873542216443, 0.6790431200533772, -0.16908087773621733, 0.7019839309003204, -0.057930740055739, -0.5290855589300614, -0.16018514618610186, 0.537485197521444, 0.2503036206300605, 0.24017725212336238, -0.20636547514437295, 0.4573123073867508, 0.5968583768055546, 0.35671743966909764, -0.5234659928302132, 0.40593957776685624, 0.454629463234477, 0.33369443572506896, 0.6779864959729096, 0.07945278615030102, 0.40862451838167646, 0.4760693262530744, -0.7403294436709014, -0.03492569751770514, -0.32857507557567334, 0.48076995982508974, 0.5269377937036245, 0.6191035522728938},
    {0.1905202570435796, 0.4535480780730136, -0.2792124682588733, 0.6241459676922484, 0.41157973373463164, -0.29300767896794605, 0.14039644095716106, -0.22487688955200888, 0.7187302746974624, 0.4381846547786208, 0.08073181751222683, -0.39318189877114507, 0.275961295153689, 0.561637983610406, 0.6801650312860665, -0.4017404155481947, 0.2325537533399313, 0.025334488056240036, 0.6316398364229161, 0.07822743850291185, -0.15789987439125094, 0.6880005767796259, 0.3784681488938578, 0.20863977350401414, 0.17114305272630723, 0.5005067897093818, 0.050974051407399114, -0.14523917107868495, 0.7309398825824174, -0.4735482020329782, 0.5329258737754734, 0.2593982357963217, 0.2870051366645836, -0.0468622765348774, 0.22619263819992305, -0.21763087019096802, -0.45855857970137154, 0.2923386372732491, -0.21719833033768474, 0.5450678557407185, -0.32486901278003777, -0.056160788594119535, -0.2615452392623939, 0.34788045500145504, 0.431214827445145, 0.37799319045987617, 0.13286516237554696, 0.03468153260656998, 0.3670846057849127, 0.4132186615736942, 0.03347372350778871, 0.5727313357234682, 0.348564124927352, -0.16118074925866838, 0.44764223955344734, 0.23451138539641705, 0.13824740793770007, 0.6460933339903872, -0.6649894051445067, 0.08019348139437993, -0.4572569416524367, -0.13433278567397233, 0.19917220656442583, -0.16177271216901368},
    {0.4306345011678259, 0.28832696790426865, 0.2564439288605271, 0.40242297779645747, 0.549806256520277, -0.5869804860720286, -0.05358355837454851, -0.08371292245135284, 0.4753714353913298, 0.5571192046900402, -0.06392436197227734, -0.1865268009049076, 0.22015517044456454, 0.4031732535441704, 0.5681099112066917, -0.3509353519476189, 0.085669134446703, -0.11092513492672496, 0.0888222959183443, 0.16851304427330724, -0.4259173592410878, 0.7337087894488332, -0.08171732386062819, -0.2097501143397771, -0.20345264210535755, 0.4592196318351714, 0.1230463511724204, 0.11372834599216097, 0.3626291810218732, -0.2804624424538706, 0.21727279397294028, 0.3837337651549565, 0.24199554612111593, 0.35120187519586005, 0.2663389936072576, -0.17714997854518846, -0.7551623305170733, 0.4257874529019836, -0.5790270008928984, 0.40277885617817616, 0.2111297103310481, -0.21265854829062542, -0.5056142891455735, 0.6430166314592665, 0.1536857155835302, 0.23878550469094986, -0.15978918673157938, 0.4810447493431506, 0.37138459443379224, 0.3211085993155383, 0.27438696372908156, 0.413116463633899, 0.10619428691498521, -0.06310288229285581, 0.2047988483439559, -0.1148769937475339, -0.03666017201986636, 0.18080712814864605, -0.5543298439375941, -0.4891435463090662, -0.1744919804384493, 0.45132637247405794, -0.01996436098492164, 0.3078055678672632},
    {0.11485444032099151, -0.47557459387635026, -0.5093217108513272, 0.15758842188539843, 0.055998072578896226, -0.08266563821693437, 0.42965565278878765, -0.3389694736513615, 0.3704741481745372, -0.2033164495235376, -0.3204434250167738, -0.08747564306198198, 0.029957057156178784, 0.21157285532963713, 0.02301620430837365, 0.11868997955368381, 0.470853194589046, 0.40620340012891215, 0.3386970115771099, -0.16529046230297592, 0.3466953760168878, 0.15293420563775387, -0.3629637768068652, 0.19191926634766104, -0.37834208395079166, 0.6786812101966451, -0.3900722929591324, 0.02795655765694521, -0.5168546335375507, -0.5428564327198285, 0.5073993594383732, 0.11568086253066914, 0.09967595053447634, 0.17976634177694228, 0.3013372446339509, -0.017211329118231505, -0.381918415875794, 0.35459836778200543, -0.5716901029425832, 0.3060472174652924, -0.32282514260515766, -0.40653558147550933, 0.5673485362994548, 0.137857393572298, -0.28333268981341575, -0.3053760953137295, 0.5107323698446317, 0.22812575238573396, -0.1067752788621654, -0.19445992693496217, -0.20425537754040154, 0.6472240200150011, 0.3065089183722593, -0.10605649644170277, -0.08360168980106213, 0.17917796274562045, -0.11558918521039935, -0.11000772553928832, -0.4480713550035325, 0.10705314478494041, -0.3540883743408705, 0.515859916120667, 0.30364577055363123, 0.5102518510939694},
    {0.5362594101894598, -0.2028226561921607, -0.5183733283345994, 0.3784943972804644, -0.1410345482997283, -0.5151381511854889, -0.21436739229609503, -0.36369588619340815, 0.3822871877469417, 0.27949997901781704, -0.7061475824016858, -0.443380357735429, -0.16522440478808936, 0.2136259984373695, 0.41631964266567756, 0.07253028073707751, 0.5385535480433691, -0.06348637894159713, 0.582607001555287, -0.37953020601202125, 0.01288379715025585, 0.29030992592171867, -0.3729734596634643, 0.6282153762036247, -0.41660286058665186, 0.6858907708346709, -0.24865234557654345, -0.6259236846130742, 0.1674768201685367, -0.30065662716976455, 0.48359623093868853, -0.6412852069333603, 0.05228695024771829, -0.12926439252693, -0.06351728976337276, -0.16196037047615866, -0.5426741255635882, 0.3960223561341875, -0.361100490246384, 0.4985542362152765, -0.5402753236018021, -0.5523831641913989, -0.5778291084897117, 0.2819429821500913, -0.3993264176378016, 0.3279769691079247, 0.4741402302909038, 0.22025006451981427, 0.5887119067385564, 0.2549440348907784, -0.4621779765881124, 0.28209724286454974, -0.32800913490855826, 0.33274404437098304, 0.4058604722240388, -0.02371861167227556, -0.2503404338082106, 0.1565692049986389, 0.02344083128924422, 0.3612935869297226, -0.06267955152913439, 0.27397778052466065, 0.3745527015783384, 0.15736855939130118},
    {0.59877346547033, 0.15869866240116215, 0.3371065675705679, -0.36000726247042514, -0.24560016603593293, -0.4324370916299354, -0.2879375566913186, -0.2561938581197154, -0.05614104617990949, 0.20134011113050032, -0.33932258854960595, -0.36586798433557643, -0.04152814299006446, 0.4524900219723283, 0.41462780566656365, -0.20082383968261572, 0.49034006370948313, 0.19785394014649452, 0.6143246893783776, 0.33852617758321824, -0.07020148004751865, 0.022267857681192018, -0.3424899359663344, 0.20495854401438454, 0.21924475659774678, 0.4277312878324526, 0.18738392774668333, 0.052563503106206756, 0.14792052453450563, -0.41286210667135986, -0.25433517189502547, -0.43793469813927166, 0.3061196675353806, 0.27188160431488195, -0.022551594984459432, -0.064417033452594, -0.18218533304245763, -0.26420544161361387, -0.46764803382869, 0.013823617450791076, -0.32667061360306643, -0.1776825677263061, 0.2829629714096325, 0.08635379635333393, 0.06676965690532373, 0.5608718881911571, 0.0029703557728876927, -0.21735852420446955, -0.19097875275153117, 0.26032207068391916, -0.07353415632653991, 0.41113348174407593, -0.05555369845109664, 0.4523768394669233, 0.1691599763134547, 0.17384884980718848, -0.3653762978530909, -0.13596169563619853, 0.1450040890643007, -0.13736237611851876, 0.24480613355365646, 0.2948643204351277, 0.384679209066879, 0.02945026952550471},
    {0.26402806810220475, -0.12303777962435802, -0.494344126429567, 0.3807745982332811, 0.07365594818963114, 0.4761373879319733, 0.4353374974985168, 0.2031021066650627, 0.5262922734856925, -0.2670352891050403, 0.2355404841727384, 0.23366827515619626, 0.26903579473573835, 0.3205196577741825, 0.5687777132782288, -0.37061601305421177, 0.0752521521077503, 0.685025753420014, 0.5383520750972346, 0.4935880681714083, 0.10392989751744873, 0.35736100342226523, 0.2841193880779798, 0.26843521481873023, 0.4945008638042038, 0.32895675063723784, 0.2821934283876795, 0.32595878650082, 0.6581678481370159, -0.23106520809347855, -0.02247181901563628, -0.1858421806989138, -0.024048048954393383, 0.4107090432495329, 0.41278504378258324, -0.11482041303763191, 0.21473124979690106, 0.07843981197916876, 0.1784276735711129, 0.22629683325831496, 0.6006974363631021, -0.0870076682385096, -0.21344723719454006, 0.1471209200762347, -0.22740225721905072, 0.26339143980427326, 0.02741519363899956, 0.0793112727971992, -0.5293794342511826, 0.5088219770089694, 0.22153539900067026, 0.3537161279094059, 0.5011509317141397, 0.2013613469254944, -0.0315985822306904, 0.27042128480973965, 0.4844581295031714, -0.015929437366841145, -0.3449907131499073, -0.31261423278094697, 0.2840202650551754, -0.01597776987179011, 0.13229996126020915, -0.2957478324126347},
    {0.13659431549478743, 0.3201684906215715, 0.22646926270887224, 0.47914723356532246, -0.12874108739464585, -0.2882382147619915, 0.4194798359484082, 0.2583883083263976, 0.3556562011108407, 0.011603476671918493, 0.24298743552427682, -0.10812312219772074, 0.19441182481456773, 0.3271346522878229, 0.316886914441977, 0.3129528788203055, -0.590263552870265, 0.5412652976814469, 0.0155850849468881, 0.36232987942883493, 0.15755983822331024, 0.48588080459567096, 0.3807820808176774, -0.12528911913725202, 0.45984336810855925, 0.5051294641599554, -0.22060257926942434, 0.03146861068210579, 0.4509036781285719, -0.005046069545017696, 0.12100274423566668, -0.03878425364569194, 0.08472175887578934, -0.2546023327702905, 0.2182780303801804, -0.3940255794309866, -0.2482808938015745, -0.1168690697479155, -0.07516676040570151, -0.08906869939690919, -0.15835856023104838, -0.3970365299379786, 0.0035729558092349517, 0.4083654070547248, -0.16007245032766826, -0.364907186433323, -0.19017755808251832, -0.46651671299298514, -0.3061151242082874, 0.012031400836225215, -0.051783812968420925, 0.5725819611736762, -0.039716153533943054, 0.27829118870967345, -0.09204610127733844, 0.23698031182625584, -0.24604682960308638, 0.2764532774649252, 0.10945656187464231, -0.19983663689981185, -0.0032249225629133395, -0.21321467960607615, 0.09785669408734847, 0.32278669534677995},
    {0.10038585459754516, 0.10853851030014795, 0.1133287515375977, 0.5053244448517944, 0.4823464164012937, 0.31065882299802716, -0.25383282472081875, -0.31601319069739564, -0.01604892952711708, -0.5813655964216236, -0.35214888822542767, 0.1505561303136806, 0.3489115803168187, 0.10571787213973384, 0.2557816409948438, 0.16333974036841045, 0.5109569645117605, 0.32287761060933406, -0.23550182708941866, 0.013537204683698805, 0.08059362235000368, 0.473792258707556, -0.34388430563317474, 0.5350142458214036, -0.47823835960108196, 0.616259544748086, 0.20592041212945064, -0.30379625939099075, -0.022970146674954697, -0.27919405201888015, 0.5040447037319065, -0.5225966527404554, 0.3154474641329029, -0.20086634702359493, 0.4440852322343389, -0.08752020178883903, -0.2460880662399709, 0.09919472496948475, 0.34902221687984153, -0.2573685172874698, -0.05966613774058295, -0.3869941128361242, 0.1986256986226718, 0.32327463437806947, -0.08269578074603215, -0.2052945799623345, 0.09399014257633671, -0.07149238122782044, 0.4503409906251555, 0.10383707829174077, -0.10760884609183141, 0.6899099161511162, -0.11421213754901531, 0.45839354509270575, 0.32126642081276274, 0.31288990500074815, 0.07115408372739271, 0.23551568363451483, -0.3461611967060085, -0.12475987242210342, -0.43246818935036113, 0.25019713062513615, 0.09150343719501591, -0.08765734707905265},
    {0.32547435641408745, 0.46414133511584366, 0.09200451092055327, -0.22542532062593293, 0.19727940565734178, -0.08237647725330945, 0.06087813839751731, -0.12698839982301677, 0.32348530392834424, -0.029191718310854663, -0.03165237442001247, -0.022754734237670608, 0.14053540533661432, 0.43744753867843583, 0.3081536022942733, -0.12827980073800282, 0.1342654941313542, 0.19309740125291916, 0.10838204581048339, -0.03650899129314703, -0.37972347812033613, 0.4490783021539023, -0.06842588669387721, -0.3674661301454751, -0.6601230385372621, 0.17675357373749118, 0.0539641085588308, -0.3432793965366706, -0.116757500604709, -0.34046294062579696, -0.2600987755277056, -0.28042942933120685, -0.17912125398075715, 0.03516318816970599, -0.44819083849710967, -0.4394360739470511, 0.02372443368237346, -0.1926485150195395, -0.12537961479190896, -0.048203682489590234, -0.145261694365712, -0.14561750786729086, 0.4765993106986043, -0.03673479906548437, -0.3539796288302268, -0.4517183204076, -0.3013513141560334, 0.06863537230543464, -0.0789801379355564, -0.06340240397450007, -0.06626049702178134, 0.2717314908484908, 0.2647557546787287, -0.025808388662456227, 0.27890002064603103, -0.1962500912732232, 0.32666732848666935, -0.34451945402786754, -0.1514385012242798, -0.2697120222599714, -0.18963693084180092, 0.19595003727294225, -0.36253251585495666, -0.05972478399744387},
    {0.34058925832763676, 0.6414768378576199, 0.46667533633142244, 0.5697464355037578, 0.4044522910937397, -0.08902955127719148, 0.42289001468154674, 0.6201724997661694, 0.7212879147597785, 0.18500525518402097, -0.36972764134908154, 0.14177687969106292, -0.21192109627933184, 0.5513163472933827, 0.4745047750240845, 0.08494801347595725, -0.020392874710711502, 0.5227917591075565, 0.5406757971632962, -0.3489142731549883, -0.05804113564101215, 0.5512357266615892, -0.043020241841271296, -0.418948222889659, 0.0034553328757699208, 0.46405693418910565, -0.17026089895820767, 0.58955357866475, 0.17769395928799023, 0.20376175836381122, 0.57106624704664, -0.6439956336513472, -0.018825877935799616, 0.08834186498427309, 0.25662679566458046, 0.1430412421977733, 0.36741582303384523, 0.357586435808674, 0.15684262722205305, -0.4104308234888521, 0.449710991422032, -0.2520210249911708, 0.23145485843319652, 0.4535330014018751, -0.021742214756555567, 0.0838279204070287, -0.06143211234612969, -0.24154833578780255, 0.44163120389608285, 0.1564498102362477, -0.2456216253751772, 0.10260804873785419, 0.6688585356416915, 0.4533089013279305, -0.11286194053703208, 0.3122055665780539, 0.28297090740373965, 0.2795132730288855, -0.32495690947059575, 0.30574759080540065, 0.4546198883033682, -0.10994258013019235, -0.18108493375363927, 0.2814313238233354},
    {0.44423340810116413, 0.6200163640102995, 0.31572763172592955, 0.6107844127462191, 0.5140152760281563, -0.15882725002159123, -0.3133718214137246, 0.05879372237032735, 0.09305368526422104, 0.2050290103902844, -0.387729409343994, -0.3252550955555271, -0.16003588669742289, 0.6144985058194049, 0.3556581989671912, -0.0731812525100213, 0.15002629275066356, 0.5149229737270217, 0.20514015162485225, -0.5702338209306173, 0.10241559553165341, 0.6264988732406821, -0.17304800134821116, -0.05140333607907733, 0.18713236492422294, 0.3401031937006822, -0.09323006855318783, -0.5995930147210873, 0.03605430253986535, -0.27231784696579014, 0.0065515836614039, -0.6455330324943737, 0.30637213753317405, -0.3738130036649027, -0.2550879230339709, 0.1229688017665107, 0.06565771965944171, 0.09632276547341373, 0.5291735014142983, -0.4677159985760307, -0.18420704076662825, -0.45554629874562497, -0.47453694775668853, 0.5338644394724701, 0.6431810441987065, 0.3596124291905425, 0.1557020676419607, 0.29192060897810845, -0.0816009417690389, 0.6088106109210388, -0.09370579533942607, 0.12921184973248928, 0.6282633542235438, 0.2286797739212552, -0.3796916212542212, -0.35245210262188414, 0.14477681918213614, 0.17293837418759925, -0.7523324680288576, 0.3803163642942108, -0.6108356214948356, 0.4582199418504203, -0.11071664888131742, -0.0796196180343545},
    {0.34078484333328946, 0.6767632830883196, 0.06619856582608409, -0.049557808093534675, -0.24724502816765717, 0.4731421769161336, 0.21070439758258935, 0.009590538867449079, 0.2923954336946657, 0.37587124182744863, 0.247840744341581, 0.10805310809623246, -0.35064244074323875, 0.14560764426354908, 0.5427367351999065, -0.450932346168959, -0.025424054078123204, 0.07759391969689977, 0.5079599938289759, -0.21646301694779962, 0.20300472021465513, -0.17314675771892957, 0.14828144613224647, 0.5356795808849629, -0.5278939700762277, 0.5491747918980204, -0.09935010118842583, -0.01954748784709612, 0.2303415671870673, -0.4107146564046513, 0.2749883290997225, -0.15409173556235112, -0.14901740538880084, 0.5949264920492242, -0.20203769453775539, 0.26757099484880964, 0.08959116888734195, 0.0715762358812521, 0.41833643266134857, 0.19206416073860622, 0.27255314703621747, 0.04695087063571704, -0.46412118245314965, -0.09392973047349208, 0.3988512033238094, 0.0037763464241486167, 0.3382196997853149, 0.28494790064079994, -0.4132179319113766, 0.04587639418547826, 0.3293471913784992, 0.003531994108216091, 0.483228744237854, 0.5256821356974241, 0.5730182661556308, 0.2759455238345845, -0.07478307873040776, -0.18352938589873258, 0.08609089051524062, 0.537227463916891, -0.17035456543716243, -0.36390482816915604, 0.48838108290977283, -0.09386057368417983},
    {0.18318144670263506, 0.48152266423462214, 0.07545458565419207, 0.052710740467067994, -0.006962469110257788, 0.3231591744816691, -0.09650204921839055, 0.37906911473508614, 0.18815928824377234, -0.048851475373189394, 0.07067264413970899, 0.17917556291557854, -0.19482210927373103, -0.09958144905459086, -0.15938132171190134, 0.14155666841028156, -0.5430462263310305, 0.4055340000158207, 0.2945152628582728, 0.594071646808903, 0.04490572094278281, -0.02152019089188196, 0.07484842782173602, -0.10155230098255759, -0.2083641076603492, 0.19936654169150314, 0.3283951622156762, 0.4731465935177524, 0.47185210328903665, 0.11662501513042858, 0.23958472463073802, -0.5390219434304238, -0.09043020769395656, -0.15975033769534414, 0.13919931062331953, 0.34096599190222127, -0.17560037842678183, 0.22317818975779039, -0.4999755475576094, 0.07888265881339969, 0.02057976062874769, 0.2947549160636364, -0.44895116527354456, -0.03534667423537948, 0.3978364798836621, 0.26267244370400333, 0.20295346748356893, -0.5703396784035012, -0.40067107448017575, 0.44768242741619724, 0.07190698803378362, 0.5719679802217471, 0.1758719011178389, 0.5293645724844136, -0.028588220955517923, 0.4149578689242518, 0.08574557915624083, 0.33745053111993606, -0.321777401351283, 0.025103144281639095, 0.32115376447705685, -0.2794650817507081, 0.24690415958843337, -0.4827907736181674},
    {0.21667490274743686, 0.43600456328253445, 0.2777980053550048, 0.22629382811041984, -0.005594373367791613, -0.3503767770471344, 0.1525367940582301, 0.5151941332983435, 0.48343909649314243, 0.18499398990154314, 0.3113914001153961, 0.01911829142631022, -0.052164061827295646, 0.45968385425449315, 0.1394093816490453, -0.314712521305009, 0.5784907339679829, 0.36007959851340116, 0.4731217025600803, 0.5468474503389237, 0.23113163713116902, -0.2562045103830027, 0.13526804725577943, -0.14103664306650476, 0.13237906532811208, 0.393407198490111, 0.003038493082795367, -0.016766057784187216, 0.23474953484933705, 0.3311622678581476, 0.23866268267156582, -0.5288948819776299, -0.47520460024880656, 0.567278871412342, -0.250774834298547, 0.09856575381717886, -0.21936762168995336, 0.1895874689050907, -0.1696180345734899, -0.3091126238633968, -0.04325459980267628, -0.34198127524235017, 0.24936756058225146, 0.4328066283490265, 0.15725074248328744, 0.5355652114872418, -0.3095740282154885, -0.45479817225391994, -0.4208766819753143, -0.21431907478117176, 0.07108664197780332, 0.09420081901652612, -0.009376265020765549, -0.24799181413018906, 0.1419346406860607, 0.5261153178510193, -0.25575069059339534, 0.49412647677501503, 0.2159623012392381, -0.052982592778515185, 0.6571241272238827, -0.08597574399089959, 0.46221630425122545, -0.02843926992934521},
    {0.5408588214940085, 0.6103269949850371, 0.5643326265409402, 0.23115870264125504, -0.2180123198978069, 0.11732682523366997, 0.5386446774928786, 0.5899788624803634, -0.1709608962493084, 0.5136802919639553, 0.15792038111315818, 0.04010087468261015, 0.5485200805882771, -0.2357766508867315, -0.05463401715722609, 0.5127629802035647, 0.24277584442976782, 0.07348718622906764, 0.34525195185880536, 0.24760900074246978, -0.06943925824767773, -0.1496204372881795, 0.3182721762749895, -0.06391642172302126, 0.3459444876885233, -0.04492758144454609, 0.3511278867070051, 0.6036402710954533, 0.3762723854287857, 0.2411704431031069, -0.09201496935924126, -0.5071527555967942, 0.4710307217747081, 0.08961652976400207, 0.005052973844081806, 0.48174837697753503, 0.04492774108296205, 0.28137066778508396, 0.3216299977079699, 0.5067474068686584, 0.2608954666211038, -0.045576713270157554, -0.735946935813579, 0.5221282843211007, -0.333882465560515, 0.1534601260411675, -0.39139448697734947, 0.4406146164755718, -0.5617103320538869, -0.1586749058124029, 0.4222854579896653, 0.2239297291056685, 0.31304541564185623, -0.05402739665613653, 0.07226042663769854, -0.11047616185571832, 0.5544842575798087, 0.36244352897185234, 0.2520492537916148, -0.06253980968389784, 0.26273010273753195, -0.1352767950953058, 0.028454918339651296, 0.15768618113314464},
    {0.4590283451049186, 0.5381760004037545, -0.045622650822239326, 0.41897259888567895, -0.21781711367160866, 0.1603633523048274, 0.6286762649108567, 0.6210806772436827, 0.4145685244729767, 0.4210315019694464, 0.45155406489642336, 0.1421206711303931, 0.5961169524353667, -0.11370944885599926, 0.2016353009866989, 0.1549959988045855, -0.3067521291363941, 0.6500445143839196, 0.22547662726418038, 0.05779070432571188, -0.06588288291602805, -0.2064637808529755, 0.39985602786202895, -0.17691764766885176, 0.561231720254811, -0.23408599911366834, 0.31171398569399184, 0.646331399333741, 0.21648186758921625, 0.5896912698816537, 0.17634209895532135, -0.4596929895293027, 0.600225942628189, 0.5391920556580262, 0.529508578085158, 0.6284140050041402, -0.44209148180006924, 0.5043838200392243, 0.4540504221478343, 0.3327809536296691, 0.17429696153531699, 0.06561808802560538, -0.7785499784274296, 0.3528172894128044, -0.14068004944949705, 0.19615709873539938, -0.007023662160244309, 0.2765276582748142, -0.15926448659088932, 0.043273653371194855, -0.024813625633310802, 0.37707388159437805, 0.5656759501215713, 0.2707188889097146, -0.3399766627354797, 0.6739911050315252, 0.03565583057302914, 0.48582977867828214, 0.14042516419273643, 0.07542294754752175, 0.4939442463054099, -0.1706953785130336, 0.49711977384480166, 0.10175442195608812},
    {0.5750036727906072, 0.35246266288733114, -0.040885478016085934, 0.4289248532100042, 0.017161735481062698, 0.5418336502834694, 0.18679833060233686, 0.16450854640294052, 0.38092184122073125, 0.5230953677174713, 0.059825042137547566, -0.04639003716549611, 0.05176440151394687, 0.36541382796672844, 0.4274070497322607, 0.10884799876479241, 0.16387869647540276, 0.11256917175989889, -0.04334752956901735, 0.22253098277315222, 0.19040319307291106, 0.06514457431189635, 0.4732198493533214, -0.3519951056126478, 0.4756049786027259, 0.2065195958419968, 0.47354944568836266, 0.14106169306142044, 0.5767460950833938, 0.23372226386826017, -0.291966327829766, 0.26339669596140913, 0.030319621342693403, 0.5160327254049921, 0.14597716963411617, 0.6256066404589102, -0.2799941113330621, 0.06251892555488216, -0.15763181889313438, 0.05692821681627128, -0.05989521896898277, 0.0802486899885874, -0.430498919317605, 0.14981752644426996, 0.11828555936674544, 0.4910553020469976, 0.43677633857617076, 0.3015205166582661, -0.0812781589364276, 0.08317371006384894, -0.3764894113116356, 0.4385802544436375, 0.049720507338022246, 0.668470664569173, -0.3228576500088964, 0.5110567819773758, 0.41184320259083196, 0.0031094369837328085, -0.16553106936673675, -0.503489512782824, 0.11348270808237954, -0.6119316192063928, 0.41854034907960463, -0.14880893740361611},
    {0.07931933988129271, 0.5305222430042599, -0.0785124265952132, 0.6315123718863324, -0.2744105904836853, 0.27133172619205476, 0.4283472449946649, 0.2310884746715607, 0.3365689292457236, 0.5592344523742812, -0.12570223541983033, 0.4215385718811543, -0.24533548398667035, -0.01900456660718142, 0.21827765448656547, -0.28492994074073924, -0.40962415637490857, 0.10993281256058529, 0.503131771219663, 0.3079060344047321, -0.08340774656348879, 0.19712965906080313, -0.1912407373494327, -0.24011911293537647, -0.4442010185210663, 0.37998259060985196, 0.37392571918578776, 0.5034468387778912, 0.36325263233587957, -0.3487471914306434, 0.590419705447438, 0.34070788116117445, 0.11757609438804932, -0.18459543361633543, 0.5564963787761092, 0.44271103416497565, -0.006276162207550854, 0.2929746160058553, -0.4788602833230109, 0.29964992413444175, 0.5761759264566905, 0.14018757001998036, -0.5051358870862684, 0.12807555299648968, 0.26182657091376577, 0.029493078008985932, -0.27978967927520665, 0.2198858120736762, -0.025553545892229117, -0.063729200694037, 0.3878635350609887, 0.3292253094921746, 0.4712035564633644, -0.06700823926135052, 0.5801875277101578, 0.45544774613169015, 0.4460274319339949, 0.507851473364811, -0.2002563707811744, -0.4136067892704203, 0.363537435352905, 0.3595655669215842, -0.027214868194244072, -0.10972448461169375},
    {0.37505378793410266, 0.13737122649584646, -0.5212550498149883, 0.41846461971157983, -0.42397741351934193, -0.5986769190848564, -0.03953199273509349, 0.06327222922179979, -0.1355528290393227, -0.19896753279336715, 0.22057622949537634, -0.35391805274836047, -0.20560026901706296, -0.14030249326911148, -0.03498025410225247, 0.02008363407946177, -0.27540425537873386, 0.2792413315088019, -0.381207189075221, 0.03916731645190568, 0.18728841743958338, 0.15364234372259555, -0.37352124810322385, 0.20795873404991505, -0.21632417173308194, 0.29441998364245264, -0.46882151427203617, -0.30718231229302384, -0.32189862282913667, -0.2363845799693687, -0.5014453059399216, -0.5585527301627925, 0.10539391033585528, 0.198969679836282, -0.00394669267277194, -0.4891070633435844, -0.0010214473360643933, 0.06423074898323565, -0.389115617867426, 0.3103993020913769, -0.1297368069361481, -0.5622998192670482, 0.030356477371053105, -0.17146210501592563, -0.6003428863740439, 0.24035592217698504, -0.27700015633507663, -0.29785978591757883, -0.0313094351464328, -0.17424879933691842, -0.5236743730875625, -0.5118710107655299, 0.19756794073804157, 0.25893970152160994, -0.38664878656511187, 0.1557018661198951, -0.14654620097887033, -0.25324464707661676, -0.10897310652097164, 0.27216013582227566, -0.4542905372413738, 0.1258456443987672, 0.35833156964966556, -0.0561962369598676},
    {0.4821475418293648, 0.5086999120875321, 0.12823567551146559, -0.034101529460073145, 0.1733415624228251, -0.10156823658364895, 0.1483854131732739, -0.055257337250839346, 0.49000421092995605, -0.4030693114518634, -0.38403141859158807, -0.09519112412681295, 0.33757853534156257, -0.3336937407061646, 0.473151374240889, -0.6150690644430433, 0.10198773849164003, -0.04655496117401806, -0.5493532514997539, 0.055658262077371685, 0.3267297685942919, -0.24752357959373966, -0.3959798475127162, 0.17843024625896, -0.5768390371629554, -0.6343937632616141, 0.19022648747874274, 0.15937246923470605, -0.3661479272758267, 0.01425881060737643, -0.25759169066383636, 0.07539107283564507, 0.2290720611933795, 0.5509207430220302, -0.21283848338317624, 0.003367843464270115, -0.2364432679453836, -0.2049465420743658, 0.5125694394061077, -0.4457824439589859, -0.44817414731591604, -0.325637609045738, 0.30804178091064016, -0.037477598318906215, 0.01914843445603869, 0.3922213837236249, 0.31041148836922716, 0.5045724662364792, 0.06818023793335436, -0.1922078398228273, 0.36338115271926663, -0.05881573937423058, -0.3316138249326088, -0.33845834083888515, -0.3039102413017544, -0.09026852129879091, 0.15391846639002024, -0.09147508889329291, -0.3380290772733474, 0.16959848832051944, 0.33954895520286754, -0.35130298184833575, 0.4199292726363633, 0.28612022074051685},
    {0.17352508887655207, 0.3073513221761473, 0.5166285628986772, 0.38246676233666277, 0.1595270030360336, -0.11392799209933521, -0.14205470053959685, -0.13361938469244714, -0.13128950379306448, 0.35885832941795487, -0.2820143400627382, 0.014530033339139601, -0.1252771912673241, 0.17942900417930266, 0.09631774164228882, -0.21945211002308404, 0.044444301054537484, 0.2671517524879287, 0.45732372530202986, 0.23085047619314245, 0.08458065139194477, 0.22314908709489903, -0.24903269909520026, 0.04464586240019151, -0.07915170578342506, 0.4096097605152508, -0.06068109916845858, -0.018778068068758515, -0.08523647502793805, -0.3159138925948327, 0.0780869492624463, -0.6711678753303614, 0.47031139627160484, -0.030606911153368478, -0.05543977910398143, 0.14312618078364195, 0.05971434741432545, 0.42116135338429683, -0.09988474820681807, 0.45960804765529734, 0.5237832244242681, 0.2548309736552883, 0.2545898962298358, 0.4495235259636089, -0.09909680741219366, -0.4103684264482735, -0.21944216475206066, -0.29069184132361364, 0.42255626622137216, -0.2784119795676073, -0.24464590661016122, -0.4083126394804927, 0.4810278287794552, 0.18224573405993272, 0.4831834891084045, 0.027131418323238714, 0.5829351494964679, -0.040759158035739866, 0.2971977402299285, 0.36613300058214715, -0.31100240861714545, -0.2065979409501146, -0.02209726943000988, 0.09679848989570003},
    {0.5016439185468152, 0.20406444353685207, -0.045364738673769986, 0.7319630135742865, -0.16443149360722942, -0.1514167895706433, 0.28441734285337583, -0.37028676633195534, 0.0719410571701341, -0.2167450556496971, -0.07177884706989099, -0.5362402397109945, -0.1270153225448478, 0.6056209013274616, -0.1541701624189272, -0.4514785281570864, -0.07543967199365896, 0.1786540302923678, 0.14132158677676288, -0.1707245867566283, 0.24428602808816263, 0.6563636941463117, -0.06986246634847504, 0.4652182118852179, -0.5600432230586256, 0.4186162808895523, -0.3013059116415603, -0.41877545490362217, -0.19322994577147998, -0.30155572733262803, -0.4124698156567916, 0.33119772050506047, 0.13547353306683707, -0.10947333063806186, 0.4555072476586433, -0.2819544854015706, -0.7561906457277968, 0.3298655759203974, -0.5762511434137225, -0.49470188699207485, -0.4827933176116274, -0.6349986859241481, 0.20202426708653726, 0.10480564965526515, -0.1981399022814373, -0.3085094428569084, -0.13780935743286798, 0.3627935034377213, 0.05677885913408043, 0.07088114665284764, -0.3038074516397912, 0.5777136527637098, 0.22011791291325977, 0.10087610613266515, 0.1335464630157265, -0.4993955195156436, 0.2757663288721422, -0.15743258447416622, -0.6350293462056725, -0.21886832125106845, -0.558874865713417, 0.2858357630753129, 0.40733260695743956, 0.3835456399867377},
    {0.6002658106386318, 0.2786673771252874, -0.2760773003131227, 0.3209150361113396, 0.06309737669984804, -0.4430892862894812, 0.2222371678229408, -0.10257536437702389, 0.3301972025808778, 0.5755811209472499, -0.4333389686397282, -0.2916507056479962, 0.03437058835734453, 0.060527924186197436, 0.4840836537115696, -0.11944005996034958, -0.33890942103925226, 0.37541494831429983, -0.39012512205169014, 0.21354045369932387, 0.06923237638190216, 0.5874044246943944, 0.07482941306047712, 0.4377727352425802, 0.22035823411329314, -0.4526050296680951, 0.06320885331115662, -0.006922980538078527, -0.2663115588554744, -0.02480201887390093, 0.15242611355164454, -0.28062547069386246, -0.05875640784890007, 0.3270569154544737, 0.06741349540084048, 0.16383612882944695, -0.0002137756880710908, 0.3790707220459162, -0.15952115082801563, 0.19039870166049622, 0.06063621205436007, 0.0642537607459417, -0.3658430947500523, 0.08766225081929709, 0.5746900848882174, -0.03848330410339343, -0.04227268395103503, 0.3437099879237459, -0.03325529288601941, -0.17961332952035636, 0.0026047761632870836, 0.36133228422590485, 0.38322502557274973, -0.27171258901656253, 0.0011350588413965436, 0.32277184314360174, 0.7097692066805208, -0.005952283881547821, -0.11959883864160613, 0.5032520100014669, -0.034066461788869885, 0.018716474713986082, 0.38079615794204624, 0.2190608329674183},
    {0.7826121392611862, 0.4077595747348264, 0.41797752664603977, 0.22799919173595418, 0.25013095650311296, 0.05879251600565951, 0.4902536266454914, 0.021323852864114264, 0.5476158267522809, 0.2802935140053829, 0.09859274543534569, 0.33196462752971606, 0.5367271495573737, 0.23840466821531456, 0.013756994838325428, 0.2612270972324004, 0.0356295035423549, 0.5977862360008936, 0.24789437869540878, -0.2869719530499787, 0.2840024231786627, -0.1028482456151943, -0.17714571679490038, 0.6045506256518897, 0.34164842464456, 0.5246810143001367, 0.22819598687699358, -0.4695418496238633, 0.13245607642954113, -0.5077165507869912, 0.31891966560166146, -0.6754270662076048, 0.8380582240178751, 0.6541898392345945, 0.009229684356896086, 0.3729195164323532, 0.029528049442956894, 0.5220877516737915, -0.37739124258009626, 0.6153565806078402, 0.03968343405441994, -0.14665407297908684, -0.21511375338705893, 0.4279886865835339, 0.13543378706310627, 0.5558658330847251, 0.6272327639295971, 0.17730697255398692, 0.1503045367586392, 0.5040079166231818, 0.32175008093538815, 0.6384284883698743, 0.6049927120756673, 0.7538007774312201, 0.18476868688194364, 0.10625738749723454, 0.005002039392732072, 0.6244337310108503, -0.2130412145283385, 0.344227532876135, -0.375402421743887, 0.27080066209099196, 0.7784792643797314, 0.5994784447994872},
    {0.599139598844737, 0.48091825739470073, -0.4688307644328137, 0.14523115844143167, 0.05709909924617871, -0.5365209821169264, 0.45614145926235655, -0.4496181460705929, 0.3455125811439443, 0.21875523162129185, -0.5001232216521648, 0.11694320776943745, 0.42833712109692335, 0.4528222408677659, 0.28029792755695704, 0.049060840017990076, -0.005228510439777307, 0.6103814517146631, 0.28113908470798055, 0.13568497689531617, 0.3826779337142942, 0.19624767631137055, 0.06872008305713598, 0.033831649161350626, -0.41475461624247223, 0.10866296881014943, -0.22642738463853865, 0.026904634278547994, 0.12858502556461424, 0.07661450399396309, 0.28846364617393555, -0.12122314090558299, 0.12913088019388436, 0.25288756488628833, 0.1438552745159764, -0.09950544492153911, -0.34376016016900723, 0.007138901034688637, 0.25658012132219904, -0.37804795789876705, -0.20797819193544065, -0.22067781970338068, -0.48587445937741897, 0.6259039072280569, 0.03138994125814147, -0.28064026858954105, 0.02659427107601885, -0.15008693773912105, 0.3154295970529493, 0.2875838753982805, -0.07629185949172151, 0.13779124733654616, 0.08419754391552223, 0.45709329748353594, -0.39967443151561494, -0.2100558170504825, -0.14085894949923713, 0.30079561780631137, 0.12285315491797004, 0.03584230578757682, 0.024972297416844858, -0.5351192855328961, 0.025206405794000356, 0.4442878637337555},
    {-0.22044811276577989, -0.28123244076712356, 0.5323996643683009, -0.3075006028604426, -0.2837980016246772, 0.3209491225827056, 0.12473951917091312, -0.26847934086566416, 0.05996391864104755, 0.19733753277271118, 0.4661897870596696, -0.28222790913349893, 0.22957949357429566, -0.2947925482444539, 0.05284054324631231, 0.1436172537445817, -0.36683662720711174, 0.09142741955797289, -0.3050260025296009, 0.29480446737446314, 0.23565288111752936, -0.09460299714286291, 0.29289727725840903, -0.07477118494189935, 0.4355783060490106, 0.146733470755016, 0.14959419502455157, 0.1715079848428512, -0.27136626514571127, -0.06655819110267244, 0.2468173998426373, 0.3872365626444388, -0.21007679909451066, 0.22715850216439754, -0.20489428645879934, 0.20080833071829016, 0.4835345094240684, 0.08995022752132902, 0.0029771189175528258, 0.12242642750807728, 0.2416728529342242, 0.23412246214710675, -0.07087256582588962, -0.32595321381586023, 0.5648889845521422, 0.3421663232169339, 0.3289411547653652, -0.021294214005551114, -0.05586607409746612, 0.06019416912012816, -0.27298663337022794, -0.16398353568097856, -0.056405156006184856, 0.45134602657694084, -0.3563260641029434, -0.1966064590635252, 0.1480988238230738, -0.34984785535104784, 0.3261292683642197, 0.10336754229621449, -0.10824140565852972, -0.35470988005372933, 0.23041261586542902, 0.3266192595022641},
    {0.239252271916283, 0.2657009051322795, -0.34977605683249324, 0.009442812649139959, -0.17486355676463058, -0.2320194100832865, -0.10072789762895566, 0.2277150330946575, -0.2429351803350692, 0.28593549923677947, 0.090122085229479, -0.24051356937149534, -0.2253564181106485, -0.3390316367862619, 0.20743784799773637, 0.17767657913657547, 0.29286849345646715, 0.16415500823026272, -0.060961928733614945, -0.18847604184451622, -0.17503169518886227, 0.26483839681021276, -0.027226230836334433, -0.08207487737020504, -0.2920066443174124, -0.3463994070333195, 0.010719545998200235, 0.17824166180056675, 0.0934144440031229, -0.16258456245022548, -0.10067093083779544, 0.38672493520969553, -0.3379524642076394, -0.1682226603253723, 0.4598480340290559, 0.016604794031391153, 0.28947095856236094, 0.11139757640861195, -0.3466678587285993, -0.1800479322648452, -0.23676432003383688, -0.2188091485321793, 0.4294507633649394, -0.09484132528326714, -0.5034096304875769, 0.09142163408112751, 0.08438775544431117, -0.11519963478083672, 0.22210292529269954, -0.06527524674393191, -0.05827379349730241, -0.44391779111916524, -0.3015023006547344, 0.18716818169905636, -0.1841353482816686, -0.33975143195775376, 0.13219084984480897, 0.1791609746712798, -0.1318607404223554, -0.2174654279777945, 0.2778063646876534, 0.45027320967014195, -0.27577512822778805, 0.30476930448026446},
    {0.43482217812094015, 0.3256256276608062, -0.17501415501529505, -0.047705719007849846, 0.3127784008475925, 0.21476229710056507, -0.513473900430892, 0.06433567934893207, -0.16376438393949538, -0.05692655810089305, -0.2998842492246168, 0.03026428934488664, 0.10905996933234613, 0.3636054247309167, 0.14730626180481568, -0.558945911434151, 0.25385536146024784, -0.2271884590469777, -0.1498761477823513, 0.11988741603396326, 0.19016567668619805, 0.2548192304358189, -0.38740662433530565, -0.07121696036107313, 0.27728968809489296, -0.4810608041306885, 0.059127516257234614, 0.2040766181015509, 0.15446054566260778, -0.23899169391742453, -0.36813015791592824, -0.26260356550470876, -0.15966674844758733, 0.35190086512981045, 0.47336573198019555, 0.10637834646448475, -0.3145828708784001, 0.1710967342038828, -0.3820488103377419, -0.4836277423618118, -0.4169320203243671, -0.00157651516705975, 0.43545464868246614, -0.3686656618270662, -0.5347994775136589, -0.4045125288843988, 0.14409284092763053, 0.35480681880454246, 0.19825725807670136, -0.15053099269979137, -0.15025210766616431, -0.12784851245393394, -0.22730612751548607, -0.14064145088134353, 0.30259614738347007, -0.29608643236025145, -0.26985425678617436, -0.193600692100724, -0.2561622369268453, -0.1356098218731436, -0.14774748413008465, 0.06738678011248121, 0.24136996874404695, 0.16946005580894316},
    {0.1411615249985149, 0.1245325623684698, 0.08032268968951242, -0.10342959672019195, 0.33189419242681933, 0.21650611716161475, -0.3603442127243085, 0.01037863916758185, 0.2732634404920214, 0.014931323127780607, -0.1348755167108494, 0.3506033619953641, 0.2670662739330367, -0.06236941171632309, -0.23313528012479834, -0.36432211390466024, 0.2233840169241996, -0.2619188415549677, 0.13219260642858985, 0.2543626219537564, -0.2717862184584204, -0.12073514720631309, -0.16095041082312378, -0.1718173201694126, 0.12836884498298393, 0.37697674842699525, 0.37121825140250314, 0.32624131501548387, 0.04996227990464406, 0.30310859652217803, 0.2532094070109991, -0.23132872591918802, 0.02163753487806429, -0.3265046881055811, 0.4049617292330961, -0.2831126348552602, 0.2644364679601473, 0.20718715604911164, -0.08706347547118191, 0.12325435358844282, -0.005249328287256159, 0.040165706150170316, 0.03808184479298862, 0.00032346791008359147, 0.3017851543591637, 0.07827909873941422, 0.011731497204005095, -0.16235734797262819, 0.13017020699682205, -0.10325779680273449, -0.2041875964684876, 0.4025331747733277, -0.2839571267132628, -0.36323389978220383, -0.2068755987719684, -0.19463784136190163, -0.3616457058878827, 0.24164229903764933, -0.2673537278248564, 0.2684154895330964, 0.31096591970184395, 0.1332049458292129, 0.18500255377617705, -0.14311334218643135},
    {-0.19424549383416728, -0.28988110784005217, 0.38157695966242644, 0.13376228593620476, 0.00909852686388727, -0.44391341766157755, -0.3802383816361331, 0.00036844518169268153, -0.2018957906191775, 0.171290272025884, -0.29785924345605813, 0.3260682140424573, 0.05456493734398757, -0.25708499405971585, 0.11001673208355722, 0.049111040519759314, 0.2861200847690217, -0.026840504712573432, 0.058840681983477194, -0.3935188908274597, 0.0008419764558926669, -0.46073184016139923, -0.4016170232553865, -0.3344501097724421, -0.40314606276346104, 0.39722916279230425, -0.2641743825187805, -0.3784388913981037, 0.08348850464515017, -0.0346852991529813, -0.03761556210132919, -0.013623458696698097, 0.4364428560338934, -0.48127825698147997, -0.07260781087491348, -0.38433089134944276, -0.15868186861023326, -0.10321261916265785, 0.47295307162012123, 0.09777066968308787, 0.0025788944879113406, -0.19580812035360273, -0.20538735409494327, 0.33711462421709215, -0.3320498004180295, 0.24244906393543575, -0.22896033595810697, -0.15243994154170193, -0.45688174577639995, 0.06853055359852643, -0.34686411405106254, 0.12208722437148774, -0.25368182696045116, -0.27732701806622206, -0.19147404747721447, 0.33469542304955463, -0.1806079478449892, -0.09857637939359831, -0.3313714972270486, 0.007519518701113847, -0.09396365619916841, 0.387118831262836, -0.05861066704428437, -0.11285185294601899},
    {-0.2669865262096752, 0.12089947569094137, -0.23345347646103243, 0.09507701787968159, 0.25834014871444116, -0.158446352816908, 0.3000143763525816, 0.018143871568880934, -0.1558117695683769, 0.17938364193183148, -0.23823889924262417, 0.043581855816610546, 0.04277759461010253, 0.11514411617220979, 0.04410430797155814, 0.12851104448211834, -0.08174280027274344, -0.33468313680753004, -0.23648793567353826, 0.06288576723165681, 0.11401113051370902, 0.4066749856415648, 0.1353446531577649, -0.16741442477261573, -0.061159105512408385, -0.027867956166920265, -0.38793356331277373, -0.191365685485969, -0.10337032247498727, 0.36595593859105785, -0.026119034322953413, -0.43753999420733725, -0.2683800162776834, -0.03238602175473622, -0.4395470801424782, 0.24987663273835656, -0.37498544368890085, -0.3669027151172757, 0.2980827978583552, 0.2338208328359026, -0.030414290531360966, 0.1383240839307348, -0.5300429398573449, 0.4777015399310059, 0.3924344123565333, 0.20478586381992503, -0.13140524195784503, -0.35962816004744624, -0.31312774928629017, -0.1838518066990062, 0.00485638331894082, 0.34578066431251936, 0.02342693487529316, -0.29378541349550713, 0.21664474420055121, 0.03096195411458506, 0.041665776841435, -0.19147976776427003, 0.03554672620496719, -0.12333401114267098, -0.22138872479167504, 0.4216880685420502, 0.19897215809230742, -0.12735902171009728},
    {-0.03914480215430891, 0.3390865497485911, -0.36513947931230767, 0.37605912407711084, -0.03403277117827008, 0.3031671326375758, 0.5181408381008613, 0.04260724030695753, -0.2780349865594317, -0.2912328150233268, 0.11161391256664284, 0.04268697734472486, -0.21604433591289834, 0.29361669005820673, -0.3799586351472644, 0.22806196306859508, -0.0031911633915698706, -0.24519658332573266, 0.10997424449720349, 0.1522080039910039, 0.23263873558214732, 0.44130800392641917, -0.1371837663101136, 0.26295775543813044, -0.1202137483412916, 0.44606657091506247, -0.1266542554185752, 0.038658446370120655, -0.13264163256930286, 0.34600555835249563, 0.29361204904516525, 0.17473317925291632, -0.3198611208844505, -0.05074710466934699, -0.4652633921584237, -0.3514078570680898, -0.465153588541038, -0.18610670827933148, -0.020387203927901217, 0.26869604250991624, 0.29197087739572836, -0.10727281077043271, -0.15534061961915016, -0.06753305235235134, 0.42083159029790856, -0.22550255834444902, -0.36182258471322515, -0.02796928623121838, 0.193225169937065, 0.2191873183272087, 0.1285628624590636, 0.025798111134753932, 0.14498694851776364, -0.29252448648725815, 0.14282090567633413, 0.004081768008141198, -0.13802672142888164, -0.1574630428513298, 0.07874909112421322, -0.08682231596287701, 0.1383925501825706, 0.4207733807063264, -0.2703095894406622, 0.17686120779311462},
    {-0.33767140278048363, 0.24740439126777347, -0.3330994744162896, 0.23694291376577156, -0.2848254855655301, 0.21796442399714444, 0.15049175204871018, -0.056872126515516264, 0.20474616675030702, -0.6723485491541307, -0.19421647214853402, -0.1624223936670118, -0.01044272437782954, 0.003364799471052526, -0.2033397229923584, -0.4423860607197954, 0.03249467734860162, 0.05376071130854069, 0.2433826197915961, -0.4545323389961123, 0.10980469870491148, -0.010371303344947883, -0.3228911718673132, 0.21164191551511352, -0.5207759494274213, 0.09837679840789668, 0.0660081544811555, 0.31838586491307086, 0.13051378882962694, -0.09242013162789517, -0.26771197120726054, -0.15270630545662545, 0.39130146923626713, 0.23216376087916307, -0.22943159668309787, -0.42070501423830864, 0.015879421901042128, -0.13217043450598243, -0.603502534775771, 0.3691181365902361, 0.29874750185498516, -0.14110396584316426, 0.02296359636214904, 0.008556184706194568, -0.23239535482094273, -0.4612390012611667, -0.3792209649228371, -0.12076173218819178, 0.21859672293837318, 0.27100516446119177, 0.2465357907976145, -0.3495228321820487, -0.05105978536088411, 0.31785197574404683, 0.04156066946361271, -0.3572742619179078, 0.06252830307589559, -0.15966971851482206, 0.2543348491859801, -0.2063236673558238, -0.3797906933601056, -0.4477231951586996, -0.19182108282696675, -0.0609259445175641},
    {0.10779978810887277, 0.17350285580030728, 0.31145314532773877, -0.3124673827851596, -0.31639736640443633, 0.052384800079476504, -0.16917761852185037, 0.2093136127452612, 0.11145985494419294, -0.5492578348667514, -0.31259684179385894, -0.32465526484738066, -0.3880870360631349, 0.22613625278425908, -0.3864046840533993, 0.2413862211981268, -0.27889079951407614, 0.06647183579707464, 0.47373743264450796, 0.0673680635456066, 0.35044851009052647, -0.01887133535895238, -0.10761137974285832, 0.308562065867669, -0.14176586228005045, -0.26509928954038753, -0.0808116827530913, -0.23132521246386845, 0.13111922932878498, 0.049239293361466076, 0.040246513418081886, -0.31884036575932145, 0.4305459174711772, -0.27811056625357095, -0.21923289845505803, 0.30467520073795656, 0.3375185522732122, -0.1880752619408228, -0.4816933265975802, 0.14686219493069486, 0.2513719924616966, -0.19290221902482715, -0.48484873650589544, 0.3664188884094668, 0.16481749209443614, 0.12997087379417405, -0.06199158349785264, 0.1443626843768865, -0.25390199653352613, -0.03537713389705176, 0.15339440470781326, -0.3722018423057772, 0.33482408118222845, 0.38051263116808687, -0.05291975360558104, -0.2381227867333353, 0.12548636551325923, 0.04413015383973987, -0.04558661389016808, 0.0623050870999091, -0.32184035846161196, 0.04804585222049953, 0.1677161587022234, -0.4508591660954903},
    {0.05722459582649881, -0.48123860268991964, -0.3248114739793268, -0.28229024928701535, -0.2111818800806084, 0.28268360342426074, -0.4752889434315165, -0.312125846635517, 0.38171351256476443, -0.30245390724131105, 0.10094746209968918, -0.44091393384521915, -0.3370669827400326, -0.24861846229258303, 0.2079443050335981, 0.025528084952727157, -0.41217297251645707, -0.20829980976550894, -0.002337643191503895, 0.32291087567490884, 0.3545108093234078, -0.17693382040685549, 0.18553060543810065, 0.3312635023091529, 0.006250059540666783, -0.0382118808581791, -0.17489015309599706, -0.5147533116012569, 0.30753851876583066, -0.3282615599539803, -0.3020890663366632, 0.08661900169576638, -0.4277257590410904, -0.052616800042496685, 0.0484915627957222, 0.16243009672185166, -0.2905028383544616, 0.2867747572631827, -0.02965695305790597, -0.43374789358058763, -0.09475091795192077, 0.23454785971226275, -0.14299579058796333, 0.297432426632972, -0.05025038716002284, 0.17958351505163284, -0.4014272381442714, 0.30451670180814355, 0.06818883624362802, 0.18617820616977573, 0.14533301998502457, 0.1575908079665293, -0.035984981048692945, 0.18523539213923196, 0.32582363053301777, 0.11923880796588583, 0.10287600993783318, -0.1993334987452119, -0.41596826394546677, -0.33289211669087976, 0.08725143153532797, -0.1515743090808785, -0.0997848178527907, -0.3285046524017734},
    {-0.006512597580174459, -0.40229124729548166, -0.25445344766968, 0.3695943040447203, 0.05206804366038086, 0.4966913966855244, 0.08224429535250445, -0.03675531792054805, 0.20180487268441472, 0.4917717427985074, 0.1806478925622022, -0.026402588468917198, 0.3045856413147214, 0.043016881258945705, 0.5869951921905887, 0.00932022745252596, -0.22954836210252433, -0.07238876799067748, -0.26227964390726943, 0.017974541803862234, -0.039750326438799916, -0.12140145975031418, 0.19474491566334717, -0.0450001339639184, 0.2536540807195659, 0.007501124447454077, -0.22931113914773252, -0.34450958559697187, 0.4167802946555139, -0.2995861589085792, 0.08417326488610744, 0.06567918987017278, -0.233372462722387, -0.3366837285676563, -0.03630725412565661, 0.08814572691389178, -0.39198514318177624, 0.24308115546233558, -0.023286218213840842, 0.07921085766246316, 0.2884748120001594, -0.010744085319009005, 0.3205706675289392, -0.18672552361551079, -0.20781801882199188, -0.3153797717550739, 0.07917147420519277, 0.31348218799527294, -0.27459624072889444, 0.029716089631772392, 0.14490330511378166, 0.13357776682524106, -0.46424910016046955, 0.21451467545123798, 0.1812476508664598, 0.3447865199457035, -0.18190138081795543, 0.22669460545416512, 0.22783584809992996, -0.3229420181266054, -0.27387177713374466, -0.3057195337966628, -0.1381608346497015, -0.3708778928748263},
    {0.40211479343292994, -0.20728806994401114, -0.27174323670041595, 0.036026227171107796, -0.12173721282335564, -0.22845294930823717, 0.4638514832354747, -0.07938356285157411, -0.059638092511312975, 0.24144724000428394, -0.005551305205950121, -0.05104528979112735, 0.06332488510244356, 0.17916591141039648, 0.0011398975878653202, -0.14846768373595667, -0.17048249815208172, -0.05511149585815645, 0.04401504625787518, 0.12210811264362331, -0.2795926157076038, 0.1546031251604475, -0.11682777942923905, -0.13284510753188822, 0.056485517894754596, 0.1639060598366685, -0.17003698117188298, 0.5132037218663215, 0.26062836076773943, 0.371798160127361, -0.09361583288216979, 0.4421613649533605, 0.08002241648809219, -0.25178375015604576, 0.013410669551569025, 0.13636956374218204, -0.006695169709300174, 0.23622970499452273, 0.3705745154714941, 0.06214523205249926, 0.3220333086096266, 0.07984735487902705, 0.3431560309212698, -0.04027441198641324, 0.13218490060872345, -0.24421641043538722, 0.24143365525007768, 0.03430961158984914, -0.3875835858896713, -0.25514755615288687, -0.1699149644727927, 0.18765638848178934, 0.1674269508778824, -0.20786711677928404, 0.33929790943328825, 0.15875480663764904, 0.23506646397881742, 0.14470824130496496, 0.10649558229412455, 0.013552005848325666, -0.21787753083926892, 0.43017697028057367, 0.2995832038958459, 0.18899116966509974},
    {-0.01892296490729037, -0.25376639818826263, 0.09194633223156902, -0.22070922589112923, 0.1830026583883402, -0.4799707284353283, 0.11451444177760614, -0.21343694329200233, 0.2605197198978347, 0.3598010343208433, -0.26917098136924, 0.4893587346902459, 0.032109659931279684, -0.37244631238226894, -0.37396168895020654, 0.37108220902003713, -0.18977447567153452, 0.21616053915316533, 0.2762844308193038, 0.007248915070829609, -0.09425349304015995, -0.16113055161214995, 0.008878025147640353, -0.24474483829771565, 0.10832081142788637, 0.23849064565735173, 0.39531852229155007, -0.08152961363581793, 0.1789652431988376, -0.13117956092226882, 0.0053835691693476205, -0.04972718463944364, 0.40050613622976555, -0.31190159163658865, 0.3706766825024795, -0.04678123916381595, 0.24414995781877671, -0.05960718871335888, -0.32740489419001245, 0.3150758094238062, 0.01778845396492707, -0.07525466714379409, 0.39707073963457856, -0.1970765977872323, -0.020369563735798915, -0.045111309256793415, -0.05267130624240627, 0.039264742081703594, -0.037551807577423976, -0.41659498339696704, 0.3705332645374173, 0.32780533654130284, 0.2368563570508094, -0.4503561082924257, 0.13144056111848493, -0.15394787423897707, -0.22368669455018514, 0.3834587887946524, 0.07971703601723651, 0.21709503323056215, -0.10336334400783442, 0.5708468724403545, 0.19005541292400868, 0.2776958302200272},
    {-0.1909785621204817, -0.10872953981327228, 0.4123570609710464, -0.515085988826032, 0.2336694747163929, -0.21656769972625872, 0.02529169250734798, 0.04345532878733516, -0.04376718444874156, -0.1557766157031728, -0.28581625633036123, -0.0409250158483243, 0.013484742509893833, -0.0074127243207619195, 0.04791093691343811, 0.4260334702078735, 0.046602447050209106, 0.20740394901615555, 0.08602451257676645, -0.3821558058211477, 0.06638777579865993, 0.07451565715566422, 0.18976638784666602, -0.31488608964055587, 0.013351992221927254, 0.43461409431334375, 0.18404580870713746, -0.30306418516382266, -0.1219319144956116, -0.46395006295049335, 0.3235104188412521, -0.2917585774738411, -0.41364674752719727, -0.29456971482510014, 0.4958641408732057, -0.31906714295814115, 0.02415457808337735, -0.3564515616283698, -0.4603199102734252, -0.18875383192470133, 0.3426316423369703, 0.3960750819953757, 0.3650216808537842, -0.31474746698538986, -0.12843273766438523, 0.255953593960009, -0.06794965631029636, 0.07321079345228787, -0.231046187410228, -0.32561217564911815, 0.18518038823194044, 0.11724016745588652, -0.31944158512343923, -0.2883377300939129, 0.36416965152160097, 0.14909720796471457, 0.27296903891072266, 0.44155785093102584, -0.09080965455854552, -0.07669636121377801, 0.48172099397196294, -0.02765804145015823, -0.24378620692453876, -0.05186329937787664},
    {0.07470411836372234, -0.2329220643335281, -0.0007011888038238262, -0.08153547602768954, -0.28305820869456727, 0.4135996881846289, -0.3422747914475888, 0.1643790564534776, -0.18971039357990688, 0.2378366089580219, 0.2228435374881964, 0.31132165000596634, 0.05131350773141801, 0.27148346193609746, -0.21495437146874968, 0.2904067754877122, 0.34411208131823356, -0.2565846032355055, 0.039095915886377675, -0.08990287347744655, 0.2933734531572314, -0.2904551369336284, 0.29400665212832444, -0.31412106038769205, -0.1131282037748583, 0.11627519452195949, 0.36681358955488846, 0.3730999151858782, -0.2537679858775617, -0.06254570851399169, 0.23147375954277402, -0.04670605313497936, -0.3996257428597131, 0.5062877301704563, -0.09128751642177148, 0.18738361450426735, -0.27926966437685047, -0.44676974953634, 0.16426837677956227, 0.1823991709734068, 0.0540000300133727, 0.24461922209619963, -0.2146711736824143, -0.09966298155896247, -0.01024438303839701, 0.26618412764773286, 0.07460182273519596, -0.36316482083700524, -0.159805535349989, -0.08874543230370939, -0.0946187243365697, -0.4051635436883182, -0.033272931309974475, -0.3274853218363388, 0.19250527232420728, -0.198913558110454, -0.11226769189278221, 0.10101358570486851, -0.01887895429313138, 0.2807990648182767, 0.5047633106384855, -0.08875762322260111, -0.027805173433341275, -0.1249149859298175},
    {-0.09204258212420682, 0.2843795998911854, -0.4165024470689375, 0.3801121014512908, -0.39673773056915423, 0.01809151298697602, -0.5221347546662511, -0.19144549874577296, 0.15626273982397001, 0.18188252862600784, 0.3091613387271349, -0.0811130977702433, -0.3263692898669689, -0.21825186065553684, 0.36369676714045907, 0.30808724927648146, 0.31945399622451814, -0.15729216434677523, 0.16699320161885975, 0.2786105614862113, 0.008000752518815138, -0.36384386275448455, -0.34881500929688747, 0.032081665965251444, -0.02474108258002234, 0.2794847388090416, 0.11170179579342421, 0.46475798110374567, 0.18991503246547387, -0.053619653915688764, -0.34205578233110895, 0.2767723374262592, -0.3002835390075709, 0.2523689602612883, -0.09058537174377171, 0.12696502279952937, 0.0369164056991605, 0.13285486596615417, 0.13232974712575324, 0.33782357422813386, -0.10526531470911844, -0.0924511869545302, -0.149117891512992, -0.09759171300479108, -0.25068950885129754, 0.050181107698685924, -0.07018985349004501, -0.4066569294599043, 0.21331694168382398, 0.1658311809832167, 0.31066759634825686, -0.49100124433247827, 0.3184348103944295, -0.04667737427365841, -0.36944502985872485, 0.34799133108757285, -0.15618690532165647, 0.16971354898606583, -0.3744223427511579, -0.2341654603881673, -0.1718520055555773, -0.14545495054218474, 0.22865192300182968, -0.48801651883115243},
    {0.18562882147803356, 0.25912276280236757, 0.2938019900277818, 0.2219351152150892, -0.12992707225578567, -0.38196819584638747, 0.08659145382463444, 0.15756809312548123, -0.129729223532403, -0.3606343490330351, -0.08475151699562844, 0.016983744029623934, -0.11353620140406678, -0.07271042044396361, -0.5704859175818084, 0.10188227114987794, -0.39462786667569216, 0.07225785376073629, -0.4915511127600201, 0.18760455756910116, -0.012863593949937196, -0.11995589121496326, -0.09778394383192586, -0.5047359107084993, 0.4641372658531641, -0.4154716157199919, -0.3160333275234875, -0.06764080605625628, 0.07598848468005659, 0.21562697276692822, 0.07694212727932938, -0.001633321847193286, -0.08756521334815187, -0.10961372535547673, -0.2538029677716734, -0.15102377093843763, 0.10611926167538896, 0.03762902185161825, -0.01836854000665747, -0.19540376257961675, 0.15553340326983897, -0.3331459803463969, -0.4854888719163704, 0.3330046522695793, -0.19012539096034084, 0.07506947903127693, -0.4226960117834908, -0.2763871662083723, 0.2701937242626216, 0.05708015986019269, -0.38522181177166903, -0.07465592224666902, 0.3588260381093251, 0.020572716746141962, -0.5148292303366755, 0.21415776339074147, -0.10705937133542019, -0.4330846159488018, -0.2597843008062774, 0.23168987804371055, 0.2217748054270512, -0.4161364629145304, -0.4384489691355116, -0.45097231923414677},
    {-0.1067667524596524, 0.2521958358679774, -0.18636866354630388, 0.18591279704660185, 0.2236225624114445, -0.418273069784806, 0.1935469906203402, 0.08136436118008954, -0.3495537655932016, 0.13081812486557193, 0.2003872516813279, 0.3166232049525871, -0.2112354280946068, 0.06355142829921719, -0.1886993473627129, 0.17002401703344064, 0.4456410704080282, 0.3921700131446092, -0.15881450701923433, -0.006843290619845838, 0.21992804103536284, 0.3912781561666741, 0.2105168961887531, -0.2486291032673587, 0.25231320303721555, 0.324202965550328, 0.021527243620933688, -0.1052523578327717, 0.2547347218422416, 0.39830367720344195, -0.015241862128396021, -0.37613236024786284, 0.44933913921100244, -0.06351090924646491, -0.20513022976115577, -0.3927465322029496, -0.29071088409341905, 0.08670384052635464, -0.004302911663353414, 0.13715064756221024, -0.2845488000342379, 0.0740374379828681, -0.4233430156366973, -0.16841511972342652, -0.1105804966690412, -0.04889722315177022, 0.17297676820459848, -0.2635464075726915, 0.6331552179521964, -0.04960497458930756, 0.15959440311753087, 0.19076784173698944, -0.12859378824078607, -0.35642623082159886, -0.27808432986833936, -0.21006068951661266, 0.3244844256524592, 0.21901375250189725, -0.34006359937097885, -0.23049230253832761, -0.03121222850427231, -0.07164833408092086, -0.3385375227410113, 0.3187272076553422},
    {-0.038317907050450635, -0.3528471707448832, 0.40219420587597954, 0.21782157588169634, 0.35796826993241126, 0.06613181321402821, 0.31570175940205675, 0.2518509588778501, -0.2758409211970524, 0.22283521437510223, 0.08228334683161878, -0.0019585221883532825, 0.32509553781649103, 0.28040431020954565, 0.4555882434242056, 0.2890447318862607, 0.2757391075696263, -0.41972169207971155, -0.2794014732506573, -0.20144509561238652, -0.15680111481449352, -0.29948355011199584, 0.47918061111476057, 0.1988451000947668, 0.40496440722290383, 0.3144689352420555, -0.20251673582962476, 0.2164550861967431, 0.15477235092516697, -0.0019573610964601874, 0.020834232465011832, -0.15462469585953026, 0.10750900558178685, -0.1851666812460052, 0.28453699333511107, -0.2869807591156439, -0.3343174594048232, 0.18927744064102658, -0.2942272456640612, 0.10363607553020251, 0.1760197195164624, 0.16323460141016355, 0.2860861863717983, 0.0877446989005393, 0.10726114315237742, -0.1823827884402878, 0.22193221603867738, 0.09237909182806785, -0.22534428768209308, -0.38947183961561893, 0.15976481010713656, 0.36145251087554936, -0.35555021215735255, -0.03947388454882693, 0.24264317087636397, 0.44430497811691166, -0.06958320392111653, -0.25054134993500954, 0.29494881839366993, -0.17185496070633516, -0.20469201874607437, -0.4473014898669218, -0.14866178873047595, 0.09041802294608545},
    {0.25617626717557834, -0.3238787007899938, 0.5394042867413655, -0.00010708403578065937, 0.4071378194163091, -0.2045758075919101, -0.16451659887315215, -0.00920278452330876, 0.17501483615807148, 0.10959881516980151, -0.053780197328862495, -0.3918681923746634, 0.42417538954615097, 0.46625412755388385, 0.11776382450251296, -0.2172228291701332, -0.2794434403689921, 0.10953453608357931, 0.1157539286813325, 0.39914923356089177, 0.13316511925236332, -0.24376631956648026, -0.16813599853883848, -0.009362019750516353, 0.013196342098741405, -0.05113542862505902, -0.19837406308303188, -0.002610712572687462, -0.28369806152815447, -0.2589794787905871, 0.05391545013435225, -0.4847611646558364, -0.17874979941507083, -0.00672887802206877, -0.07346235750423867, -0.03438769674048431, 0.06471766182794857, 0.1312272608646369, 0.0681658763220818, -0.16275817444543242, -0.051159291912308696, 0.3388751965904806, 0.06028499529414394, 0.3284468730247269, 0.2574404128564317, 0.17584899620237818, -0.15360877925224908, -0.028276361049940007, -0.40020986530332764, 0.47853200956721204, 0.09709935709686093, 0.3822602645114985, 0.24956952988701273, 0.41193450573355395, -0.1751143464178752, 0.2711087444645484, -0.04949205804891102, -0.26672709909413966, 0.13412600866102303, 0.4408417479207882, -0.2656227207697682, -0.4135817392820028, 0.20386758871557112, 0.44380584882429175},
    {0.13859511547222803, 0.18340664208901572, -0.20662324828820597, -0.24195174600594002, -0.4151536498705741, -0.33536759255291054, -0.24729952332245275, -0.13454433837116195, 0.45053735829965064, -0.12413737479129301, -0.07171907285876979, -0.3302705465137631, -0.31968016177592323, 0.05277918640970555, 0.2522371612546434, -0.2206408251668056, 0.01971234985988308, 0.025747361525497996, -0.06264163012878132, 0.2092574821079132, 0.31102969372139816, -0.05076016428066265, -0.3816809463549973, 0.3052559204854089, -0.5602564503428017, -0.23562130607214563, 0.20293904049766098, -0.08233732270411519, -0.2711572295742026, -0.3828382574858709, -0.42445576840193633, 0.009776693885132663, 0.07411502694748551, -0.06365426606991038, 0.26213671094962937, 0.27914017313543393, 0.37751519606528966, -0.2684121039698189, -0.06217956572161359, -0.3754686514549256, -0.3891442594338528, 0.17365431569723333, 0.3340808602736697, 0.16924470404837963, 0.13778200902135293, 0.06629749515745628, -0.25027656242538754, -0.3603222693400567, -0.423513896160351, 0.4051664672739656, 0.12212253639739516, -0.1340731068927414, 0.14412727915586038, -0.09950223373523581, 0.07731231170838655, -0.2742757062622113, -0.21522917508741782, 0.2251773442144734, 0.25676878061222863, 0.23717210487128113, -0.0640390580871183, -0.40607812554064515, 0.2752924520418794, 0.08903115541166712},
    {-0.47521303089207917, 0.002690014206435576, 0.006413706896894739, -0.07213723036396881, -0.4302793513916656, 0.0948234535873361, 0.23798889879328533, -0.29304651005301596, 0.445544631242344, 0.18097466054442454, 0.12044747059258462, 0.2728867199714648, -0.043804678523559924, -0.3389187215227808, -0.006986086174844481, -0.36101200746226947, 0.19134457466659827, -0.17259938513386536, 0.05160478173575991, -0.029070099236081018, 0.32884871206872374, -0.17881635125991208, 0.32222216900008155, 0.2519575350782194, -0.23580229402214467, 0.2642083052699519, -0.28965717546978215, -0.3546519036699137, 0.11905607103097704, 0.20495970704723132, 0.14744086252613764, -0.21740387426760546, 0.30870495062618775, 0.4656888248919513, -0.2941723863388698, 0.24251364672124434, 0.2630403094843845, 0.11072669504302991, 0.37877720956463024, 0.07556246895888027, -0.17217735994328398, -0.012846719084783834, 0.4169271413022952, -0.16273863335436195, 0.049558017042738364, 0.2968825332030067, 0.06593072886127728, 0.0542614367132263, -0.30096436398557314, 0.12163162927810003, -0.07943207332321442, 0.1869887961604215, -0.3289089402970711, -0.1823304126126866, -0.4112113001580154, -0.016236707867030475, -0.3154127274906299, -0.17077689174703928, 0.3709484618785128, -0.1995512890057313, -0.14132374732629907, -0.21576585322872885, -0.24912371420878557, 0.27130048634527576},
    {0.07542515029024774, 0.4472870236875752, -0.1645960005427985, 0.2345587168738771, -0.20660388514483274, -0.15959886107767088, 0.06478066146625425, -0.1916856239000663, -0.09575190807277492, -0.09606063413434451, -0.1258053621001983, 0.05308555818701598, 0.28262794495074745, -0.2909682208233093, 0.29441332289039074, -0.2565931708754154, -0.12336964412891196, 0.2349268269657682, 0.3443518543779413, 0.06902419727336218, 0.13327877271264774, 0.1743935643536571, -0.10445766271654532, 0.4070687982626887, -0.38633158820138885, 0.464230964373093, -0.2818299008190416, -0.20084057608146927, 0.3799756184601391, 0.2297065993727769, 0.404784929314738, -0.1227865380150475, 0.20268777598944204, 0.3868961886280699, -0.30090414276382543, -0.15402971537535481, -0.044098209807305236, 0.1903081365131765, -0.13776905314844215, -0.2702544471161844, 0.3491532393815495, -0.0775039122380167, 0.07086145990397386, -0.17055259285710092, 0.3635581730535379, -0.0914664082412858, 0.15552562860448094, 0.3165630022887485, 0.22361707500452094, -0.06174319367106784, 0.07381927586601827, 0.22600412915091306, 0.11964499635706287, 0.3790410163781779, -0.027515837823856876, -0.19659099127499433, 0.5082335575294685, -0.08212769252177024, 0.061537909187564736, -0.2790093916935112, 0.15197343357927282, 0.5378519642782795, 0.2562566341597852, 0.36153419152064764},
    {0.2825559615066909, 0.14249498607124375, 0.4392457635942765, -0.07767324712968113, 0.4680997050491833, 0.16810947050262223, 0.08189833044984932, 0.3816514980713034, -0.497951745573462, -0.25665971129811493, -0.15383883054521016, -0.35279625310782914, -0.07650298871941216, -0.16970596639824861, 0.17123128575252228, -0.051240219712530344, -0.18885529353920738, 0.3271374956970914, -0.14122627295937287, -0.14504599666246415, 0.23439660079326188, 0.2512323702909223, -0.12205763467558738, -0.4999250165891933, -0.15552375228445467, 0.3500081601940606, -0.33716422199903695, 0.3082404341649761, 0.22973712582147662, -0.0914285617588932, 0.3251929976886987, 0.20297515375047426, -0.2561763051158347, -0.01778359846128146, -0.1368607110461658, -0.10030825418401566, 0.42510964310850596, -0.13540003777199944, -0.0510247524376492, -0.3855636106910213, 0.43657166545934795, -0.055896708015884776, -0.10172512489452744, -0.21252069802909127, -0.24984325709003075, -0.32344083823643455, -0.3715907358904057, -0.12525372758981865, -0.03157485251119039, -0.36709324045212355, -0.03453848673444199, -0.3914347315824646, 0.06973394204883439, 0.09818749679370463, -0.2670295476351521, -0.07373668934679747, -0.04366592507220472, -0.18947326335289888, 0.3395259200295367, 0.23946636438601834, -0.18236756254980505, 0.4845987088136831, 0.00564884419744134, -0.09693924703734086},
    {-0.35210131124112104, 0.07377817623613048, -0.4082007904086339, -0.26454255907650204, 0.4335220173333213, 0.16675343020562233, -0.04720118229727306, 0.11468980281131355, 0.40794151996102956, 0.07208150323443879, -0.017103426351427573, -0.4095948609156692, 0.1551137181998979, -0.09319297211245689, -0.01747374307844499, -0.5221630444478222, 0.33155683961830695, 0.18199637868423651, 0.10092989147476701, -0.14256897908209198, 0.12132812777291065, -0.11584570913373295, 4.2480087769641916e-05, -0.2130286775876196, -0.39117553856489884, -0.12101931484905808, 0.23177568136996973, 0.013939716651975582, -0.3149979360845046, -0.42444623509911195, 0.01677582332651408, -0.10971944527257824, 0.3466722430451023, -0.3759559807060533, -0.15715411699860848, -0.31967835153053475, -0.0139172927557786, 0.1873669037099371, 0.0592268389285534, -0.2854429827021135, -0.16887453719376794, -0.3283641025348134, 0.27893759631134446, 0.18713494307424264, 0.11175005482051026, -0.1315062047072246, 0.11755323930283922, 0.034738409436945616, 0.028859762110027564, 0.15512114911486607, -0.19409141002190666, -0.011844177829178031, 0.021676537418164575, -0.0008958740872099997, 0.07175306688254467, 0.2010992150817384, -0.4930467670789441, -0.15205222160010495, 0.1727900497282547, 0.020397684859392515, -0.22491448484852325, -0.04092475653373001, -0.28581459631597594, -0.401636055988618},
    {-0.3207727500182121, -0.2507367340783351, -0.2864639273210346, 0.5488854800926344, 0.1534495141017142, -0.13710398292554252, -0.31616838337818043, -0.15662873144970568, 0.055259378232731006, -0.24933408107520724, -0.20132678287690886, 0.23004125876975054, -0.09865688193318621, 0.30848787695859115, -0.0005498058919205567, 0.3001524833251021, -0.2456543571093374, -0.3235651544227706, 0.458775810976351, -0.1528157956788496, -0.38224210950946597, 0.16981169438274737, -0.3640679735291531, 0.43849630993004024, 0.05323001563666875, -0.24037234968728172, 0.3133135246383421, 0.22864045763966864, -0.27570231760699887, 0.025440024388754645, 0.3804072736887704, -0.07332788083485416, -0.23044570450627144, -0.2874529372653161, 0.45779387146411904, 0.34632457692100976, 0.1689643218921922, 0.3949501603363368, 0.23718732629157122, 0.4307825764982114, 0.1575857293488268, -0.2827989001548658, -0.260857524942394, -0.21116388128141217, 0.15208554794787474, -0.091393382542455, -0.29310593849343003, 0.05355038841723258, 0.04765285236865694, 0.0050902228672484754, -0.1425158221503723, -0.3518607343881105, -0.27136107957178074, -0.1113486113942973, 0.04325932272075733, 0.340879410926061, 0.3467764349863168, -0.19471162393125963, -0.25802150153212244, -0.17432413674615962, 0.1723463347999203, -0.24223472916618582, 0.31535118153959024, 0.0921468763182236},
    {0.1184482986216791, -0.41518939273042293, -0.24745157907088539, 0.07543302844173615, 0.21399909496407915, -0.4633321417371921, -0.02626046739168476, 0.19240724524068836, -0.042735609381905425, 0.44665392496984513, 0.15535651462146993, -0.12606646014536083, 0.023656930835387485, 0.2928227757179097, -0.26226082641687176, 0.25799812701490255, 0.1700360601319656, 0.18874920317943653, 0.38699630403050633, -0.06469421897431589, 0.10258145590614791, 0.23389964092221563, -0.13136276303277927, 0.4416197569848661, 0.4143115516172291, -0.2449728231726785, -0.2529907360285106, -0.352521109075369, 0.1880800959180158, 0.09753987537112414, 0.4920910831744794, -0.09716721792882527, -0.2632002955197788, 0.3396564986418764, -0.3013170021325053, 0.24000423519659345, -0.4338146532467238, 0.06711898575882003, 0.18607237276574232, 0.1018599549592358, -0.010714432698165393, -0.3603837703609629, -0.5717459097011057, 0.2712637127432655, 0.23986683201585832, -0.10232295567161254, -0.13306705413984107, -0.26942189480625073, -0.1618837455051162, 0.30824290842711616, -0.04207092581856053, 0.025783931187700202, -0.002377333148177421, 0.05928262326863398, -0.17625807953817924, 0.17858052060329657, 0.16372907414445026, 0.12592017828574278, -0.08413856409941536, 0.38061625687395534, 0.0039056336826069175, -0.2411458747632738, 0.19990856221817313, -0.08671130342018472},
    {0.3097966059964079, -0.09276214192488484, 0.3186638719244915, 0.16121357323159827, -0.4169419605290652, -0.1426673321165368, 0.08799609179452508, -0.08466128554441624, -0.2510238237751645, -0.41097736804556245, 0.26992981152131057, -0.41240019868125477, 0.3175149364704663, -0.15196922986047381, -0.23234162247938636, 0.1057490451744133, 0.27748993521641435, 0.15514881912698086, -0.4696436654328292, 0.03374536091159664, 0.302545952809995, 0.0030622179898638327, -0.1497056136365507, 0.15806546278900793, -0.1379573116769409, -0.195509133695899, -0.4564697374781525, -0.30020209801090175, 0.0010058296768228356, 0.2529662185041011, 0.021056657594084902, 0.17919100614838918, -0.20012699262721798, 0.26395524535071063, -0.2994261450085006, 0.25416798888690595, 0.3482858113567394, 0.05220598991517861, 0.35481970444190564, 0.2924808390496349, -0.2887777089409483, 0.305478820661967, 0.28507373063120806, -0.1316176440150927, 0.28565291843750396, 0.20471108932167226, 0.10215891305409418, 0.3165475293533459, -0.281510230139344, -0.34920616826911743, -0.1378262520306153, 0.19858520423434575, -0.25937401313289504, -0.5583567895868754, 0.34461696055175733, 0.2644996795269734, -0.0836230199377609, 0.14862038958625173, 0.17440912214309276, 0.1867765785137255, 0.12728358496353329, -0.3355629664018526, -0.19795037396759185, 0.32417827886813727},
    {-0.31428145342772235, -0.029199042742640357, 0.2550959422189986, 0.09148815229344374, -0.36419742374470027, 0.3565798367887479, 0.19511197356006227, -0.13222761650406106, -0.4429054441030581, 0.21583328607068283, -0.08725265084877623, -0.4613233049122615, -0.08680178729528223, 0.2498666798452567, 0.045862204637779604, 0.27437190055149757, 0.1343497492703842, 0.08003642344707888, -0.1369526398549844, -0.145842637385203, -0.22724052748364085, -0.1699985085475287, 0.22591862051414427, 0.03195795906135812, 0.14311919084899977, 0.14711717617734546, -0.009586624777597518, -0.2390756754586348, 0.02802507688733021, 0.30257942286600836, -0.23833212024998862, 0.04546677071950019, -0.22851038355894449, 0.12214290460563008, 0.3720765660910764, -0.01118355491174363, 0.14165001232012814, -0.10752692997227588, -0.5404417416440707, 0.2551887797075105, -0.0026175545770009247, 0.13621677740136506, -0.42192438896017714, -0.21896743425462648, -0.3035822928800163, -0.45161281570667855, 0.07945655111305598, -0.11599426576121326, -0.3656954652581048, -0.31012518241466, -0.4463911639132315, 0.1467598964298654, 0.1524080925597526, 0.03504715915807831, -0.0006109610285013876, -0.42545275478318884, -0.010404952220213804, -0.17736544291860826, -0.02030708674291946, -0.3612200042428609, 0.0682597423813333, -0.03401708593554017, -0.04570055332237356, -0.01531298731775629},
    {-0.024285275957965327, 0.21277002922713628, 0.1952672583582319, 0.11771774103650655, 0.29795842038638676, -0.472268615883156, 0.3384681487789722, 0.1318050790972096, 0.38870511649005696, 0.4352304989514378, -0.27182940371513326, -0.0762222392292764, 0.01694853215393858, -0.2637013732051603, -0.16399213770177656, 0.313021246213929, -0.16108738929116503, -0.4413944939512187, -0.17114721925123866, 0.281375737440329, -0.16904734099304478, 0.1731057653897239, 0.32507152374119536, -0.4156450345189528, 0.04848072836397807, 0.5613857477391538, 0.28567825340315844, -0.34791757570130094, 0.3887420944377248, -0.0732024047115408, 0.028900430687711844, 0.39941149743456794, 0.45996004109234634, 0.012230703638750177, 0.058409808209300994, -0.28649204453480565, -0.05831678482220835, 0.16821615927765407, -0.2790088763818692, -0.3155512012424395, 0.23195723303186652, 0.2699194274365149, 0.20904267126302087, -0.27695659682923446, -0.2737609395558285, 0.17853976934469215, 0.06284548062009619, -0.05812257722882099, -0.38454435199032805, 0.1972700053360465, -0.36077108959434884, 0.12113256958917556, -0.16397458629828596, -0.0011392944501406215, -0.262475104153987, 0.13779019532626838, 0.16879517887553286, 0.18122789060907088, -0.2746288590972388, -0.18316983057604388, 0.22181863858606785, -0.13681512997195883, -0.33487316043993354, 0.1683836650823132},
    {-0.06806639411651909, -0.3893649046985534, -0.4715791684903902, 0.4740854638709993, 0.4856953570847524, -0.8358883309490276, -0.11995756807896317, -0.7836158106929215, 0.29912578891680836, 0.27458017638850396, -0.8902337411841473, -0.5158949337222624, -0.1889416178320548, 0.770551677003611, 0.13443440188720557, -0.6761077619683833, 0.3522108291357435, 0.006507358021638975, 0.2544230904340083, -0.9655250144217327, -0.7486704780170677, 0.2789517988967999, -0.7460874459778362, 0.4547466355532802, -0.3560894687642179, 0.15509322412894988, -0.6633676619601659, -0.9703311934582148, 0.21348854545722237, -0.7812608510685641, 0.20541158862607684, -0.47989613516637186, -0.46289801970012706, -0.8379911843439718, 0.2521728927172785, -0.5958170521353476, -0.7766062318928807, 0.6125175692383636, -0.4690739412181775, 0.45639850422266726, -0.7393321312078123, -0.7237374299000122, -0.5465029377605121, 0.4014455688554391, -0.45714321189547635, -0.41405088711645727, -0.17177264821862082, 0.32625115812782685, 0.556424682939782, 0.21322887124241705, -0.853656679411168, 0.37446536715220013, -0.41369925179047784, 0.08073894394639597, 0.5139370796033484, -0.6240282313818092, -0.29929442770405457, -0.1581864761836487, -0.6473651868709243, -0.3501968029177008, -1.023887451818156, 0.49960024952909565, 0.020418653457763166, 0.5534097045967727},
    {0.28808510713324076, 0.31061265846320213, -0.8634065153981635, 0.39741206207756125, 0.5790200523643317, -0.6570163252178514, -0.597430812724508, -0.9388819137265372, 0.5770030636661264, 0.5377393725791263, -0.9212915840949303, -0.799474528687201, 0.16177598202626758, 0.8623912295715307, 0.4584505223191969, -0.7604020250134851, 0.125048586619493, 0.076454585501111, 0.05988017747584778, -0.5974058296901883, -0.5982684190807497, 0.64516874664704, -0.9645612829339463, 0.8038683263371331, -0.5999827855909605, 0.19572249949328002, -0.3528819001489232, -0.8154857520653028, -0.30721810705514535, -0.8214913789558705, 0.10696011012467309, -0.724117223291472, 0.05035348696409591, -0.6182698846057844, 0.2771945038536518, -0.6631001078649423, -0.8135585798218838, 0.5961955280901505, -0.4319062188814037, 0.3742266585244216, -0.5243496767591146, -0.8709308123162942, -0.6527485619115502, 0.5431198404285866, -0.43910830098675074, -0.785828413351039, -0.03919679965248822, 0.604011233773144, 0.5837718983500608, 0.6764641635736663, -0.8352683138984104, 0.7526008850555226, 0.12226548969424651, 0.551514356151211, 0.5100297306546289, -0.71153328974059, 0.26611453256805906, -0.2005676188624619, -0.5758703727005643, -0.12857933307960137, -1.0052288364913515, 0.4093286522194669, 0.4772968943405763, 0.6183980763862954},
    {0.05463010712598173, 0.226498455099995, -0.041460711701290495, 0.13585899658351783, 0.21328689769811868, -0.37986425512329414, -0.146568227500115, -0.52945138812844, 0.67440330370264, 0.45419007142818874, -0.3467994367580496, -0.28005344949853705, 0.15528673798702822, 0.283970895438734, 0.4311873970403089, -0.45512031536811637, 0.11360614948235652, -0.12974015610601672, 0.41903973200999356, -0.549686166769552, -0.2648808964070171, 0.5182629421516874, -0.6066917080906657, 0.18986478734609427, -0.5346843363313896, 0.24506533523594037, 0.07754448758296816, -0.6246294055049797, 0.3325210053710086, -0.6627216824775892, 0.0735265169371831, -0.24831627298200032, -0.037841684621725984, 0.32332123232299037, 0.5245254254180866, -0.627163526371934, -0.882583419339044, 0.5084860702811957, -0.6138281048104274, 0.1283053806446912, -0.08126380903333785, -0.547495691031654, -0.6896367512211183, 0.303846503993594, -0.21356196197091312, -0.35912995239491197, -0.12663860659226397, -0.09533350795252443, 0.46688197565245493, 0.4081214529882985, -0.32121831283184926, 0.6352687282925149, -0.3456167866950999, 0.29905677795495583, 0.057149348413760175, 0.09626970340516797, -0.4064327297459108, -0.00532561978871653, -0.7233636656647314, -0.6456438693024784, -0.4617673278154556, 0.4753134363673639, 0.11979993074780482, -0.16276683416525897},
    {0.3734643910144138, -0.23200662716200113, -0.39336683206507544, 0.38738288182015534, 0.19306765167113527, -0.11985850421864441, 0.3059466192762209, -0.45712755924747406, 0.10765273383774025, 0.5837847533068476, 0.16687285586497624, -0.19462253816084885, 0.12083660159744108, 0.6618266142986816, 0.6736479878198105, -0.33032838179119683, 0.07404242942501255, 0.17647761949843246, 0.15282873901297644, 0.2906938017042438, -0.24463117585411592, 0.3975142285747789, -0.5467420056546202, 0.1221652392749444, -0.31939809369682143, 0.7000912555021512, -0.1930772532076189, -0.2547607529354051, 0.5677209906498473, -0.5785523188138335, 0.22843624430767354, -0.4358536893807926, -0.4667592802076434, 0.1548006001195585, 0.26585911975177934, -0.27025326408363465, -0.7782436795091913, 0.4485987234454144, -0.5369209952277871, 0.5948642844385195, -0.2240273858797404, 0.04475666506746033, -0.3440804924709554, 0.3341781427244112, 0.16752528578638123, -0.13850961151895994, -0.37684985482311106, -0.12073406051642285, 0.25697563422761355, 0.6467657248395008, 0.016903956899284228, 0.6040178692129335, -0.019789999001554145, -0.3020939409357015, 0.40065649789343866, -0.23619085053396902, 0.1646371201134519, 0.5341912184807509, -0.31431358493177636, -0.40257913807711493, -0.5684963425656323, 0.24681081686651798, 0.4106785479623765, 0.37130173435286523},
    {0.44834535929938213, 0.17251662088848915, -0.42816041844129415, 0.33180259549581187, -0.05402432731612837, -0.6333620224800748, 0.19131460411634307, -0.6843461166163568, -0.09866023804464437, 0.09355350194466802, -0.41741616317656915, -0.1929989567914697, 0.28532200642594785, 0.22483968866453147, 0.19890480378898442, 0.13682923432828348, -0.29350869959070136, 0.33260827457053804, 0.5449012372868414, -0.6133753774991045, 0.036125414089843724, 0.6184581413928764, -0.3069317431695617, 0.2429245769546912, -0.6194954795911449, 0.33061264084392133, -0.10409103840693691, -0.23255223576355138, 0.06035924022503083, -0.6857563687065767, 0.45300027071806126, -0.5898825393266159, -0.1585541273082326, 0.08044582299341367, 0.6834392938371072, -0.22744242334792333, -0.32393720196339526, 0.36627938462379356, -0.27652759664874926, 0.47174623689748807, 0.12799131515094245, -0.41686804096433333, -0.5076144809312019, 0.3571198363071784, -0.1809508605662676, 0.028450626871706963, -0.046941848708323713, 0.30123187707866, -0.02668984084059784, 0.39293670897984145, -0.6153621520373983, 0.12565656026573097, -0.015253087891932998, 0.09237238114476085, 0.5993351634659503, 0.06687243897246316, 0.3108556151462415, -0.022114418168639058, -0.728832291200344, -0.38622600371001625, -0.20754388176450178, 0.6233582541561189, 0.19879296566280125, 0.1146938022099493},
    {-0.2439692365062041, -0.14763891666812246, -0.6074962839190823, 0.36723687286478196, 0.040636737643236255, -0.494193783703713, -0.19361046545317942, -0.43907385422985473, 0.5359099895468251, 0.3003845887005304, -0.5122463092716116, -0.6098094157688538, 0.1811088975301675, 0.7060137930261793, 0.5812809044039208, -0.655047818004342, 0.21771090576095573, 0.01890140623220695, 0.10238393477930531, 0.09235815178149108, -0.15971337719627385, 0.18856566849793094, 0.1349726668794158, 0.5478126769022192, -0.23034054613040528, 0.6437286405467116, -0.3620068795698267, -0.37876639173037563, 0.21258859429456048, -0.6784896877336554, 0.39260118860558985, 0.16690601209406747, -0.4340412152698276, 0.13935376222084028, 0.17200792133970827, 0.04810344411413611, -0.34240647757198434, -0.01550296184959414, -0.5132102904451776, 0.08834508492392452, -0.36369952966128827, -0.5990349900968618, -0.020878216446688656, 0.49738151998106084, -0.36433749440831453, 0.30887212216824206, -0.44293682939491175, 0.16040384327196935, 0.06300692587006929, 0.18237893064788047, -0.18312969520209585, 0.23118819379264485, 0.40784303849788667, -0.2830476550454805, 0.45775306327892135, 0.013317474023500715, -0.1918508342969966, 0.42147406251596475, -0.4055114873896529, -0.07958330066751473, -0.49664700345054064, -0.21075696534388316, 0.0733283911839455, -0.4102266267320285},
    {0.2784340350432551, -0.03605603958251111, 0.20487491994795104, 0.3205956237908112, 0.5774699595349839, -0.7351804892536379, 0.047351239667040086, -0.11652392296989107, 0.039731179702267624, 0.1470246038145121, -0.08754818425195493, -0.5095086041231934, 0.4543287099657649, 0.38871245873052157, 0.4195928006658502, -0.4286122560271811, 0.3598686097287445, -0.16176793703074033, 0.007037702518845377, -0.2534403120589634, -0.28026954518422315, 0.6808374562872561, -0.04948032820919097, -0.161843189454217, -0.5690455395628756, 0.5578325599336146, 0.14079733815624587, -0.1455626213357012, 0.23979588821744569, -0.32551786981875463, 0.32666848988422836, 0.39712808385677095, -0.14481480161743868, 0.09410532323082434, 0.25245816298156476, 0.14677728468536538, -0.703721062669073, 0.19127290037580197, -0.659539160937126, 0.48966702145370467, 0.10302100416013392, -0.4064632786358227, -0.6533477574286389, 0.3418736957385495, -0.2612421373063314, -0.0058025912406122525, -0.013939052488900799, 0.16456713542871557, 0.42616446608003483, 0.36403244745954844, 0.02563280478705302, 0.18662160473129913, 0.061846924278898645, -0.2842225490663911, 0.20621978642016825, -0.47696567770276715, -0.17203136253014178, -0.05508789606009243, -0.7550764288720411, -0.4439134831118727, -0.2063503989018091, 0.45019656727299173, 0.23107380304143854, 0.316015432933974},
    {0.2805856312363722, -0.4778840150243087, -0.5604981395821477, 0.3161952585718006, 0.003782309541628286, 0.03251128840741139, 0.3415059092484823, -0.2352195021810992, 0.4582650346222018, -0.1692305118984184, -0.19641333499995248, -0.08496886012309274, -0.21523563411590163, 0.3854178399023764, 0.3220087097528867, 0.04183055882313193, 0.1813387388122838, 0.20155394695924436, 0.2747063337916334, -0.34713003306341406, 0.15888516959053203, -0.05949706750451395, -0.5156658159349364, 0.24646839252079547, -0.3522996665499136, 0.5268422634606779, -0.5831195305170827, -0.25262046049137354, -0.44970748668717847, -0.6927958422509384, 0.3691966500688144, -0.42401433190384036, -0.032073761217855046, 0.032461559717452904, -0.07786083128263453, 0.029320816997571938, -0.35296892013934833, 0.11601083575194657, -0.17676083400381712, -0.04816421994558447, -0.2146718211341501, -0.6969770476290572, 0.5124625704071478, 0.25869910191497225, -0.2585334624681665, 0.03449985938926785, 0.2574014379109402, 0.2382052414604131, 0.14702647264657645, -0.2226615487575704, 0.035561531738424634, 0.7141135451000687, 0.06278479752955775, 0.28922480554446306, -0.1799116119169309, -0.20140397967882168, -0.25862034708852577, -0.14707462758155707, -0.4003790676105725, -0.052890989123175816, -0.09016592017399579, 0.44007478591527277, 0.40328068573424347, 0.5038162493536643},
    {0.18237509918454228, -0.24922607445609066, -0.3799207264693144, 0.32570002822944627, 0.03434237689485205, -0.6936580825518559, -0.34210090030820794, -0.6360288009208667, 0.577782576452005, 0.5981805892395644, -0.7123957980633825, -0.4088929533289393, -0.29142252785735046, 0.2807572643605256, 0.35364182425317703, 0.07692786319631491, 0.2934703170522217, -0.20540354332065863, 0.5104379265965843, -0.7026255284405378, -0.06577848930179987, 0.15312877113091056, -0.19090997387218384, 0.6032887778409258, -0.34186061755268793, 0.6421954110466892, -0.34562804765196775, -0.5944394476172579, 0.13241838099126274, -0.25936049944607753, 0.01610724665488934, -0.3929203725231215, -0.044470175442827234, -0.5411695973751294, -0.3215659334016124, -0.19105436011273075, -0.6798774683044151, 0.11781915048836845, -0.5764162934730613, 0.5972725137534249, -0.6487107056930316, -0.6032598043270061, -0.623420483149918, 0.4502103248026027, -0.10650071288830948, 0.26722493064720776, 0.45084142020523343, 0.3218880595262861, 0.4465066558865847, 0.2884578746247029, -0.5531880089808543, 0.3397087078263749, -0.06405204834177608, 0.4521660008568569, -0.12350314488925705, 0.0933305103384796, -0.19771805519175795, 0.22716781049879, 0.01231077656124731, 0.1962901100935101, -0.32085316919073276, -0.010121924891834451, 0.1385027593664357, 0.43111848903618905},
    {0.3225745697455564, 0.018485155078935167, 0.03214158954232433, -0.43708965826363827, -0.1761490210810808, -0.2135590631247347, -0.04317378803758482, -0.35517617622886766, -0.01058266423174218, 0.36789959868954014, -0.10257375713277635, -0.07232710303258208, 0.08647423315590475, 0.43330856907923226, -0.056501624389830814, 0.02207678941171183, 0.14296065086592954, 0.1901328766038358, 0.4367466226982173, 0.2727515949548185, -0.29650476383490176, -0.35975991738045143, -0.5605010297032066, 0.22684661878600784, 0.30413182791153953, 0.2520986141917537, 0.03588187217257093, 0.183093908640246, -0.1928567914168259, -0.3002294629552251, -0.26081713059467854, -0.5038235692846529, -0.16729178451478, 0.19114636788610326, 0.005042375511881866, -0.18011369607641045, -0.12143000806526952, -0.32246095805019714, -0.32622854031636583, 0.36141993233803704, -0.2315788562052492, -0.3160904364532624, 0.07560639783545571, 0.01972919750410228, -0.37103326353300886, 0.4729982908670964, -0.30940424673946604, -0.25260176466823037, 0.01955549667234869, -0.14600014223129917, -0.1187325139492732, 0.5544581527534725, 0.04381598775248676, 0.38456632214892955, 0.07956744968095578, 0.26162186037435603, -0.3958262483519285, 0.21130135170695583, 0.0998346336168901, 0.01421280852365319, 0.10714602493311577, 0.33483624719957517, -0.01123773668352093, -0.0433341863041731},
    {0.13496565142681446, -0.3003817542064537, -0.21893852348382614, 0.26367760531893114, -0.0339915002571396, 0.5063961459275818, 0.48606820486579944, -0.1599733884975492, 0.6202389288713865, -0.35678551438522266, 0.2789319852224204, 0.06807683620112466, 0.12138044179514096, 0.5608446476457758, 0.6260105876661677, -0.1974149413497856, 0.33862587665705074, 0.6823840026232152, 0.5483815235952261, 0.20923457975470544, 0.21511867277223454, 0.08848611467324162, -0.009796914185197717, 0.585675580438497, 0.5172725117391055, 0.5128759398397862, 0.007025790986301403, -0.09142494968295731, 0.20049573023395015, -0.14730184146515435, 0.11375827358288403, -0.36119578379065687, -0.002155809089655714, 0.520098204175209, 0.5637606270579837, -0.1489500873633289, 0.3193501056661306, -0.016515458965072477, 0.0789800570754659, 0.26920805344730797, 0.5895463124731114, -0.02087533144144903, -0.06834300593314936, 0.24366853452151027, 0.3776610711055587, -0.08977426267172776, -0.11733300954884811, 0.3605471207175713, -0.20474677461053503, 0.2263829476807878, 0.12102893369136242, 0.14001672930906456, 0.6615416732179635, -0.03015562939739528, -0.12592015364520662, 0.49275096118630146, 0.17204243849879894, 0.2892884289344643, -0.036980688320177965, -0.20821693951670386, -0.03278193220674876, -0.050644017035519906, 0.24237114602507556, -0.05882178865036933},
    {0.41564311972528173, -0.04566355592620343, 0.36599070609889606, 0.5018540751229058, -0.26661522407059096, -0.25386673758343986, 0.1880095388873597, -0.003981798258547523, 0.3461376750598628, 0.33690312410864626, -0.1732075148041665, -0.4134267463990109, -0.04806933617429049, 0.4437402985328456, 0.5080044462421883, -0.16712662060916805, -0.5127571608556293, 0.5519690866035003, 0.054685802461248594, 0.37650215343901045, 0.273319815435318, 0.07355527349823636, 0.3309940540776969, 0.03879945925455015, 0.18486301837120792, 0.5073089611510939, -0.3549885621901079, -0.3356392652792261, 0.05839937602964689, -0.07810902713134306, -0.030653773985895385, 0.0046515075092214584, 0.25760453729445193, -0.06965794763469019, 0.37819847110109067, -0.046785836156265775, 0.015082771089575524, 0.05211471717653092, -0.304777071605052, 0.15298889240956948, 0.024244306773145482, -0.18343081389944096, 0.07010087045350472, 0.04285545920134826, 0.005435899183562177, 0.029210924967617513, -0.03861839588202446, -0.5596368636357614, -0.4431127945872284, -0.020483772303089127, -0.3037347111438736, 0.4415447695944503, 0.38697064564027356, -0.11263006886527847, -0.045914940831672836, 0.09937516123952114, -0.15229275342231696, 0.3994493316112288, 0.292685631835853, -0.04052171470451689, -0.06426390476934316, -0.32598032635699753, 0.13032316020526652, 0.1722129017269384},
    {0.038608043579414185, 0.24166694635358035, -0.06935201767837625, 0.26475888308338047, 0.2746361201704874, -0.08164959173533748, -0.4566315340003855, -0.21360659592664688, 0.3684918671584233, -0.40304241195969825, -0.43373019060080087, -0.39532052748048985, 0.15704783132518615, 0.39041202695854255, -0.025072728246807403, -0.08258249895907238, 0.4345060152453267, -0.07841064871131988, -0.05709635663078556, 0.05080913943851279, -0.06196346955878397, 0.1817566282435131, -0.5407924379058172, 0.47631104433761495, -0.09733918225529334, 0.7522735197917184, -0.14497761726118685, -0.2617709206275749, 0.1910371413069773, -0.1932572306358513, 0.029057304768007566, -0.41759661038235796, 0.4415064042097561, -0.2879287323305819, 0.4291807156978434, 0.07821110922899557, -0.08129917944202675, -0.08179222122618952, 0.013413685372158366, 0.036965888081845096, 0.052569832935156914, -0.5552247842244279, -0.14420135886810537, 0.05148606548170517, -0.2973635831916229, -0.10415901645222514, 0.1793404065882779, 0.036457421920114266, 0.2498799475996779, 0.22745723665872536, -0.5245215346661155, 0.6533894081486809, -0.29085762815110644, 0.5790461973199573, 0.038614261018425716, 0.31199698414224714, -0.07516928444882269, -0.24596143395095219, -0.5983643777160621, -0.3941781866631934, -0.5360084858490332, -0.11248997442022425, -0.06520673848412704, 0.0019032348125002899},
    {0.30005036346717334, 0.4286835247711915, 0.011769026276189967, -0.08547881430450047, -0.01455046135549089, -0.13385667448121638, -0.3676845944536532, -0.39778982469600926, 0.11312904228928143, -0.14199146059191203, -0.3105259195641542, -0.1971041026061331, 0.2410268032590428, 0.4535373553001593, 0.40295607364087216, -0.012912851842355837, 0.12911458165547424, -0.10288789565134443, -0.27733616277770845, -0.3141304196503661, -0.44404421896667534, 0.35089004010587643, -0.30845808228175053, -0.20235788741131355, -0.5195982126172517, 0.10339995829075968, 0.0044326902187431004, 0.023827806223597373, 0.18893664684409806, -0.4581474526119681, -0.24992588269023774, 0.05130190189036682, -0.3129595228262858, 0.13538919324898302, -0.3716278760726241, -0.34511381730714186, 0.0858750349146182, -0.28196692860574285, -0.5192987947106205, -0.19552838362731237, -0.29414178622944553, 0.1595524968815689, 0.14759590700633152, -0.19922586470611856, 0.0807442486044167, -0.4922270271467889, -0.2237125059202872, -0.025972083175786673, 0.1738258738303124, 0.15402161431205488, 0.1556594256205591, 0.18409097322629595, -0.09337223672882876, -0.13636038752488017, 0.17299821098396864, 0.03052079240198397, -0.06584089460763984, 0.12599325376887052, -0.4835316443020842, -0.43452669049821896, -0.45712327072974057, 0.23615138018740248, -0.11494461454171058, -0.155414587582578},
    {0.3952403525262008, 0.4418781372860273, 0.34707985726852775, 0.3410095582843918, 0.2595895472895173, -0.25002470131171545, 0.3209102840824419, 0.3993745859522939, 0.4282019689957094, 0.03631881629406578, -0.700065108517678, -0.1078568666436559, -0.5162839837170475, 0.20079004103467124, 0.34394592264569573, 0.12338897971881296, -0.23970120174724996, 0.3079219074269797, -0.13845215260822497, -0.4187971851632467, -0.006327345685758074, 0.17716774035304358, -0.31704832411043327, -0.3219680453370165, -0.5023971974087411, 0.49924328822710634, -0.4728300684061264, 0.3058757279120617, -0.37814861308044606, -0.5032110017771246, 0.3313663783091239, -0.6675520596510629, -0.11362213849832464, -0.15907956105261217, -0.058444441779735776, -0.20100274188143147, 0.022259276655852547, -0.30073913098215493, -0.02312621066992094, -0.39445300463771393, -0.07974629206669044, -0.6139433462535653, 0.15331872962545562, 0.26638229448374967, -0.042390072940905944, -0.1482446064633031, 0.0043923742182039776, -0.5501237135157375, 0.3070603144615332, 0.24139680518930481, -0.3762610412272645, 0.32285935678205485, 0.4345017670903606, 0.13976263843785203, -0.3886161603116742, 0.21207892123545957, -0.3896484665936208, -0.37085617265399456, -0.028706856149262355, -0.139698940496446, 0.23351412149881648, -0.17350872654344776, -0.4518490598410456, -0.22926510268991585},
    {0.3644134750215517, 0.621077792708241, 0.23267771405884533, 0.10006975430988409, 0.3556205265524221, -0.15721386918929794, -0.20767855411541392, 0.031502501234463035, 0.3476855652902263, 0.279589884798724, -0.23754496774858455, -0.46405137710701383, -0.22283900291055458, 0.6663091344519209, 0.042461620715911315, -0.05184723663801562, -0.08463981742839921, 0.08001749181861145, 0.04133469078149239, -0.46118145460445453, -0.05659715057436763, 0.48510815327753665, -0.33712502943422834, -0.1580435320364809, -0.16456927684153394, -0.06183634892357545, -0.23613014791411996, -0.7419546856005642, 0.21210147587810288, -0.5365102397697706, 0.182168671858567, -0.37528111042514206, 0.029523203663248995, -0.49370931269815577, -0.47804565937546345, -0.3295408314034851, 0.015535537971130886, 0.2416818216650109, 0.4878524402243351, -0.3345110965290056, -0.39867899058947365, -0.24120656384235606, -0.5523284376996532, 0.02772319751395182, 0.4222057331944614, 0.3315625084498712, -0.16060687055074307, 0.4844602272637647, 0.19226514524091198, 0.42643978282313044, -0.1557239498984446, -0.01816853327654196, 0.5739085304648154, 0.3846525424502838, -0.4044954723485999, -0.37163681248288566, 0.261110599025264, 0.2385122845623189, -0.7738409884671272, 0.10382196450095517, -0.6274362345694853, 0.42348124380788305, -0.3048974039389382, 0.15614412954815668},
    {0.2605631423869446, 0.5249393354709462, -0.4192971420000257, -0.056867081588059205, -0.12793357606233666, 0.21284111315907966, 0.1641394398835526, 0.0092562715710025, 0.4445033687890595, 0.18020199206484494, -0.28699037087074075, -0.20823689609931484, -0.3999862645136872, 0.022437261576645665, 0.3037343818111985, -0.38013077135731455, -0.1489029744814547, -0.19397537848011878, 0.5019295838063237, -0.23524840518831378, -0.12599385024916418, -0.2329543684253588, -0.23817476452054281, 0.34247117509160074, -0.6004353949904433, 0.5212433077989662, -0.48393140232021026, -0.5494564514059139, 0.061936715234878426, -0.2745121956645401, 0.057526753152024, -0.4824092675006433, -0.07157884461577751, 0.37264995228931364, 0.1089367488432712, 0.18139426418146778, -0.052932213226710205, 0.16372995722341607, 0.24505648388672108, 0.23912397705116079, -0.23228909802977418, -0.27787017542346465, -0.4084430761042196, 0.2963153505804493, 0.35283401025637545, -0.015091108401618548, -0.2636422147264077, -0.031804050188421244, -0.19924761401034147, 0.21401358761351222, -0.0585012375130763, -0.18835671887404457, 0.23455391096535527, 0.3588075430234713, 0.5169421348637051, 0.007530048352719351, -0.04561735142569828, -0.46953596604565473, 0.16658767019076626, 0.28254436113918996, -0.3575341444708484, -0.2644542013488135, 0.08978938143157705, 0.017399555030651107},
    {-0.2425008082186415, -0.09245544957807864, 0.029869940651169567, 0.01555171087002975, -0.05893681965048016, -0.14387292969061102, -0.2689904638840712, 0.09593875998850039, 0.21518201269533677, 0.3320373372647466, -0.197120505132907, -0.39520698980600816, -0.4590717970003731, 0.15244846718661095, 0.10888028513754898, -0.27579678641437394, -0.5190267356675413, 0.1452497328923871, 0.3546972139456336, 0.35161840789716636, -0.25548597807505424, -0.02844038291338735, 0.01382065427482924, -0.417217218787219, -0.12520771231155572, 0.3199220559669252, -0.08758291450660471, 0.014274605177524253, 0.20735505695508866, 0.06644189006501636, 0.18578145830694964, -0.4540122151294977, 0.23132903865388632, -0.3961854072201607, 0.23729633073145492, 0.14669820710591747, 0.13323738236918614, 0.051257211661814725, -0.5740731430263126, 0.3703186167290881, -0.09514234298285447, 0.20586580985710468, -0.32210859079349885, -0.1304246099566385, 0.11862812981589313, -0.08743903799265043, -0.25488169530737365, -0.5531091816215582, -0.010472442679127184, 0.33230335405499467, -0.04069464890615464, 0.5726416867200046, -0.08044162211360495, 0.46488251750522014, -0.3313271055579935, 0.24851678057772086, 0.08367257551644228, 0.31206792377281906, 0.008391924267963539, -0.29482064450568674, -0.23389101510941018, -0.44193629737124646, 0.279362208364992, -0.46753422080047113},
    {0.1466342507893817, 0.4979408802018315, -0.36370693430412304, 0.06040300719641291, 0.07897483881438319, -0.5801130234310986, 0.03498632896776195, 0.10435293246331735, 0.39809054080295325, 0.35771258634421593, -0.2643210263763278, -0.16880471095571836, -0.32284221006490377, 0.45462900887586716, -0.1405610149852228, -0.3004231124002132, 0.4090781277295628, 0.09587662416052917, 0.16008989158168835, 0.17522144297825817, -0.24082488757538154, 0.07282205274983179, 0.21504822171691385, -0.28944983015964754, 0.1023143250249841, 0.05129137520189482, 0.21102799295358257, -0.1834165720390639, 0.32972383877961847, 0.11571731641399992, 0.281822623178554, -0.5569604935586229, -0.4278718819073842, 0.15762651684916604, -0.22709883087194588, 0.26780805626792553, -0.30276979546465305, -0.014984392407328647, -0.3908880399426661, -0.214269590802978, -0.10600587978949572, -0.18613407693063858, 0.20024929842381778, 0.5260794200055612, -0.20727103100538505, 0.38609439323720024, -0.131550477413181, -0.5627586965680553, -0.22366593967139145, 0.17642283033099276, -0.2651442187585349, 0.3571241540614218, -0.07404383185065486, -0.37851507591530403, 0.4331235048086656, 0.422397395868272, 0.033015270230725806, 0.3428006524350914, -0.22739643939663426, -0.10025153681575369, 0.388738024287508, -0.1708563482233073, 0.36248059937971827, -0.3144549649729739},
    {-0.025410191793252383, 0.41872617749931423, 0.0700886491359202, -0.16181877135946507, 0.04251379058731442, -0.16005586422662144, 0.034043197879558784, 0.44631235816116827, -0.22217025901395032, 0.2034225244166862, 0.42321844334809094, -0.07953181128672314, 0.37671292580607885, 0.22653760550040414, -0.018335826287085143, 0.002177880813680831, 0.11715617230112525, -0.09750109716195057, 0.5076922996135468, -0.08590722810273596, -0.34441385148513126, -0.32320894313026016, -0.17952421221681897, 0.3260365566121859, 0.22604117920970074, 0.3255269685028449, -0.003987443533404305, 0.41972295024704115, 0.3930604870108663, -0.009709628211305927, 0.08054170494077025, -0.6399783761678576, 0.10508155302125338, -0.249505686811708, 0.47104355337382203, -0.10436968917704997, 0.04757506791555967, 0.18309790978630533, 0.18951474233011675, 0.5931155033943362, 0.09820483227806312, -0.04781027096772773, -0.6065659035205602, 0.18858754553461132, -0.37975051395123155, -0.08652999330606813, -0.5468176485657101, 0.44777257077579063, -0.6552288893998984, 0.131501626984489, -0.2556126517208838, 0.30840332572366747, 0.17886803352815406, 0.0003261756557028578, 0.14738546723179227, -0.16158537682717783, 0.3047086182430583, 0.2859668012296356, 0.25445069006706916, -0.3379753837367437, 0.26147417435686, -0.029561985677012053, 0.3592963487730557, -0.2270850280802596},
    {0.5092592004307857, 0.46056484538897147, 0.08836490125647005, 0.557763311816426, -0.40042568269836626, -0.2838307030891557, 0.5886523401201007, 0.33991731038600653, 0.14422696953740474, 0.2135091023183126, 0.4986576369972674, 0.07075996073937799, 0.44084530611216005, -0.019699390302193472, 0.1676639946727359, 0.03682892580282622, -0.19439554743777515, 0.5945242683020912, 0.10962625231794101, 0.016227029630847763, -0.06401384488911199, 0.05844946745539409, 0.19757454144608974, -0.30997802505160016, 0.4500877564876104, 0.06537607972059224, 0.41657089174002915, 0.2818578401458074, 0.19706446921466697, 0.5034622438327703, 0.3429284197723526, -0.37912040706776057, 0.36165312196518246, 0.5398491152326459, 0.39512245402654755, 0.1903126173721542, -0.46170413826441664, 0.4186073309919467, 0.2946090275999639, 0.08406846630168832, 0.4624857342376621, -0.14160416329503345, -0.7353575927591787, 0.49026313810781835, -0.1747930070592931, 0.07007366158576961, 0.0405798731215523, 0.0448193524578767, -0.41627440224385837, 0.4030268649706513, -0.2930742873466229, 0.21031196793911616, 0.5019611202571844, 0.06428712966442426, -0.2993066548822362, 0.5106666084830395, -0.03918910663364596, 0.45524477769183547, -0.16738310670374737, 0.15177169956119038, 0.5144987637403728, -0.5552639809317073, 0.46763057898537114, 0.2976239324753988},
    {0.6294496381404437, 0.44135093972273237, 0.0710779915058874, 0.20681674119926222, 0.29466837680824576, 0.4868997372136606, 0.36246823948608886, 0.3058892975104994, 0.45658306839993773, 0.4932894555968923, -0.1774607034936465, -0.32434752955972324, 0.34526701705876395, 0.49137402798529595, 0.13079654712486297, 0.062172772996264544, 0.2661601145945672, 0.06122330172541011, 0.33924797329226447, -0.03944472143993373, -0.027942236064435803, 0.5276886976507127, 0.41912284123570287, -0.39484774827977986, 0.22883473024066825, -0.005443201422609806, -0.003534176783691455, -0.10674847971369368, 0.6628130165405444, 0.22936575346330795, -0.28122751145823166, 0.31256853124701867, 0.4401347181414156, 0.5269234302350031, 0.40964390045058857, 0.5333131742818836, -0.4425486353108732, -0.1146682617219502, 0.060985103255374984, 0.10369627349725076, -0.12623395983268781, -0.24595745877623937, -0.5390234457214823, 0.45666850236094747, 0.28231317722602006, 0.3327785440121389, 0.44695337703772786, 0.2656408391109718, -0.09095117969119262, -0.07506876419713318, -0.4807492134938819, 0.14143493761612033, 0.21962112687460342, 0.6659715028546516, -0.3131411179318624, 0.569754770164668, 0.11996609919221402, 0.3633642750178439, -0.35470408088060046, -0.4083397198949075, -0.02229784699693804, -0.6296948213973108, 0.35829703450826444, 0.23812640523309128},
    {0.09607884718783039, 0.458440376976524, -0.04502394254071104, 0.321506151029922, -0.32188959061458305, -0.261745162235952, 0.27828300444321896, 0.11646130793390214, -0.06853793500776455, 0.5131617860352026, 0.21618783005479905, -0.09378373662378037, -0.40857058309938743, 0.43778460210730435, 0.3975440664599467, -0.32332934588637063, -0.4746428034334235, 0.2830755936434839, 0.2063687417128067, 0.006584675504325523, -0.21222029822435884, 0.39775952964493116, -0.537943280612277, -0.09764444451438099, -0.5576124069935161, 0.62266053091095, 0.03532899734296533, 0.3615824729372479, 0.2971191279424206, -0.28472738739473474, 0.45547655286916683, 0.11746526627313428, 0.3048819384754872, -0.26484726320959173, 0.37597399524085534, 0.27532832460466417, 0.09442397790860947, 0.41890861817116504, -0.0624042249517208, 0.38658514764086993, 0.4325489298412826, 0.19315668836620806, -0.44774857017048486, 0.09241106890321088, -0.029415563364900133, 0.24131295845393108, -0.26958889663179825, 0.14420711488008744, -0.1433887543366799, 0.09058363683985425, -0.13985338017942872, 0.4903040185887452, 0.4894102197254423, 0.126438518315759, 0.5405856469500173, 0.21522634816669403, -0.10942442669482631, 0.39774817972972254, -0.17236782715725982, -0.475097557868572, 0.4574433427530341, 0.16653882959385422, 0.12576096835763692, 0.08469083884055603},
    {0.41496258372852984, 0.17547001077212693, -0.3136181027459796, 0.39600121295513446, -0.4635549770015481, -0.6309630872365983, -0.2007262902073684, -0.07491541318288299, -0.19125796047374433, -0.26250329839040093, 0.36046611461209865, 0.04776481607984139, -0.0830067402255481, -0.047157664144657, -0.0017254149821959064, 0.20205547406112542, 0.027765615456868946, -0.062472226133362466, 0.2328917420310009, -0.11976531230333314, 0.13946869899332845, 0.3570694266962615, -0.5272909342303229, 0.21345707196979713, -0.11253739864408643, 0.04507315102020164, -0.15624734923266043, -0.21891061847632612, -0.3459407434878774, 0.23673084205568914, -0.29673645065788123, -0.5146733697343909, 0.16990066093597556, 0.3197979063289224, -0.1202013615477951, -0.3244926286012923, -0.06484032018281728, -0.084669700147534, -0.46180822649056913, 0.17037187159567144, 0.10088881327633561, -0.1594625235660933, 0.2578659979466928, -0.08695362588354212, -0.5815251173218594, 0.08800375242230186, -0.2895322435992784, -0.25568169958489007, -0.4668600390491158, -0.163753806500663, -0.5548040605244215, -0.5578635340439286, -0.08314334768007249, -0.10877352004777664, -0.06124697315382218, 0.14777399597935809, 0.17046540465775736, -0.2135265200818043, -0.385975197488289, 0.1466843912562769, 0.0020921199623637663, 0.022092035779258366, 0.1821249799769336, -0.15974598543588853},
    {0.05071157553084934, 0.5152369568012128, -0.26725352265125835, -0.15998366238559994, -0.11472915510451132, -0.019363360003802177, 0.39585367516274905, 0.07678404821671649, 0.2864592034248053, -0.43145842393343825, -0.037310998224418884, -0.032250160719395495, 0.34110739172273297, 0.01712700555072457, 0.5071142940445234, -0.5678090210901392, 0.4213020832460751, 0.15326848039555319, -0.10185089097076246, -0.0650673558928059, 0.04231292040281237, 0.028626428031407674, 0.02992356820378189, 0.254148920704133, -0.4529533773239905, -0.5325712925397104, -0.015388492999254455, -0.2661182634461734, -0.4926350906706861, -0.3917446383596325, -0.28503356342835173, -0.3002513837710365, 0.42380501448414315, 0.5141648743510001, -0.3566689405746144, -0.2261427658053863, -0.26044556942825087, 0.2182580779929735, 0.16071922138608555, -0.46376520080159384, -0.36612482465123186, -0.34514723673620373, 0.17715681431746572, -0.001298850095231833, -0.013288556295726684, -0.08052638486704647, -0.12036520206238553, 0.48520511958457213, -0.11344279682833892, -0.054746412213561114, 0.09182155924326253, 0.08687018236689291, 0.08534320775247606, -0.12840145540109124, -0.37233208783348765, -0.46022960586033107, 0.08446848041489248, -0.11592787325836672, -0.22570443776888757, 0.08284277118394917, -0.18789747866465642, -0.546916108902148, 0.28551818600634304, 0.4792617664617211},
    {-0.04574762730308563, 0.19901582301774673, 0.3437807007593324, 0.10578154122489825, 0.2186340763082936, -0.36187522996324867, 0.08117024558397753, 0.26001682348387206, 0.2633164026165854, 0.0792141405890447, 0.09951397837941077, 0.1314758952321418, -0.047044200977463625, 0.48063296816263223, 0.21830451342820656, -0.4077516399655295, 0.286541387279585, 0.3546255774275518, 0.1284937386132458, 0.10912369658117342, 0.06527095825715035, 0.009425267491921442, -0.322832576544934, 0.08184243064259666, 0.25085765059443577, 0.20469547800493412, 0.277782480079251, 0.12789794332358592, 0.08833161292260297, -0.06750232912801059, -0.18750700677084087, -0.4436861219968762, 0.28572976614857315, -0.10786759977584165, 0.11115563230667734, 0.2784406543870422, -0.33098159948573425, 0.15321097055255203, -0.17020438371844399, 0.29315709373599963, 0.5130737732472002, 0.09951264087380561, 0.2611498852857746, 0.33272641323401747, 0.21525782762068715, -0.36690550898001667, 0.09031510169620946, -0.4467049726675846, 0.3196715840759275, -0.21209583734719104, -0.054435764864845866, -0.20958113398755868, 0.40332585302125046, 0.5352256579886505, 0.16828133571962114, 0.301623353339351, 0.6111395105756273, -0.05876861171047556, -0.05375730506023339, 0.40555449848644837, -0.24094008987036553, 0.2654865733728523, -0.2434299368426508, -0.1860315132676548},
    {0.010941897946074626, 0.17494618998862838, -0.37524237161388513, 0.6939664348545195, -0.24899850927351735, 0.20678040725516028, 0.17306247541039152, -0.4853805032173, -0.0030463952954959245, -0.40131060159063653, -0.32813903585202325, -0.558044184336066, -0.36305869190250756, 0.6563560031990308, -0.30564744697278556, -0.6600018989249599, -0.29800320562919125, 0.1587346318854714, 0.1544523063861323, -0.4020826527141211, 0.2150374534086737, 0.5693240997626355, -0.046651139260670486, 0.5136167971210568, -0.5496272956670714, 0.44931395729852486, -0.2002539120237103, -0.037910374611621535, -0.20650834109509372, -0.4669948212869941, -0.3990927731242814, 0.4499699144456445, 0.33073337968311245, 0.0047408866135964485, 0.6017585268508729, 0.11189490202741671, -0.6850386034937284, 0.34017298135598684, -0.4900299481832645, -0.5663921533867393, -0.33739552879437806, -0.5981814071343481, 0.34872653432805784, -0.15019376064411963, -0.06051074791182829, -0.12168867765272355, -0.22843138366742446, 0.3076798059594459, 0.2571754049796909, 0.2743456648120214, -0.12545544263397712, 0.595990882790448, 0.2944068151291111, 0.5107602226499557, 0.08145408945212691, -0.2059856711905327, -0.2850973496255312, -0.1627719955519274, -0.5906927709037417, -0.11770086668593022, -0.4790399417331095, 0.4772993262392358, 0.2157700160704253, 0.3985768916063199},
    {0.45115897267989813, -0.24378369267880381, -0.36502320690625195, 0.012114502562738251, -0.3171503917351704, -0.6208312690227991, 0.3144948116246291, -0.2563776153679673, -0.02359253974034466, 0.6366761335013276, -0.1994909689310701, -0.5060583202865157, 0.025744844819454063, -0.0055587099718595765, 0.2317808321663245, 0.32202388291756157, -0.33315274383534016, 0.07083935070065848, -0.17146546090768183, 0.07583652221959705, -0.45974176718952786, 0.6098091455362011, 0.3047390017682425, -0.027592055799299908, 0.29146385872077213, -0.5160450209527908, -0.3293683812622022, -0.2756016019636019, 0.15676858255296594, -0.14017904377935853, 0.370934726404533, -0.24170009352193322, -0.1253143543282588, 0.25948175535001294, 0.1359480294716171, 0.1357298534855932, -0.5239392683389305, 0.0887483097929667, -0.26973080529750815, 0.18729759981526886, -0.18770337263201234, 0.11495590974301617, -0.5164862481640307, 0.1273245995598214, 0.41503462534821756, -0.050118182109582375, -0.028085235271417666, -0.24056364823547524, -0.06449150650791541, -0.054490005422452234, -0.024990170198178927, -0.01855854415438841, 0.3379183300616805, -0.23819731880163772, -0.2833119855212345, 0.28130374978575345, 0.650131965814251, -0.07458223007008795, -0.2765755074167074, 0.27967652956922684, -0.09749879977685166, 0.04427407610021148, 0.03913418161882509, -0.011479543175058428},
    {0.5807023344193168, 0.43669092364905404, 0.42727634264007053, -0.06823916706020025, -0.17817743924814772, 0.22281998431407757, 0.32832660183864126, -0.13930243144034993, 0.055673364037828944, -0.20652137778195034, -0.1803591426897186, 0.06471093321370672, 0.14892894734942116, 0.24557770358402037, -0.12479379646061722, 0.311141856441718, 0.2546727511253067, 0.6387341228151651, 0.5198414887628299, 0.04202056054314726, 0.060849135714716764, -0.12906786116663746, 0.11399302430069255, 0.4165822651372465, 0.44422044992770027, 0.428647001865724, 0.06024977527516214, -0.4535029314314482, 0.08800254284423371, -0.5082742991884248, 0.13657723373846364, -0.5876115823473754, 0.6445791201822493, 0.571630133221324, 0.3619447173693219, 0.532131734743892, 0.34135580232725027, 4.308418070203519e-06, -0.37979605192455923, 0.5160154828296879, -0.02559558379704101, 0.03530875218807255, -0.18814606552523996, 0.11373009125917677, 0.23133091460342417, 0.5005592953439634, 0.13726178915319226, -0.06208747526367871, 0.11834348364324511, 0.15363269908833807, -0.04355079996026827, 0.4695920994644192, 0.35987603225562376, 0.3223646845337754, 0.031668239118382756, -0.07257859232192747, 0.03501598290632421, 0.28057548993666276, -0.38447545629637725, 0.2541936777699655, -0.18110352791530732, -0.024485260895035558, 0.5240851010506571, 0.3720130283211226},
    {0.27708541254913377, 0.5208836927856446, -0.3603026093167239, 0.2874977402333857, 0.278767101749242, -0.40445150956754633, 0.37967132619195876, -0.048374872510102085, -0.1108201597895055, 0.451617421194402, -0.6302038330841453, -0.027860363592745636, -0.20596074318138174, 0.5372668728573177, 0.24398392660507534, 0.16867453695715628, 0.2637612988309226, 0.2639140780812844, -0.2364451896370754, -0.16722290179818752, -0.0034506317033497296, 0.36105299792676165, -0.06633514524823873, 0.04950339705014442, -0.4101530888129376, 0.32050393337335786, -0.17911173514916376, -0.19857145219339037, 0.30797406806281924, 0.023453431836343987, -0.1769529025917994, 0.030280584691220268, -0.3592124901143681, -0.22272546884712105, 0.3792063719358962, -0.11138909455628629, -0.4748582783080546, -0.3741234660539233, -0.013143360858912906, -0.3031264652013014, -0.18855377099919055, -0.4952905352112151, -0.2870106947213355, 0.30806278269141535, 0.17051914737457358, -0.4302794210951075, -0.3840329574941399, -0.30281165989573555, 0.1210801654935692, 0.07673714189733179, -0.26502660278757434, 0.08332557868114526, -0.2922893294311627, 0.5346278863451579, -0.44378924056755137, 0.12367947702206122, -0.378525538974157, -0.031083691824811403, -0.2876887065901425, 0.06131477853417821, -0.2367147608185247, -0.7017225844610053, 0.023238012299822485, 0.2419611346237165}
};

static const float b1[64] = {0.9665799927426237, 0.9901085677329633, 0.9866890565959635, 0.9915855955567869, 0.8080419980320396, 0.9865945639706106, 0.8802840142340329, 0.9916455111152828, 0.928847999611126, 0.9038289684841913, 0.9313097028538836, 0.9632030150136244, 0.8322736323341068, 0.9880542922503782, 0.9694543658759084, 0.961665578707368, 0.8878607055583836, 0.9694271346724728, 0.999376636985762, 0.9540049111391352, 0.8909175486717655, 0.9987784168193183, 1.0156908905061137, 0.9811640645008597, 0.9998613639137229, 1.0003839715395395, 0.8171542630365135, 0.9837596237070277, 0.959541898876047, 0.992467591994409, 0.896283377603031, 1.0320793750134247, 0.9865215625925726, 0.9977831106634489, 0.8980936231479516, 0.9838877462382957, 1.0105423322321383, 0.9063720797744779, 1.0309259791773828, 0.8939120935211008, 0.8901827927961214, 0.8979830295297985, 1.0082289145035979, 0.9507297349737581, 0.9365319477435224, 1.0163236550680348, 0.8880664345201649, 0.9796975496977837, 1.0243283539620682, 0.8348838740785708, 0.9322665428770962, 1.0104671925580202, 0.98575077875005, 1.008988043069321, 0.8393042624974727, 0.9601279152394113, 0.989153827149328, 0.8395736605200896, 1.011379283976711, 0.9583445687438448, 0.9463046841917955, 0.917717316212301, 0.9948441248975057, 1.020363248719336};

static const float w2[64][32] = {
    {0.7317649290907314, 0.47959079299089097, 0.3750883854620748, 0.7044769957385074, 0.6489697879279793, 1.012658165252747, 1.078827813541355, 0.7328340990549075, 0.12095729378522757, 0.902084858597306, 0.8703602055228941, 0.7411329784246337, 1.0210082382406822, 0.6889150780498215, 1.069764566285482, 0.6433517135647455, 0.8163450908287246, 0.5285243372336141, 0.9777114894421667, 1.0868585151782133, 1.0981490094128663, 0.7225679215132592, 0.32066325954503, 0.8698947800839293, 0.9216978399159663, 1.0363524168163283, 0.7501368615609373, 0.21996427330835483, 0.23584758094403316, 0.712293244995689, 0.4886088459406896, 0.892785587748324},
    {0.781893295784715, 0.5904277415988836, 0.17287607464810226, 0.62432371264269, 0.8233779570467412, 0.9877208339250925, 0.8317686625012696, 0.7361311703239355, -0.0023216434038012906, 1.000115239203051, 0.7604941985064195, 1.097863496547366, 1.0825045322901055, 0.7347751122226805, 0.6894690522033479, 0.7414536943094978, 0.8078416885992512, 0.656695228747532, 0.936452093915337, 0.7171319343153988, 0.8539276003047661, 0.8882818735171142, 0.4957824039659195, 0.7522719346631849, 0.920510056423547, 0.7375883714985699, 0.7500999917486789, 0.2642123504148836, 0.4171574937778334, 0.9540584615372733, 0.15888061068079926, 1.0435179351232051},
    {0.8021795402415085, 0.7202054590918504, 0.011574156653751734, 0.8582988411992515, 0.9882721969048112, 0.8590471687463963, 0.7944810605610522, 1.1023424009003002, 0.010855898478716906, 0.692583994044756, 0.7585958543651887, 1.0777532289072678, 1.0499895964099055, 1.0218763080861628, 0.922187010764416, 0.6829088004807501, 0.8993427144839423, 0.5079166537975137, 0.9430248172898964, 0.9910978627653072, 0.9253392408188427, 0.8889438408206811, 0.5395946483709041, 1.036595308242154, 0.9806619174651932, 0.9907168846815718, 1.1386411942862225, 0.07928718580220628, 0.25034454955280094, 0.8035612220879943, 0.11359761872272504, 1.0037452071562292},
    {1.0555744332971237, 0.8156119659486375, 0.48315617340665235, 0.6734083566613618, 0.8209092659010135, 0.9263267992533513, 0.9942776592857391, 0.8345909508290631, 0.07910205435107986, 0.836752443385316, 0.654213061042339, 1.0498907264006705, 0.9200751172354276, 0.774163007695411, 0.9398206470269311, 0.8103201811456066, 0.9573127194401323, 0.7992294824154889, 0.7800022914461207, 0.7010948511052637, 0.9917099426158108, 0.9330095488604876, 0.664086543480853, 0.9900274519923552, 0.9448531190381477, 0.8261584321831282, 0.7281698470416342, 0.13133091368452138, 0.16790572640329854, 0.632781999235004, 0.4105020902560476, 1.128438559516047},
    {0.7850516827970107, 0.5462130404645794, 0.19816443673267048, 0.7305423168433587, 0.734404480088317, 0.8642695001000821, 0.8620878598972618, 0.8186375977263294, 0.07234417242369376, 1.0169512661352085, 0.8498286206479481, 0.6643383173273533, 0.9776691484888075, 1.0500687928099492, 0.8007361676763441, 0.57680571614303, 0.7879744981619781, 0.714973209359175, 1.1868501400743414, 0.7003547471396742, 0.8524783876970846, 0.8992102671998986, 0.5591104531459794, 0.8883372958109875, 0.8071624481560495, 0.9188789548326829, 0.7304255016450105, 0.41008350388646475, 0.03206778535938211, 0.8497381160549388, 0.37936109676311935, 1.0583385405723786},
    {0.7822440519897982, 0.4368682056536937, 0.38004247464362134, 0.6237525378073909, 0.9035732270522503, 1.158860920219027, 1.1780604810710376, 0.8917120065187351, -0.21618639223809563, 0.5106219671850303, 1.0445710835005761, 1.0519858447706572, 0.9721267911040323, 1.1452797833883162, 0.6382095685658711, 0.6513894508286912, 1.1645873449253934, 0.8435680663678626, 1.0541476162308692, 1.033188144270405, 1.0046375136339432, 0.8488483941095517, 0.44434436993831733, 0.7637033431776966, 1.125780333743528, 0.8108091154679585, 0.8716980525710771, 0.46150819566643364, 0.38184012396598077, 0.7785499157925377, 0.176629704353402, 1.1809794108508544},
    {0.960914922957646, 0.6576448028881638, 0.08593988438848463, 0.7802674429479063, 0.9350273988883161, 0.9188376847271271, 0.7727226577703644, 0.9806532818964444, -0.1043635901688667, 0.5907209011087402, 0.9356892446785297, 0.6925255453705055, 0.7947709916971132, 0.8839142265809575, 0.6288869748795061, 0.5125909073775659, 0.6910914747409489, 0.5739623121168523, 0.8243187170445939, 0.8067625313831126, 0.7134219617287623, 1.0156496237331587, 0.41232450314269686, 0.5583833287255083, 0.8387521840824979, 0.9797232665540203, 0.8713257240704897, 0.2965218949316402, 0.09669369259571031, 0.9680877187810009, 0.4261017926442015, 0.9855460427370094},
    {0.7936974196179061, 0.4309261118434009, 0.06380071547116116, 0.6812296363439933, 0.9773310015714136, 0.8925018408509381, 0.8421003225512488, 0.924728831941792, -0.010430217750491452, 0.5138774780438717, 0.9577029177581137, 0.8408460359698655, 0.8694667377944806, 0.9842006663704902, 1.0691894598852318, 0.7386468959093355, 1.1518044264715857, 0.5199076840268438, 1.0376688091955597, 1.0593459724080647, 0.7798629277262633, 0.9425713660084527, 0.5160421367055885, 0.885942043809505, 1.1180304080554704, 1.1160354084666182, 0.9046395471516707, 0.015591934709678975, 0.43738414964621924, 1.0009513912510073, 0.4261661967558964, 0.8387256211902183},
    {1.0290666262774397, 0.7555533465927085, 0.397474288947395, 0.6059386491765966, 1.029623471658424, 0.7230268320060385, 1.1496523869119624, 1.0880798243352636, 0.06391632250967152, 0.5541518493333473, 0.9719955476473834, 0.7504019979788954, 0.8638823623396581, 1.0369484328389729, 0.9765090840658338, 0.739956901526677, 0.6910745853934471, 0.5327333071316327, 0.8722662157121961, 0.9499916405207031, 0.821052879440546, 1.0566827018995595, 0.36059778445805146, 0.7104150521624463, 0.81711108572418, 1.0209551719156826, 0.8080533902783921, 0.16076419920164706, 0.38378899240633096, 0.8653931126800409, 0.09268068858072612, 0.7209733960499501},
    {0.9740491994222393, 0.9194858966918387, 0.06550993573072009, 0.6074732365946406, 1.0072255227191864, 0.8931861930095562, 0.7229994309416581, 0.7872604253096199, -0.09283169229654083, 0.7440333543187156, 0.723949017301392, 0.9295197271767274, 0.9822478808891664, 1.0527699529829686, 0.7508336777058564, 0.6313699962126976, 0.7316357039031837, 0.6076810195039921, 1.1680400519061693, 0.8531788648293053, 0.74775742329244, 0.9064053860988324, 0.5951646116347435, 0.9158381245751456, 0.6899317394985672, 0.9892875073118517, 0.807937027678768, 0.4074473110684685, 0.4411579351474451, 0.6342823099697559, 0.4515095381601186, 0.956123226645672},
    {0.9670958405176425, 0.6869182718250244, 0.2804523298759936, 0.9457307596441293, 0.8170948734284145, 1.0550286641464515, 0.9288035782816645, 0.9116593653784401, -0.08917743967747682, 0.8617988111041861, 1.0788326410671294, 0.8159011480918683, 0.6583957260402581, 1.050462740531765, 0.9047502513414549, 0.6692238966647012, 0.9185170169820396, 0.9498662186402478, 0.7537382908553555, 1.116736097936432, 0.8135321973615628, 0.7007201465498197, 0.27347173836517136, 0.5961080698450562, 0.7240593721731166, 0.8477402185088037, 0.8143235732022892, 0.3520277173391177, 0.35456304051700455, 1.0154702714232609, 0.2607270528232381, 0.8113561951803422},
    {0.9539462478887614, 0.7912345011426284, 0.4480118751557849, 0.8009051669796179, 0.9402785697918095, 1.0805279950824866, 0.874659587144851, 0.7356056484811468, -0.056441213048340814, 0.5501257320496764, 0.7371898038795541, 1.0241898007236858, 0.9484272228829697, 1.0993503843435517, 1.006869935912643, 0.8739013136136785, 1.0042831186332435, 0.8173300035402631, 0.7135701016423373, 0.6688531008862539, 1.0415609535258896, 1.1511684056014517, 0.2825723577315335, 0.6506590683404008, 1.1006885148407366, 1.1318580747150468, 1.0927894229523538, 0.2951979007440703, 0.36236115710512085, 0.8904467051067534, 0.4337402873791256, 0.9692103089188364},
    {0.8588586286816369, 0.6437169265758558, 0.06774463343119685, 0.7097760167226851, 0.6695507813950146, 0.6811755792287616, 0.7767493856777541, 0.864630516786303, -0.2912063960922625, 0.6560429619199617, 1.0060979250757283, 0.7447439412996228, 0.8104256600852705, 0.9930142432109265, 0.687106123129948, 0.8725838621509062, 0.916422356803896, 0.8193110858637828, 0.9613817149000444, 0.9079112096202774, 0.7815399385453069, 0.7168335913785923, 0.6288021354667378, 0.8362635243074603, 0.905348375410766, 0.700778286501158, 0.8899968804836413, 0.2674371542956208, 0.4729242504132518, 1.0390323566266562, 0.12351140218162299, 0.8887974070989659},
    {0.8485524736542976, 0.8760770575634446, 0.06886030676220806, 0.44403784912629224, 0.708969177103308, 0.6541049187157671, 0.9385936514477917, 0.8699065884962238, -0.15003969538253037, 0.8486591172831641, 0.7832193968257104, 0.7888162782793104, 0.9423890783628787, 1.0076202689883493, 0.6741219948507063, 0.6232934194639034, 0.9048699201387448, 0.5780104955165902, 0.7702312598682085, 0.6775258873605488, 0.7913076786145078, 1.11388958598029, 0.418345235307788, 0.7966340143373859, 0.9385333330521005, 1.0217922484312028, 0.7114498131740224, 0.26310434250586456, 0.09667241199354736, 0.6722754014571645, 0.4155251442331922, 0.9107940088390637},
    {0.6813699298326439, 0.8805572899795547, 0.04650019573586075, 0.6790130130210225, 1.0704494297183145, 0.8002401428806333, 0.9505179022477597, 1.0889144774893307, 0.11956294803546387, 0.5274843845917152, 0.9140003103723473, 0.8336141101559832, 0.8102103086594507, 0.9971088816298744, 0.6227769554671293, 0.7309385310711856, 0.9792921880270956, 0.7827280533873147, 0.8028515664858065, 0.8520246478283771, 0.8539555700539146, 0.877709369270163, 0.184950315682198, 0.8584777820758486, 0.8686095333220882, 0.8552484764155719, 0.7033096279745089, 0.4281343915515773, 0.0078627898243055, 0.6327028971241426, 0.5447411891385016, 0.7745573011548222},
    {0.7471227279753287, 0.44742066563704863, 0.3325585636968918, 0.8809351811163393, 1.0366811224890076, 1.1170697422642635, 0.7614636727143348, 1.0283670142793593, -0.027917594734307622, 0.8019711477935413, 0.9699938458208748, 0.9708656555139511, 0.8598751566298796, 0.9443148657971056, 1.0741168131897678, 0.7049045933840248, 1.0751376711932676, 0.9171260615495098, 0.8495502839039759, 0.7288637402946804, 0.9496749420449521, 0.8455024985856088, 0.575868784797347, 0.903647353951052, 0.9565812769414475, 0.9442855806127023, 1.0537847202782018, 0.02683286836933716, 0.42891474915790045, 0.6318152251105246, 0.18279058335365014, 1.0436083211667972},
    {0.8934755681753032, 0.6279651685880212, 0.27860304716774403, 0.940131054621576, 0.6656383544313788, 1.0674844856551815, 0.9585713045894954, 0.908289565630881, -0.1930066763403337, 0.6114820338626723, 0.7094189268732348, 0.8035837779718674, 0.7193547427037548, 0.9464828833656549, 0.6665524118343558, 0.7102563095865818, 0.7400454470869862, 0.6863886300174702, 0.6951770679717765, 0.7305708667106101, 1.165985912710255, 1.1220090862270433, 0.5387056273231128, 0.9837305968738985, 0.7329888903177506, 1.0122912619853413, 0.8717291804719521, 0.31189546983692745, 0.35229217674488755, 0.8233574191772071, 0.2597443870026903, 0.9890036848110632},
    {1.0941227538624678, 0.71531137568207, 0.1446662862858094, 0.630075795667124, 0.6207601662164584, 0.872200451114808, 1.140133927177616, 0.923633724928112, -0.06250511382217053, 0.8526206803087373, 0.6186267573663892, 1.0525755565138408, 1.0783352823328847, 0.9601966418178354, 0.975423716599708, 0.4963971685473057, 0.9951468493776384, 0.6744170267340213, 0.8565022619833957, 0.973487393799274, 0.7389198662177775, 1.0051006318739337, 0.5817011133042892, 0.8225974261470136, 0.7800635059084643, 0.95634059149946, 0.7246703632533215, 0.21916431751728133, 0.27887355205523784, 0.9195191019144457, 0.5563849017927629, 0.6750328532071902},
    {0.9863275065661136, 0.8645671895510645, 0.21226718891808669, 0.7324077372432503, 0.648043855094779, 0.8629403965021042, 1.0421093727986122, 0.6785292448165876, -0.30038176238695286, 0.514595274464468, 0.6605004542989928, 0.9364211506051229, 1.0335413148442687, 1.0509401450465685, 0.5688881479250986, 0.7840520459937167, 1.0963109447793769, 0.4772608405908744, 0.7458301155176006, 0.7286000346174263, 1.1079448813390238, 1.0137835598304408, 0.5103538383638221, 0.7353455709032727, 0.8691798610040992, 0.8286458476208568, 1.0622842290311347, 0.3407316069442059, 0.2920960335466095, 1.0215420830323665, 0.30568961505161946, 1.0798550724602458},
    {1.0275847595435055, 0.5568153844224601, 0.2323957938692915, 0.6810670033941035, 1.0173596429311584, 1.0677446780469626, 0.9278322809761518, 1.0871529530059207, -0.30248367090735767, 0.9020675027640849, 0.9810692699500496, 1.0941392516889172, 1.0741250767338395, 0.7999815964330492, 0.7549199148732019, 0.9165042755063304, 1.0942222526655745, 0.9572754738025301, 0.7099556615108474, 1.0493129387675548, 0.8673916013670897, 0.7127973439487676, 0.1821543413713346, 0.5887532141894112, 0.982485838190907, 0.7556468789199926, 1.0766970111733343, 0.3371422394177083, 0.4286454829234754, 0.6446903982277568, 0.5400448480108175, 0.9886648188643796},
    {0.7889895353979789, 0.5029474517344158, 0.36991720679468115, 0.5347042839334707, 0.7432523633328408, 1.1712009684270337, 0.7337531297527359, 0.7817425443509785, -0.13260429217959116, 1.0078126202235416, 0.861541982631411, 1.1620639796367465, 0.9877784334948908, 0.8499912672631615, 0.6204511893232054, 0.9439054533226928, 0.7166357019822162, 0.947489576254993, 0.8730426302293376, 0.793016205788879, 0.8717566629863007, 0.7197390444465088, 0.47635916632346015, 0.8901254665280575, 0.7653016365419674, 0.7841647506689333, 0.9091173862067594, 0.31014451809089066, 0.5230740385390547, 0.9803633968317628, 0.18500693452159442, 0.8113961144942243},
    {0.9131650432725906, 0.4405309155518702, 0.09978830817709282, 0.5194759272290461, 0.8618766770420068, 1.043094596863067, 0.764665137843472, 0.7426777630478998, -0.31105159109484803, 0.5253576400563955, 0.7233504445771268, 0.8217751581089849, 0.6392777424059355, 0.9520593382727117, 0.9063197339745778, 0.7415026019980541, 1.0672828933454601, 0.6510234745843174, 1.168643931168665, 0.8154216975757889, 0.8798922686705463, 1.0880383917175183, 0.24286238487471254, 0.714360620501729, 1.0974286071544117, 0.8180034986403356, 0.66968212026384, 0.08425781265982617, 0.4044041832723156, 0.8375089912816333, 0.21964077641210025, 0.9911738868416449},
    {0.6494757294201668, 0.6476326863798926, 0.15095953986840183, 0.590793564369321, 0.9332643331185627, 0.9615843835844616, 0.7125386609945392, 0.9642717413872594, -0.05445567841303982, 0.6284523428442483, 1.1113719214968445, 1.0290806737982554, 0.7551982841497275, 0.7550016125492277, 0.9991744164911265, 0.5755929817428576, 1.0140867748356177, 0.7100537040598663, 0.9927131529364747, 0.852981489470898, 0.8183577400201447, 0.7392702914155387, 0.40835664249588066, 0.7786064008626655, 0.7623399891219533, 0.909895366240103, 0.7067301259187396, 0.29474697382455045, 0.10258152075424112, 0.6893198196495597, 0.14149990079187647, 1.0326009767891988},
    {1.025176226060089, 0.43799403782453344, 0.07724334677015635, 0.7927019770018442, 0.8496928145588399, 0.700127964986599, 0.9696020808810648, 1.1482023856611734, 0.05427304469989073, 0.8471629504167189, 0.839733583400337, 0.9682448172101545, 0.8093327344337422, 0.68678586228546, 0.9073977765283777, 0.5173073429529117, 0.9533136084768765, 0.6177843980243147, 1.0009019013360851, 1.1164323774562748, 0.8000265040779292, 1.1401281019705363, 0.5542367004849013, 0.7178397681167588, 0.9046914071971979, 1.1048432684403715, 0.9174316397114244, 0.119966068973871, 0.5201940448290859, 1.0628096785654573, 0.10241633955092125, 0.7135000111364096},
    {1.0066765500601234, 0.7772370432422102, 0.11467117331202256, 0.7430014230199317, 0.6375948797697492, 0.7202275520546628, 0.9168030462988539, 1.0044899325079764, -0.21261377019791736, 0.8081909354425842, 0.7376065774152589, 0.9507097382293196, 0.6992430255175178, 0.7921014237361285, 0.8328311036540144, 0.6913426438844352, 1.0927765789445874, 0.759629421263427, 0.845464772239473, 0.9230346101485997, 1.0778401245869915, 0.8129590206012461, 0.4748631435444776, 0.8093597546134871, 0.8714593341560567, 0.9056234671984448, 1.1402809396426878, 0.1516813768708882, 0.08739259978427186, 0.780887359993838, 0.180561659433308, 1.1650200711816923},
    {0.7998357865514341, 0.6831617355416972, 0.030920957304326337, 0.6869678933260132, 0.7801312364389862, 0.804182821514951, 0.7966356652861031, 0.6933369495058361, -0.27734722097885406, 0.7879097957007969, 1.0674063402495142, 0.9021712560209415, 0.6504903405856944, 0.8459388130591293, 0.8897984093811672, 0.906728514019926, 1.1239149713366605, 0.894344124826859, 0.7090813236431298, 1.0794598076438937, 1.0410334740246383, 1.025921172534785, 0.4001048644458848, 0.6725753681815139, 0.7493896072060673, 0.7080790784713613, 0.8500358301988296, 0.08557574761339164, 0.24368324440011357, 0.7409591322128136, 0.07872688511332095, 0.9598865875715539},
    {0.7477931331901524, 0.8120586148924827, 0.05660695746357225, 0.8870842289519879, 0.6859722852239107, 0.8675040130461729, 1.089192182312556, 0.7503929084441441, -0.051525138640013735, 0.8545282650977337, 0.7515307406192161, 0.7283918213949758, 0.8963976393156632, 0.9914375963436187, 0.633944604979712, 0.6356222630493665, 0.7316546269842884, 0.5784324931116611, 0.7367556981241574, 0.7997284182495011, 1.1553183279114752, 0.8699580069146561, 0.5304568280218294, 1.021827023122909, 0.8471867847181127, 0.7258505407268918, 1.1464548911403178, 0.16388128978518093, 0.09160611868926412, 0.833317379948086, 0.24264035310602944, 0.8531714027771902},
    {0.9429219226870852, 0.7674261462443692, 0.32155418963468047, 0.8668206475645938, 1.0160419231192606, 0.8149177158697501, 0.8054391009103783, 1.1149044818961893, 0.07345373146595138, 0.6761093898803106, 1.0755236351378485, 1.0261922907418317, 0.9585964752560996, 0.9563602265194109, 0.6930807255568844, 0.8276016740309186, 1.1071968391205382, 0.6674124686904339, 0.7293772512915578, 0.999491888528208, 0.757196991210858, 1.0622542910678667, 0.19970859269457397, 0.6273173295933892, 1.0793182603089027, 0.9427137210799967, 0.7109448407675596, 0.04211609708852851, 0.16098865063836376, 0.8255104736924209, 0.07114296728915953, 1.0265852407144787},
    {1.0530706289589773, 0.8117748000777987, 0.26221829403877733, 0.9676958482702328, 0.9395201434091133, 0.9204556232376508, 1.0561413042056047, 0.9973274372023088, 0.09224779048385613, 0.6052991671231684, 0.6879584440427732, 0.8496660654980565, 0.8380345790759072, 0.9695922168198862, 0.728802866673716, 0.8525086293366143, 0.8407270091509348, 0.6065999865933129, 0.9233891070628752, 1.1074842460918723, 0.9271965788339351, 0.8799348607052505, 0.6193992343569125, 0.5840962717135552, 1.1243494338222897, 0.694215358026571, 0.9654074580213376, 0.0414619084389787, 0.23813638149961688, 0.6046786134307678, 0.2641037541366224, 0.8488169107412071},
    {0.9548051368198783, 0.8354461232712337, 0.20099950080673443, 0.7487960924896424, 0.6924821350033161, 0.9613085942587556, 1.1554613037814525, 0.9934341022774258, 0.1289101044237501, 0.8279063778932179, 0.7582716640107304, 1.1315198784184106, 0.8934749450051002, 0.8637220652221267, 0.9548970374054337, 0.7767815796244202, 0.7225830625103229, 0.5140262470101316, 0.6955454613836595, 1.0647207962872378, 1.0804710352786164, 0.9125664826004163, 0.2524071559021966, 1.0194238415834114, 0.7056041033996621, 1.1151612045643928, 0.7349379926908023, 0.29638835153776705, 0.40861747965869333, 0.7249416316779999, 0.33631130056118097, 0.755300823881846},
    {0.7137800438229543, 0.7961766000779805, 0.26076298835243367, 0.5297463911599765, 0.9442279899755062, 0.8171872843607225, 1.042016590489284, 0.6485706663923632, 0.16057383930358432, 0.4963843476027096, 0.6820024530010314, 0.9240622006247331, 0.7686830070599403, 1.094685118579429, 0.6323318376148253, 0.536653256363721, 0.7668141708010037, 0.5749470637167227, 1.0238219810125921, 0.6422072624001837, 1.0813201404354567, 0.6534268719358145, 0.2821905908166533, 0.7584941603423768, 0.8436607060268813, 0.8008163260421536, 1.0883686198505764, 0.1975186156102916, 0.24373176404596456, 0.7971998945979398, 0.4147359663577836, 0.9202549294827512},
    {1.0323040108174775, 0.8604840150527315, 0.3800180478287834, 0.9020224547440556, 0.8716969004606745, 1.051003565069042, 1.128091041320725, 0.7278444271775432, 0.06829892958180364, 0.9762590279144363, 0.7726877063971539, 1.1716531979003781, 1.1567271506696253, 1.0766779048829087, 0.9842988272156599, 0.5937912261971054, 0.7703293705809265, 0.6635168652277604, 1.1580742199286225, 0.7905072499965169, 0.8273087704086014, 0.8931809855236656, 0.5338764541173286, 0.708897661827343, 0.853599583160705, 0.9531481926771933, 1.1754418015106614, 0.359773748664126, 0.35620888255038596, 0.8129101508312617, 0.26293444205127064, 0.8535233368808899},
    {1.05693420386969, 0.843334102617675, 0.07518695030194682, 0.5576625589930944, 0.6863417574739754, 0.7419674015416886, 1.1332966350869342, 0.896468933879255, 0.11284334713239949, 0.5597217639872282, 0.7899078614905378, 0.8191154959632514, 0.9069547244869125, 0.6668987068025807, 1.0164040540852854, 0.5232690845750301, 0.9012509503896181, 0.645293851031915, 0.8801997393377368, 0.8594391623898366, 1.071928738200581, 0.8780625473206419, 0.5078858881005361, 0.770248393627599, 0.9740970573349286, 0.9575275021449191, 0.9761553230611671, 0.27029922275345886, 0.05789235739475543, 1.0294233734924807, 0.20609412846698602, 0.9232719297311137},
    {1.0200838582854435, 0.6112756493152449, 0.35867717036980473, 0.8626051431061426, 1.0289690209105211, 0.9946937860159035, 0.9842309943448184, 1.1135078033795422, -0.020046270850386825, 0.6298318396670642, 0.9347323083717879, 1.0043321763100663, 0.662407113032047, 0.8075617549100097, 1.0581411085481025, 0.8632798057449462, 1.0803910152698948, 0.7489867974085189, 1.1353626297647952, 0.7632490227240959, 0.9865923205227133, 0.9105186636096276, 0.3164669792190853, 0.7627991147183554, 0.7471891293448125, 1.0238306437329743, 0.7261330853847588, 0.07563219381714452, 0.08002163726729088, 0.6733616256099023, 0.24311928054311827, 0.9342400501943908},
    {1.0160176021095595, 0.898987351929318, 0.09662111304108537, 0.5948659686168934, 0.9944550431294664, 0.7623864328293913, 0.8417776521802907, 0.7197448090221433, -0.2077647900347258, 0.8896586046694018, 0.7884602026304597, 1.011147951856364, 0.705582417171969, 0.6733239531023856, 1.0272038093944131, 0.710763327377779, 0.8022062146277478, 0.9172640783132511, 1.1366315095439332, 0.8599699929373915, 1.0127095085592714, 1.1053020428431461, 0.5958974584488282, 0.8884047668800508, 0.7614691047294924, 0.72100249642785, 0.9372511044907541, 0.2787720592528931, 0.05808231674996596, 0.6272594367959855, 0.0801518220587017, 0.8542639057275457},
    {1.0017582242236944, 0.47830464969964503, 0.14445643913252273, 0.7948255444590937, 0.6703365930630198, 0.8038504229091739, 1.0112769727536333, 0.6618156907308653, 0.04390006812244756, 0.7386114137330019, 1.0831904679591378, 1.101990470397945, 0.7695693316874509, 1.052624088730749, 0.8173409211262922, 0.8369343691789709, 0.7914284711509338, 0.9226911060106668, 0.9769042814078867, 1.1155304106368469, 1.1502793803895535, 0.7522975607501351, 0.6013853770295462, 0.5927560292787795, 0.8959900081971193, 0.8413217244127422, 0.9660637633660855, 0.4175800842364939, 0.31580426321886795, 0.848940779468319, 0.18269233014128414, 0.8405023483087786},
    {0.7919037417091926, 0.6257013904641471, 0.5416435691114768, 0.6365046616852706, 0.8018153886004019, 0.8370817972570596, 0.9775626899010601, 0.8671219938295252, -0.008804041738486526, 0.8626896126682491, 0.9912564082039793, 1.0583162675088724, 0.9425682098828794, 0.6767708543512051, 0.8450482287892914, 0.5107036784394517, 0.9851346631406355, 0.5260302713840546, 0.8746499408692588, 1.119668862701333, 0.7971311679910643, 0.918136624053931, 0.6155356514229005, 0.8205199290161371, 0.6918311199062267, 1.1525665207128175, 0.8978909259159892, 0.3288306541936022, 0.22589642054612988, 0.8632609606995006, 0.3381265954727417, 1.0346564890170258},
    {0.7987928588021767, 0.8481699458730871, 0.018119827920281394, 0.7607052097904143, 0.9781449353529879, 0.7401578021207371, 0.8546690466194293, 0.8466377071505584, -0.2481113005963323, 0.8592545256750368, 0.7098767235572528, 0.6815724910087109, 0.7929526990333713, 0.6899557740824879, 0.7943652734614933, 0.7544723648129242, 0.9913648319114893, 0.6144247917157101, 1.1572328858761494, 1.0656040106610072, 0.6587433677316141, 1.1470693905822873, 0.18383040462203487, 0.6993352109138283, 1.0679968414459675, 0.7275610516901819, 0.8780128639354958, 0.43808534771014307, 0.48248890285089924, 1.0663897414775736, 0.47354634959689573, 0.8746690443790246},
    {0.7471491294672157, 0.6979111168335227, 0.5215336041003772, 0.46226497721002063, 1.0547445125206942, 1.1317709761699672, 0.9706943024139483, 1.0488895063558412, -0.08301925756333838, 0.6670962072425631, 0.9221066905397661, 1.1182600585712603, 0.8071756416374231, 1.0986941713661, 0.9577378972613608, 0.495291899324533, 0.6948499633493823, 0.7427052127275364, 0.8040147685047128, 0.7591880328752759, 0.8995256468734277, 0.7478984623581946, 0.5407505412478747, 0.8266163122718408, 0.7916219422461915, 0.9923346104721223, 0.9187486164104032, 0.14057522552040067, 0.1901055861645137, 0.7519658666819938, 0.46651605581822075, 0.896782075614924},
    {0.893578182822342, 0.8511917455828322, 0.4793893759718285, 0.5783190801072022, 0.7120956613377082, 0.8061532553482135, 0.7752066975678296, 0.7248914644910988, -0.16805960521917204, 0.7262059650787742, 1.1209232819671227, 0.7992653739510607, 1.1002087042191673, 0.8812494538294727, 0.7469377117213905, 0.613491368616114, 0.788873070170054, 0.48572743622739456, 1.011323597066398, 0.760939941254051, 0.9318999021773032, 0.8764139372968329, 0.6242260244744859, 0.872811711808386, 1.039554879500299, 0.848975938759737, 0.9146865704890759, 0.2096013526763272, 0.47640375116439837, 0.678167219485956, 0.535682514227366, 0.95610419570146},
    {0.9643207013674723, 0.5730605231072108, 0.2427538369779116, 0.546767178121263, 0.8703926734779702, 0.9740360908954336, 0.7516880446636073, 1.0035083925456225, 0.03447657320196254, 0.9592724810250223, 1.0139391711987904, 0.663685584860442, 0.93065529429682, 1.0263187941325318, 0.7494638076206941, 0.6968294318331566, 0.8959824603622089, 0.6682435313817148, 0.9453736040853353, 0.8526961470312261, 1.0925065145161823, 0.7761811806579418, 0.5960872868959508, 0.7175912412596301, 0.8209735172283356, 0.9781568978286824, 0.6960361362545118, 0.495945719662537, 0.13190651908427795, 0.6508394904027801, 0.5653843752913694, 0.7300053024374401},
    {0.8506965834846635, 0.7816272360525149, 0.09504030459367509, 0.9349338497566576, 1.093294433302323, 0.793945607601005, 1.0598857702569346, 1.0722869237206507, 0.044109169922252736, 0.5202585495043346, 0.9107326482066072, 0.6786428622988033, 0.9678993739645495, 0.9023860995663927, 0.8253823453019224, 0.4776285816706581, 0.88854580540044, 0.7496230520647875, 0.7624466642635934, 0.9437313740883017, 1.0968175757456518, 0.7321656323763771, 0.45495892615917116, 1.0415927423266749, 0.8460384863751941, 0.7933495941504399, 0.7806208215588281, 0.08084281516192897, 0.3319252055335503, 0.7292307911857054, 0.10896869485091867, 0.7681150162292752},
    {0.6823645477296411, 0.5665359951932954, 0.29020177558776866, 0.8722115574409698, 0.8215879005185647, 1.1220380099472065, 1.046090705156136, 0.8209422702261403, -0.29244861678735223, 0.6020477454363086, 1.0545386414491522, 1.1502552965311468, 1.021479175347881, 0.661052566651654, 1.035786203689494, 0.6313964740744338, 1.0596742780355453, 0.5258901079053425, 0.8833437674483533, 0.8919810980857238, 0.9547897211280904, 0.844506236685647, 0.3857624075518045, 0.6148372382669232, 0.9976422388150314, 1.0669993242815934, 1.0906487544715633, 0.44274323561853274, 0.12166287697343554, 0.8598053747581211, 0.5648823739480919, 1.1578949728381849},
    {0.9399652785615732, 0.7638988231531877, 0.1823568345374051, 0.9308420828314742, 0.6620369095477486, 0.7071403174181428, 1.1617694208166205, 0.9056128306177759, -0.13785279207479592, 0.8600790821900804, 0.7571244614142466, 0.8457870743802942, 0.7174808095744584, 0.812811109947928, 0.7773392107246831, 0.535302246607053, 0.7956984607091706, 0.4813630872228545, 0.7620331512812564, 0.7773136776026841, 0.8861906034581482, 0.8388956812469616, 0.43275079350212936, 0.9516456253261533, 0.9386775015563971, 1.052598530820166, 0.67316100741714, 0.3105773665556152, 0.3963289655881636, 0.9300596789615415, 0.3121319475313132, 0.8592465588272706},
    {1.008796957424664, 0.562476574223109, 0.10360060267950483, 0.4621953688320069, 0.7146468832654765, 1.0244575957094344, 0.7164169530971097, 0.7465097122799478, -0.12460974455655625, 0.8337792515875563, 0.7496872699290644, 1.065827695717669, 0.8430695835204475, 0.8203788673299635, 1.0354564731557132, 0.9504957333726056, 0.7597245205798413, 0.4715690776541498, 0.9929552131704225, 1.1035072290509993, 0.6859355429835364, 1.0116317784317685, 0.47428806287897635, 0.9993981332451408, 0.8213440431408146, 0.7228448017892786, 0.7215940422449983, 0.3732675317325662, 0.377565424563729, 0.6616416571207132, 0.0818042821095977, 0.8538067050204446},
    {0.6627080177132416, 0.8014264671380625, 0.024490526902983523, 0.5138482698676922, 0.8426980150653867, 1.0385784866680243, 1.069230094161012, 0.7227401335309974, -0.08252450288780717, 1.0035124401310398, 0.7246816628660285, 1.1238368657506976, 1.0005651515419975, 0.7529341729559139, 0.7334610788919854, 0.6162946734722415, 0.6870729674221209, 0.6174199250382599, 0.8107471675626498, 1.0822741984366049, 0.9972737864806267, 0.9329872862261375, 0.3287369286906391, 0.7059893862557126, 0.8280547045113937, 0.7957039674332319, 0.9827151335666746, 0.3278119118491282, 0.4756835271277912, 0.6850741875034416, 0.2969156151708426, 0.8426676840310368},
    {1.053173953904748, 0.42059081928628544, 0.14436027001514162, 0.8612182731636605, 0.8362983507976042, 0.6835181232264234, 1.0221671453634662, 0.7748076478269434, -0.008969406876595783, 0.7639444252479707, 0.8657661682335231, 0.6602884900373388, 1.023888246441024, 0.740159918475311, 0.8499481213746231, 0.9035895076947457, 0.9676073091682854, 0.49921146170932523, 1.138410702821135, 1.1095259197040706, 1.1110559326016023, 0.997318416582004, 0.5145780740773113, 0.7308646591285554, 0.8123406253696741, 0.6920358783573253, 0.9328548649594314, 0.21141304173444872, 0.25537075574086027, 0.6613574027856121, 0.5606300235812306, 0.8486616083158336},
    {0.898913248162224, 0.7225391477597777, 0.4648060418090673, 0.8105412326195415, 0.7045844016305678, 0.8501204271370759, 0.8727474206890025, 0.8876455750439618, -0.19781279517520794, 0.6614924335367304, 0.9704703115908103, 1.1295489868987192, 0.769595184392185, 0.6809807245237488, 0.9044533074133617, 0.8483333725662852, 0.6824797526717836, 0.8188319571173459, 1.0861121696912264, 0.7368769565960649, 0.8750402612691429, 0.7633837940573078, 0.461787158557727, 0.6783674392299173, 1.0971838060404884, 1.1525503774967667, 1.0988304571274852, 0.4484695612808653, 0.5439304941719124, 0.7775556940702203, 0.23157080845893074, 1.1026405263377186},
    {0.8745963709853313, 0.6287399399374896, 0.1529026022369647, 0.6838588615711121, 0.7974175201890169, 1.1267079589724036, 0.8122688281528908, 0.6809486481026642, -0.010236011889664423, 0.911405000957942, 0.6754354943518017, 0.7346413963419582, 1.0213762314553931, 0.9250962348474904, 0.6005882240182546, 0.6328689166289417, 1.0702216895628147, 0.519736437949894, 0.7381553995484865, 0.9192343870204507, 0.9523121616327554, 0.736016804063136, 0.5041230814026156, 0.6461585723970843, 0.7247023998211943, 1.0599705847983878, 0.9648979949259696, 0.0012755731359048502, 0.47210120524460314, 1.0310483076783084, 0.35677094480560484, 1.1752473790764404},
    {0.8128792417583989, 0.6463910578281558, 0.4068669844125395, 0.9587449778808983, 1.0601599871894016, 0.798730325442191, 1.0863126543929933, 0.7359123418849537, -0.3060257030661192, 0.5808133417011746, 1.086639265072705, 0.9037683230145733, 0.7601212328847687, 0.8461871676869904, 0.9882236556205283, 0.9051577059256702, 0.8505651893778813, 0.6226018356049572, 1.1005248172072462, 0.8112018963741133, 0.9002327625409479, 0.9347275546789743, 0.29667989815927537, 0.8545485699123251, 0.6725111806428409, 0.6589141745675505, 1.0806910090233965, 0.17463703566503333, 0.3666740626052536, 0.763158643967703, 0.5395717757460197, 0.7147930525787322},
    {1.099904421508459, 0.5946840935140772, 0.14624651852127857, 0.9400549286367806, 0.8217061950646832, 0.7740770982909732, 0.8277391400755522, 1.0145013509805747, 0.05781383587375657, 0.9299090354048211, 1.1046999549717118, 0.7619693157922259, 0.7490197417625141, 0.9062866125256148, 0.8572678858425635, 0.9157007586866083, 0.770272439994772, 0.5798412084854919, 0.8170246542405811, 1.0991711093064511, 1.1003341123913213, 1.0711770552644995, 0.48006088710387335, 0.5788542194090498, 0.9592965828562983, 1.0672272065885469, 0.6867006227839968, 0.17908305076828213, 0.46736773947731985, 0.8254118020397866, 0.1684912419893649, 0.810051163577863},
    {1.0640756944882244, 0.6570706357373085, 0.5107980115017012, 0.5338505244700744, 0.7934554185023421, 0.8783348119648222, 0.9898172860497934, 0.7274548965500222, 0.016106145955497725, 0.7799187639628986, 0.7632512038253939, 1.0807861147061735, 0.7457265868694366, 0.8959544064438081, 0.7187344678048466, 0.7064159232746777, 0.7645345608080477, 0.9353741995919561, 0.8816025905644076, 0.8133666396878001, 0.8564801239704707, 1.0642822503313436, 0.4663750521852517, 0.8669742663896944, 0.7855322852778304, 1.1091058395053914, 0.7949012886071508, 0.25818884117961866, 0.14959609779702818, 0.7431351720521167, 0.27924158371594515, 1.031321316033041},
    {0.774153305579649, 0.6063249275115553, 0.03082139718906157, 0.701196733929435, 0.9791589056100182, 0.7337577750666475, 0.8182440560220748, 1.0499113829088924, 0.0271237058839056, 0.5470343810882283, 0.8900400581848513, 0.8074973736104162, 0.9764324117832167, 0.7416195828619316, 0.9829263356354775, 0.7545404091143588, 1.1396971060285874, 0.7629261821602783, 0.9047210069738613, 0.6711955696385581, 0.8624041028741728, 0.943422155208424, 0.2671522047260631, 0.6035612717873524, 0.8329201586318031, 1.0556101404383786, 0.8990574450810452, -0.023090003679859156, 0.3149274514147622, 0.8357594471463435, 0.25806095970734166, 0.7621347125691237},
    {0.7565934518730497, 0.5965462902685555, 0.21330350134399925, 0.6409311297577139, 0.7260951504983009, 0.8672253794737649, 0.9535714377218594, 0.7091592704742504, 0.13717367888107382, 0.8738017490892676, 0.7301085708756235, 1.0998040898634285, 0.8595821230402743, 0.7609678450670143, 1.0678304103552598, 0.5018790772612659, 0.7546631712587353, 0.7101027029347816, 0.8044346296063063, 0.9527065528197342, 0.6631169341768449, 0.868115804196495, 0.4331528029167422, 0.9557053589595277, 1.0761085596237123, 1.1229352517170708, 0.6858501416616279, 0.13016824653549217, 0.16251166427835603, 0.9692502204983716, 0.2717029522845105, 1.1175360614439804},
    {0.9173503120670903, 0.488556305780366, 0.41191611611987883, 0.8842511616332233, 0.8085103582353265, 1.1092542517366233, 0.7164011441979853, 0.8709312962337119, 0.02457198460608382, 0.763851740260261, 0.787807787699791, 0.806917978027478, 0.7702571389535177, 0.6874696347128179, 0.9948497791956411, 0.9001408992632057, 0.908312275482391, 0.644675672635923, 0.6910042181944859, 0.7512240902274341, 0.8072017574311271, 1.0579718005980205, 0.396937136250097, 0.9789524929575789, 1.0617287739731194, 0.661678600029222, 0.7993764053073439, 0.29454054641644933, 0.07192763527496178, 0.820362882646333, 0.2540860050101283, 0.8669280305758725},
    {0.9018918920906202, 0.5283692571299121, 0.1346172369866071, 0.9156137838841739, 1.0662375768080719, 1.071472027117876, 0.7700552432370927, 1.0835411779341066, -0.23384260618786992, 0.9858281036040182, 0.9126168587324488, 0.8091095276440947, 1.1135952678433638, 0.8062770934451052, 0.6895597861703597, 0.6130480017277214, 0.9947963295318024, 0.9398556384057508, 0.991433738368034, 1.017786079751792, 0.9348667273320989, 0.9296260664004871, 0.4682069101376643, 0.9293444817987523, 0.7456148123480574, 0.7024829786375455, 1.0579019666223062, 0.4810083935049767, 0.3028871020917869, 0.782783515156082, 0.3759874209094367, 1.0990665516022997},
    {0.9341144607531161, 0.5313899854788481, 0.2098902340775518, 0.7490657539124442, 0.9014294247711331, 0.8054705815990707, 1.1467511083560142, 0.9970005949937863, 0.1296131318857932, 0.722904995682187, 0.8764833299750646, 0.7900888628772802, 0.8715706867862273, 0.766633822721833, 0.6988972129310042, 0.8904193761635955, 0.8844230310942445, 0.4743326340100313, 0.9778078646997569, 0.8598468008381669, 0.8269892182817542, 0.8358887318255164, 0.6338706350046827, 0.5664794530406179, 0.7648549936499728, 0.9787937169625072, 1.0693441103266856, 0.013218580726151972, 0.15884138148062088, 0.8478958255687281, 0.20756624675096594, 0.8694756778422023},
    {0.9834326220319576, 0.643519271335638, 0.3533875869036967, 0.6672313369948302, 0.9698396712559666, 0.8253265588954191, 0.7632604506971363, 0.762454188076927, -0.10924490315947064, 0.6641867347792687, 1.0243539454539916, 0.6889506530137938, 0.6761945406166618, 0.743743478965186, 0.7491720817211635, 0.8357558859921265, 0.819099930696838, 0.6429103476918029, 0.774853493235737, 0.8959492668479533, 1.0887068479237052, 0.9325992237617866, 0.4627800593289852, 0.8297257947371582, 0.8509932873591757, 0.9620815454176639, 1.0468256680017267, 0.4601479607682257, 0.1626747024347001, 0.957687054232261, 0.39429172166108734, 0.7757316532954585},
    {1.008645687372684, 0.8966742550989734, 0.05104198526838005, 0.6214373461430757, 0.9320347521656462, 1.0907931301542555, 1.163015833930847, 1.0905589990925457, -0.039150092807450014, 0.9666626191504331, 0.9788305546025494, 1.0730683552022662, 0.7951345178080907, 0.949073648058091, 0.7263187588625463, 0.8916887377887779, 1.0745192690294147, 0.5349311577482735, 1.0041131583407439, 0.9257445781642065, 1.1111303834377297, 0.9199779965120778, 0.24465819872278782, 0.6752842519152389, 1.14046825722253, 0.9650846274948336, 0.7337461233203479, 0.31373329635337777, 0.4211803102731238, 0.8094020471641272, 0.14065939180530523, 1.0708856205934114},
    {1.0835099068428942, 0.4538735823650458, 0.20523835382549885, 0.9554522359527367, 0.704458383021869, 0.8572846873070934, 1.130570460613426, 1.1005390018788261, -0.09210813049934735, 0.6624962399372165, 0.8503473730889927, 0.7575332759484542, 1.015339241679074, 0.725559546447935, 1.019341132419948, 0.8696471760103125, 0.9968339556292918, 0.5073282612298072, 1.1305528401313012, 0.6933276537376711, 0.7491099181061542, 1.16335165475606, 0.6969199000862009, 0.809716261250785, 0.8800619772464273, 0.9260556300420126, 0.9280431873878139, 0.17225610444479955, 0.21220671601455487, 0.656834275280398, 0.2817547400006585, 0.9070338977676449},
    {0.8176714329276099, 0.5317574327510698, 0.24907371753476074, 0.8302269237075185, 0.9484038662127142, 0.9507770008370614, 0.6960479300013804, 1.03221634747767, -0.28155539900806814, 0.6200750208950907, 0.770850145003763, 0.7527425297515065, 0.9158765417461732, 0.6601387790954767, 1.1014674097797645, 0.8134238548114141, 0.8720616541987188, 0.5357647032919437, 1.0969848976260836, 1.018852785220797, 0.9477330179348118, 0.9653840326634643, 0.29390748289677604, 0.8830054878554018, 0.8322681227800128, 0.9691962433689824, 1.0671314523231508, 0.16436110446838575, 0.48101880069856523, 0.9739598216904364, 0.27871170801097767, 0.9352193392792932},
    {0.9894992696835062, 0.7297364229908778, 0.14786356088124636, 0.7185555930235168, 1.0050462428073168, 0.6731145228597635, 0.7100530004004211, 0.6508460513297631, -0.03762646544536992, 0.6112884487747423, 0.871920884130595, 0.6622874624896612, 0.8405973894974171, 0.7587140612804637, 0.9003574613807311, 0.6194525953132881, 0.7207602219040431, 0.9043865807351155, 1.0841755148472163, 1.0095408011724547, 1.0347124798742438, 1.1037999462095962, 0.3401699384321266, 0.9798592002425067, 1.0040181277427402, 0.9749798063007866, 0.73516666210714, 0.07092979391829538, 0.05820718742796199, 0.9187317773791367, 0.4164780422833966, 1.1240377352246835},
    {0.9494628394462263, 0.7525407316957217, 0.45922659055633785, 0.4779920167835269, 0.6628434456859661, 0.6516549301152612, 0.8083638382589762, 0.7620668959410415, 0.15896475273472946, 0.8198034352845014, 1.0983602291024193, 1.03198244791112, 0.6491891598168438, 0.6753070197939038, 0.6921183670277512, 0.4593899833767397, 0.9756311338452491, 0.6252001131002497, 0.8428799257828429, 0.9021311311175281, 0.9942419674887972, 0.6676474573027651, 0.5051598702964754, 0.6605514427568637, 0.8667877472354071, 0.6936095568486128, 1.043622012246903, 0.18353366844654967, 0.2075495790864031, 0.6330765133942619, 0.3015340455813478, 0.8593152293616445},
    {0.7274069365967099, 0.6260776669671605, 0.325997026871321, 0.5307486735070776, 0.8223956652351618, 0.8463585625633431, 1.0260423394107983, 0.7124220931753571, -0.09897017783962965, 0.8402300004875117, 0.8590638481103361, 1.1059315999769204, 0.8468695693946953, 0.7895389419132927, 0.7949139013366742, 0.5353166780886419, 0.9452145776611954, 0.7003789572888873, 0.9620171374694169, 0.8304887645615963, 0.934613065476105, 1.156081360974776, 0.3364123103194362, 0.7814815297012895, 0.9383427343492835, 0.9770822913990851, 0.6859947155581084, 0.22475302702678218, 0.1303523819610555, 1.0284194865804726, 0.49903937838325574, 0.7303204668283901}
};

static const float b2[32] = {0.8259203091495618, 0.6122172495768452, 0.3178040496209842, 0.6862594221288839, 0.8333679864875402, 0.829952850541567, 0.8728371011692682, 0.8611455971187372, -0.06165675809566181, 0.709037228406209, 0.8169955873305561, 0.7985552349950839, 0.8104487704091257, 0.8116877031322871, 0.7914669962187809, 0.6642795616009906, 0.8199510090947933, 0.7144938953189043, 0.8868073970162479, 0.8334614097135744, 0.865330657917174, 0.8626860866541001, 0.4227113448915314, 0.7558622135797536, 0.8681319534418425, 0.8257977487286717, 0.8842283774758241, 0.27634882392996307, 0.28949335836266304, 0.8179726819141407, 0.34635541275918735, 0.8494641831686124};

static const float w3[32][16] = {
    {1.1750758591672437, 0.44785847287334724, 0.036447366863826214, 0.9469033172635098, 0.038712468370247055, 0.9202658438157585, -0.1517760114164632, 1.1637374444052169, 0.3482490250991934, 0.7178180682151243, -0.18063201855203317, 0.6358300853530007, 0.9974557070072136, 0.941462851045831, 0.7371986022159097, 0.8177729375003956},
    {0.8226881704241086, 0.6691671656181712, -0.2999911922162663, 0.6107646102344865, -0.25462483235193656, 0.8002428683930123, 0.16264058128611145, 0.7694707207899851, 0.134305761977486, 0.999334827072964, -0.05136775324565964, 1.0789901278693521, 0.5341248186704244, 0.7947521402227579, 0.5717328022276716, 0.7474146496984211},
    {0.3010210947122147, 0.764565965108307, -0.2221114028105463, 0.2089125432311457, 0.11203334203754604, 0.1798568716374101, 0.05061453824875366, 0.15089312225842094, 0.5418582374863676, 0.18442173386479468, 0.014537576784014409, 0.7742020869089589, 0.455771750989116, 0.6771134034224265, 0.40285643870570226, 0.38170140826276483},
    {0.8333296281719359, 0.46791296908841573, -0.07178842782997774, 1.164128241786563, 0.1527260537719007, 0.5388014994364688, 0.3051498982996045, 0.9533051625558562, 0.3376193194743137, 0.8340662730544174, 0.17049026020364375, 0.8805565588894365, 1.0491254901812697, 0.5943434633738115, 1.1426797894279375, 0.5458105900247924},
    {0.9467929133960551, 1.0853237029034277, -0.3243919852329727, 1.0848061188110147, 0.21679944239464743, 0.9227335701519566, 0.033730603954420534, 0.9446965671097745, 0.11546780107126592, 0.8339626074678786, -0.3258380016645233, 0.7005568297078076, 0.762441290599672, 1.0662525877407085, 1.3073670705614766, 0.9573937441478355},
    {1.0723202434181172, 1.1132297659787855, -0.2868613367218184, 0.8850789181400252, -0.17510984254153283, 0.8603783444351008, 0.17855142709796668, 0.763969614089108, 0.2619836215554844, 0.9650004024012043, -0.13297339116674864, 1.159667909512699, 1.2194272357417668, 1.2802818416280994, 0.828851238460753, 0.686657620247969},
    {1.1487782156052075, 1.0024010272352815, -0.14269629805327935, 0.5955290621436528, 0.004322496820288212, 0.5165034764227626, 0.20176923905951566, 1.2339846496622962, 0.3900246276376795, 0.8951654522810608, -0.32549107116174525, 0.571021228873122, 0.9814245465964158, 1.1837290343564388, 0.7405043445440436, 0.9809692181407454},
    {1.1564299116979144, 0.718526639645568, -0.005702131534884078, 0.6954197090737504, -0.0022855692186133864, 0.3403242954987378, -0.13075084576756058, 1.132647691212566, 0.10760642441180948, 1.2653269387767974, -0.030420530256417975, 1.1344606166228843, 1.2010758641976773, 1.1870660156333719, 0.6467434925375071, 0.9128902979410436},
    {-0.2019820384705747, 0.2611415586290656, 0.019355162101968488, -0.19532582048307615, -0.337108028140149, -0.07677965942207492, 0.12130869251042181, -0.2663866708776475, -0.27373932107862714, -0.26167224756011165, -0.2493224851784285, -0.042969732886579744, -0.029345856323619912, -0.07216462901812346, 0.07303386940600241, 0.1692945995779793},
    {1.0319563934657499, 1.1202064285310718, -0.3136128745622073, 1.1393249347745849, 0.2005837736326498, 0.8834757075621339, 0.18274532380420722, 0.9997223044525702, 0.5406774979624605, 0.688538672986959, 0.1312842688525539, 0.6765803047017704, 1.0672810665027663, 0.7862398817452922, 0.7731583003026528, 0.8860840590590205},
    {1.022331848668753, 1.0789557203445292, -0.2597142529473315, 0.9625740138908208, -0.26214901417674535, 0.8048708414724768, 0.328627351928937, 0.8685864122970692, 0.40492765588756247, 1.16035973600628, 0.08310715134103987, 1.0130693916631437, 1.230650143800874, 0.9159830710127181, 1.306438263335965, 0.8695780323509261},
    {1.1714440545661438, 0.81689463691127, -0.2285640398866606, 0.9043481048474931, 0.014670046696789951, 0.7268581808793166, -0.2928447273014879, 0.918630910018769, -0.12383177197882708, 1.25802863332939, 0.2249351414319104, 1.0944642082770006, 1.2072470055333417, 1.178406729182769, 1.2003708558105173, 1.0049061694579084},
    {1.2281514014798165, 1.1825849039750316, 0.27044169679636915, 1.2698469618469783, 0.29263303474063973, 0.9787254868963864, -0.33419769387881976, 1.1516012617213818, 0.3372916669575095, 0.8754566249734033, 0.05596656019563047, 0.8276920721172767, 1.2514123669684212, 1.1210554175522076, 1.1886349037302748, 0.7361358669127521},
    {0.9203152828508708, 1.0040917767397046, 0.2745873395268759, 1.1436692907302508, -0.2223583590792319, 0.2827538905321411, -0.24500328081144895, 0.9299191797268014, 0.37937506187083847, 0.8260012512836982, 0.1770185321302078, 0.9134031645111945, 0.7906100113058131, 1.1627928404928147, 1.2399839909440598, 0.8768482216431152},
    {0.6691453938168214, 0.9611572601540591, -0.06921623281262536, 0.5845574738151911, 0.06719014363773218, 0.7475616422026523, -0.2065935352833033, 1.0296740138665539, 0.43812657890293344, 0.8205407138435212, 0.32705049130029945, 0.8118753207779067, 0.9784078004905549, 1.2730363592021516, 0.9739504212170069, 1.1613483076898654},
    {0.6244430887573358, 1.0170336459916653, -0.23691925250833767, 0.731510740971947, 0.15474767606830558, 0.5743439081480631, -0.10869992262735403, 1.0860438516789837, -0.04463103416174708, 0.774860354935323, 0.3048420020127053, 0.6860455285870352, 1.1707292675837386, 0.5949004811790617, 1.0555851979421018, 0.884274335832989},
    {1.2531824337852437, 0.6494244183753267, -0.0033846607676946963, 0.8458021549277145, 0.24129196679788079, 0.2697018629468345, -0.22610120301192063, 1.127115343238525, 0.20765340891829265, 1.0442744325207032, 0.16706441132540123, 0.8327350610679148, 1.0134000566420196, 1.2145585846264402, 1.187543709359294, 1.0038331898950725},
    {0.7012759865520337, 0.6821382679637107, 0.10850539554020494, 1.042102092185952, -0.15534123236998912, 0.6992523812901049, 0.2892584298146232, 0.8580297240837037, -0.009355930205347123, 0.6173363675804586, -0.19285221467450928, 0.9955950545026557, 0.5498542076763584, 0.8696768878591807, 0.8728599265364094, 1.0685132808828224},
    {0.9727770827322646, 0.7422508755910386, 0.278196303834676, 0.9306239236129115, -0.07194893507432461, 0.742917588964282, -0.0436213239997608, 1.2488760364132991, 0.3073588327226283, 0.7999121465906904, -0.33429399208713145, 0.5419602917404281, 1.1738033112278772, 1.0597648116347462, 0.6632808577652716, 0.9952357717852383},
    {0.9343414984802255, 0.42366835010401876, 0.07973747549254412, 1.2295754590678958, 0.28832195901390084, 0.6882467674201954, -0.30301284916152516, 0.7416399397566956, 0.14779519459061077, 1.1289893195674394, -0.3201938510387985, 0.5295677324838662, 0.9084367056088448, 1.2798397802696655, 1.1267456222892345, 1.0200206913976089},
    {0.7720421757899659, 0.9578649459404751, -0.17218481830452423, 1.212936636273038, -0.2639587207876938, 0.5008632239420923, -0.07826982252873096, 0.9354154972261592, 0.1661901231920188, 1.1992451577957381, -0.10910814938918992, 0.5180154310735534, 0.8846598701391242, 0.7896685521014294, 1.1096565677267762, 1.235102615575107},
    {0.7043605131120778, 0.5155922458216401, -0.08179197664138695, 1.1669403346741647, -0.07339154805543245, 0.6627140205432528, -0.04310283031356555, 0.9473695938618316, 0.20599096497585073, 0.943621518913103, -0.0717011503691953, 0.6782097917075687, 1.0682636861887778, 1.061242186698356, 0.7099058424337985, 1.131775105776655},
    {0.3758609682494766, 0.46920416892085237, -0.251848492288363, 0.6163283967542811, -0.3416499913458612, 0.7366465243068601, -0.17460472348844022, 0.7562872473962269, 0.45776776134403496, 0.5644692833300695, 0.15337856504733827, 0.31146917028348337, 0.7234483475399485, 0.49017271548426455, 0.4847318696187053, 0.722058843998352},
    {0.7666818793327519, 1.1350236722678215, 0.20942676952623757, 0.8901304129565673, 0.2762369168938607, 0.4787854229445403, -0.2577782121410412, 1.033739718652137, 0.5045174870764412, 1.0760801755704432, 0.28546819517055894, 1.0615729435529835, 1.0599383657064312, 0.6249689290186914, 1.1721629084095095, 0.9687751590378493},
    {0.894303732621821, 0.5000339612004323, -0.2534082840764284, 0.729967347343396, -0.019208467166616963, 0.5441417724165538, 0.31025979802476283, 1.0399960265266923, -0.16602552390369874, 1.2867034983731631, 0.024233322944572217, 0.9649430711420531, 0.8973367500677466, 1.0638191145279818, 1.035641699262632, 0.8663778191128036},
    {1.2234926864762472, 0.5409304361152398, 0.2516922961421468, 1.0027451700437633, -0.34090709915091266, 0.6702253600812708, 0.01587436029501876, 0.7128171495940194, 0.18525549668659158, 1.1027978454844292, 0.117898026722824, 0.7973155616599227, 1.0393577388535284, 0.9292466306113376, 1.275816668450594, 1.030904858549223},
    {1.237317669176703, 0.7352759466966636, -0.12198990566874629, 1.147893456890679, -0.317796390161971, 0.27037247113910157, 0.2886330883359637, 1.2010213896404425, -0.09837720631601085, 0.7187509973437589, -0.1339471165869297, 1.0749688635795558, 1.2855534904428647, 0.9131077477744943, 0.8291912577974423, 0.7358353653110435},
    {0.7171658389201532, 0.17419316446441044, 0.08630791303942377, 0.11080743529285916, 0.2493719015864091, 0.6463606270334199, -0.10629242105193357, 0.2710229549077265, 0.5607449684044884, 0.20226917078967288, 0.13783552393881457, 0.2533381164597561, 0.43100336464709915, 0.35405633113735646, 0.4058706057934666, 0.25929856985241295},
    {0.302315276629544, 0.5783001622093237, 0.016910012661785812, 0.5343721654209035, -0.042787177735576526, 0.10268166413864091, -0.08295834213017124, 0.6783869112101146, 0.15272350964145312, 0.12067442443439001, 0.00761557464129636, 0.6935492587173732, 0.18036017879306507, 0.2538718119355114, 0.500087987244057, 0.775675495555026},
    {0.8354323574429241, 0.789386883255187, -0.31189005657522717, 0.6861709880523826, -0.25613409200798504, 0.6568318582625716, 0.1990292548198725, 0.9242382215729141, 0.11866042487269293, 0.9283494734095644, -0.035579416467549245, 0.8397494436148117, 0.8292326399876653, 1.086749107356504, 0.7812100029553949, 0.9433858513918959},
    {0.20016122218353283, 0.35846414135493154, -0.1899021547252097, 0.7206498486813745, 0.29992337745194514, 0.6343422679814421, -0.13988776364846167, 0.7504649449842246, 0.19883678380809428, 0.3455241975871167, 0.11495596573688147, 0.6189741748177247, 0.5724834766235698, 0.17590452207788237, 0.5786927151774492, 0.38008837874534895},
    {1.2545871345506048, 0.8546894727023153, -0.2447692439482284, 0.7428119563053084, 0.03233404853393656, 0.8657531110827842, -0.12417270231269784, 1.0478920166508394, -0.14519596326737746, 0.7713749579141681, -0.32741871529480626, 1.0492197781523396, 1.1942963621675367, 1.1451191877370983, 0.9378695639561565, 1.1809116646495648}
};

static const float b3[16] = {0.6244960247441165, 0.5820234298655962, -0.0406078972844933, 0.5780659384361914, -0.06885604876026373, 0.4612121047309199, 0.016228225735774218, 0.693082868947044, 0.07875042919844806, 0.5783487131724145, -0.018821778241334797, 0.6059574169162264, 0.6391190047500127, 0.5703927773022859, 0.7217253841722263, 0.6834970821431968};

static const float w4[16][12] = {
    {-0.525163146606147, -0.8133734643815842, -0.7902997905623464, -0.8859295687558373, -1.0563424731838735, -0.6216368704826755, -0.9961533162046247, -1.1803363954579542, -0.6515010000126795, -0.8949208291369433, -0.9692240005091725, -1.0273186371673446},
    {-0.48785860542697973, -0.4325552781716576, -0.8924732173357981, -0.5100034360412502, -1.057089708791038, -0.715619724825707, -0.6966413780337503, -0.9441915159981344, -0.6072942643985267, -0.2793915968316287, -0.7498108471765924, -0.5304280787559881},
    {0.39241419753084084, 0.012471136543771537, -0.05974178448843187, 0.2773438665713532, -0.2174234474716227, -0.3438153281700539, -0.10882942659034175, -0.4894706411915778, 0.3401515770346912, -0.17053614027636943, -0.47592766181693846, 0.34701015295188276},
    {-0.964137912808085, -0.4849702267526291, -0.7222695573358641, -1.1209285265215763, -1.2529499838698914, -0.40211124038238194, -0.34008492924690453, -0.4693293976239663, -1.0347933694190041, -0.2276466832387932, -0.8936290721735108, -0.6257963993519849},
    {0.19107637157920285, -0.027898616845240178, 0.1811473015751652, 0.39323321217832086, -0.05816389050195306, -0.47322102122741494, -0.2092853604665461, 0.14811109620018653, -0.25096228469312115, -0.4460678583694799, 0.25451898831516245, -0.24790384509022984},
    {-0.45015795382728163, -0.40623301553575497, -0.8010202186211491, -1.073934391379404, -0.5198668215558183, -0.32229304500689854, -0.48801520792318925, -0.6373226260733494, -0.6469934459594856, -0.8122364095759188, -0.40769544991770507, -0.8658979813278409},
    {0.0744058854671014, -0.37318074897923437, 0.380557989111272, -0.29601962649755187, 0.13400749375600632, -0.15259730505924507, 0.18043213084125356, -0.2624816586997269, -0.09696545795033157, -0.37595122561534544, -0.09693805369306309, 0.2372309294904061},
    {-0.8144220412117292, -0.7469909131435942, -0.44401048926049547, -1.1447380728207055, -0.8679983849992265, -1.1822007462202107, -1.0879437127733684, -0.34240813371815265, -0.5561229557564145, -0.9720670040971855, -0.3633080653493346, -0.9809847491253015},
    {-0.0680191743359771, -0.3877396818736833, -0.6711991211971671, -0.1304616256542648, -0.39054703418274833, -0.2420970276811818, -0.3352303537781478, -0.23031180715259808, 0.1441630753038164, -0.23731966299512325, -0.28446044051384883, 0.06624118042831324},
    {-1.33307648721792, -0.7462932451708006, -1.0812208154715595, -0.8196172603955283, -0.49498570778759626, -0.5985701612825036, -1.0156955113885915, -0.7506523914287052, -0.8942926765137326, -1.016046009382446, -0.3857793606961292, -1.0790018683790525},
    {0.12544099241265652, -0.46139599008168813, -0.40909108165114244, 0.3392362167609478, 0.19282352933154404, 0.4181366064675659, 0.2135522433135728, -0.15628185451928625, 0.15839059978168873, 0.2354172212179694, 0.031345011730400905, 0.1440674158658559},
    {-0.6258374757854561, -1.0058727067807114, -0.45941230528982285, -0.39245246779636017, -0.3838277843105942, -0.8528142419850062, -0.6415222182496516, -1.0010419519973637, -1.227165048038318, -0.7266257154447597, -0.5526280585827067, -1.1875625126659821},
    {-0.5371392753220302, -1.1821389810609106, -0.7401139380619043, -0.8586154434056675, -0.9545532064115041, -0.9961107878449031, -0.33901561903753985, -1.1070055453515, -0.8714841315830477, -0.9659818551839069, -0.6537072355530131, -0.31772023490738244},
    {-1.306242006078339, -0.6303256494284855, -0.9633444112368806, -0.5086175060542762, -0.8041785210572141, -1.2561873777457597, -1.009091217990501, -0.386178430714397, -0.7271298832148781, -0.9656474735676982, -1.2372361152692468, -0.46574092602894074},
    {-0.5939002101973946, -1.205536968388781, -0.972310388333042, -0.7905185635024959, -0.5491846828451966, -1.0090034113916315, -0.9066081033265853, -0.7223761783553733, -0.6784472926627357, -0.72686260923959, -1.067710793212046, -0.5045937719605766},
    {-0.873919806571546, -0.7228097860277444, -0.589412661902684, -0.49989966398723473, -0.5417282449894767, -0.4192914061389281, -0.9208606626087876, -1.0526210030802596, -0.7862466833934797, -0.8800689626290021, -1.182593907994136, -1.0822842717060928}
};

static const float b4[12] = {-0.36805669268219293, -0.2669933123226607, -0.3688244364123639, -0.2540391225596306, -0.27981399363841125, -0.34243484141201525, -0.17859761330960067, -0.27774959196972876, -0.3233134866476553, -0.3152015417711259, -0.2644966183671375, -0.20602275085228158};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
