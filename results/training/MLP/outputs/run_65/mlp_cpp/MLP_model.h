#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.24079287650659875, -1.3083172710834101, 2.835910780690329, -0.9898662821116797, -5.075848468201502, -1.9102173730615015, 2.258433406641067, -1.1058390393574504, -0.33415232091061425, 2.716608201138097, 2.067028591439767, -0.3297867693277385, -2.6852914105524617, -2.0162852343785853, -0.6887629711170214, 0.05170029128727097},
    {0.17317280600124635, -1.4019021814244672, 0.8997781877354629, 1.5083342400393287, 3.1301066113336518, 1.3832716600499653, -0.6340510199801499, -0.3675484701327968, 2.986591368971221, -1.4286101319815017, 0.5172768594934307, -0.4079145375714821, 2.1613964072419116, -0.04089166441067551, -0.6982849240507103, 2.19169497476644},
    {0.755089819787094, -0.7226482690426556, -3.935608230013391, -0.8193519710517772, 0.7895211907357358, -3.0178624889106143, -4.062780765243004, 1.775186071501241, -2.693716871463706, -1.568213615091739, -0.45756279721914517, -0.0021432691125883446, -4.7468289710482825, -2.392255327708407, -2.40768256286162, -1.1208107496587325},
    {1.09612076717571, 1.2276788446419429, -2.529674696713797, -3.0160666788739245, 2.4283693692058117, -2.9687085311011936, -3.2740167861806726, 3.130216609661738, -4.904443506239463, 0.19491850634601068, -2.107230036812984, 0.33884907818940413, -1.7998045180541757, 2.2918621979557336, -3.1742837219389393, -2.584981851852685},
    {1.7729426395681174, 2.0405007345249504, -2.890003417812842, -0.5698668890771733, 2.8369511950538726, -0.6447084186299888, 0.25862996096453544, 3.5709254830802926, -1.9580555133871602, 3.8946903601610696, -1.06038875250322, 1.7662443834144783, 1.4256183629885153, 1.0485658178727122, 1.3617666902466974, -3.368550515946172},
    {-1.3628901766205614, 2.5015186229540647, -1.7152677687753264, 0.32733340005270106, 4.105764811979893, 0.165344303588946, 0.3704216583788831, 1.630696551174231, -1.3473254325030846, 0.5398919056405669, -2.136714804537585, 1.2518308090307395, 0.9187464814693359, 4.053442043147896, 1.233829193344207, -2.166931854891382},
    {0.288044192574261, 0.9156703527400871, -2.547575976037472, -2.056060555298916, -0.7958709929099079, -2.58715598834026, -1.0797183916873732, 2.327531372399025, -2.561407121921697, 0.7810762774581175, -3.805846688017939, -0.7578023034210357, -0.07063048689254578, 4.332756684996534, -0.871744495137517, 0.7702342570614358},
    {-1.5544710390788739, 2.4750889694237905, 0.3069047539047978, 0.10419058517729571, 3.793250461146876, -0.9101067450991266, -0.4628048139487195, 4.852234510268729, 1.6029928474535606, 1.599310242736721, -1.6022470364918306, 1.6903066639354614, 1.430669372384041, 1.206536181852199, 2.4998948098643745, 1.5158663572057847},
    {-3.0372292920725545, -0.9237152993828945, 1.9609037875522333, -0.6530616137281202, 2.30508985230127, -0.23337656556810774, 2.1550250203648185, 2.061287171705387, 1.1975895937310568, 0.4838175837720098, -2.6230098475826793, -1.1805326487090275, -1.8204066651982904, -1.04475314734123, -0.14611307898228995, -2.840942211101762},
    {-0.715215094659919, 1.068759939197532, 1.789922092044158, -0.6650582216336125, 2.1596337949354756, -0.8489860293625887, 1.3285060879147168, 0.7011606777359672, -0.40296254231068324, -3.593438695702114, -1.781767070922211, -3.295727112136429, 0.8618437647912616, 2.2302728063686397, -0.15078029803813311, 0.9692926149841523},
    {2.2715297127961556, 0.34373077910885425, -1.076838052847159, -1.5040832702121478, 1.5645690909961678, -0.7697102253701549, 0.05670041769794667, 3.279763750224085, -1.6480927621713801, -3.653184620827344, -2.1370787179970656, -1.259366273077516, 0.9336796719863792, 4.096385744022585, -2.8262029840123803, 3.248025649709351},
    {1.158912294300912, 0.8403690929007888, -1.417968198643212, 2.058171454140837, 1.8506797034837326, -0.09373281401835634, -1.5199780389660793, 1.4763642198014524, 0.5165923051055866, -1.632536640785623, -0.30820163530981753, -0.8885841824546726, -0.24326478375699143, -1.826992383134443, -2.483745689518273, -4.253950538548499},
    {1.2134495965878616, -0.7722447571758787, -0.8640296805854398, 1.8621566151692597, -1.1169761480044016, -0.8664207318818307, -0.8109092478498369, -0.5906574603566742, 1.8511091536091326, 0.10655090706360738, -0.9647744219992529, -4.368167648903121, 1.7915110995414927, -1.9553164936067677, 1.2447830669473239, 3.4969750586586614},
    {2.5296070276596256, 0.3959395195966286, -1.8913241196219615, -0.7193033000783012, -0.805348578949998, -1.6464431187964692, -3.581156175815342, 1.2771177413487202, -3.938578382409972, -2.082193690711737, -1.81564791814219, -2.894332135542943, -0.14324458502674367, 1.887225384214934, -0.15508826202508885, -1.112627195471257},
    {-0.8214181004402983, 2.4178812222876127, -0.6219968486658829, -0.4114108885035127, 0.5134638110556924, 0.7139022426988788, -1.3783448783438612, 0.9190734601685225, -3.5257632092821414, 3.1058168109215707, -1.6421676469627533, -3.4645444323328216, 1.6168876555768372, -0.840355614471741, 2.4006902394210266, 0.747529717272338},
    {-1.9190991209488897, -1.9589510448973273, -0.9423222040483027, 2.9619253296545316, -3.235894138266298, 3.5000147552716987, 0.7556967066200773, -1.0386747660314404, 0.07711644299259023, 3.4976943562630196, -1.8539391625568145, 0.19900375682015825, 1.4943791026750206, -5.206171176318098, 1.987479333704868, 3.0794409303000188},
    {0.9531868356049751, 3.09458350022232, -1.9000683262736706, -2.160236055295933, 3.866696314172982, -1.5960312764046538, -1.7724017775298848, 2.505683064909196, -3.758955703738724, 1.8026686520306787, -4.028116717280872, -3.9767294446234756, 1.9547885602577788, 3.415848625467338, -1.4837992283433212, 0.9866694972108356},
    {-0.2747392553139464, -0.6410138433954777, -0.5046921488648681, 0.6439598266445218, 0.13950689029576038, 0.25378768403415874, -1.6329743255595903, 1.4996045325459981, -1.7984140460009845, 0.17522875618032788, -4.3036776163697334, -2.9557959555802253, 1.8014735472052505, 1.9377328982802768, -1.0238398413375478, -2.412820771356973},
    {-0.41475202971092845, -2.377061488377713, -1.195676246294707, 1.0398001452930514, -0.08765096442184185, 2.104641346189605, -0.9821328073618277, 0.24564784039275983, -4.1063143516563345, 1.7431089854318915, -1.5752035580115684, 0.8993619305867008, 1.1161234831778923, 0.5900713684421043, 0.9160986143159684, 0.9986305118250218},
    {0.3251544590391005, 1.0310285969186277, -2.3334333368225693, -1.3256537592626159, 0.37154183149224185, -2.439576007486615, -2.274222547709785, 5.9869365444567375, -1.9339388945263323, -0.8053067476751088, -4.247727365086848, -3.894411510136909, -0.8282526532659413, 3.7150682449539407, 0.6149981048970872, 0.5869295197941101},
    {1.2524582744825254, 2.280411083784516, -2.861720059398708, -0.42254634541643027, -0.8909098559947816, -4.094526222851763, -1.6499799807820863, 2.243314634757365, 0.5004872288509044, -2.1555011163269784, -1.4295735972028885, -2.5298970027214414, -2.894258532055561, 0.40895147970001, -0.8203297586988884, 0.7289124877198503},
    {2.636916207589316, 2.63015843738196, -1.4290291904263956, -1.913697431952303, 0.223760402218225, -0.5147726880240832, -2.2686632261289668, 2.6379463953202738, -1.8782354088417754, -1.2364826280136958, -1.016488672256609, -2.063270997178679, 1.7707789667698213, 4.934167370991458, 0.7196554384148744, -0.49831023610308467},
    {0.8857337336262447, -0.3329485466101781, -1.293674001985715, -1.3009860497220016, -1.460730742272973, -0.0902119875218425, -1.415971327660793, 0.7818929397018007, -1.394852877545481, -0.7672581555672211, -1.4465116411280203, 0.17276632747131201, -1.1626162093049757, 1.2593958789775086, -0.05835836142703911, 2.6881186676627884},
    {2.8911276444470806, 1.3330346524762082, -1.2226800557196051, -5.1247068969392835, 1.0668092712273793, -2.1831181158782482, -1.9772821327587162, 2.7042837847592165, 1.1060648193010354, -1.3789160707805346, -1.1059293519541735, 0.3154203893482729, -0.6280156437579802, 3.578695563279757, -0.5987631548417716, 1.9790023955800586},
    {3.7380250616945707, -0.056281190455905745, -1.208798376939277, -4.891977682105506, 1.4507795856882284, -3.5159389019092018, -3.3494571244346703, -0.17845387721896497, -4.904585136783888, -1.1153375889142791, -0.10993384178738226, -2.8024161550119686, -2.7892152011841262, 4.799674955837054, -3.701855587327494, 0.05583260374810352},
    {2.3604537729103514, 0.2516425185727153, -3.5516938273691068, -4.0807768745348065, 2.687704684584056, -2.324868279873714, -2.814764858938255, -0.07192543279374666, -3.4531206423283334, -2.4525968775785167, 1.4887414482159023, -1.212021582524701, -5.063507881685254, 4.340315904083314, -4.27284444798876, 0.8618856479524063},
    {2.6828125008625743, 1.8926000953691404, -0.8674032792558469, -0.888357417142104, 1.7186369093961058, -2.731281058478907, -0.7408303939717253, 0.18264659206082662, -2.0427725204118548, -3.4107575066435043, 0.44033797198086183, -0.305826590553094, -0.9325090124091341, 3.2050792638225065, -3.757829255168338, 0.037419000052045556},
    {0.7627158310519586, -1.722028727532498, -3.3241427518979147, -2.970334470123345, 0.12129277313290553, -4.350670773339049, -1.8029971339253974, -0.7918101359432839, -0.5846919060706138, -3.9960204531447894, -0.3691723926243472, -1.902935464200983, -2.271532354542144, 1.6323978194283082, -4.047639868312855, 2.8404807029393746},
    {4.260111990672818, 2.8513213363287813, -3.6161827312568313, -3.3253588077483225, 4.018015693167631, -2.805094224845098, -2.893573963580375, 3.21314291742685, -3.0847718520507, -3.9267638465624697, -1.2315455086155795, -2.841390830383367, -2.8332979209710936, 4.753536754178256, -1.1601495222774556, -0.730985935189487},
    {1.6433446589104785, 3.789619483636099, -1.205091915882898, -2.6869441348218492, 2.064140511421399, 1.1956414612948176, 1.0920892706451035, 1.198396506363832, -1.4459066986156908, -1.276949055146227, -1.0491044999153538, -1.589275217157319, 0.5213808923754059, 1.1306337879297126, -0.42793089758302977, 2.1819397438882397},
    {1.5635588333744352, -1.0748339750148348, 1.4835541054466088, -3.8916340747439553, -0.8530718364212205, -5.643294172498892, 0.2459535427851885, -0.18624392934804157, 0.02920614239688331, -0.8281864394066577, 0.7969477993802537, -4.129019155264145, -4.838138926908986, 2.145235418547503, -3.3888454152148646, 1.811430825146677},
    {1.5209269447785994, 1.2524828708130569, 0.7939049795875789, -3.740572015332736, 3.336535983826343, -6.06368192026668, -2.8795736962445195, 0.8404784446040587, -5.193792027855349, -0.1820897416578761, -0.04325747487310018, -3.924997217663472, -2.478512964778592, 2.6148127568280612, -2.438906031614799, 1.4351089275189914},
    {2.2209201144662836, -0.3168665615717567, -0.335117724096114, -2.8633153939830964, 1.2354413556870651, -2.102523028616129, -1.6138839922258714, -0.07645792036591646, 0.03460862447974005, -0.05842460614376978, 1.2016869206164862, -0.46511155720166086, -2.770089554854116, -1.7049431084121967, 3.3158029023214826, -0.006171714267080818},
    {1.6267805754733164, 1.238366913910062, 1.6529561655035019, -3.0213570126335934, -0.18766451956745747, -4.101111273454644, -0.45303901230215543, -3.131764919190683, 0.4963569704730516, 2.9680524025553128, 2.478963081041684, -1.9106048728923313, -4.612102850256393, -0.30767884972392034, -0.1659024503793224, 0.5274846142382908},
    {3.3016021543261544, 0.24286953186436447, 1.1934858661029273, -0.5148181197987217, -1.0480463409731597, -1.9072558144134508, 0.8903085025187405, -0.029390071756271934, 1.2050458247331886, 0.3948903430654673, 1.2422783584356059, -1.497991951815647, -1.456095880762288, 2.1569271156852317, -1.0263120876068221, 3.227328240605113},
    {2.6791046598565282, 0.9742254499291155, 2.2035270200051644, 2.0138759373007526, 0.9643953275835319, 0.47984162044540046, 1.8292370172704107, -2.5445636525062048, -0.7744525963096027, 1.3391964476207294, 2.7272740010882135, 1.8119339954869174, -0.2785427084095886, -0.6452308880120805, -2.1832818854465272, 3.3374358300788436},
    {1.0707641064938167, 1.2324232106237636, -2.8876196621117103, -0.8391121399690944, -0.9899870994466939, -2.1441296656909254, -0.55040598833087, -1.845500838115526, 3.4018704688368047, -2.4089965574394987, -0.3758816930034814, 0.8931989753999979, -3.061482745861746, -1.5254891760047586, -2.8807361003830523, 0.5672013128639305},
    {1.9042717574313908, -2.8184107309304203, -0.39082176644601047, -1.0953983909629128, -0.4268098484852458, -3.779037634024909, -0.9236712220233726, -1.9448155267186695, 0.5965450985036641, 0.9758030597724531, 1.748131422585287, 3.1400451231052378, -1.7727370055599463, -1.5428923283847613, -1.9587061943734054, -2.0736157361030654},
    {0.287286788061183, -2.4598974658043544, -1.2681334407209217, -3.028874018271348, 1.4418308223757397, -3.4096749619425575, -1.0648181227230467, -1.9223952762002976, -1.928519028385158, -0.9697491342485598, -1.915559990579538, -1.8779234131574638, -2.770091280429087, -0.9218466827347173, 0.1327512646234867, 0.7578340354817361},
    {-0.4141278721022178, -1.770240582204885, -3.362126688799459, -0.9258619529611095, 0.7581500248506341, -1.9192631149802748, -3.3719767200849926, 1.007549551955142, -2.44103438512588, 0.5358403398273095, -1.2510600525190638, -0.8974804991211061, 0.1207798066267268, -0.06060074199857652, -0.8056167593680864, -1.983935650840862},
    {1.7013989778377936, -0.43585594891688567, -0.3361325726816964, 2.177142614020371, 0.057312639634858664, -2.5212990081893927, -0.24944435855039507, 3.9292945359438387, -0.20448285065877972, 1.4058129644239754, -0.18389002828473366, 0.871561986841197, -0.9710361720063276, -0.08315780769213113, 0.9994866870815262, -0.4693753770723746},
    {-0.04683198553591392, -3.2652855864914447, 0.4793890194835757, -1.4039906249360776, 2.2468274669677326, 0.15071484540230826, -0.23423689758794852, -3.229159599327849, 0.5316454417975623, 0.09312432188424456, 0.21638128477055873, 1.8728623682275052, -1.3621717550069445, 0.34910404838781683, -1.8693479085351952, -0.9248029079108082},
    {1.6731788063109563, 0.5090001266065264, -0.5322936439963699, 0.5742293883032948, 0.13917305484073256, 0.32890462957748373, -1.478966274007311, 0.21379656224633295, -4.021007411866699, 0.012019317579030403, 1.5883947726394356, -0.6019001069097167, 0.20773119618313987, -0.8816026037246685, 0.23005729623479698, -1.454936907577462},
    {2.5141924050079467, -0.02236421773489504, -0.8441780214284477, -1.037021664300882, -1.2913866051793002, -2.09775242514148, -1.0615248241356339, -0.0396688291054989, -0.7832376274824758, 1.2173513151299522, -0.553468069312509, -1.3129611408089004, -1.5642653964962043, -1.262584387942663, 1.6538485935477245, 3.200573171371771},
    {-0.16057503070593718, 2.7395708322847336, 0.35025009114864236, -0.6583252978089663, -0.27368693428368335, 1.1621351613038424, -1.014310578774917, -2.0833633732546013, -1.2867108849682087, 2.1073225965000724, -0.8790706501244508, -0.1141645382011659, 1.6178204289671674, -0.7360288885897276, 1.8647313431141803, -3.3668000769082123},
    {4.988833165692183, 3.024203707001525, -0.8824169941056176, -3.151037352362454, -0.3945090022517914, -0.5733828214734195, -2.049882918675246, 2.2830104519325607, 2.7226956090328494, -1.8670314227556914, -1.3091122423215638, -0.6275225075785504, -1.9818516521514984, 0.8356262951552025, -1.0435675747944935, -0.9308475523499623},
    {-0.30571153100277243, -0.49456599359731446, -0.7497120140247393, -0.660401562226375, -3.1260563436751783, -0.20143706290403376, -0.48969677965026825, -0.5148770067997633, 1.5667669895167207, -2.7804187668133693, 0.8919158714275252, -1.940098967137367, -2.2943505152439605, -2.4835121320758398, 1.049906905573023, -1.2871908610676692},
    {0.23941700104601743, 0.44420902149201474, 1.511324035906972, 0.9423116014084878, 0.49726404585312933, -2.3933792692093134, -0.04690883888978123, -0.9172401621036149, 2.7378055143450637, 0.3116286105432248, 1.7376128042670385, -2.031016782186898, -1.2723814894263081, -0.27114306891942364, -1.2339619929782613, -0.44636011499587935},
    {0.01642637183999269, 2.3726221152366245, 1.9218423993751372, 0.36817098226721373, 1.4811087457412653, 1.6487555010967956, 0.6005388968740959, -0.19912525717065332, 2.017694045447329, 2.3922008573010767, -0.3787918989703906, 3.183773992385518, 2.820950362863151, -0.33337176115925893, 0.36945690246051666, 0.17974728715401547},
    {1.5167803814422753, 0.7220195501515896, -1.9583278207987345, -0.8388527486089109, 1.7496472364002986, 2.1432512843484073, -2.4782822217824276, -3.689259468667823, -1.5071687589925442, -4.524376042949695, -2.6898446008365, 2.762981888528858, 2.493728518119513, -0.6514390273449724, -0.5806192942555427, -0.25425089135571394},
    {2.9435043019908784, 2.5238597840335526, 3.590648850657592, 1.4400422784860574, 0.3882301529641797, 0.43762114479076175, 0.5044448359640145, -1.0272129379767108, 0.655851457459805, -1.7280342025143018, 2.0887976935242127, 0.6679376270146979, 1.5599869237470345, -2.5188110287671908, 1.448526083799088, 0.5949667791185581},
    {4.693956643810209, 4.67998601943078, -1.978974541347939, 2.628341428509169, 2.9275499887640466, 2.3181806741085413, -4.643015485201833, 0.7166720685663508, -2.4032625097463893, -3.6829990572314717, -1.0637344454857334, 2.9838862017436205, -1.145455720587836, 3.6625461556508934, -1.5148171873755287, -1.972723786891097},
    {3.878077433190002, 2.3033150366373074, -1.1553370916535364, 1.048556801829756, 0.5857738569046472, -1.3685288655873382, 0.8145963770675997, -1.4752892499376022, -0.20239599656816323, -1.0481089096866467, -0.0031059308885863796, -1.0640673993626115, -0.3353474849960536, -3.0330039697356312, 0.042797886321049375, 2.0879836097217908},
    {-1.762213830193294, -0.9199416837061346, -2.3408791286233845, 0.36673001569455393, -0.1690839186794062, -0.6321873945354768, 2.4102796119222076, -0.9591020841938218, -1.765184197651619, 1.2817087374300118, -0.4525490745339943, 0.5557666218909456, -1.2940704333197577, -2.222892839662632, -1.9901796973476402, 0.25785625438876203},
    {-2.151682681586065, 0.9642422514407069, 0.6287875740047542, -0.011212315543848248, 0.4706165951437575, -1.383883841780749, 1.1530299900420846, 2.3668533791447426, -1.7682614112394335, 0.6379415271947371, -2.735110979916675, -4.016466215919762, 2.531951953989517, -2.1710821641512315, -0.7540574585529417, -1.931679944509473},
    {-3.1176199178868718, 2.7354947205534725, -1.1179619181971379, 1.2834772183752219, 3.8597302553480177, -1.3540756078973746, 0.6858489187613507, -1.1990028546864486, 0.4001129637557888, -1.534892787595281, 0.8817339364176471, -1.6998219061069868, -0.1899182056856135, -1.9949036533798752, -1.6760091823258765, 0.465621849322396},
    {3.060140852886856, 0.9032794965127585, -1.6584856335464662, 0.5193834390565394, 0.9805651199940517, -0.3536713306905167, -0.3575584097951761, 0.5619169985768936, -1.0868169504989718, -0.3087993961004378, -3.4063175239546117, -0.46271776918541335, 0.22629206961087225, 0.9208216799833542, -3.500682420327022, -0.7519888849756527},
    {1.350006389819941, -0.16118194481764964, -4.622249497539592, -3.099428579622107, 1.5204528516156899, -2.0215895250895053, -1.6885201361102553, 3.2638968099763708, 0.026579058316520146, 1.0943983669169757, 1.5221257200689864, -2.1067184902250626, -1.4723292713979952, 2.426726134301862, 0.4868395452344356, 1.173519351362546},
    {-1.1266565377595559, 2.2571471644457914, -2.1079568542683957, 0.6905919108539992, 2.5270264437487633, 0.39665305702983084, 0.6282137262514271, 2.0334864654061167, -3.0463345802347543, -0.41257678647643975, 1.3102927962520703, 0.5104286170904833, 0.0470451185069823, 0.040805084543385495, -2.044716852167262, -0.770695072677388},
    {-1.3789794651966791, 0.18153270503958122, -0.6453395966201367, -0.25630178688768257, 1.1106233359077191, 1.1544836345510947, -1.4007475142906671, -0.4236875621820223, -0.6491383129144591, -2.3155481047315147, -0.07862286912704407, -1.353305538929013, -1.8841878386162993, 0.41759730563707254, -2.1532760041861456, -2.4196954533383246},
    {-0.6591900139393571, 0.08308489465359176, -0.18082434326948923, -0.3372806460065895, -3.555786540916909, 0.7309587890735199, -2.139026795136524, -1.4521858428367982, -3.2639724449387586, -1.0514519482928875, -2.7533487844858158, 1.2797913677353792, 0.50228704863534, -0.0998984611619296, -0.3399470294221963, 0.045237442867631},
    {2.661775975433262, 1.7553000416751328, 2.3955734131545228, 2.0798471651949533, 0.07960055936562174, 1.6185358170616206, 0.3512534166919939, -2.0520946746803532, 0.8935865568037759, 1.9227276849432215, -0.6436002217338729, -0.4523570091917546, 2.550565414227595, -1.4454695201361807, 0.31738132236856287, 3.441265795383777},
    {-0.24011782655678052, 0.8932766748057422, -0.056839555506613425, 0.8186614708406563, -2.0605068839114096, 2.6602794306153403, 1.6258947072205407, 0.22583699485098443, -0.4383562211368426, -1.001273202231576, -0.8382996685483828, -0.6964043827856001, 0.8747056390924987, -3.2477941866960043, 0.2808594213142971, 1.0728600122117251},
    {-2.2622046528925654, -1.8143791976664514, -0.8473381182428913, -0.012916817265703607, 2.023006745306008, -1.7312946634149715, 1.8336061812376472, -0.17017844631463416, -0.5114299064907596, -0.12842771183466795, -0.98134500174602, -0.26385175701015234, 0.3042691675605556, -0.7293466886280494, 1.800881732840214, 0.7861290757508613},
    {1.3251152365876178, -1.3224527483735693, -0.1409734011096946, -0.9394061670862317, 3.1275507106134923, 0.7407934906236601, -0.0012712185800611293, -0.4204924622327003, -1.0806014840865148, -1.0942767714058224, 0.2652224333191516, -1.776926534189015, 0.15344789963130206, -0.8891346479062913, 0.6760408602590309, -0.8563161649839178},
    {-1.7151506253060311, 1.0523736244785422, -2.7725366241974743, -0.43772232237299025, -1.3646077688371179, -1.7354799674376973, -1.491345053641026, -0.5214903315019435, 0.08310796823279769, 0.018610661747886014, -1.4608493895369952, -0.3518527691480481, 1.3085130592694387, 0.35632348290099813, 1.0754124096904758, -0.23235837901344764},
    {-1.838252636241128, 0.21991218279608182, 1.8246067838414488, -3.004292318480486, 2.991701967303822, -0.960123234993969, 1.7714703028618122, 3.437955952509171, -0.22011004208923954, 0.8074244866144094, 0.8983774950718945, 1.1187611711038512, 0.2846091201665434, 4.418447020484127, -0.8154158381906267, -0.7746286990735597},
    {1.6859408353604348, -0.2865637416171811, 0.12103628183085015, -1.5774310432020684, 1.4429611834692282, -2.7271417788136945, 2.286395124913904, 2.4044878218831975, -0.7174177790429395, -1.5391998441110966, 1.260507609448919, -1.6241485220032672, -0.8513460709326592, 4.093705725091559, -1.1150331364316424, -0.999130231878021},
    {-1.0676431902048298, 1.76358650972097, -3.7644619795461587, -2.362431437812833, 2.1582742814753715, -0.34464845987533776, 1.8549513206772923, 0.6029838158405508, -0.19115664450957676, -0.1378266123414549, -1.233495917448944, -0.8760475163165458, 2.2157091305682846, -1.0957494451266085, 1.5654569130439955, -1.2843377432979723},
    {0.8761906361333354, -0.2153947638000435, -0.04713914426789092, -1.0346219903914966, -0.028660570004035345, 1.4617848708924113, 1.6214705268884917, -0.8369012615306787, 2.481543062486553, 1.6192061259710804, -0.37925424190806284, -0.9868904099147676, 1.109145620211632, 0.6668059297813244, 1.2146636480835782, 0.5792306034977647},
    {1.1965698722928055, -2.606564821538891, 2.100190439860125, 0.7806848998213156, 0.9961410893999104, 0.6560785583613712, 1.91082850704423, 2.0108428428341054, 2.5337497032578784, 0.5247360077196317, -0.38486899630331106, 0.8309530811902281, -2.7036504262261203, 0.24168264624300612, 1.276715792226515, 1.3122932246614194},
    {1.7964915653201425, -1.116328499364182, -0.9066889412762992, 2.0839257841032928, 1.859652848656045, 0.1028242347617013, -1.452576010262949, 1.891469110980529, -1.0765544182258373, 1.2374648701019044, 0.09936211599640724, -0.46732918332808676, -2.4856727105627017, 1.318293512446184, -0.7134316877167259, 1.6583079812753783},
    {-0.35501228479406954, -2.928118170511608, -1.736555257155258, -0.9225443156617444, -1.699744197161871, -0.8635219924042244, -2.550268907989502, -0.9535155774341347, -0.34232905596204244, 2.393843321260519, -0.3488924309204985, 1.6033764061433449, 0.1515012946608103, 0.2553981536424985, 0.8988091713762517, 1.6203051428438087},
    {-1.5925079431332105, -0.4326947964739468, 0.7529666631945513, -2.468029324662724, -0.1870244210214233, -2.72501672000942, 1.3754940362971133, -1.4193071960470467, 3.1909027136816386, -0.10939164487107521, 0.691598103197975, -0.10545974127702604, 0.476678056124529, -0.7192078075350007, 0.5673610718498415, 1.601546283915084},
    {-0.9353309965619139, -1.3134562266704044, -0.8075406334650199, 0.45218999870787074, -2.2946942818180616, 1.4251767333419512, 1.0211401420469155, 1.6893096422636833, -0.7357014071211333, 0.6285703671328361, 0.47064560058044275, 1.5047599135496987, -0.5272604705797089, 1.7883683572281683, 0.48848423588685597, -0.8245098554433267},
    {-1.3138717110217994, 0.11066352435790906, 0.4396096452266357, 1.9613710131253521, 0.5688748357116798, 0.20179737380793564, -1.139699418028937, 0.08420779508353983, -3.466925794539757, 1.1915033891443936, 0.5709240300018803, -2.08520883081722, 0.8500385194944722, 0.07398192527226484, 0.7127561794572242, 1.9954722387099704},
    {0.1110181334582187, -1.4637992780828035, -0.4579780006911343, 1.702096227919638, -1.8558005636124424, 1.4096656247893502, -0.9504498957720858, 0.8300229205162355, -1.3249322028947819, -0.3013246119937245, -0.633338865462938, 1.2380238120864187, -2.4780023758711356, 0.8307992071762428, -2.3344518345176786, -3.211724240458243},
    {-0.5771260904408831, -0.0013584837318347638, 0.3508422346784811, -0.08210104778163238, 0.674607820823861, 0.26409031974470915, -0.4944226042933084, -1.7696553902639889, -0.7781584378020031, 0.7543940660946054, -1.1101579872322684, -1.8158701353762259, 1.5103355591652086, -0.8376771811196343, 2.238676814788144, -0.1648504664035332},
    {0.7984714888659541, -0.9585563145959077, -1.501490716211408, -0.49953355237610453, -1.5993650887294937, 1.1965510266793997, -0.17751760638298653, -0.9672247725806166, -0.4664580528974948, -1.0450402064935158, -1.798198517568723, -2.5774767805748855, 0.7233871708493171, -1.6120565221839689, -0.19795919028852743, 2.6283546559039768},
    {2.1600681091118314, 3.009663903333477, 2.8934999324768333, 0.3159992737784534, 0.9161873911740197, 0.48247943893184, 0.5731956108585704, -0.023480565292766643, 4.419330473630099, 2.135067152226426, 0.9172038444555625, 0.1807416910822382, -0.8906041596655914, -0.6094599791009131, 2.8930153855448832, -1.0829336955346154},
    {-2.0028391739836606, 1.1119188345624043, -0.21169786830531157, -1.8771869334919324, -0.536946047191721, 0.33399454768185305, 0.5718670912554098, -1.6606202514873312, 0.2018743912558158, -0.4534982111208006, 1.8334102438960356, 1.7121078928454148, -0.20913904416947768, 2.0782377561073115, -2.767198181377504, -0.6767667944610671},
    {-0.7812486945310834, -1.528592583250453, -2.43595424813423, 0.2647642842855548, 1.0551672189012307, 0.30083915161306896, 1.695199880625993, 3.749588373402548, -1.4614985249048047, -1.0333206476198546, -0.11111257771987693, 1.2387476381290334, -2.997105663896047, 2.9225103314819085, -0.06655555639153823, 0.09638496224651684},
    {2.0564288510945494, 1.1494890489735259, 0.03722416022302431, -0.618228038212613, 1.822043940318675, -1.0505975860255319, 1.405896389244125, 0.7960597431752579, -0.5702802699922969, -0.7461137776911388, 2.584938915684567, 0.11062231136109638, -0.34076311771446804, 0.5141254998182679, 1.4422991306051394, 0.013007091817858385},
    {-0.02628599567479672, 0.6656966966616729, 1.0776917263368528, 0.691588927091327, 2.7281944611928033, -0.5304479194247399, -3.108419840274849, 0.05726441927972805, -1.5855596097307298, -1.4026836958471587, -1.6701936291549426, -2.804527025225763, -0.5739667726988215, 0.3397316685824669, 0.1781119969413386, -1.5205822207579773},
    {1.8393644111949492, 0.8844112102813152, 1.3944738631143732, -1.3234564450680593, -2.9819752581350407, 0.34076074725961586, -2.8978084089621987, -2.541175314440231, 1.2679409297192819, -1.7880933821872087, 1.8363810508245253, -0.0743122297797424, -2.846636304126063, -0.2178457466317144, -1.4736728891999917, -1.523074502390072},
    {-0.5569758426161797, -0.85261062712751, 2.0194627921903123, -1.086746652002049, -3.3476433251367625, -2.365087378723467, 0.43105361023975763, -1.3533187821849615, 0.9906506079312017, -0.6123056697763783, 0.41993884363347095, -2.2036203133776358, -1.0782756371936673, -0.8000817040529046, -0.7975749981917154, 2.6031168688766453},
    {-1.020478452561001, 2.0429492939376726, 2.0918397216136997, -0.5952395496727476, -4.331883622027378, -1.2240907056628336, -1.3193095340935992, -0.5958139055431961, 1.039764731519846, 1.0609547040948766, 2.1550620125163507, 0.8877949207492553, 0.03428593324869066, 0.7810456047428828, 0.6132713028962856, -0.04162371383585742},
    {0.3073503664067813, 1.368647142816948, -2.6956727305186394, -0.04593790890947446, 1.7123760470572702, -0.7936627241775411, -1.6574422427858584, 1.8850054005564447, 1.263256820822086, 0.15035952801840252, -1.4854682475227567, 1.2013965482556166, 2.757626555633289, 1.8953463035144889, -0.19135629419946165, 1.4421039225685017},
    {0.15495840962910926, -0.4962461558924363, 4.206064089096159, -0.8855752163567501, -2.8727923408615506, 0.33647938799899574, 0.8063586015815157, -1.3629849636489926, -2.0714501917826666, -1.637698280745176, -3.356238592573897, 0.5552165119693121, -1.6731667380093294, -1.1602221518545566, -1.3772734261076136, -1.8149293882711042},
    {0.361186038795516, -0.16137446961057425, 0.9261341210839982, -1.0647511271645502, -1.994631262105747, 0.529972980025542, -0.3312863316385481, -2.66363049506224, 2.3593178573730107, -2.447960898023295, 0.10232066260973226, 0.08133406429963516, -2.39946029565022, 0.24548953209602453, -2.298365465421696, -0.49947650464212423},
    {2.259672474706482, -0.27098308057830855, -2.1041956686361787, -5.252477549530636, 3.2647205300882924, -4.457463823543989, 0.5574043755574408, 2.3163433440113237, 0.9690764662407424, 0.36086106435117654, 0.00024068921030667375, -5.882374495295165, -5.114805544778868, 1.5269425351366381, -2.817205577832153, 0.12431921939166059},
    {3.3454934865329595, 1.1387808405127031, -2.236992123760803, -4.671239972941353, 2.3832959589217295, -2.337760003961464, -2.577390488555472, 1.7334961149116621, -2.674518074226882, -2.119750843201325, -1.9354637934212924, -3.025691252583534, -4.696899526527572, 1.70590032197899, -2.980581300174862, 0.294835694312904},
    {-0.24783965740178449, -0.08490819317542522, 1.6362372073538687, -2.193138281528842, 0.47490061843029024, -1.3318906768316985, 1.0540830808589896, 1.5938886479452057, -0.5905829767840552, 0.3411291630231822, -0.07575270843633732, -4.035016293414962, 1.1693889422193928, -0.42115277956753144, 1.1916424857890018, -0.1426723740183643},
    {2.7166830522365424, 0.7237982257145654, 2.787407678232935, -1.1261249652860486, -0.8475828157174502, -2.6851998994566877, -0.4548440442557765, -3.675840616855839, 0.5081106578011872, 2.3393983660123348, 1.0040914127275073, 0.15035065316682017, -2.7257485064482547, -0.061359784501767115, 0.9141086903753413, 2.15773248580481},
    {2.7001362918834038, 1.6702505550229554, 0.2391678283556297, -0.6313033311957622, -1.6002668733970733, 0.8067501500043621, -0.669136818013894, 0.16900603431061545, -0.3639743391428261, -0.5061395991950176, 1.6356455938383012, -1.033467089241177, -3.8848186613699993, -1.1560785674618297, 0.3235366250285491, 2.4197537132980806},
    {2.95512238561155, 0.47663184508075573, 0.6765982587851666, -0.583446375624398, 1.1457744734783195, -0.9748933456605925, 1.4385134223375684, -2.62782878745945, -2.8417715964670625, 1.8957277486792519, 2.9224489377482206, 0.003543735993131834, -2.371051635175446, -0.3724765049558183, -2.872894293629026, 1.3570436550272724},
    {1.6350911553302951, 0.34783735081947625, -1.4335250276547093, -0.6949535176525753, -1.2418717800280832, -0.4415278121590121, 1.4580902969577312, -2.8984990045932535, 2.8880724189367535, 1.622960764945257, -1.1150271669197243, 0.21409731157799816, -3.183670611211879, -3.0480423173954785, -0.6970007317239139, 2.6021362180248366},
    {0.0873728328295993, -1.7786782123206781, -0.9442336676101767, -4.0856900070494495, 0.8402776512573213, -0.8470390741285513, 0.4206733439862984, -1.8970672339335872, 0.6103329066151424, 2.5610194464276756, 1.5742282880099334, -0.15050429107581437, 0.9325027285494902, 1.1793064178861534, -0.3220163499012521, -0.5714438689333285},
    {3.350827617213227, -0.05432093529200983, 0.8287190650543168, -2.1041646985213758, 2.352973160948284, -2.5027630783285173, -0.20463685720333202, 0.16014820509976374, 1.136697122887657, -2.877203743326345, -3.52194581230455, -4.679335383552989, -2.873090366184835, 1.7027741040229476, -0.4148629975076728, -0.24716001975954288},
    {0.6266509200405095, 3.337136705161219, -2.129598332069512, -0.7387349145511951, 1.6049265962608263, -0.293845042202901, 0.14620797772789826, -0.2091206145524672, -1.2006896796022217, -0.19871091285969994, 2.3040316304908135, -2.830175695534671, -1.3326204466843512, 3.1075950107340846, 0.45948553911772727, -1.859898067235705},
    {1.55721803859408, 0.33466495063433804, 0.8827069277957121, 0.8083665963869521, 0.8741405290490224, -1.422948202016261, -0.05496875872776715, 3.017038454957863, 0.6564884258582141, -0.21173922689265004, -0.5868851032774879, -3.506422996084316, -1.6525237208557368, 1.0762322373237876, 0.10237187954473062, -0.15763595931593288},
    {0.2574425566938014, -0.1155905314920646, -2.4424837175854033, 1.0787604533915145, 1.58506740787673, 0.3751222956270069, 1.488243090353933, -0.3209904953248788, 3.6942919798743965, -1.3361869238218413, -0.21893279827356046, -0.4433444862957362, -0.724035570494132, 3.7078681749215767, -2.553982246615496, 2.1287911248570275},
    {-0.2606127383604208, -0.20541214773270045, 1.2152703986127096, 1.7130182527077997, 0.9271583495881656, 0.8843612202386336, 0.030766355961866828, -0.9196550591485884, -1.477758314582905, 2.632770535943568, 2.33137451630604, 0.4077300807392433, 0.40352554706199284, 2.465079229976704, -1.5698649757162597, -0.633496193529431},
    {1.6152215336379274, -0.24896975905607008, -2.9651463059102814, -3.8581313349438666, -2.1430341572364804, -1.7650934625606662, -2.961202472325951, -3.4292050626072466, -1.0607546617313552, 0.5024853291798322, -0.7833337580631042, -2.312125846212145, 1.1336859605431202, -1.735013307890826, 0.7119489645541277, 2.044774536800353},
    {-0.42961089838662714, 2.6479765280361653, -0.8370914419316601, -1.4751138445975587, -0.1603834852513841, -0.7812358955275011, -0.8770956520735117, 1.8198836082249652, 0.39385296592301605, 1.6236627059244595, -1.6775366495834105, 0.9033870169846734, 1.4663039317294366, -0.5496459403589506, -0.42771146703652974, -3.1971207661585814},
    {1.1905500288536388, -1.4853646018389721, 1.4980696123333868, 1.0267759781615953, -1.5407945514588413, -0.08893020444375226, 1.728950464470023, 1.1191335746987372, 3.5123880613070058, 1.6104317788877673, -2.0468977938734456, 1.058235522684528, -1.1046304841479102, 2.605327979214053, -2.216909664264201, -0.5244513028908607},
    {-1.8047475051238608, 1.735790462007667, -0.2841248635153003, -1.5298793066159189, -0.5033824689689298, 1.224793810993234, -1.593648194102875, -3.8303931786810943, 1.7896894167061426, -3.4988345733100115, 1.7540750455836196, -2.273735847190579, -1.2853581232366393, -1.3980124946753925, -0.16634405246123174, -0.1900264030683865},
    {-1.4836179118981172, 0.6839878992074587, 2.1291975484146546, -0.04432796324618694, -1.338509185701214, -0.8313797453008019, -0.813826138235841, -1.1760885271617025, -0.5548157401896995, -0.39240754359208174, 1.3466108850012133, -4.307693404369859, -0.6204189711266808, -1.0655740860244955, -0.779858841454574, -0.9162104618947565},
    {-0.2258528017478215, 3.5162083247611102, -0.9678921392107608, -0.4424933957882666, -0.26611385868508275, 1.3912719118684627, -0.32568957008641186, -2.960339355190982, 1.0273825541075106, -2.17494349320275, -2.095240188414129, 1.3279029146157417, 0.6847647872503054, -1.5635861717791961, -1.9078049274889908, -0.04938589514338757},
    {1.102042274955137, 1.564331353353799, 1.9645893069404825, -1.489537712202357, 2.5684220591463696, -0.13940896246525475, -2.443602836404294, -3.235275222884775, -2.0454656188854132, -4.931228090835674, 1.969193635893905, 1.0838265052624874, -0.4551063794406149, 0.6208481610378869, -2.2692647539722968, 0.36661851851157884},
    {1.2050932347829986, 2.8576707096345215, 1.4214811796545699, 1.1919814323406024, 1.3732339790544346, -0.059848237563010394, 2.947623999165921, -2.800651205830423, 2.4553148610510376, -2.739534017547822, 0.2532168581529727, 0.670006898160878, -0.3312693494600951, -3.075685204084489, -1.9427936460036888, 3.253631315448651},
    {3.9037217149267787, 3.0710893395214733, -2.230196004758083, 1.4368413327755065, 3.6378150021341105, 0.7955318359287271, -4.390381965910226, 0.01361813011175469, -0.621605171515999, -4.727210439311648, -0.9998357441824031, -0.27877749539436114, 1.0171266976001123, 1.4264031517142057, -0.5450074886970742, -3.5712682483617297},
    {0.008228072259976276, 2.537150843512164, -1.9007933723645458, 1.9713095252526738, -0.32794182920346876, 1.0807606619932495, -1.934916482178208, -1.2224004857367425, 1.93480938279756, 0.4655030455859137, -2.199297753309884, 0.7040836356444208, 1.0844235343908504, -2.3181556642269454, -0.753213928799259, 5.0558713435653395},
    {-1.9035550210856116, -0.7884189731696366, 0.8456930100056329, -0.4991278385845628, -1.444681884553997, 0.533034721599094, 1.372165104871363, 0.9065240652661701, -2.16494207511543, 0.27486527598564575, -2.8937047316802715, -2.099723617389759, -1.7255288124240604, -0.43104184478217555, -1.459586121655478, 1.3443922546924258},
    {-1.290716805312596, -0.9289045855525162, 0.7086724540573264, -0.15810598921152647, -2.615964949016206, -1.840561019770144, -1.125296514138218, -0.6349993972843821, -0.9860500992317113, -0.3284560274964479, -1.2318492637269962, -3.0096675297674342, -1.2804248806912266, 0.9845473032201584, -0.9058045852089207, -2.9305199232839954},
    {-1.0133215292885531, -0.6111283591197958, -1.3955795563219804, -1.4413218280463909, 2.574710424412858, -1.6964133072170382, 2.9527592522764627, 0.5165640933902291, -0.10520728933682356, -0.8277867625314373, 0.21396435650810403, -1.351715092009499, 0.44519502405444367, -1.9435432186257275, 0.49299892191433153, 0.5262560651795191},
    {1.500202292988855, 1.337592675802194, 1.1725470091309969, 1.499409791822959, 0.411120478703685, 2.8020758950318165, -0.9545025485864699, -0.5785885538360177, -1.3737956446132502, -0.3815036956580678, -1.3646728947165145, 1.5004984980547806, -1.263376246226382, 0.3506985377001813, -3.232584105176666, -2.325339287909549},
    {-2.534916924553803, -4.135438180762008, -1.988794706047057, -0.8619231924711593, -0.24262627164602035, -3.484128242837998, -2.631820159755108, -0.47157236589291884, -3.088853000906429, 1.6160374901686418, -1.7196278792489956, -0.5740435297053609, -1.3594691987093668, 2.105413133536663, -0.560474160380172, -0.04210270075076869},
    {-3.6306322094346335, 0.191252408842587, -1.8851680679406166, -1.7831610109831515, -0.03571315738535277, 6.955333222048805e-05, 1.1037977130888132, 3.879890722533789, -0.6131374444447549, 0.48077040768842155, 0.4261713222501923, 1.2262225311277848, -1.0992066839247783, 0.10695065924550543, 1.0346361888309445, 0.16841100141930554},
    {0.8575188291179815, -1.886824311193308, 1.031908013202452, -0.20912568376496096, 0.36606860189950896, -0.5438679314207845, 0.9532201811636439, -0.6435610910378476, -1.0190436640106324, -2.118279013741772, 0.33363452203599914, -3.948632298017809, -0.541139752391884, -1.5755668141611705, -0.9135074557538804, -1.8911422335856358}
};

static const float b1[16] = {7.525667256300455, 7.330976857705638, 7.665130325836768, 6.439000516411963, 8.199494525748122, 7.641821688104628, 7.606840977100904, 8.295201961474772, 7.952526125789867, 7.245754050879663, 7.691157912527481, 7.477725590961072, 7.6786304439364805, 8.30609866429295, 6.842742832688106, 7.474931645020227};

static const float w2[16][12] = {
    {-3.9407349042489255, -3.2263244354451217, -3.5741503586214947, -3.498750367329264, -3.8428820686025333, -4.234543212816638, -4.835723036563748, -5.6881137720325645, -4.300675220760979, -4.0421383084619915, -3.7848295130145155, -2.773470837234675},
    {-4.509106380575619, -4.32493506765175, -3.7260495706500234, -5.205818912043516, -4.350083073959503, -4.260384285428854, -2.8827901975917505, -2.649074903219397, -4.0304477345619825, -4.02319970841964, -4.117213808251975, -4.761877350578718},
    {-4.45250673547439, -4.285257760968736, -5.156233874118972, -4.697151987448576, -4.596734957847619, -4.60396541397132, -3.5824095868055927, -3.8426536806124383, -3.407953591637322, -3.9217093477847667, -5.466645332254513, -3.2625993348114433},
    {-3.26525760640698, -4.5484196992015855, -4.738755956931222, -4.23518966348219, -3.298354199311671, -4.211890524832572, -3.4680008126264763, -2.779800835674366, -4.247804529201044, -3.030279363415589, -2.3745836290889524, -4.662581240533391},
    {-4.983572746239832, -4.922046372412174, -4.789519177582158, -4.230938451839235, -3.7354145189296877, -3.173715572578371, -4.324708816427681, -5.225858433039644, -4.333845244441908, -4.845870924754093, -4.30055496405352, -4.0593822540350155},
    {-3.8129238735622573, -5.034233592419836, -2.9694444419845163, -3.9442745272487145, -4.999152108624184, -2.302573362270247, -4.4655675965485555, -5.882337363724189, -4.40204112823968, -4.786818523203179, -5.142215650326758, -4.503220756958979},
    {-4.319668237644864, -2.979499741530387, -4.573939442750777, -4.491829148855968, -3.6263038335571145, -4.238772858484048, -4.262067823805099, -2.991010853467846, -6.209621445147577, -4.87459515489948, -3.3640949791272994, -3.58027140177579},
    {-5.290666579986746, -4.454626538890654, -4.756683990387721, -4.571925657602572, -5.028665171018314, -5.086510658735904, -5.00427681464136, -5.285951101509252, -3.3860251883020966, -4.130095713312701, -5.120401310588448, -4.22698898880221},
    {-3.877903582879233, -5.154527562964646, -4.8302205394357145, -3.3965040971330245, -4.303218250365879, -3.8918047578301525, -5.074852659161887, -3.9462317354697403, -4.335658872133736, -4.893976130958423, -4.789686845954944, -4.374921266027701},
    {-4.281768712655369, -4.912623852028617, -3.2153527548785643, -4.150648714096128, -4.079191516563101, -2.8042643315011326, -3.592200589811074, -4.450326152415749, -4.18649613090918, -3.407168152039326, -3.5472867814851434, -3.8253444884395593},
    {-4.760335098272256, -3.907145047008319, -3.4505075228377833, -3.9000744240685736, -4.293586551513045, -5.043646814536159, -5.342195814996557, -4.746519447442494, -3.8574865228942476, -4.6453610063902335, -3.119922203228017, -4.906052520995031},
    {-5.712694881624721, -3.7267762234309805, -4.06808487829575, -4.463065752675399, -4.023874606299093, -5.081520661836871, -3.450439923187899, -3.9399629319734566, -3.937782862444573, -3.491625270476875, -4.941859994205864, -3.726868182917356},
    {-3.1283052449889466, -3.460480823435694, -4.023602374456492, -2.94097655017472, -3.5352870323708196, -5.075029253568282, -6.162327725846339, -4.03660458958489, -3.9251743212997385, -4.28689690396801, -4.2927790238842825, -3.79472265687758},
    {-3.5429154409013104, -4.712698560433021, -4.104920374973837, -4.5128861890874505, -4.703243050176484, -4.562384358450586, -4.105569903635157, -3.894147095294201, -5.018571026272484, -4.796163257565538, -3.967709280226099, -5.627407492901379},
    {-3.4392543946834433, -2.8946325957642003, -4.392874940748849, -4.098248729662795, -3.2338931936152027, -4.088596615082659, -1.7839928396153353, -3.32241036900485, -5.012778957523614, -3.785072116244097, -4.002728111661501, -4.021030834252147},
    {-3.6492227933378705, -4.0716676633897695, -4.840581583844166, -4.249847718154666, -4.618892698298211, -4.088426367499073, -4.25519432235767, -4.124616612630776, -2.9507697259549217, -3.22838473338754, -4.606874296632488, -4.880469987955586}
};

static const float b2[12] = {-4.9707285138012205, -4.836484263737796, -4.294392385351681, -4.989680565945349, -4.794391663937676, -4.986165555369746, -4.809189861071479, -5.274302967200204, -4.870603775508778, -4.601443256954637, -5.189015507985056, -4.765557998873569};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
