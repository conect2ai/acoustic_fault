#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.2340948560217119, 2.762910955202513, -1.2856606671438355, 1.2303054962674616, 0.40306646466335827, 2.1393810322797795, 0.7490805487491423, 0.8630840148470056, 1.5305775176251684, 2.8690450381994865, 2.4441557441614483, 2.3273318873785924, 0.7300984949522707, 6.073062621316818, 0.5639208971044061, 1.4895704120986797, -1.416865886270423, 1.618187545152244, 1.867504513553551, 1.610817238739458, 4.518313490545384, 0.5651423301865169, 2.7221225933676045, 2.878808702293295, -0.35388317325636626, 0.7414028016739922, 0.9192790170479279, 2.64351273104486, -0.42409845646580274, -3.7724252869086063, 0.5824893270320078, 1.1725659032623514},
    {-1.6043807964786696, 1.8583296714623332, -0.6803293925901301, 1.5524073744018456, -4.41951942747939, 3.421991485200438, -1.4749650230950788, -0.3454478239887717, 0.6873609058639619, 1.4425422064048063, 2.5689066718067775, -1.6253041051721042, -1.3820340449320552, 3.5482352042456533, 1.5133157493596392, -0.36178727007804057, -0.9935943014364377, 1.376300177017252, 3.9039440824904843, 2.328088275836716, 1.5909844910441673, -2.146404942778884, 3.3170983969605836, 3.566353805828788, -3.5507459513271047, 0.826411782925235, 2.0315405683460606, 1.7725768703418974, 3.0243087283604275, -1.5959062350134887, -1.7850715125392742, 2.837527828229532},
    {-2.5200223795375267, 1.78678185647743, -2.843222682533502, 0.7883800841496691, -4.2357373892817956, 3.8981551964686796, 0.8167660678182656, -2.1841621815497807, 2.184168817313679, 3.6598954318662855, 0.5018587867829182, -0.36398646480325253, -1.4000182617165655, 3.554877996926246, 0.20761896727867318, 0.9758168740298161, 0.08394324632140111, 1.8909052229941299, 2.871061837889289, 2.0954231365199267, 3.0596957497143613, -3.3915167486683955, 4.594958598291826, 4.022779785895167, -2.5423129586315896, 0.1208673665893289, 4.463717958864007, 1.4033438944698609, 2.23156232556241, -2.4580721925626294, -1.9090945504706889, 2.3633192970974406},
    {-0.9131564515102165, 1.992561457945236, -3.9999949928270047, 0.9929956294300795, -0.8963697664831871, 2.018730014693464, -1.089366548544268, -4.097130598650614, 0.37117568590864003, 3.3055891911850863, 2.917239297198317, -0.4650861561043987, 1.1039631508936179, 3.5658340874969627, 0.7975418081346983, -2.8508199947765656, -0.9149950066439578, 1.853488316552923, -0.69219944609474, 1.5705096797225282, 2.1902336447969453, -4.305045712903278, 2.9307271003314077, 0.7488142895563505, -2.6686633286945494, -0.8254405041009762, 1.8282811274010886, 0.7994079509105605, -0.9505934622541646, -4.699258136955096, -2.015319967376992, -0.24341331163679125},
    {-2.0264964447344624, 1.2592550516899987, -4.3878712070327675, -1.6384232246839228, -3.878647175866992, 1.9464034379815354, -1.9583968381073278, -3.9841488403736594, -1.2390324773199366, 0.7976271606741256, -0.6097915550613442, -3.622452975555449, -1.4889409746172335, 0.7954337799342474, 1.142521114784804, -2.753590437909191, -3.3757887585789277, 1.3765464814831814, 1.149587856507754, 1.1267069138276888, 1.2845959557129334, -6.2542847317719605, 0.4191305779538987, 3.088571091760735, -3.073877191058475, -4.211087468538266, 0.41956154587345895, -1.6521069223048135, -0.8212733862538677, -4.8084286430440875, -4.602970048448449, 2.2838949277235447},
    {-0.5196029805049511, 1.5144425922854337, -3.700597617966186, -2.920054572329727, -6.874377174332038, 1.3063915166897833, -0.5891349724498022, -5.283896275753912, -2.319976413987445, 2.756577588377814, -0.43693043289187916, -2.152230964301127, -1.946911162265324, -0.507949072642583, 0.5794230751542487, -4.17468191568045, -2.608943831130743, -0.26898977892146064, 0.748886131111224, -0.38766008334921404, 0.7642517348617466, -5.732584238327824, 1.0220460310566788, 3.631280038281318, -1.436746582435814, -4.921422970678124, -0.08587469652108168, -2.002205208431917, -0.36420754402975797, -2.589398344093773, -5.468920155584523, -1.5968297057748313},
    {-2.4162005349643874, 1.6394547845855374, -3.8384334546942123, -2.802959546574784, -3.7976342406849533, -0.7088869275730544, -2.0572415381345177, -4.900599259952907, -2.8166867129986324, 1.0363864043179958, 0.6090387986110533, -4.601945194135841, -1.250131083006239, -1.0710329227987525, -0.2956196579209972, -2.979707151130568, -3.4766548253259524, -2.1256168113097487, 0.17301393624908026, -2.222975064307661, 0.6448022854566372, -5.508921482334046, 0.16547726117723718, 3.631018984975029, -2.429046563891022, -5.1791813685669865, -0.6203836761325242, -3.7596202621357517, -2.1943603492822135, -4.667540973577209, -5.086143263571675, 1.4492789430002337},
    {-2.442788244705726, 1.1038902794487107, -4.648667579207194, -2.0975785306114716, -3.9569096064839147, 0.02648079342851656, -0.5266561992020561, -5.5783616224941985, -3.26995773968528, 2.9649143831941993, 0.6944595299284946, -4.126085259939167, -0.5505394104780779, 1.2412550114174903, 2.8031757339619214, -3.9921160879890834, -0.9872127714642974, 1.0028355177900314, -0.04865416563935745, -1.7203952989887448, 1.361142737497658, -6.19915574042334, 0.27522432517426615, 0.2658908377472469, -3.504952533829475, -3.778141475857484, 1.43984854545127, -2.756645842129541, -2.0753975741574235, -4.140351655711347, -4.881832806380263, -0.0925544248078935},
    {-3.51113068113293, 1.8328331105113722, -3.084609253922873, 0.0008481079483842728, -4.222079550047264, 0.7843421263769773, -3.4093258387455503, -4.4890951840759215, -2.421230121257336, 1.3535657201936022, 2.326391584850746, -0.3644573420163114, 0.44385074130302254, 0.8952929476515037, 0.4545507438782486, -1.8363612618796694, -1.0041735676214971, -0.10111325995755148, 0.9129660684730968, 2.3803501682447803, 1.833001043785177, -5.997228130643829, 1.0007537473967714, 3.159758942967527, -2.1634968250183255, -2.332169918274959, 2.3200890348947887, -3.165770587596723, -1.1307533619878003, -4.365348293927447, -3.6145554688215547, -1.443610227607134},
    {-3.760637600516835, 1.619960205050935, -3.165249307985166, -1.4431163808906509, -5.469709134847274, -0.5621344717604779, -0.030011359690604696, -5.641664240228277, -1.8807087660650492, 0.5403665706160551, 0.13303998707573766, -1.0996782297757979, -0.5927348414405369, 5.17196987258384, 0.7367743610196268, -1.7886466610356238, -1.1493955135436411, 0.9326779331035455, -0.4188594967636472, -1.1275187172707657, 2.260166506920348, -5.428490707422439, 1.98358811303161, 3.499944124848957, -1.882770174494159, -4.743843912745809, 1.901775366223622, -1.2117923729935707, 0.21341278499184588, -3.7377898239304557, -4.782360399193992, -0.8153667999278855},
    {-0.861739956647239, 1.2608900474040932, -2.348172991641012, -0.8883513816267612, -6.049123037928989, 1.6128439095449398, -2.2693652420355614, -2.684704396275769, -0.24097162552258486, 3.269304123327982, 1.2105506942974553, -1.827411188138901, 1.1982129138350475, 1.031039542883996, 0.6214091414363806, -0.8479785633136556, -1.1731532330505963, 0.4439434780472648, 0.920466368857613, 0.5094096852284435, 0.3461367607621663, -2.834334772764446, 1.822656302643156, 1.3689907399660461, -2.179218281984699, -2.8233128930947973, 2.319039363726304, -1.1793762719183774, -0.7960555937910438, -2.4258864724966815, -6.356919391391865, 1.3603112214422008},
    {-1.5237146313276013, 0.9633527898818962, -4.68632199052303, -2.851778761551901, -4.205261483035241, 1.2939124234032964, -1.5366619474151937, -2.0875687051678935, -0.37558503260508846, 2.5407791084435125, 0.5583966467859403, -1.6584743556974557, 2.5707210072944364, 1.4832619219790095, 1.1683471725727885, -2.127485027180161, 0.506820780936298, 1.8658054616619197, -0.4326456688635898, 1.2187847202583852, -0.10739955486931496, -4.542646527337656, 0.9175697936037085, 2.20032290200887, -2.217976091474247, -1.1465704046744827, 1.7742503599195352, -2.651559908087048, 0.401437018352246, -3.411042362451702, -4.144935940915978, -0.5566347940570948},
    {-3.997871004331026, 0.15842430503613514, -5.608027322554193, -0.9791664675883384, -3.3729561770647756, 0.7147405901574371, -1.4831999851472004, -3.355884934526167, -0.4885306005721679, -0.3166890530903386, 0.6151370755287453, -3.3082642024864266, 1.8896875593184357, 3.1602630079074383, -2.3859986453555324, -3.1107975349377215, -1.4026684871127706, -0.1539997180928407, 2.682457755978168, 0.2928503927173666, 1.7672096093576122, -4.247929761152205, 1.7468056587231566, -0.2753233479721009, -1.7535621965562682, -2.1648194157339136, 2.5270719564661306, -1.2292069012859725, 0.1552504041867725, -3.649609429043651, -4.3361527506905, 0.4612858837230784},
    {-2.479981425002552, 1.032474197709553, -4.158068075053947, -0.24149039493459468, -3.655249710640813, 3.2577264533668733, -0.37498314458920723, -2.243031138851566, -1.2140458255985682, 2.604471196482213, 1.2267402838821748, -1.0777729134144338, -0.4611260256683038, 1.534123131376418, 1.4397587103619607, -2.1517863982333822, -0.2193575043046335, 2.207427343312302, 2.09730209897462, 1.7984106947669516, 2.0006572381224625, -5.2405827284667845, 2.3703335032447104, 2.0125780671813023, -2.802610382551886, -4.167722682491104, 2.606254574775154, -1.1323919191953025, -3.5425074442815094, -2.634415043080828, -1.8297425351649057, -0.18429371000485126},
    {-3.1256660229818243, -0.17141774925915162, -2.756717006977508, -1.207665292044055, -4.180562252045192, 2.9822850875445073, -0.6825119883544634, -4.169901027208341, -1.3889562586694895, 3.506744970619591, 1.3041805981148133, 0.32703292220511626, -0.025852866648665117, 1.5975792291976474, -0.1136089226261147, -0.9700172444014262, 0.40738614015243896, 2.185781826116786, 4.34323729966191, 1.989417065617508, 2.9055815742882856, -4.7777212500545225, 2.3661268304496588, -0.010070638323408638, -2.127124711931668, -3.979367938670999, 3.196304595847595, -1.0329562304186197, -1.8357455751407614, -2.399256411594434, -4.339701364331183, -0.1719301791394363},
    {-2.1410976135294244, -0.3931327644666022, -1.6040995817939017, -2.2079849030722345, -4.970226747401842, 2.971831627849592, -0.837865602138613, -3.801476934634123, -0.13675674528974469, 3.9759147296547814, 2.148397328038299, -2.0498922087849425, 1.0896205608616778, 1.6320033714453244, 1.247742151314031, -1.2003222963294358, -0.6747341194540437, 1.6123707078646587, 1.8463263020772491, -0.15767984414343558, 1.093861345853503, -4.351225215738308, 2.2624522686417197, 1.522619686570475, -3.319364833613803, -4.604790866627678, 1.2374338378068068, -0.5829877151056435, -2.3325869223598636, -4.006670824545323, -3.961979583623964, 0.739192907293102},
    {-1.326300836361966, 1.4008219082358686, -4.630982750717118, -0.5692353744570311, -6.559522261172988, 1.5832641976109416, 0.028158408629387625, -3.9445919724779968, 0.37417484877138213, 5.153862731549594, 0.7564462874408472, -2.498349224821402, 0.7229430234165346, 2.5947310657674274, 1.8098041665796938, 0.7705560021269501, 0.621156673648471, 0.7717466387397637, 0.30075758754954884, 0.41941017605542047, 1.725651404151708, -5.992605894054286, 2.7272017786214575, 2.019673287253769, -3.349523261061679, -3.897568607332791, 5.412775694411622, 0.19225191946413545, -0.8514195322934239, -4.556209540212224, -3.6972473034379956, 2.0937920888787045},
    {-2.7652552999203315, 1.3702129106320091, -2.2666176769609105, 1.2627260694236635, -2.2460634232516448, 4.633266382376345, -0.7877715650914695, -1.8678966855928871, 0.026548745517707122, 3.932424314510072, 0.26992681620855474, 0.17166595242677574, 2.6297705939261817, 3.754463032547269, 1.857076956869075, -0.49831407126817545, -0.5126054458475018, 1.8615511339057849, 4.634204716190982, 1.4957050313924116, 4.211915351598207, -4.5349976227145765, 4.392721248119713, 3.4793294884243515, -3.614554118435974, -1.2359315301137712, 4.626880729786329, 1.5535821668386747, 0.24546484365934615, -0.9582222681969832, -1.1992849836671626, 0.9366132127095693},
    {-2.337607642834787, 0.10375813825059935, -1.7501229180881788, -0.0006609679786750617, -3.250051084039724, 2.128178947996222, 0.9117431714893224, -2.891436839158803, -0.47310883815188265, 3.2162272474684217, 2.955122639901488, 1.4439183357100174, 1.5181875875898159, 1.6472266959589663, -0.38916511784683344, -0.08287044151433788, -0.08513017627989672, 3.2618389502591643, 1.7374028977020202, 2.501613769076906, 1.3465859967728746, -3.3987519449218824, 4.130210534881046, 2.324224268350667, -3.714318132624061, -2.334632665653462, 4.442047977240406, 1.4512966123744078, 0.16935400337799864, -3.5485797793391916, -0.9866262909376003, 3.4606019789623055},
    {-1.0841743157429895, 1.6576094398968368, -3.614383102660547, -0.04997825091592966, -5.516755606139828, 1.5054187661029648, 0.6820756185415163, -4.590937978698084, 0.029524897215985797, 1.4494764793965385, 1.8802017535670374, -1.539507156304379, 1.4841112641271568, 0.8168422700146287, 1.931468718372327, -1.7967070824336853, -1.0952760858190522, 2.391968937781253, 3.13974142293537, 1.3067814265579274, 2.1107269741865933, -6.220046961353179, 3.1859806467373724, 0.8745609931228161, -2.647354095512305, -3.838470118388698, 3.2132130886691987, -2.109352128921732, -1.893412532095894, -5.5955389455940425, -0.6535717081703544, 1.6068531036929055},
    {-3.53925947353898, 1.5906156541950474, -2.859626040891864, 1.0865288953558514, -5.511743367689869, 2.270126930607432, 0.35582690415612017, -4.388222898895783, 0.3111336402802205, 2.4880434854229474, 0.9382211296443003, -1.2098421133805133, -0.711678213873755, 1.7761881934353108, 2.4331256735298448, 0.5776810512147066, 0.15958055143644415, 1.6077252776516302, 1.7937977470729445, 1.3474622110151064, 2.3025820902165743, -3.6352455516676163, 1.0325871518420244, 1.6327719657121007, -2.781604998695265, -3.683797719527229, 4.223576715492057, -1.4704056820063116, 0.016408684116170483, -3.728558715644021, -3.0445654947805116, -0.36554645278535985},
    {-2.1133717787409707, -0.2187889573068129, -2.0536682298461244, 0.14595977598018123, -3.3972678084125176, 4.30013674017226, -0.12381181974105206, -2.474556595343897, 2.0032007921284887, 4.017580028137213, 1.819810854745515, -0.3342900115402266, 0.6018996325951207, 2.0539548245911763, 0.5610726035969126, 0.42880215143580064, 1.198194791867795, 1.071673074648121, 2.1117205078467234, 2.3892611275357867, 4.020145521174421, -4.4009779206586765, 3.359940387349265, 4.299798264514541, -2.5935904986485756, -2.317033711856576, 4.010881158474824, 0.07039612971158589, -1.9475771844631695, -2.2669418606493132, -1.8901733821319349, 0.3169508942080472},
    {-2.7181078240816734, 2.3270555079658712, 0.32914907937957183, 1.3184070995787494, -1.7957064843349513, 2.590490112698263, 1.0329696592191147, -1.3109171402923534, 2.433551173684496, 3.1792548619298664, 3.2148288347442437, 0.41709088494579116, 1.9853244882134016, 3.5880930773440878, -1.431810297418845, 0.13100411470323842, 0.6376872141299945, 2.6396376134440045, 1.4804312701494171, 3.1137476938410034, 3.9922462747935987, -4.2249549795674595, 3.581676097587283, 3.5546527448976097, -1.2077059033055244, -0.6945759446892803, 2.5404678089649466, 1.38558047400345, 0.6750885245748441, -3.7246545997443135, 0.36749099168082217, 2.4893824475631168},
    {-2.47905155399043, 2.1833026074498076, -2.449842079232411, 1.1725001319684858, -2.9517754090747457, 3.255250027707922, 0.4398117243307997, -4.660267603022398, 2.4719668933345047, 2.9975098823476385, 0.5922812364458463, 0.1635306097492044, 0.06779630875484144, 2.37962698070482, -0.42822301596392826, 2.0925740487113464, 1.1843128684362147, 4.51848261945353, 1.702520676815618, 0.2517582261857487, 2.962647156581235, -2.7465262100070356, 2.5748158972545876, 3.272501802933392, -3.0518371693693127, -2.7910217746495674, 4.303498592400674, 0.5662660163218568, 0.38519766961867896, -2.8457899122618437, -2.809312853960446, 1.404955125917181},
    {-3.4126196176887715, 3.2565721588014527, -4.056762173491058, 0.927607423965285, -3.856224497067595, 2.294322634610691, -2.0659023350781167, -3.6908760646931853, -0.7919409722238011, 2.8846214667163763, 2.043779664531283, -0.8243523139988856, -1.4042466065747645, 1.857791922996013, -1.572204294642814, 1.1470366484233936, 0.7433039279170667, 2.2129917282483658, 3.24729043735988, 1.228814982962693, 1.3856642774831043, -5.2202101210105125, 3.606818545205799, 2.1987707638693608, -3.2795323131174654, -3.3267106398062234, 5.691232154583001, 1.5589626493781985, 0.18906871089052502, -6.202750935448108, -1.4927413052703622, 0.5746626316912736},
    {-1.9300380365342484, 1.3225991054766224, -3.6284197583623063, -0.17433812062826193, -2.333654293837627, 3.3384977884745455, -2.1287043543221076, -4.697744493285826, 1.4946262623362678, 2.05407800370607, 0.7525380269929886, -0.6666983053711418, -0.025478418757626065, 2.9661333467665263, 1.0826146615095595, -0.004817859333809944, 1.8478466287090929, 1.4132272351710793, 3.006788693330555, -0.013175412248349734, 2.494445362119012, -3.8318107756704025, 1.6649310450404347, 4.548523820654414, -3.882247569862231, -3.137821523630033, 3.814541058545448, 0.5722327552318578, -2.117077913050037, -4.323083115925721, -2.6091688833863476, -0.43815517289683675},
    {-4.30648426666452, 1.386878130907553, -1.0095994652176257, 2.350512302552422, -3.225957878534128, 3.260112077301152, -0.8422414867548563, -4.29614421433199, -0.17089686540422488, 3.8313264513056247, 0.7306508290032542, -0.12020415733575113, 2.5917266586920906, 3.4220387980054214, 1.115042091437015, 0.6214095430548915, -0.2678023697187648, 3.8939913064493, 2.3249439906183214, 1.2523039681321089, 3.2544943067986973, -3.9513845238241463, 0.34703356443291633, 3.209301758982596, -3.4885629062918313, -2.256896006819443, 3.706265541830735, 2.0260160310048407, 0.6556846257024621, -2.9204790390941855, -0.5060388342410129, 1.871649842755417},
    {-2.5979814904307412, 1.229563440276328, -2.0020542210047005, 0.06773913850133147, -4.7967303300122275, 3.839596508849588, 0.09187464958112443, -1.2279452146440701, 1.944802862140842, 1.1200722132826313, 2.282340382755276, -0.9091475085427443, 2.0628533302475582, 2.6973308536367573, -0.2031787052687164, -0.8046461273854814, 0.1886572922864568, 2.3664709626622895, 2.581884952224292, 2.7223801342202374, 3.330825429073272, -4.3695002845712665, 3.6213635172116336, 3.104306828045217, -2.7068230274129577, -2.0358928801511884, 2.2463115477776165, 0.6104177213935148, -0.4672353407536525, -4.628247422693208, -0.4757301839326889, 0.9690582936565357},
    {-1.6799462052600154, 1.518967203013712, -2.342137036031416, -0.7503625792397888, -4.280277620035568, 3.2335438711393913, -1.195444111201594, -2.987506210542464, 3.006754611806329, 1.6914001681398347, 1.186929779260347, -0.2562530532242816, 1.1623361277717257, 3.110880666983424, 0.5554595434278621, 1.4651312801176655, 0.3205202558597099, 0.17579252452595015, 1.4877503765035238, 1.9586763207648674, 2.470486466061637, -4.052790990465889, 3.2895089296083935, 4.843475551868922, -3.145637920389744, -1.5235173550267749, 3.0665866662808092, -0.8526937702729587, 0.3731224527536526, -2.4812018205456234, -0.4912365441537927, -0.12354548439890299},
    {-4.055965567799749, 1.0895731821063197, -2.051284202956339, 1.7605825851274324, -5.061728421296174, 2.4918199406818937, 0.702989511573068, -3.7372681475807985, 0.14330200827217515, 4.081278175092941, 1.0267847735981315, 0.2707895072286677, -0.6428518163199515, 2.0700146077433907, -1.511354190441459, -0.6143141145455067, -0.7403863518593834, 0.8599986541358137, 1.9479037269985002, 4.334518909362183, 3.2218298837421524, -3.9120349924735773, 2.385062685453726, 2.3373225110945546, -2.3460476352676363, -2.5836948368607064, 4.5547109390503255, 2.481129465283797, 2.022822889165551, -4.219242396052337, -2.61324217890391, 0.16173849418631772},
    {-0.1630966968311618, -2.489116654883371, 0.9543968080191872, -3.0466030785944564, -1.1682060471944695, -1.140477809945815, 1.7136968052384882, 1.9606956679337837, 0.8939581037148557, -0.1982405871560509, 0.37770379824240036, -2.3436577286387266, 0.8775335404982872, 0.8464459152672263, 0.2073053580131503, -1.5054162477470123, -0.227251095755337, -0.8732823929975281, -1.592054753871634, 0.2954400960425083, 0.0440629708563045, 1.0398398695258197, -2.6242801115106325, 2.125196395381072, 0.6306287271739769, -1.6929284044251824, -0.5402497581987961, -0.6649434994507345, -2.3802589877564415, -1.1610724551294491, -0.9854978483787894, -1.335299061127028},
    {0.190437213641959, -1.1354494350104112, 1.0799551609952447, -1.042040245875554, -1.7257834376708816, -1.0095759549346637, -0.7117457545325024, -0.764183811000313, -0.09605157755280855, 0.7683202404328765, 1.4014665052289161, -2.16248118568434, 1.14225300937031, 0.26352308036184824, -1.3230195322702227, 0.7100890376763586, -1.3490454049914296, 0.2636541785317609, 0.8828081720621446, -3.044640466636576, 0.03424276850153482, -3.4409397587729513, -0.47252664371645414, 1.7830569719549707, -2.0948199123949, -1.5407806537068989, 0.6780890588181494, -0.14022609161291968, 0.97799445999667, -1.9519289889136306, 1.2454829314266405, 0.1554739918970512},
    {0.2990097214405462, -1.7485957375089503, -3.4931348635587005, -2.218585304364664, -1.3070879113026956, -0.8590421159656371, 1.920132079425959, -0.8303967408409864, -5.900729852958852, 0.6253676280177013, -1.8668060442236736, -0.4079193760446293, 1.327343457210472, -1.3422641639833108, -0.481839389906323, -2.6724892199607257, -3.939416669335195, -0.9094335519528716, -0.6379682069816485, -1.4238159276668467, -0.5844388914664471, -1.8483233396338767, 1.3040103557464084, -2.1345850203332297, 0.03131559626387884, 0.9058414331223497, 1.1887943334231734, -1.1130308927531354, -2.8559121791282105, -1.959711141104231, -3.1504100728187074, -2.69931573322331},
    {0.48599963235516463, -0.9866664843939511, -0.7211256592852394, 0.4372576862177835, 0.1741971050999039, -0.2833375725170228, 0.6798096890021808, -0.4183543030163524, -1.559149808907092, 1.5187102814331908, 1.823238334391338, -0.7764347125037789, 1.0358465907811647, -2.52133891429257, 0.16019412395955032, -0.1418675386446849, -3.0017402545893086, -2.499335977951988, 0.7166899792911942, -1.4706777958854094, -1.4458165757042776, -0.17481828867740337, -1.0383057755527427, -0.4928695257505053, -0.7582228049153553, -1.055379383687533, -1.299852391269756, -2.105748276170946, -2.130470895756587, -0.660094759382389, -1.5482549852469887, -1.9915929123366694},
    {-0.2909914466003455, -0.7310946474057867, -4.028518845564106, -1.08715327974687, -2.8128975565670578, 0.46715121834991324, 1.2236884926724534, -1.7033790791776493, -1.8103000716679574, -0.2569380961792873, 1.2354927322176157, -2.0977887991068056, 0.05857624268465485, 1.3492992325283768, 0.3292161588639791, -1.5470389175470105, -2.6342987471267247, 0.6322055969089418, 0.1670174037669593, -2.522317394849175, -1.5201223449735162, -3.2436656280702825, -2.131083175901503, 0.4042512318780271, -2.720925896515773, -1.4054383957868408, -2.137976120723628, -2.8247615381677527, -0.6113827855554262, -0.3304772831282918, -2.186847616083425, -3.383451639938009},
    {-0.6930224884361585, 0.32756871406841487, -2.1501119470979497, -2.0147108704754078, -0.934428818459002, -1.1955625425615193, -0.29305358103978907, -2.0137308586762357, -1.6504240214535697, -0.47359186351281163, 2.13603599554386, -0.8285765583714775, -2.7970856057217772, -1.5736793343761504, 0.7810065976911397, -1.0334616861602828, -0.6669190174706091, 0.04936665464875195, -0.4143377108161543, -0.6357370252377609, -1.7681483800825961, -2.2179010833543287, 0.43261301762763604, -2.0746174367909083, -0.6258659145943999, 0.027261498337243402, -1.8451547052114303, -2.198371208021187, -1.3803867660665634, -2.1825131843180205, -3.053041236299154, -0.6527361063643871},
    {-0.3809759976016059, -2.626287694428842, -0.18889504864326775, -0.07196507642986773, 0.629570392597491, -2.099141596569992, -1.0768217439038368, -1.0236339670392602, -3.1743963191121987, 0.6871951860907282, 0.6704428491618051, -3.4598734386174566, 1.606220431256938, 2.2451996852868192, -0.05016837827505467, -1.9759010961373566, -1.7694721210152786, 0.2010663895204787, 1.6720833893540106, -2.343736204302569, -1.0722256081130759, -1.733694727285662, -1.0468486315766374, -0.09691770648173291, -2.135344328913747, -1.9236116659196338, -1.2322213765063665, -2.4183915224081765, -1.2950686214963418, -0.17892972661760087, -3.7939698969893554, -1.501900527746452},
    {1.3783622057836677, -1.3227365827802884, -0.3573082630736566, -1.801190788249058, -2.5725701379417356, 0.4740811231493607, -0.766615233960049, -0.15830755790411405, -1.0302827696950074, -0.518625719896731, -1.546124259104266, -2.6297270660667906, -0.27933397867821885, 1.431578023058872, 2.8063563605926127, -0.40990961502772794, -0.6523298849357988, -2.6237546173138906, 0.29229929094135604, -2.643452688978364, -0.8388025360192454, -0.6327334470130936, 0.454054675367232, 1.7368720735900018, 1.4350854565529878, -1.5192792856771928, 1.2450856724157036, -2.172738205250009, -2.620911355793784, -0.9746510570733453, -1.38926767486173, 0.45976868594939535},
    {-1.074161210230492, -0.5105244447972841, -2.2063074981503217, -2.473041809379604, -0.23683013822287852, 0.22935696885879198, -2.0891217869074414, -1.8741179545264646, -2.720777218346234, -2.1581337486055348, 0.8173594825852171, -2.079965500699405, 0.8052749324812563, 1.1056679508331144, -0.7597289819595466, -3.468140528901372, -2.4194076914308607, -1.686166446461188, 0.5709161060784396, -1.226813934977856, 0.9611299635009738, -2.2572469206332952, 0.8781773194971524, 1.3692732284605795, -0.08586281791296752, -2.032818329379076, -0.7839209293776247, -2.2932084869355243, -0.4499767228705643, -0.8032315697004798, 0.5585072658439891, -0.17519510125997803},
    {-2.6274868643273535, -0.6069502499451084, -4.673351780234506, -1.6410399826769084, -3.1915510288469373, 0.49161382371997203, 0.1689388909118134, 0.09421650548573245, -4.456682009283537, -0.7309867256310562, -0.5751052242411945, -1.1415660564888794, 0.8951999671786842, 0.39604606542596144, 0.34594942449855665, -0.5904909274966814, -2.8885259626692, 0.3877008794081831, 0.6828069175976853, -0.3756466907315231, 0.35877849168448245, -3.071770686592816, -0.22709044336794082, -0.23249055122169515, -1.645598820400826, -0.5185869266404046, 0.14798825947051056, -1.6861856083270705, -3.2997333502843142, 0.5235292008008431, -2.448320277896336, -1.992410546176586},
    {1.1555952417920632, -1.4029940345065486, -2.1189241558218623, -3.4250857280513496, -0.37183969974554154, -0.8492010808972708, -1.519766847294016, -0.10864093674854404, -1.9391625414587577, -1.5506637083580332, 0.65508526780452, -4.110858832428541, -0.8134236122663794, -0.1574923244262305, -0.9210989546828795, -2.4332292568852925, -1.5146879844017787, -1.9626832409367596, -0.6019743543520554, -0.5486826405838385, -0.8795275862263576, -0.018453665394142012, -1.0833049129505845, -0.0713157603913137, -0.9368148755830704, -2.480147212107257, -0.759863646252031, -2.7275040987796877, -0.47404898628773257, -0.784568894026253, -2.748382900322718, -2.1618166571073223},
    {-0.9034779620353138, -0.3164455612026965, -2.542031726058188, -1.210398965437196, -1.1589637933185122, -0.8985349102330832, 0.7070449644597524, -0.0425374049154285, -3.8283928882627145, 0.9632725122464333, -0.43715508063391145, -1.9385355104944038, 0.696150331542785, 1.4833124253587324, -1.891901153215011, -2.3802709395963486, -2.459582115190317, -2.3981385526130694, 0.8103510566016945, 0.31274291927962977, 0.08170847597495536, -1.7755220948978259, 1.076563993306156, -0.6113336675548084, -1.3437778663176496, -1.8900169760948187, -1.0883135600539615, 0.5384257291409238, -3.0175279299977387, -2.151256180378967, -3.6022464907916367, -0.6484569429676045},
    {-0.48478169815081973, -1.6508508385360523, -1.5206770137893295, -1.7776852364700084, -1.3485002871365874, 1.3055800458473916, -0.7268506633043672, -2.7597321071213137, -3.9617832992349102, -0.6050492634947842, 0.7428397874588968, -3.369736874773135, -1.3126967125250737, 0.1949237319941393, 0.31278144905838623, -3.0215725650406355, -1.4173173238447463, -1.7856920441809998, -2.316458713146498, -2.0216905024838168, 1.06519274812928, -1.8742047206932069, 0.5778761493819414, -2.1088173161530213, -1.272616947705475, -1.9137842394713158, 1.8253285096308143, -1.5892270990457171, -1.3923398738262764, -0.710629347098532, -1.6497956089910477, -2.2688212302161},
    {1.88441727932276, -1.9175249680669748, -1.5727138293853953, -0.4571634503002262, -2.423885593392435, 0.22703921940276425, -1.8592776660200119, -1.4462580337667295, -3.4494230843169107, -1.8065457556027817, 0.8872409091048241, -2.4947615013376074, 1.4452215000476505, 1.5235081421361503, 0.8687264127037214, -2.1217512365951867, -1.2684594799793654, -0.9697241480327731, -1.5268705903346345, -2.175226325541391, 0.07833519890802493, -3.7175087301353957, 1.080546167896386, -1.3972754235650973, -1.6559349282763494, -3.2860304958251754, -1.226383572888976, -1.802211888811595, -2.6719214846882995, -1.1490074344231613, -2.994702901632116, -2.4287050239281216},
    {0.599660328304982, -0.4405971251321002, -2.077694812858493, -4.022411921723951, 0.07594129436882946, -0.42411508868885534, 0.22706378043754435, -1.8924544830550503, -2.66704573419134, -1.4816997849279445, -0.8526549974752811, -2.56750609538402, 0.1929357213246815, -0.5696568398363309, 0.0019823697086709066, -2.3452746245293725, -2.4180670043557773, -0.9281504987609047, -1.492344650380715, -0.8603489310483612, -1.9217242590967978, -4.225139302638316, 0.320166301213635, -0.6963955686993301, -1.2639771592544635, -0.8841967449760956, -0.8512445203938213, -4.1154715912361235, -4.2778833242116745, -0.6299925608187714, -3.0538950682469492, -1.2557302896066165},
    {2.066320256504788, -0.43987167877028255, -0.8583894540286001, -2.74095872305401, -0.5710108725234275, 0.06358963658632956, 0.26355596311629276, -0.4930740500337953, -3.3864202026414523, -0.452787668935122, 0.12994065386144932, -1.1989886881835643, 0.0030259271933549994, 0.20246425071452576, 2.278468386813506, -1.9831144185119611, -3.0294055670288165, -2.226015304412112, -2.3106596810442284, -1.8462099165423207, -1.0995914356576042, -2.0632016115159217, 1.049626972309299, 1.458927528229431, -1.3373382513056737, -1.9372046015342117, -0.9860719591551528, -2.447789679618437, -1.1163883936832715, -0.4028082354546533, -1.3028802785372202, -1.0622072677482863},
    {-1.4176562339039906, 1.386638520346023, -0.34930259730675617, 1.1732225038100452, -1.4915498975195267, 0.004921848062202502, -0.1932218165268353, -1.4696006371456127, -0.8051005173239766, -0.553758126624219, -0.031043616803498382, -0.9048964777092694, 0.2859766029344301, -0.645700668631476, 2.5279316258290025, -0.6928499641220955, -1.9150537161097962, 0.23481053688229772, 1.246888143150753, -0.3005736162620441, 0.3877201096127913, -1.5316084257581521, 0.7742503752387772, 0.06030467991768454, -0.12340952801124547, -0.38964913738053497, -1.6501886678390734, -1.0368215167325427, -0.9601065951381839, 0.9416755238078158, -1.2970030304675195, -0.7322032994474366},
    {-0.48871566649991616, 1.360003420336143, -2.4885580451693956, -0.7589669468472666, 0.38990434846048067, 0.06183452547773979, -0.6268094649213857, 0.056004578789513565, -2.0794787891572244, -0.5159414083605626, 1.2455897353519827, -1.994136021413166, 0.6057604969994953, 1.0050698976112304, 1.7265693663758075, -0.27254335375415245, -0.7232591309675046, -1.3014224481128316, -1.0001177676474833, -0.1603600787750421, 1.4707954106649939, 1.3128568459311358, 1.0274192014044394, -0.48024287656167786, -1.001922163864392, 1.0488163742971486, 0.04130962193919193, -0.6742014643287598, -1.6006827592143376, 2.5017846743807155, -0.7436622952287579, -0.24183120989841314},
    {0.41723727947424805, -0.14801913195588223, -1.1055233919108327, -2.778501674469694, 1.272532338334498, -1.0117724836213084, -1.0600694481415538, 0.7583116686780383, -0.9062393757172647, 0.6989484084629793, -0.24392182334979634, -3.535987085213217, 0.9276356027680075, -1.0574335634608112, -2.3019857899060456, -3.0707370886297807, -2.6463438004033444, -0.4796577620178222, -2.846989636109139, 0.23643909025351553, -0.23565519161784151, -2.9018403175446235, 0.40167254876805475, 1.4667056950053865, -0.9165176237572892, -1.893088417892396, 0.14165466667311788, -1.4848772952142735, -3.4444758123962065, -0.2833278146508858, -2.374503003931217, -2.2154146014953686},
    {-2.002358193887259, -0.9191601295447387, -2.132698512760156, -2.8038563887953982, -0.3392022449627146, 0.5710425773030151, -2.0390294476061213, -1.5683173671000987, -3.0900910464629465, -1.6310089240432761, 0.16140577590188465, -3.825638740659009, 1.3177832072649505, 0.09182422520946303, -0.048825176242474434, -1.4289914013223082, -3.773105418262751, -1.3042541238765006, -0.7330001340879728, -0.6283622917238444, -1.5891814853832114, -2.290274475970874, -0.32773942925040717, 1.849659504286509, -2.1645215406741753, -1.6752070213705714, -1.119245130367458, -2.225251355534232, -1.4575535314578885, -1.6835358959609525, -2.616929299108611, -0.7439803054696835},
    {1.3998323755220012, -2.2195143292018216, -3.1978572503393345, -2.0299561699136928, -0.9722083961811642, -1.6226684121324109, -0.033715552916703764, -2.7041621650291345, -1.7681675864806243, -1.1757734189115143, 1.007108011428154, -3.3410150922779156, -0.051710528374103254, 0.33177664736852686, 2.1292961474815435, -3.72752694029533, -2.26856977201573, 0.6402061428642856, -0.3086188146568361, -0.038427053768847814, -1.9402562182603595, -3.4183974628773517, -0.7259611659513845, 2.1978828660409144, -2.3707253167688473, -1.1028942785735645, 0.12723314125118915, -3.7016364717318293, -1.7626431466228978, 0.12007672280055386, -3.591649908843969, -2.2785633328559243},
    {-1.1903832077587582, -2.9773324639726577, -0.4922840479385199, -2.7536344460824815, -2.932358136341328, 2.6959394993691306, 0.043186675846165826, -2.333620220440166, -2.179206972921826, 0.20578717442357464, -0.2422921158609132, -3.377264473380242, 0.26436558681092254, -0.4637135923245395, -1.564196721823959, -2.4152246748215127, -4.649972036077205, -0.726905604034858, -1.7613583604796132, -0.2810013152664293, -0.7626399882875061, -3.1134195459824316, 0.7187986549347506, 0.1576580088223505, -2.3019244811673447, -1.8467659700768693, 0.5013155667486064, -4.061745037051422, -2.1031206583841406, -1.3428803434618164, -2.7990448164767545, -3.1424333231432207},
    {1.9215306968850694, -0.011143780453881235, -0.928905337046621, -4.219414020371244, -0.00378441334833079, 0.5785674220948309, -1.0698307758429417, -0.38100102097613486, -2.2878591475737444, 2.089462113208929, -1.1523854856721834, -2.6250651900102877, 1.9854421094990373, 0.30053431562516153, 1.0410463559456928, -4.3260877231346, -3.2395862699535956, -0.19973823636972315, -0.5714510909205321, -2.4411981758485153, 1.511296780712396, -0.4400264647487831, 2.553005788875665, -0.30934652773648624, 1.0225528943887185, -1.9328513788531105, -1.190340619913337, -2.775686889449947, -4.646991528469638, -0.7820568458174441, -2.784414862658083, -0.18196688939549618},
    {-0.26499713615079273, 1.6264934518761238, -2.581865515304532, -3.6841279745690474, 1.0162023993880769, -0.7389624054362737, 0.490683061172683, -0.6608432766510705, -4.415700176686165, 0.950438167709571, 1.9949576657562935, -4.018204921286295, 1.885735139462057, 0.016658969824935612, 0.37110728296998086, -2.2192511607242995, -5.306511002876619, -1.5288967259984407, -1.7874860372776602, -0.5916833833868506, 0.7744422817755126, -3.2916133707176702, 1.828898137332676, 0.4900744754482938, 0.0035511434426834143, -2.6735478542473827, -1.8782694231750285, -2.572412151486405, -5.397283288293019, -2.2826236050981086, -1.211136533187851, -2.20158260319275},
    {-1.8950463042867158, -0.8373241868601463, -3.034923564628575, -2.3512239425070462, -2.60974540617245, -1.6225222989727603, -0.4477177080850078, -2.8716678112785194, -3.8697820718710187, -2.048646087706127, 1.0942530611225192, -4.1079384598545845, -1.0987602108786658, 0.18578201738614677, 0.8299324430263662, -4.187053714115282, -4.959406088081682, -0.2736843848669943, -1.5878892607425161, -1.8925647894192292, -0.061058215062707435, -3.7799927681271233, -0.059431576084408036, -0.17085839997365387, -0.9997603488374249, -2.891806362027964, 0.4156595047486665, -4.028410650047427, -3.0120169437623656, -1.6147126485666408, -2.236699454752457, -3.1545926071388224},
    {0.6486212141993294, -1.9790619681139354, -1.7037020937414475, -3.6185702213945574, -0.8553723049095298, 0.059389246944048645, 0.7764102584724804, -0.017391733773043268, -1.0475903303204248, 1.2335202982529188, 0.3537587831004873, -2.6927427098733485, 0.0034367560986119272, 0.8445147910655555, -0.1490550425781987, -4.187072206380289, -3.822466010953099, -1.452958222613905, -3.3605990065228717, -1.547397256576667, -0.872742477441153, -1.3079161507409904, 0.3920390477702105, 0.3372794351096023, 0.8769429702746194, -2.5862488141923756, 0.5707403028420863, -1.8757905639204842, -5.457055521100212, 0.4015878110979367, -2.2016902058569343, -5.380997976033003},
    {-0.8046843994319732, -0.7596733830781959, -1.428695302181808, -3.349623656722131, -0.8576590720932047, 0.8028903645179879, 0.15650148726105298, -0.23352852565358492, -3.2276395804991167, 1.5032163400494627, -0.07219775233556079, -2.7305846587974587, -0.8301064048222733, 0.08182393730332861, 0.9652071408700658, -2.4496083132285245, -1.919044872756915, 1.0893349596495376, 0.05257406372301597, -1.5684106519143732, -0.16771370228756402, -1.639284707932125, 0.48469536070965297, -0.8444818074957838, 0.7514990595540066, -1.1388253259798118, -0.33232204064841897, -4.726522270403266, -3.4345297210302133, -0.6780971809940164, -1.7793961734286308, -0.8978287138767954},
    {-0.020410173925913346, 1.0565417426505967, -1.931480915872043, -3.7836491888570296, -1.536535744064581, 0.5618416756222095, -0.01308158017973702, -0.6956244564804276, -4.269526397579734, -0.5328306360655878, 0.6823324541992896, -2.9931411675733806, 0.9256451203601045, -0.287506409862221, 0.43502352830104146, -4.566792187907357, -5.173705267468712, 0.5232225380414528, -2.518818479001137, -1.3698612767516785, 1.3753366935792037, -1.4498490185848998, 1.9844907475915412, 0.606417183909553, -2.3412709347938185, -1.7261685665393718, 0.256462985034285, -4.375593071082957, -5.61514832428719, 1.6713827449918925, -2.4436930424955254, -3.60112986681501},
    {-0.2673687375020231, -1.4119121496143456, -0.8260346523086792, -1.2160805283757385, -1.219273203746232, -0.9231842419859357, -2.6566141075882514, -0.6643949115289177, -0.39272969862063234, 0.8264936070058971, 1.6962176588349946, -3.467943580781078, 0.18231026294875963, 0.28268026471311664, 0.428113739389033, -3.4029031217181105, -3.7900856092322392, 1.8655783264818966, -1.436491452268634, -0.9871532313319559, 1.5047683146842963, -1.211018757796617, 0.7935263995139554, 2.333423853400973, -0.4658017059993246, -1.848938204289195, 0.9926862322590272, -3.7415261015533563, -1.6924185388843436, 0.22655650157511378, 0.0507859106513875, -2.3631544326126948},
    {0.20577013330420085, 0.9108339527391137, 0.7982338898875723, -2.2426881431961716, -0.791433209471747, 0.20344060305784234, -1.2071138601850018, -0.657392682846718, -1.3065301291654106, 0.08577185707084169, 2.505241365985878, -1.7211626206343922, -0.02282039591941989, 2.2982507162434476, 0.9748210957592124, -0.6922846417027354, -3.3736140206592897, -0.5550534622063394, -1.7869632923025178, -0.8978994604606713, 1.363605764645109, -0.6451866977733723, 0.5683734003922633, 1.961726566245943, -0.562007733408341, -1.1410493233952521, 1.4664056662785836, -2.8771062954407656, -4.312422151278865, 0.608581534674464, -2.660400363953386, -4.286530614677826},
    {-1.1638127529614608, -0.5381906259350387, 3.3136656378069658, 0.9221847659481744, -0.014325737539497037, -2.3728096122113613, 0.5107027450996763, -0.8302848846545341, -0.45054984383795205, -0.28584670896587683, 1.7899940065073947, -1.5404188776040533, -3.0435243935582528, 1.88905596908434, -0.8169448760156752, 1.1601509641135161, 2.411674204904878, 1.1945195711980343, -1.3003332435610624, -1.9487170444948443, -0.4993425267605952, -0.7166915756304025, 0.5612211187555542, 0.2484085875227418, -0.2666984934495741, 0.9399219035376256, 0.048023131526478906, -0.6396347587474077, 0.8058168105733147, -0.4697342539171265, 0.7873724499935367, -1.3202450906629124},
    {0.015628153758810652, -4.2999783685428765, 0.14525741654822155, -1.0282481199332631, -0.6916854844145456, -0.1613092553953598, -2.709154793931586, 1.506299165026664, 0.21784172268357663, -2.7287476540401943, 1.5860505349803014, 0.063662426660405, -1.6930912030807677, 3.289902269134442, -0.9724825626745561, 2.219157014737398, -1.879238549339985, 1.4566630472963817, -0.872754944594977, -0.788830973655072, 1.3552010059766846, -0.379433871532528, -2.0854363308792396, 2.7915860592405943, 0.7094677919098823, 0.07872928797447705, -0.6156769580023496, -1.204963769762582, 0.9778843952596364, 1.2675714380532135, -0.8607503917627837, -0.8282844630164231},
    {0.0020353943387301835, -3.4055764301773435, 2.0216423418473672, -2.3654425059832773, 0.13890599595085473, 1.8323801051658801, -1.7563639532227333, 0.7331058242566865, -2.3695409849431286, -1.4192989679832666, 2.487302250338692, -0.4030316833748752, -0.04676164700176594, 1.3253575308716026, -2.002534088380997, 4.20922663809491, -2.6853369602106856, 0.6479028917310153, -0.5956426755046624, -1.7234763075940984, -0.04820285017473493, 0.4159847179520726, 0.5320010108509301, -0.17005107212248993, 1.072567157088739, 0.9386804601858093, -0.08490594103815914, -1.1108195849955864, 0.1910617029241768, 1.7465497784818027, -1.4059481085712018, -2.0148627234284886},
    {-1.2926136063803808, -1.4800579438141819, 0.21189615202833093, -2.4363886982587863, -0.9790067482065661, 3.221570877678366, -0.21331843933917713, 0.7756954622019909, -0.5778556751751142, -0.6363436924507926, 3.536418281066171, -0.15162486292960656, 0.8451927183706965, 2.15143605540006, -2.505005607329, 4.018703798114098, -3.044737643630768, 0.4925042470143165, 0.73485626502099, -0.29303282734368047, 0.8304874109243943, 2.0377774466492107, -0.7280793114998287, 1.0376176360175158, -1.867096131551407, 1.0798785981881731, -1.4335391851409651, -0.15115324195082705, 1.1049815299159227, 0.9910155653135645, -0.5137674232888899, -2.9687458590838043},
    {-0.5426191377386195, -0.21088941743821557, 1.0635154999221725, -0.558773103266955, -0.17840302459463245, -0.1304619057759936, -3.7584189796296474, -0.5436269022281671, -0.3950273068012079, 0.6847038112892402, 1.0514697860847484, -0.42896053164050046, 0.851994446560692, 1.3329273079125774, 0.25488117478615163, 1.872095329243542, -0.860924278428002, -1.7164580912039022, -2.6741428280172257, -0.5740187394029236, 3.1844302913453144, 0.2041959298746198, -1.1660713399801008, 2.434701847074181, 1.6334380384227323, 0.8286980239363754, -3.1637217628369925, 1.1651599625675881, 2.047772772377755, 1.0931715736971634, -1.882325061075242, -2.483652498178353},
    {1.43197187093343, -0.16847703114596752, 0.2784804052818322, -3.780882645677522, -2.4794421645331943, 1.3864703503522082, -2.0117954242869986, -1.0874363982858877, -2.322709541938791, -0.28339188676607996, -0.1538633062602405, 1.161410978949426, -0.11178170098648224, 1.179939465740163, 0.06502051784483756, 3.646062159535966, -0.37482580325325027, 2.360301996532756, -0.5660575620824374, -3.446713539296141, 0.35191315767441844, 0.6251064066780145, -2.8872263294896507, 2.4726199879324007, 0.34567660744882833, 1.0339283182181547, -0.5761631521571314, -1.6444588892197123, 0.7269884141066567, 0.7060725676522251, 0.5395716409271478, -1.512967928857411},
    {-0.08181323422726872, -2.299735664794097, 1.4219728765998523, 0.774099585631216, 0.4964095860798698, -0.6973164164309432, -2.6729522224386555, 0.3687811603848789, -2.290208448567044, -5.012126359454818, 1.6091316083124123, -1.3430134780683476, -1.334606218126891, 1.3455969659381404, -1.9427049194851835, 1.5261007648098082, 0.23765695856231947, 1.0784068774141142, -1.1125599925377971, -2.0683144767451362, 1.0184065722030493, -0.10556412434918006, -1.6773897360363037, 1.3236106790858895, 0.10714257988295646, 1.859019280573536, -1.2731086338921613, 0.5010995417168049, 1.8331736170778679, 0.5356901865463664, -1.4179399610818548, -4.702900590105594},
    {0.3179427172349337, -4.165864228127478, -0.024030656397943623, -1.1772596347786777, 0.28873939822046785, 2.058464655849183, -2.7203250650769966, -1.4673505691061015, -2.2613724098367225, -2.036829177830655, 1.9102364342520015, -0.21843646449986504, -0.10445031385041922, 1.7709840205799767, 0.11417497891034929, 2.8670601784680523, -1.6708338220230639, 0.27979557679251826, -2.4159365005658477, -1.9707914656062393, -1.6759285164714688, 1.4558026632357652, -2.504713985698923, 2.1129155845720997, 0.7228079307557836, -1.2134868691082636, -1.6798895008378725, -1.851668158357562, -0.45997080135601504, -0.5631619152985046, -1.69876725971814, -1.0328878706679285},
    {2.80052051709949, -2.841327006721609, 3.3925270834530408, -3.215139126741386, 0.6455288894466081, -0.3592911504074365, -2.4063740813356937, 1.0860666682762175, -1.3350806057624007, -2.5892399654521236, 2.8866453534913887, -2.3402677380074985, -1.6816748163372315, 0.7203479092755305, -3.6158444571102533, 0.18465097391024218, 0.1734734024704597, -1.2266950795423275, -3.677271295436131, -2.3794317351713237, -0.6571102473394609, -1.1078606774763329, -1.1853515991935186, 1.6357858685319913, -0.6551469693462311, 2.63476290750438, 0.7770429934569498, 0.29400662384126686, -1.361970110763722, 0.4681965020992711, 0.8585876669264648, -1.750687743817052},
    {1.2808473608881163, -3.9148510226072877, 3.324766957450589, -1.237397001385625, 1.2398086950727867, 2.929858481548407, -0.9257337592058773, 1.764476260647155, -0.6661849561015953, -2.1843974028418636, 3.235203958985353, -1.7024431066140873, 0.787066021076754, 1.818254263655279, -2.2222075170274116, 2.3292576116741923, -2.3297698465525705, 0.8969245195891965, -0.3830398114484348, -2.29817713887724, 0.6158499439668146, 0.16679847669155418, -0.6747607603864803, 2.274953478420704, 0.10385867357287284, 3.256536727076416, 1.758858574356654, -1.3459899337216523, -0.9766594167065805, 0.22320915379970474, 0.7515184682813951, -2.007400696978233},
    {-0.4117748835799108, -2.8354542400254052, -0.0483800993202745, 0.09214509524743035, 1.0323676395875538, 1.3393470807642518, -2.615074991224533, 1.5404479601623275, -0.6131868364749525, -0.32183688695664686, 0.5788495537349653, -1.632559445206466, -1.478683252502733, 1.8302273317523932, -0.07930877269801027, 1.5375344581754953, 1.3596970190177624, -1.1576683239309862, -1.0173577391325836, -2.6666448712321698, 1.855035095478815, 3.225987070208642, -1.6979682236739082, 0.35707466383538167, -0.7196670788894416, 0.08605347283871402, -0.9999786376341141, -1.2978056889055058, 1.859449212837931, 0.24023316410018442, 1.3924691433664658, -1.1245610218238848},
    {-1.3938786482182544, -0.29627882209419576, 2.164640031761428, -1.996835583380886, -1.621681785209309, 3.60780361288174, -2.9269845149042077, 0.29766742650803446, -2.7833135867992773, -1.1550945603960878, 3.467760386791506, -0.8438923880788511, -0.3995900538504582, 3.108246079045457, 0.0012712379202974634, 0.8184918594157647, -0.01988047585406021, 3.9269603112735547, -0.665820503666984, -4.575094311017338, 0.527453715318024, -0.0882582807477659, 1.555924046428258, 0.6880789507521932, -0.22838750192579332, 1.0285684269230988, -1.0474861718366368, -1.0015390527272605, 0.612333501592437, -0.2852909420076482, 2.0456441356053565, -2.4997616385361674},
    {-0.4898204868939532, -4.237966600026032, 0.08992126424894331, -0.8452717424550777, 0.1207268586888743, 3.085566241479968, -2.1911571509074204, -0.15674649538742197, -0.16908550577016082, -1.5998758462406428, 1.9882235545179814, -1.5322240632131756, -1.8650642335268006, 2.9100088432195452, -1.116377988788222, 2.524587032447967, -2.1569519028393183, 3.2059149446420876, -1.0907674904685039, -3.4344488880507824, -1.4004239355681312, 0.5532798771171813, -1.1068503884722984, 0.1400300950440219, 0.3012664076813279, 0.06440117778283445, 0.36342510112642107, -2.4626205820338742, -0.6328645750890116, -1.4211487232874485, 1.4185231674852383, -0.46087395805329284},
    {0.3310941603344222, -2.0988819595652712, 0.31484312411317206, -0.10650913565179158, 0.4890024627082338, 1.6925237695152013, -0.4591047507700176, 3.7670814487830784, -1.6969200131190976, -2.7085020954916095, 1.109615347639122, 1.4143059001865965, -4.0632972343856295, 4.529273137431491, -1.6402070335630556, -1.0595552104432564, -1.325879198361946, 3.779220400000153, -0.04256469158959765, -3.185444188967128, 0.307024734614307, -1.2005907700891452, -0.6698488790282916, 0.20129658228993016, 0.04185801030937272, 2.6004146953531113, -0.5577100920678282, 0.9510218182865069, -0.02669455747862218, 1.8394563179218082, 0.3607223891933786, -2.4573942803447575},
    {2.4422452031566073, -2.28425555537776, -0.74978929545863, -2.560815960505895, -2.3175665763303965, 2.132021033818269, -1.2750765648653455, 1.3605318879473738, 0.6440246879186661, -4.247581192917363, 2.2014777203689935, 0.07590388876776166, -4.581785913296261, 2.110466979853192, -2.4408157770890617, -1.3432584999200552, -1.9328002818043675, 2.7693628718483447, -0.41272953488677183, -2.1192823561299017, -0.6662843911839139, -1.2458225519717825, 0.8558345509160699, -0.4255024373807624, -0.08474588713306377, 0.9176642154858582, 1.3636887212799151, 0.3774366270507028, 0.41255103532101434, 0.6686893581006328, 1.7725234823395697, -2.05123514006097},
    {2.620170574233304, -0.7460257261080673, -1.4236963493654105, -2.9451735028167123, 0.4595223239355303, 2.0125095555587333, -0.11545276875226552, 2.999816402931554, -2.7003444676723647, -3.5948408930039406, 1.1453218513418808, -1.568377930782904, -0.7421187823501213, 1.4429435722406179, -1.519856617799391, -0.9844181163168565, 0.027567879863701693, 3.2171959153228706, -0.6602245391667745, -2.3628840424070847, 0.3044028869362288, 0.0044532095072501825, -2.7515294551499845, 1.7161557361238087, -1.319822542174183, 4.657488637545758, 0.9304547813981019, -1.9325071298377516, 1.1752175318131541, 0.4637034440663211, 1.5948912547791527, 0.398002509188237},
    {1.9998983499392924, -2.4285893408289367, 2.716594919571404, -2.764491081205229, 1.273936578366096, 2.3629953840363815, -3.910307456261356, 2.518881879787254, -2.9675031730687906, -4.22364069835565, 0.7943921672729487, -1.9321786326842085, 1.654972405363894, 2.144686879326195, -1.3661630207909472, 0.29522900099662486, -0.7228737288406354, 3.3052332620505833, -2.003912462879095, -3.451706327140999, -0.3451083779781066, 1.1383075330284809, -0.6795034627627354, 3.8394099875893293, -0.9882764619569631, 2.3557177303498333, 1.2964763800262114, -2.575600521120791, 0.6084892465139509, -0.5459205116472357, 1.0233970595481672, -1.5468319176456937},
    {0.3502344380360361, -1.558298640543733, 1.7224711781302762, -1.347852930614787, -0.0259928580792884, 1.3785617148411577, -1.3543980585973443, 2.9307978703560638, -1.0065917472412582, -0.8680811785066788, 2.453214997931343, -1.6396275405317917, -1.7368821207048362, 1.8161697922471989, -2.0499058021977663, 1.6237800779397629, -1.7060518936695173, 1.5011916658915527, -2.4773514854497236, -3.3592884443134863, 1.9150842509002062, 2.305628720142546, 1.0162050064749193, 2.180605311949968, 0.2511408166245505, 0.5808125205274822, 0.16152706697944436, -1.1035417102594327, 0.737306306184218, 0.09102652906919305, 0.31424796837488694, -2.8934498920884995},
    {-1.731233570008947, -1.6461439818676638, 1.4744816860804295, -2.5281162606143734, -0.7789835138817943, 1.1649496981919683, -2.9703575261471964, -1.0663004890103345, -3.29602099775685, -2.690543070940499, 2.294877591650387, -1.856300319895106, -2.1256208735017004, 3.374158582165172, -1.3369348804949726, 2.422995112211517, -1.7479948549051754, 0.3759609451292625, -1.9435017737388192, -2.8470510406921283, 0.18767498328837476, 1.8211391942722064, 1.1965495332823295, 0.8858424062692226, 1.0974837034221476, 2.6847518154735885, -0.07121919403345313, -1.6723088612394186, 0.654520449356145, 1.4370611937728002, -0.11131520672531667, -1.1286404330187896},
    {-0.06303874312980895, -1.802594837444943, 2.2809716164618217, -2.968203825797092, 0.3788757569012894, 3.0997578238066965, -1.211162690506246, 2.3429945730294346, -0.3892368319356098, -2.8959371918851833, 2.9999513983271227, -2.050298863030285, 0.015275109050275393, 1.6029424993814934, -0.6911417583793059, 1.1117790362487203, -0.8142193482710052, 2.4993772286602205, -3.479893806179057, -2.207775483481957, -0.4986903498034486, 0.4194510040946502, 1.532048915268194, 2.3014461545068694, 0.3412544249340318, 1.9507001736784129, -0.30286133248645314, 0.6560576836713028, -0.4669873732761338, 1.1516972655535491, 0.4664991960588648, -1.027146765398168},
    {0.20553463221858773, -0.9871843977723403, 0.6200781249607468, -2.560629386282616, 0.868802010315196, 2.2954941253412735, -3.4686121520851554, 2.8070306427594294, -3.021225120857884, -4.475932780830049, 1.8833142235953162, -0.6816406859898262, -2.0460639783748027, 0.1952821152198408, -1.4287013200025023, 0.9057889356475177, -1.213473809842556, 1.8502350044544105, -0.13713018520205092, -2.969641848837079, 0.23136311907383467, 0.6857486297473447, 1.0340962898037347, 3.101560767526718, 1.0958880705925722, 0.1639301962812086, 1.4358534564805683, -0.09653001632302616, -0.7482302647416079, -0.43723849857136615, -0.005193372181400811, -0.014473036702041775},
    {-1.320877964409147, -3.398689516767678, 0.5861011852789072, -4.090520749510508, -0.4220662646479686, 1.579209006908225, -4.354403244244994, -0.06921125788320483, -0.17747704134430106, -0.9210230536362164, 4.832147209348014, -1.8290292076166872, -3.6740225091212517, 1.0885567183446556, -1.9765089733101586, -0.2837837345893613, -3.5310780363304874, 1.665456883591929, -1.1130857855490826, -4.817571777946898, -1.9021864750815225, 0.4372457951524365, -1.6689608583566402, 0.5046966135009693, -1.3159676927790904, 1.9134005338873374, 0.23241587409421902, -1.7129332254741854, -0.6552135645596044, 0.1756935827446697, -0.38341063555209587, -1.7824045065369545},
    {1.8207223882344754, -2.576959193090116, 3.289337956767439, -3.8546929805902153, 0.35744602709714485, 1.9127788290751495, -2.8250836676909934, 2.0058866365547336, -1.9443464144985037, -3.4207584101113198, 2.4923994402544345, -2.3609521765057595, -2.872812380112129, 2.2276763622531637, -3.3559433722796315, 1.3475675971771301, -2.210180943361233, 1.6199036777013816, -3.0946289382432974, -4.2082406396489755, 0.040547442731167505, -1.302335334083162, 0.3567587617980021, 1.2453980852636943, 1.8896088111878786, 0.2453570241665688, -0.3474965772214551, -2.8673742598166654, 0.1878334840128989, 1.6655610383106791, 0.9719896415571122, -1.4530209294564511},
    {0.5539773883137649, -2.5191956468231838, 2.3844422609078944, -1.4383420646994196, 0.9246316763181782, 2.443370920041758, -3.0179461592292864, 0.8153243633824142, -1.9724256266888363, -2.8958750539939615, 2.4232978303265353, -1.0191032986091428, -2.931585290489831, 2.67323504667826, -2.2837374589983384, 1.8510511795357796, -3.1970768438637727, 1.422174411677647, -2.1121353418721043, -3.909358254428234, 1.9081347577013075, -1.4542993043176395, -2.2871236993226454, 0.27385938097102347, -0.7968481495768972, 3.559167826190236, -1.535437877227982, -2.875404208940317, -0.2468335975117162, 2.4057981218509163, 1.2442127320879237, -2.5971541459565453},
    {-0.10955674019086488, -0.48270444901837056, 3.121715819742285, -2.2390476251238596, 0.5674983736576309, 1.894882592370087, -2.2016780879655586, 0.46100221286170856, -1.7456377917616224, -1.1342988872577004, 3.0489995777679026, -2.2315326514855207, -3.237288558965744, 2.93512400062341, -1.752302895947499, 1.5638973134618988, -0.547580176857332, 3.332610294107363, -0.7695425504258457, -1.961953032352244, 2.779899368686942, 2.5068720864055942, -0.9019148127359009, 1.1353699269428439, 1.7790330332109079, 2.827245178084364, -1.582500323457602, -2.907855086991957, 0.2959578974983123, -0.793697893070246, 2.2488633494744246, -2.279630102134841},
    {-0.4799496924118184, -1.7861054829303153, 3.1035557228533883, -2.6087898316851676, -0.7800458999166904, 3.015742806625617, -2.5418637796091494, 2.542193633730342, -2.2032226486251716, -1.4046582705275314, 2.8390911659688114, -1.2442198280613836, -1.3004861556349105, 2.773745448875609, -1.604172715813825, 1.6634024538624317, -2.152119113655758, 4.3737603871660955, -0.0639536571617522, -6.281471362706255, 2.3806914979194387, 0.04474981838331369, -0.811882573939119, 1.6610254467339902, -0.31117303910329736, 2.122208359265167, 0.8639592232783683, -1.0868269969028252, 0.38087962127747427, 2.6194884241039604, 1.902370385451704, -2.254378589682394},
    {1.0629853840615542, -4.206491354598435, 4.301848602837839, -3.280366572689143, -1.1492369105586202, 1.0862427872050733, -4.097548279292325, -0.6813227295112008, -2.0583158290980834, -0.7800471583854535, 3.7564759188793557, -1.8416958488897384, -2.0257606427856683, 2.573293116799248, -2.4215072042729964, 4.122300628135906, -3.037176611654381, 1.6962419688939712, -1.8498022093968916, -4.032104198133287, 0.7625186003773856, 0.44208167254908454, -3.7635070469291345, 2.9429676507500426, -0.38725039143221934, 3.2908783460297584, -1.640696045883841, -2.0167151262244736, -0.16544854960681557, 2.8209047777623693, 1.7335151239993052, -2.3859840501650753},
    {-0.006682802160326825, -2.9117783156621506, 2.1951762302178706, -4.4526292827237866, -1.3152246444035314, 2.2971439069241724, -2.3630482201208567, 0.8774443016647843, -0.7197858173728529, -4.2357752884608955, 3.888263819282124, -2.995105699974262, -0.3651609348475794, 4.048782685135861, -2.243718952841625, 2.2468385685503827, -2.269263344950923, 0.7971253178707686, -1.9027382750463973, -5.942026204212577, 0.45125564088399744, 0.9197139029084846, -3.0832968849800717, 1.5077124955798917, 0.36705749533771614, 0.4893428160740828, -0.08828652963145144, -2.6032253894188644, -0.40479007983688853, 2.1719488273124488, 1.5052797426543916, -0.22831134935213263},
    {2.573927982307223, -3.406924148371693, 2.834635409486025, -3.4456647175487065, -1.1963513040239506, 2.7579616130574767, -3.4359558793361273, 2.8894294840441517, -1.9416075592706108, -2.9141074614396953, 3.522047553945666, -1.8029747123362434, -2.0390437126178638, 5.394420899644239, -3.126669246168779, 0.8846968783751203, -0.5614609934303061, 2.2956594705003224, -2.0109052263064013, -2.6375341795591214, 0.82162300138758, -1.5753740921281794, -1.3803946426864664, 1.2056494683774812, -0.46705278679443746, 2.370982720687636, -0.3574501112687205, -2.421130475584602, 0.6296319089242292, 0.5464359742353165, 2.290627680806028, -1.153437629090073},
    {-1.7266561491529913, -3.619184664987036, 2.3217530481715216, -2.371405972292811, -0.09658833955833543, 2.587300960963131, -4.917653323484088, 0.6425914053145353, -1.3740740847347468, -0.6341391380538944, 2.461260873099996, -3.164072213206558, -0.9422902232792512, 2.5598995653263517, -3.346396447979113, 1.199962362665883, -1.0349097783388033, 2.3010872270255285, -3.542918463758594, -3.1253068093099743, 2.6659791359797906, 2.30276354325197, -0.4726374123368683, 1.7587370773258308, 0.2614177564683764, 1.4193324356505697, 0.9351380469368318, -1.3814354095931096, 0.002375986047889701, -0.22492923361496697, 0.8792978092612019, -2.3305435866399473},
    {-0.5441939251932781, -2.6881747751788354, -0.7571154463987749, -2.599730206128626, -1.394422226576541, -0.871695109487695, -1.45631866619268, 0.8343642618936046, -3.4881697330942356, 0.29242872919043866, -2.171683395755609, -1.5706165310959532, 2.0585543885515896, 2.2716285489624677, 1.098065972847266, -0.5356932096092085, -0.15749387069732182, -0.9062151536919874, -1.102820775928794, 1.2494904752761142, -0.3836077764282889, 1.3746315107132616, -1.4816264158982995, -0.7045601925242827, 1.4327891677870037, 0.7950941655518593, -1.7615537425992205, -1.969301180975409, -1.2865670007333205, 3.713516109971348, -3.9357073120820143, -1.9462050714763692},
    {1.0986396340476097, 0.8854542434592845, -2.119611418935314, -1.536118983002472, -0.5961007522345214, -1.358602012833336, 4.1729104561889026, -0.16229290070983982, -2.669515524250438, 1.576819511297159, -0.21994001155776516, -1.3790027684866955, 0.9453767690954983, 1.4850863303119488, -0.1372871674195535, -0.7058038696163622, 0.5393751875930692, -0.24814250856168724, 1.0003629383987456, -0.6035034975496881, 0.01244800706199611, 1.246406720176083, 1.9795754110711583, 0.46366302135936427, -0.003069908771092283, -0.07761280704398484, 0.33489447858285726, -0.8282500994358378, -0.1397097314675381, -0.5814251408161081, 0.22710632922644092, -1.848315377319661},
    {0.4228505141452385, 0.20633157004037958, -3.313225226445112, -1.4932132461101981, -2.4319108117477395, -0.5794004250509976, 1.1996402068639993, -0.5214944908714165, -1.4397351062461814, -0.3966220836555155, 1.1370305940049072, -0.6824267660999571, 2.2689955311029144, 0.6392013009286945, 2.1920120064890463, -1.0917709337531372, -1.5556889806125642, -0.9267539606234091, -0.05497738661322221, -0.45144061976502514, 0.1240858441374268, -0.8906654875501053, -1.5604849347335057, -0.528953362157411, -2.179248124677123, 2.035587942103494, -0.5021308562970311, -1.7667235239495314, -4.795944421911459, 0.3271941842023008, -3.5069629627257135, -1.0320136657245513},
    {0.6203538851879987, -2.3206266594221474, -1.2706371408096597, -0.23591624401803865, -0.6785856757359294, -4.58162574900341, -0.11110915268705883, 2.639693157242612, -3.453808072619791, -0.2409148433616467, -1.4407262583614484, -0.6325027616033854, 2.1376885765092104, -1.213233072401349, 1.8863506701091397, -2.0746915927454257, -3.8070868456041342, -1.1988417292763305, -3.2861284610660446, -0.7197859622924032, -0.1787557860714654, -0.08685549037751886, -0.035288942449126434, -2.2576494782726546, 1.6692337895915546, -2.040938409753296, -2.291366987643715, -1.8156157673016973, -0.7824690753375899, 2.5469192609266385, 0.4202956110907684, 0.356108680973641},
    {-1.0884445189880727, -2.206729174569291, -1.997481804470122, -1.738803973416656, -1.5708219564890897, -0.26101183399574385, 0.6888852903766249, -1.8200590234312122, -0.7415490613972738, 0.020056921932748863, 1.103560860630681, 1.0682808541504885, -0.3147782725190989, 1.1482866968049907, 0.29544588681017153, -1.2544819262739308, -2.0883208611882145, -0.7938526535970679, 0.28826948970683663, -0.8250325871295886, -1.5557463670519458, -1.592379710678632, 1.4336315206823145, -0.09078619326542106, -1.4441827203890631, -0.11650700120361793, -1.727702520978905, -2.182738391039047, -0.5642703948326204, -0.8898162712007167, -3.5783640074751406, -1.3938977475649923},
    {0.841872046006533, -0.08992841933750946, -0.5255627754666671, -0.21250569007430364, 0.5766437458468354, 0.9929333943175085, 0.46106468930074984, -1.2566568505100173, -3.9612914130954358, 0.3494766721971411, -0.9358264593742069, -0.43772548797100935, -1.6507768825229832, -0.6020473100659386, 1.5393539484223577, -1.5610421184801082, -1.917633636045642, -0.8549148868426719, -1.035977564174207, -0.7054352329854523, -2.0899238740358, -2.148430580665959, 1.185796313430223, -3.0073382154754587, -1.4973491657394713, -0.9642467937069468, 3.0149051621591485, -1.076997119980509, 0.5046895355417437, -0.9730149847192602, -2.985418345293463, 0.15076940764349894},
    {2.1671661921406358, -0.9851281857455141, -3.1217815728469462, -1.925511700211788, -0.5815433558715629, 0.9921472011486794, -1.2128932968794754, 0.5156106295133746, -0.050935705173683926, -0.6714078097783439, 0.665485490898231, -2.0932523417282183, 0.5321892433586111, 0.3620821595030513, 0.6024104515361229, -1.853122844422392, -4.385304047882555, -0.6818580797439786, -1.7134099990436795, -0.8137180474714447, -1.9030023929053264, -0.9717295588026441, 0.9544290465150673, -1.4414724070784177, -0.4527402370766485, -0.6679373851940731, 0.591500524293736, -2.628010242362927, -1.6182582419321425, 0.2890705450707325, -1.709854238133237, 0.14454996659086558},
    {2.98554345416134, -0.29686384633678237, -1.5184007505117432, 0.06471657301774957, -0.7496972619763831, 2.8721290446983283, 0.1860367211516121, 0.5349637865627992, 0.779960999744277, -0.5509802815171316, 0.757125289707468, -3.881155644307009, -1.1456557876327462, -1.3503077082256765, -0.044046646097998146, 0.5748594071630576, -1.3834291504821294, -1.6619440842698943, 0.38589594559065443, -0.2995074248494393, -1.0973418238262018, -2.0044843331679814, 0.5541319643853198, 0.9801266617657245, -1.92042511119413, 0.5663105130626184, 1.1317917823546788, -0.10846582380750551, -2.8882547789130912, 1.53580574575139, -0.3392222282891262, -0.07782970130468282},
    {2.037604860103616, 1.5581776929511966, 0.4142625398617916, -2.768832943084184, 2.4325929727532243, -1.2561387840678049, 0.021490068237028925, 1.7681739275555162, -1.3997314312898472, -0.3229026783968479, 1.4057440092520852, -0.6891762185567845, 0.21318061296330296, 0.4697743264160387, -0.020046866585965332, -0.8261207408628954, -1.446838001785862, -0.9304927970560479, -0.063568565598239, -2.680934059401353, 1.7210132003094083, -1.7166289044135337, 2.049242459953773, -0.0666880308019017, -1.2772704926337006, -1.5217461114121407, -0.2427344506126374, 0.2603299838373431, 0.8866167609836302, -0.5695996329908852, -1.3228911376601735, 0.4220586993375565},
    {-0.2031868021369449, 0.2619361478479997, 0.1092126217963365, -0.40052134463311195, -2.3340536383798267, -1.3954901732849796, 0.7521903971718628, -1.0125066856170881, -0.5581107677776584, 1.3937792236967235, -1.208799259673029, -0.5725285483851026, 1.1675802363336358, 1.8854613456026568, -0.5199524245832684, 0.3297961064507177, -2.0387102398629353, -0.7762456909465251, 0.20015816754526145, -1.1466621570988136, 0.8609950270112251, -0.8073860334847709, -0.6930522928721129, 0.35306004451749323, 0.36386042320731826, -1.1847047262016637, 0.05897166508091142, -0.9438787962085929, -2.296582250169409, 0.929048612525954, 0.7596717093511279, -1.4520387200426406},
    {0.4878313480444881, -1.244994270193289, 0.6927023515118717, -1.3631299818215539, -0.7972344539727902, 0.48645551474437737, -0.442110720787667, 0.21668050302649755, -1.961042203898311, -0.7536044317291772, -0.45867850089604434, -1.4181367641353555, -3.059184441154821, 0.4132926962193594, -0.14186158261250645, -2.8989884310458796, 0.8256414091361606, 0.5980421997916315, -3.2928634065648024, 0.9688875980461799, 0.2886218086867364, -2.3174552127097514, -3.3029657124631906, 1.793955434815428, -0.3487137400075481, -1.420122150339067, -1.2110459712035286, -0.9866116007307425, -2.7910573292792162, -0.6499038265487983, -1.4284990950927043, -1.5918081874768955},
    {-0.27017048208592376, -2.6573147461988094, -2.369969759982503, -3.72159614322502, 0.37069894127261566, -3.286981702615482, 2.6607515682388345, -0.8150236411373045, -1.2915646704819492, -0.19665831778675746, 0.8287720867598531, -1.8326507250083237, 0.36972920858752967, 2.4315553992424053, 0.35817755510108884, -1.470309347788949, -0.07208572245407475, -2.3995252748217273, -0.768387646811973, -0.9749772053090683, -1.9252624725268899, -1.460181081895684, -0.981983238613294, -0.3256442404126643, 0.4948717253752881, -2.7060556803079887, 0.71829410569404, -2.7475893751959926, -2.7269886129136, -0.31493827455105666, -3.7321756157230723, -1.0024943889755846},
    {1.3848619408847613, -0.3553070213595337, -1.7948525870951981, -1.6937152266733562, -0.7220856991257869, 0.11529170143719202, -1.1765256525992371, -2.3072604143517172, -0.552965909719455, 0.5656977557352607, 2.228392849472541, -2.6583625876778223, 2.332153123896053, 0.31556936103080985, 1.4871960633851855, -1.4074288183719967, -1.5490169294620335, -2.094992203429095, -1.2285729620900059, -1.4017559176911991, -0.9342902789932832, -0.6307564447007614, 0.0016386159918513868, 0.6568693870903461, -0.5140606570179083, -1.9266278382872348, 1.0618063202112171, -3.4604153433684157, -2.4130471206183115, -1.843612922811218, -3.089662776441358, -1.1756299282872793},
    {0.5216358311978302, -0.28754302834725276, 0.11162794965373274, -1.1415117806198205, 0.28602055915942476, -0.10136162491389099, -1.6283988980395614, 0.7880622499020149, -2.0044519347339835, 0.12427810786512385, -0.011460933512860963, -2.479561397323567, 0.2208621519883725, 0.13587265020565142, 0.3581797284386953, -3.942769226068489, -3.4661377253730805, 0.27702132344203206, -1.6459382577280426, -0.9811830171155934, -1.9967452856488306, -2.776579283861408, -0.8665221527573104, -0.9992820019577562, 0.012694209524303838, -1.4165134043709013, -2.077925098916659, -2.797730002036042, -2.251421970494361, -0.3832367768000824, -3.1717750651490606, -0.2194876714405643},
    {3.831320419818225, -0.1321309722466511, -0.5323362803430977, 0.0227356479275141, 0.9588242407480659, 0.8544984277378287, 0.14002476959262602, -1.1006941890374997, -3.397970781033491, 0.11176600124398293, -0.8640659196438772, -3.3491410685569, 0.09539984999352843, 0.3872539450749856, -0.03139808728600377, -1.2610195482182356, -2.0335417803651445, -0.47443990713704914, -3.438812241670829, -0.42550560543158644, 0.33317636242955195, -0.03477221288765565, -1.3277737484999526, 0.7251406213707361, 0.5203750727704027, -3.188115181026584, -0.8537554071757655, -1.2442132138634199, -3.1330375525643133, -1.65577577754628, -3.6105542726007314, -1.7468782230599997},
    {0.7910150982680934, -3.626019923931023, 1.647945305871433, -2.4521592009263804, -0.5598479565658427, 0.23701323861782653, -0.0274898881955594, -0.9094402196608282, -2.71530190747208, -2.766221639770213, 0.9465481189662668, -1.0411573341553217, 0.009010938173014583, 0.2882745186086366, -0.6215615186366603, -0.9746760566627085, -1.8918024736999164, -3.141854390130815, -1.5316639140429942, -2.1335686346860054, 0.8794881073318869, -1.862610663809596, -1.2404448418154497, -0.2723817135559256, 0.5268458099738231, -2.074584310270657, -1.861315000905012, -0.547633001361706, -1.7441381633682866, 0.5577562862906178, -2.1561531710206263, -0.927111545701496},
    {-0.32182564290105664, -2.238813901666342, 2.673834078486763, -2.7540519781297945, -1.7878803660266716, -2.761981030659062, 0.38292396368884835, 0.051595827943874066, -1.685945185588837, 0.6314802895764885, 2.2070729318342153, -2.5835564737405092, 0.3152497510682473, 0.42979142963764744, -1.3626849914621868, -3.0580492658732714, -2.7161980544045345, -0.4472848828346819, -2.711352151833818, 0.12061331872769923, 1.9381510978221388, 0.23297508530534358, -2.5169463188297776, 1.680770737263185, -0.15850177010620728, 0.17177805888969144, -0.6191256976483066, 0.38372378751397174, -1.5343309097350102, -0.6222469156646085, -2.2231689816305087, -2.4754386463191436},
    {2.3888214441133644, 0.9549246467572164, -0.010980563596048046, 0.3170041520129251, -0.7636473766334099, -0.3888837596949948, 0.49916139279874844, -0.5452775135173641, -2.4512411362606445, -0.9985009863405729, -0.17420659703019042, -3.009835945969002, 1.1911338364561355, -0.6748099216852331, -0.1734306780376211, -0.8054255365577262, -0.2777617222146665, -1.8214917244759579, -2.27726478458542, -1.2551205230624665, 1.3628128013574292, -0.1525387820507321, 2.927717123139562, 2.1776607420283485, -1.0012892717450281, 1.9981769086066568, -1.1606972918410046, -1.583877895446673, -2.573466771307658, 1.2868357941238049, 0.6409382372130257, -0.12454456866112286},
    {-1.91097739838523, -1.3232720528594337, -0.6665778160955819, -2.6136527797258333, -0.4688748220163961, 1.516254078002257, 0.6918958018828261, -0.09997713071098414, -0.9781327620446039, -2.2407884112510543, 0.37538787512508953, -2.5867762189015564, -1.4577489609413208, -1.1082194220476498, 1.218115536335606, 0.3408114766359508, -3.395917389838009, -0.7428228941895496, -4.112361434434001, -2.3429922428799954, 1.102415166256354, -2.260627522078016, 0.9831323804576118, 1.2244024949434102, -0.318591399175324, -2.956652272714865, 0.6028226835259942, -1.9190207146283262, -1.690400833191591, -1.6305867825896798, -0.7138299284012918, -1.4537102360523362},
    {-1.3173758726889329, 0.69005975413011, -0.30408302199727555, -1.9537356065221092, 0.21775623318295317, 0.10398177913781416, 1.0479353403730614, 0.5030300245209423, -1.5436133186640373, -0.4821442402715285, -0.28560212864946405, -4.855774682097323, 1.0491683023587983, -0.25955773072248256, -1.521745871596307, -0.7586300802994744, -3.4058058881649207, 0.4440927996604087, -3.3423114295357954, -0.4247716082932982, -0.7945466837767481, -0.6154146600567081, 0.24615526275230826, 1.4555451159338182, 1.261630019686226, -0.629497994036545, -1.8794237769535642, -3.1939209468978667, -3.395007845503153, -0.23340545801391524, -2.1991964742962113, -2.635200816072162},
    {-0.7282061942148972, -1.4579939850952066, -1.2212511708763116, -2.643129817985197, -1.0961874023511327, -0.8294693870852627, -1.1081695570016656, 1.558952786273584, -1.868802520506197, -1.2062580107009424, 1.7815785004053981, -1.2558748973712925, -1.236200417378425, 2.1811654906575733, 0.9981375883948143, -3.5797494808524166, -2.1221319084308923, -1.628878134528862, -2.9898621699712806, 0.2520612109599437, 2.2141336699516634, 0.5649127415401702, 1.5810109985736231, 0.040653144722069316, -0.14072132361810033, 1.5853919597527473, -1.0421142020714058, -3.473952344293051, -2.462662860766111, 2.5711536715289562, -2.344323007409798, -0.6629844604728725},
    {1.349987469166146, -2.247898358653141, -1.5324959904283837, -6.423143642487871, -0.025822210604839465, -1.349467914137325, -0.21778658576472043, 0.7787924465710485, -2.22595482943963, -0.9399061334056927, 0.9330478799465222, -1.7821982488460426, -0.36981377085512734, -1.4267012366602847, 0.25625515750164735, -3.6827349389332933, -2.5851522770909954, 0.3745559004847316, -3.6260141187770403, -1.337196970470654, 0.5628324343706561, -0.5324719550108505, 1.179986342914001, -0.6794177799054151, -0.12721986926120665, 1.3949404991538916, -3.162575043915399, -4.217123139125428, -4.230451561755923, 0.7324977640128327, -1.6521384132400687, -1.7842921136602365},
    {2.936495062874724, -1.5886335720188012, 1.123562604930063, -4.135389406769527, 4.302764542663312, -1.0318744253743497, -0.37335444588070293, 1.318462517692645, -2.469139853805897, -0.9284819794133882, 1.36571081482212, -2.4829394205779813, 2.544897134758562, 0.25065534657054345, -0.13898769716583115, -2.714141506653149, -2.4345796066490344, 0.06013754139755531, -2.9494865185596044, -0.20722793920085247, 0.7570726410780028, 0.1698552571788507, 1.8833688332013563, -0.07808408573231189, 2.30957044088971, 0.7955898242928704, -4.254602060344773, -5.1712226902589356, -6.799664018304173, 2.215102108854051, 0.44191932429720665, -1.6290876227339177},
    {1.2313196109361184, -2.611094712826922, 1.2277209308528647, -1.4029007234760515, -0.8463072643955711, -1.372364561634875, 1.2890409603155746, -1.1412638632227075, -2.0905675879161274, 0.7296773789203839, 0.6997646105866646, -3.522402902746926, 2.94887211963946, 0.47420975189719206, 1.4124966009794953, -1.5752072562759745, -5.729081607004161, -0.04985419872063375, -4.028306201204098, -1.7138966554579982, 2.3787133638380618, 0.8310321636594831, -0.0224657382577352, -1.5837845087912903, 2.065720990246289, -1.0962175865433375, -3.417130666590991, -3.520973276775666, -3.887793689806975, 2.167007494981121, -2.105571346103514, -4.677155719082075},
    {0.9139139895499216, -2.7742107117333332, -0.7137894096622996, -2.6700532285904788, 0.9398744428950314, -1.405925602948955, 1.1658244616969817, -2.0980618443232064, -1.9906347170004557, -0.907461891767605, 1.5356278942696815, -3.080914682897624, 2.6171870636233106, 1.916415037772558, 1.9859175379244454, -2.939685931090274, -3.878163760650036, -0.8679482990126278, -0.530805383623601, -1.0731578712765926, -0.8114161941239538, -2.301580034753712, -2.2440842839206416, -0.9847634678375073, -0.4150999773475301, 1.8017108910465105, -0.9143877788211718, -5.1178683583402576, -2.021646844220412, 1.1170076719401218, -0.5899308078848782, -2.202491876095439},
    {0.3612296303986451, -0.8068507222422994, -0.7065424687971358, -3.3204946353678184, 1.5666589361936856, 0.5472413758637912, -0.004582807426275499, 3.2291337845949717, -0.7271389293860593, 0.9422151048444262, -0.3315335545251477, -3.128729546805945, 2.365700222298127, -0.5893132378776724, -0.10993882250871552, -4.892097342478824, -3.230684204893137, 0.6401030817110731, -2.361180214165297, -1.4204060561404022, 0.3460025392183224, -1.7719631775262454, -0.3924070337879606, 0.6003262279672046, -1.1807013554492078, -0.007077669739439153, 1.1279331458670687, -3.125839733588636, -4.405353280286103, -0.45901862341838406, -3.1038381891688975, -2.6885665990307674},
    {2.2972945863585226, -1.9413742554482665, 0.14574941584670376, -3.1457260557022577, 2.452147620392305, -0.6494373524561228, -0.6433618534767311, 0.811757783813567, -3.4768076922700275, -0.4864554181213945, -1.202763421932915, -2.9028998064948826, 0.14687250305851757, 1.733812987015542, 1.0297342524057984, -3.1268380648752476, -1.9861386081427281, 1.2134184993114037, -2.498647123950977, -0.3254608875621918, -1.2407951946331428, -0.5901070416798789, 1.2793288908102751, -1.5441738853350122, 1.5767888171577757, 0.47088648620919366, 0.6717638875780436, -6.697368097350646, -5.56136440740581, 0.40693829260046765, -1.7567507239244478, -5.368164996200342},
    {1.68640728851848, -0.7691523213938627, -1.9386305873045508, -3.8893925434075762, 0.7359911238908258, -1.2792087564490673, -0.369627051118532, -0.03268318991329799, -4.4780407205116886, 0.16317968837039856, 0.7657917668459614, -2.194474278037553, 3.2442173287565654, -0.6713642596555509, -0.48212800477350726, -3.0528369689198027, -2.2474735216132338, -0.6284194953474515, -2.486372820626288, -0.9394234154609594, 0.5476694078571295, 0.05343188454275688, -0.869113249281375, -0.5264360454977732, -1.5402854260367218, 0.2702090377963158, -2.978744076202468, -5.405169838363329, -4.993498620681078, 1.1829186681865602, -3.364316313507729, -1.9437899259085087},
    {-0.9594911710530625, -1.4340537821631982, 1.4234501391649457, -0.7714199897072788, 1.510559495717652, -1.2296143175853864, 2.3550337457007084, 1.7462947364569037, -4.25205883816932, -0.4253805182174999, -0.3801824260194846, -3.8461308752854166, 1.691013587401605, 0.9540289668925975, 0.8065115662910886, -2.360258584632203, -3.713808136631552, 0.17868432540091067, -2.2077440736522655, -1.6678295255421192, 0.6374843990236617, -2.0840619181431843, -1.7860695000590343, -0.36875975413261197, 0.8099767058354133, 1.001735588071404, -0.9918173066295929, -2.7139341517619764, -3.6382158814357286, 0.4831963858418403, -0.690579710829172, -2.6983839264149223},
    {2.9717558144151193, -0.8970078846204024, 0.23934784564935502, -3.129172887859389, 1.5872616608189687, -2.0447107555961597, 1.5369946675852766, 1.3598992666661078, -2.8093681259353236, -0.9567229994040892, 1.1080106741608455, -3.439519926139061, 3.262127554617546, 2.201302899133338, -0.4850021072462795, -1.1517022558452672, -2.458628602255227, -0.9299498102275894, -1.5716646696995207, 0.018763114266381407, 1.876335859526453, 0.9613830424827317, -0.03442628316543724, -0.582880668622682, 0.783431572898885, 2.753435869700881, -1.5738191970902093, -2.2963363717066447, -5.2340329493826765, 2.145871914338968, -1.9885880931778392, -2.062751888023596}
};

static const float b1[32] = {3.7877867489554795, 6.0280104348829315, 5.5570430098802275, 6.297753624078442, 5.962519218070158, 5.655161366952409, 5.22384879494415, 6.134407385880505, 6.471682683897486, 6.295359966138756, 5.632574136164747, 6.764328575205024, 5.712455472986651, 6.3252439304075025, 4.053656000471882, 6.81086181093194, 6.576933653578738, 5.9816853414514375, 6.128083132500101, 6.287200881572578, 5.946860511126961, 6.6873045403576405, 5.759089835263061, 6.061720673081102, 2.830670430899854, 5.448866120280941, 5.933987001606904, 6.546948665216595, 6.5311865490110055, 6.007154273164476, 5.780536269747174, 5.274952921424858};

static const float w2[32][16] = {
    {2.9025757361555837, 3.3523192715322963, 4.2083983576473365, 3.6405643872040243, 3.6273448097014382, 0.9348611706357631, 0.5881684212516675, 0.04125289560941397, -0.3217605332075665, 3.9169658222142174, 3.533636315585115, 1.6727865275175322, 0.8495856885449641, -0.7542491711943399, 3.878010104579301, -0.20973383550742397},
    {5.219890692946306, 4.365926856353387, 3.9087432048182524, 2.504432507140997, 3.9705130585296846, 0.3879666248342064, -1.8023825639764324, -2.9210548545412744, -1.6906778499403008, 5.32849351643621, 4.57391792121329, 6.70134509119179, -0.15788706879136843, 0.08772987177232565, 6.078258638400893, 1.75724391590503},
    {3.7327561730667873, 4.950499857824443, 4.797316769660296, 5.662677009621762, 1.4323280629660815, -0.11943420102803375, -0.4884389265361813, -0.7184708179828323, 0.016099327376895567, 3.976991854183996, 3.95911339306634, 5.639430585660258, -0.3496925585303444, -0.5051625098861102, 5.99882462697971, -1.3689534596352495},
    {5.053301201098407, 2.5550280408309547, 4.328888090307181, 3.5855841595008147, 5.332925037774051, 0.48376948889390303, 0.5156366602036544, -1.6767468084569863, 0.8299959587043406, 5.118487974796404, 3.6912928049959746, 5.068838501878994, 0.32379668781222776, 1.4911327205801752, 6.487332013732113, 1.1110854361340563},
    {3.6715448869218483, 4.811739545056005, 5.210113990100713, 6.266877097956033, 3.404116373834307, -0.2007765862484615, -2.5786961223623086, -0.2803974751251763, 0.0885127864033713, 5.058754696853726, 4.078408561974005, 4.290916756414189, 0.08645225372815675, -1.260017191370804, 5.8832498839578395, -0.05672597753351963},
    {3.3025983949137094, 4.207796060648896, 5.0760541542798565, 2.506224423433568, 4.627369694054042, -0.21933825802063642, -0.35677860762118463, 2.0480913420311273, -1.614521284814903, 4.650986292513624, 3.7392573774189364, 3.9617227623868456, -1.6555550456424317, 1.0379927433577993, 5.001874152976518, 0.13960904449442488},
    {2.6216195672383344, 3.5755122008374824, 5.592970510760053, 4.778977965451505, 4.961655841861197, -2.324934868925814, -0.816579341128286, -1.0164341901966616, -2.329814609282558, 4.564792830449804, 4.473097639209067, 3.2925123095871203, 0.12184731911945831, 0.4613154844685587, 3.8856662684891843, -0.7533976313744524},
    {7.140083209716808, 2.3324615481845505, 3.2860186365349557, 4.516753732602965, 4.277862389512014, -0.280047130575467, 0.4347682801647116, -0.48174197594565576, -1.3509842325625043, 4.194032241550958, 3.752852789722837, 3.579151403469862, -1.0527387884881492, -0.9803567586536192, 6.1372269349305855, 0.04942292912223432},
    {6.026095435577119, 5.364783411010364, 5.511266748402756, 3.689553699042867, 4.092767311009064, -0.4164785399183567, -1.1507051990134267, -1.1248960084091346, -0.7631295226608317, 4.456645418151812, 3.9929523643972797, 2.7399912172847616, 0.4572497360140533, 0.7122571256761803, 5.81446370443489, -0.5139591195453023},
    {4.828739705915798, 2.3437780298652067, 4.941822817019187, 4.450397575118123, 1.7440119468609314, -0.7559198033481324, -0.5853025678004911, 0.805886389223762, -1.5526021153131806, 4.370425124076372, 1.348350065500763, 2.3809871204887734, -1.7997989761628903, -0.8206258973351348, 6.342017124770815, -0.8639489131222855},
    {5.068651145577412, 2.6529417455463546, 2.533609734107359, 4.1009544089278815, 3.6609970799600533, -0.3447102881430066, 0.4092280661262978, -0.7468597751637301, -0.4874931722274955, 4.54794264058684, 4.1954074223972, 2.2414731114336006, -0.15220823433070116, -1.4367785129793378, 3.05590518371683, -0.018113315467644744},
    {6.0152541413900815, 4.866947758793247, 6.798366003608929, 4.790026546886581, 4.540399679856758, -0.022271301880657055, -1.9547176677919644, 0.9159221986459228, -0.07157943630320177, 6.626810767494088, 4.74095300913543, 2.563341000547266, 0.30776036936339235, -0.9956864171565635, 7.666441102239715, -0.5795669044832097},
    {4.845476702577177, 3.1642185350348613, 4.656637247036147, 2.9406345310484667, 3.7390384434928907, -0.23015823785543302, 0.10182220909539443, -0.27809507948983136, 1.1703431408237643, 4.509003968083846, 1.3346252905480678, 3.1555639404462723, 0.8687922098184311, -0.5845744750249137, 3.9952605441602507, -1.740206230687701},
    {4.249681330290432, 3.6143224236013314, 3.395693772014699, 2.4573516003527893, 3.01080792754863, -0.33810326845532457, -1.2956194760081372, -0.5411053686998831, 0.799461247654981, 3.73688231434179, 2.7319511679762334, 3.1408656465563203, 0.009842870359212842, 0.06757701893763893, 5.042990803931558, 0.7751595545929216},
    {4.247957273763943, 3.991926912670781, 3.0188889863816715, 3.33796166313828, 3.0662786669281297, -0.3292696088470151, -1.4577691399050094, -0.31365690116070105, -0.3914982762076828, 2.4309651131654175, 3.907321207954748, 3.55860538667883, -1.1148767464419962, -0.9281966071975303, 2.5351059185262037, -2.3542874113282033},
    {5.478330956467997, 4.100848326767901, 5.552290686228907, 4.76621799925076, 3.1243704996064006, -0.4862053380747578, -1.1581276303208112, -1.8265612646671519, -0.5958101161335525, 6.508056162187097, 5.190253507909795, 2.121297957280379, -2.191417369327911, -0.20398879598096564, 7.319611022135053, -0.184712961817545},
    {6.863138424587948, 3.9522276204725624, 5.67355310313844, 6.123575473275259, 2.904428665343021, 0.3083875181397834, 0.3083013947280809, -2.565083506950093, -0.5728066613274498, 5.220826313568809, 3.383977302827203, 4.586643662642838, -0.054925620016599355, -2.1424227032371297, 6.646569620676485, 1.1886129000881513},
    {4.921039719896125, 1.9841309033197363, 4.330086029203834, 4.055870905952194, 2.852446521437115, -0.4318550330453139, -0.7893722699214819, -1.5079380160795233, 0.6222081774447795, 6.60634170109881, 3.581769788972186, 2.9359743568780443, 1.716851980665841, -1.376962146935004, 4.552689772072046, -0.8588442312796716},
    {6.351925836347205, 4.89008398101734, 6.412538980794219, 4.2374701409441435, 4.164583328920784, -0.7452895897968227, -1.960101972246114, -1.158675231726, -1.0165311021616334, 6.161434267978377, 2.562034766500698, 4.515503447440563, -0.5540333262237103, -2.0771880617135388, 4.6432724993387735, -1.9908386140858},
    {5.185105558542205, 2.978979849649948, 3.0577069472768876, 3.0109869318760625, 3.9644342258443652, 0.3726919336630273, 1.5731419429587938, -0.6892549740096146, -0.2941525271194551, 6.859141739348573, 2.8444373365345488, 3.5193965924004864, -2.278381609265414, 0.48519287209656153, 5.272574860878892, -0.7075004114674333},
    {4.678318165125166, 3.3450958988775157, 6.258121094320669, 4.724636703468974, 3.3728267417323434, -0.4269316237236525, 0.5062682815776273, -1.340719492891743, 0.41293914405202653, 3.982214418505315, 2.8307214668294933, 2.943138112981864, 0.8117890235595088, 1.0388389179364172, 4.850069673828601, -1.661625487176157},
    {6.908425753547382, 4.089822274677516, 4.483442897748022, 3.9217688564547246, 2.6462073524232723, -1.7884919900470464, -1.089450731217744, -0.4784986393701096, -1.2968711606371985, 6.044979058865814, 5.433241218412873, 4.480102166592641, -0.21371372257394358, -1.6779733310485236, 7.197150888268419, -1.0159978558986777},
    {3.743671821011309, 3.983749262769258, 3.3641896867065544, 3.908777653472572, 2.3490370943738776, -0.16002427452062556, -0.8199376565975425, -1.9596090022880728, -0.6326171076433554, 4.104474963501344, 1.8959727566076443, 1.5049203403379363, -0.2110519288394482, 0.9182610660332076, 4.164095098733693, 0.1579394476239687},
    {4.3176707261055185, 2.263302943619229, 4.277329447299224, 3.2752418779489743, 2.0660753977313786, -2.115252196835875, -1.375005329147502, -0.17258571926257035, -1.1176619086849615, 5.469643228483648, 0.8701973646504702, 2.1528451450143016, 1.1678838231178792, -0.8688381364498289, 5.242687757196559, -0.5255019254098572},
    {2.6782554700713592, 3.202860788535154, 2.7984410760713887, 3.3943372973501833, 4.124365653827656, 0.3297113269796648, 1.0317396189745036, 0.47709421389635087, 0.2806278296542878, 4.71291317738858, 4.105399829941649, 2.186806190562942, -1.3178950297630965, 0.36422132899747184, 3.3514840638461765, -0.33196894549636874},
    {4.109240262326156, 4.772734146204076, 6.5148299164564545, 4.781165771021049, 2.6698935451208166, 0.9765443160877322, -0.5457382293691194, 0.1744675682422368, -0.8255240087595414, 5.041769630990816, 2.8269615999887714, 4.368947108877848, 0.3244855370394925, 0.4261809565421602, 5.023136757249514, 0.2789985742765572},
    {5.118921518496648, 2.909606268464647, 4.1183359762990035, 5.2366639073540435, 3.389454496891355, 1.1484902549184723, -0.9783913590769647, 1.1143331466763646, 1.9492615004568705, 4.700873007496485, 3.4672329520162055, 2.43905941888228, -0.08057098711356858, -0.20996895013952024, 5.066617679064891, 0.7131848951400586},
    {5.354792145899079, 5.20231525336789, 4.282810315046886, 4.824063602746117, 4.079184263535616, -0.9641891347442755, 0.8231887161415157, -0.5138981632296296, 0.48920262280041676, 6.24887610718787, 2.8504716333221976, 2.7592872865444846, 1.0577148263130174, -0.957613245254384, 6.89654677310057, -1.7853209076830996},
    {6.3736702501696865, 5.3570090266795285, 5.0364358242728855, 3.114990041647011, 2.8865161295287125, -2.1287651735692164, 0.19685214760798006, 0.813351620806606, 0.1174051901031219, 6.506475137068, 5.193067980032826, 4.064492061816191, -0.6183712878395848, 0.07324654559821824, 5.7406223985081795, -0.3300243131477843},
    {4.576684371680136, 3.4393540008829344, 3.7273279071413405, 3.344407239111419, 3.8476577468374167, -0.8639145766397411, -0.23543112557438287, 1.065038428763706, 1.7959441857432512, 6.091678654536898, 2.6438722778795634, 4.972717989635774, 0.2981565508498206, -1.3856473996767167, 5.557345624774399, 0.5025892851494569},
    {6.187519754626038, 5.178982567459315, 4.512208602296864, 4.834866148722362, 1.8960822968291609, -0.2943889748213195, 0.35403877095863073, -0.10239353064451955, -0.7813396017115218, 5.35132641921727, 5.636254218453018, 3.9103518751976925, -1.525615994120721, 0.8873624838068126, 4.2934887035868945, 2.337489479949479},
    {4.304429885485599, 4.003933855172987, 5.6058062370682915, 4.743599764759585, 4.304292897758041, -0.3959259832801, -1.3135176232062267, 2.1826723916171322, 0.12334398184469292, 4.146455014035343, 4.398279755432361, 2.680681106160103, 0.11308395056546018, -0.6656706659588983, 4.863802662155905, 0.1005504045184355}
};

static const float b2[16] = {5.900274960742981, 4.804808098255422, 5.447936757693134, 5.109840843049785, 4.849213664556286, -0.33977191947086927, -0.24595978779253455, -0.29757591113754567, -0.07343006280116791, 6.001207411475735, 4.62619668829747, 4.442462187555273, -0.390895695704566, -0.43816060678169133, 6.299487912145737, 0.036015921717952315};

static const float w3[16][12] = {
    {-3.0923784629189295, -3.90013527492679, -3.353744977061346, -3.817238613171939, -2.8502933661111953, -4.483580432093952, -2.9201457954223597, -2.788538867899475, -5.402976449794748, -4.0648718815535485, -3.654254702401253, -4.2710630471163915},
    {-4.431284287863519, -3.155971828747986, -4.044099684910148, -2.7283810607526497, -3.0201266359775767, -1.8392781556909636, -3.67316176314945, -4.71697882616509, -3.6277252110688676, -2.6264718692713664, -2.969132698629055, -2.136625454398232},
    {-3.422687982605181, -3.8606967352632644, -3.3819184762844863, -3.663071875512219, -2.523167900014899, -4.937489705586645, -3.6732368076156097, -2.927401460392558, -2.3415381159373547, -3.3052568468708885, -4.843592428636517, -2.645327217542074},
    {-3.657841115119676, -2.779277822475044, -4.7017694928052, -2.722573590618863, -3.275724059229707, -2.6333531933311107, -2.7622875458008993, -3.151773365971508, -2.5036372402215785, -4.086966187365703, -3.255894368623243, -5.087617015285352},
    {-2.461672838267086, -2.8677910994385853, -2.7253849345670007, -2.7210968438325622, -2.1622417483116902, -2.7947970244447458, -3.2945174204077023, -2.486539544113701, -2.72588475793508, -3.037328453919589, -2.5323611266401733, -2.2169863694301744},
    {-0.20031046766893804, -0.544448681130572, -0.882648488966314, -0.7690708228224682, 0.10490410902946495, -1.3894184663926759, 1.2900348652766567, 1.5387768069430294, -0.5372556708444604, -0.2154440591113016, -0.3641885906339717, 1.299799000450111},
    {-2.1881176399927624, 1.058012588349698, 0.5029255803755676, 1.4529197655875494, 0.5400518227325112, -1.7799467167974792, -0.8593419974786773, 0.6948787733177538, 1.4175840939606927, 0.08391667042936907, 0.8346700579352399, -0.24354187504285488},
    {0.5064818613557244, 1.4360584867240471, 1.7974774204066342, -1.804694971713574, -0.7425894327246321, -0.507529444420646, -0.1764425375884513, -0.11157408730206707, -0.578811185503907, -1.4668839924924821, 1.6836789040992728, 0.21635187394154246},
    {-0.9816186854369615, -0.6432846758400026, 0.34599501475958994, -0.5099131497458319, 0.3277381424850141, -0.44562095240317706, 0.3280993617180974, -0.7856829516786913, -1.2414670291922116, -0.23599979503352317, 0.9789844032570687, 1.4548339327426307},
    {-4.44937421247349, -4.605579018507208, -4.448488533268524, -3.572706473284246, -4.2184539003054615, -2.0257332689422847, -4.117086172391806, -3.9629068133537815, -3.3613916414286518, -4.249817995118335, -3.6669841393265563, -4.775505941647094},
    {-0.9172964026933031, -3.2640791362311905, -2.2404903315931075, -4.515874144921555, -3.8313957795539397, -3.563168373840821, -3.931458326318133, -2.965043694671634, -2.9277089722542917, -3.712638289356453, -4.256983112580725, -3.4703609776258646},
    {-4.200829152189158, -3.0547003633678775, -1.7927326801128705, -1.8928419996594914, -3.0902506860785537, -3.5010991497546846, -3.2447502958309795, -3.871705826871465, -3.6785071984553395, -3.61779736372797, -1.7803415419935067, -2.666240009803286},
    {-0.8372069759782215, -0.7712350172108682, -0.8509128821306561, 0.9910080531111011, -0.7037756412974151, -0.6796962939419517, -0.772535681955218, 0.41775002528076965, 2.1254798826995045, -1.2035750716405844, -0.663211772190146, -0.7119359037106184},
    {0.9809178591234029, -0.6761026007738105, -1.0399021462010327, 0.18907496441790406, 1.1515028577955968, 0.26472836025508645, 0.1676853126017201, -0.16803594167954766, 0.2969896425004084, 1.0749517912012967, -0.535945459012574, -2.2033614303240174},
    {-3.955176998449639, -3.229442193487729, -3.7916795648499484, -4.8437767202408635, -5.535809727392478, -4.778899747566303, -3.595150135601229, -4.150580407313919, -4.14682302865949, -2.5183691125836427, -3.6508416731097424, -3.2637338746630253},
    {-1.2308219388256663, -0.49615865635568274, -0.4997482858124051, 0.10725043987201788, -1.7018470985843688, -0.19730607056198368, 2.4119686124772564, -0.33832125569424876, -0.12525294639947304, 0.9409146753303193, -2.543235652057093, 1.1893701707094464}
};

static const float b3[12] = {-2.968069607617883, -2.314469379675577, -2.4066073036456612, -2.689882113756961, -2.9203543215666254, -2.617441651706246, -2.662341743955144, -3.0656740148272337, -2.389186609234782, -2.4602943241400945, -2.325491857913444, -2.3941562930731233};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
