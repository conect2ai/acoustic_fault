#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5167721233212578, 1.461561081010204, -0.18957520413712062, 1.890330200719504, 2.556899340451308, 0.09921964326788398, -1.116193140805316, 0.7835610932094254, -0.22230781391449686, -0.6782611412228035, -0.2309118839481457, 0.3951064670659403, 2.2517474339507193, 2.571308690716251, 0.41175322895224614, 0.12721609027021522, 1.0328370190630436, 0.5553913134788526, -0.1046440319735724, -0.17655434106060874, -0.5745773410047734, -1.0609584892162847, 1.1287107639206875, 0.9679730373108356, -0.2845289145846605, 0.25923098301274206, 1.4178521510957278, -0.6350633466334743, 3.2316850163721185, 2.5855236952857097, -1.4461042719367343, 0.6948333077195574, 0.5105945021628988, -2.3214467823987843, 0.5243985603624014, 0.34321408398442876, 1.8981555761743472, -0.9218938116873048, -0.13134913116930932, 0.49786807235028435, -1.1119989939860384, -0.12961583266718296, 2.4006198283876694, 0.9513818113606666, -1.2082670848532322, 1.4886740167729389, -0.49944864535160527, 0.1815897684757406, -1.0372044628223218, 0.3732317361982479, 0.8180740860646556, 1.0180643043460174, -0.17033445751783732, -2.809356264013658, -1.7880134170259898, -1.345226343424865, -0.47376474150402303, -0.9891794783179392, -0.4490789382899685, 0.8500430258587809, 1.9792548770243066, -0.7806056976848025, 0.2563559962733438, -0.3154848338743963},
    {-0.0794665177029827, 0.9096597631920968, 0.1627650739016105, -0.1789708389546551, 1.0467955898424415, -1.003974930235133, 1.1816571157548472, -0.04173927342526448, -2.7351435913391153, 0.44279174591210885, 0.20850598282255456, 1.0425153074245506, -0.7963225224759065, 1.2795775459600243, 1.0337886517050214, 0.43660899738561604, -0.10735785860587808, -0.6837633751068293, 1.4131131252931335, 1.2113700674057761, -0.2519417704920259, 0.8507468887681745, -0.28553725125244367, -0.20727479468914764, -0.3756237289853222, 1.0723827593294475, 0.6727767634278665, 0.48532307639775574, 2.473701049169122, 2.1962120562283047, -1.6819953380102182, 1.50760924620117, 0.38630940400570235, -1.4908085777116638, 0.15138924148041114, 0.23279757817952507, 2.1228559280661203, -0.8611319187840616, 3.550626451593597, 0.3816893032427752, -1.524680012979684, 0.7464598101078764, -1.0870893394935757, -1.1266139227787317, -0.14681779101997594, 0.5833458329827473, 0.6029534280633022, -1.725831282785177, 1.7087891581033663, -0.7649313103764671, 1.384370697070095, 0.23981337415467285, 1.288392257707597, -2.013873707991484, -0.6740022986878982, 1.285771038165689, 1.1290431206911578, -0.5679856017553012, -0.6356733709758008, -0.16958638661960534, 1.8322717212225306, -1.663992845798219, -0.08958274812849197, 1.1610886638206628},
    {-1.4879126924597312, 0.4411141102489523, -0.0011683884089408348, -0.40821789585925006, 1.0158499722263603, 0.34463799151183094, -0.5231138492132398, 0.8480768155742403, 1.5861370947608424, -0.2774242390917881, -0.38820621166550534, -0.4817983951417736, -0.0687333188945764, 1.6147055870221927, -0.5365927620658771, 0.5083140418633267, -0.26279434704323246, 1.2030870770666016, 0.2519443847681958, 0.09143524209489937, 0.6758087529538026, -0.045356230374557036, 0.38652400238538737, -1.6394274596010303, -0.10352707365580886, 1.2903371261943972, 0.8551342612692926, 0.019351861049630898, -0.7010139147530162, 0.5067585649131247, 0.7304990065299539, 0.3085589080607949, -1.880702092414411, -1.5556181154998199, -1.780015164571302, 1.5960718929485205, -1.0627971274271317, -1.2634804925115093, 1.4717142473931324, 0.8652246759689917, -1.060972862658333, 1.1137520781789545, 0.05160305404056258, 0.011962904433225155, -0.7571262847787513, 0.8817416688497327, -1.8252455810590382, -0.6285547756469543, -0.7189698408150139, -1.101193732049985, 0.4453441367854641, 0.37981827172897503, 2.073316645366925, -1.99236742104447, -1.3875197618525066, -0.8240761231145768, -1.5301587330121165, -0.4681585054282065, 1.4661588653886877, 0.18757542284726691, 0.47337261678247666, -0.35922818467601486, 0.3071021770940068, -0.7531620177064328},
    {0.3561162104316251, 1.8295769816671303, 1.0176514822172635, -0.43012265810777317, 1.491180961977975, -0.4716374545734683, 1.5778122543522068, -0.3149973576499084, -1.7295699395979018, 1.438808363274981, -1.4264629795187906, 0.44492562864513086, -0.41722651500730057, 2.3394087991082038, -2.0673631011714395, -0.7170064605233856, 0.03495642976880825, 1.2347185296757697, -1.497372341825387, 0.1422772857235757, -1.3505855595395275, -0.3127041469244367, 2.1385640672503268, -0.5173446082243394, -0.44800435782437564, -0.4603412639309615, 1.022908292992419, -1.0683096666310037, 0.8941980282003705, 0.7061397118366217, -0.08100383086607325, 0.9368145560606556, -0.6132160091568298, -0.7993880089490312, -1.9946012188812212, -0.35323142139427355, 2.363099746217175, -0.512812395417915, -0.6288204607485011, 1.1139077703646034, 0.47431805663647686, 1.0972614500403581, 1.0032583441504197, -1.5523470965020212, -1.1859388908769246, 0.655657407505548, 2.367842313947165, -0.9220787665000131, -0.5686057205919103, -0.5929928135757182, 0.6752593055451875, 0.0786871310300604, 0.8385928283940275, -2.4731876901909002, 0.5033079318971202, 1.7821964523713267, 0.03330121490553719, -1.3806366375502754, 2.28139712939843, 0.10351750829257636, 1.757970920236347, -1.562074108404589, 1.706462778415169, 0.05409369332123102},
    {0.05724311433562767, -0.5997718177023573, -0.6264120312168782, 1.4244162909389753, 0.9479474756226935, -2.428848187921582, -1.127539490601991, -1.0061538019549168, -1.5204586566872937, 0.08200539684581057, -0.6443137239636736, 0.7039200503808729, -1.3753591410954817, 2.3203164530343448, -2.0092514036335007, -0.7235991179012153, -0.45616750377021414, -0.0005704410282671128, -1.9513931892905902, 0.29641343824545346, -1.8079281491414942, -1.0069217278292355, 2.0333743390663446, 0.3384731557112189, 0.5121508249894947, -0.1342715595245191, 1.7206612289543735, -0.5972766612018565, 0.31104777376426296, -0.2531840734574524, -0.6114078138236597, -1.5431234356725059, -1.6882004399850292, -1.9344973171252058, -1.402050730041531, -1.3371565259453495, 3.030651898385053, -1.6764521433218085, 0.7901532835634675, 0.6749730742196892, -1.0700923969313039, 0.4531882625658734, 2.8610835834907626, 2.5390013203510486, -0.8435092236509543, 0.41293866442977323, 1.4835040905141252, -1.4922194057348985, 0.39131421516328163, -1.6995657673169233, 0.551056508006696, 0.5885549084828321, 1.3842549182899617, -0.6515167491251052, 0.6881574640672748, 0.5721899567733402, 0.576143213025258, -0.21569316271898825, 0.7174207086342078, -0.3479396302927436, -0.8695735124551489, -1.1576950938655153, 1.0121699991731314, -3.0409297719942248},
    {0.25910663426289615, 1.125358635904384, -1.509810730840494, 0.8125634103839394, 0.7060365298095309, -3.6828663951026592, 2.573204755447368, -0.7062276122987196, -0.9772170996936786, -0.34801323135696577, -1.0912434060266805, 0.02055678958865672, -2.181003848588019, 1.3018450975922644, -2.527009080472239, 1.774612687562297, -0.24076522623180585, -0.051951675932208015, 0.856820448902984, -0.6677619413854682, 0.17019457505845492, -2.5760244727380335, 0.03205133783162884, 1.3869435954883897, 1.760839894558398, -0.8827205790510005, -0.2585859639622497, -1.9228072097906586, -0.08647143598212313, 1.8729885619591566, -0.21941923622126028, -0.2531242813561662, 0.041838126379158236, -1.0832058209799005, 1.1268767477595838, 1.6231442422803841, 1.5002453720245652, -0.16750342760722742, -0.07840227112851092, 2.0944500441137004, -1.986560968199975, -1.3711141797637016, -0.3929552711872806, 1.0649765487319642, -1.9615032533112962, 2.1525301816906044, -0.6477723790400944, 0.2589281956358271, -0.35705861907189346, -0.481066021060712, 0.6429971734950458, 0.31449379928170673, -1.1477962532810413, -1.7527190218332462, -0.8974981723166063, 0.7626292580439712, 0.04384020153326822, -0.5324065210878475, 1.8564598294235826, 0.23690869924840488, 2.2107174046482454, -2.2759059592897946, -1.3611041123115362, -1.1178715920503064},
    {0.38466290371197304, 1.261403607890589, 0.8327252236128894, 0.8568165198186184, -0.3157618846975832, 0.3298985156938889, -0.6608040493039987, -1.5438447759099738, -0.9639797679454984, 1.7646232564785596, -0.5857974203078795, -0.0737788255079472, -1.025796451542949, 0.6941750399369057, -2.5038335441989488, -0.26030444839586453, 0.3075184730145239, -0.4199582437916311, -1.0478406337224413, 1.1785714986856328, -1.9224142650398521, -0.40247016198385394, -2.1233346741610366, 1.2445792896086938, -0.9920426318071667, 1.9081899749275568, -0.33850153694506396, -0.5751027902229172, 1.6941618874568798, 0.1288687238903793, 1.4262269439198079, -1.737180412584509, 0.046105341087952466, -1.8378675119837495, -0.21266101782448246, 0.9916435271504044, 0.5207687962308727, 0.6356588179126936, 1.645916139030752, 0.4887007987908309, 1.0756271333058762, -0.12542305959290198, 1.1890726717024087, 1.657134134471426, -0.2715450248283088, 1.7802324995370866, -0.7043336696286366, 0.4755657172722814, -0.8087393199554407, -2.729567208065354, 1.8443400212793257, -1.4656502389905277, 1.1888529314400584, -1.4625751272291758, -0.555185758190859, 1.1292149427164133, 0.30931082847074054, -1.0653610246006746, 0.2886476512465824, -0.3643460808930894, 1.4281716077379536, -2.379497875385549, 0.9450144335510613, 0.7220860649197676},
    {-1.1248675653929336, -1.4775308661598676, -0.40331813316862375, 1.9078547967545427, 0.9724954375147166, -0.4552896418832766, -0.7771525677683271, -0.4546471633797408, -1.7362131168478137, -0.7896453950808531, -3.1558262803233763, -1.0439086304558793, -0.3774566841938708, -0.36924714447222906, -2.999319225692573, -0.25356093586695394, -0.4020491787063797, 0.5820020851577691, -0.027494117236142528, 2.486412395125031, -0.35683968739652494, 0.728762186787017, 0.5204517636096565, -3.6878073318226905, -0.3367933535297858, -1.3065298618370766, -0.06654579853293184, -1.4562382326586623, 1.5463428604712197, -0.3297047049826299, 0.09052447193568793, -0.38398250352362706, -0.9358896160361462, -2.229443919541451, -1.4866772118728886, 0.1637732735985116, -0.13554056653696933, -0.47402195853687396, 2.2009288841222783, 0.7446258512187557, 0.43834256676552785, 0.13507545229492807, -1.9354293779479876, -0.25604540202958465, -0.18679416523621548, 0.5217374816522076, 0.23329769165693753, -1.1231535209162915, -1.6409695876166706, -0.8303615129581696, 0.15656462446036623, -0.7939282714450437, 0.5999846767953979, -1.7101327195186977, 1.789835637368781, 0.5818800360328447, -1.1056310264435536, -0.10142418011424373, -1.040327134872665, -0.08263144219518155, 2.102283088748048, -0.16013509514107882, 1.0913192795207898, -0.8071556562272582},
    {0.8160778321425656, 1.3315007319148366, -0.6532036459125399, 0.8887473696717949, -0.1416945553262874, 0.2531635059775459, 1.2454660683139565, -1.893627246083348, -3.0246571985935757, -1.9496909528642852, -0.1251734058323631, 0.07676353176553671, -0.9362537816066883, 2.055718024998018, -0.839842649325978, -1.3889597270831084, 0.45550311798541343, 1.0493569881416431, -1.2853769420122145, -0.6258513411444077, -0.7751484789869776, -0.3267223919558861, -0.4984771327794383, -0.9293141724691311, 1.051026705363791, -1.551511964543561, -0.18476831555772077, -1.0410690087270054, 0.4804715841818393, -1.2087246704437546, 0.40197983028133927, 0.20983333926893608, -0.05750542933413553, -1.5097191884459502, 0.6289505705652774, 0.6331951749381608, -0.056846830599145366, -0.9877512458725122, 1.5067742407755595, 0.21542734965014126, -0.10482771848893428, 1.83187012042138, 0.25821887380195185, 1.1066642686127823, -0.9161662650149924, -0.06073256891343822, -0.5241654248576372, -1.130880548630288, -1.9690195341996086, -0.9009641346874637, 2.885176033060608, -1.6482976483991285, 0.2966676150392033, -1.0755441675033264, -0.48217437792162315, 1.0223349861258189, -0.9163287282650208, 0.029544073682898696, 1.1972410965431586, -0.1315563417881306, 0.7487475304038362, -1.063625019968271, -1.6518113025417656, 0.7317555802472051},
    {-0.34078701982830295, 1.0908375639078363, -1.5119462498637481, 0.08760232734727945, 3.6681595846367054, -2.0383300324133704, 2.2018684146335237, -1.5554466787144, -0.8587487526000611, -2.1205813930269883, 1.281900734089241, -0.2560184740061859, -0.134436924662266, -0.23165664061186028, -1.7820044328853564, -0.4399281113323666, -2.597582836673667, 0.3595675409212979, -0.5138260086111056, 1.2079025244112545, -1.245204309280012, -0.16073676753885313, 0.1755973598082004, -2.5988578904983637, -1.9343617363670431, -0.5664833076615128, 1.216989666006741, 1.161711970029958, 0.6977036377168441, -1.3917419515978093, 0.7205854674323495, 0.33601919529744084, -1.5911296083950808, -1.0901322693667832, 0.3182403740206337, -0.5154665017890109, 0.1183170376039834, -1.2976657726065497, 1.5543198284870328, -0.5186993276150992, 0.6510369228747871, 0.02542263534736545, -0.9604923355213614, 0.5986029803376074, 0.5988495270764813, 1.2998802776910277, 0.15647911396972997, -0.10556629309666794, 0.25001973326042715, 0.6444418255096452, 0.10741117835001823, -1.0521016995851193, -1.038792830410264, -1.6962215005969072, 0.09189331289559874, -0.9586443223969643, -0.5153888832995971, -0.6204919558869946, -0.6829182740436947, -0.7847959245193622, 1.0159570266522915, -1.2686285597753004, -0.2298286285071619, 1.2213996683969803},
    {1.148078856332211, 0.11153912855419496, -0.8538061172686708, 1.3574952411558894, 0.6202786167553246, -2.844275216150064, -1.3512307780986814, -3.3973870795792793, -1.8289375367929608, 0.594824519160952, -2.374988786070101, -0.9116997044825723, -1.6471004391819988, -0.3795795237007366, -0.9764072617361731, -1.5948780530190416, -0.9252739357176306, 0.7670571255509323, -0.10318251873464869, 0.09825467927782364, -0.8372052836454442, -0.08250665973895556, -2.148077410989021, -1.5010595707111132, -1.997397791088144, -0.8082519041242884, 0.9444984582165179, 0.6097618824924325, 1.5282394802085457, 1.9326051545509018, -0.8762555127635958, -1.3026879511626535, -0.26185282015987615, -1.8505078407828148, 0.20600671834373885, 0.825757029091189, 2.1305920934100264, -1.5260766319189754, 0.6578133426282132, 1.5938963851527184, -0.26250316187361794, 1.8921754540260565, 0.5437438643635438, -0.7176939593817122, -0.5803863945648852, 0.8522949770645228, 0.051129411367704984, 0.1738477993100358, -0.9028395338091307, 0.43319140619657626, -1.2770323624957143, -0.6962466707893209, 0.27759637347735244, -1.600231203482019, 0.06922991407755126, -0.7286087332421025, 1.4620715580960995, 0.09046624691153113, -0.1542393536467558, 0.6643338293097393, 0.2364060753487109, -1.969758983138117, 1.1327975554984946, 0.16238970226095825},
    {0.28445265800565445, 0.1427594783390482, -0.46156227230741675, 1.5287984771098209, 1.4248056204357695, -0.6154501292309194, -0.2501726207273405, -0.9805366503281189, -0.6428699222363461, 0.6615467555706135, -2.1863702228984487, -0.1546094006787703, 1.5171016685715, 0.1136374920795952, -1.1201105869775627, -0.2837828259571783, 2.194537355456742, 2.3917525475939905, -1.1298536932469512, -0.13950626345748304, 1.764914909200948, -0.6982328293882398, 0.13082530473208678, -1.0416046994704649, 1.5471033330932351, 1.0678057528760465, 0.5523992845949953, -0.365956530196673, 0.29911449417362523, 0.8391229389440891, 0.2977386377011978, 1.097443666517771, -0.44055286116010983, 0.0184772569845205, -0.8979443398427165, 0.18461458135782516, -1.4183737466364434, -1.0874574880288777, 1.0026846131172498, 0.9833266846639344, -0.20988272802258917, -1.1076292197606383, -0.041821098663656985, -1.702694026839698, -0.19675860084427443, 1.1800792996882161, 0.689921078831242, 0.2791970843356496, -0.806457423522966, 0.929769773167002, -1.5509493421045315, -1.4808401442722707, 0.06912053056777763, -0.18529051373194974, -1.0006017065058306, 1.093879831223017, -1.490883054504721, -0.5588213877915862, 0.08253562473916208, -0.32435395908078185, 2.927407327822483, -2.858639184195239, -0.7856951153370918, -0.015046135162154603},
    {-0.5461495204116729, -2.045487283670966, 1.408343909594237, 0.8543036642026098, 0.8737864883502215, -0.4168305160607347, -0.006855376669945449, -1.7932753923778872, -1.664375352367117, 0.9883953040180891, -0.8272129807415991, -1.1608568281250713, -0.22391959615032392, 0.13291718152920845, -1.7327810486963613, -1.0974388993274826, -0.04834254200119602, -1.199965066978585, -1.9272389449938643, 0.07078442033861586, 0.44932189098318354, -2.2267637275664143, 1.2410448031797263, -0.9181788285240123, 0.16669002732415425, 0.6905830834841973, 2.0608090522475093, -2.5533900009693484, 0.8588901554514535, 1.5529305802202271, -0.5516018898041762, 0.4261016043904739, -0.45570965563185317, -0.6079698317873208, -1.1750232971662442, 0.27522114350999727, -0.9226263433486517, -2.2459229327720074, 0.02712647861253433, 0.00036487695894110603, -2.2779216307302326, -0.32302370811082215, -0.6784911373530446, -0.076588163077582, 0.757252488998011, -0.6492479306761711, -2.325410861042606, -1.867918166094158, -0.3223302377470289, -0.1261817063434721, -2.8654790603569302, -1.414801722718228, 0.33993247292394807, -1.227309782997439, 1.3421210821344387, -0.17629351800618093, 1.0491594382585097, 1.3372141636115862, 1.5612867864792008, 0.6396770086072472, 0.7039004294590311, -1.051286062286298, 0.6590553696962489, 0.02383648220318982},
    {-1.6408111250013933, 0.2321276330000847, 0.9816686044489379, 2.2590689553419576, 2.503886243279784, -1.7541111874467004, 0.3089526059029016, -2.4086518849399043, -1.9752800658501082, -0.6978327446817957, -0.5465982923194908, -0.7113466385348217, -0.2860198383031607, -0.8612706718385896, -0.4949584508444861, 0.9838032140338275, -1.415830441033408, -0.7404030912951955, 0.7981490808122811, -0.9864628979853268, -0.386569269943622, -0.546753935978803, -1.0120520431880857, -2.18279020191812, 1.2625169122629012, -1.000558116736807, 0.6890345718227677, -0.5929909352196654, 1.8160063082954585, -0.47194303966313855, -0.9596588896628613, 0.8827034914093227, -0.9162560600892028, -1.736502925588869, -2.619747682239904, -0.7278927518509172, -0.08641666274432265, -1.5874727999630458, 0.8752843476904372, 2.1669703109115557, -2.0230504313267956, -0.6318321884783532, 0.137963140054616, 1.447081865508226, -1.7259568558465521, 1.539965423822833, -0.5010559328688361, 0.32736775444489946, 1.3281451155990234, 0.07662460023034855, 0.7948045114333245, 0.18711059504967273, -0.49536722179073206, -2.0273669689396323, 0.20353299130163532, -0.4346586526483561, 1.1049309192324714, -0.23517815492762, 0.8005628456000616, -0.021413812076554475, -0.5811749711062526, -2.7317405033330484, 0.1015505644479802, -0.17637346841340948},
    {-0.40850759877825066, -0.41975183315784187, 0.4042745213623919, 1.333185197447778, -0.9871383522097374, 0.4123591819313142, -0.11376287934215912, 0.08616467608628213, -1.5026977643843755, 0.17448266121720613, -0.34517673605811106, -0.7813093452868412, -0.3046110294740237, -1.1485674704691393, -1.9656659885679, -0.8668243748760261, 0.5228890638784854, -0.8608751537629888, -0.023882226109228452, 1.4864851169233715, 0.6139303192216019, -0.37512276186845606, -0.08030374034285581, -1.2523406475882664, -0.13983193687937884, -1.707972426562481, 1.2780790689004042, -0.8883027038814313, 0.10923196927681272, 0.38626615316277, -1.3966681531784961, 0.38318006592229525, -1.107572746389683, -0.6067414578610929, -1.2482161981845665, 0.29277643180271284, -1.0250841327114903, -0.4427587870033912, 1.6401945250360106, 0.6538613499263033, 1.3788190229730923, -0.046634523860541795, 0.1309457018193835, -0.24778810544184848, -0.04258347736879381, -0.8882849608404488, -0.6742457733148043, -1.6284414900878557, -0.9750857213945482, -0.1075848809747927, -1.9343554279202333, -1.8051557894932866, 0.3188078799362858, -0.15679972728988534, -0.3445812961605565, -0.7452965225438641, -0.49005231899632656, -1.666292842542913, 0.9832201317140754, 0.7303381301751061, 1.5875472766066205, -0.12628776537500183, 0.09870075764795179, -2.3896615739074396},
    {-1.1599765715162018, 0.5424511524422563, 0.37762970076264896, 1.6259203275581282, 0.46138943842933233, -1.7303120536622927, 0.15261769039962927, -0.6568224636034492, -0.9742624609492436, 0.4393166950511696, 0.30383812569879104, 0.3665524103427572, -1.1777769156642328, 0.7405070792568627, -0.07211233999487585, -0.4515584606763241, -2.2124388012817517, 1.1770514411793698, 0.49384564023438643, 0.6783950379430015, 0.15805271950657032, 0.3251255054808315, -0.9924766750394473, -1.0173610308745933, 1.0344817962122905, -0.6300189344836138, 1.4112836433861193, 0.190892866547381, -0.6053322817521184, 1.9060095841535882, -2.253905249568075, -0.8959912588495724, 0.8733030363570651, -2.0980569261061874, -0.6051767238424925, -0.4827035918546205, -0.35668080220642534, -1.836031259319904, 1.1047742792478223, 0.779121503925897, -0.8004205843784805, 0.11998601119182883, 0.29142803510981363, 0.34457158894879986, -0.5760970961942157, 0.9108462213780253, 0.6401427643215899, -0.7222151677840797, 0.491811763115052, -0.24048732606361015, 0.20969587068166975, 0.764393400856138, 1.0149681038748422, 0.2455244843347976, 0.06629474365457283, 0.2421744444741083, 0.8162965608051618, -0.006512451130239886, 2.038504002962339, 0.5074201055765784, 0.39923067196443085, -2.6505763984317854, 1.924651266220989, 0.27094333917369284},
    {-2.2285609427816295, 2.7033994694944665, -0.987636986190948, 2.185100361524679, 0.790057283372736, -0.9971788918289323, 0.6218002763784449, -0.1723481979564687, -1.5193884883158089, 0.09488075267196087, -2.9571581598921957, 0.36126479999391237, -1.1476847611098477, -0.12688880948792103, -0.07729414577931254, 1.8483853374612527, -0.20116154465938682, -0.18992202943924305, -1.315599110488452, 0.753461184389262, -1.54793222913224, 0.7127859823746652, -0.19339071093896845, 1.9582193963844334, 0.5969684206478891, 1.1682116552229789, 1.319158238542325, 0.1434588827149273, 2.0922023104687155, 1.8946898413303879, -2.2720034036750234, 0.3399531032665307, 0.858802151085288, -2.4708906131692814, 0.5298058952794318, -0.0018213281451121114, 1.3008966851002706, -1.5809140801035382, 2.6906238710252213, 1.39665366597428, 0.4314499984406843, 0.2984551893314285, 0.19467267500719423, 0.8291639447456126, -0.12236461328504525, -0.30363515063830154, -0.74698688104977, -0.3620799465585934, -1.5416306288618393, -0.9755105591807433, -0.28188384924868026, 1.090065231794085, 0.3351182964261629, -2.048567418740299, 1.1471620676099523, 1.1491271769484341, -0.6814397174545653, -0.21422863604371065, 0.40467146772013673, 0.4263325671149444, 0.28577550450067474, -0.9858652894201274, -0.5161886971859392, -0.10772078048359447},
    {-1.1138669419908573, -0.45424294823182315, -2.294975425370767, 2.61444093203591, 2.6358686334842276, 0.9889410351633847, 0.1258050554628633, -1.0147828550581992, -1.7253535193028116, -0.6410341339789961, 0.029745322328742493, 0.9110479663302227, 0.09221466265914449, 1.0083836210637944, -0.6609406995639447, -0.45782324828659793, 0.47224101517795614, 0.7878258952716246, -0.5623964579991076, -0.1891652308258136, -0.12586790634749895, -1.2723849382230181, -0.29753922302964736, -2.0172212071132183, 0.8559054815019927, 1.6971554370466946, 0.9386634722584023, -0.5621739294899128, 0.7915587465581367, 0.8961939877983129, 1.3572333639796177, -0.20802318873851702, -1.089697241440628, -3.110983634886166, 0.2956857718759714, -0.4449786384982018, 0.9129850396950185, -1.523536192681185, 2.5757947514981856, 0.982728927981183, 1.6265002664290096, 2.67997428105519, -0.9965237449396126, 1.254064024558951, 0.5143734816214858, 1.2101359115218668, -1.1018569220554695, 0.22887247347146145, -1.4948847036012425, -1.2325234454040537, 0.8674026848394552, -0.4197322445105184, 2.4707607370417866, -0.09040958325002516, -0.05719737317658474, 2.2873915806933094, -1.2104258790630942, 1.1743403105575363, 2.864856356492147, 0.27654578413737274, 1.3601850628107712, 1.750411320382113, -0.8918945685308258, -0.26584338417288156},
    {-0.46069792712111385, 0.45356590953390485, 0.776921443839013, 1.5262490944501226, 2.4810114357600606, 0.9065954330312286, -1.967956722316221, -0.5325665493100271, -0.5687820347906863, -0.8606582605502082, -2.821428130576651, 0.6410060835895168, 1.2857445349134693, -0.7672133255932181, -0.0626584189007401, -0.5671673063548441, -1.7576159295082874, -1.8159585009571246, -0.13533308408954145, 0.44872930009306417, -0.012476356377488064, 0.35743625100347537, -0.8699611619672162, -0.44793639000120333, 1.712864992160596, 1.5562351237574394, 2.9455639888540497, -0.511822595450619, -1.5102754755205476, 2.455189850039565, -0.8197148834736857, 0.47779597635157584, -1.2555141357013486, -0.7527540796238213, 0.10633483646298786, -1.519940324966862, 1.8112288223803366, -1.1820450349395657, 1.2886755119211244, 1.1330791741732673, -0.033796271059506194, 2.0016859162870118, 1.0512510780952344, -0.11597354535128543, -1.3588240865695347, 2.8743692679262427, -0.3939360852883536, 1.5535828584098186, 0.9988794649356459, -0.49833943751962345, -0.04254215777943492, -2.426300094974772, 1.3522527243130065, 1.636095367568503, -1.1086905824970077, -1.116015283061686, -0.4702217099091196, -1.1271516336321483, 2.468632176046839, 0.8872864210736213, -1.817409089968342, -1.2091871884146037, 0.11131645952659396, 2.0647768242715263},
    {-0.007231116222602537, 0.5702486579891268, -1.6392703250572047, -0.0890081420211288, 2.050187313797585, 0.2586135060540381, 2.6905041525912696, -1.7899460663768962, -0.9036084782534718, 0.08463325716043132, -2.0869585149819, 0.07535354761684575, 0.45370497516813413, 1.7391646279788437, 1.182186108859491, 0.20106103884919466, -2.608626274182281, 0.12855912313935575, -0.1072541818179308, -1.2423993634008843, -0.8659251692681333, 0.4148971803830073, -0.34755649240606507, -1.2487951021229062, -0.02550059371262742, 0.10080958920458792, 0.9706823964368266, -0.4719692909692424, -1.2678150088979305, 0.4362746150604735, 1.290681339720073, 1.739941239292832, -1.604789261719678, -1.4975582964022283, 0.8768033052125841, 1.3529792416788144, -0.27358076481770766, -0.684625696698988, 2.7409945986930118, 0.39849795981692754, 1.3941427641065676, 0.9110071758463276, -0.7554033183816569, 1.0865755179643286, -0.9139287902825305, 0.6138887677015613, 0.06281154048235019, -2.0377866900734998, -1.1829878496406876, 0.0646722848806905, -0.38873879287525287, -0.7366397439786727, -0.4805152886963465, -1.3693792092733634, -1.3593383898312028, -1.469789049758607, -0.5967399345307471, -0.42890776855096424, -0.05396907926307639, 1.1180651950541278, 0.6532556859508548, 0.42410029159835977, 0.4876498574443994, -0.6024690151836216},
    {0.6651031572670881, 2.5149897850141194, 0.7558609270511111, 0.6582208041619038, 0.6058629783985237, -0.6065348051129762, 3.3529570228177237, -1.8291664916091175, -2.0031715723836325, 0.07187710980930448, 0.11743181740433614, 0.393378650838241, -0.17149415869187573, -0.06571861733951766, -0.829891874778783, -1.66447518598124, 0.4488358327712728, 1.7469356144580002, 0.38476742718838236, 0.07811855043113594, -0.19678453744715432, 0.33603472549038255, -1.429450757220207, -3.7311668582319597, 1.5057614545906937, -1.9276696546429963, 0.8754524561116722, -0.3092200741365452, -0.6185412980011398, 1.5024601235795718, -1.3420698564622555, 0.8407921492951935, -1.1708435034064835, -0.8661347305225364, 1.3150702856788368, -1.3646327086241479, 1.4986881636488267, -2.976613606420837, 1.0692186152982865, 3.063714010440992, 0.19789929089027905, -0.5397108139340238, 2.5986206450320632, 2.3688446240354186, 0.2519232898509636, 1.1556247184759472, 0.14349203197607113, -1.3891005263715215, 1.0811569004769324, -1.7321361989818371, 1.0360973115636802, 1.1610907473034475, 0.7336776909941415, -1.7909553410454937, -1.487218297209725, -0.2643465319719229, 1.2063435984898712, -0.5403136760893884, 0.6421051797089598, -0.5007885251539862, -0.2121385912825122, 0.3903062055790057, 1.3289388662072261, -1.1453555666066544},
    {-0.10216703563977668, 0.8914326087050406, 1.341712219539463, 2.266621006738558, 0.7054808791601637, -0.5147232429630982, 1.585786815346918, 0.046730375680545375, 0.10930508656782696, -1.0354301857337331, -0.5082411644506714, -0.5205927063356032, 1.499749437103603, 1.870814017636792, -1.651066578862498, -0.4527355250985231, 0.07639652596520946, 1.2069728753809366, -2.1919518678800363, -1.2405998879058238, -0.12150463215782521, -2.0747500911684744, -1.0996890146831642, 0.21829685637768909, 1.6800919861654973, 0.6933880397474148, -0.1979728332985561, 1.5583599559486776, -0.7186817153568794, 0.9276625838700834, -0.3694845576931833, 0.1644720195815857, -1.533242894916834, -3.606894687852728, 0.07150641294216012, -0.7689590362672448, 2.1656656536855508, -0.4582258554166672, 3.3684787664830274, 0.8392362713298357, 0.05461566202010579, 2.6606407637642335, 1.6489055484522441, 2.5576633576337917, -1.4618980039843337, -0.4446761132739624, 0.5029530321124372, -2.1378943973293114, -0.5968228924077941, 0.5324627798075715, -0.09028439429467555, -0.4091222930013, 1.4179756714252432, 1.105538822098675, 0.34953908523564164, 0.4970253370238316, -0.9601986060053863, -0.20407483313862748, 1.8949676986455641, -0.025119380493301247, 2.038256835613845, -2.4250834107876345, -0.812736970047176, -0.04930945557557597},
    {-1.8493319129437986, 1.6150615381390663, 0.6777588283193708, 1.616453910365653, 0.6400533800529016, 1.1000666950384401, 1.5597102586614204, -0.15350522533607786, -1.3866860857018293, 0.9317327770779763, -1.8524698725791051, -0.5114812232733683, -0.31524895058953833, 1.9349554230510126, -0.3111352730709713, -2.450462502238922, -0.29512883116016636, 0.08479081731078483, 0.16989346803462835, 0.12765308133383535, 0.5336230702235774, 0.8976090150897529, -0.4212121289499913, -0.8419101908592447, 1.073783448273808, -1.623784625807348, 1.86961747575541, -0.28048057100445584, 2.1610796545096753, 1.1043748916359462, 0.5427078011480716, 0.04127609226613002, -0.4711789557042393, 0.07883541894616243, 0.7074909697626064, 0.5897093165242742, 2.6862544706330684, -2.601493917181434, 2.608479537246647, 0.36365855809626274, -1.1427433577822397, -0.0904097786624598, -0.341858593283153, 1.5693402298247945, 0.30472082410874535, -1.164240713632753, -1.7329919861011533, -1.6141621928915926, -0.4743979806456659, 1.1481705101468864, 0.5227045057840914, -0.0729747144585627, 1.1254501448180243, -0.04780714521426194, -0.045989165958561284, 0.5790002613216557, -0.8347377208462387, 0.20191183527110365, 0.7997580323095327, 0.06770322446287956, 2.1501325906209465, -0.46157973740555763, 1.8645886606622286, 0.5826814660100503},
    {-1.3148114645516567, 1.215229326735071, 0.26654395653846596, 0.3739452230855901, 0.9634143968719612, 1.4773297947324089, 1.1840792657192878, -0.5383398949855087, -0.18053483239482696, -0.2826798874847462, -1.210095979179075, 0.08285051882780459, 1.6833312426241804, 0.685625591205665, 0.3958485491284775, -1.3282118999810253, 1.1687956266886226, 1.7490369213693355, -0.6874616653449763, 1.6231221188244762, -0.3209302389760298, 0.6189339585192561, 1.5409909794794916, 0.10240264334157277, -0.007657521757851487, 1.9719564146743305, -0.13287211791190856, 0.2185563093116911, 0.33936515423391234, 1.6736955248372818, -0.9291301055878568, 0.1879744782050709, -1.6034951485298703, -0.611286720284788, 1.2098278958708184, 0.6812953890859325, 1.5670865197917576, -0.6692188932504708, 2.999224836625423, 2.1530956086618334, -2.0550586648427687, 1.4589068646721064, -0.379390031491374, 0.19995028370565435, -1.4155762458656076, 0.15178199418323535, -1.19247851214962, -0.919418638602188, -0.3631243853908195, 0.0761762099092248, -0.5815340064954378, -1.5939027689094059, 2.2527065851765538, -0.6726018234527527, -0.4496593620605625, 0.3293104932854023, -0.5823780107727405, -0.2265171395752232, 3.4640172303754198, 1.3530574283940286, 2.1446798926173667, -0.32233929389017973, -0.20832573622440106, -1.6023475584692324},
    {-2.1135613626271095, -0.6625075741696914, -0.15133635890676686, 0.737374897522176, 0.40953975007982363, 0.4619547576658418, 0.8228832335062477, 0.7293002439799993, -1.0574646930525091, 0.7590219920011304, -3.3339341829190268, 0.8089901562978405, 0.7819031635095869, 0.9657866737708425, -0.8806897636244609, 0.12065233160545312, -0.023740977161075556, 0.6792263172854769, -2.121394587494196, 0.7890227188499983, -0.25309533407394413, -0.6430966943266784, -0.5167977645656051, -0.2485622250458282, 0.27348538441137005, -0.3232832674608682, 2.993630928189216, 1.0221953803664763, 0.7113491073157703, 2.5198506742621305, -1.3788705637456502, 0.1429186743580873, -1.2461234555320242, -0.48192910160206803, 0.42929841410344005, 0.14108851088571162, 1.8050387071926761, -2.2887531486148958, 3.3258211026388684, 0.2658564610797072, 2.6865344652780263, 2.59081785883992, 1.0093199635307701, -0.7611946311533345, -0.9802733378503908, 2.2634742407513246, -0.26303505616007583, -0.7227579846917742, -1.6750337677990386, -0.9212827629605954, 0.4945061130911141, -1.1934419237025886, 1.6930641018541739, -0.6166397313734642, -0.7832544292887831, 1.6208596065418392, 0.723081577248091, -0.16285605462888378, 2.5860412618793704, 0.22656171315333637, 0.41042333249228047, 0.28194034258424505, -0.08224891484880062, -0.8995414926799914},
    {-0.4772376197709062, -0.6697634274144723, 0.1996832811260154, 1.8699413880540134, 0.6130655014692858, -0.44863659326882116, 1.6042976535649485, -0.7976142733975865, -2.0277463120596226, -1.6240162587288414, -0.4849622883757834, -0.466602057024799, 1.1061196565205496, 1.4377064958965242, -0.6900594655484726, 0.6836660971487954, -1.0874581819702467, -0.1841275240377001, -3.0303248246403873, 0.8908064667554474, -0.17030888055017993, 0.8420702243395229, 0.6351099407666269, -2.236927704142709, 1.150271525461689, 0.45573509199137796, 2.029813019949158, -1.366039801212955, 0.6396721457151309, 1.3075761357733802, -0.48340852249868516, -1.1321295879818738, -0.7352469709838351, -1.712428411910041, -1.39859067167524, -0.9748051388267206, -0.6454812776923637, -1.1077401480559614, 1.1219320696979789, 0.6133614874758981, -0.8731103022091896, -0.27430503114923666, 1.7905576886706558, 1.340076012119128, 1.4851206246381499, 0.551453836651803, 1.3960931042540068, -1.0487653864679616, -1.284521265890179, -0.1321903419397309, -0.5769200410773423, -0.4260153534326388, 1.4870694561339852, -0.8961437717272208, -0.657096610688279, 1.2972943960272016, -1.5750086733199418, -0.0191971469193475, 0.7901727158632978, 0.9881936057756402, -0.24130849276674537, -0.43794491181299006, -1.2703164263596998, -0.8007254886455014},
    {-0.7640880173599449, 1.251839720350897, 1.3600847426562965, 0.6440314657742615, 0.7587606419922494, -0.7826102821988278, 1.3915175979719345, 0.959994943378086, -0.5504667399821259, -0.4006689842630891, -0.5517052922997, -0.34837976690275474, -1.6126429228507173, 0.804844846219875, -1.2618042189357352, 0.512977496176102, -1.0454707621573753, 0.7243325175526005, -0.3939669496985951, 1.1703703392653744, 0.19060118605986512, 0.027714994687941627, -1.6259437166601516, -2.81665360454586, 0.547044549446869, 0.9135214679101837, 1.480819176268907, 0.701935355383334, 3.053239659480158, -0.3360226830084179, -0.6006474146918193, 1.672817378753295, -0.9973577984324223, -4.21505800603274, 0.7058113803780486, 0.6557556976820959, 1.6038486080533383, -1.8393450296920115, 2.108925422020404, -0.2515812443197873, -0.35551707181848907, 0.012256358668720371, 2.699533106850007, -0.07486798695896946, -1.1116189040168063, -0.8891162392575448, 0.30190121074059745, -1.124878002008702, -1.583081742625566, 1.340204532764828, -0.7760664263746018, 1.3830077675011523, -0.5316493872227769, 0.005483775589509532, -1.4581584490566841, 0.009134448351068417, -1.308086928520459, -0.824272557143715, 1.4481935921905251, 2.0210017875140864, -0.14147546775007874, -0.09274086159118287, -0.7093413187786914, -0.24046560039429998},
    {-1.1722444116023572, -0.6032650214222273, -0.21290138449555568, 1.7143513910334032, 1.340188540859203, 0.8499131993179244, 0.24558311727975607, -1.6640474132994423, -1.5261040630427796, 1.4604056462942214, -1.0201872267979484, -0.40723136450065917, -2.9298581464278355, 0.5561106659279615, -1.7514619397058322, 0.524092125097474, -2.4488275503305887, 0.006062442254706251, -0.25572830464479723, 0.3118497470578583, -0.39792727137590034, 0.6364426978727075, -0.03064281347493575, -1.765798370683393, 0.5914475302507634, 0.2708091810006606, 1.9202207515782954, -0.7975858533187542, 0.32044295878757095, -0.08078045970791985, -0.01239553409799181, -1.5291998938255449, -0.5838044003208337, -2.265081939477861, 1.459202240882556, -0.728061795162784, 1.7910700041929544, 0.09890646701810742, 1.8478127215370326, 1.011045674967949, 0.5797155254835515, 0.5125960431698369, -0.7252596032973776, 1.4834539675197895, -0.49056245025961853, 0.7524753151117946, 0.6406945209164893, -1.3021850067912077, 0.1403202934932143, 0.11850169256827243, 0.18068117330627112, -0.5762233682939383, -0.2735440879350282, -1.6582584943666663, 1.0951673597548843, 1.8523028789848213, 0.36220121660726706, 0.7987483868967599, -0.7275882287708598, -0.024684900367256197, 1.4270062373150434, -0.4045076801478923, -0.526016106259145, -0.7582192388640125},
    {-0.08343370992885923, 2.182225787456767, 1.3467427272866752, 2.6172338765485135, 0.12455392472934632, -0.6371304172299566, 2.173880227974608, 0.43593028291149843, -1.2513885039551416, -0.9569039179346297, -1.189609436623381, 1.6803991571811432, -0.6067775663350745, 1.0748386727481016, 0.1662688192578554, -0.3201905877426638, 0.4448605704814492, 0.03874914078401923, 0.7151536956357754, 0.2988182867039729, 0.611855317101956, 0.4007676157619453, -1.1829857588201036, -1.0160462918087387, 1.0456970337303062, -0.1902005358350807, 1.3418013375800797, -1.6680317148534127, -0.09877447314696804, 1.3312370758948084, -0.734220348195513, 0.5105830881169541, 1.3571196687605094, -0.5650556513980067, 0.41331432959151576, -0.7702506828214685, 2.5474065773691557, -0.8606449773403259, 3.1115234482470253, 0.025663181518370565, -1.405863493615635, 3.5305011915736384, -0.8748488932585669, -0.7310194539784428, -0.9369015432897148, 0.22843699669471337, 1.3176791806943995, -0.7346640041007085, -0.6933537259147761, -0.3725276612375656, 1.1403426696571133, -0.047006015188368486, 3.5282137606016235, -2.856140994694405, -0.42915818428073266, 0.27788691539039295, -1.3149701671443692, -0.7575873923046892, -0.5201717614577878, -1.4213421223497318, 1.9256307143055864, -1.215253828906539, 0.5645071792610395, 0.05554255356489685},
    {0.43348958007461286, 1.886606464636942, -0.6128074120496145, 0.6425278891520522, 3.3464517279318606, 0.03436221762248004, 2.6472960955869875, -0.5360771828939878, -1.453565537303706, -1.2335717655262597, -0.045813455906043174, -2.1994084147305393, -0.2193315993667028, -1.138295102110824, 0.8760817586112021, -0.35004392871383744, -0.03781260232182213, 1.3157084345562464, -0.8267899605489828, -0.01558756174617992, -2.7742123089502253, 1.3282465846670586, -1.8662811825550594, -1.5903689942175379, 2.1397730472225143, -0.7931122682864521, 1.2313379675739586, -1.4058881141412778, -1.2141953319571133, 0.7145247308760143, 0.39381589612660506, -1.4092300156094448, -0.024803702117658897, -0.4516299436227802, -0.7948885779497421, 2.0429690835028236, 0.42949072572980074, -0.6792185372324824, -0.05983005881580495, 0.750356421157018, -0.6369506252911044, 0.08633121376616351, 0.5499558976625952, 0.8365043053535897, -0.6170709904462249, 0.3589684891968039, -1.848791808122079, -1.1630265512331137, 0.1939874466866251, 0.08883541733799391, 1.3281600726336418, -0.11127165918370531, 2.463413265710871, -1.170283069639499, -0.8747280127504243, -2.2537805353355838, 2.088985617761204, -0.9967067329765511, 1.166118425649621, -0.17031934139431645, 1.8536645092549608, -1.6718264717871099, -0.0812481923270761, -0.6211803693562797},
    {0.4337835909056401, -0.15844742867747816, -1.9929943938186878, -1.0262163917829024, -0.19706655252346866, 1.0058051426473615, -1.741595757752079, 1.2377286865466441, -0.4583396780802597, 0.2701416644988694, 1.0764032987060541, -0.5771630657265556, -0.17084014446342444, -1.2536505990801685, 0.047286020029197774, -0.08703169752888924, 0.9019932108350995, -0.8399935670705412, -0.2759783794296058, -1.66880726047556, 1.673949542401833, -0.9137580851642879, -0.49945341184647557, 2.0047583006900727, -0.08524767938232589, 1.4056000934855348, -0.9782070816472102, -1.0290574547413776, 0.30030047145157024, -0.3347161520590032, 1.852945029577927, 2.30250163287842, -0.9036266892772683, -0.2138804969686198, -0.8935069448438148, -0.6378790515381965, -1.3336507699142732, 0.32206527590863626, -1.0399076212677707, 2.0383449752330733, -0.7226884033833275, 1.1710853775710264, -0.10479955520479463, -1.3723586260537581, -0.981182199285374, -0.8941358551587177, 0.4618497237305315, -0.28232286883750185, 0.31917805616726364, -1.085344948463051, -2.592859446391615, -2.6953627501613426, -0.09730396689071444, 0.05041797261809637, 1.0630855451606822, -0.8225743757021244, 2.155920671148137, -0.21192844460064347, -0.6517551033727488, 0.18255734239488636, -2.530377046496004, 0.1706551354549878, 0.5529265436187648, 0.3271434165112076},
    {0.9630591194856456, 2.311771111082413, -0.8577209649166773, 1.1584836230668607, 0.4611427112890565, 0.9349164009797829, -0.2692562744936128, -0.29357462151405317, -1.6925033885386314, -2.7759307859699702, -1.3608125191503677, -0.02369516601517514, 0.6826263544486548, 2.806445984373239, -0.8695881788616177, -0.1918336798836841, 0.6571676018334218, 0.4111101752365642, 1.2921899217191932, -0.429040754158667, -0.3976436440635849, 0.2520558113195616, -1.2171675684795022, -0.41067549662688724, -1.678100159498411, 1.9497923623949318, -0.18834762000502128, 0.6290499612587792, -1.1651439179344536, 0.4953186539425105, 0.1633202902660319, -2.303137545500251, -1.3151673995339679, 0.05029943441568953, 1.0743731225759354, -1.0461546497895526, -0.36654232306811296, -1.468954255606985, 0.9160825605037122, -0.5947431160972623, 0.7613382007049196, 0.2022670990018109, 1.0297068532910914, 1.3584219536953848, 0.25389756570416716, 0.2632478527085065, 0.14209996038831946, 0.40168607512199567, -1.3704565746767476, -1.0791768583549393, 1.2460098461426512, -0.27669875826192175, 1.7397573170627505, -1.7177430480532976, -0.21486400297994102, 0.36839143275306335, 1.1607642654067967, -1.2063668618686705, -0.6152204458235854, -1.1002029609529116, 0.11422068277002669, 0.5618449517079643, -0.4289945433207652, 2.234256601855966},
    {-1.2526301635718862, 0.21945662815280703, -1.1283369707623851, 0.4216343736328393, 0.7378329662525455, -0.47052878620720107, -0.4488244145819509, -1.4313427837953765, -1.722842867771134, -0.903663012632468, 0.7708583713185987, -1.337790990071676, 2.1403885235311004, -0.26927741799169835, -0.6526081317208058, 0.09721735365362222, 0.2073410600355699, 0.5849944565933092, 0.4661164173971589, 0.2005107949118613, -0.26544887756550073, -0.037152698255445656, -1.513853679755609, -0.978301091362182, -0.14513084878197685, 0.5869466239883314, -0.4663329371489229, 1.0308453149555548, 0.05391920490216246, 0.2062144962973522, 0.36038500216244124, -0.237751557643968, -1.8789003162441043, 0.40417255929149976, 0.30249722286745906, 2.2212737819187693, -0.7935193658524853, 1.7958222629913583, -1.669453240352632, 0.9320811663308816, 2.4675088760788024, -0.8366452983009726, -0.9364237968268848, 1.3325693449538836, 1.3011107286830463, 1.1220150839831153, 0.6064919386567066, 1.1710464199347812, 1.0302861999088373, -0.06849139628630696, -0.26715344328097573, -0.28567221308703156, 0.6661744413083632, 1.825291992182855, 0.9723525817752784, 2.310968265810727, -0.2740399561932992, -3.201004456903393, -0.9963523074410908, -0.3187523311905804, -0.6593896012763928, 0.422144628634096, -1.6101739343235322, 0.12225258595570516},
    {-2.6670285156874725, -1.4312028355584223, 1.2528042555885022, -0.10713848111159208, 0.5900584830601104, 2.750508205761734, 2.020251870127149, -0.1402312527431609, 0.644162729844635, -0.591167332575966, 1.6889131380489009, -1.0123676549390037, 0.6888075407124696, 0.8555149228255162, 0.450304497940632, -0.7772126163514467, -0.5505711027783639, -0.5566761349482452, -0.4651428898294618, -1.389044567059163, -0.6910742579600943, 0.6240928791229466, 0.14924761185747557, 0.9333611301637835, 1.205447292042908, -1.1427113053788984, 0.0720201787705957, 0.8782075361151718, -1.459101203067331, -1.090745882912925, -0.7577774922663547, -1.6036994221219454, -0.8855387645933904, 1.9879419177344924, -1.9701250897341787, -2.0646471205660566, 0.9039902019974964, 0.004206826536491223, -1.3052412662141144, -0.35287882269021803, -0.4738494292842818, -2.3093537174960836, 0.7377721633371926, 2.0970353674342723, 0.9468040569831205, -1.1420232128474261, -1.723181477688822, 0.4075881334925273, 2.1811532511921268, 0.2600020903267797, 1.381982006339267, 1.3451568268230023, -1.5516951602691829, -1.48172809589317, -1.7530149331367926, -1.0872748321097139, -2.9852548360170164, -0.27172376886214955, 0.5550973146757131, 0.4960358820298708, -0.6423893297055737, -1.8519532231884324, 0.17358214851066378, -0.2032550124903824},
    {-0.24878606522795924, 0.3074579969210861, 0.47456539587137914, 0.592374397646746, 2.3873950842440044, -1.8857959429396287, -0.7205390500727812, 0.0006909771820756647, -0.7857735912700019, 0.23754745122484483, 0.9882947489256722, 0.8990549355797011, -1.3900821634536935, -1.290677016939948, 0.3913748942141286, -1.5560788896644642, 0.36117324131796874, -0.22350116659391103, -0.8571453421526792, 0.36561567344295076, -0.1061837710462441, 1.3953585000321422, 1.1151136366711816, -0.5680927223082498, -0.35113087929340814, -0.5775858336299023, -0.6644427913573523, 1.2880556031044583, -0.09921638564975134, -1.2299335151117168, -0.1333852391127398, 0.003715937849940216, -1.6369725688846688, 0.36865753489733677, 1.3632643870561292, -0.021397174046967546, -2.3731299131868053, -0.59243478688763, -1.0841590398764203, -0.6152873928830526, -0.013743163191438774, -1.4278217980603725, -0.3731973399074456, 1.4156191554697677, -2.0443011597211918, -0.4788568138030621, -0.32358764501383, -0.4060764032802878, -0.523326326229821, 0.15393386833416947, -1.446298893328896, 1.4247225085657458, -1.1900960691860183, 1.0808920308094716, 1.1317718729218864, -3.1768562723806024, -1.6225427383295277, -0.35927129535242724, -0.5642478228478336, -0.2172308059922357, -1.4744860722478232, 0.872518026451944, 0.9965573123927727, -0.4207721155824752},
    {-0.4907644654558661, 1.296473610407159, -1.3380554384551544, 0.6930644946499802, -0.4404865216545559, -0.285308794252548, -0.0039357121009295426, 1.4839643338848514, 2.4360560635236173, -0.2529522130706612, -0.933418785029649, -0.4670708415113464, -2.320131080907878, 0.6672972533551103, -0.060315334830804944, -0.6619900727708766, -1.0471487693878372, -0.755454697075017, 0.13836368973564614, -1.4656374168202844, -1.7998194571795376, -1.6995985951340171, -1.4470910810499724, -0.805948379031778, 0.260477661130616, 1.075433129276385, 0.9947969901365148, 1.4935013457740982, -0.659313604876613, 1.0369021039736768, -0.516923470983746, -2.1162730201512705, 0.8018717681021533, -0.9441336999034755, -0.397689385758362, -0.33752919111516233, -2.2112435387729006, 1.521750648860438, 1.5529673551054688, 0.1572985946893475, 0.23562327952514064, -3.452395490320151, 0.48305912700045434, 0.6115122763038752, -1.1464565755678882, -0.013589765386061745, -1.8280550840541894, -0.6848110330825057, -1.0527803644557543, -0.290748656495565, -1.7074004705167385, 0.11998866985414254, 0.915631369396322, -1.7141493884004912, 0.10438242485123919, 0.7219665973754185, -1.721315963849728, -1.2529521576014533, -0.8846490705130541, 0.5324554217732186, 1.5570550450889167, 0.14578727247431156, -0.7954657719955684, -0.5855942988990149},
    {0.3295407511245455, -2.3121024956668212, -1.6962198981737233, -0.039439656982990186, -0.6380639230206796, -1.7435879070094131, 0.35057571630804046, -0.22673453109287445, -1.1797593288546424, 1.340554381872641, -0.6761117881196801, -1.0793222795613384, 0.7558450689659199, -0.22833106690812363, 0.774007622601295, -0.9558884713750095, 0.6415541316486097, -0.9670096880487085, -0.7138605178734001, 1.1730136376913864, -2.269733475572837, 0.9415565485926624, -1.4221470211352076, 0.8944995892674587, 0.15570313598110422, -0.19378599127508067, -1.4450318169743803, 0.3053367038750978, 0.5469469917362012, 0.9552519579104584, -1.0880331922747464, -0.29295811506554914, -1.3161104447073542, -0.3654245890451919, -0.3543544873678631, 0.655377519903868, 2.2494158088842187, -0.7186494055277751, -0.5646422916340127, 0.3883186131442484, 2.1927030274169548, 0.7510175694182916, 0.5011508190843159, 0.07882508424946276, -1.5162803298472316, -0.7418990279914502, 0.8170240894709003, 0.3461131350805842, -1.9549103019626028, 1.8305524781387619, 0.14451799828572942, -1.5889906733161152, -0.6818224028591584, -1.250776415631117, -0.14390435037414925, -0.2808101704487076, -0.05934457592839313, 0.14512896804798445, -0.7067366491700383, 1.3084001522276085, -0.22169513655830705, 1.2139397516743027, 0.22152716303899755, -1.3100260261778538},
    {-0.13192860929939534, -0.6412339898997302, 0.02610975947124846, -0.07859117404184501, 1.0795789124676833, -1.0902472802942533, 0.7509471907795496, 0.09534572894111185, -0.9193989966775898, -3.2494312611018894, -1.0136290322586021, -0.269380439576415, -0.6416952520478524, 1.0476515623231544, 0.6671726260528044, -0.12425372533580666, -0.30366437825559295, -0.3590300056930697, 0.9720776213767908, -0.17963700322329618, 0.7259166822012232, 0.7193347744734315, -0.7556967278995635, -0.6947870891499388, -0.8168567202613043, -0.9369679377888931, 0.867231016900547, -3.643633255999436, 0.05044655935613206, -0.3249780191147551, -0.42991369272300445, -0.9241095197597733, -0.8179261570521633, 0.22158470008479972, -1.3898849110788192, -0.7592146444844879, -0.9997972243499493, -0.08064846716963144, 0.3283270675171105, 0.2243295954376218, 0.03896508619587782, -0.8509621366327241, -0.4238524492085893, -0.24792941214796585, -1.8700937748185873, -1.077588698894692, -1.3310946876319751, -0.7046008199396714, -2.3505567421922122, 1.2641577791395338, 0.42927143180071053, -0.7634336648655484, 1.5441247376737834, 0.05940629203445996, 0.7420185800964635, 1.073405667759973, -0.03979728418749255, -1.2279607962153907, 1.1550396997179295, -2.281079482196115, 0.00690587937237252, 1.457264668680327, -1.2556410523708053, -0.16981752451246693},
    {-0.030950293146225293, -1.3520367610520352, -0.6155479086067815, 2.143396171010222, 1.2633101998149414, -0.048436649405790115, 0.6506700822983974, -1.4678795346886173, -0.5327048816495766, -0.8767118281056936, -0.3026922105066012, -0.8201680889929475, -0.6191807881809102, 0.08159588333400614, 0.11623694747021306, 0.6513714546352442, -0.7225139211101176, -2.7789303943042354, 1.3075234521135566, 0.04656609537786249, 1.2823439957639022, 2.511665780832108, 0.023598519572269137, -0.4571639314660851, -2.9891252350244977, -0.19306309091932317, 0.45667112795774367, -1.1754264704949098, -1.0631584504888236, 1.1880081279493895, 0.7164242531480524, -1.600956239085578, -3.0525881708172644, -1.4854738563971628, 0.7033684136909754, 1.4808503367793304, -0.8529068556212015, 1.6748621739634022, 1.3456721545647496, -1.4771075012199626, -0.5938411542240938, -1.361916560954765, -0.41694654842574697, 0.5002216531545519, 0.5703845384451239, 2.001522945230948, 0.592970748116467, 0.7602259666519707, 1.2636232282781876, -1.0718395087669135, 0.8420312797883545, -0.493581961562348, -1.3832026592191782, 0.9100299596945916, -0.4361904000316974, -1.9493376571305148, -0.41797336531714563, -0.8447033003734272, -1.395420864060918, -0.826508471283683, -0.23523666475526298, 1.7979105606644943, -0.23900437598504887, 0.9996029125214043},
    {-0.9964484658368483, -0.7765197741430302, -0.8433831574898752, 0.8288538852030096, 0.6501683555158244, 0.37691421313142337, 0.18133128941207016, -1.5463513160778575, -1.3337102345638168, 0.8270271323108134, -1.2555409141169545, -0.8951638837156234, -0.39824333719373584, -1.3288054309615744, 1.3945366814360844, 2.3989330096349795, 1.344241171500906, -0.9171836321468115, 0.5566469699812447, 1.0499055461499647, -0.9236854570629479, -0.4638152021148489, 1.0678507175905672, 1.0302258143245517, 0.08500563839324318, 0.060056966756310906, -0.3797355371820257, -1.6725891146910825, -0.7360902320753661, -0.2517073121114654, -0.10005958921718093, -0.9030143335223608, -0.8931778093708657, 0.27260571600705363, 1.2828559682801293, 0.9338330758364014, -0.4769524056501325, -0.6258245754090197, -0.691381267721125, -1.2261000042068992, -0.08107556078365713, -0.8039992607506371, -2.078199312994339, 0.6974488093677546, 0.42803624386750627, -0.8912816669362185, -0.8595520759017196, -0.6789097795282628, -1.1169984268499822, 0.7985385077404514, 0.6088877935791559, -1.264084452734681, 0.030196878887347574, -0.3902009837611287, -1.6094543205204253, -1.0738116067565047, -1.8470292541733673, -0.9456345185944641, 1.1195188999536898, -0.8805001147947589, -0.48259936160022865, 0.8689724205203837, 0.8427065384780371, -0.44453971818404553},
    {-1.8077673033815058, 0.32406291042062396, 0.8199928500044602, -1.5360255220625798, 1.351113448000308, -0.9637216411149709, -0.6358195108361052, -1.4272781950738218, 0.38722662043703016, -0.612910146881775, -0.7669180431586634, -0.2159633394490651, -0.0816596044052743, -1.2269045324861811, 0.4235921099531913, -1.9897387212129878, -2.1643793568059455, 0.30210869098839155, 0.37686685814334103, -3.367004122050943, -2.4617034545066225, 0.07116943797647503, 1.4347966156813738, -0.8653678905877213, -2.687299934058702, 0.8113227753393912, -0.2051511651509735, -2.1331058360863686, -0.49808311196125815, 0.9274866475180391, -0.2833867396467783, 0.1556534790197913, -0.10359623761458336, 0.4901883849274514, -0.6789317528652673, 0.21289998795366039, -0.6076789625289879, -0.7212739939904423, -1.4773287543506244, -0.8867761852663808, -1.7247644984175865, -1.5930064335064904, -1.3164808660064187, 0.6805543664676985, -0.19824403068411314, -0.29635762210852157, 0.008080689478746655, -1.125110999278504, -1.541027996439068, 0.37232687560577515, -1.164758445954386, -1.9216590497115507, -0.7007805478585994, -0.588126109430455, -0.3056248777990331, -1.6302051872665577, 0.2197662339774306, 0.5374169278057555, -1.867336234232239, -2.854423306014414, -1.097032079628031, -0.8014254715858958, -0.5349619416741265, -0.7184914352401192},
    {-1.9590041003090035, -2.8400639766142723, 0.24201961476960468, -0.336892399416097, -0.4033225029876524, -2.146183734370004, 0.40654119525658133, 0.19053565401709915, -2.9488524118733066, 0.25479362224373187, 0.31894186691744203, 1.6067023716368425, -0.8863276395613726, -0.322825034128711, -0.9340999890889291, -0.4557672004319459, 2.499507233327792, 0.46999769713319994, -0.2374272785011213, -0.4698710496106062, -0.4210680929704924, -0.3110328167684536, 0.019184408579031392, 0.8246044425579035, 0.2235346071906571, -0.3791692415246723, -1.0582198543918973, 1.9777049866954501, -1.025105503975844, 1.899578777634217, -1.6643951593726138, -0.5804476461265333, 0.31379783979865644, -2.0030018700159054, 1.647329948588429, 0.19835346188494946, 0.1833198941857554, -1.375286970095843, -1.4212556977364061, 1.2027668062484023, -0.11588196007734021, -0.14240504529627693, -2.0709849716984343, 0.9474525279837958, -0.09843436152483627, -0.18212050355415196, 0.46301407460886684, -0.044775445424451235, -0.8653238600681237, -0.803786132690527, 0.29255372048134176, 0.3318660355196484, -1.7818616698986731, -1.0440605324029026, -0.060634368864230404, -1.6006501357402407, 0.19896691367479882, 0.2616154363068152, -1.3702279534106656, 0.5184239770927177, -1.0224621301647585, 1.5343997178275786, 1.0205658685083119, 0.6412746575468696},
    {-0.26777687810424566, -2.1658785934198974, -0.6359088628272457, -0.6269135537599974, 0.33233461133430636, 1.9298839386831008, 0.34284775209761875, -0.713144169374381, -0.41824308693242007, -1.4658065970979495, -0.1337543916380154, -1.4299079488251443, -0.9418495242366297, 0.156494977954591, 0.13953947192091562, -1.8207587136489913, -1.1855665931609203, -0.4710475857500469, 0.24979224095279515, -1.5962079739103463, -0.6159703207944477, -1.0090691002603938, -1.3583091944242767, -1.7065450736544685, -1.2587349333625835, -0.6717087191128024, -1.50081013149387, -0.8367868667233245, 0.18429327022768222, -1.2051304388138366, -0.36650402536811677, -2.486961761583667, -0.056164970467731765, -0.4343883586589693, -0.5749512394089223, 0.6010779943185443, -2.1256298932901276, 2.909604284534939, -1.183864943894665, 0.31777805444086976, 0.5375002697091088, -1.6017037964834533, -0.7650029991257636, -0.5694235121226153, -0.45325499716989404, -0.39427977919601237, -0.6479808482437207, 1.015192608524926, 1.3359082658710844, -0.013867735938325857, -0.423301453633434, -0.3167259913999634, -0.6828336583665694, 1.0894636679504732, -0.706104547487281, -1.003214858406864, 0.11579265244061411, -0.38213186041955105, -1.2236261181641706, -0.5895194727361781, 0.25653876210522836, -0.8175725375887788, -0.6301720235730052, 1.2853944870746674},
    {0.4337600350501366, -0.5420552827004551, -0.8609894100761024, -1.4734996542110705, -2.0881781741433207, -0.7828777639537752, 0.5216673089492918, -2.516146347196049, 0.40509412947126844, -0.21601760190054053, -0.8658443708558176, 0.7517728938148166, 0.9370135045016517, 1.682336515716407, -2.0776085913754962, -0.9608111466293568, -0.8088949481483323, -0.6983260228102534, -0.45226748639726916, 0.9987303278763093, -1.1236882681708418, 0.3985493240440428, -1.522334291566509, 0.33736661514876787, -1.3413677282419563, -0.3259696472569659, -0.8813734852794408, -0.06286918761225482, -0.44996046499770914, 1.2123742328859282, -0.524728427060586, 0.10682268094771616, -1.5486390233839344, -1.302378027222026, 0.15583662581975138, 0.9502001376766143, -0.04131081763169926, 0.1256318889387195, 0.030062698955644233, -0.00797043237446492, 0.22999510475276072, -2.963615165534742, 0.6811547733977908, 0.25253357967205764, -1.449698135710879, 1.8215378020875603, 2.1415753333597274, 0.47837380313041006, -1.6990965344974043, -0.46768072803377897, 0.49256633041102976, -0.9314690949920281, -0.6298503019364861, -0.15978793413605816, 0.11101467440416717, 1.0194569852462387, -2.857347019886461, 0.18261627847529752, -0.27721550149752394, 1.923733651313732, -0.3893689321778122, 0.18771851827345032, -0.6537242317751981, -0.6253126366743647},
    {-1.824718406846127, -1.8419909333100917, 1.3380420850168118, -1.639975828550344, -0.852877739338572, 0.8153713781790529, -0.22790388808752457, -1.1489231084110663, 0.2871180768897425, 1.5813487404497506, 0.5964052395218337, -1.1668271485490482, -0.33453638386079193, 0.6211853763084872, 0.10351949622246939, -1.3366750602602504, -0.7818213411604861, -0.8492220526768886, -0.548605712031697, 0.5747965839099115, -0.48522386566875014, 0.31628349748467055, -1.6854687753085418, -0.5201216566654564, 0.8309099960716367, 2.319307340307449, 0.39488835389861066, -0.11460686116394926, 1.1651672059724472, -1.886835477377708, 0.4063633757175097, -1.1261048283255803, -1.1283044675076954, 0.4090241870154469, 0.030194771205436968, -0.3285878914211124, -2.1626549630730363, 0.841414630330583, -0.16516780350733573, -0.4140122284701061, -0.5860448309160956, -0.2232512588851018, -1.0704029628457672, -0.2095079236344982, 1.8235017455514035, -0.08291813018134639, -0.10060927877211186, 0.4687173228944866, -0.5890144635990298, 0.12587358541711482, -1.944846749974008, -0.564289462258993, -0.38649680998102864, -0.6190158164237897, -0.590637014225195, 0.47822322672861534, -1.5481984917999159, -1.1960095304874536, -1.0768085270945582, 1.4075657815629674, 0.34682509952355756, -1.1699267404591887, 2.2258018223377465, -0.1004872524261572},
    {-0.2845451178313682, -1.6505300146272568, 0.2023803181039556, -0.6926764333058932, -0.3270147165889807, 0.9732812440571688, -2.1362156591345576, -0.34271927161050464, -1.6103769455989654, -2.25898608383109, 0.7657518294105924, -1.7850236429628838, 0.30394448864226353, 1.0692203187957945, -0.8131539886567987, -1.4845423534991227, 1.276844539185519, -0.6613610240999936, -0.2664297898518408, -0.5911701900313263, -1.0934695505189995, 1.322720483030408, -2.119089006030105, -1.1354198248022185, -0.899171395739279, -1.0618478067811923, 1.4595852542298131, -1.6617762843147854, 1.0490028332990027, -0.4977134338639491, -0.6323916895335798, -0.6414939337403768, 0.5378818793233199, 1.6387763050925577, 0.6347946403484586, 1.1877865548514215, 0.5708012903775568, 0.5071296878266646, -0.6074595810105143, 0.470823620951489, 0.8804550058583487, -1.6636758194733938, -0.9541391085660933, 0.44584454499669185, -0.17710430713631817, -1.5847011944520333, -1.2047313158131252, -1.3432042765505765, 0.5033785295393173, -2.1309156548294075, -0.1665509561028122, -1.6411255447859177, 0.3675169721169912, 0.2000185545914992, -1.3568500210259156, -0.013684204088088387, 0.06437169680184228, -0.3168228953800287, -2.1124559927487776, 0.9256046731152898, -0.009957649078449458, 2.3084311745073776, -0.8232863611453729, -0.4541664754924262},
    {-1.2425603101344138, -2.566189142570701, -0.8789550462869482, -1.2058331189409652, -0.9612165258879038, -3.4590267351343553, -0.34836405744603677, -0.9104915296072029, -0.7640349566735569, 0.23093234550857944, -0.5177862986994773, -2.0652964147577393, -0.40106283429545464, -0.5700068637434472, 0.10561888114644444, -1.309905452106443, -1.4050914196943651, 0.5922932016957969, 2.48612402236771, -0.7003070142977865, 0.2806235925238104, 0.31942499025996973, 1.0689966908683175, 0.4070978101226833, -1.6864247344343233, -0.31988094897504316, 2.573725159965979, -1.846779432028578, 1.4848386059032914, 1.4392028884210117, -1.1184927434968808, -1.3069756606223653, 0.47200861073390105, -0.88777183454372, 1.551661150126477, 0.8014321417556693, 0.5201467117506133, -2.02400023027855, 0.46330236190623986, 0.39842110056245084, -0.6681972649274249, 1.1698660189761403, 1.3971635313792568, 1.819041708329342, -0.61391338005002, -0.19060354708712074, 1.121566098197591, 0.22704992727680506, -2.554576661471174, -0.714174789842091, 0.6837645757656985, -1.3925017200426073, 0.36411978559274083, -1.1379667733477226, 1.5349986162305231, -0.7584681745189943, 0.9861095772943845, -0.9581549840513618, -0.12735890056967578, -1.958672997766367, -0.3026271748553325, 1.025357134454051, -0.39066124437205807, -1.6877297817477435},
    {-0.5780499199362806, 1.79441960098854, -1.050490664405634, 1.6214696824470411, 0.48610282824828077, 1.1989495330471274, -0.24660478586949205, -0.22645868564107316, -0.7484635573156782, 1.7205787103803742, -0.6983339729225702, 0.15681592463359184, 1.7156820603464877, -0.6764584791714966, -0.1733864005959546, 0.44101671855957875, 0.5764517611482526, 0.2687644275000639, -1.0313908628118684, 0.16265628518376074, -1.5175091087547885, -0.4888351096991446, -0.45879645088256604, -0.8724499721494576, -0.3913869988507306, 1.004559530833364, -0.11681895739471986, 0.5562820316082719, 2.437296873163813, -0.9306249233623883, 1.3793736655797342, 0.2694165743935355, -0.038329380964315686, 0.32385240800770576, -0.548266309461734, 0.4796509606192213, 0.13897651996561608, 0.4651809376670633, 0.11084424721682502, -1.7875136181543405, -0.71694887759332, -1.0674665760222717, 0.7179243561382825, -1.0929731453998162, -0.8917103809943734, -1.5497361352651866, 0.803015955770099, -0.9866951743335823, -1.1199224685120364, -1.1336973424770604, 0.22447697537926856, -0.2640467764435993, 1.254051471150397, -0.7541380182094223, -0.5268436967464466, -2.2290338301970065, -1.1767810723847136, 0.3099734956442485, 0.6558289982351146, 1.2772990965682915, 0.36125760423851483, 0.9961949712334314, -0.2746469147953629, -0.2513325029431162},
    {-1.6162302655589378, 0.28629723100564547, -2.2566489772977367, 0.07514378502749167, -0.6850458304847057, 0.15266224722100727, 0.6738399872690887, -1.8363006920703664, -1.2989605230103949, 0.1683242277613973, -2.097205659374971, 0.010362697594336855, -0.6406012169107151, 0.8869016011612558, -0.6697680683488212, -1.4896396113531083, 0.8248215643839442, -0.042591477768502556, 1.1752042029429681, 0.4882673917655515, -0.5186657696013833, -1.91843320149434, -0.037193550228922484, -1.0725689576358082, -0.09110794829676135, 1.2306638471085867, -0.6378652742010489, -1.3202929955471945, 0.41190759850456926, 0.905516354712609, -0.9556539889382794, -0.6817375172823524, 1.5609609578083772, 0.11331522572905535, -1.8089570745163666, 0.5309142256935454, 0.30877327314963693, -0.9271997762012639, 1.3937506312221783, 1.4357192457575652, -0.04266537251304464, -2.731004406198811, -2.6435501304731264, -0.4372298654634079, -3.2255180309809663, 0.646189168321789, -0.3105018241780813, -0.03810747650896479, 0.1513053272153628, 0.659525465908733, -0.0517466004504593, 0.11587218065483522, 0.39493463948347346, -0.901099991459225, -2.0317491761536677, -1.6793754992447048, -2.249144524122276, 1.4258286694319986, 0.1446347269685499, 0.03592300807278807, -0.7740992779354585, 0.7436787243339916, 0.11281833529320894, -0.428337444471219},
    {0.3449695730795043, 0.35620537761072, -0.0728154424621213, 1.9233870594577553, -0.4295089891892644, -0.5262385329174878, 0.3999298132746681, -2.120946824857207, 0.4124138190882144, -1.3846064705976109, -1.2704760032954348, -0.5261312388827694, 1.1370160596044319, 0.0033911092251593072, 2.922729406554933, 0.01844570352300866, -0.8210558191444732, -1.6610059532304282, -0.6785315611946781, -0.8743706063328145, -0.3943546844714419, 0.29439481002239776, 0.13355437616091356, -1.002905948914323, -0.24748302357663293, 1.352915796018083, -0.6791764626155209, -0.8731532611272685, 0.4169542740880587, 1.3717742243762379, -2.157788842378478, 0.5253816320447438, -0.6815432719928324, -0.7105357196705916, 0.07287929744641704, -0.001153073896026319, -0.5815093159672489, -1.1018340659070553, 0.9535484930168568, 0.7592657305405742, -1.175261008653663, -0.7428153233947846, -0.8025592355225373, 0.48032116320157064, -0.4827830146728884, -0.6383800163068927, 1.6892869807019626, -1.537029034693394, -0.5869096880670179, -0.1472789613794856, -0.7760359878011734, -1.830199475314366, 2.1094971274092185, 1.2135978761570638, -0.5589930438462549, -0.23636543214703465, -1.4299826659629253, -1.3550687295666441, 1.657097125018095, -0.9847913235212187, -0.8167082409819576, -1.0116999205714343, -2.4173302888279653, 0.7776195914700805},
    {0.4343626238626101, 0.10184695395439596, -1.1707154579318007, -0.4737248033549361, -1.9223292225549757, -0.5796387865206633, -1.0107707526534861, 0.0997436809830719, -0.7818415896246057, 0.20681564086750856, -2.906719598715935, -0.046972954088100954, 1.1958346583001687, -0.8247671386948323, -0.9880746620387472, 0.03556736855075283, -0.29445884382537457, -0.00873327732295981, -1.9655909767473385, -1.9439123233547684, -0.8679272571204406, -0.024695300791408133, -1.5740972107863451, 0.31627501671911057, -1.6068218365232139, -0.06884357016674052, -0.5185657368451124, -0.48539802329557286, -0.8567095579680423, 1.6096576510116045, -1.0398162086283294, -1.425450096805898, -0.7387578536452214, 0.6726235937180132, -2.452207158381725, 0.9832378596479393, -0.4727691270783255, -0.2137094390854475, -0.987344952828911, -0.3259208214306502, -1.3377671995764935, -1.8659138549721046, -1.0051937023278041, -0.6920803910475722, -0.8417089133446976, -1.0843795756609882, 0.28647170622218954, -0.8094199461875907, 0.10979390210333591, 1.1600292579367786, -0.006342313076748556, -0.4297562976191129, 1.6351331104031022, 0.7667718720626984, -0.6547358175897576, -0.3063217425851604, 1.5425104560355642, -0.783102188251477, 0.0525741174535605, 2.0147104012155403, 1.158769826394616, 1.3134339144872806, -0.4908396319089249, 1.1205790535996043},
    {-1.0634320519967717, 0.3147708670160268, 0.7798145274092492, -1.8562270394728129, -0.5482470594534756, -2.0314992494702837, -1.3982183556082142, -0.4037794694186987, 2.240497928975141, -1.0391386163767566, -0.8603057378078003, -0.9300614752520487, -0.0747816287795506, -1.031473580128125, -0.4993038671546954, -1.118236915950305, 0.017143487709366165, -0.5824552699533917, -0.022152567140577322, 2.651165704131779, -1.1143057267776797, -0.8792087137294533, -3.402955508982892, -0.3310646446026615, -1.247302368279875, -1.1859560424843985, -2.06838156078075, 0.45012715134460674, 1.3960402705610555, -1.3836217269933244, -1.1490196573682805, -1.9680969545973273, -1.3354284909349516, 0.6820019824959231, 1.1215701928297026, -0.24734568355885123, -0.83063068787102, -1.087133202490238, -0.09004692576261453, 1.5363796853094995, 1.0875867986961754, -0.27612512492637703, -0.2926762611163994, 1.400688505441021, -0.5282381384937994, 0.8282465284228814, 0.39554830722384854, -1.5328647679204799, -0.5289511494927754, 0.41560865757678556, -1.0943211704500078, -0.20661727603964072, -0.24567652161405548, -0.5627518512018131, 0.3394978515174036, -0.27383278338503947, 0.8421087963344195, -1.0052524024789427, -0.5913439833896824, 2.2018352705957165, 0.6953077256739032, 1.1140378756695275, -0.09776333424633242, -1.181615890488773},
    {-0.3818814655806215, -0.4867312617882952, -0.7052941854956042, 0.606964182397015, -0.6196951035548391, 0.6293303418500711, -0.23384891468145294, -0.5497491544992095, 0.9298796787798667, 1.7412378909115995, -0.20507820445903344, -1.9019179650750295, -0.15924786507531888, -0.022141633352768544, -2.1035185152985445, -0.605257861825113, -0.5886604332193727, 0.9144215574278249, -0.663713752125085, 0.706117383919187, -0.7133411578963053, 0.3721806143456067, 0.1011659418283775, -0.08288719613992658, 0.556267251272205, 1.3979427070159467, -1.063540725240987, -0.5997535952734604, -0.15931603872709485, 0.37493653728088877, 0.6345944427332072, -1.8680315046552645, -0.6958496875580388, -0.9669356319206959, 0.28196674097050317, 0.8634339993079394, 0.30947984015693164, 0.03702069349609302, -2.192751270043725, 0.2877846479947438, 0.05430123776441294, -0.35556233505758267, -0.5246897253989667, 0.982770797699109, 0.5449638065273139, 0.13358206904243106, -0.9827488016850316, -0.0637932548205231, -1.7209458086192713, -0.28797345628375465, -0.4823463454456128, -0.799578038548208, 0.19250879143538555, 1.4035503773797002, 0.668922902546705, 1.0607142508092322, -1.7154743466587268, -1.0507647363203165, -2.6827785992326025, 1.854128616658979, 1.0730083922255664, 0.1990788501580793, 0.8601813911833248, 0.22227580212179235},
    {-0.8068096457750559, 0.02837916466728109, 0.7393499433498939, -1.317930396833397, 0.07858568598064114, 0.08123026023881022, -1.1028915400814703, 0.2340342265058351, -0.41983478462605883, -0.44410953225598737, -0.055382745268727315, -0.08938433112965163, -0.891752677362165, -1.281298483259236, 0.24020437827103433, -0.49779155795254504, 0.8927846422821903, -0.4656401997963197, -1.7724160363268497, 1.9718973228445789, 1.3231838822126738, -0.8935483441613298, -2.55661355480312, 1.9720585370775, -1.0462802457645455, 0.3617703140907083, -0.8275801025069119, -0.973099965815793, 1.113401389803907, -0.29560611069630455, -0.6719972991358746, 0.5646388655565573, 0.6298410389964721, -0.21251334355007157, 0.06099125859340389, 0.8666399053781666, -0.33310779544717406, 2.4708267334146754, 0.912054748903321, 0.02135875733116722, 1.9695174492206389, 0.6383832520044649, -1.2104306985581408, -0.4894357188651429, -0.7498860576175137, 0.769155743032934, 1.5515763567477903, 0.9658263489220318, -0.7796177398120081, 0.39452726485182643, -0.8897975124442439, -1.8822858349857803, -1.6572261519312608, -0.1996448678479268, 1.1184182607243878, 0.8256488947442496, -1.4074024827161513, -0.449576964609595, -1.3143115049639855, -0.12842287138949943, 0.41487897390852535, -0.9945294015619252, 0.7247740642522147, 0.004368043604990729},
    {-0.34095979237093477, 1.6759949585852985, -0.3417402925771519, 0.23711063805450205, -1.2217540409380914, -1.231626747576139, -0.34634100730269407, -1.0010255944031874, 1.344552804965658, 0.017835178454083972, -1.7607410490061586, -0.9215099667299113, -0.24964776631968946, -2.0338688716593833, -0.31265209135946054, -0.5786332663202843, 0.7417180782338467, -2.5364092248578816, 0.2527818839435367, -1.5079964487450799, -1.3487445483928606, 0.5101956565448749, -2.1872545111723882, 1.1093286838063054, 0.06623316117873951, 0.6506629618939822, -0.7666926905833982, -0.5858302565966115, 1.1994399360596755, -0.32257994998226874, -0.9653884613643627, -0.6857575171540289, -0.51322143247955, 0.12611312705484007, -1.4810908139464964, -1.037618367571386, -0.42661697388359926, -0.6361506702712001, 0.1535530960346041, 0.7388459029579382, -0.5423078059376926, 0.9015786789263487, -2.0564949359144817, 1.5181867579953074, -2.1079664228763515, -2.844867346819495, 1.753490190176295, -0.8976523650568633, -2.5049825106753048, -0.8995331033517266, -0.6618137371511871, -1.5112737374161769, 0.7951707720975705, 0.27068640690424745, 0.5286656359398495, 0.8855505601563021, -0.7613109843409149, -2.261053548246959, 0.7148503188622246, 0.17158761559785646, -0.5627033944403128, -1.0115779177350448, 1.5267027112375815, 1.011634590137452},
    {-0.3522081723004125, -1.7028429534744625, 1.7558677982550783, -1.2145346531492236, -1.5604954678882916, -0.39191670265961714, -0.8079903936745958, -1.2042581813590232, 0.2995122344074947, 0.9739999105050776, -0.522354086784992, -1.7302320747883062, -1.887054551761657, -1.5275314147012264, 0.22683461097698415, -0.7276304412118134, -0.24689702667671204, 1.4892034557731435, -0.2283141984518949, -0.5385672287204394, -0.9155987397443122, -1.3280051362733067, -3.0524602569884065, 0.3750485627356278, -0.6804451775961273, 1.0419020727839616, -0.10623979155524442, -2.169534509784404, 0.9155514380432215, -1.232975754706894, 1.0097555378031164, 0.9904019848287475, 1.4473054748817427, -0.035549779568273286, -1.1773800654486641, -0.5204866629430834, 0.08787099748936883, -0.7948923510178467, 0.9859336605090353, 0.5835655715144382, -0.4408299369470132, -0.10152520593081124, 0.5135038952020532, 0.8656700208307505, -0.588761645397882, 1.7179509949986167, -0.7935722117838775, 2.2372479695852747, -0.17148473692311403, 0.7576826634118315, 1.5039224928710488, 2.0385167318868884, -0.7992276199040519, -1.5677882727174728, -0.050386810053584315, 0.2112513120993583, -0.17060830304398322, -0.9398098913593496, -0.323493655897907, -0.15807872119299693, -1.3912798550034362, -0.3565389845196215, 0.6985044960651339, -0.22691403346962125},
    {0.9093244191115869, -0.5391276708744747, -0.8330984495301147, -2.066748030914348, 2.3573306951168713, 0.6767662826623637, -1.9548319999886086, 0.22631384648949265, -0.290014522379218, -0.24700141558622943, 0.000352303337179779, -1.7538411835259071, -1.6786613917574398, 0.3915942516292365, -0.6532871720756526, -0.9864885346052895, -0.9161256250686994, -0.40684677245340606, -0.5155948107153921, -1.1898508060046562, -0.008026199882074559, -0.5797178876277984, -0.3898647746997374, -0.5472411612131729, -2.0035785416172094, 1.1259369716118641, -3.882999702190595, -1.3238435175245595, 2.3867500208616783, -0.4976388673212717, -0.248677076423024, -0.06064048989264422, -0.04364321969155234, 1.4112928898182548, -0.6603040114354447, -0.07165466130201786, -1.5141505331838339, 0.35612516884043083, -0.8081787213098026, 0.6163614276399249, -2.7685602962646265, -0.36766749846891755, 0.045201225544079106, 1.6666168063626312, 0.7019926202596416, 0.6612138896206893, -0.15004297891605353, -1.4006570981332291, -1.0185783343307906, -0.4354379874772617, -2.037093709556452, -1.5538508259972974, -1.618774064611772, -0.16063449910411054, 1.4179999115483097, -2.6386410852342514, -0.10816316976740716, 0.38282387480288066, -1.2616915423252828, 1.0904273802533988, -1.2468116579984414, -1.2094478283295147, 0.13053531761435497, 0.4419344627217574},
    {-0.41660977835533713, 0.07004835969138723, 0.5121537312432581, -0.7928766573822723, -0.6259899739910076, 0.9047811216943897, -0.8441240645549698, 0.18945207606419703, 0.5161929246768286, 0.8846426249525577, 1.127729181824755, -0.4919486809061034, 0.12297332543075193, 1.1432229188750176, -1.5394049669910255, 0.9666727106449208, -0.6824562492058491, 0.30874759310932925, -1.0242201166471414, 0.06885649551059003, 0.6610661511790556, -0.8896069519916949, -1.4007175261098175, -0.06072268702129416, -1.31632781962121, 1.8197776211172627, -2.3033393151464208, -1.4788228738426081, 1.332133901055957, -0.5722671638367488, -0.247498709827436, -0.20546737058970443, -0.43831804219691495, -0.6852470797038516, 0.7879874395885229, -2.2284713632789503, -0.4016868242764466, -1.428871402672406, 0.4378326193213537, 1.3465457181855367, -1.4702017522008788, -1.597082593207013, -1.0443631683584056, -0.10299975091468414, -0.02844248893919399, -0.9094223601882577, -0.8385532881027586, -1.2057879969399268, -0.5987537273083448, 0.14595717480956616, 0.03282389955485581, -0.1457594171129267, -2.4724288784748003, -0.3661694428712084, -0.2994429639850667, -0.9793549482009296, 1.131729701157094, -1.8930665614002458, -0.06886375081147231, -0.195067852683289, -1.4564463962850296, 0.4776321597529997, 0.5330494314731985, 0.7121854597631325},
    {-0.748883199674765, -1.516250994068234, 0.8903139073594869, -2.031953373794098, -0.08208534885378406, 0.6860487498170954, -0.4758278740235344, 1.5084328452705362, 1.0528618266335696, -0.9684835609576177, 1.8566701170526347, -2.6280152822376133, 0.42014248351770467, 1.9619604802305441, -1.2889573354325072, -1.001625255243959, -1.773729424426761, 0.483032657582548, -2.3194239035293696, -0.502920146105945, -1.7048039406830662, -0.4064964985660863, -1.4978257270011341, 1.4222816753844916, 0.6653250674282163, 1.1722194092115832, -1.005280157144695, 1.6554117362482266, -0.27112637171028564, -0.849648969527381, 0.9798504764871125, -0.4035610744817575, -2.5961538158924817, 0.16016157958408567, -1.4312193476849635, 1.8814546860818488, -1.0852753281471195, -0.9412808912756847, -2.1644859164085353, -0.9128064535274502, -0.7457288771856185, -2.721828027437806, 0.3131401487844322, -1.5182412075872234, 0.9909529123375322, 0.4979070576674868, 1.4312553094317444, -0.1865517614347306, -0.6362683598738658, -0.5748823739312586, -0.4871303603073713, 0.17732094390344588, -0.12562393421636459, 0.16442482006961018, 1.8400513746852698, 0.18981529097126015, -1.404519216872444, 0.8194167881464249, -0.11383131158395007, -0.44567077248186354, 2.216631510369607, -1.6131519879745835, 0.7706848365072939, 0.5174824344853313},
    {0.4927798304793428, -0.33380530894929333, 0.7319890261842662, 0.29813945873121084, 0.2499218037653915, -1.0094542316284478, 0.5422865890793254, -0.7088513206898521, -1.6410255627643702, 1.4214193796347105, -0.07839014955129438, -0.824057712587841, 0.572167443548355, 1.7078718091678728, -0.7123888116444116, -0.14557299050396866, 1.763502922552654, -0.6106383468477082, 1.1637461321357985, 0.770163452903944, -1.4501687423475003, 0.4253163394458452, 0.14081958865566144, 0.9807276601620172, -1.218946142243345, -0.40114879446604235, -2.3234292531928364, 0.5119744147578171, 0.07385790297310235, 0.36623920444491503, 0.5776392583445897, 0.18952264311858813, -1.331868751642493, -0.1454285545533826, -0.4954819255300858, -2.278178465305303, -0.5493986513346959, -0.2256254431853362, 2.0805173719849903, 1.0563256787008923, -1.7364942944214823, -0.14044414809858985, 0.2315625824115297, -0.6235563657170541, 0.3211314254842221, 0.12739517591351082, 0.5278405778519769, 0.009280552841444868, -0.6558175346721394, 0.2406932594714437, -0.8713193978050109, -0.8365223706631846, -0.28878291943994827, 0.6258322065908918, -0.23153027520142191, -1.7993561371255236, -0.7583575782792044, 0.09303872638729516, 0.5112109839974119, -0.8351692350189306, 0.48941644480420343, 0.00082382702925456, 1.3431953399139929, -0.8880794449958377},
    {0.3143203028364013, -0.6805273549184219, -1.528056036285278, -1.7932156029507138, -0.5532417070814512, 1.3771386464556161, -1.1271597789814845, -0.15826292781196394, 1.3200849267322485, -0.8669874002338003, 1.4133018875436125, -0.525552396374426, 0.05384646623445224, 0.10288099922144822, -0.5844908508858971, 1.2270313424844974, 2.8241002826262704, -1.123571728634733, 0.16104876451918515, 1.234546816962882, 1.1627924093901743, 0.1361042266193116, 1.9339249314051121, 0.5007616067553152, 1.4258164251193433, 1.467983822711076, -0.40985217330012025, -1.1408139846290946, 1.1470089834002901, -0.040469453077508065, 0.9708537304581488, 1.82528851878566, 0.24662272292549758, -1.3062638395244255, -0.7323389068641137, 1.2550635258897196, -0.6627567276883639, 0.45907189411124866, 1.5292130748258181, 0.82426966447321, -0.1959670989635103, 1.3583915447249841, -0.8751357972386498, 0.09546795273167467, 0.37025429814002503, -1.8608865435545556, 0.3415270780791442, 0.16264255090746044, 0.6530312814203105, 1.2144727582539787, -0.5880278954877619, -0.7600246518621026, 2.3120346676501735, 0.3809898421342653, 2.7472221011958426, 0.027269327828098138, -1.2312523702841658, 0.6011204061830201, 0.04211819993619655, -1.3533581418052225, 0.10039472669847858, 0.3803763722061686, -0.5282635679500012, -0.28720051158168675},
    {-0.3239111771103097, -1.1913531362126257, -0.43438831912764303, -0.13813174473902196, -1.904743220285039, 0.08835311215734616, -0.033642151600726, 0.037059851526984114, -0.2536230951214375, -0.17768847612948047, 0.7273027112738194, 0.037531973866473424, 0.7363118297514204, 0.1916210450598008, -2.2496786666316706, -2.294398249927396, 1.8856169336374957, -1.5883990037822122, -1.0978410008468202, 1.5576585080510932, -0.47002348661394355, -0.6812579497764939, 0.4203990514617654, -0.8762590473003252, 0.8709487137825905, 0.1006136532969836, 0.8835371561892408, 1.4845003332563858, -2.2083752001417256, 0.3975353809185126, 2.052968278903321, 0.29344111674090784, 0.8812247771911469, -0.06577249330336328, -1.703682323246003, 1.7006805451813956, 1.7339475136575206, 1.3623394704281888, 0.2423779453850594, -0.1276007056929807, -0.7501601566193175, -0.35956061388916455, 1.7872094477110347, -0.29054298931845934, 0.6529304036590947, 0.6212752858971496, 0.896044682959259, 0.14970190681625078, 0.09233424343076137, 0.42395933512542583, 3.718583350678138, 1.2010929854900676, 0.9723401674370327, 1.040610514460041, 0.35905262626470685, 0.45614515481722434, -0.9188963588570045, -2.0066707958267838, 0.07176597916993054, -0.19985805766110312, 0.9424184097937246, -0.5211005466274287, 0.20824666244766135, -1.557732430827515},
    {-0.18991242882847295, 0.06225383888749863, 1.9663111731055989, -0.77093265514723, -1.457104360019432, 1.4756117220797595, -0.3747200664388239, -0.569263918437084, -0.4363725182256203, 0.6718644214258741, -0.6452631642226742, 0.5797772144674501, -1.2205739693171556, -2.0341754632508917, -0.47311897911014456, -0.8965980822328828, 2.604930397015091, -0.495992799656551, -1.2728171529884649, 0.08749738168881371, 0.7919796161812019, 0.7579222878289457, -1.3845303614407705, 0.5248142801243177, -0.7086292363740033, -1.2546130947961014, 0.301575723836196, 0.0013808961299672977, 0.7813489679215897, 2.1960104424327813, 0.8646605808789735, 0.9489012684867577, -0.5978040796157085, -0.11899943626670989, 0.8220202239948832, 0.2043630372066831, 0.2015257333398301, 1.9173143599596496, 0.21315944020948208, -0.694162627384132, 2.916930276885828, -0.8619118836240832, 1.9652982049428371, 0.5257620830558936, -0.004095385742075463, -0.072668800602063, -0.5497594204658542, 0.41539565190409394, -0.6618286099548536, 0.8041954711514394, 2.944906542272837, -2.129584984285633, -0.04592705167602155, 0.38629466483077823, -1.1451357513917806, 0.29284601077722006, -1.0368556636406712, -1.1298108846583932, 0.6650775221502263, 0.7271796204787649, 0.6462782547311315, 0.27723750406015574, 2.5697099357891897, -0.997226344102088},
    {0.01192920082004827, 0.055818454492936764, -0.5389888023582162, -0.7899695826432147, -0.203132452469498, -1.1716725415114815, 0.48186558023281445, 0.29388751795230794, 0.07651496447393863, -0.9789745857001266, 0.06365657863259537, -0.06382456118414742, -0.6503385774929225, -0.11806744249698371, -1.5004889259040635, -0.7600049660409333, -0.005459873756905784, -0.22168276016593697, -1.9551715094880198, 0.8519594834853057, -0.4907253408931898, 2.2009971607095937, -0.7014652085764974, -0.20119083630903142, -1.6371189016040784, 0.15250285250651782, 0.3762713574719447, 0.8967441156408014, 2.16095681835089, 1.8940157319655626, -0.6522481016616843, -1.4289943038778046, 1.072298489155967, 1.2889205395235313, -1.3631549359118944, 1.5414454730926388, 1.6798048778441308, 1.2960463083162443, 0.40680125365948705, -0.20341214416703626, 2.7223916558881687, 0.3990198393972961, -0.2964746879719526, -1.3346759522632343, -0.8054485883751689, -0.6039526867986778, 0.9309258280561861, 0.843211315231054, -0.2649044408165755, 1.0249640448362833, 2.5110013355432157, 1.1311927438969915, -0.6798420337388384, -0.76446248415885, 0.7835826618019553, -0.35956280674708163, -0.4618535318907782, 0.12737518350864613, 0.6222801955392702, 1.1335724957329592, 1.1252405464371258, -0.9542862688722341, -1.7785115273918506, -0.2164268814957953},
    {-0.5571719327267405, 3.0649467830319725, -1.9230999368279942, 0.040182593180905474, 2.007537068592122, -0.9264533044818174, 0.4056704329959382, -0.2689102314568406, 1.1435398691137881, -0.5137075617186541, -0.9562240632480112, 0.12493762148256747, 0.25461856959456053, 1.1812932221849977, -0.6035728116358613, -0.9097103155973623, 0.48776601927137647, 2.8300953652531566, -3.0193554162444936, -1.2924690769128906, -2.223765281817074, 1.5269896421648075, 0.5333571898834569, -0.004839728503780754, -0.404726628844731, 0.7193165464285989, -0.12862264819910302, 1.0745854025075492, 0.10753462193266024, 1.5978045146224884, -0.41242527225850084, -2.2330467749287246, -0.5713280602054196, 0.1789464100054643, -1.2799048751721311, 0.8336131753991225, 0.4069103477784834, 1.2291044395883688, 1.0331883646171691, 0.07436587990275308, 0.33574970947030147, -0.4289839349291479, 0.35538709306488825, -0.11397839227887716, 1.3283966181579625, -0.6761837333483043, -1.350523800336174, 0.21271315585051753, 1.2833262381113617, -0.7017178794499446, 0.4199506724181326, 0.22540987845398142, -0.5543810525533116, -0.28272595983973164, 0.19898970820629436, 0.5735935873122483, 0.006000283694376645, 0.34464448342767956, 2.6091989681561176, 1.2677563256778397, -0.3670257619951853, -1.8799131581706299, 0.29848284827878074, -0.8312668905309907},
    {-1.820841166648631, -0.3784264339426049, -0.08376745656227809, -0.7769216528864631, 1.3170641293320453, -0.08166810576472806, -1.5750514122757955, -0.4171812166314572, -0.6477805236486517, -1.0861693817358362, -0.4390388780853188, 0.44790707743538055, 2.324539636802537, -0.3003229712237064, -1.743136548869108, 0.5513444381525852, -2.0209404324565834, -0.07722160390531099, -2.765150914907351, -0.35949704256142206, -0.8889217264722096, 0.33682975553009453, -0.6422951327822277, 0.10915783149660979, 0.9986258331101724, -0.8221623076007164, -0.2605053309307814, 2.0712667135661724, 0.08663418961992195, 1.2753903232229098, 0.9674969909802352, -0.2453338464096274, 0.8820684203518001, -0.7666456506602636, -1.6044634335964454, 1.2337928777431617, -0.03459621509886623, 2.503815468698674, -0.8747912471307244, 0.2848336074327789, 0.584732842046269, 0.4950956175021633, 1.7241144738464245, 1.7301637761823758, -0.6886921655785179, 0.9403593615546908, 0.4367958919729096, -1.7012950638296631, 0.7635355084158664, -1.028098688965123, 0.10743636501091365, 1.7084189062971469, 1.0483341798117456, 1.4546529376469923, -0.4552249208980879, 1.6633299530197754, 0.011295520990811663, 1.1488263479086613, -0.16153178428613, -0.8629779217839566, -2.6529380147367414, -0.5696774907650072, -0.36552182522635857, 0.9810148613323652},
    {-1.0917240395198256, -1.8906699377656986, 1.18211336157845, -0.4667095723549159, 0.7754532838280006, 0.08043433039446023, 0.5559184749165037, -1.2421909100307005, -2.667499027989673, -0.6662264953807628, 0.30819814813709495, -0.9640805025706728, 0.934322636332537, 0.08176785876758116, -1.29349439910147, 0.5575984474057484, -0.27205988283648475, -0.48191687444972087, -1.9157928399129853, -0.44758377262618, -2.494882444571406, -0.18875004620860694, -0.49037446384724165, 0.3883969317896362, -0.04114616385412915, 1.1544585010013373, -0.9051756982296517, 2.346024437675361, 3.187179647599325, 1.8529764078797535, -0.10966919167387643, 0.25482985502276445, -0.06484288679206318, -0.7188837316114299, 1.390333088616189, 2.1762539130909793, 0.47898977952042826, 0.7431935043539324, 0.26476700307422946, -0.721190509267063, 0.5256082529042408, -0.17537054762207843, -0.4884724797318913, -0.35239045684432135, -0.10385270829960042, -1.170375610502544, -0.012088915832879112, 0.5749105451828828, -0.13574109235743148, -1.3110941841439696, 1.2988330635457175, -0.6164704195021193, -0.37015817643705345, -0.18668704574714093, 1.1041324904149035, -0.02163430079673269, -1.1347478098820216, -0.20636171900127667, -1.6438376333876465, 0.09118265837439227, 0.414089736006858, 0.056534885571477726, -1.4216431165782062, -1.750296610941256},
    {0.7899794389562234, 0.6102040169437692, -0.41619363450544417, 0.9240630487010549, -0.3032155396146135, -1.6701674080776052, -1.4827441555293288, 0.02817455286868979, -0.5595078915038779, 2.4682594095537826, -0.8605782509228511, -0.046667768091545714, -1.823217116718869, 0.6586637784205223, -0.49545983919169106, 1.309924625561451, 0.28936733194220665, 0.38752845269110947, -1.3649928259378719, 0.1985968965878705, -0.34020271741146507, 1.1725719346878711, 0.05609529117397055, 0.07933358322055901, 0.53636125419335, 0.1859921014079213, 0.3088875593034698, 0.017037980996267278, 0.6145424336573933, -0.24624681430006912, 1.4807023926797207, -1.937605009993278, -0.19402517595763855, -0.2315398059261151, -1.5664182553419175, 0.6168145198701169, 0.8106872103376122, 1.7175255081581862, 1.7240051757618953, -1.7469208975603698, -2.122037715799279, 0.4429829612622363, 0.2748835573624855, 0.7972173921034165, 0.21504259590580874, -1.605616970545596, 0.5508427145903015, -0.6874807060116976, 0.7857882397465473, 1.0374307991100864, 0.986151025430361, 0.32429868483546787, -1.2212886735116024, -0.3489548341998253, -0.004242438425705387, -0.13334089487011205, 0.5743618598860093, 0.5232026400875534, -1.191718972156717, -0.8631917988087972, -0.6845361289619706, 1.2818639660895224, -0.7038088181181208, 0.9158189699152143},
    {-1.4972080402346921, 0.14015124203493623, 1.2400152597987484, -0.31968030278339393, -0.15832488979757248, 0.1525096771472315, -2.547520838402603, -0.07493185690574526, -0.05820921615167041, 0.1844164266115269, 1.182531916672184, -0.6795829685159366, 2.9047935872867034, -2.477094236862278, 0.7275783811015761, 1.0237160173697006, 1.0584492982525047, 1.8887813054102032, -0.5687375210929153, -0.6653158886796112, -0.16408147546752552, -1.3377854198962766, -0.004948895249253182, 0.7361608264367643, -0.3040595991077811, 1.650197315356448, -0.8894480589850439, 1.27444565314612, 0.24014536984890328, 1.691631728319511, -1.8907239690370705, 1.022340395263824, -3.700724225518794, -0.9697345713774022, -1.8349948489181624, 0.43556299028130024, 0.6447373723390066, 0.14728029645428362, -1.0539649269955627, -0.6950067181202023, -1.0369903230753152, -0.3707384680308453, 1.3769364653395126, 1.1756259352620921, -0.8197278942957367, -0.8523034669255617, -0.5779562119600729, -1.3011411728837212, 2.1517476173288674, 0.9542445970284539, -1.0551089734765442, -0.6173600157852872, -1.8783225397107208, -0.21956318077364617, -0.1596234318396876, 1.4126893701296463, -0.8801951432533307, -0.7986254504481513, 1.126661716514213, 0.5948910055141192, -0.9303728222526113, -0.1230552905445809, 0.01048293342806078, -0.523706216331693},
    {-2.9356276864133877, 1.1188085183834393, 0.7643551941465888, 0.4786892394862796, -0.6749558206731724, 0.7380595119386415, -0.47783897321143837, 0.41987399904297734, -0.09186837479471903, 2.2691768512332526, -0.3001481460130621, 0.18021729581719678, 0.031043118214240738, -1.4090406153786907, 0.6667495656334048, 0.7604348290627472, -0.8772582876787502, 1.2801637044204794, -1.0448770132894496, 1.7746050624669352, 1.1471170336355012, 1.0580471217310576, -0.01341274871692475, -0.4643945084732507, 1.8364839796242263, 1.5499858125084038, -0.043310117855754726, -0.8346428645217293, 0.5034583644505825, 0.1482816391036722, 0.418325283247856, 0.3318646809982922, -0.21926106962670977, -1.6798298147922415, -1.2720118380328647, -1.527489507676742, -0.3907856779846845, 0.965978852507237, 1.7923113204275947, -1.0876828082156536, 0.4683692021977622, 1.7436862839843543, 0.3456522510703947, 0.3752556615817339, 1.022010604703966, -0.38258090390923183, 0.27270165802270424, -1.9493089277897238, -0.21212965691507552, 2.3935485701238806, 0.5315471917570573, 0.13641804071864852, -0.7361864887803349, 1.0883867006658954, -0.8800215440721174, 1.8248363718354375, 0.4029977356672815, -2.023541650481825, 2.114883197764762, 0.7786070708643342, 0.375886883412345, -0.5657588435285141, -1.7921349000962095, -0.5729467631226429},
    {0.1323092285074415, -0.353904949520433, 1.1151071859025719, 0.35614269353449685, -1.2248889488526278, -2.1884777224525704, -0.2152193905696909, 2.1737942007259283, 0.9090178279485523, 0.6650455146197574, -1.0305787746901878, -1.5948612496643675, -0.07137906698292917, -0.1277305558483631, 0.04175086624857187, 0.6110093467771031, 1.6900893186735164, -1.0387761604717352, -1.4583610984307518, 0.25584688198274824, -0.4893178679290084, -0.400525394306541, 0.649925333197006, -2.459021823424319, -1.7874176322604487, 0.3573908139623986, -1.1172544634521033, 1.7708988512773773, 1.3449760007023892, 0.7849857875035973, 2.435509307333741, -0.0650722186939322, 1.5067595515875782, 0.6235191879637408, -1.412315067291711, -0.8250767207420323, -1.0501365261783995, 1.1141270197322677, -0.8947529604081786, -1.4873526845175706, 1.0111699281269344, 1.4524167866807838, 0.0612669530504968, 1.3878807801014619, 1.3414775275671922, -0.8559260169967995, -0.6314224115164272, -0.023431540750768177, 1.060771259067122, 1.4544619306642945, -0.08511595838703885, -0.9251395892852405, 2.4328311363396913, 0.5473615175989232, -1.8766591577895275, 0.39400894633185685, -0.008442760769623267, -0.7314361969633425, 1.074928832719626, 1.1921053549177103, 0.38539947071626995, -2.0425877620215562, -0.5900764949864499, 1.2169891599488267},
    {-0.6753956770585445, 0.01381795313038924, 0.8708689315053281, 0.49494297949922533, -0.5941445124184805, 1.031423215456071, -1.3417129572019282, 1.5057769366580414, 0.8915589890631141, -1.3747933477073866, -0.7969029225253615, 0.6483003909120295, -0.014799690943081272, 0.89607563620985, -1.0609023381490155, 1.9115369916737934, 0.7042476803523393, 1.100449135633782, -0.8589166204504007, 0.6636177046723336, -0.7588802064996713, -1.2477559236537297, -1.078202985858452, 0.21095802022026222, 0.9649976013932715, 1.8367332069427569, -0.21564633091709262, 0.17055367901774984, 2.5283905312559933, -0.3157522264119183, 1.1560121385050695, 2.546981982305039, 0.8828215112343477, 0.33445142981459125, 0.21885067829742547, 0.8724331155906625, 0.5908767357144816, 1.5170340835878156, -1.6501892653967491, 1.440537423318839, 0.007699520509150814, 1.801739954091865, 0.08092100409517068, -0.48753201528169915, 0.7699356015989066, 0.018563020916237315, -1.2101344695926388, 0.714218890190836, -1.2622077504803748, 1.957931787153295, 1.890671239596628, 0.29131579431997356, 1.0230787312252347, -1.6077281086960111, 0.6037846247990672, 0.313511281007632, -1.4361938692821186, 0.9873394815342091, -0.722805424281674, -0.6335551798306928, -0.38466988600271335, -1.3484441329688936, 0.16455433028640487, -1.114443442600264},
    {-0.9645201328118533, 0.6785956565071763, 1.8695086123048497, 0.9260746247921335, -0.37530839703841856, 0.1695176515722947, 1.7370337597950767, -0.7810587574793573, 1.5773689055688496, 1.3536525529322312, -0.2845611018735701, -0.7248722112038523, 0.19462442123809015, -1.0248566860613784, -0.03654340355939516, -1.052627111653156, 1.3461929572928935, -0.6953991324919172, 0.5752120496964562, -0.48388079027308417, -0.9968117803469421, -1.7488812915501786, 1.5454052447596738, -1.249462069644706, 1.0934645198066968, 0.42150542909554894, -0.9349314749902199, 0.9081076552652404, -1.790060977605161, -1.3180962751403198, 1.4674295396680606, -0.4738475223112099, 1.1092856536801725, -0.586492862411988, 0.1224485663637802, -1.1119435811613434, 0.2980000846069311, 1.1087883576630138, -0.08923138380606505, 0.6843123964396517, -0.010736630781333951, 2.1885492163909666, 0.9505825819802239, -0.6892040908598999, 0.420966823977664, -0.24757073406942728, 1.191802666263421, 1.3933951327345588, 1.2883848388562007, -0.47655899349789493, -0.3744643716396922, 0.9217201352407974, 1.430670268413065, -0.7710051841773952, 0.08548823603635136, 1.4914951023135294, 1.2989506834284212, 0.8908186614720522, 0.5667283264294056, 1.6653497931654035, 1.087555196080773, 0.9784667921451453, 0.7563176673838133, -1.0278424055942155},
    {-0.43367704880112606, -1.3515182882201955, -1.4325707916808026, -0.23758850183464936, 0.5523910192852458, 1.680423749995066, -0.053975283266481364, -0.20926669646489035, 2.308938789849781, 0.6811724696312216, -0.057378646582620214, -1.6141355937317872, -1.2001233017089359, 0.48168190659403204, 0.11838915954839502, 0.19577207283055204, 1.8630399213660338, -0.5031831707285027, 0.14844119725414553, -0.8849842213298333, -0.11326236688730631, 0.6791390609321346, 0.14077390667722942, -1.3714654917770857, 3.6348015116134933, 0.5105578792981791, -2.245451232932955, -0.03522817170106876, 2.1246027301965116, -0.28512862734135286, -0.19895377373068424, 1.1611332539044292, 0.20275176656759436, 0.8182868407458856, -0.6220127165960377, 0.05861294863113881, -0.1318590559764934, 0.5964060369899001, 1.4009479911616982, 0.03085885458873552, -1.7757051363966962, -0.08920956539020337, 0.25031804868990754, -1.997154261840274, 1.4839838683894426, -1.0417606246914677, -0.25177468930398006, 1.8907874684593644, 2.091539797056602, 1.3051570505307224, 0.4619642905724007, 0.7909641843628382, -0.5059353793001609, -0.24092279002435915, 1.4659901491647154, 0.20748550375558059, -0.6336047991252068, 0.5358855552157122, 0.09746152645516626, -0.31619391182179246, 0.08230986267931753, -1.3596462574684824, 0.6655064775994635, -0.03733941218667981},
    {-0.36969259796209125, 0.46859625014499773, -0.7717749803249182, -0.14039229213389015, -0.6542515255194031, -0.6396707673884979, -0.8900957752743214, 0.4024885845962176, 0.44567318343449297, 1.3298728861145874, 1.5186905957962595, 0.3563053840449469, 0.46465535270339947, -0.008890035483416422, -1.589588817429787, -0.029748363847548163, 1.0572279680018726, 0.5554078782999984, -0.20207695917688642, -1.8675670460157616, -1.6916692852066142, 0.062015354186146385, 1.1369594009735657, -0.4472888795377236, -0.42427078658023315, -1.213269143952944, 0.8514900446535137, -0.8096743288729452, 0.23278225090619592, -0.8851411049139513, 1.6937375170316755, 0.6375707661236908, -1.2861896466777745, -0.10067926184600295, -1.1623257415462813, 2.405809568702316, 0.112536887775415, -1.181126894656078, -0.1598584827053376, 0.7562615809520216, 0.7432965903903327, -0.7390914762862316, -0.23819795532252241, 1.3507142012586628, -0.7583063861591588, -0.29264675126338696, 0.3209610229457012, -0.06457756238931882, 0.029431302125966806, 0.44571173469732306, 1.4088054632132085, -0.7347402428645058, 0.48031122936638154, 1.3616449598750926, 1.7032128237738244, 0.5607115099328752, -2.5263810821001287, 1.2603277508003952, 0.6538217392850365, -0.37054405102525145, -0.6092522491853857, 0.05395685581227031, -1.0692076325792723, 0.10644981179640907},
    {0.00479662845685789, -0.3210037935043247, -2.0320507231545126, -0.5899029527606816, -0.6798228129205062, 1.0295316881077294, -0.17019985916148098, 0.8868361547179394, -1.38210226148625, -0.39962295013800003, 1.2616353750922509, 0.5393596544711479, 0.06213780471848685, 1.0411215666852358, -0.07973586490895984, 1.0154429306389188, -1.4637908406707574, 0.37515677235837036, 0.16590268367946157, -0.4941609568513367, -0.8323707822809613, -0.3284703350065331, 1.330329631445375, -0.09275704235424034, -0.25334945184500784, -1.505599753634534, -0.6070553709358015, 0.2618507406191687, 1.2294868840535715, -2.3052873969463885, 0.6422604609063866, -0.44203102393832183, 0.32568872713504654, 0.47739016123743494, 0.04392150377994864, 1.6734980505993553, -1.3393093724075888, 0.004695215198158416, -2.202078832695096, 0.06055505596300305, 0.49761324086975756, 0.13569284253300343, -1.29272750274334, -1.1712049576760517, -1.9196124844868834, 0.6532078112101248, 1.3323794326983656, -0.984820690021456, 0.7638632097281152, -0.12107227748668993, 1.4810562596355068, -0.36793153499270564, -1.7630980467513726, 2.0434366200116165, -0.16334025328367419, -0.5679414337990413, -0.5814228078603035, 1.1756747401235526, 0.1763257317575524, 1.1828499165539, -0.233813865721596, 0.4393053951800482, 0.8960788167323059, 0.22794947486744926},
    {-0.7137806026145731, -1.630432641560571, -0.8429249445864271, 0.025700180704059866, -3.151725338511014, 0.20654576230327854, -0.8113446959987383, 0.8791106424193832, 0.21937266844155706, 0.5511851416360278, 0.25158698214577213, -0.048846371253924374, -2.6083758500505416, 1.1918859783970999, -1.1534720742873754, 0.879379192632195, 0.2809073358861678, 1.129869453064863, 0.2705810442884919, 3.7732845496491834, 0.008276661628620315, 1.216832736265956, 0.38182392203325505, 2.750970484905127, 0.34075260319304507, -1.5022516154495023, 0.5867559725853185, -0.035163784555481345, 0.43438511578044037, -0.5117636176410463, 0.19625801111635416, 0.7788294910708671, 0.8606150820231725, -0.3082081352543091, 0.14152050494094928, -0.4460606126226191, -0.4149977547987452, -2.6034882576961484, -0.17138186664458036, 0.07571895419088526, -0.0008831506509714731, 0.6398462420563436, 1.9383929015646872, 0.0388080734377693, 0.6872810801975155, -0.29612010434685315, 0.5168608825953603, -1.5059420002580954, 2.480876008071566, -0.5806522688427211, 0.8750213838091417, -0.22015758677850386, 0.30898776109359033, -0.1798877087143473, -0.5250401998311538, 0.5077574363277406, 0.3758518861449203, 0.3219704156724332, 0.5440502564196859, 0.040774588173800703, 0.015892519610955926, -0.44952902425069435, 0.8285837611869604, -1.7571938058616197},
    {-0.122131222069299, 0.975437049392797, 0.7949060421730496, -0.016971230077420314, 0.21150337352885554, 1.1086654826403044, -0.5791028080041308, 1.7738304863658254, -0.41558333311396356, -0.1455243770458497, 0.2717017792288947, -0.6607370863880297, -0.18091951971719322, -0.6641754612356287, 1.446062007535931, -1.426787871763568, -0.05547843789344671, 0.28778288884872016, -1.0067329918591381, -0.10167129225475995, -1.109111299398774, -0.29954428259324495, -1.3815641334686637, 0.1201255556567875, -0.6465401808887291, -0.33816914693632055, -2.1869895157347727, 0.06422331769102464, -0.4608058759043899, 1.0996972745187692, 1.7717618389567198, 1.6576421551700378, 1.9164991710789916, -0.25282293152655416, -1.967257960787094, 0.9407918640092295, -0.694003140329287, 0.05187252618565693, 1.8061866578375168, 1.2383101367390734, 0.31230836831872527, -0.18992642725089037, -0.8409577452895795, -0.4322295238276428, 0.4863321207366073, -1.5334723263907997, 0.29766866550961535, -0.6812288573964803, 0.45674012683861626, 0.27060691486755223, 0.6252178868260173, 0.40061625145409396, -1.3966601013159694, 0.7113522703894233, -0.711475592895574, 2.843149096544933, 0.021632131094490133, 1.2651270165595174, 1.2789040044136442, 0.5140628018053075, -1.4267664861888014, 0.14746899554968396, 0.47786798317517487, -1.2628540976333613},
    {0.24188351386005616, -0.6287288176915914, 2.225965717045214, -0.16496530793129305, 0.5391015541065628, 0.4175406084100982, -0.3062436881660389, 0.4546612563861327, 0.4252093963969328, -0.5258475563313361, -0.31926093088803736, -0.3595884312315854, 1.2469764324749104, -0.7627306468114071, -2.147445494979831, 0.7513109900970993, -0.037281618002566505, -0.5996222966798979, -0.06177893731080099, 1.8010451391407698, -1.1649163150599673, 0.16190069679966934, -1.6487233935301557, 1.692982829847741, 2.66225885811897, 1.8676235747041774, 0.3421582245499088, 0.8787619975796671, -0.6011987878560757, 1.4316514651520584, 2.389975654647442, 0.9451739964270561, 1.161073284648057, -0.25944805058470705, 1.6102144685115833, 0.7305374288874257, 0.5201093099130866, -0.9499241102523314, -1.9022032558755246, -0.7571692518995091, 0.9731141034937713, -1.8924209186238017, 1.6279077106594877, -1.2834919397333535, 0.008968008172283517, 0.7840413008450215, -0.43010316330477305, -0.3744129767912776, -0.6731668406454603, 0.8916785518213978, -1.1378524452309655, -0.949378561890088, -0.1816650500724947, 1.3039977066443695, -1.9337932326701353, 0.32357201222807125, -0.6229888075075807, 0.3526663693609898, -0.11955566972451726, -0.7264000193483442, 0.22349190075152905, 0.8336754617101181, -0.4024761927001814, -0.9047149349865925},
    {-0.07165755925183401, -2.174299934871816, -2.1406157674275197, 0.3921115950514023, -0.6409389039791928, 0.14700188116994953, 1.1050937775624214, 0.0610439402496857, 0.3012491321797829, 0.9937478225163506, 0.8642098522611006, 1.0507799908095061, 1.4264356265009839, -1.2268143946014312, 0.8468393459955526, 0.4843936456268464, 0.5686166746346274, -0.19289139010855533, -1.1926647437304685, -1.751704126396686, -1.0096406122519694, -0.3904997411501238, -0.7036093703979065, 1.4480068908232524, 1.945723699121626, 0.17991794346601644, 0.9041855705027853, 0.08619010182270838, -0.8288837803030907, 0.3993754179525773, 0.9362749119396139, 0.20287997893580612, 1.3261267210787393, -1.501038263461191, -0.5011213371820634, 2.453723892806547, 1.166793838100184, -0.02886626104179536, -2.159416010178139, -1.6397627779778827, 0.8550265189392394, 0.9892477478590528, 0.054464842045725444, 0.1973690935619738, 0.4325026257509944, -1.43521624448296, -1.1866650219066153, -0.5661871145448872, 2.4172948438453457, -0.20382085213125284, 0.15431050450141023, -0.8446062652820998, -0.20709732523495994, 1.4681207030059036, -2.025968063665633, 1.6064114533242808, -0.7372887725328203, 0.13862828497589422, -0.44174651739006404, -1.5121973897284613, -0.060602884775385786, -0.791997264755331, 0.3249600391409842, -1.7102727100943569},
    {-0.6773611766595377, -1.587958390015981, -1.2768443805915437, 0.02706702439075223, 0.4746974828310473, 0.1897194143153504, -2.353881939456959, 0.18035430699834873, -1.8365531566048718, 0.010055009484016343, -0.5592710694728703, 0.19899938444196952, 0.9324073612765985, -1.7521498361731456, -1.2531277181172347, -0.7204651625300433, 0.06480615879944138, -1.2542936328719014, -1.342171317242272, -0.3329740341939756, -1.5894815719757294, 1.4956820735077498, 2.5990873313906344, 0.7686571509352853, 2.370796279230258, 1.0578800511428388, 0.107087818960045, 1.8137090852997617, -0.16410795383134547, 1.1271587300388137, 0.9640593355812218, -1.052318338538943, -0.39099035076412947, -3.5511131573737953, -1.8814097268886651, -1.1282560138157118, -0.5533190808650321, -1.468533779940577, -0.40102443399867005, -0.309746226948848, -0.17719472442321496, 0.9214377482640833, 1.0870253158757015, 0.31984173745271094, 1.124111137867644, 0.4994275285572298, -0.8312955556476467, 0.25375757712271535, 1.6158806876738867, 0.23680602758512398, 0.9617509058646849, -1.2453672514986698, -2.0905394339027885, 0.27866809746603816, -0.59787867549678, 3.2425955018498605, -2.1156163634286003, 1.8225173332035396, 0.9431395012226741, -0.8640569076318562, -1.24761104914563, -0.02225390876902398, -0.5027187971437995, -1.5262956912430967},
    {-0.05874784415223815, -0.6847240583391511, -0.9935703230713754, -0.3278371051000777, 2.600177645723429, 1.0853720976159382, -0.07606164581144473, 1.4435926267517156, 1.4711630715346322, -0.037476927650977, 0.08716165713037537, 0.1697477023764664, 0.9153884174597918, -0.5080892573164112, -0.11727446653006891, 1.1597500607351596, -0.23500452886035114, -0.8896366145304935, 1.1145607608642392, -1.183969785032373, -1.1126347868438775, 3.2377066179042746, 1.0850780673560039, 1.5173058634299346, 1.3053221241949404, -1.478331869870019, 0.8471124677990328, -0.7467996214730864, 1.031650448109928, -1.1249884690100747, -0.6475361790528757, 0.6863485430895864, 0.9541301983989279, 0.1855390429032592, -1.9970227945917927, 0.6951877452885621, -1.5810527951459445, -1.7137087063714167, 0.63596866957144, -0.670367257650058, 1.7462673433370008, 0.8783221443801733, -0.002278174588335271, 0.18288490267201535, 1.4547972025021962, 0.4382927119323563, 0.4925456914208611, -1.4153626556807455, -0.5334893784267591, 1.2852217037557319, 0.8896437901734668, -0.16219820881624858, -0.4381795115850161, 0.995845547073568, 0.431326754802605, -0.16823858928606925, 1.4557817647809548, 0.6551037498367371, 1.0596874945446741, 0.7758164453523374, 0.11535773946881066, 0.24721296680212423, -0.45903084861337484, -0.2812127639852479},
    {-2.485177044934928, 1.9557744134161732, -0.39705401278698266, -0.3822880432056463, 0.8450568881174018, 0.5204309689778683, -1.2254008689531621, 1.3469205881465522, -0.7434817795274714, 1.9030605902493618, 0.6883686075224044, 1.6637718043977572, 1.160856255321742, 0.33796015620312986, 1.1595654387466012, -0.26456020048824685, 1.2317431529369036, -0.1696986966962685, -0.8585212998068006, -0.8962273659893621, -0.6513678402578325, -1.5499678174885307, 0.7795342112251674, -0.39462819461507936, 0.9529604442782631, -0.5384722147286509, -0.8553297576695826, 1.6570411970510424, -1.6432196677085258, -2.0705186575416348, 1.1406436819582537, -0.3833465024321578, -0.31936350821700726, 0.850946789746164, -0.42854492397150945, 0.9190651227924621, 1.4497800766261089, 2.094721936691111, 0.8628083793498249, -0.459380040579051, 1.0054505403403506, 2.4080252818010783, 3.463347368559096, 0.06964035557392922, 2.892673095059906, 0.4886648444967466, 0.021715049153301937, 0.1024038259589003, -1.7975380443316922, 1.2943921833881027, 1.0597631903652827, -0.085241928777012, 0.638380092085221, -0.19922194533518386, -0.4027824906578764, 0.6696404236173428, 0.8312432313521102, 0.696132778669173, 0.5763430102457789, -1.103142443668579, 0.6396643906456375, -0.49203119737811246, 1.3003701919926731, -1.6033793669569687},
    {-2.2082272354798214, -0.08769405342967439, 0.45066955940091713, -0.6972766477081346, -0.595880211428149, -0.562027209532314, 1.0597231022718248, 0.1378269160235173, 0.6975909017110421, 0.36100810877546485, 0.9414927448503878, 1.6490101232106642, 0.23861354424344416, -0.5500941748039334, 0.8344997310656226, -2.1290009426716843, -0.0843944570056813, -1.2856685222611701, -0.2985998950716347, -0.16365929361747683, -0.5579441963149451, 0.636980533073085, -0.06239404953821576, 1.480716678826281, 0.6702961554787258, 1.3391750070322026, 1.2296089089907467, -1.2020465389512542, -0.11559158969888866, -1.3371955741633605, 2.3883425898155624, -0.039949202915587886, 0.492230084477787, 0.41121174717622155, -2.174162957058549, 1.6557119107681977, 1.2929834544815932, -0.997669142122573, -1.2087964780731173, -0.22418882882419483, 2.1014987911889045, 0.08650111028452222, 1.7209280989809868, -0.85627026499633, 1.0972975292081748, 1.0691557890052543, 2.1532436744743206, 0.4630548213146281, 0.40937116865242407, 1.8197875300364283, -0.03575152089416626, -0.46937425309426106, -0.4207302902513306, -0.7086243774391124, -0.08921664497153914, 3.675846661299296, 1.2101697533264464, 0.5407605924608023, 0.8369489887900242, 0.07298921834858033, -1.1125905317037783, 0.8309014554108723, 2.1844024963009274, 0.17646586628003352},
    {-0.9710147570533907, 0.30335192156461005, -0.7094858280182904, 0.3496685910983105, -0.4476676926061072, 0.35344410794037606, -1.2765854482171328, 1.636829256933177, 0.3034369961558032, -0.5149530956317505, -1.057110598166012, 1.142878325395718, 0.18894958455013566, -0.5558716197781786, 0.507489294805985, -1.9297887219647758, 3.0056384825559177, -0.005267081172767443, -0.4423754960393862, -0.0285368482994259, -1.4850259555848755, -1.113363858958225, -1.1167476329001622, 2.744827527570731, 0.07878090595680382, -2.5950012828555926, -1.8380309840930482, 2.1612735132683083, -0.40961436095759934, -1.1735762171731527, 0.6847668446932281, 1.7159495194313084, 0.5427512129628979, 1.4094884428941903, -1.3877608732673266, 1.7728892713282935, 0.701447273938363, 1.1681451687078879, -0.9223263913923937, 0.9128497124939499, -0.6569327769462149, 0.8116446883792934, 0.2895036640478475, 0.3013587940016188, -0.4123104096632331, 0.5656630095796821, -0.5549048720735558, -0.24137163471683082, 1.9288319081513432, 0.4779079672168825, 0.004474428076776404, -0.2521760822854138, -0.6165791246174145, -1.6820804041301523, -0.1922659340655396, 1.8763069747126038, -0.6216475166091323, 1.7072322483591467, -0.44457644931642515, -1.5546226045603198, -0.896531123358408, -1.681504816114313, 0.4293422873876257, 0.5287973122395234},
    {-0.7075450296842922, -0.34340312764467873, -0.978924234358608, -0.7547551368733689, -0.6457261948869144, 0.8098664789860139, -1.3635886194899753, 0.5939270117112736, -0.038610512071442026, -1.3164599555541026, -0.227873088779593, -0.21793473490116916, 2.113628967882507, 0.0990858940663534, -0.6060418794726287, -0.35979770345700834, -0.0833499722195291, -0.12518693681580706, -0.874812958916325, -0.21621257145748765, 0.08817185318223189, 1.375966492639964, -0.35150975687032726, 1.422101474583537, 0.4341506900140063, -0.46566249847615065, 0.47361638571279685, 0.32190241062132, 0.8845027964784697, 1.1783400332704619, 2.5557358181099175, 0.8593520030394334, 0.6049506201558918, -0.4579734242151928, -2.3763250629823696, -1.4112030892618945, 0.4619508690866251, 1.5240939748089979, 0.774983509770639, -0.011169112418961173, 0.5866686859734014, 0.8658786796676383, -0.19221459169371355, 1.3509867415528414, 0.10203130824036237, 1.8663737584620226, 2.449516751988609, 1.6654328303147536, 0.23130424033913022, 0.19211709372234517, 1.416277020098451, -0.6849483115759714, 0.26703267535782144, -1.084722854855464, -1.402580680144244, 1.7244509841305309, 0.3379261253078907, 0.3192150739995694, 2.2687345131491257, 0.6852963875928864, -1.081988649861236, -2.1281110374572023, -0.12595485999974787, -1.932328042448225},
    {-3.071033853263081, 0.04074405456149057, 1.375525963740641, 0.4196116319258083, -0.6544104604807721, -0.25183518920301395, -1.0759084139063444, 0.6402103276093345, -0.08602300140565348, -1.7666062528726936, 0.12920852733361737, -0.07687135365602928, -0.978588288240081, -1.5121837980059907, -1.8806963840573392, -0.0004223846728488489, -2.270377956823229, -0.5068734458964012, -2.1259859048821617, -0.2266049838395376, -0.7793898763121134, 1.4119025651357808, -1.5171563448489978, 1.0837443901073076, 2.2217121986093082, 1.6279561885336695, 2.043266913648554, 0.4554020472849342, -1.5710816678368424, -0.3410085351530189, -0.05744893638261618, -0.6636438972173483, 0.2077665146104858, -0.030917875991096345, -1.4542279843381105, 0.5834260276897715, 0.8174229076277827, 0.4517478653181399, -0.0477424074157809, -1.3752433094668859, 0.20944966605178658, 1.7633005232296919, 2.3937273108484933, 0.8748351921307336, 0.6944586530329627, -0.2051545916685537, -1.3620741905957863, -0.12452336169612219, -0.5160440840708997, 0.5539237365558388, 1.002397526032452, 0.2555186210802446, -1.0138543032698164, 0.9236920702645954, -1.4463974616641977, 2.052522326119041, 1.2054900009522562, -0.08999805286358599, -1.1599154801039413, -0.6620857013233115, -0.22364352772030055, -1.0811311715256844, -1.660721520430321, -1.304431742131049},
    {-0.12045205042067944, 0.31099662392479216, 0.01127687988166523, 0.12371420914983884, -0.902513399964666, 0.6764863759375761, 1.3067465755835892, 0.8736676218217225, -0.2597636090939531, -0.6866406725356943, 0.12265507399625804, 0.6334132461078582, -0.7898203052870902, -0.2561531401543278, 0.00047646221419990275, -0.7546932963358689, -0.7453845895154559, 0.3752383198097319, -0.8909881008626865, 0.06177901760259952, -0.5620498184818828, -0.15253925683450878, 0.6400976402945614, 0.5265011829379262, 0.33473748499042993, -2.108319912213847, -1.5694757019136338, -0.03904956453560557, -0.7159014806433861, -1.13641223581396, 1.0692445971862181, 0.9449395677971849, 0.32379293224573985, -1.3834923092503215, -0.7915334924193954, -1.3306672016245737, 1.377393705086368, 0.6096513547348341, -0.30081774690938484, -0.8670473694964672, 0.8618631825748859, -0.8579625177795749, 0.7138993144503173, 1.347656415389287, 0.6810920408618462, -1.1248866540211944, 0.47242734367577277, -0.3340179308512774, -0.9655405101486588, -0.46756410004621674, -1.0667274752092257, -0.9119388919767929, -1.2258055747415852, -1.4290079674655884, 0.30058600023869086, 1.1100386667463908, 2.4020953485084835, -1.7420558194206466, 0.4437432992554551, 0.7929087898650584, 0.19833038815304946, -0.9408334930672172, -1.2283265852877303, 1.836287340665927},
    {-0.23207044076017974, -0.5627619934422773, -1.8735475029995838, 0.3267369625261431, 0.01098744830248007, 1.3342085456198733, -1.745060557249589, -0.7267227279981953, 1.0605436986390024, 0.5129299206117236, -0.20587617059173507, 1.114158509631902, -0.7101203350391624, -0.05620594747110201, -1.2148894964300676, 0.30059479582203896, 1.2523489140850954, 0.497308372695211, -0.4830669023274989, 2.1719435130706346, 0.7104912450838649, 2.056483727418263, 1.110357679025562, 0.7322489990844134, 2.4034693912583314, -0.4356067104667464, -1.4693455977596728, -0.525786957698387, -0.24981783062460206, -0.6779790340677029, -1.056247984826307, -1.0730621275976435, -0.6144579650956544, -0.61664747447455, -0.10726537268587036, -1.472519208384487, 1.227527900180623, 0.3964508637393358, -0.12144220185333258, -0.5968806594760465, 2.167162015792422, -1.8315637798579127, 1.2685876330903285, 0.7774753169072236, 0.3740174286202065, 2.090332175498232, 0.7643029077112437, 1.126945435751189, 0.8853173721475149, 0.9210034442791769, 1.4086860096824567, -0.8143696511526204, -1.434308418148585, -1.116419788232643, 1.4698549968532646, -0.39035687482562226, 0.12936391509457254, 1.8916190523182903, -0.18237555229714986, -0.8014006348902339, -0.9064022663976794, -0.8592464816392172, 2.0477984027133997, 0.066031512142516},
    {-0.6925649839295542, -0.4471814292883829, 0.066143338168977, -0.14030965849426014, -1.1817314942233965, 1.6122076678131008, -0.6723034371504962, 2.3117861424904103, -0.17949818267860995, -2.2559765757156387, 0.32771192271291855, -0.8955763417527758, -0.3481767493976697, 0.3966419808594052, -0.9821488371073689, 1.0991764502610912, 0.605875930328865, 1.1432825042122798, -0.1642648056814243, 0.10474084630868777, 0.4035940735268932, 2.003534529541846, 1.2475386385742466, 1.9984466225145263, 0.8632786912195146, -1.150481639329219, -0.7091115194110379, -0.20243916718386265, -1.1421520558042826, -0.7623438519514321, -2.42129890707696, 1.5488637349796925, 0.35259117540609103, -1.4211589716445456, -1.8255398463020471, 1.5533670115654685, 0.05809844787570953, 2.5113603030226637, 1.5453697723438038, 0.7039997222649812, -0.1287800407661971, 0.7731797509668434, -0.6194175297417422, -1.3591780242697613, 2.8482445121823368, 0.7001294246240236, -0.412265909686778, 1.2813954674151926, 1.8062966719280376, 0.8419635970196006, 1.320334343415767, -1.3242966078474756, -1.2397710482199973, 1.62200859319359, -0.6074833358825978, 2.373990908655001, 2.0869524952633633, -1.0824614324007293, 0.3002368553868648, 1.792103811710363, -0.8666495826897972, 0.6577303894914581, -0.5231101485413043, -1.3472732139567607},
    {0.470444153446879, -1.2798981910366263, 0.4900253850540418, -0.7766316416162815, -0.061972524357838475, 1.3403346488204633, 2.1025649614278707, 0.139902108024968, 1.487048760476366, -0.12090214100694976, -0.9646610891898671, -1.9671956585271306, 1.353106166737521, -1.2078595733375437, -0.22387323478482665, -1.7984471888894078, -0.23815143555135784, -1.0032655743212264, -0.5488806455872898, -0.3881788748872252, -0.5835148983224482, 1.65272833639345, -1.0006363422857476, -0.8945380530145343, 1.0426444698808617, 0.19639901198991114, 0.014774494618359916, -1.1020370292952346, -0.8575577911253841, -1.896645663434928, 2.127131065793328, -1.8159409542676916, 0.7914796228976486, 0.5785757185802407, -1.1546378579611036, -0.21214363250766072, -0.8478234243327082, -0.08501576111108075, -1.0445447198201525, -1.9833960135684345, 1.1600716645751958, 0.1157505614220328, -2.786507519093755, -0.4439805900539523, 0.443153132686546, -0.3383247206923638, -0.40103210501113984, 0.5933659324720585, 1.6229953629895109, -0.8467921440370685, 0.4810347767167925, 0.11466851406368901, -1.2923598806273688, 0.4093097212243581, 1.1404791491375548, 0.17668176555656323, 0.02607465119146671, -0.8619847216287381, -0.4410599128741824, -0.5732811715221126, -1.791375201073839, 0.9088227819266059, -0.013504638655360938, 1.093878720498661},
    {-1.8872606579928766, 0.7925400906215987, -0.22932813619801148, -0.8491682381122192, 0.2038847739952685, 1.400060345544077, 1.037645167714628, -1.0747750097275786, -0.3256315889446644, -2.5695220146509348, 0.6017231498918852, 1.8662304138277712, -0.2951038593143567, -0.24117580029546476, 0.67983935105097, -0.7187642830708899, 0.06878381737348689, -0.6113587352311962, 0.8355191881448728, -0.41896343525472585, -1.0416996865671175, -0.6237560022158197, 0.07634077086672163, 0.015301701856461859, 0.6331468891305719, 1.5108430820786471, -1.0919582492759177, 0.448296355346155, 3.0514660114212013, 1.464172027693753, -0.06565758999302952, -0.0038281636926400077, -1.836441405520907, 1.514895097378639, 0.1768225981192056, 0.18030568932866692, -1.2395333856374304, -0.8160414533981363, 1.2010996216483503, 0.6300225822145447, -0.12475892585688389, -0.638175003242948, -0.852860865129682, 1.2499601770933244, -0.19917641813211012, 1.4963021600551671, 1.5787672903163816, -0.2957193177826321, 0.4376238581950792, 0.1595289364753543, 1.0195626921174508, 1.5221274509639837, 0.8530274643475335, -0.42690208991634526, 1.1883823540904899, 0.6350703414348663, -1.6011913010685404, -0.49000437832255017, -0.3508395268667164, 0.2225232870097828, -0.06729080941092472, -0.13189534257585334, -1.070305264757856, -0.6186483267428322},
    {-1.4076885319291748, -1.011510660906529, -2.0204874682822798, -0.2755171069899863, -1.491816768047635, 2.215134204961993, 1.0057579516037651, -0.12725760174570502, -0.623015723352219, -1.8336586876913037, -1.062998144533244, -0.8043253056785452, 1.3285757369463864, 0.3310650649551229, -0.9232765291405517, -2.830488949312247, 2.3058642977247223, 0.9805815316535736, -0.8917376112004088, -0.4690082123261899, 0.8666090418539043, 1.3182864811096313, -1.4393793756927382, -0.16569763805994256, 1.1504851814909345, 0.36457180477917706, -0.6958794393341412, -0.9205361973872093, 1.1020046253656854, -1.1705345881012086, 1.3494458242650889, -1.1173364342517729, -1.126880419024339, 0.7573890493000733, 2.0783790855563287, -0.9530373676543389, -1.129286414121509, -0.13170951061307723, 0.04295885308807178, -0.46986000251829424, -0.20864082382184992, -1.9496464389311003, -0.5026356374531777, -0.263438655014137, 0.7809721954535651, 1.9559062064966581, -0.4453270827785453, -0.2031653539322613, 0.9469480689229691, 0.24798065108160078, 0.1649104572547945, 0.24806337094436873, -0.33432410590175665, 0.4023016500499642, -0.09103263153110108, -0.19136046394025275, 0.9929858467355329, -0.16611703043227308, -1.8441401555290764, 1.0286656662929552, 0.9055085032067598, 0.6871579059431768, 0.5750436550856867, 0.28068945344262225},
    {-1.9724009756006282, -2.4084187302930635, -0.08344799822719691, -2.6018678170431477, -1.9935822342618637, -0.9047233200105352, 0.17012929852745404, 0.5043767677955081, -0.4283876800753631, -0.5465111898574537, 1.340868121832224, 0.5594708423072371, 0.1479420119289013, -0.35234745316553856, 0.47681192731346705, -1.277741938356492, 0.20662491355473966, -0.8194438777735029, -0.9389409255558284, 0.20168679268085082, -0.6068063825575186, 0.27536238850708783, 0.23249799718730685, 0.3703779553936833, -2.155903107025724, -0.6974552386817849, -0.04264595288389183, -0.3908429444684976, -1.0801030326118524, 0.3491084018844471, -0.7837664771896108, -1.72660987989562, -1.1767510514280193, -1.648283968543, -0.27749659737935417, 2.267666464452521, 1.9107966641093528, -0.7374937670207268, 1.6110408735610888, -0.4142636715592631, -0.3348867807427226, -0.4015717530058183, 0.5548483492032366, -0.039198813608656354, 0.325275929688966, -0.26631804644656004, -0.39862962839987676, 0.39007039205160154, 0.09465154953353962, 3.3358642147080477, -0.6600088490675384, 0.38769979572388824, 0.708163320646817, 1.125129869935701, -2.5856104081379745, -1.2772246860927563, -1.0664434536269278, -3.1448015313638393, -1.1070573332923568, -0.639242412856825, -0.12238149403845293, 1.7142884215933951, 0.18991059990155412, 1.2591426540292525},
    {-0.4201174463068892, -0.20197307081693464, 0.8846148003891151, -1.5258542698484305, -0.9585445338593864, -0.29403829708409196, -1.4774720458704185, 0.0330242084796304, -0.5521125764430606, 1.8110753119660865, 0.6598952643884205, -1.0619264447686982, 1.047152630436887, -0.3287977323634399, 1.3062250604895782, -0.37847102226003393, 1.4278308342890116, -1.5611417947742237, -0.7237040008569702, 1.2001374986683782, -0.31542981199013725, -0.9355635086505403, 0.13270151690599563, -1.09592718804564, 1.7583591554573679, -0.9985317606544442, 0.8390009980474754, 1.6565666907359577, -1.4622815116343695, 0.6819861921878387, -1.3052146089549144, -0.13256605928649498, 0.6505646903858947, -2.1360005743154304, -0.5972711034697824, -0.9455325787650151, 0.7154031068253779, 1.8342164845031754, 0.3092672508724204, 2.058825274646694, -0.33861006768178054, -1.6125775138256262, -0.4177846401826031, 0.5802589872853295, -0.36748706019158045, 0.09443313582182691, 0.13994420322113815, -0.8719293587981388, 0.5155912533730299, 2.150251364444959, -1.816790153265894, 0.15947761735073482, -1.0405985007138396, 0.2013824366509551, 0.714595605269916, -0.7959796903069822, -0.48956486575401853, -0.27945514978983427, -0.8809819281971588, 0.8288816416505129, 0.1985652880326741, -0.18502493340772921, 1.1494353123812158, -0.6831074371859662},
    {-2.748517014421864, -0.32622552780853875, -0.023862476291154164, 0.862387543926962, 1.5649329241895198, -0.69729019808957, 0.10590728959903772, 1.0747444982151544, -0.4612054821640531, -0.08056097316830378, -0.4833042837526324, -0.6642066176007223, -1.535393573561088, -0.4910583787682833, 0.21319313243091603, 1.3840259445245708, 0.19007781593854328, 0.824147852539655, -0.20468031934865552, -0.0825348520305199, -0.22832123173744837, 0.7120495446629229, -0.36283736203871175, -0.6458363828531292, -1.3241784263082925, 0.06505883226523597, -0.7893362533065793, 1.5609515594134065, -1.1357237679172012, 0.5809983819158213, -1.47566256054481, -1.8339746852919454, -0.07865132311931755, 0.8555077256644996, 0.36432722294057807, 0.6443655953124944, -0.7059808689253692, -0.16729565017026263, 0.40172402465462953, -0.3320857480548306, -0.9313679020433441, 0.29925129601931283, 0.5853095077257889, 0.8234275722488421, -1.3785930443358276, 0.08529305980542888, 0.8296485719893824, -0.47772472285142936, -0.34041445682585225, 0.9177575161934765, 0.0041088535314581735, 2.310304256780242, -0.0007913179324454496, 0.001427247090205839, -0.9799534078444969, 0.34843148008292923, -0.5883659303945441, -0.7787429353530372, -1.210667978288345, -1.854979321728001, -0.13186558210754315, -0.9982595094903917, 0.41586682775916073, 1.425345748327049},
    {0.706932350621203, -0.12288918785642328, -1.2059190744154735, -2.40197267986115, 2.070714743020214, -0.3490058215819371, 0.08489164267896887, 0.7811472296593032, 1.2718888805976611, -1.0624984465573637, 0.1853748376144603, 0.8055279399857622, 0.7574246578837373, -0.6816656814704009, -0.0677989984073593, -2.0173486802208918, 0.2006287470646912, 0.2999670237921037, -0.06266028959540329, 0.7510657608837942, -0.5427291230897628, -1.3668832374577844, -0.03651228613529592, -1.3159332546933378, 0.34381669167748097, 1.0375382022054223, -2.233232644005475, -1.6180278936053416, 0.9431779212140233, -1.3596643515946074, 0.3934865211888476, -1.7053777473907263, -0.2654667783460472, -1.2005156997526059, -0.4482418087991759, -0.7088553499321442, 0.6182052428793011, -1.5826351887102292, 1.3340572172600569, -1.7744415372233826, -0.7787636266324723, 1.4718600533514234, 0.7059483999247178, -0.4757632380396075, -0.224987922414288, -1.7396970580117586, -0.8169183685729304, 0.010980589927316643, -0.552667439799702, -0.5439374638743396, -1.9239299703815353, -1.6092278874000436, 0.20313888975560823, 0.6477132446486359, 1.1018575250881555, 0.5877924371272338, 2.0574597091753075, -0.6165854898286509, 0.3284829155475333, 1.5877431945291232, 1.0293882121967588, -1.6772532164687344, -1.5737266274913595, -0.7512219319270581},
    {-0.280116157746111, -1.2291562233449331, -0.6066353797191616, 0.9889712581660185, -1.7671753885842532, 0.30941557014053217, -1.0579151603985346, -1.7261459533267942, 0.8760555566272407, 0.4993800533277773, -2.7087621183317934, -0.7197579715017268, 1.759437265896346, 0.32141005018009006, -0.42366857127124224, 0.8463990031863426, 0.12153964425394569, -1.1981194827525967, 0.8777282011561642, 0.3940614319550858, -0.6415881757176284, 0.1267172928523011, 0.21134707812206455, 1.589003266933372, -2.496481561975127, 0.7061242458827816, 1.2340325878038514, 1.2389670786281777, -1.1202180642692288, 0.8701344519207563, 2.105923158390531, 0.1989703729567072, 1.0865245898471867, 0.32168700358727664, -0.03321488158250429, -0.2692411583857365, -2.052417640638672, -0.16408693706155006, -0.17108508691772978, -1.3234851602085682, -0.29271377287670103, 0.06464302651141676, 0.9140867847595746, 0.34109935658528145, -0.9775602973533086, -1.2176438377713827, -0.08135550354686946, -0.8811234834854237, -2.4077804387787802, 0.32781435664018094, 0.014388903441656884, 0.7405809489635303, -0.11528973917343685, -1.3244729433057532, 3.4402669483291475, -0.2973808559708029, -0.07172256806133658, -0.8129206480730192, -1.4704420702328755, -0.8679062741836203, 0.9037343828239093, 0.7922577273196173, -1.5946392308411197, 1.8471086203127434},
    {-0.5079080711206072, 0.10617010018126861, -1.8969542739010052, -0.5017763973693998, 0.5538012661972757, 0.2657286306628592, 0.29135052574214326, -1.7660649032500153, 1.221541441714568, 2.453486883122779, 0.021072834681738865, -0.05968829585349973, -1.499777830093555, 0.0591370876841477, 0.2180396271901151, -0.549423536892425, 1.6897213675612506, -0.1104797882807548, -0.3940862907003586, 2.078648357973218, 0.085074876708882, 0.9770485284319226, -1.986892226818138, 0.6301671933725062, 0.11547698059201598, -0.2782386674558148, -1.1143276272785474, -1.6259603937002702, 0.5689368789722259, -0.5807669361853713, 0.10546574485856852, -0.49218835453341014, -0.00951743125807484, 0.4805672565960917, -0.8761821191757628, -0.7269877368626669, 2.0811962147725627, 1.1394399801528103, -0.6026351694890666, 1.7148638049568237, 1.2082795864606763, 0.6530145717094316, -0.3472883865723929, -1.1943006269241851, 0.5768665961660107, -2.973556044280057, 0.32744624015153095, -1.5928249800354648, 1.8549746991542826, 3.5582244141970754, 0.09879639393595067, 0.03423184863361383, 0.7181222435271307, -0.515035183415373, 0.3314500428421718, -1.5285144241072088, 0.3694978187677789, -0.4885351117569891, -0.2663157777818601, 1.438424692850637, 0.09017533815111291, 0.5825116661993811, 0.5561046627255974, 0.9463923000168434},
    {0.16762015396430838, -0.11515062624801184, -0.4121159204893462, -0.7716477365966024, -0.2737979311132933, -0.024813496752025665, 1.8755864076904376, -1.0754156183860257, 0.09542605726449353, 1.237318247361259, -0.8714630453470565, 0.4885057633423376, -1.8732945017781382, 0.2831549374791261, -2.7515775007384953, 0.5483116104603734, 0.36253835250780087, -0.9386389207091645, -0.6067917683965094, 0.4102003314314771, -1.0047457291914328, -0.6787602515993812, 0.8595652053374832, -0.8064673947495401, 0.0722952932198086, 0.5662703988979902, -1.3493734549776613, 0.25416194206794307, 0.09002242456791963, 0.6343218573657052, 0.9189754405662959, 0.4650387329535507, 0.02236877807258786, 1.8908616917897398, -1.6596346706143292, 2.0892572012464194, 0.13658161587829964, -0.563153170072081, -1.9940259075206574, 1.7659572146595517, -1.5000088864828938, 0.8163521753042121, 0.3752324515268689, 0.33409059902888066, 0.6047344831149533, -0.3227140590436342, 0.023638127890666615, 0.5922203602755325, -1.526987409352687, -0.8869009226316514, -0.5700542507449224, 0.3526410576391967, 0.346320040142614, -1.2210345182811282, -1.2571812224624814, -0.16477480022063606, 0.2760549235973871, -1.4211034260062576, 0.5637860691626952, -0.07554132376233193, -2.1689081407608786, -0.4875869752609097, 0.5321029068499361, 1.5422723967872334},
    {-0.835547389508875, 0.31905016937182124, 0.14409834475448804, -1.720768542964404, -0.6799194324726971, -1.2155498393602906, 0.3043125211178401, -0.30319574418825174, 0.8425684985303026, 2.223718687781305, -1.857994457025912, -1.1325251178865914, -0.4217756445548948, 0.5494058354656848, 0.526496363629066, -1.8239250907875213, -0.48932288602060864, -2.791791107552086, -0.8501096164443419, 0.49247731046385956, -1.1550225418915259, 0.6045262919544496, 0.38212565539197835, 1.6798272957126419, -1.197162349906218, 1.3683255483057604, -0.10865937383472632, -1.261379473360244, -0.2591310535545443, -1.727479569659964, -0.2819375773589875, -0.49421385263889733, -1.1647332729987143, 0.5466202115439451, -1.479257134095996, -0.5389774514083391, -0.5118549485840748, -0.293215691202451, -1.4614888267946933, -3.187426888198353, -3.564089998943227, -1.418239368543055, -0.20597875990663825, -1.0684332636315717, -0.9600133217086789, -1.1489813039798134, 0.21607470280250946, -0.48904479278552226, -0.35247775335265596, 0.23408839915212648, -0.07523161798277779, 0.30494197123697, 1.3762547841889723, -0.4111725918893129, 0.4897527458567576, -0.02178544404752696, 1.698539828475962, -1.5884371131548032, -0.9896204780737639, 0.39598763564068157, 0.7992521772085377, 0.5212904841201552, 1.0237006397936215, 2.1998178721497568},
    {-1.4626456637184222, -1.9113643530050652, 0.426236927353059, 0.5324683688895498, -1.4550047998321647, 0.03221314872554915, 0.9788953739399603, -1.7468653508564547, 1.0806499349174727, 0.712480546909784, 1.6234628195757341, 0.3968227882611882, -1.3271785382989794, 0.4211333004367628, 2.3453140761528415, -0.8796517319682919, 0.5169049625715149, -0.9797238258146155, 0.044255522539349126, -0.3850933032654788, -1.1622973832038288, -1.1975475221190768, -0.5386167166116237, 1.3545315370209223, 0.7974638126972645, -2.1165251831875405, 0.563856404284636, -0.40734137994457786, -0.34932997274980254, -0.6623727364722002, -1.702574212106126, 0.4929456043648462, -1.385147919001114, -1.6177694196238959, -0.378566747809731, -0.41942993126920425, -1.196318242816302, 0.03919681515767292, -0.9046744776995157, -0.7010384316335276, 0.3513601937475352, -0.5386798395836238, 0.7695206211781689, -0.9897316267734899, 0.9335344690346863, -0.09445222449291456, 0.16736704623277116, 0.18837220772966026, 0.09677267484428302, 0.009656513907713507, 0.6543641037185851, 0.7915030521666886, 0.44813591102653266, -0.53531817046069, -1.307567794364499, 0.4263296016459743, -0.7688426190142751, -1.8701772897670008, -1.1087470244118378, 0.27491039336158585, -0.4493487678870687, -1.0841384922215864, 0.5808480751905496, 0.34056875203432696},
    {0.3676818673764854, 0.004979103373357649, -0.6241740571381627, -1.1475287259305156, 0.06415289235955536, -1.3413419385860355, 0.830728405169964, -0.434067546014971, -1.2417844446677038, 0.42751474037873327, 2.071531359400988, 1.187326659505497, -2.0688677945622724, 0.5688612478437032, 0.24416895466251856, 0.08103635354273664, 0.9503604695224823, -0.6252018239108071, -0.18966381491910098, -1.5664350581543887, 1.259748267462536, 1.9990752321463696, -0.931723168739528, 0.9832428157683127, -0.4354639363265271, 0.4014690508050763, 0.8788714584682125, -0.6363660857038683, 1.4044383793507698, -1.2330446376098538, -1.7882720918692963, -0.6719999000329598, -0.8454996497139464, -0.30646059042370954, -1.1341682572364125, 1.0008329913721827, -0.7886643230988784, 0.7838696346537207, -1.4220725443518556, -1.1084889727019387, 0.9895974166378693, -0.3417452707657086, -0.5381736097129592, 0.190886927114955, -0.28375773867394044, 1.674796692420474, -0.0906182615364748, -1.087997693325126, 0.5210996839035297, 0.6056395428720242, -2.63287306278383, 0.5268328276863502, -0.07190847999413846, 0.1481423954952805, -0.28426804054969573, -1.6786956461102027, -1.1916749658531178, -0.2653612945397746, -0.5623773919601165, -0.34458131420053323, -0.05713605868123871, -0.1243069675458963, 0.681106136152798, -0.28451854298581},
    {-1.8550573167048197, 0.7992879001888884, -0.47734249858114614, -0.7356107105522965, -0.9218832257072547, 0.31478087463480503, 1.1458461369788524, -1.0079242045348034, -2.0061796122597015, 0.3342594468152813, 0.271818294533965, -0.39353913303027616, -0.7044913716950909, -0.48927102420947594, -0.9867887529837365, 1.4603581900765215, 0.15238905718170948, -2.166865633510267, -0.5839894781181291, -0.4382480375259792, 0.13744910690137904, 0.6548946765193702, 0.2498754870251622, 1.0927680619620372, -2.1774028905839677, -1.293261585534697, 0.3210900578404422, -3.4384511302509377, -0.6583897788946977, -0.34612422170321894, -1.5078098585206638, -1.270058379164412, -0.53740635929925, 2.2423625938786285, 1.1104503519978157, -2.3795810474406665, -0.8869224304040901, 2.2255184331686646, -0.8467894775929997, 2.916418724811865, 0.7681959028716316, -2.39630198288213, -0.03534900050643826, 0.17672966324251077, -0.7383861375438909, -1.093207543699618, 1.5225989243888602, -0.18843561101888573, -2.504778710311139, 1.7225412698177076, -1.4310312922721793, -0.214179633013959, 0.1315480027968405, -0.07394028667653532, 0.41181816462108284, 0.5420188203695082, -0.8559795107203957, 0.9444150119786919, 0.7868326596578759, -0.0011574957930303306, 0.5459151887614538, -1.2951102539384685, -0.5129395048438032, 0.23179885269439435},
    {1.1138725426433846, -1.1348666305582362, -0.6084966765298939, -1.5056226766427807, 0.3596930998580143, -0.6063759102581745, 0.5745336858306432, 0.9854597763606948, 0.5002070844818598, -1.3885608394751807, 0.5158463346229402, 0.17196093135990484, -2.599908576617523, 0.5054497391829531, 0.4680492433366982, -0.44508708909297795, 2.1496495968001357, 1.9750110972502182, -0.5655325190766186, 0.5435006772637214, -0.6906766749311559, 0.9274424249305058, -1.9027384608040359, 0.6857651580397176, 1.0404009319266208, 1.1397842072319846, -0.7524023819416306, 0.32860336323342, -0.5482803161511092, -2.1156962613394437, -0.9089161985742416, 0.18727852943133827, -0.5034453723542816, -0.7767444942562205, -0.686347198692024, 0.009806546855706956, -0.9183335814599826, 0.22756626097731267, 0.9216069821607232, -0.7530885179255048, 0.5314605148132804, 0.970602281349666, -1.40903592914288, -2.080668950003574, 0.09619356763281328, 0.2477887121844683, -0.5133466203352091, -0.6952005961686535, 0.22193523836739085, 1.9802364225076812, -0.3394581624636763, -0.5380519089993089, 0.050314762530361594, -0.02853566078138462, 1.3870100319943315, 1.553663916735269, -0.7194122057005539, 0.0062033082060789935, 0.22214074815767093, 1.5024797662975968, 0.2170974740631761, 1.604668255410354, 1.365802181819127, 0.46992332336728504},
    {-0.6590887190845515, -1.5571895802946032, 1.1267397889292032, -2.8590658356571215, -1.7638391684988846, -1.8961984708778712, 0.21609527968568665, -1.1838790915994468, -0.2981939967881145, 0.027968639237909324, 1.9717697780501329, -0.9053703022090611, 1.1156092907712272, -1.0357088672160966, 0.07345161039860923, -1.4632647760623916, 0.8949218412490417, -3.1255289354290796, -0.34394306283925646, -1.121268955340892, -1.3960662070813015, 1.030798378869501, 1.1277424225056507, 2.5223227164849518, -2.2184337625452692, 0.28584108425314325, -1.922270255753724, -0.47939036646958977, 0.6002388898659353, -3.080624974023616, -0.07750546511352452, -1.3315977383070887, 0.2741516186006567, -0.5543271932860653, 1.7274249389077745, 0.9236645190290819, -0.6083987882365194, 0.4371040058865387, 0.3520127262489966, -1.9211123838814583, -1.156191651714153, 1.2057983846023066, 1.3263217741182554, 0.5313677234369342, 1.3378002427581928, 1.5497904898346997, 0.9676909741588408, -0.6363123320249746, -2.8612277497287018, 0.8147757275806369, -0.1529545280702681, -1.092581761098646, -1.3025289263071862, -1.2770428400584586, -1.9094046553459905, 0.026596918908780454, -1.5772121647202317, 1.5797392619108377, -0.3218559838922673, 0.9822889332831836, -1.1668484098214067, 0.35152755971499183, 0.30533247154470233, 0.23971100217607144},
    {0.1643040124112004, -0.5654608136878959, 1.3066665146306433, 0.025663957204814073, -1.5462335122300273, -0.515027986372028, -1.1472236274326244, 0.6409791354035124, 1.9819235011504013, -2.2159516045774423, -0.9438121067532235, -0.37287251750049777, -0.46737736047994166, -1.434331211900518, 1.1414947436055405, 0.8459891607049524, 0.9144817349629311, 1.2774892177362744, 0.9589337430891536, 0.6227494649222134, -2.0421066902004656, 0.055932916282082745, -1.4971380188843497, -2.069725268265281, 0.5312222905475186, -1.105601352094017, -1.2819638276710579, -0.26547681483606106, -0.27463874597036836, -1.2275761731153838, 0.9836311374206315, -1.8497029885302663, -0.0006555127427828665, 0.33827718870149437, -0.4651120922460782, -0.5359127473087754, -0.5218633843990064, -1.5153476336904732, 2.438846106668965, -0.5299725284362516, -0.552586463551678, -0.9683096486776916, -0.3129971214604434, 0.0067696848944016254, -0.3730716158295571, -0.6517821117139235, 0.48557693303282173, -0.9832093105558127, -0.45897104541219896, -1.5812241319170088, -0.5949619955086435, -0.8446775754537618, -0.12852219663357833, 0.3471541831600112, 1.307168194794424, 0.587255325391864, -1.016683983607988, -0.8166958477585002, 2.011341045526465, -0.6562275247586863, 1.553510910674679, -1.0052153414630047, 1.763204268947301, 0.41223604738050706},
    {-0.5456517302332903, -1.0378092473980145, 0.5297026520834167, 0.3421898025250142, -1.1844645378625462, -0.04233941263838574, 0.09368851656593667, -0.3120306639318234, 0.6048540331861316, -0.519222806231983, 2.4271936619704575, -0.27541374455332723, 0.9963777638936324, 0.8804264148519941, 0.0042548648352567775, -2.8315412779304054, 2.6026003736123857, 0.8185200008154627, 0.9270244513493866, 2.630084374913139, -3.2027640788713136, -1.2261224550222007, -0.39596316645556745, 0.6789869228034288, 2.0254885961625817, 0.5572973892834804, 0.2756990332396815, -0.5732447684382067, -0.14683748187090823, -1.5485288807204507, -1.1666187994373622, 0.822142258655311, 2.4141045621752513, 0.9797141494423408, -0.2835390350164663, -0.03722601014101602, 1.2024910452489208, -1.147987706171717, -0.7621739165714111, 0.6794614655941627, -1.56617841789435, -0.5488062952476701, -0.5856032718099793, -0.2723282168972603, -0.49305238938074847, -1.252960112225187, 0.694758735858064, 0.5255685566714478, -1.8706203214387493, -0.896403312286494, -0.8634022669638364, -1.116386171379072, -0.5133278450573324, 2.268143562017128, 0.15347398544043295, -0.19119046561894473, 0.20101039036130836, -0.8781181037145529, -0.47638172949808627, -0.18443562585580295, -0.3650172135107709, 2.977584452996946, -0.718347443348502, 0.11102693490723196},
    {0.0023544847790762775, 0.7278248185708446, -1.2161342289929684, -1.198652797800649, -1.5423322874891485, 1.1968812154206128, 0.3223158689819731, -0.14941153243998562, 0.6052463033733609, 0.9249092933133654, 0.9865307937602308, -1.8334835948529484, -0.30278378419501795, 0.13188726541574872, -0.23410734691226337, 0.3333307544227241, -0.05584202232289817, 1.0222046994781375, -0.5361308654421565, -0.9387771918850039, -1.0316060944896537, -1.2556738066062325, -0.2198639632782814, 0.505888090096222, -1.2639321408275899, 0.7961816476866288, 0.03919350297845449, -1.1755576596652788, -0.5519022023947217, -0.3590734089691873, 0.16174245933319786, -0.9203415158904692, -1.8157860063112239, -1.629523755548488, 1.4426517628314133, -0.8951727051973918, -1.9456197961740878, -0.10916067871258135, -1.5056396711819413, 0.12342377670815782, -0.3956621839190899, -2.072274068221973, -0.4619416696810849, -0.13153544585163834, -0.015804230309421935, 0.5119879518731606, -0.36431247578755527, 0.3592147324861638, 0.9335642881750685, 0.8148575747861561, -0.218507492152654, -0.03840729766773904, -0.5490109678864424, 0.7325323673151326, -1.4673998576630294, -1.5009301890696092, -1.6518928287201113, 0.659163098765968, -1.1068621418877986, 0.6314564004734783, 0.12084841759636748, 0.5606891895817929, -0.6451206909117163, -0.47115804221133284},
    {0.09102710943161146, 0.59402207340404, 0.21958318981929908, 0.44501765347516964, -1.3312639157005888, -0.969973242282757, 0.7036889725562717, 0.48705956498623504, 1.1565337696212883, -0.19533885270246534, 0.4295472165181117, 0.574804992550186, -0.16129920920097143, 0.39712103324923725, -0.09863339019583953, -0.17459138467606528, -0.44574415591750105, -0.9601513847362474, -1.0499034721679958, -0.3411072515818535, 1.7539650895048788, 0.819517417856476, -1.082233324251531, 0.055720628030516535, -0.9349580220344083, 1.3419803098476373, -0.5272798636715098, 0.28773596012630354, 2.1991778135105777, 0.3521753161797746, 1.2405209798436503, -0.1473839220149009, 1.5213507991322759, 1.03432770753728, -0.2827890003957483, -0.39330068137120433, -0.7575691187504503, -1.0783394040798195, 0.5378109603059539, 0.6630326923612642, -0.05947533061636029, 0.0804230540335901, 0.22983964033157864, -0.33747992076045236, -0.75638727112549, -1.0051012232047865, -0.8758353558276598, -1.424037600085614, 0.9326558562468845, 1.1395177820571052, -1.9413757654366959, -0.6677745703323338, -0.7806525335701773, -1.6509403740296384, 1.0133412483213304, -1.2365083587827175, 0.8399152351774656, 0.6118430804453105, -0.593790869994065, 0.8069205887457764, -0.9493808453637896, 0.7146476642067863, 0.18503295587513335, -1.3981913223816576},
    {-1.769229925714163, -0.3151282776830036, 1.5776879259381784, -1.7422833056269265, 0.07864537317036656, 0.13829106729762278, 1.6634397447428995, -0.6361255345952374, -1.1436391278567795, -0.31837000557142664, 0.42019337866003975, -1.6200306695425428, 0.537392191130062, 1.0415373838590671, 0.2315315910614325, -1.335389888660277, 1.2769973948051583, 0.8725491849424017, -0.4340696904554699, 0.3977489989993531, -1.0617158076400302, 0.861742638224723, -0.8871622218421394, -0.09726719398453165, -0.8081677353878769, 0.3682950552242933, 1.4726415460278983, -0.25267433912070075, -0.05806509792402829, 0.757550771653854, -1.737418743017455, -0.21341527875667424, 0.09921643891999293, -0.16620034937310726, -1.7225706255633346, 0.13589605357447918, -0.27494758187306334, 0.11796448316348608, -0.852302828284407, 0.2873378266620819, -1.228944077664969, -1.7115122330779438, -1.7624544573287864, -0.1385295318794286, -0.31519877493588316, 0.4847798066134502, -0.4919636925666814, -0.18702430775319911, 0.1664375450198243, 1.7760686139162742, -0.17197419817194576, 0.9148621072267101, 0.3779855619501478, 1.2932222180561521, -0.46629522191934947, -0.10131218996702741, 0.09228705072280093, 0.3168015234917903, -0.8537891040247425, 0.1815260529957053, -0.9293447823486609, 0.8865713808542418, -1.4581031876407498, -1.0688031019983188},
    {-1.2281990966200664, -0.7981449071710381, -0.2624781701426515, 0.30272627462366236, 0.5302445665458768, -0.8624987258763702, -0.38174222777805417, -1.0923172066664235, 2.5450616949358285, -1.398203271742985, -0.7722867627907061, -1.1445510938025383, 0.5610701173599691, -0.5523289946550515, -1.8030301630473193, -0.36285839009673526, 0.7752400966842855, -0.42965641846045316, -1.5859655877962933, 2.0357942441451744, -2.5771544005267204, -0.043772401890261825, -3.5103002820480667, 0.5311336986209787, -0.7848122321234363, 1.3050673069661847, -0.9288178953306349, -0.2992383826046662, 0.06621085930755788, 1.1779767077165404, -0.11892513321121159, -0.9299307074436406, 1.4094864105051739, 0.3929115645301692, 1.0350962019372458, -1.3029879129691946, -0.7507944817514496, 1.1241836170649702, 0.15467634189453147, 0.229787312831049, -0.8653760006421503, -0.7380447024879659, 0.24173892940078204, 1.3293272938961778, 0.8307953888369044, -0.44446095098462485, -0.19616616804014414, 1.0628260783493964, 0.7132498999351105, 0.7979320699370739, 0.5771601616588335, 1.9534856971394137, -0.6091995033935137, 0.6991324991617214, 0.08196696799655742, -0.23393054837803534, -0.7860139202745471, -1.1360938652439487, -1.5672120328675863, 0.7796836418957508, 0.49590864009010177, -0.7932476453650129, 0.7813985472681437, -0.11166865814852564},
    {-0.5598986804618318, -0.6982080157065269, 0.6956916830323058, 1.0120175432154999, 0.16763204513908725, 0.3761721203405179, -1.7618976914347309, -0.6969031816675849, 0.6297506980060943, 0.07705355176784742, -0.4394110685808377, -2.3243762851351963, -0.14108099819005593, -1.324219278055963, 0.5944846470901011, -1.3666840656649133, 1.0628248382502872, -1.0322335889279137, -3.696360728410594, -0.45611355137898196, 0.3342046271291349, -0.8689642786804604, -1.1644008055244697, 0.5332147136018787, -0.42221958737585585, 0.44679536762347277, -0.9138956395316115, -0.3916429138503148, 1.2908719912068178, 0.09115496003020278, 0.6579238264407785, -0.8190737582527247, 1.6831490451658042, 1.1990364710780208, 1.5414376998489598, -0.734543050266283, -1.321108042179977, 1.3992264956302396, -0.5203571478253072, 0.9068485010565536, 0.5296528787874265, -1.8127690169957613, -1.5867757154906061, 1.0544077243405434, 1.0546056359446223, -2.5412105669343794, 0.6032446578442975, 0.1782279235863044, -0.6226941457901302, 1.0360930026683026, 1.081641737655551, 1.4710852880588363, -1.9637393300272201, -0.26701537491157057, -1.152666216575863, 0.4245240355337004, 0.06657542871524853, -2.1502827993386666, -1.1812788243297812, -0.5531138155674852, -1.1287804303296924, 1.14265442269128, 1.2264704683221623, -0.5282271807507353},
    {1.2398546572667961, -0.45900141784936693, -2.135973459140933, -0.9941152925332453, 0.7433573041015156, 0.14080852728302254, -0.4657629966889075, 1.24170266115393, 0.546304177302717, 2.8130638627057185, 0.21521970693431378, -1.7370998514328113, -0.8834222404676166, 0.3776238792681423, -0.41149845332389035, -2.3525415484434817, -0.15888339994372197, -0.5176870790342991, -0.6609809258835051, 0.0042716370465102575, -1.2657584286475676, -1.473727493493478, 0.6206591787911658, 0.31371672763991965, 0.22244924724414408, 0.4029887040489803, -0.1653545973730447, -0.9396949268520909, 0.4057342907460463, -1.616208056528993, 1.0300579379080192, -0.2398214466499141, -0.5999361332945141, -1.0884254644441407, -0.8886497732103263, -1.5890621016365154, -1.1811629940820167, 0.5031540660480701, -0.9199249966166109, -0.9195179960575951, -1.2745555385947092, -0.8506766052467992, -1.7037252411335067, -1.3521764006230677, 0.613889701758555, 0.35972621929877197, -0.8401171013457106, 1.768722502099418, 0.2998059743274223, 0.3980911069375514, -0.4918511508071061, -0.7513307733784492, -4.212638279595256, -0.12054326025123117, -0.37888839452269385, -0.6838721489254032, -1.143268032338507, -2.2103791250292426, -1.770494851658788, 0.4187652639853791, 0.39520910831274964, -0.7216129221192306, -0.5711162650933658, -0.9793662556730999},
    {-0.7256082838768908, 0.671188042579925, -0.8002104786629485, -0.6370113918096882, -0.5168380219241048, 1.8622651059258657, -1.083350902901595, -0.6905187462803296, 0.29329890974855116, -0.9536509153132322, 0.6072477179762141, -1.1871048934966122, -1.555740594129017, -1.5878354206525127, -1.310012516422577, -1.1611247103721938, 0.605722744994746, -2.001049865952923, -0.27167805228019815, 0.44272813396958627, -0.7512252544071932, 0.37407220705931565, -0.12437616788026372, 2.222723863023378, 1.4373751530358612, 3.130600608610844, -2.359323728579309, 1.4333791995939837, 2.3988055658233973, -0.7452306054641901, 1.9583903941732075, -1.6325925494911873, 0.4026135027936423, -0.9246836689363851, -0.12135124939575911, -0.2644629863760857, -2.090833854015315, -0.10696155898725951, -0.0034967853046217923, -0.04451390895562165, -1.531084853554686, 0.7477499839382176, -1.3459762573462217, 0.04474094354855451, 0.2864616048008744, 0.1463860780867231, -1.8415784306227538, -0.084772979546263, 0.09816348783504548, 0.15278157055896677, 1.3110729689238376, -1.5995336281510741, -1.2159684806536812, 2.0591795596192775, -0.7243635345230125, 0.7640097919087073, 0.6201865590372575, 0.8076012878150863, -1.2924934878275047, -1.7771349419223599, 0.8316779317255437, 0.0005998845483506335, 0.5782421352525793, 0.21936623519244405},
    {-1.224578118234945, 0.2581391312247577, 0.3046361921457952, 1.3761183642196733, 0.8734338203601127, -0.3698023872721722, -0.7243153935637304, 0.13726521745279419, 2.612098014163159, -0.2773012699175104, 0.9089327212340462, -1.4301359178189055, -1.4216304943744194, -1.1505895794930627, 0.8524427632385846, -2.6052894199796643, 0.4107289627265998, -0.09496873698900167, 0.941815799206281, 0.07597840044890032, -0.6141226470121832, 1.527039005857417, 0.5121340013892455, -0.7689274483822761, -0.07262031318179644, 2.637523007329213, -1.8204226511163035, -1.494613462507891, -1.0823289954704578, -1.23300930255009, -1.3918686428509415, 0.43274345980506695, 0.3682443983872185, -0.9848765172817787, -0.7464834685940468, -0.7971383763266628, -1.1521769652277578, 2.6796485972809507, -0.39325373989857393, 0.2890914298109758, -0.3120880748708626, -1.0435615715268818, -0.8216463570513469, -0.0033851213005945437, -1.3977680715479743, -2.3619059791034482, -0.039374740483225874, -0.377078765339968, -1.7046107543902116, 1.6920836574531235, -0.4897761445550965, -0.6377807737896845, -1.5935947268107584, 0.8089826194996073, -2.0492454208910282, 0.037949638449041825, -2.791111546639278, 0.17960513493324942, -3.3811308131186077, 0.8451765746597169, -1.2823458613344556, -0.5122511617243041, -1.7241546835100077, -0.6170387132262259},
    {-1.618155952686963, -0.750208019695436, 1.8298485758389378, 0.40446579227329676, 0.1205210677829359, 0.415545692583517, 0.23365244372707225, -0.5015808366169181, 1.0414127132057367, 0.47407719380861163, 0.8780174478003565, -0.4997669897894316, 0.9902019258665818, 0.204840284192873, -0.4466993120530838, -2.0536467402984697, 1.7350619493519654, -2.142224025811856, 1.0859826966393047, 0.36739594910160855, 1.7906549418990334, 2.982413724870099, -1.821491004857818, 1.5499448035456573, -0.5821414780846698, 1.581730042270809, -1.4133374143964401, 0.9465005747013201, 1.1704128639500477, -2.144923309107073, 2.831217987937205, -0.6405205204968272, 0.8062583423817278, 0.9062820028132185, -0.32891965282886465, 0.16121536216622695, 0.8773048643410207, 0.8727732242983238, -1.9793830978870264, 3.96055613117596, -1.5327769796257207, -0.31084599973233307, -1.0085131494616149, -1.0346110959031063, -0.061208761898621046, -0.546991996307588, 0.2746999140685239, 0.862160498733125, -1.2574508872178911, -0.5688857495511768, -1.429180383677049, 0.19379595024451882, 1.464808499822977, -1.0336335998562836, -0.18805958838547104, 0.11801237321428985, 0.23655582451797597, -1.963022134436727, -1.6428038585191247, -0.08746277805228646, -1.7528787796795082, 0.42926557380916996, 0.3576004063704774, 0.3056120815887105},
    {-0.39572464953920006, 0.3695398309047377, 0.98196771690611, 0.6227796357153039, 0.4606644727832608, -0.23222120093509396, -0.8901322486370156, -0.04920203015036657, 1.96526456229396, 1.449202989767454, -0.3097926082335311, -1.3056969444109583, -0.1386757099950747, -1.1661971205936672, -0.4032930442386043, -1.2227706647419079, 1.358978147558375, 1.5576179276023447, -2.199657024602281, 0.11655167761297841, 0.40065765299536826, -0.18042658817278023, -0.10623330822909087, 0.6018826174467169, 1.271708756175847, 1.1606027710677662, -2.209297195803789, 1.0067275152797264, -0.8780787264305857, -0.7527334007520332, 0.008542560950800035, 0.833834636053447, 0.010077995107693066, 0.6353532077171641, -1.8326735004985457, -1.777472972143872, -0.814462640318164, 0.02174553535570606, 0.9167862165733717, -0.9230327606271778, 0.9583353654468111, -0.4695732097370607, -1.5282063922363982, 1.6191758165969476, 0.6615523716521519, -0.6148445408637018, -1.540330331145622, -0.011935489889547802, -0.3369252756121898, 1.8345913289309803, -0.5760245455249837, -0.7411053941384231, -0.004476902273563832, 1.7257566981041623, 0.18614584054608646, 1.1905251517604951, -0.8784057335628912, -0.6320820648034275, -1.4603080511730828, 0.8745690581328869, -1.543352874890384, -0.1364536138671249, -0.10204254794045085, 0.4090741936025582},
    {-0.16293757944458795, -0.44104090947690366, 1.0134447640057729, 1.1849758193746258, 2.9545204234979896, -1.2685719556695347, 0.45168093292939154, -0.5482628971000157, 3.5611917533154123, -0.28020246779077534, -0.8712816598120702, -2.476350694768047, -0.3089571508191382, 0.2303007743910937, 0.8230731625199944, -2.695721161297028, 1.0821810154080274, 2.4224981740729126, -0.20462682088043796, 0.04053643132474404, -1.391206072424554, -1.3261744423832995, -1.4201321722517772, 1.4756438893633856, 0.07152838020553169, 2.139102837186439, -1.228247556518707, 1.2821495280068236, -0.15997938923590285, -1.7367283140654508, 2.172158783486718, -0.9315679117229853, 0.7615153098476487, 0.5988627460132557, -1.2914290906111752, -0.3193431820351414, -0.5438264292643012, -0.39747487753134575, -1.6211242135522392, 1.4159112303845547, -1.4320304167164493, 1.0230630776289584, -3.987591688617355, 1.3893168343582312, 1.276625183949337, -0.5362057924878055, -0.40940576735291456, 0.8219218297828338, 0.44853767647836407, -2.4786528303762636, -0.8757117432678841, -1.802726778091676, -2.6849476991474828, -0.4423707077194127, -0.552354598845356, -0.5161478943044154, -0.1922373429224621, 0.8596762631896926, 0.16416116030452402, 0.06673103486208731, -1.1098081910197053, -0.6254305048988212, 1.4141736743502955, -0.37920361117264306},
    {-0.1053086418825387, -0.6243877742109374, 0.615938158646273, -0.07883610677007111, 0.18213502067805706, 0.8849335026001891, -0.776762657080601, -1.2643998068558444, 1.3136174646418275, -0.5142811685842742, 0.8361446674646578, -1.2188657662653066, -2.245917653621264, 1.3346698565881547, 1.3394229836707494, -3.1310131270634396, -0.1612458646679057, -0.9684838806946989, -0.24694629665948248, -1.2006587703810634, -1.1306040854915032, -0.7276014885587825, -1.8995689886113256, -0.03750648781822502, -1.166927669300672, 1.9116781567804977, -1.5385060187131463, 0.3824273018038143, -0.5228258470827735, -1.421997437492213, 1.1044274460517407, -0.9533791207701532, 0.6655262945790066, 0.3854974228942612, 0.0859132732435679, -0.37932914768463705, 1.4454553356518463, 1.1358173631463853, 1.2271845721756893, -0.8805416653197613, -1.8150369935270354, -1.8091452659512848, -0.23633855105337986, 1.0769246453828136, -0.7427929031623474, -0.5000038305537444, -1.8268965917166138, -0.2594984278623973, -0.9950782679038711, -0.7828655110781793, 0.16774359076453005, -1.4165809699321807, 0.9741162980016186, 0.7410979822081385, 1.4013754409405206, -1.7233982075938743, -1.4486369133703654, -0.18264806694464195, -1.995956927684255, -0.13909592186613215, 1.366239810697362, 1.6577005143200325, 1.717176429859024, -0.9587618177013524}
};

static const float b1[64] = {1.6513135420990803, 1.66337929749744, 0.7742536063591424, 1.652445741950807, 1.8688690890648532, 1.6928071845348214, 1.3936834585376283, 1.8628593269183833, 1.8180068585841327, 1.2249037958660598, 1.5168076646794346, 1.6453502963847793, 1.5646933322166345, 1.608423387448079, 1.8483357942549474, 1.7398298056681023, 1.750905098063358, 1.4582295883819414, 1.7114972205971453, 1.084438734560237, 1.7167715001425026, 0.4893108849082865, 1.4185342233191116, 1.708001781869737, 1.879209907967624, 1.7558336479686358, 1.5615415311768803, 1.6179626541575312, 1.9017841028156963, 1.9930574030199053, 1.380969927116208, 0.9022059705624431, 1.537954262054978, 1.6779343011222363, 1.367545941845518, 1.273993746831511, 1.8079702882913873, 1.8115286041884218, 1.7725957893820194, 1.681785128899503, 0.9948702129197263, 1.9261654011209324, 1.9141756460074555, 1.0431617655285264, 1.10203203204978, 1.7093717474973278, -0.3631283464440593, 0.8864392136739845, 1.0076022340419561, 1.1792922388889688, 1.558514454835323, 1.6651972189139823, 1.8511798231891607, 1.556037390395592, 1.5729559152723935, 1.787911294979687, 1.4693673655171944, 1.409720825162416, 1.9928699780537258, 0.19132039269513978, 1.1481564045804324, 1.690906701804898, 0.6157411308223104, 1.0923228009630954};

static const float w2[64][32] = {
    {2.88954235132576, 1.4352812112782867, -0.10212806647979711, 0.012003558358128559, 0.5684840470988776, 1.662278102651567, 2.8915397873604483, -0.5971203862685434, 1.2503013755553212, -1.089831218147104, -0.7559713195206966, 1.305275616082581, 0.6072072760809252, 0.2959483820103805, 1.762263717582198, -0.08617283827802293, -0.2825752962823464, 0.5512635982112051, 2.7581460429958766, 3.2221608162571096, 0.800537477474599, 2.6581582763740568, 0.15440492947733128, 0.7160990511972763, 1.9155627465944984, 0.400196113456818, 0.14891093697569965, 0.9646297979308203, -0.19511024249716982, 0.26267956322152086, -0.0957595496170301, 0.8934790320143291},
    {0.7245386907727738, -0.6440444350675693, 2.1733148040899457, 2.286668837826787, -1.4334800823877476, 0.945129785991139, 2.0577967467103018, 0.5940345016247766, 1.5369812507804836, 0.16686492290130295, 0.8121229403150408, 2.5533626945497354, -0.05738890330812519, 1.131524781507081, 1.2386269259330975, 0.8433396902499565, -0.8414471915976269, -0.2002109822585785, 2.8324274322083753, 0.29622528963106975, -0.38265306781775055, 0.5106370368764784, 0.29469916441841837, 0.6346095085720712, 1.17321556304056, 1.8929046511508487, 1.2996493396666806, 1.605285852625447, 1.1525768155312175, -0.12072221403052086, 0.2607077954956761, 2.9119757885655906},
    {-0.3624857116221648, 1.5006741481174872, 2.128020620769351, 1.204015230804257, -0.2131922690714713, 1.1138502823010943, -0.795221742583349, -1.3426776242923673, -0.7245378112242162, 0.9641574344160291, -0.17881693753347877, 0.20111171507499773, 0.06803717926612281, 0.33332762368387103, 1.4553658600730341, -0.3925130370224864, -0.800565953608566, -1.0540134732535997, 1.826582159106151, 1.3532609012459786, -0.27398595258512987, 0.6655090946144399, -1.285475348948402, -0.353705841986814, 2.0371155502240166, -0.005633936476613796, -1.6738060674083488, 0.6003226248420324, 1.2910485202590045, -0.38263356807643734, -1.689645887918417, 0.3988921559630928},
    {1.9646220228762932, 1.6794066732669815, 0.7458108350028182, 2.8450162736068885, 0.41793802320649603, 1.13178106478081, 2.708888009418363, -0.8158896553142426, 0.5776970591247196, 1.346895275771146, 2.241987317455238, 0.6413730280930074, 0.6950558570218748, 1.8344140884922304, -0.7582587818717894, -1.7822106113247245, -0.8066714174569951, 0.2863252062339937, 0.8622553879186619, 3.5849750622782963, -0.5173045287132676, -0.16857507961348914, -1.1291011040723566, -1.2147330126157634, 1.3449827009035338, 1.6824237525645467, -0.21600943401685546, 1.4677275938719163, 1.4660021607215399, 1.9423557445346864, -0.6359153243496455, 1.7591201838422446},
    {0.770236619167067, 2.6789909917021433, 1.4668043832107396, 1.8074839680072907, -1.8080946798046118, 0.7546307224970195, 0.4280250943434451, -0.6477478971474714, 1.0205499910061393, 0.4466972270915734, 0.6822824383574475, 0.5004939100246546, 0.08245057821454119, 0.7211645389098708, 3.0931262862089124, -0.33722024309944987, 0.053203433919305314, -0.34919513016904485, 1.5294026026917313, 1.3744696915255512, 1.5412292839428876, 0.8704541487883429, -0.518795979167902, -1.8249960961324234, 1.826633947343191, -0.8795861277148701, -1.7512638833003829, 2.141089278395961, -0.027273397968850123, 2.1973830811155235, -0.457578982821984, 1.5649245954068436},
    {2.8737304606108025, 4.3720980417195525, 2.491123528809785, 0.03261433662605687, -0.2353237125107284, 2.6416328432844236, 0.44675870813798413, 1.5681145796145974, 1.0655446364948904, -0.1458089927475284, 1.4978910167330117, 0.9588291203777514, -0.5883319658990387, 0.7047645587855335, 0.607955405385544, 0.949787184086081, -1.7907396036289522, 2.1423006030724254, 2.0883421403209526, -0.35132921065118355, -0.12375506715332184, 0.7510237516456, -0.4537073626529948, -0.14105162251318612, 2.248362463497571, 0.2293262626147536, 1.2533031046870071, 0.1037551442371641, 2.2415195438995132, 1.1471595389499183, -1.0942146674053381, 2.8409525477398976},
    {1.3204894326057122, -0.9026840040131358, 0.8840923752390555, 0.7180675958053517, -0.4462363344961646, 1.1315038313254029, 1.914641921073302, 2.821252741056598, 1.199421857057309, -0.014753252366502649, 0.9810746108442316, 1.5209624796399086, 1.695494485645649, 0.2684467914484876, 2.159669037078001, -0.9609441631374274, -0.20633679052545945, 0.11892405243133378, 1.9595492164148585, 1.464134216768852, 0.4818698018451065, 1.073962596666489, -1.6107629740299654, 0.7674293582728445, 0.8686660324517387, 2.354186835198414, -0.22608610792806066, 0.5805304567111313, 1.5249288210798422, 2.779573956860428, 0.5049588274398226, 1.1789710341270587},
    {1.9758690715827114, -0.2051629603636652, 0.7257949499435733, 1.046537329651075, -0.36334732758820404, 1.0723921308844462, 1.7364794347249464, -0.833290671157491, 0.6016202152747067, 0.8761985683323216, 1.5361233168033805, 0.2620990666453316, 0.18477786300655527, 1.1302998115757386, 1.2522839190331319, 0.31698606193861156, -0.7828014668997633, 1.273280765383867, 3.478778762715838, 1.8970151377577646, -1.5860348290276882, 0.3644753781986574, -0.29377289964915243, -2.3118494966802507, 2.7531530175347445, 0.39148726532094913, 1.1423464629886135, 0.8252802439881873, 2.1615152573006906, 0.8479869957654597, -0.2602841761102153, 1.1527457705960595},
    {0.4788037183505772, 0.02852424750799516, 2.7792155957849727, 0.32985468148708824, 0.06097743762201178, 1.208296446597298, 2.991309614718318, 0.5246499597009955, 0.7811468583746349, 1.0646817314374026, 2.62061232180983, 0.7684384856965515, -0.39013085166440603, -0.5529671546203306, 1.226675794303832, -0.8890094236925501, -0.007719782165669009, 0.018150249087055953, 3.936253771541839, 0.2794475687480826, 1.623793329018248, 2.8316202613552615, -0.33977655447665345, 0.3354231801332303, 1.4550752547969765, 1.7380310534863488, 0.633795264420025, 1.2698921662108351, 0.5720085741960144, 1.294486420523676, -1.048696172293446, 2.875095751135518},
    {1.4956429653950647, 1.7561640673088899, 1.1831116438105334, 0.01428715106807486, -0.4859226735176276, 1.797170372481258, 1.6768754048163168, -0.7330385263185724, 0.8939114684602537, -1.4504454011365981, 0.36622941377445006, 2.0118445240398892, -0.9258168592124634, 1.794213872536071, 2.5591449318508728, 1.0804245449109697, 0.31663733703981123, 1.9393695613880912, 0.7298566514491373, 1.7409164620427333, -1.2179035458377652, 2.800283626058833, -0.19241593925747186, 0.9087959066489276, 0.5749755898731022, 0.36416984209884046, 0.6700576638990249, -0.15219279291751855, 0.5051696627244594, 0.465848786122818, 0.7926095492547146, 1.4524722706889335},
    {-1.241724950257059, 1.100694534420116, 1.4650632915016222, -1.049887581565689, -1.3645515315456436, 1.8631806460730187, 3.109341601744382, 0.2630445734157929, 0.583331633211486, 0.742461919551332, 2.430708487994525, 0.6693528722120017, 0.18799091310787175, 1.165633747613565, 1.8125507368811107, -0.7195330732400836, -1.181617438940307, -0.2467709821743383, 1.45589516079213, 0.06444233169476203, -0.6594882590042651, 1.8790326803482602, 0.031670840645126076, 1.1525959316674186, 1.4809978906964263, 2.375751486731905, 0.6572441976179848, -0.06535743115695715, -0.008417127327840779, 2.0469786709671856, -2.1758171593587403, 2.2893493209950266},
    {1.7768713295471998, -0.41315726388644713, 0.20511881722047542, 0.19737059511615357, 0.7523660013506788, 2.934402547780108, 2.871949743696318, -1.0090667187395446, 0.33365019458795336, -0.9150236815799304, 1.8247202376604006, 0.7300018073627035, -1.1218519364325632, 1.9569213521390547, 1.8843932747824612, 1.7349462339966895, 0.42594292132783856, -1.5637316965968293, 0.8667857465315841, 2.459451971613519, -0.6037341542536138, 0.9097641922227574, 0.515887540290811, -0.3623090685581611, 3.0020328363981794, 0.6137582168290304, 1.6019952168470295, 1.7321256406193424, 1.5757169753688256, -0.3598253242827838, -0.6091317084762933, 1.4360625293931546},
    {0.5155823092940183, 2.116051872216755, 0.5284639206983683, 0.3752508524281645, -1.0965040406994417, 3.605888965824838, 2.480181875629094, -0.9170606795523042, -0.9023717348710631, -0.2961375490015284, -0.07623281180746765, 0.9599228472102793, 0.14742692364536278, 1.9497622903285472, -0.13941409226527784, 0.204976176451355, 1.1822792207540578, -0.4134246298608327, 1.31333892322338, 1.380790346541241, -0.7231175520487233, 0.7145631468778184, 1.726367244849059, 0.6683809659018487, 1.6473876278528392, 0.993599234893058, -0.8666983920340867, 1.102679774297111, 0.21186871501803084, 0.41424494302181153, -1.1116147144743866, 2.0027917553067547},
    {2.4848694427661298, 1.2390753327795758, 2.852384067597789, 1.6024040090573197, 0.5590716663107462, 2.762728633188659, 1.6632443175042917, -0.9368083510034361, 0.9156130567871408, 1.6607634261833837, 0.30468904371807076, 0.6975638336083801, 1.776669258722472, 0.28061134862838727, 2.042045234487248, 1.8395513955578875, 0.37124228518224023, -0.10127615696335314, 1.0721621617164117, 1.1871814726840146, -2.013646301807494, 2.2401354178989066, 1.5898100590380302, 1.692069734514679, -1.3786557730595055, 0.5288634184316386, 1.2389466422968196, 1.7926668133955956, 1.6461296582873481, 0.6760049681801069, -0.16857422081634937, 2.9861012002378517},
    {2.4267185873167065, -0.40133360966834536, 3.632117076168079, -0.0011088542875294354, 1.2580959032416037, 1.2790150766931818, 1.4889672825672926, 1.1336085585671005, 2.010115586039281, 0.4832921584013193, 1.8131263360604242, 0.3941716134276481, -0.5119938847647264, 1.784380700020156, 2.709212345585337, 1.5462498052601588, -0.1858571244137987, 0.09189464958794956, 3.134991747589152, 0.4191753580753057, -1.1593865551167315, 0.49476957294515905, -2.306684725595602, -0.4394058564664612, 0.6574147927013055, 1.6796041557074648, -0.07164552484692145, -0.09381288638690516, 2.546499592888492, 2.5618080962409704, 0.3342086250890449, 0.5099209341680656},
    {3.5664344685126825, 2.290195523854712, 0.5101809745628308, 0.0019955523174926236, -0.5133406811147966, 3.4803247094134337, 3.560345538255261, 0.9877775476884127, -0.2087152163530878, 1.7313136518451362, 1.6530995336076375, 1.4025501261688234, 1.0858358500389775, -1.2679830705623119, 2.7545903989246803, -0.47118113452225013, 0.16974357954965721, -0.23059856272571427, 2.1241208872643025, 0.4118151697041725, 0.3476814493175333, 4.378333474156563, 0.8030588887500775, 0.5000328370110627, 2.0080050602426867, 1.0645234786891267, -1.860307130993719, 0.3001726422689215, -0.5868814063805611, 1.221647799540907, 0.7384214427317515, 0.8590153246071145},
    {0.9879457470770424, 1.4766088817191265, -0.09155175538726593, -0.17388773347115422, -1.2374113978715542, 2.3691812075541514, 0.4100089643087774, -3.146851012177283, 0.7637367635572377, -0.14877486304881463, 3.09351668075135, 2.697375529719932, -0.045848142557488675, 0.10515549345712667, 0.5841303684823136, -0.5423502496781993, 0.4779638237180479, 0.963667040899961, 1.3154265556498315, 1.8484492602682183, 0.22713971600272034, 0.9233471089347364, 0.03622314152271792, -0.6763125888631243, 1.9433573152449948, -0.8964295987828346, 0.24175485392287474, 1.9503699473923848, 0.5836533658827436, 1.5680410645352645, -0.12499975424879116, 0.9509698825031763},
    {2.278560832088827, 2.9813559642054264, -0.2142346209705304, 0.9433302311284426, -0.33090276625520926, 2.771176987007497, 0.848992361502881, 1.2471577335658772, 1.6645038733413304, 0.08930700539267586, 1.8583201717747195, 2.4469033576230528, -0.6191176937780051, 1.04178289539821, 0.8562763203812468, 1.6319130943530638, 0.3400151413700813, 0.7704558770914123, 1.4840894063285046, 1.3207573160871113, -0.05204531274122055, 0.2889582705956996, 0.6072747371835799, 1.0193405508272488, 0.8889516493381708, -0.8886349024837985, -1.1697671313331517, 0.3424959890528223, 2.460152729597482, 0.7983356560009163, -0.1889206594841822, 0.5525415165411423},
    {1.0668375315415666, 2.9623214755927876, 0.5539270072097063, 1.6325416593665223, 0.33714126768083563, 1.568353977206276, 1.088500013516991, -0.1716290257218692, -0.25446599359019584, 0.6532183420704274, 3.162648385956864, 1.274393536522252, -0.9170996969694352, -0.006350356295147096, 0.9990103348048492, -0.7625070064038176, -1.1897720354605512, 0.21237614843194785, 3.004705090623013, 0.7802258910100909, 0.3092350066468144, 0.41502730610055666, -1.8603703671122316, -0.1414102484153738, 0.9089712715755853, 0.9865516593390091, -0.8222693800189954, 1.7599108915633277, 2.0601460944778927, -0.5753166576948292, 0.03771678681231217, 3.1064412055801367},
    {-0.33852696991325015, 0.9060968315861592, -1.0389885769810934, 1.294486682568564, 0.5435817138628576, 1.8518544181938972, 1.7054044191352435, 0.19329404866695857, 0.8368765086328407, 0.2294562898857039, 1.0900849312812164, 0.8105771915378165, -1.7232919302247875, -0.6547116581347469, 0.8250689217146331, -0.07792923316342956, 2.188935623866821, 0.40175247452466334, 1.3450818041242834, 1.6924367314227666, -0.18456988925993417, 0.4970624727253029, -0.13853764578633532, -0.6991183746197358, -0.590304007920999, 1.5027521262708852, 1.7285624817542167, 1.7267950496983324, 2.3503509103885114, 2.089475044117431, -1.1033420405412744, 3.0203181803098347},
    {0.8491018139758278, 2.1549154362496776, 1.5330314093529538, 1.0228404812229897, 0.2166781603574563, 1.4473014021778259, 0.4762181535049305, -0.7146060263411605, 0.9083349360133609, 0.8070887730575035, -0.27499557379171, 1.1179484966199382, -0.31637497400114606, 0.8639808412211999, 1.8890811424510414, -0.6521295990908552, 0.4017814943622245, 0.5541490942878758, 3.034101744383722, 1.6588331175274638, 1.2834264629345706, 2.301384754150426, -0.49253674441566386, -1.8298004087051098, 0.9699492169608178, 1.5462681728380891, -0.3907546663528859, 1.2418698913450754, 1.0255092543518711, 1.7823622844893872, 0.55111731854649, 0.006375388358687694},
    {1.1138124055888305, 1.6398508187423422, -0.44789939848096527, -0.13574324595910553, -0.8418835436627775, -0.47424157923355764, 1.272118872776954, -2.258472532003414, 0.6731632115806159, 0.07025554327941959, 0.7721126779463855, 0.4008111835566222, -1.9520068569504583, 0.5827890425611517, 1.4663844711257255, 1.2655344304026332, 1.1746152346379348, 0.44868148190522567, -0.5582737365904521, 0.6241149197549402, -0.1647166027434404, 0.4752395612197591, -0.18087813465220762, 0.36992934857898824, 1.4101566758269932, 0.7261809984800021, -0.7778176219661675, 1.7563762293470409, -1.7176632002117513, 1.0219824801201656, -0.2564632754900773, 0.8696402670777735},
    {2.2895617848308643, -0.2754940518365798, 1.5103355992851686, -0.20228490095157148, -0.5691583017647972, 1.4060016303922307, -0.10350034899791656, 1.4703355951702217, 1.0470209848376932, 1.1503512643882323, 1.9621182314997179, -0.36486927907000144, -0.9267030911528759, 1.1054219972158268, 0.6959492267254976, -0.39752393408838327, 0.5439997316643096, 0.2944910775426412, 0.8111626742394917, 1.5720475438819463, -0.838967254363323, -0.6864994320802387, -0.11959072383279931, -0.4236134396831249, 2.7690882383957582, 0.5806303576906953, -1.0947880036221926, 1.9765952692201114, 0.535017776463352, 1.0362170463772848, 0.3772954739952334, 2.1036274520663465},
    {1.007388684933922, 2.030934299310297, 1.3257444400436071, 1.4107559138234678, -1.4863269353183008, 2.1240253458785587, 1.4625344825820632, -0.5759265274065465, -1.3685902078403296, -0.21535415351992637, 1.2315855213717857, 0.5914931703643241, -0.02566728720871713, 0.8582439413326098, 0.036701007323391384, -0.7716364257761409, -0.866780925188066, -0.7660363357526052, 1.7799729762447543, 1.1016340232408837, 1.1681339138746953, 2.2023908888810424, 1.1188747165313981, -0.0844480192215876, 2.9417579599507016, -0.5327641358756459, 1.745818096939896, -0.41670897945697144, 0.4434615561231435, 3.1732052652833294, -0.2904821506794876, 1.6837434770634432},
    {0.6575406467478231, 1.2005183895326321, 1.609430405298357, 0.0033978894299646406, -0.31594501173986206, -0.11250308202681249, 2.4246560369897483, 0.44232236333002817, -0.06447490893451738, 0.1205520640194041, 1.7333237018333998, 3.4896139807715336, -0.5516565653177993, 0.8567580965931818, 1.1692660495183114, -3.1082915799912416, -0.17898438914070772, -0.7259120492234552, 2.2548593267449664, 2.9383304133433015, -1.1548610917583666, 1.040333508351113, -1.366565559121053, 0.3000754517193097, 2.510338970523698, 1.072878654727843, -0.6181660535178131, 2.1393822979149064, 1.6319905589006425, 1.3373257780443004, 0.3907891107910294, 0.56374128563448},
    {1.2807295344515044, 1.292191951521797, 2.0342797141461295, 1.651014716051714, 1.0852740135027243, 2.144910725516457, 1.4438087282811878, 0.08905791769723667, -0.5862191915546558, 2.782824142948638, 0.8358093380132264, 2.1708253835988556, -0.09167956376223106, 0.012610880982173308, 2.2503187005586773, -0.20689910711036852, -1.0909188792006328, 1.1489697817308855, 2.830524835646665, 1.1839497965628962, -1.4845424215742395, -0.00589483876527373, -1.326654968617898, -0.6056228106843137, -0.03665943214426045, -0.02396580640775271, 0.910088298843619, 1.7071343624824749, 1.5933914150673292, 1.4912957051808073, 0.4526100183362503, 2.236313466594024},
    {1.323112392785694, -0.4885501890244037, 1.256324326540787, 2.1643590050869985, 0.8639488809789471, 1.6775048139848168, 3.3699791556162957, -0.3561335501084412, 0.5740817104557615, 1.3747609001521246, 2.050007885815295, -0.5888578944807052, -0.45280834630128536, 1.6120209081776145, 1.5602652054766863, -0.4317745845616773, -0.34076320909513386, -0.11173523899882003, 1.624510402952756, 0.8049975598415049, -1.0908870234890329, 0.7368519089438176, 0.021046381886513504, 0.7996613275992844, 1.3222321535267714, 0.42443101583029463, 0.11102017895147322, 0.1850462246351525, 1.2495043575602978, 0.8030312870306497, -0.1281869411231644, 2.146756652321919},
    {3.318371482350634, 2.12889225939489, 1.0341137241635256, 0.6573649427341904, -0.723173187921397, 0.2564028260763829, 1.674551761051928, -1.117660057878265, 1.159948912284668, 0.15502952090260064, 0.6864837403476687, 0.09379989373453682, 0.49745062079408997, 1.3203926894025493, 1.0629873672063321, -0.5687426854277593, -0.4201459336095969, -0.8574500457183273, 2.1604240030666504, 3.106086827280422, -1.0869938004448283, 0.7360752370660768, -0.13780443651306776, -0.8310311736260031, -0.6603148483680505, 0.5077791392972139, 0.712229256514694, 1.0066598710380141, 0.4406314402593379, 1.6339974117030103, -0.23761828338813717, 1.9339988490014033},
    {0.11942390004886416, 0.9180221225158293, 4.091173298011175, 1.8257720222906642, -0.5406295149573832, 1.5337079772832203, 2.790938508861788, -0.19791562504626925, -0.13726357437529116, 2.212797078616801, 1.3326830238223402, 1.2165774797537856, 0.2012004325418298, 1.4422574655242113, 1.6448601843741122, -1.1331669900162449, -1.7616593394767104, 0.11645681173987603, 2.0404307600831086, 1.2596408979833678, -0.10099535477939314, 0.8011180717337364, 0.09403890978354107, -0.46014251506302056, 2.173291941017362, 1.0068103968763753, 0.11877779771858468, 2.2006620069341927, 0.6970252247839702, 1.118624128193412, -1.5488500642016056, 1.2489160132679098},
    {0.8114674490593863, 2.2860835414898752, 0.9610625329764919, 1.3516284218208414, -0.12794083116711755, 2.3701890529495975, 1.2973724937405224, 0.3788801028052868, -0.19348971571266324, -0.27283890469971317, 3.3692010346708647, 0.21351093491110573, 1.180110578213582, -1.1648062984254295, 0.5018902072489706, -1.1679846331956532, 0.6784732322473761, -1.0140196974485707, 2.4228579589395425, 2.9064000802090995, 0.20962735138241137, 1.9148202201427968, -0.28518979960559093, 0.3526047458373932, 1.2631070247787985, 1.0579668603366446, -1.7483230599470159, 2.49511357950397, 0.5605016712329153, 1.0335478912875353, 0.015021734210917901, 1.7850900431410326},
    {1.2257264592723123, 0.932540499774288, 0.38962028969991386, 1.9776130578327216, 0.9939129525900458, 1.9026442375874333, 1.7855662650930368, -0.4636896250339887, 0.44012548050955247, -0.0828840634394132, 1.4105351615949053, 1.0238025867766785, -1.713819854904479, -0.5826187595109222, 1.8293527961535427, -1.4013417746824317, -1.5260895598653752, -0.2516987373802257, 1.9461311264510703, 0.9651310961465936, 1.470526593863816, 0.23374612785768956, -1.3041457805650791, 1.4483500818227701, 0.9582894684641728, -0.022067042772770527, -1.016076601049327, 0.5654177053811681, 1.1981769148717962, -0.3919676506272162, 0.13545409698831315, 0.46166418602554204},
    {0.7218120294947288, 1.265050368975729, 2.0549155079043593, -0.25030043280890324, -0.7044726420138748, -0.2144751963885405, -1.2362791607653671, -0.7951540934964928, 1.2344005200856167, -0.7473728728975975, 0.2339048084801727, 1.356609947735264, 0.21232889615294925, 1.8238935209234417, 2.5109770750215232, -0.7034425797693383, 0.3312267235192449, -0.6987127703661792, 1.96448581752006, 1.2622415554049256, 0.14072304061263788, 0.28182767537200476, 1.4785233281842285, 0.1069501811063523, 0.8574805173488816, -0.010351918397707643, 0.6787795091944687, 0.07329155044079298, 2.366084202469644, 1.913776512713344, 0.10881287998792413, 1.3841075671503638},
    {1.7989541439396508, 1.5478880566484539, 1.1781093531505131, -0.8865818464652603, 0.24421500730514029, 0.06750993719769484, 0.7550161405586875, -0.12486836597046125, 0.44264964398966056, 0.6945037779910508, 1.4290398591008822, 0.4091932818544688, -1.7980362210115644, 2.168046380083191, 3.470363114892878, 0.9549006500759166, 0.8793643033172165, -2.031952992154149, 2.9450330010311467, 1.1629816063910001, 0.2362635341941839, 2.0570670068915, -0.2084003102131682, -0.48435544541221665, -0.3960629957179802, 1.3753799097816437, 0.7476621674259327, 0.05038879364630546, 1.0562338736026204, 0.46951714927705257, -0.7680042110160207, 3.749407947415746},
    {0.5303383235418226, 3.374783394073474, 2.3748984242604, 1.0448483611867072, -0.09501921770740672, 2.4072226870140514, 2.6636870186766908, -1.3112447565771113, -0.5051046863310811, -0.14329595835094405, 0.8151603716629012, 0.6617391603786461, -1.529685748930182, 1.7334647198367874, 1.6283268959623094, 0.8662240331005807, 0.8818650845695184, 0.3393611140990359, 2.7623250893721885, 2.7123733801235663, -0.7831450098610253, 0.9428347327639582, 0.8373232060082695, -1.445715280200598, 0.7683697619354138, 1.485051883866599, 0.13458780235452628, 1.6217819824264479, -0.3222051102641784, -1.11013518699892, -0.16039223709214145, 0.9014973716239623},
    {1.1196177564863201, 0.6785734341606223, 1.2758127586213128, 0.4892799861312542, -0.650406938526152, 1.3543388797555216, 1.6726687653598207, 0.9521523355373647, 1.489675565181166, -0.19550514999084123, 2.403517621859114, 0.7973333753873145, 1.0844344897245408, 1.5645571802358844, 0.6398624124022835, 0.48818852770314203, 0.026705941022269253, -0.7060666215143087, 0.9411661717595217, 2.248673989298794, -1.4067880723312247, -0.9618955416049773, 0.3755814111699234, 0.08003490668072052, 0.8225027834956582, 1.9813438368477065, 1.9516707932105828, 1.6871678501898246, 1.3568370839899413, -0.2045270560282181, -0.389319847212357, 0.1519752135435653},
    {0.4977634929833678, -0.5200058383875122, 2.1490504197204974, -0.3023912857986396, -0.3778444856603897, 2.641691846186005, 1.3866887906690701, -1.4762959835586704, 1.6857669648937328, 0.6646516386289401, 2.889361848010023, 1.2340592741412704, -0.2301929025588534, 1.3029064010970541, 1.622135703101062, 0.03623831380083876, -1.1686547589621656, 1.2118757145612402, -0.529607783558091, 0.8195156233472386, -1.5845020205610976, 0.4029560154417476, -0.1337610679331113, 0.7673478401378399, 1.5199581171296772, 0.5462476351239328, -1.2106388700364776, 1.5251390561621327, -0.03590132364843665, 1.3165036925684568, 0.3820339596954809, -0.24418319391353563},
    {1.906478280471015, 1.0304947120338732, 3.8032485539422747, -0.5008830633038658, 0.11792047348203033, 2.052595786782763, 3.1164852020064053, 0.8626334856148283, 1.9690019658935813, 1.3818516922181485, 3.1164723655746145, 2.5457422198453363, 0.8410924201275921, 1.2704383700782005, 2.1952683454092794, -1.4606804548486945, 1.2970054064457952, -0.46562935245585974, 1.849589369497801, 0.41929692591750145, -1.2534278275832036, 3.2586453700695377, 0.3170364488325362, -0.11797664924908843, 0.8796298964964796, 0.9249502058013708, -0.1896421772753385, 1.6723581248413686, 1.3271544365818815, -0.4010835141058989, -0.9517939502488171, 0.5186283735998382},
    {1.154337052554024, 1.9297437522511363, 2.6535895873267767, 1.4074096743566522, 0.1287832932056648, 1.380967257050184, 1.891071820773479, 0.991936685793748, 0.07053993935009369, -0.01892982797643426, 0.5554005458490274, 0.7467500288294694, -1.703063756258295, 0.5689762676425094, 0.8230273341375093, 0.7951379881101153, -1.155887286982244, -0.6549916901072629, 2.9373831867417093, -0.8482407150226053, -1.6457942282455598, 1.1356204673450343, -0.5016591645265419, -0.06502056810859551, 1.4980720765873285, 1.5957220061402988, 1.3105369668137095, 3.0480164266823024, 1.333673405648735, 1.3891377645741416, 0.4860429646032617, 0.8819647228195178},
    {1.0649397091644297, 1.7757733968970817, -0.05656884816922481, 0.4897659547753242, -0.8098721995857924, 1.1671411623007943, 0.3609519400251667, -0.9361337950583514, 0.6590803418796575, 1.4567841529893766, 2.2800019351420335, 1.113704393019695, -0.10298123193348832, -0.4039015413400187, 1.747453863463615, 0.035024355457146356, -0.6622057521338568, -2.7811981143548925, 2.279216640651156, -0.10768022220663484, 0.8542723981147919, 1.0698613075678394, -0.3221145953640707, -1.6623902229427003, 1.12313100056381, 1.5641653680142746, 0.3901911579505851, 1.1271182873821781, 2.127342704007374, 1.868617793275882, 0.27824104040147385, 0.5455119638683973},
    {1.326676464847627, 1.4936567654368293, 1.180097672754402, 4.129870979656204, -1.5390620475541494, 0.9461777439600891, 1.1808093328454397, 0.08719486941624995, 1.9119240987596253, -0.571119178876973, 1.2353547012456532, 0.0380217289882056, -1.4465253796014168, 0.4666756421421327, 0.8306636271194369, -0.666147681123882, -0.9565569820622019, -0.19239258146166668, 1.6694247708772998, 2.486919762532372, -1.5662995075132449, 1.022147991394049, 0.42094474251851727, -0.5356968938037977, 0.7653758484166141, 1.8814305663947049, 0.5684379422784308, 2.3911013310585028, 2.2369484396106802, 0.5402294036104381, -0.012365792328843002, 0.8578188072789114},
    {2.5601912987469264, 1.9183064075350302, -0.08950117872294573, 0.962569030736625, 0.0002878724064323173, 0.8588227657108475, 1.4331017106822626, 0.013241998833372515, 0.22108664009328768, 1.047633038302089, 0.6642954521689471, -0.014737344012779268, -1.5092519070118813, 2.663781042239582, 1.6853862470438692, 1.6046293102171196, 0.19630314267277973, 0.6236009597552111, 0.566801524455116, 2.0016637181280172, 0.21432411958985942, 1.1273867814011478, 0.8916874278075255, 1.114208415317186, 0.6988548139444649, 2.829730107506364, 0.7101017312492512, 0.4606427514282139, -0.2766523809147274, 1.6243924091227087, -0.6886761182047451, -0.17067524367915343},
    {1.29307251596238, 0.7769876112041908, 2.3005501759318108, 1.3777531384374715, 1.1892485214958928, 2.2156197797899626, 0.4008315480561923, -0.31628424997763904, 2.5839616196869697, 1.1340460485895598, 1.750801518602311, 2.562920301649021, 1.1173875797765047, 1.1115727876471546, 1.094351093593592, 0.4675733763214578, 0.4676962581718372, 0.3257763409082888, 2.469234084679771, 2.0453646623999626, -1.079273451441216, 1.8631086628795348, -0.1823316490594056, -1.3187699281982272, 1.4520904928197367, 0.9012270000654978, 0.6019956063580664, 1.5694697100855204, 0.34776332914955715, 4.185399439282286, -0.7748179984560793, 3.183875264393924},
    {1.6234688217052555, 1.536979384918612, 3.0817849620896105, 0.4914677113391318, 0.6489316976856346, 1.242718507167871, 1.6877682164665166, 0.6020390126994541, -0.0929877252273424, 0.7866810889421425, 2.478905378807016, 0.4040130520180275, -0.17827608889361887, -1.3811471109578524, 0.6498565466291845, -0.5669811577129473, -1.117853723762535, -0.4598557083517519, 3.4344706582321893, -1.5793783804020343, 0.8009295377602078, 0.567701091739056, -1.0260081808737078, -0.3068243407865966, 1.0382400700050982, 0.579233457656721, 0.8423863351572165, 0.5578788051438306, 0.9891844903109381, 0.5708598049562008, -0.8709152251505065, 0.7030242308951745},
    {-0.21497284434399386, -0.7149586104481016, 4.003531780869924, 1.093549893583832, -0.3081412401677823, 0.6782099219335863, -0.7267560096071053, 0.4300328947798341, -0.3893221741043856, 1.518403223831148, -0.09557447505594119, 0.42149077204658836, -0.04293995309059734, 1.8682832380857708, 2.8348345654023586, -1.6087887714121476, -1.0380969251486194, -1.1952999020824122, 1.5861922111724378, 0.43123499692702855, 0.8934024279075325, 1.1419010104615377, -0.3172473244207534, -0.6590123319090195, 1.1071754163722847, 0.8986616086902383, 0.11914948288471962, 0.563652334914616, 1.637815463887006, 1.2575931868633654, -0.9896736836194019, 1.0883804556822922},
    {0.9430500825140262, 0.8949325734034236, 1.7711818304793674, 0.3004286094524935, -0.7849763208651986, 2.22733064884229, 0.8821725354303075, 2.447591765190066, -1.1014562504036904, 0.7672700855083476, 0.7676803356740793, 1.338862955858304, 0.31150219106463733, 0.11034634258039687, 2.3403714703866525, -0.16596342465801456, 0.045799444608831494, -0.3360042695584113, 1.1628824895432808, 0.7235689255239899, -1.2593242761418737, 1.2300149455594318, -1.059745777093638, -0.8949251922615581, -0.6372267139101784, -0.33136937142319484, -0.6706088939654479, 0.8781531209917686, 2.3313241355778223, 0.10103834718136631, -2.140001759614116, 0.8875624808828926},
    {2.340101451259825, 0.30624405143306066, -0.10455130684590182, 0.7388004363224252, -1.0954825438152302, 2.204737918980219, 2.614169167334491, 1.2182000882113369, 0.9953290828817869, 2.600755590057178, 0.8907268905734778, 2.2489361513175967, -1.2679448402121989, 0.3425724875470194, 0.8963299788777528, 0.5718336726650567, 0.40864787434154803, -0.8971156480983642, 2.3450018702018713, 0.9151323883193306, 0.02269908759055201, 1.642784344705568, 0.6567868025846344, -0.6121870979439819, 0.6354857572787563, 0.9278610385380689, -0.6250841152472716, 1.8509130097780508, 0.6296159067855512, 1.525199588890266, 0.7276785433961764, 1.3249323293170698},
    {-0.03972377575738651, -0.37729477280514373, 1.3875458235265374, -0.15031127090970037, -0.2217102814334076, 1.202532283075841, -1.5681892235808383, -0.07289381010669911, 1.8073049410326965, -0.11178478808739865, 1.3887306199288731, 0.8177054197694735, -0.14302399132947807, -0.7870770085686748, -0.2582234382200197, -0.23978346911478715, 0.35941554890780697, 1.126105897028018, 0.06106876740659897, 0.27815614582704973, -0.027739569576880688, 0.018531558736577778, -0.5569047990891457, -0.5440664311183137, -1.8306541174849413, 1.9544379210287535, 0.9028956901436789, 0.9110385100837103, 0.47329300183020523, 1.5495811409025406, -0.0299940355163341, 1.3883542809583047},
    {1.722543501497677, 1.7998997869905577, 0.6010850172328975, 0.10524926483040616, 1.581709157648, 1.8711992511149709, 1.5864855608677995, -1.0973691165114035, 1.0819842534064563, 2.5651927549629367, -1.1287061296598857, 1.692585300512646, 1.4270199628673872, -0.4968596179458148, 1.7209433074440967, 1.7434884123860526, -1.0408840197049316, -0.05604190863488885, 1.3616846542945134, 0.4474433473724521, 0.6710761165921563, 1.1231208341901677, -0.31887475795979914, 1.397515749069054, 0.7194789134164483, 1.10768782898773, 0.20358490316772207, 1.3240707891258159, 1.122966196763143, -0.4906869825779038, 0.4850424719692463, 0.388508239283099},
    {1.6668371817091987, 1.3485414264114879, 1.8444898549628312, -0.5510721658332112, 0.7600110307461564, 2.5944095768727213, 0.2707226018566606, 0.7566147322651134, -0.8636649370257181, 1.3199167466235628, 1.8381656816038714, 0.05167056264526673, -1.888680991430261, -0.8287799991379597, 0.38417998828078725, -0.8191182243276153, 0.37094613938729465, -1.064826627615115, 1.6808357061421406, -0.23985198093311852, 0.4490248190140648, 0.29257701274283004, -1.1889377508696604, 0.4301507520618587, -0.07668563134161091, 1.0391458777448968, 0.6968531056115904, -0.31807354501099266, 1.6446901485930367, 0.5169175760832193, -0.6228286909601851, 3.1583670334761442},
    {0.5629466502064224, 0.11071266112619987, 2.121591672149813, 0.22003377919567862, -1.8231986512414973, 2.226059736808521, 1.2103445574613407, -0.4236443020322745, 0.49035252931013434, 2.5481086320173816, -0.12360317899419385, -1.3855245372532787, 0.5085671590101799, -0.2595228928053402, 0.3697351241252671, 0.9795441239767454, 0.1893952755014732, -0.4360155119294239, 0.9419721035327658, 0.6308036544270046, 1.2220161784423722, 0.7739039687555482, 0.820719922837954, -0.2540758450937536, 2.3482279001742814, 2.0609765936185296, 0.16026627108443664, 1.681229402814225, 2.636747037477001, -0.32186298220561804, 0.31688587817326713, 0.0629690436149232},
    {0.7044356827003716, 1.409955617140633, 0.299307775064447, 1.6013933805302945, 0.28380650519710104, 2.082440724530943, 1.17151731258665, 0.047020266505869435, 0.6027245057115954, 1.3237616096886171, 1.6333703219555857, 1.3478860817412572, -0.9307136600809981, 0.7552470237771604, 2.9483696002203073, -0.887248097169174, -0.6240241157559706, 0.5533304909929984, 1.446158020292872, 2.158910958850917, -2.6519841426973585, 2.674675713913701, -0.9173480088937005, -0.16316236552114194, 0.664620700826173, 1.1901857486928582, -0.5077849091449718, 0.8592719127986456, -0.05590248065913354, 1.6243091672431627, -0.410714717251266, 1.4063621122201477},
    {2.979970000361141, 0.2863418548380008, 2.9689141146473985, 0.2666719001694625, -0.2640284659072536, 0.16059663328610027, 2.1512221371669864, -1.1092628761916943, 1.342018005192609, 1.0210301276399956, 1.4440535949668662, 1.167257455330977, 0.05368156957498197, 1.9528737365747804, 1.9895068779550262, 1.5599326477040778, 0.3078113988465183, -0.5707380330418107, 1.7834816350833127, 1.9457948692544778, -0.8414724883889593, 1.1140467452570735, 0.09542453568165314, 1.9743880617759557, 2.234356843058722, 1.0200771374721522, -0.2723844721554898, 1.1837358456930005, 0.5462717693929977, -0.5641642249274302, 1.9871437842032982, 1.6054784663124695},
    {-0.24870804353494638, 1.9701218442682242, 1.1036346748590262, 2.3026016217633107, -0.5551569665601321, 2.407991098509357, 1.3135225458458282, 0.6613649702224879, 0.9474433491025545, -0.07545966532636966, 1.7563446602882844, 1.126856763376697, -2.0201994288510816, 1.9640694634086702, 2.1240423688849344, 0.5792773448547044, -1.4445592797100264, 0.014086601727488986, 2.733863638059931, 2.435662483278249, 0.9294780766151985, -0.20134056720036408, 0.8620532425816451, -0.5691843791019232, 2.1424787427732617, 1.5803421854180875, -0.001348963515142045, 1.3952216561081365, 2.4644254086638324, 0.26616512329925823, 0.3017457825870275, 1.83452749094421},
    {3.801964534521703, 1.3825843567267657, -1.0173068892174175, 0.7675196308154068, -0.899162790586613, 1.4393060951527936, 1.052045960528853, 0.13789396369765472, 1.1619419099524513, 1.2608490401595946, 0.6349574983646954, 1.3800899439501877, 2.307273446844284, 0.42304490430924596, 0.5556014682769869, -1.3613448195174354, -0.8871360796251706, -0.5354764418398734, 1.8532931796414205, 0.5642870293522203, -0.7495559500820071, 0.2886501712385082, 0.8635855439705423, -1.1845384264972227, 1.9267571383259487, 1.841278748073865, -1.1158290526891308, 2.079723067211139, 2.384664906667337, 2.3761621287977803, -0.6685212597840112, 1.910342835009429},
    {1.6118990238480109, 2.1907906557602392, 0.8832478052931093, 1.1091704359648713, 0.5472472870121315, 3.142220241361264, 0.6176037155780474, -2.258738808352065, 1.6344449511769537, 1.2684133929571857, -0.9872506102677872, 0.23490487500956858, -0.7426644312138024, 0.8302146420943808, 0.5630733938988655, 0.2534722213162531, -0.4665486005959492, -2.855486895107377, 1.4842181194549289, 1.3993094479725046, 0.988294771916875, 0.20345193013995158, 0.6259262473109473, -0.19161478821055783, 0.40904551246179305, 0.29380453338611034, 0.8123648605396903, 0.3674296935163139, 1.096632340986139, 1.9232648619177528, -1.0274175762290672, 2.953280292799416},
    {2.0258084660456905, 0.2891485737259773, 1.1743246839509025, 1.1184091626668704, 0.507303668081379, 0.6636524353972282, 1.206526952109353, -1.224254203807846, 0.8534845833623621, 1.927488918267225, 0.7266291040439501, 1.5932547425951606, 1.3122329391728789, 1.4726005370516437, 0.8671393719993284, -0.32697029418241236, -0.39019974064596835, -0.5447426359760089, 1.9816138764380327, 1.6429166411363476, -0.4434803612559906, 0.4194387066870805, 0.9942327600535288, -0.10670281795147753, 2.1343877558808115, 1.3018680388543755, 0.1112545678479348, 2.2094008932729694, 1.5562853470605487, 1.4699823329447808, -0.6963420709387005, -0.18022931273655965},
    {2.0618388288419003, 0.7803747745219312, 1.7094990189348829, 1.5532983298951855, -0.3079864290257542, 1.0582344931884053, 3.2182843881663157, -0.6002757503823783, -0.10232104785040705, -0.8130597825554314, 0.5551026197912761, 1.1902138863929577, -2.5996004941134974, -0.5976721973309059, 1.3417828725463345, 0.5749517186997406, -0.6380782875008151, 0.7208014951039083, -1.229899726171518, 2.389662232134077, -1.117074621455611, 0.2737809610933183, -1.438523739222278, 0.15609823327971412, 1.656002265965395, 1.3860582824689933, -0.8620557771457551, 1.2899671012264133, 3.207149755976605, 0.7095708554860677, -0.9261563524939413, 2.5066338233475993},
    {-1.1536687587478096, 1.2914699339452753, 1.6504310884570035, -1.0175778167275584, -0.20533657378781947, 0.7620445918265022, 3.5427231144120177, 0.8782258572978187, -1.0166052635823009, 1.529820462844118, 1.34156399032054, -0.3404909618697088, -0.7585113228111526, -0.06932086556670727, 0.4707893148951364, -1.287897955300264, -0.13196153061054025, -0.7524590340866331, 0.9987599044311595, 2.4291264322033395, 0.9408412891051906, 1.3791213060852279, 1.924471688350642, -0.7326199278081359, 2.1817094509577806, 1.0739320891959054, 0.6609159511077056, 3.7365671551832196, 0.7097284240088475, -0.7662021449335786, 0.28341711963753236, 0.4546586910926004},
    {2.669573458547569, 2.8369837688348047, -0.09313625909700468, 0.8937309678167505, 0.2913855379136523, 1.8125347882373894, 1.2303888034900266, -0.6135248032884488, 0.31898936610317935, 0.6099937895174188, 1.5723265072042751, 0.417850652393844, -0.476955584311583, 0.8527119612363837, 1.7113148571019414, 0.9577753732797175, -1.4371392933556817, -0.3834856635311696, 3.420533714708365, 3.5487074963464256, -0.21834908677781714, 0.894871030733298, 0.18629287237469738, -0.929081289403397, 0.20510132184086344, 0.3908237747750571, -0.4152821040532553, 2.036564684956549, 1.334137068668647, 3.304034731190735, 0.025312914214212334, 1.529104576853068},
    {2.7079074993625603, 0.6240697665850291, 2.3171336378710565, 1.1261867250187427, -0.6543550079921504, 1.2545113379936212, 0.525698420814459, 0.2369894035046873, 0.7829276376622263, 1.1416262238363502, -1.0814503217661604, 0.3596598131180021, -0.5525364164355624, 0.3050595089953696, 0.05068553109531073, 1.1692039664497824, -0.5047781495977743, 0.36166833839516926, -0.8219925139127316, 0.12343698723852932, 0.2232529909481091, -0.7767985769077038, -0.5172051603427201, -0.811764939210566, 1.339606033643102, 0.44344078532733644, -0.23718984060381432, -0.2900802418318779, 1.904873631523921, 0.870369627792111, -0.7208691060355599, 1.3387737698302367},
    {0.9671234353376993, -0.40480772627222045, 1.930607802659904, 2.1597092798555666, -0.8470784098212678, 0.4611938870691237, 1.3378687786392378, -0.39901162315648486, -0.5608909847408552, -0.9903162259520503, 1.825412716848428, 1.6388379615499498, -1.034544150426498, 1.274778114837252, -0.2692557755676269, -1.6877262125249348, 0.6279779888732046, 0.705611799143916, 2.142274493534786, 1.2594170019762756, 1.5908965398534118, 1.4924034642412214, -3.3616841930297094, -0.37480810368172957, 0.736378869479946, -0.43646141889750434, -0.4033235632309823, -0.5461971694958462, 0.606591488388184, 0.019964020620252678, -0.13967146687318896, 0.9292986077629958},
    {2.6107717871331153, 0.06399654187191338, 2.1540906471185695, 0.371552052999502, -0.8218006942528808, 3.334282067475597, 1.4540197563446253, -1.5958099155020011, 0.7517498050571553, 1.2663998995180934, 0.8164453935039049, 2.362998567936819, 0.7332982154157003, 2.0205733914741404, 2.2434935191788017, 1.3112369470959964, 0.16118492915939922, -0.5415575073667053, 0.549756749049138, 0.26382706826250063, 1.1294936282801054, 1.2910051894853987, 1.1188999729052784, 2.1479507357670253, 1.4449430614291607, -0.6232041658758104, 1.4918763434649853, 2.9825538489956385, -0.0329289591689616, 1.7867890270062818, -0.28048283978000044, -1.6494813538117763},
    {1.1199677935402146, 1.5697017257265633, 1.0682189487215785, 0.15198385335294234, 0.23576406057795216, 0.7421958460323378, 0.6724729948214893, 1.8571971488501735, 0.4797844372362805, 0.4681713191211733, 2.221387294267494, -1.4272102592094016, 0.6419853218851724, -0.32074890796228417, 2.089535752948187, -1.2019822653470147, -1.3229147282994471, 0.3257300407707694, -0.7012974608057255, 0.8367679812401086, 0.15469275002867444, 0.4827626492208477, -0.6486394446575876, -0.25571294725786525, 0.37252756966103895, 0.3245105867749738, 0.0812783077986855, 0.6633706786845763, 0.9623351107278408, 0.07052679210296803, 1.6479935318699093, 1.2896592075785438},
    {1.2109226496699799, 1.497107421722788, 0.4119972332257557, -1.2800584705384723, -1.8209404316275046, 0.6539496121389652, 1.3346480732126085, -0.4346865449745119, -0.7088329312556233, 1.0165879118295862, 0.2926550555879085, 0.2858295024019835, -1.972979299667567, 0.9580594464876449, -0.20008944655102456, 0.5796286691785959, -1.0986580879423482, -1.0194263683211344, 0.6941655738143638, 2.6242984284304662, -0.3379845907582302, 0.14540890592961064, -0.40150819601517995, 0.2304701423154201, 1.6568872165085256, 0.4218358450255346, -0.6395798146177822, 1.0922379194829506, 0.5850392192399451, -0.116021221486342, -1.4784123188741563, -0.5136324082757312}
};

static const float b2[32] = {1.693909508487764, 1.9143360504145643, 2.0130684901595393, 1.3094292967712684, -0.29215593938097884, 2.3479851569380337, 1.910982925973496, -0.26985244363734784, 1.102768089649732, 1.0247600326020778, 2.08666125656605, 1.456096134080842, -0.39740419739140426, 0.9331219086736419, 1.7486710952122895, 0.14478549481174713, 0.009784814368169494, -0.2445946071288085, 2.3835253767964493, 1.809430246952436, -0.2332424092645029, 1.353852222818596, -0.06354458439563386, -0.1404908942080718, 1.7197267721584422, 0.8106208371932299, 0.26345585122547654, 1.6665963446690828, 1.6195259080666553, 1.7285198985194072, -0.2862759209767992, 1.570108198164601};

static const float w3[32][16] = {
    {0.3531172343114182, -0.526229836045364, -1.3741266320176095, -1.391930048062255, -0.516018217529681, 1.0386102786090434, 0.22075274165603676, 1.5976527709458144, 0.5968528745962116, 0.845179604943806, 1.8416610615020272, 2.0224728736441215, 3.118231241243064, 2.5007476077082065, -0.3283633787833243, 1.0514759817501071},
    {-1.5474278076687258, 0.25760409648554644, -1.6104634053618228, 0.09236381361156526, -2.3653369446009145, 1.2442271065380834, 1.7777150484233044, -0.2919165556259924, 0.46751948225793244, 0.772900236279585, 0.3753563324497731, 2.631984759743175, 2.5777406388777253, 1.4976738846298123, 0.07578102493231124, 1.2130191013772573},
    {-0.49967886328031896, -0.05522125285719869, 0.128814054150975, -0.09836695682153422, -0.9411146533605078, -1.0597459320133873, 0.42741236058687104, -0.9336637098647987, 0.741209310666579, 1.0543057066499313, -1.5022112017484683, 1.623587811535897, 2.930426707273541, 3.097570748026036, 0.7575643986205333, -0.6718017271231148},
    {-1.3835292090657685, 0.4160263653381989, -0.87028336127182, -0.289904806212858, -0.2678989484162069, -0.3425019406499062, 0.40073286878507686, -0.6679303460454421, 0.9613454226005567, 0.7213635411043924, -0.9508427033155915, 0.6048396869463727, 2.046117146325236, 0.7944917014278772, -0.01341922663488174, 0.6896606297770648},
    {-1.023885068653231, -0.1592332632099602, 0.08158223256997085, -0.4116428637357492, -0.22473431937592855, -0.4965130013917048, 0.9285164851368706, -0.6069405033106144, -1.3393910177367425, -0.030135320513859573, -0.0642253012068379, 0.0002773380460996821, -0.08878597461068007, -1.425754449279652, 0.5702404311735774, 0.5309050536382932},
    {-0.6867713353921715, -0.9475993395472015, -0.8441374564449384, -0.6249628640544753, -1.2815896211303677, -0.47267339232528005, 1.2095887230477986, 0.5270480217866074, -0.013166054615804704, 0.5733442061348937, -0.28222121630078084, 1.524262074007014, 2.440504185741349, 2.129932784187676, -0.08915115261037078, -0.2969753636034998},
    {-0.12854713563963027, 1.795953421896239, -0.5077990014012659, 2.769615511665495, 0.7662749984472433, -0.5341440425845502, 1.8285760015134513, -0.49910884641407544, -0.02212831549043937, 0.17509251120523048, 0.21028469191389074, 2.8588835574937037, 3.3609170562954667, 3.572454435882448, -1.3183695226640042, 2.5681974510960295},
    {-0.29935388232402627, -0.4015201894772253, -1.7314044032078773, 0.9429840369253467, -0.5254957458209285, -0.2064954340789433, 0.0410296856575054, -0.38787088525522695, 1.545517080403432, -0.9724003423099749, 0.6263314023585225, 0.5853619958186002, -0.1186225704574376, 0.803892310319646, -0.7542756286403975, -2.1008572284995477},
    {-0.4152002893370514, 0.3032771135164791, 0.27477712371828866, 1.9376147619760802, -0.3192157164922469, 0.2552089859221468, 0.25834696807953417, -0.930746416879814, -0.7419460110718397, -0.5414352497557765, -0.8415211578500483, 3.3338769437565556, 0.4431370521266962, 2.841004386317474, -1.8317095419323524, 1.8938340713628596},
    {-0.4509583572090758, 0.6557766185099275, 0.08352493866860643, 0.16557464782563194, -2.575211614733028, 1.3034498978009055, 0.8843476095607568, 1.3748232269123957, -0.403928044931919, -1.8106228139515963, 1.061233875846717, 0.787411591024969, 1.804222313747147, 0.725009524749073, -0.522728637090065, 0.7040416271862097},
    {0.8037689240415663, 0.04362405901208595, -0.03116837044784085, -1.8642005433109008, -0.8650824387441088, 0.1556187288443294, 2.0482263211712968, 0.1989693027442453, -1.4008682837728177, 1.0023292966895798, -0.1621588222002758, 2.1282439401715525, 2.8162838511508377, 2.135252927256983, -0.09682441853290957, -0.45357703474323774},
    {2.3250380803064927, -0.24149532867920478, 0.6510915961191572, -0.2706186680190242, 0.6801120635768799, -1.2235233991634442, 0.7844634294190925, -0.45467691492999956, -1.0285795898346626, -0.11367613378192404, 0.5974321199969637, 2.604297047464866, 1.4533785172012932, 2.480541494578714, 0.08750752168279083, 0.44267841156335436},
    {0.5043399406494034, -1.350643363397277, -1.6855692019028186, 0.2972097854045657, -0.025569770179057604, 0.07357153401143722, 0.06323705170228396, 0.05036261817780459, 0.545270749543879, 0.40827132382520825, -0.5217734757084741, -0.4856284136884226, 0.058273958434691533, 0.32248604191291813, 0.8870873124348008, -0.688550962214757},
    {0.8418333807909225, 1.2784213489798806, 0.16110106499677293, -0.7961909092481225, -0.4835580764442618, 0.9935096803211083, 0.6689535687608789, -1.1357792524869712, 0.05558582800731563, 2.843593034554129, -1.8580618376691065, 2.3262198734799977, 2.376194487961297, 0.41878359040656427, 1.0521803881177072, 0.5499446543823548},
    {-0.40633826572294135, -0.5842282033035641, 0.6775940052327868, -1.4491410274567564, -0.3876490823551284, -1.1821320393485386, 0.9308903850404353, -1.9686557458426832, 0.7198763141587178, 0.179470459198053, -0.6090038845928878, 0.717521306453244, 2.506114292328894, 1.5265096621309298, 0.9534360566755508, 0.09137013676570746},
    {0.5530689040049293, -0.10701383313966469, -1.900741958845836, -1.1390689469318043, -0.6866491670561864, 0.10093814350314559, 0.19786019316344036, -1.2657928032713064, 0.6212496157844362, -1.1811039772545668, 0.3962959273499874, 0.9814027145280021, -0.7901069819446633, 2.484977635847964, -0.15727032825160717, -0.294427948868112},
    {0.0025851097236320696, -1.1767749221092385, -1.865187551219278, -1.3277277305405906, 0.9139980729768604, -1.1295237077537068, -0.08735697316825243, 0.029527691551086675, 1.4257642372312587, -0.6572312358773377, -0.6830597219391057, 1.126372237082035, -1.298749413483931, 0.2854414272072266, -0.6229977853044482, -0.6266953556483472},
    {0.5662172767531257, 1.6809749541710786, -0.8538714881632298, -0.5264574234095513, -0.7856214918945594, -0.05359758338823346, 1.9963372400904407, -0.9968454344193829, 1.0313410079439553, 0.569739329678067, 0.22723638868598425, -0.2969295098602396, -0.8407127661162879, -0.19620798896253072, 1.4295736960012473, 0.16163345910141821},
    {-0.3365728086376526, -0.11382993178257347, -0.22834121693678042, -0.6906869421507577, 0.10608659914587312, 0.17489545504057297, 1.709667590003179, -0.6560621933486454, 0.0066247368857051455, -2.048819796308429, 0.629860348167292, 2.3366622653475506, 2.761769983183681, 2.618365714504559, -1.7505043099911994, 1.092826685555296},
    {0.08748888568672583, 1.1864950352656358, 0.6841507607906963, -1.2107798068083313, -2.3018066292466832, -1.6631500062175137, 1.759209568613894, 0.3839426625608609, -1.8192854182302987, -0.44200972865387905, 0.7127815672994764, 1.9919638852960988, 2.653352889908866, 2.576000446534392, -0.1850573824438824, 0.48834830098097876},
    {-0.8992382400813163, -0.19409946687295665, -0.1321291300498978, -0.6399330195862407, 0.6691046259327263, -0.14298794426469752, -0.7428749994090702, -1.748646437655487, 0.918114315498386, -0.5119186624469186, -0.10102531721615876, 0.8502556821427081, -0.842918967933379, 1.286512313201006, 0.43924994103438403, 0.17343474062881029},
    {-1.5702049768768704, -0.3227218335019484, 3.34191507285115, 0.8345411518451924, -0.36663729649210147, -0.7209469257759356, 1.2790814976624219, 1.48274246173101, -0.9955623620742738, -2.8892307436554407, -1.2899724582628107, 2.301844963491569, 2.1266624727550703, 0.5679533497058814, -2.3985481391633585, 1.0600045664374573},
    {0.4844093520790699, -1.483113430922805, -0.7255160636399889, -0.06139923128089038, 0.05869369425649785, 0.5154222843537547, -0.6779711976826063, -2.2641874343813497, 1.1194017803308602, -0.007023098827904175, 1.3625758078454875, 0.2841535978931727, 1.0217423098537508, -0.7038781207500668, 0.7997308997235979, -0.3943079321913885},
    {0.3131246779627627, 0.5585249116077604, 1.427692037886972, -0.7459695258281445, 0.8248432565617294, -0.8141466535221898, 0.3934227746709558, 0.343914264038773, -0.3399852275511281, -0.23580234550282997, -2.0020071351422986, -1.43596053579792, -0.14581634112724826, 0.34459225872231836, -1.0492910692109059, 1.8625973646135103},
    {0.10441226451721429, -1.1116135884376956, -2.3218560018969603, 0.352982028484903, -0.9017782312182889, -0.8697640582797259, 1.9539037940230652, -0.8102697739738751, -0.5105948866371404, -0.8796006026825921, -1.9550048945785445, 0.5245384210210716, 3.2806874353413544, 1.107087185950194, 0.28316293567733053, 0.8673103620845269},
    {-0.8819325391218903, -0.7263802152886154, 1.1101740519306695, 0.5206071968444058, 0.4593775609677534, -0.8153386865021366, 1.6934993030220806, 0.7373949413130624, -0.8185196858006285, -0.23856465133538463, -0.17514100962742632, 3.3535959754226163, 0.2147260588158292, 1.7691443798915203, 0.6284738951548925, 0.6455784492726978},
    {-1.3801450952989764, -0.12171360179260751, -0.5431323144552083, -2.3801579183930515, -0.7709623191276115, 0.2971484363667901, 1.4544043826241762, -0.8002059334790094, -1.304669630105091, -1.3590360553466234, 0.2702810446541376, 2.4449638313012922, -0.02480993086932584, -0.980846806244395, -0.1284284209002263, 0.10623908842289272},
    {0.32427920588329706, -0.1757605493735774, -2.497182987114994, -0.16703775453940775, -0.4510158390566084, 0.5794334968770881, 2.8373617216908547, 0.3116064789967648, 1.2707554297528696, -0.5018410328670112, -1.4803176162247553, 3.1200446525993795, 1.8043123790998363, 4.647995817853786, 0.47329568696174595, 0.911527268357084},
    {-0.7982336850717854, -0.8419982302418128, 1.1065086374274633, 0.646758798797601, -0.3556989791824334, -0.6177177674734603, 1.396157495120976, 2.5666813606963954, 0.45878141304093845, -0.29601973753653205, -0.03487187752163609, 1.375187723385713, 1.9543967786010872, 2.395474981061225, -1.0968380150032706, 1.7960901285613813},
    {-0.6073254144179022, -0.3723675772553172, -1.494377697166721, -1.268640827148991, -0.03757551205482707, -0.9306529881605964, 0.40033209346156096, -0.9586628375681651, 1.423134760287112, -0.25385519803559053, -1.364444681299571, 3.364308146486166, 1.3059995908857596, 4.506913125479694, -1.642393495550943, 1.956994572387514},
    {0.6872395189521081, -0.2545689875411178, 1.3166187088872092, 0.3246206553107014, -0.3297058456120231, -1.694960498657901, 0.8502230320518352, -0.04515251315590284, 0.10988910324093155, -0.09633349001262707, -1.264192540626626, -0.8386394836679867, -1.5062527053121355, -0.7131518955139774, -0.6276126760406134, 0.28547572757080036},
    {0.5830669587781476, -1.1288659520824085, -1.9329168289255556, -0.014392858381371523, -0.6634672337362435, 0.7831919341568835, 1.4933697159999655, -0.20893469557761, -2.4094247767481005, 0.3753201366276511, 0.09438567282067795, 2.7062650059572806, 1.7603910644542566, 2.2919966156887583, 1.0381524764813628, 1.7532124465752812}
};

static const float b3[16] = {-0.04619809430218063, -0.32060067461490793, -0.19310617114373013, -0.23736239223671163, -0.023075218963415446, -0.22790743765965396, 0.7228738326535958, -0.23505421821913763, 0.010891707580500112, -0.09416149828336548, -0.2660818578991104, 1.4779972188677428, 1.6698589573585063, 1.1643546898265336, -0.38031319067836455, 0.4795795349138032};

static const float w4[16][12] = {
    {-0.931239162698279, -0.27637627074636356, 0.8286072456536372, 1.398546825367407, -1.7662678565344063, 0.9270964296437205, -1.52608422272563, -1.163247770778876, -1.5962582162534036, -1.7679160239535756, 1.5905811275208657, 1.3671233487585523},
    {-0.34052712515386363, 1.0531179107082764, 2.2656669317920017, 0.8924031146121006, -1.4161430614268593, -0.42844593352129806, 0.2882596357938485, -0.6188775227179397, 1.4614889373404152, -1.2606938753536718, 1.5152152054304084, -0.9521695955917703},
    {0.6778132570170455, -0.04969686850525875, -2.8874172760592764, -0.6984505091472021, -0.23516798843409445, -1.0753008381899354, -0.1664621433484048, 0.9042630661009257, 0.9669964665337278, 0.7983780447602558, 1.0978218684404735, -0.9501937699967178},
    {0.18979574521985815, -1.4820568537720695, -1.120979853785325, 1.2924006351468698, 0.4966596846845774, -0.37951927445875605, -1.0055225269741066, 1.063152600879738, -1.3246679187818529, 1.1574261939061405, 0.25167937011945307, 1.2270340863386546},
    {-0.7710539297530542, -0.7737419205642423, -0.9349480672615996, -0.011270946366871325, 0.21874645587265443, 0.18964449973283953, 0.8585296120160731, 0.08268515951448276, -0.2484843200244022, 0.029262159630407823, 1.8438180330695602, 0.4998421662231943},
    {-1.451363224571779, 0.9411606815147505, -0.0251437023677383, 0.8133501420297796, 2.3805570853878013, -0.749453657374487, -0.1639306268312402, 0.9140042170388596, 1.1384781781968347, 0.3607309679387817, -0.3944269902020567, 1.1244278801484204},
    {-3.6212240680980825, 0.01849942013613049, -0.10660928916913391, 0.2565331420940984, -0.9110268199919939, -2.366877072432313, -0.7017754596756781, -1.2156929444522189, -2.0287790840669637, -0.4077155823918321, -0.8960010148666603, -2.7026108065533103},
    {1.8018966392198588, -0.2788437359629269, 1.6341417447101243, -0.7251504089101509, -0.11202981314955794, -1.4339237026986082, 1.030886319140195, 0.5775246917853978, -0.2677742481593792, -0.7311129094789942, 2.043212402464796, 0.5727950779361314},
    {-0.386269625681538, 1.10244775741526, 1.371830224704263, 0.01596023446379666, -0.08419401677983662, 0.6648994451120851, -0.6409831643232236, -2.5522174138295615, 0.6464173521247927, -0.12357796106135073, -1.4216535797776553, -0.4705991056260998},
    {-0.45597113854536697, -2.1037236075175234, 1.3993585622174438, 0.3267054796515386, -0.040193962120286676, 1.7352100379822581, -0.12796742547892753, -0.6907680859513992, -0.8765772958339648, -0.2259092883137644, 0.1217742898098555, -0.4189778977312368},
    {-0.9958455908942188, 0.6507041737017084, -0.7451208438990489, 2.0579204215349622, 0.40341594157031035, -1.9821794280057885, -0.4883771836364284, 0.6758459405405135, -1.111549053718046, -0.2878143045312784, -0.2751426437807314, -0.9653682845108323},
    {-0.39895964943318296, -2.429924105333125, -0.5562184889191696, -1.3127426646614555, -2.054227956893836, 0.31314856232344634, -2.4305778141972056, -1.4606106113813302, -0.8962294386729757, -1.64746790337205, -2.235687570682331, -0.04140903024826931},
    {-0.8357144789365596, -1.976459516282874, -2.888686677022964, -2.868452769424834, 0.09898117958532465, -1.5969941982260796, -2.5813533500940555, -2.7512773272189097, -1.4301604054931285, -2.6402223508958578, -1.349824712345018, -2.2801816550442386},
    {-2.0134596123800335, -1.0730530893219037, -1.3972166790460645, -0.8718990369163674, -2.76889193241081, -2.082769920088909, 0.24122386111310698, -0.15050792434156884, -1.435192641056567, -0.8079291887166754, -1.3302175105948844, -0.7066156300388399},
    {1.483100842933293, -0.9238694981026168, 1.1728258343181757, 0.9810292837226434, -0.07205185780802886, 0.09747929263688698, -0.5721391208646174, 1.2045094181438107, -0.26195424342247714, -1.157039566604839, 0.500977105929826, 0.29092770716078165},
    {0.08233667002569277, -0.07382053069261593, -1.21212014209718, -1.421384979208467, -0.7073444336516153, -1.2247718409364028, -1.0545146233117673, -0.9941275638632716, -1.164760757652381, -0.20072339532970412, -0.1290446860776418, -2.016623188952028}
};

static const float b4[12] = {-0.8712085712800834, -0.9063481464238854, -0.6561499084338867, -0.9263964114902076, -1.1275805981028393, -0.6106119645212899, -0.6739963619993599, -0.9991258263432482, -0.948065659248655, -0.8384109606181772, -0.8547857850287901, -0.909919226816497};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
