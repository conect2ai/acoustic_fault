#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-5.078693494844432, -5.737479077126356, -0.7940913443092087, -6.251083260316511, -2.6354491779886775, -5.610670793347186, -4.483475933967862, -4.387563013010177, -2.684457874338232, -4.687279750335776, -5.695096866716363, -4.279076041501764, 0.11279213949999004, -5.7989630254376285, -5.284371596728773, -3.7413901545514245, -0.5621726718162267, -4.523989015101021, -4.973558832650239, -5.6861454404038945, -4.366633361999028, 0.24361491312345895, 2.8929734831138427, -4.971540864722217, -5.773661011059037, -3.397128114787605, -5.123999562896104, -5.751152933786315, 0.16820169282927985, -1.9555883072760973, -5.00055575741761, -3.0940282386921623},
    {4.5874191771847554, 5.334328449842389, 2.8456389051849675, 3.2400452440096266, 1.9729316061743056, 3.2236034040918264, 3.174013544695494, 1.5248052419028655, 0.05888694101151225, 4.543154413537502, 4.012860621805002, 4.600683342671256, -1.8356840050101648, 3.892549132257844, 1.9216734856552462, 1.195247509885305, -3.5749485793955045, 1.052214389891501, 4.673912319259946, 3.0152335901453617, 1.837631907639778, 3.9737638934478565, -3.0634904314729705, 5.349295251434653, 4.735590139131899, 1.6078364148504696, 4.605294951033553, 3.4795508751664803, -4.068367496783349, -0.4535974633029872, 4.861727280605572, 2.2534531871710994},
    {3.479649934313614, 0.049653317601048796, 1.7693878425972769, -1.666565564440212, 4.69545857614459, -0.6368746420591005, -0.5224222025944468, 4.939306843503321, -0.5854980987412699, 3.2494559533993828, -0.15345975888479768, 2.073395881095212, -2.556726830742217, 1.2944106792418664, -1.588679126978599, 0.536622969371133, -3.3225692007926426, -0.6302271800114446, 3.8135696798594463, 0.8987190739910363, 2.8911157296123187, -0.3702352904035152, 1.7181162477738714, 2.753744832975561, 1.1070405683558244, -1.0581248509659316, 0.34996923929625023, 3.6589306481615798, -2.760531568942501, -2.523266671849028, 3.332884047799332, 2.5160973719955066},
    {-1.314553131556559, -0.9762985249981883, -2.439534212878955, -0.9770123777090431, 3.22444818889439, -0.15885441812788256, -3.280228370568392, 3.05127731132752, 3.023860504896426, -0.3351791819120515, -1.6259678275485419, -3.3684530739349348, 0.9138952508977699, -1.151389673448272, 0.48742571103241966, 2.2883892781062696, 0.5216274539089719, -1.1921348398631877, -1.785810849339364, 0.36242986996035303, 0.9510026327094881, -5.1067934490527, 4.51679046495378, -2.7204244035633676, 0.1316267431212698, 1.52989370264517, -3.4216533126394593, 1.35508346811957, 1.3843903457878584, 0.9856219952024625, -2.160708145241757, 2.194129141462727},
    {1.7772766320732107, 0.6867137999923177, -0.18413602424983383, 2.020391664975259, 3.5115114999389894, 3.5146093495222237, 1.0755765360668246, 3.347618249428178, -0.5550063703026535, 0.4354693236627448, 3.1435047861529957, 0.2207255576493007, -0.6743115722805527, 1.8926180862019533, 1.6119639903713188, 0.8897137666718201, -1.0006136018849785, 2.2154129537851164, 2.253991551157978, 3.390930769406923, 2.1112784421248203, -2.8133052672120153, 1.3343722504167985, -0.08214003234701137, 2.752294771479416, -1.1000690729312643, 1.3060601067468922, 2.8077144983612867, -0.5777864725103474, 0.05920818841987045, 2.142976946980283, 1.310189208813641},
    {5.226089773792786, 3.396167488046647, -1.2810169422885271, 4.92660268781431, 4.661723704410683, 4.592135538854131, 4.759413673921432, 6.266215229888359, 4.508034449924578, 5.203443848044409, 5.163237827181366, 2.973374589134738, 3.5372749817804072, 5.5568805357672195, 5.62486886439119, 3.5607695081792565, 5.048120045555913, 5.0217317503538155, 3.4824021639216265, 5.004048388442662, 5.32720795843887, -2.9705547239752104, 1.4704149779340097, 3.0709414967069373, 2.079509306399164, 4.018696270229593, 3.997027530397936, 5.069106642234751, 4.990416438332814, 3.7260118858245774, 3.8342943152480173, 4.459386673809286},
    {4.844444394711717, 3.0744538979412055, -1.2574931673154421, 4.538496452603094, 4.227362853586971, 3.65356600310693, 3.527933917035606, 6.1017436523358475, 4.460276968323531, 5.467784744062251, 4.569062547005218, 2.543016761057439, 3.6333988364382823, 4.696234419518474, 5.177660967029125, 3.295640865724378, 4.834219098556326, 4.418983560653394, 3.2206850449588162, 4.740665562169267, 4.947616441105364, -2.973676821389672, 1.611276759237986, 2.4165182271018777, 2.2429662044867325, 3.604001235297252, 3.8804598649887114, 4.437808846673289, 4.795447072302221, 2.930492818538424, 3.6340898260318197, 4.107177089053408},
    {2.0701923005612803, 2.268016646038761, 0.0621700823019727, 2.0609129560729764, 3.79973357398405, -0.06709854391937277, 0.9348993650623204, 2.947240969793588, -0.6758313734894995, 2.0965288327495344, 2.6208263647154437, 2.6142355464899953, -1.5070328057777334, 0.9877635394714878, 0.3932801730445502, 0.4851343661830977, -3.6795017458350325, 0.3024355371953936, 2.214270727837147, -0.005588528458173084, 1.8495345769902418, 0.31588739932646304, -1.2897901320196274, 1.481079491236474, 1.282512808861754, -0.7711242641775278, 2.137078137837526, 1.4390488009764304, -2.9431396573568036, -1.2698608100958804, 3.100650099211408, 2.0472579334977623},
    {3.013389766200957, 3.0544413717272434, -0.3450197153506482, 1.8291724328842918, 3.878714870764269, 0.20966588114644658, 1.1122014559415139, 3.521074728174068, 0.1727021170874064, 3.7364864235821633, 3.0625793609423604, 1.6370597282055732, -0.38317102225566246, 1.6265198713063012, 0.13935888275283345, 0.39872959294868726, -2.8781140993801393, 1.4948946024769605, 1.8922070243757703, 0.09380233231047672, 1.9122650797660654, -0.9232934242501838, 0.07396801285704063, 2.987569713202338, 1.7274979437023903, 0.36605825482957677, 2.9312886346865037, 2.003017652683401, -2.1520024575402226, -0.5658406234852402, 2.4620869643234644, 2.148311679494169},
    {3.5863775814916403, 4.906654469515291, 3.31565941304826, 3.1396132137249015, 1.1343460532317793, 1.4370425439590084, 2.774854358935912, -0.36202955662891123, 1.650658570839949, 3.7568487615751356, 2.6912216453225044, 4.104524316681154, 3.2665535144908238, 1.914552476744124, 1.7228792890484206, 3.420663989795472, 0.2828001237961516, 0.4114687203001691, 2.6542281522597757, 1.944951332983922, -0.2434354545779778, 3.88206570298168, -1.7822391628230156, 3.319898816434561, 4.150899499012353, 3.5623796462240813, 2.9458230800267864, 3.099429497423653, 0.8180059154892536, 2.406884813106489, 3.0439997303915383, 3.1103090164850657},
    {2.765583715585425, 3.821425333649065, 0.737867833752866, 2.7755637814127367, 0.7020691477326688, 2.2967793114955524, 3.3842939954606726, 0.1812594684636186, 2.4396116874939033, 2.769202999434965, 2.386163717987009, 2.266037609046053, 3.0469632859269544, 2.0049235584140686, 2.3297589301351214, 2.6033334350537185, 2.9787179774828183, 2.378363112150093, 1.3031063416685835, 2.423149073983765, 0.5262056906060527, 0.701035254834395, -1.4480921493371428, 1.8173608069635117, 3.3134178437223643, 2.9341304056930313, 2.9785406387600233, 2.065330012081936, 3.007044356565796, 2.527155775029224, 2.047312133807683, 1.6575998064676913},
    {2.2073964045972323, 3.576056203665259, 2.075122480694124, 1.626984216205647, 3.007482058005804, -0.5008616445518408, -1.4147958022031586, 3.165639484131564, 2.6524792558950643, 3.4569056825464024, -0.9266004977969677, 1.0816854326118157, 0.8329752427705589, 0.645700518907536, 1.6245312625129469, 2.8657618035354457, -0.540539459519729, -1.9273659306957127, 1.265081490115716, 0.296822913168728, 1.5926062651683137, 0.6560704773383976, 3.6142531510455855, 2.0015698628072394, 3.4042019067239133, 3.3483300895280124, -1.3289319690916888, 3.4631235607026687, -0.49587443973916445, 1.5912907054702654, 0.5260210437056134, 3.079059871770742},
    {3.646839436244549, 0.79497422515139, 2.005548670230392, 0.8747570072297933, -1.4595784617590573, 1.2641987538288728, 4.4025372102344225, 0.1877327276409257, -1.2610597284240852, 3.0749058203149677, 2.0386571988704367, 4.727732928039955, -2.806643817726871, 3.8414622344856295, -0.0863013062142389, -1.8519715527904446, -0.7640717859462414, 3.351482463836428, 4.068065636297644, 1.586942652166188, 2.688143599777635, 3.812935730094421, -4.776246209541742, 4.906491097460956, -0.3833618026928426, -1.6753766502989549, 4.783749444169183, -0.19375325564079532, -1.9056282194943932, -1.9236555012522343, 4.577204532315697, -1.5963735337650875},
    {1.384942460269075, 3.4827448391059255, -3.7011669874503657, 2.834049695376737, -1.0752968239252603, 3.072942988141407, 1.9826531780866254, 3.193252281735774, 5.10506308868623, 1.5212685690863361, 1.3820466969496246, -1.2907570420789671, 3.99654823357375, 2.130948288616153, 4.40822474906818, 2.8585718006870153, 5.3512571138805045, 3.1730933457263513, -1.6629979569344664, 2.0353777082217768, 3.204761078598465, -4.152087158522236, 1.841786852243596, 0.8803038935777294, 1.2278696878700894, 4.608693224140957, 0.9218675005687261, 1.5567251913186562, 4.323604319168662, 4.043314411300963, -2.7884774313053784, 2.243079472544659},
    {-3.0470918407406695, -4.31255485524593, -5.657215553237405, -1.8257363989835584, -3.988709988756741, -0.7967963965921282, -1.2519511171000806, 1.7019645128545746, 2.7964197472396997, -3.176212640851646, -2.3117478732205834, -4.8635216114862025, 0.32252345933748316, 0.4020061469325354, 2.4392532532744666, -2.6095876676316254, 5.558535550118381, 3.9796914005493247, -4.624657834938039, -2.3090565567450163, 2.484220279102788, -5.70314193559351, 0.10686756390321904, -4.08862440056955, -4.8582512300050125, 0.11323309899161833, -3.431575565678338, -3.941634473346078, 4.000912026788483, 0.7419451531756323, -4.63942010007065, -2.810438098549132},
    {0.09335124289394457, -2.2813189310105733, -3.7090446829999193, -0.9733535278763442, -5.159708019483767, 1.403366054563872, 2.6644545920750784, 0.5428644396797244, 0.3661162158249294, -1.2693749390483138, 0.936755019051648, -1.2957625581202838, -2.022741439382991, 2.5688449993962457, 1.9412082575265057, -3.3843782892420604, 3.801467680435189, 5.753886992609661, -1.2263097012210464, -0.8204739020240495, 3.520580792709142, -2.2697735386985443, -4.085448012516856, 1.769991790150425, -3.9392691972595926, -1.3936659842648316, 2.476715317844554, -3.4434873318711285, 0.6342595964017864, -0.7293378565425485, -1.4981867884841267, -3.229614251722125},
    {0.580179300801398, 2.4414760435818383, -4.4183969830624, 3.9469567009155453, -1.274351841331712, 3.472901528337891, 1.9793827103315136, 4.029760641731461, 5.842647038643481, 1.8404661207944117, 2.373407717729521, -1.4305790758532295, 4.970546357948535, 3.660070448067191, 5.6284755728515385, 3.53639899662728, 6.310903435485635, 3.7153155452480098, -2.12157563480469, 2.666312306679626, 3.344608429079393, -4.914902139501208, 2.9095941308861404, -0.12381734355694367, 0.5177467149320638, 5.581870544038733, 0.9869110228783569, 1.8627887393864733, 5.3662266908614376, 4.5843938509124555, -2.1768909469499613, 2.7870857347638838},
    {2.0299095706514407, 2.8989726203049804, -2.7835106943439603, 3.265410354003867, -1.359579835220506, 3.5290201602254205, 2.8778160099710317, 4.267896838644473, 4.877134195012911, 3.3143499538552157, 2.503640286387048, -0.23534580400562088, 4.51880202915719, 3.4746577451867524, 5.054097747883447, 2.9024748717061586, 5.8484782659195975, 3.916278240785173, -0.8010075296439055, 3.0612048607557747, 4.0522955491505845, -3.5214231457244236, 2.2050752073687074, 1.5499154684901688, 0.725592850919472, 5.171704835079713, 1.841284480812297, 2.43741754291605, 5.698343936049523, 4.4626677215264445, -1.1363523063550582, 2.254015248777273},
    {-1.7776684738771973, -1.043773790638085, -2.1739990712125468, 1.2998452323032517, -0.17111943582326544, 0.17243933611418888, -1.2057636653104375, 2.971222007795296, 2.504976810103508, 0.6146184289666936, -0.2635298823098829, -2.517363677547089, -0.31616729700972956, 2.2472804212967517, 3.391286080753329, -0.3298396484214934, 3.112855027723697, 0.5291783810768895, -1.5735435101568347, 0.24016244326873823, 2.1124090179970274, -2.8721044367262656, 2.035610023902067, -1.2495689689770628, -0.9182611249897763, 1.6205150852704568, -1.791494794643402, 0.791981023229633, 1.646448985056444, 2.2525808378508065, -1.8216954943099577, -0.36286822737366},
    {-0.8932114063466611, 1.319272331827927, -0.8645343312326212, 1.9457726406733487, 0.056308764307139554, -0.26072197537567526, 0.02399215488655604, -1.6538122378862006, 2.6150307551219774, -0.11909116095555494, -1.3938168314773425, -0.4824376023214172, 1.1579059062625228, 1.1742213877616752, 2.031513552934745, 1.5234418744743587, 1.9226112227784835, -0.05727812799707143, -0.4977348806755744, 0.6379670246105044, -1.4548256991627475, -0.8017671326635876, 1.7243095332278144, -0.6022578555967404, 1.4682171005823816, 2.5075095359515243, -0.6426441920419138, 0.7471944722356404, 2.4830256007617506, 1.8917082779565848, 0.5055361597322405, 1.1181918304219662},
    {-4.204214902970909, -3.702722125870987, -3.3009193106446753, -2.7066675021847852, -2.572694535335137, -1.8363095103810934, -2.819460199581438, -1.8523707876587474, 2.1350345000967565, -3.9310674256117144, -2.8413698782568706, -4.448744875660654, -0.7724692334052552, -2.3878824596537527, 0.9218336394329317, -0.5046781125847433, 2.4538246890337336, -0.48876301023107044, -3.2730182249122985, -1.553379366746394, -2.0443437243058478, -3.7183634371642675, 1.9987757609851415, -3.941511515821767, -2.6321071507538347, 0.3566315866657899, -3.854295770962091, -2.5984927057899703, 2.0311076702685438, 1.0657880164261004, -4.087663213509727, -1.517903053472331},
    {-3.427488497097679, -0.5343781333197317, -3.8921333558031863, 1.3728499210045702, -3.787822657007433, 1.1796653033737081, -0.6992649220793797, -2.14832073721062, 2.9141148835176973, -4.1869822553876626, -0.7564577326161815, -4.085493390977541, 2.93462058236246, -1.0827135905789265, 3.0371113926553512, 1.1384410480981964, 4.734715293570753, 0.9632693126354632, -4.3720406912624945, 0.45316874018250564, -1.2058230297099546, -4.022070787306527, 0.43610500064766294, -4.190478613338688, -0.07899461631857313, 2.3478730627842275, -1.993957615052441, -1.755240462021111, 3.9601501662059393, 2.7977154030229765, -4.614428023780129, -0.867545251590466},
    {-4.343819224529475, -3.429447722071614, -2.9591349405638305, -0.9687392356721002, -3.172462840167441, -0.6771223723357763, -2.9203920263162018, -2.2071830047417964, 2.2510565343394657, -4.226030773893664, -3.248143643594161, -3.9256402506216754, -0.4427717888551467, -2.6170357346854085, 1.8111975304731083, 0.40935732808504816, 1.6898710440409204, -2.070285320372312, -3.2450379699339837, -0.03572071084908996, -2.044736401265713, -3.193545137018672, 0.535996678975191, -3.6919721408964077, -1.7354393077164352, 0.8629270978570688, -3.5727262657481855, -1.6148195640475222, 1.634213894982249, 0.6640431397424392, -3.7192960300625075, -1.1799273478730226},
    {-3.794754538975758, 0.8080483353090694, 1.0459676011074945, 3.0261029891992375, -1.088562498752473, 1.0168392281087948, -1.9486188754826217, -4.423528880901797, 1.6619590614666113, -3.8572288488459083, -0.06841246427622696, -2.456041369620461, 2.280992054742954, -2.047623754582853, 2.2358231313322965, 3.2403188531383833, -0.054669274270909445, -3.648729976356474, -1.7767033612898273, 2.101662294334397, -4.000398656791871, 1.3219918704633935, 0.45255940381360565, -3.2445328148149546, 3.372007055533113, 2.0237459472661667, -2.4569362383817874, 1.260920124017885, 0.5775272858765155, 3.697465790530394, -1.908483047594098, 0.4379877709601634},
    {-2.0698501757951195, 2.6098642553664093, 0.465132049498218, 2.312510219704952, 2.57285470986735, -0.5158713561063848, -2.644618448224949, -0.9480086507136976, 3.848750032953298, -0.3576402432242082, -1.9748354685002458, -2.7914652855710917, 4.859168903636973, -2.7471127219963476, 1.5440857053303465, 4.668279528449133, 2.3812069409603356, -4.0816773998672975, -1.9909726302199888, 1.3611350685854975, -2.871024122905094, -0.7024650409333558, 5.003297760650848, -3.2112459399965325, 4.051548589011716, 4.458382475982687, -3.444714964598374, 3.0583316316788216, 3.6762965649786796, 4.861643705220775, -2.1760298560677334, 3.5922833171497888},
    {-4.060272765946266, 0.8912422355370343, 3.189117839607826, 0.49032104194109866, 2.086678148768177, -3.1177680429206176, -4.854891753574242, -3.6820475640253965, 1.3673868972939878, -2.4455694554967846, -3.68486050223109, -2.9980522655496875, 3.1299366629238423, -4.663566350288794, -1.9257199170076411, 4.100450536531813, -1.5944806770387046, -5.556401207872891, -2.708450830243557, -0.6763623691267038, -5.080773215681058, 1.6563316292809547, 4.561325321684365, -4.501693813917932, 3.401827225014167, 2.0699122887404595, -4.795737954871212, 1.614333485115559, 1.0958272804197133, 3.919104985119986, -1.9751094972449401, 2.1799854082040033},
    {-5.276359373890695, -1.3193471490297042, -2.3823715905767546, -0.17199789209921926, -3.0781440974080074, -2.377658872489712, -4.666960217766696, -5.3879248370629105, 0.8824780570704928, -4.925088637231732, -4.302494781787212, -5.1952979450693055, 2.5591160593647, -4.352767981042207, -0.283013472816931, 1.2463087737491416, 1.0087619610135703, -4.9797138094060465, -5.399253103645298, -2.150300771511754, -5.051043717036155, -3.0956964919193504, 1.6696562152923342, -6.055596564387517, 0.23063568257517514, 1.4086445214966545, -5.746207136390238, -2.7122159675255433, 2.4127241856228148, 3.1486691778255698, -5.071169146833638, -1.9754266030565515},
    {-2.6940681858526045, -1.008513821146312, 3.228117542312086, 1.5156921429875663, 1.6269075208400388, -0.8666406309450793, -1.9675249173184082, -2.5573025774891467, -1.0926910963025607, -2.333321069050771, -1.611148790116458, -1.322574046895759, 0.3732158758673491, -1.6217152365170888, -1.6795058340336233, 1.9028958372884872, -1.1876667107539876, -3.2101829279995795, 0.2011578066451436, 1.9438843379137047, -2.860372239050746, 1.820474816930815, 1.0792246377749952, -2.7620157615278242, 2.8323736167155507, -1.1372647440873025, -1.832119201320749, 1.399264496841909, -0.6773962929948696, 1.494356755345609, 0.3749176520743178, -0.19424453410991707},
    {-2.626654849431723, 2.5706203943435812, -0.4213614357472022, 2.9017566271776767, 2.1285891381065385, 0.12383102614127957, -2.0167887685038433, 0.07398734209722573, 4.578033406925765, -0.43837541895485804, -1.2588991267903276, -3.97170540963704, 5.075809976911645, -1.24119366154125, 3.1595995686188263, 5.009586503040411, 3.632239049329029, -2.9917177253577676, -3.438038051581804, 1.576552708687825, -2.20537242784731, -2.8796759087429904, 4.999151186143949, -4.378773962701081, 3.9378919047072984, 5.001836201674699, -4.40362763040854, 2.933768807846785, 4.570388399886588, 5.072742298676131, -3.6959369753206173, 3.2819714273578366},
    {-2.478521877210736, 0.9375546605458331, -0.04692089751723247, 2.4729957401205684, 1.0774837345082715, 0.7728239356697949, -1.6789153513963548, 0.5699905580190925, 2.828947157816603, -0.7768902935624299, -0.4257444563575101, -3.8387543741336985, 2.554884243838112, 0.021756298070820145, 2.7808050147675285, 2.149785560219662, 2.7363548727220555, -0.9334491428295962, -2.7652041863681744, 1.7205167944340083, -1.05991096511327, -4.2478098103285875, 2.9829026732859223, -3.740246911255778, 3.202480825835225, 2.798465035209386, -3.126095531365449, 1.5854406910882073, 2.6793057132022544, 3.4128903993900854, -3.162850201308553, 0.6678582701680875},
    {-5.463718218051347, -5.210757626139068, -0.17086410086054601, -5.396104445446753, -0.8197793575302401, -6.738529966461108, -4.848174990702878, -5.851390425431488, 0.7007231788745564, -3.60739153481158, -6.295301189795537, -3.925107125689263, 2.495461842743579, -5.433135295835848, -4.365448094520734, 0.13769578642845473, 1.8406401212161576, -5.5546204660792355, -6.572204578950324, -5.414376077020226, -6.409681218366101, 0.7563986190896653, 3.1054563697024857, -6.59595589144316, -3.506839603979182, 0.7249329789104523, -6.527184115050826, -4.841460875992855, 2.4021076600367857, 1.6662981330995024, -6.685810251755127, -0.23701281313232936},
    {-3.4844098721853842, -3.7447751524733266, -0.20684304355099112, -4.7868044185984155, 1.1555742580481458, -5.866518480709469, -4.390360472293256, -2.972405371091287, 0.357587037039857, -2.164785229490533, -5.576441546967489, -3.573422209595407, 2.099774191232873, -5.25179530394405, -3.914132332496933, 0.6307739439833042, 1.0718974083106185, -4.978577450902418, -5.252710041236381, -5.756197991190131, -4.883393552723751, -0.2617974295703514, 4.0015916765504045, -5.314345962626863, -2.0894680468756373, 0.7798374485010846, -5.891337828628976, -3.5495883054852175, 1.7915121540010484, 0.9049566462371637, -5.078416294072745, 0.8566731900242424},
    {-0.40827016116183934, -2.0777685517513595, 2.400098775146844, -4.959923978206185, 1.8065493034299367, -4.9321506486146305, -3.1941360036884427, -0.4087185598384396, 0.6028727667038175, 0.18699484420670712, -3.979694273883539, 0.7950650296080279, 2.582797560626691, -3.9817826242395267, -4.647259361051047, 1.0125007136524993, 0.9588917578035132, -3.5806583856978587, -2.0797320975591678, -3.8419730565010464, -2.733476817945234, 2.8569707391735326, 2.6609654319143927, -1.7401907827826897, -1.7981999468418226, 0.7758318168429119, -3.766849539106628, -0.9379332520678985, 1.4467627627399784, 0.6372457011944169, -2.1752867362118895, 2.045361375121917},
    {-0.8298837968235914, -1.7170813564218057, 2.621626518683544, -4.189594825430289, 1.7450462792679746, -4.234754917875107, -2.9397397398001974, -0.7895269379565614, -0.8047197020396111, -0.005696832866726355, -4.278932200854543, -0.21702229672970821, 0.930318680278536, -3.368596914896268, -4.520706538040199, 0.5435824749244174, -0.5695865180588799, -3.397632650855585, -2.530590479657245, -3.4405824859680503, -2.3503867657280817, 2.504054300506531, 3.1648315466965626, -2.0319309919638298, -1.5581898518515394, 0.21743787383339355, -4.075645183931729, -0.40559127492184194, 0.4874659742239534, 0.21486931652986133, -2.680066704670037, 1.2226745015235192},
    {-1.865433980563924, -1.0981089713629015, 2.5274838108356628, -1.6784200431036587, 2.501275649856226, -2.8064626739586886, -3.3034793849824076, -1.047960354178072, 0.7466408198789425, -0.34970812334626805, -1.7075585559072823, 0.5589554591390138, 1.7532478099144506, -1.9187691961046012, -1.6334676502973973, 1.957769589224911, 1.407261648150618, -1.766208699437868, -2.23653049975857, -2.0741380204857798, -2.657510319031275, 2.316872936026344, 2.6763617876461896, -2.5052770785196588, 0.5571009379538079, 1.2680508796608563, -2.610720086252996, -0.28051619825843344, 1.5779151527041888, 1.2690415090594636, -1.4378127895161112, 2.503793735662593},
    {0.23466782453198196, 0.10633220395340794, 1.8795538744469167, -1.0243766310479843, 2.4404865678746193, -3.147079060826571, -1.6364181040508845, -0.04605593165383102, 1.5623099749407043, 0.5794847474815213, -1.6759102057597912, 0.07591432412106046, 2.951344159884559, -3.225695224479808, -2.4301544404831676, 2.387319124023094, 0.4870792596311214, -2.2382383662624683, -2.282129662878144, -3.4921973881836745, -2.8551332913115544, 2.617460684367927, 2.8838054652659455, -1.9055758389763913, 0.7257673493249417, 1.8233938770835296, -2.7864753522476833, 1.15431269913569, 2.121965815539659, 2.6945092836588125, -0.832353384123192, 3.096271830476183},
    {-0.19046494586020826, -1.1336854674894306, 2.8910535726609305, -2.158617858774257, 1.763405234021389, -3.5576240353173927, -3.125046956165389, -0.05241890089612816, 0.923667012104277, 0.005021403186385491, -3.277915794273513, -0.340574829850283, 1.8581651496345704, -1.3143649684380476, -2.750341804935773, 1.0445078255031364, 1.2633562473145916, -2.0219541024841523, -0.42585474202412504, -1.6116874349138073, -1.1017124625772872, 2.1213438929438957, 2.084813868505043, -1.2739955030991894, 0.7941818415804138, 0.59216073503676, -3.205814007368267, 1.5812761768702501, 2.3466338697043723, 1.8904481624329912, -1.6127682845139817, 2.718686745691904},
    {-1.0924920332165404, -1.031348374878959, 0.599334837932972, -1.2270958084905526, 0.9399706528167847, -2.250992844451218, -2.885838120570158, 0.8637963130022225, 2.189333489797271, -1.605396747717887, -2.2729437976458757, -2.3677509139600414, 2.148961058105821, -3.15996199602779, -0.8064948678820478, 1.03435808586556, 1.325596070846053, -1.2922896481295987, -2.9301926759152006, -1.7010592778600613, 0.36626703698873575, -1.7415663285616083, 2.7337397730856807, -2.592447457521303, -1.2437287473958645, 1.0714464042263017, -3.4932792310225023, 0.19209048865335213, 2.5679239041120856, 1.3275562949581656, -3.3125697696488876, 1.1120078207619464},
    {-2.0695490562915637, -0.7671088543390308, 0.0069885900871525415, -1.1259813496959508, 2.3836394930949334, -2.9003384451002843, -3.141374798421169, -0.8009072837961406, 2.062524257523301, 0.12301344869598171, -3.0172070057300555, -1.9146350767060443, 1.5874728796656332, -2.5684894546152206, -2.1895253456470773, 1.197600746560923, -0.2886762454966513, -2.120536582575497, -3.3376035255054903, -2.889276546402932, -2.857949544495182, -0.8068390133597194, 2.748649499362694, -2.635273164270364, -0.7462893903754996, 1.0506936224188619, -3.175150639973125, 0.06264137486097297, 1.3583950785438845, 1.9045163128063587, -2.676952333884322, 2.1952401248330107},
    {0.04735249839122543, 0.7055688031180641, 0.8001046029414085, 0.04742564395719765, 1.634870435039125, -2.287039313317496, -1.8042316758404566, 0.9981992268687677, 0.7226061965543387, 0.9692242138935314, -2.303044108832584, 0.08380869542244565, 0.9787557253904601, -0.8649639521586823, -2.3322757230638445, 0.5993505407292693, -0.522752072068897, -0.9159277695240939, -0.39531503563596765, -2.6705609818105738, -1.170822568853307, 0.22433681078399828, 0.10914879742399805, -0.7762203257806624, -0.763366709281445, -0.24978842395903914, -1.4608561361700718, 0.5686616933590493, 0.5149198941414367, 1.3302080730401864, -0.08178666302118014, 1.2607580885175373},
    {0.9829345025518588, 1.0289966932159256, 2.1773889936560806, -0.13947029706663666, 0.38538607449509416, -2.1161777857409585, -0.4076403785335054, 0.2617658458572884, 0.7959660872898795, 1.415483371791305, -1.7538407487740622, 0.719653900127566, 0.2927337158089856, -0.9886820683412768, -3.149783526347709, 0.360379682168946, -0.07184426831904572, -2.4599243234050903, 0.34239088607918317, -1.5642977419055064, 0.6364703159855836, 0.7312940619206635, 2.0255593293719922, 0.8876929941932086, -0.21929536888483717, 0.6262373921432649, -1.7667570018751313, -0.08909934631741682, 0.21399361428823152, -1.4033348468852416, 0.30130933839863966, 1.4308305172502698},
    {0.6429819113589654, -0.10837267259960022, 1.9320651877866695, 0.33762069221304813, 0.3069045188031289, -2.3112847427645953, -1.4464016012708736, 0.9186953900388063, 0.5113724781505302, 0.4016640038165647, -1.0744517175480712, 0.7502024532112528, 0.4795542617827876, -0.9926295076469804, -0.6849889221472623, 0.7789305110638396, -0.30218282148209935, -1.57220318526206, -0.1630413311600434, 0.1431103449195844, -2.035401661454637, 1.3089323112637554, -0.2954998073088658, 0.16206431607505437, 0.8097057952063168, 0.04951940914158915, -0.4586387591445935, 0.21328735369112486, -0.7304631479116885, 0.08511545458361716, -0.6532396827936546, 2.1375507187428275},
    {-0.06996985366562124, 1.8137146584186756, 0.5576266141225473, 0.889367736161742, 2.788069122985399, 0.6830955853830063, -1.055137064651915, 1.7028427885470723, 1.991798037783113, 0.4594719116566862, 0.24553559418392776, -0.05004724532485227, 1.776623041741099, -0.14471935086639195, 1.0373239179368372, 1.7587257964516712, 1.1806437253622435, -1.4363470880416058, -1.64346218632483, -0.7963632345349084, 1.2761189068613823, -2.048730096580228, 1.8527013495806028, -0.12609607266365236, 1.396120339992388, 1.8184939290793667, -2.051643116136389, 1.6290377455650935, 0.951592186124711, 1.2362296623508118, -1.8162027301134742, 2.331343243916582},
    {-1.867066900892329, -1.036958538330821, -1.827470725166614, -1.3633285908423656, 1.5831225985279942, -1.095626538780101, -1.7976871491704531, -0.5617632909270772, 0.45504616454466296, -1.7876828151195856, -0.8329684393032741, -0.669225729181489, -0.0024642859101440488, -1.025247388389425, 0.03017588755403612, 0.5136863268171068, 1.3068734331386123, -1.5745507782092294, -1.4791221481138135, -1.525726153195498, 0.43785978754831356, -0.3449912087450801, 0.28541165662522366, -1.2791677773059185, -1.5918115469909084, -1.2469915441415729, -0.9520984548766711, -0.7850213602765216, 0.19953939760543637, 0.3125190724331985, -1.42377730460919, -0.20949476934253553},
    {0.44540868394147554, 2.3456786950719306, 1.48163834229899, 0.8758562152021279, 3.353243588542117, -1.1446874754407186, -1.0275701891741966, 1.4386665999147152, 1.9785355516076149, 1.1516185497521079, 1.49092735687835, 0.7938156091603766, 1.0294571914716266, -0.5989081808241661, 0.5533770784536541, 1.1668711093061692, 0.5738477846885733, -1.3787399505243363, 0.7105552803765149, 0.2829406764463351, 0.3677021007509014, 0.46700344158593016, 0.2872061662667018, 0.8231058388806377, 0.5723796696534096, 2.453458082818098, 0.3322805903447764, 1.5542114345510794, 0.10356153082501596, -0.14533842209139883, -0.78476706276196, 2.3864433975627364},
    {0.8231040011470826, 1.2863835922779956, 0.3190201948105288, 0.6872594908620098, 2.7449660352680105, -0.7778115551667931, -2.0912411141919693, -0.0006374198071346221, 1.2934362746021104, 0.8231261229832063, 0.15557417261001563, -0.9701630710635211, 1.8738394933380151, 0.22585230551204158, 0.30110247917598654, 3.266419053152009, -0.3629956954725974, -2.4286686890113525, -0.48624369725327043, 0.43216762034591905, -1.117343963677136, 0.6125948118318112, 1.8251133383521805, -0.3428869056036889, 0.7702951649105525, 1.8805527925973546, -0.9007700580995361, 2.646245619308663, 0.3928128264300778, 1.4693912407866458, -2.280231306553055, 1.8332676672440091},
    {0.3810197369741558, 0.8581054458147847, -1.277715471161209, -0.32437516943934547, 0.8304800379302123, -0.1913719512530635, -1.042573453093351, 1.5113499780904498, 0.5090382605010872, 0.41299613691500764, 0.3487081016215892, -0.3049412903695606, -1.8976274164905784, -0.39797158937763677, -0.3448652559611938, 0.7085931226689729, -0.6107728783324726, 0.2416193356927597, -0.46226236703834983, -0.504653856443143, 0.6176265717182803, 0.10512721887729772, 0.37447712186473336, 0.36704426973578164, 0.3122911896687057, 0.5634794398416443, -0.6961777998304175, 0.3610623935768465, -1.2931927686743996, 0.011148171886441247, 0.19311764958856067, 0.6057187726212672},
    {2.063786133020218, -0.6293108717282697, 1.9727133958425969, -2.0617280526992006, 0.6073290609833555, -1.7885729503940615, -1.0454066207440225, 0.8052159095483487, -0.6164182251927899, 1.9149329616494088, -0.4434055290936285, 1.0087283062739696, -2.336698988904451, -1.5627092674843879, -2.51086655766397, 0.5925638148486848, -3.3024961029031203, -1.5143229839003345, 1.9140507717716584, -0.6447711799233841, -0.6552875715766104, 1.7025404132983084, -0.7373827358765755, 1.0653155071598817, 0.8497680949850605, -0.9128365824870915, -0.5809238236015021, 1.5408675916447525, -2.8946947256226645, -0.7903861751927046, 2.017993092673062, 0.3875775583859595},
    {2.121024393302544, 1.316485519692907, 2.361856209481943, -1.4094382495455324, 2.284848186077256, -0.3307027119024177, 1.1023785655931206, 1.9432994825650367, 1.3900546802436624, 2.1896868339405917, -0.10739272218861189, 2.642558275361579, -0.7836823196003767, 1.0920969347562381, -0.6461379722588658, 0.6075781094712517, -1.6422205213713308, -1.0035242427897846, 1.881216033022552, -0.7563113269800247, 1.6538677369351613, 1.6203941340994892, -0.16255914153414358, 2.6954698166788713, -0.6642984961713385, 0.5478185452188956, 1.1290605587636793, 1.1126757624209722, -1.480358538511363, -1.0627965675450637, 0.6791031078211236, 2.01136011439555},
    {1.179965721963597, 0.04098396290135962, 1.24414730805487, -0.2317531444169561, 2.1925814055343964, -1.204254164547136, -1.6544747730045457, 1.1593884594730517, -0.8944904656454239, 1.028190917870458, -0.6776342604081377, 1.9424644546961247, -1.4240459733959436, -1.7886774773966314, -0.7458984794798663, -0.4276995176054057, -1.9493013423992205, -1.72187412793534, 1.8997607114109138, 0.13220528484037286, 1.356117151167621, 0.5561434436836177, -0.2437824288708777, 1.6496371618984844, -0.20742239049721986, 0.6426228789494877, 0.5361322882006867, 1.0871165139817403, -2.4171242658336456, -0.9033157739187566, 1.9811658021051506, 0.8141400170204561},
    {2.0619031915939927, 1.6117318839418147, 1.9929096898459517, -1.6751421109196074, 2.822845944253251, -0.7377966851285956, -0.5532907068982119, 2.4821963005012786, 0.9439246764946819, 2.0917135306264405, 0.7634097968725989, 1.0765422567442602, -1.5900270419825082, -0.7911089817105952, -1.47885012930013, 1.944590153310352, -3.000524111988401, -1.0721259415087112, 1.7471829905858134, 1.304739654588511, 0.4771282595831712, 0.7672953884440421, 0.43306922455505403, 2.6443994191174967, 0.8934693901214703, 0.48404826355555114, 0.4099952465322454, 2.4446908000659073, -3.604514809304618, -1.9363725138703989, 1.8955551994919357, 2.4717847622375224},
    {2.7888770058214445, 2.15586968695876, 2.1844788233481136, 1.0822655038723266, 2.2354875316006377, -0.44815616236899286, -0.8089855112597888, 1.65925043786053, 1.6218505182153238, 2.570566872454701, 0.9368085559187533, 1.70299804580891, -0.03552066751118772, 0.3677323502042406, 0.7431325918556008, 1.9285074014604977, -0.1788160274722643, 0.6085570703268519, 1.681468992739928, -0.7605706443542595, 1.2430911939179807, 0.683225583038569, 1.7108730897486297, 1.5983035217810377, 1.539456480711495, 2.355322512228386, 0.7972436071911299, 3.208472182937317, -0.6763350012977871, 0.24223082388406963, 1.6040115720412544, 2.547093886181181},
    {1.7191619550271315, 0.9796910647867075, 1.5391879631698262, -1.194347674737508, 0.04651684804145778, 0.03130495287435803, -1.8719934421411835, 2.003564317639715, 2.1742969877350418, 1.5550321688218458, 0.2965677232738424, 2.1179093131887394, 1.3480062310794152, -2.0426349360103, 0.21685068744080752, 1.3777111547354033, 1.1375350235047346, 0.3649110074744296, -0.05213403353656608, -0.6561299950632601, 1.7346281238941121, -0.6562200533801784, 0.4406347714915907, 0.6955017162194275, 1.2990930644306835, 2.1696698687222304, -1.0035908984202475, 0.7364011857067125, 1.3613051804841714, 0.547259937369665, 0.9186793766960617, 2.4400496524172572},
    {1.0190967657348584, 1.3169132071066294, 0.9608306199347003, 1.7526440173451483, 0.26751770018978505, 0.6391792804861822, 0.109052525201621, 0.622980512315674, 2.831041808208021, 1.284945745495547, 0.6374675342531749, 0.008390610081318889, 1.5752536971816786, 0.3369062371583557, 0.17337948083232807, 1.6661217542553304, 0.5678048796516532, -0.30969665867961826, -0.478028200887072, -0.7875851674661484, 1.1454409283472238, -0.33374213277770276, 1.1307666845134325, 0.4890633038189416, 0.48416114014301437, 2.2966223116397164, -0.1333840639056242, 0.8706640265115532, 0.8396143200625007, 1.421216196048111, 0.6657252031629469, 2.2323028902308812},
    {-0.6919061519583367, -1.2917386640091408, -0.4735824953107947, -0.8562271828843241, -0.7083395471352574, -0.983722138021401, -1.2293826046944267, 1.4637081153947709, -0.058663080379770145, 0.22630319149337988, -1.0368652731866081, -2.365208567399823, -1.0178986371264254, -0.882866528551827, 0.28850264026644884, -0.05425162865604697, -0.3477951342404296, 0.06013957002088558, -1.8965563469471802, -1.920083333186043, 0.8081795990185201, -1.2237335666249485, -0.8428836703461574, -1.4086770803857984, -1.026643430906141, 0.252416447885929, -1.9501888732126011, -1.6705074316782627, -0.8499685160646026, -0.8639298770560485, -2.551510874311497, 0.5543123717668462},
    {0.3464297561784443, 1.9853054539148833, 0.4881333456154248, 0.31669657359340964, 1.9847314274388799, -1.4481849912128242, 0.5817245290707117, 0.20000074293462672, -0.03483478541100464, 1.357604963595651, 0.8914907808586394, 0.44517578482077125, 2.276900807129483, -0.33575092232128184, -1.3234191302853924, 2.566828248731189, 0.5049259074091101, -0.623754655101943, 0.38820603647140983, 0.5081423176158207, 0.27057701604226014, -0.45370835603190895, -0.026243327163262286, -0.1572925555113656, 2.407343970265179, 0.8821961019064004, -0.13647179019662525, 2.58214226687956, 0.9477805417852022, 2.084738251677329, -0.07768716171501477, 2.6241407540105968},
    {0.7538109670244899, 1.0193000058871462, -1.7708123635681188, 0.9793742439554146, 1.0618425385825176, -0.7662267190027853, 0.5813985972193402, 0.292476148618799, 1.9013589220161977, 1.0147906186391125, -0.7342820912195697, -1.1249079184255129, 1.3252057462858198, -1.167703440991207, 0.3764591708291464, 2.086443258563736, 0.7537008089995834, -0.4600079204581607, -1.3064876322829073, -1.1708219335085892, 0.19959937119418786, -0.5014752252901965, 0.6826418223930308, 0.21560543291327647, -0.697522812184557, 2.328264259882474, -0.5242321218877238, 0.14398665979396308, 1.2740993821948574, 1.6422009700616835, -2.198975250675528, 2.092176001922591},
    {-2.0414685173268574, 0.8724193842876449, 0.9756424454392014, 0.6489886253265451, 1.84348960728569, 0.7237303361720714, -0.2890121013516659, -0.30724983410178924, 1.8959368724751562, -0.8878869176434906, -1.6761773106682285, -1.20684257043911, -0.4706659388200529, 0.9733433406518726, 0.8924168319626112, 1.7809304073937287, 0.172704715221585, 0.3263130821981838, -2.542668840527486, 0.16122502983769446, -1.9564594711303231, -1.3706444830755544, 0.18372001295507834, -1.4621901715469898, -0.1459950315126989, 0.6630189885963594, -0.6522704181228095, 0.18948742129333898, -0.04735954109909046, 0.7904731862643333, -1.4515588560692498, 1.5324581225929597},
    {1.0803548100061506, 2.419786653841526, -0.12384050976342284, 1.9671011204059459, 1.9566061944876578, 0.08855746290296992, -0.2577445389093502, 1.7123069512700615, 2.8518075435908354, 1.589691946485576, 0.6530574838954584, -1.528230749234723, 2.11824573751482, -0.3510168409037017, 0.4909185040106607, 2.3105444108360493, 1.0134407051732202, -0.2983157592893122, -0.7884368724568371, -0.6021407755866351, -1.1315139669550855, -0.8234605547722641, 2.8637938661283715, -0.838542667288866, 1.3210622281443913, 2.418723821145742, -1.9896933777065648, 1.975571700589578, 1.89023831045233, 2.957555688238621, -0.959963898422515, 3.1209240477215827},
    {0.5688342343120545, 0.37480852872026, -0.3001274801493053, 0.683191237466225, 2.7931889052789485, 0.11766179041216002, -2.039237039982442, 1.454737078512416, 1.533511209461064, 1.3280013122171763, -0.5855453404192998, -1.2524906302757783, 1.9484166870807116, -0.02381142321730328, 0.451305457370057, 3.631654896333597, -1.1596642042234022, -0.39189481327592746, -1.1728193771495423, 1.648195322385053, 0.2757360572262476, -0.9474130944339036, 0.7849613253685374, 0.0011879038294359278, 1.9261477977693027, 2.0185513949995726, -0.7014731151793968, 2.5250383611597016, 0.5770951474488932, 2.6822081133802285, -1.5210277713366736, 2.768973048118036},
    {-0.04386500581655654, 0.984959884413092, -0.9003884658032176, 1.1822442857670679, 0.18463604416114057, 0.42778141324208596, 0.908186914843999, 0.6504231594084157, -0.28859498940535405, 0.5701584090273037, 1.2660886433501004, 0.20788981100262183, -0.6143497068167505, 0.8580246020083906, 1.5724660784033095, -0.27976575261169956, -0.006406575867580951, 1.6124638486708849, 0.372684523561315, -0.29551050251932476, 1.0543380554779753, -0.16777541262202902, -0.7077091999485953, -0.6293265044819765, 0.5526881672145775, 0.3629134072811904, 0.4084854244366463, 1.7851048408607006, -0.28308963425695016, -0.43935199251638635, 1.8233273446554226, 0.31338467431798217},
    {-1.1328218360275963, -1.2024886503745245, -0.5198243132359505, -0.2998193976883739, -1.2935507910793802, -0.7035498719840277, -0.6939025978439446, -0.26916563783163905, -0.10944170704303055, -0.4967023310209711, -0.8788745297018568, 0.4322764192072, -0.14236721145900788, -0.7499377660650868, -0.9726270021454413, -0.6208982361961103, -0.859259933874534, -0.3778178233788142, -0.6690878354864537, -0.3703137994493524, 0.7338849563286257, -0.39021244932023547, 0.3315026840455743, -0.16716029672536648, -0.5203042974933572, -0.2965624825840249, 0.14171193790308706, -1.082761323301987, 0.1985530301355926, -0.13981974622952426, -0.21344460276721292, -0.6515283755118785},
    {0.3658578489168243, 0.2539502885140326, 0.8549321921227518, -0.1054745093888461, 0.05116779203441191, 1.1744501136408738, 1.3044971223189905, 0.1396517575947566, 0.8398367919257729, 0.1423122505699786, 0.17470259029042257, 0.35738424666226026, 0.2470662754001457, 0.7275526466334484, 0.21446565978408066, -0.1610307517163061, -0.02220034217539037, 1.1077270245183577, -0.8831311875956984, 0.3512042205652938, 0.21922679288950914, 0.6306106607260156, 0.7589964392610332, 1.070062421506465, -0.5106804709305608, -0.09589738085799447, 0.01158555064356661, -0.7869890538999487, 0.4408745898755051, 0.4486765267508533, -1.1707770101052102, -0.2622585542603719},
    {-0.6728079017412391, -0.7860849738572587, 1.0079075483478568, -1.0882994319672636, 0.8870092033176364, -0.619420348764791, -0.34034923138467876, 0.26810014377036234, -0.27898889379214437, -0.2933597949978968, -0.5385564461977332, -0.9179223467399815, 0.22678817577564128, -0.23135245495868703, -0.5110032737573954, -0.09696178858412481, 0.09393419230878856, 0.125610269379779, -0.3515857582537526, 1.2745925552345292, -0.5041835480164275, -0.2740972343641714, 0.14272873610795675, -0.5022562133867052, -1.2019775019916787, -0.7300561412675456, -0.9262961826140141, -0.8234396276533934, 0.16580131163962042, 0.9205026308438348, -1.871894555245292, -0.29415816331694783},
    {0.2728931570847061, -0.48226312889437306, 0.6219982295180628, -0.7317177832973769, 0.49438052329591814, -0.1724891712067183, -0.8570813152454334, -0.03339921230448726, -1.1704293407682311, -0.21183806173972725, -0.30882023676396964, -0.435052936578327, -0.34645848111146876, -0.32268785823795487, -0.5248067412318994, 0.054341023155927363, -0.5682502141574701, -0.5162590287759526, 0.4133916424321637, 0.5032675885291958, -1.204676276736185, -1.3928023865023136, -1.1966655348540503, 0.5364065576735229, 0.3772192208954083, 0.31573005036556834, -0.07508035977534802, -0.14307975165245007, -0.5501699007475307, 0.18346820955485327, -0.36398421330290703, 0.1396737513802584},
    {0.421764264254701, 0.5090893539417205, 0.5269911023507865, 0.15241236877628442, 0.5660862490451262, 0.8150922059305304, 0.022558502485553265, 0.22249673875071274, 0.2333102430559891, 0.467259744985117, -0.13977392643769457, -0.05377382704810311, 0.9624426020301808, 1.740973554383831, 0.7520907725308642, 0.7959775463491069, 0.2412333161824068, -0.8144121688736208, 0.8235290154418746, 0.5352252873883218, -0.9152732812826102, -0.5994057096657406, 0.9297819807359121, 0.3655595809565514, 1.4819826128029523, 0.5420381055339242, 1.1027031505736564, -0.2820090863122322, 0.3909386901167665, 0.06636032392603916, 0.7017405964334716, 0.39198760589814224},
    {0.9827609795609052, 1.2513997913954946, 0.13791396119657648, 0.2432522102358037, -0.04096287768834147, 0.6008570166784014, 0.6159762546479034, 0.13356940180624158, 0.30535751059757416, 0.6893744149916708, 0.31782913212232516, 0.9520404246729071, 1.545390086308834, 0.6670580200319142, 0.21497911162189137, 0.32217911244416136, 0.3877255637754631, -0.5471268169099694, 1.2716642353817236, -0.42704482170297065, 0.21261422867602117, 1.037710703451997, 1.7831106760572861, 0.47966676904490363, 2.0279140088614445, 0.2060044500686191, 0.29393353779387593, -0.04281802395874435, 1.0718953655461465, 0.5356505651666946, 1.4697049394283437, 0.6868833087518504},
    {-1.0016186748960823, -0.04528906151415704, -0.47014327598859235, -1.4282920616455805, -0.7642893992731732, -0.46444893899851614, -0.19895233929078263, -0.14815430017333117, -0.7126479901109031, -0.638379331596511, -0.2609999511872811, -0.7912610352862762, -0.05690426972836493, -1.1728236535059358, -0.8202177552893023, -0.7621082470728133, -0.8593009184176335, 0.02212645336257974, -0.755546719677335, 0.24553284095454464, -1.0908284799185677, 0.48870267286604807, -0.646968406683937, -0.8794270554290927, 0.16785711112284643, -0.20544988152935756, -1.1935493839024727, -0.8126594859127765, -0.4410470378567977, -0.7143849884464138, 0.0010742210950915353, 0.8708831712830916},
    {-0.25025598101880947, -0.44563725420721556, 0.5869884243926531, -0.7663300419905198, 0.6226907069904801, 0.14237813699265187, -0.9814722080084646, -0.4197072084727437, 0.5667708601695496, -0.7780215897237898, -0.15217827882365736, -0.7100837213378455, 0.9263358994066894, -1.464218915116132, -0.9736314512529008, 0.33077057467380544, 0.7737339032093858, 0.5458557851298121, -1.016646678303939, 0.30088105832277007, -0.9564358216805783, 0.021757421143861012, -0.513822073226934, -0.3584478510934397, -0.5838913267934633, -1.0771172681771652, -1.1661580925973054, -0.04519715251715986, -0.44901536369754785, -0.4331064106188161, -0.14560692531632133, 0.35009555136164633},
    {0.14739296320236858, -0.5842268015999199, 0.5722079535696284, 0.562349662709544, -0.7369146462616267, 0.7721077235809999, -0.10189722989506422, -0.2001747244659544, 0.8015583126681256, 0.16376350457113165, 0.6950287345352657, -1.1926713944422274, 1.0138918268154034, -1.2922170620795215, -0.36878630853236344, -0.3374970377761788, 0.6900379718937547, 1.6892575357084454, -0.5030396152172901, -1.4747076334955196, -0.2700892005770127, -0.57632421500399, -0.4911130325894396, 0.49221107365021904, -0.9060639491823351, -0.5124984085197711, 0.3205151577603114, -0.33798139838294894, -0.41834879058085633, -0.7022479937919398, -0.6752589328476825, -0.5043840649540716},
    {0.623492764261509, -0.14227104241300773, 0.5882663636566802, 0.10912639179224563, -1.4846460007639175, -0.603182405475609, 0.5009764674895254, -0.03808913920889947, -0.8742721642888109, 0.15989862555732132, -0.2261403094495438, -0.871789091220551, -0.5952410691065949, -0.5657714010832761, -1.5106888180199483, -0.7506371614788174, -0.6408693105326007, -0.5212750041861607, 0.8780823064542966, -1.8653093738314346, 0.40004323172292183, -0.6880556079180581, -0.3847118802778157, 0.4937188767887149, -0.5496523973412757, -0.2856025841633254, 0.589328415095695, -1.2895466389077377, -0.36787049884671447, -0.8620461090469967, 0.21946673054320115, 0.1592727120258158},
    {1.466085890657966, 1.3078822026030914, 1.5750808597165604, -0.8553753344172067, 1.1327489818657928, -0.49478623034139346, -0.6626839906696781, 0.31806008862908614, -0.9900129792789998, 0.6446047692289766, -0.0068628558078689525, 2.4483081694404647, -0.5642650453405422, -0.04613511386207316, -1.6704098826177813, 0.532766792820229, -0.049844106501705995, -1.2244027856686923, 1.9846022583424077, 0.8287378243688246, 0.4445055397075346, 0.4699438765194137, -0.04299207011908786, 0.2847087430560343, 0.769332155117569, 0.0613512253884146, 0.27560667299112585, -0.25499842701170283, -0.8312994154846383, 0.19172868410160507, 0.6920068735599373, 1.9398501917442392},
    {-0.20611247905131355, 0.12446231852151618, 0.6998784920261709, -0.5663028331197288, -0.547429557211097, -0.679199098220093, -1.8107573395395986, -0.2421240623141945, -0.2962703287460886, -0.191016756393589, -0.45884197954104783, 0.20107156635684903, -0.4192123715880874, 0.3516395025624967, 0.014306085746720142, 0.2665327091886786, -0.21770221563122077, -0.084950443617415, -0.31208342668507816, 0.9630773381185503, 1.0820971314203698, -0.3643742297985768, 0.06614146432999914, -0.4712505968215617, -0.1788690834864465, -0.03721762968496506, 0.24635438782942168, 0.8574344216061747, 0.13549977340378558, 0.9489265447020147, -0.010207459066082834, -0.7060396109888819},
    {-0.2560912433309725, -0.9178914264516023, 0.535225466207627, 0.5923962548416639, -0.6705794000299922, 0.9082091738437682, -0.39060517373456893, 0.20826565767690994, 0.3360957633623665, -0.4533843605527108, 0.03258578499417684, -0.4636581116544902, -0.7366307725166059, 0.45679131420523805, 0.5741516395248456, 0.8645151439224705, -0.2519876773541801, 0.6383320056665659, -0.817331224918929, 0.4271566728811622, -0.4243343598954294, -0.14126679923806237, -0.8101182538371695, -0.6196520294939242, 0.31633811406224627, -0.7868637711103585, 0.8068009953133958, 0.40789768782122804, -0.28449872837199713, 1.1040594472243093, 0.1101873614121606, -1.2669048413461923},
    {0.36065932095935554, -0.9721022116798911, -1.5056166964546094, -0.21445326976935053, 0.6656550203715921, 0.8860642268802174, 2.0064988844097424, 0.7027163762997137, 0.47896214365560374, -0.5354489235908516, 0.18906915055197873, -0.46346055223904264, -0.7968776708682346, 0.6107124311652183, 1.7493632718635659, -0.2510533433064175, -0.21637685608181062, 0.7223807514945807, 0.002133654550411368, -0.1413940298675571, 0.1716375416891834, -0.5568184714469743, -0.15598561487911536, 0.832217481515572, -0.4694820473959162, 0.3762663376058667, 0.4624339416760062, -0.5694023553982498, -0.5491664409017524, -0.804161745223259, 0.9442156970666162, -0.8765022600490929},
    {0.5550392044565831, 0.09254961284368662, 0.12312191702068206, 1.0199700079748928, 0.7911041323168223, 0.19519169297874867, 2.1418836396060184, 0.2756479213743212, 0.06332975449980652, 0.4864684960847238, -0.15820810646835093, 0.8115909655288539, -0.16361174926132765, 1.2409074736678471, 0.7372635631656883, -0.9741003461529252, -0.5433351944937215, 0.2666180683066132, 0.8728567917411081, 0.6197525590564473, 0.05416283813775191, 0.19120587944162235, 0.7286584660794154, 1.1783260053025995, -1.3344844335985537, 0.9317940828563989, 0.42086523140141113, -0.6698046698569139, 0.1574819468794802, 0.01789970990101003, -0.7714526930106202, -0.6478431412962155},
    {-0.062276901979951095, 1.226895688131472, -0.36305986744755303, 1.011283410835009, 0.9385415551190671, 0.8003208355712784, 0.8414101914152534, -0.4134550443422126, 0.7034753890713953, 0.2825707326312361, 0.4603656579217325, 0.8752837616899604, 0.2445822668226816, 0.6812516454018568, 1.0241691552251928, -0.03806948346505292, 0.36855185368941973, -1.5577021810951086, -0.38281401558113354, 1.4896580747780561, 0.23462441536232598, 0.9636212954817674, -0.7886764327650787, 0.6629918111600361, 0.32780243735043346, 0.29848343693590723, 1.1078825106742076, 1.3507824091836784, 0.5270471338133886, 0.1351907673574149, -0.32386861599869937, -1.0778416474793497},
    {-0.3958854266798658, -0.057501516949539845, -1.5847211797416603, -0.5899797990759847, 0.02043741070440833, -0.5863551599402466, -0.9179470597478597, -1.0735286152833527, 0.8561252690269695, 0.3360557891705435, 0.03396969172599794, -0.5252258041911694, 1.1670585899835657, -0.7750693062940678, -0.08398654933126438, -0.22756707877602098, 0.9368164420792295, -1.3971814061794758, -0.5990750430187637, 0.4318357850377305, 0.3399124926171055, 0.709322371026291, 1.3447374442331577, -0.5030459386572554, 0.2810249430352866, -0.29302766338791686, -0.15647676190249316, 0.6131186198906761, 1.0572656572855617, 0.3001367919467902, -0.2041130596550355, -0.36694886495508844},
    {-0.17502442703280865, 0.8522197169781777, 0.07804684058368763, 0.772992320399135, 0.549331939590067, 0.006171024731635837, 0.4280933419385271, -0.11717365936783845, 1.4024855237059455, 0.5517858493492038, 0.5197728631668885, -0.3831601724765552, 0.446462080460067, 0.8266940761940944, 1.0440171493624046, 0.3552954716235505, 0.8876110822230817, -0.8246946682541341, 0.6984073106308036, -0.057062193759466966, 0.5190713380918116, -0.1588243799436381, 0.4741306005268681, 0.15281663369821757, -0.038818336220843734, -0.04908370327278503, 0.7256631086703449, 0.2964226260926574, 0.3931341836678447, 0.22934750643396246, 0.5516482110059004, 0.051864069159713276},
    {-0.7422940723988523, -0.26360707626428437, 0.32287513196869017, 0.09408061868941262, 0.5803722914005413, -0.8712129258086068, -0.029952550335415804, -0.3051094260140874, -0.3038173580505328, -0.4858946355137473, -0.5330908643589107, 0.06068188687063238, 0.1499052214968613, 0.5089642699488279, -0.47416794065492895, 0.23712628779297812, -0.2309805196680375, -0.055293448407386564, -0.8177871827303825, -1.0423773423537683, -0.890333690757594, -0.5420112238875977, 0.33743082815884057, -0.3894817138049643, -0.5790603206882047, -0.38320295938760396, 0.5586999107569972, -0.26330696337444087, 0.04886239482102039, 0.3628374464382164, -0.37751750403294293, 0.507526099126577},
    {-0.5469971422039182, -1.828220607291964, -0.15292602270072883, -0.0021569185441947, 0.5877778979734968, -1.2332177525177366, -0.01296221107665223, -0.06770341883145758, -1.0654150649550944, -0.026295900072616694, -0.60097736620439, 0.4201722048841381, 0.4004616714957734, -0.7916416036800935, -1.623576209283819, 0.10398458813896672, -0.04382243555466676, 0.17894754081344108, -0.823290748857153, -1.6675293675085414, -0.4708088698667612, 1.058266662342001, -0.5921553773380928, -0.5864271340821472, 0.09333304928527464, -1.2761036413208577, -0.3031646430998218, -1.5471168211202575, 0.402321472835277, -0.27970183874613574, -0.7148908060479113, 0.8371031694740437},
    {0.43138335143233175, -0.30285824737425865, -0.28470913927283437, -0.0019411269261174217, 0.16625949392204925, 1.1618218917859147, 1.1932396333253836, -0.21922882436365704, -0.5955390841755779, -0.044069074591882966, 0.017624580966263997, 1.0539982165127957, -0.20698338977570688, -0.2875764800191185, -0.578672059589458, -0.5181231054129825, 0.9711402218116119, 1.3961586208664483, 0.48811453980913316, -1.1451888661880132, -0.12555243167838906, 1.1116214078591815, 0.00024766586775991194, 0.3051146463210095, 0.184205152883403, -0.23740529756121848, 0.0008110183263023977, -0.5521412378000528, 0.2646530748489361, -0.7893531471865447, 0.23541073880689523, -0.337863736479345},
    {0.8637711547268505, 1.0311418387871722, 0.019971170806973113, -0.43889573938048054, -0.11790670329838829, 1.460105816851194, -0.3603476183861897, 0.3767096295645777, 0.35537501062728266, 0.7868689247004199, 1.1413549941733798, 1.343614546994472, -0.1128875936301714, 1.431718893084777, 0.27178998522356956, 0.28991452705565035, 0.09094669105304531, -0.2556350327020575, 0.4734426250460717, -0.49247134534705017, -0.37059237184671956, -0.4414241860029773, -0.704524705370752, 0.0766568655008127, 0.4008213521855869, 0.9906533767060037, 0.11070314428045215, 0.7660043826000248, -1.0475851979652049, 1.6643122553196934, 0.07616096005860663, 0.9473083879696818},
    {0.12204093350132482, 0.29312085312335046, 0.007005986822816334, 0.15654171495760857, -0.5625508951955716, -1.2575403655144943, -0.5205034377026099, 0.6134263859854638, -0.7198115230661232, 0.2871777329118011, 0.5503027723574001, 0.7654857641461013, -0.06002232276790748, 0.2266168416059208, -0.11078862591217448, 0.19886425569669078, -0.365297607184041, -0.8176978372677257, 0.2694737933033321, 0.42987784237869997, 0.1594921495597605, -0.32722171720919846, -1.156087254403834, -0.4300677668150328, -0.42290458586729057, 0.6306117819533203, 0.2433794116541152, -0.26609832917590814, -0.061923733017221136, 0.2792143643825686, -0.1337691236314056, 0.9314684022909423},
    {-0.060312973503284385, 0.9128772795114892, 0.5000090565820762, 0.659699285267568, 0.880768681060291, -0.7813488934190402, -0.7733522856120852, 0.19746395264462396, 0.05076679243542725, 0.0060600733292256155, 0.13207333431628507, 0.10916941961862042, -0.8350360656034836, -1.368954055063641, -0.29147855350485286, 0.16790685755528556, -0.42066168206845095, -1.0373766196355962, -8.702582425378621e-05, -0.360011237633124, -0.630414368463456, -0.5146215981504717, -0.8211668807392002, -0.6550238240479176, 0.009642797155095731, -0.0407371941939019, -0.1959819598711418, -0.39467152548723455, -0.01873487621769116, -0.35637348406359215, 0.4211030986222214, 0.5110652880175205},
    {0.09070238498418555, 0.6681323263005825, 0.9890047424747764, 0.8853377327682954, 0.6588246062421991, -0.25251958929719015, -0.5572944723571212, 0.1738621359173538, 0.8896158658529338, 0.33329723553384233, 0.22956458242368008, 0.004086583283586494, 0.970582373754697, -1.0462905783183516, -0.7199629841979504, 0.57240087157631, 0.8836541703010959, -0.8214276204674971, -0.3788409308412448, -0.9633621610394404, -0.12086747942047846, 0.16787292386247585, -0.44629937560259775, -0.2027461930379698, 0.8054291227651219, -0.17521344794194305, 0.04526743620347952, 0.19580363740608103, 0.7085101615269536, 0.20723138680967146, 0.2678549944154624, -0.26954001876135963},
    {-0.49925743639163733, -1.026338350141837, 0.3257696081968998, -1.0144509319932626, 0.8675744876801078, -0.8621879224228207, -1.9107187515330841, -0.6375109800832653, 0.2161170858434184, -1.4881037243189152, -0.6677950359219667, -1.2482282110590202, -0.5158713843191711, -1.0330951645313458, -0.9985416259497493, 0.030350576926885503, -0.17842733269763647, -0.7291178746847112, -1.4313543811396539, -1.4558384332432135, -1.0671475745050192, 0.04721695193487169, 0.051296727324258294, -0.7787973711580047, -0.8489371655747275, 0.322923446614016, -1.7297266098571022, -1.6067204569313644, 0.7640718891003871, -1.1586465732392706, -0.6076660467490957, 0.16012934394152856},
    {0.5030844161646787, -0.638614371958115, -0.5896219015203824, 0.08198776037214342, 0.037261584383649224, 1.0430201485516453, 0.3270504359043532, 0.08275831787503482, -0.7987569923038494, -0.8792347972842017, -0.9228253693858818, -0.36029591516493004, -1.325784591163356, 0.5109374540602831, 0.9285352481170815, 0.2630790182292831, -0.809673095291352, 1.3888057055649974, 0.5364702411732737, -0.3831671783580496, 0.9157025922515734, -1.0902933084131248, -0.8232677680458652, 0.8174964788071509, -0.5955590464123767, 0.4441733396022897, 0.0792210135326845, -0.6876062160896211, -0.6919420721401498, -0.34631910513649616, 0.06906584182734622, -0.11880401438738479},
    {-0.400676042468866, -0.25837568402106775, -1.6553773020356974, -1.5187567418860908, -1.741933135327606, 1.186690099943684, 0.12979859544198277, -1.3599437624561015, -0.09192002763975782, -0.4427037109127458, 0.20214051150612106, 0.16974974390571118, 0.35969313930007313, -1.206693862614361, -1.5450274051021615, -0.48846330460178483, -0.1582524156706027, -0.7520884871846552, 0.6901821857450776, -0.00923387825346245, -0.5875172867879267, 0.04781659151718233, -0.756832817686914, 0.21873641802650595, -0.33315828985750706, -0.35784178504753483, 0.07806793819542084, -0.34679119062151775, -0.8534162046082203, -0.6991486589002076, -0.002491771206876414, 0.22460557998256733},
    {-0.5609789834638166, -1.0811038134063673, 0.42145330267042236, -1.0929158562192547, 0.5084562765741801, -1.3316445262687866, -1.2980970615395715, 0.19446619874909188, 0.9563664377474156, -0.14428833322229134, 0.19917094858511594, -0.13701448861141047, 0.2607923351391535, -0.641592517711881, 0.2670912295855051, -0.4265051805099896, 0.04270562117962447, -0.38825382094093697, -0.747241162323313, -0.027741595822707712, 0.4363766849087542, -0.17211733745868743, 0.9884573073722769, -0.3867583357180721, -0.143244642071659, -0.020028641746523683, -0.1229336966041701, 0.32862247128918176, 0.3968655984623191, -0.16234275801632383, -0.04377649955476368, 0.15486121785116422},
    {-3.855080653265692, -2.669415406969636, -0.5721839347463719, -3.4603483144702163, -0.25837315795393834, -5.591429898128555, -3.7966208603101164, -4.850143586336817, 1.089792414989863, -2.7097502150780404, -4.915691501287615, -3.025742918384891, 2.755234517274374, -4.339414395132219, -2.633850171938328, 0.9049121889219998, 2.044751533096012, -4.210596121773805, -6.074755941164059, -5.009405455434934, -5.738597672291907, 0.19737997648127606, 2.789663074701324, -6.1708504157478865, -1.7906991196883524, 1.3310612048603006, -6.131434001505873, -3.390611175799559, 2.5125214158235427, 2.526101206883457, -5.572495971712687, 0.18394617914262168},
    {-3.7021091389931, -2.5666757140519265, -2.6453443400705376, -3.626995371860368, 0.04049758430771174, -5.393691911542203, -4.2689710552956095, -4.208136241182778, 0.161547753845793, -2.1394748255724623, -5.2251535569738055, -4.186529847200189, 1.856494504905746, -4.478388566417577, -3.069905389566096, 0.3114803790962995, 0.8273971992076928, -4.199996878655746, -6.00478468214669, -5.794863119283667, -5.14464352189347, -1.5950914341444726, 2.601694893483382, -5.706811149663907, -1.5670874400242472, 1.236188001928623, -5.88730471784303, -3.0344427658193243, 1.5452568897797785, 1.1307886142085435, -4.993125572274844, 0.16710808273388736},
    {-1.6209320952692685, -1.770375007648625, 1.2195452721024989, -3.5652340794912547, 1.1874491026573755, -3.8918875684393517, -2.067856405107491, -1.6311645300580297, 0.32839084717858313, -0.6827254557750853, -3.0261750685186497, 0.07295997421094329, 2.400244353621139, -3.3254260898735937, -3.72021323077724, 1.0652988627251772, 1.2561028403773218, -3.024809677760486, -2.554660018536509, -3.4915357163282197, -3.419711340280256, 2.604327560963974, 1.9250861487142958, -2.5736664289323903, -1.591237375635331, 0.46329714033004626, -3.1795679874061937, -0.9937766043290254, 1.2270625838095865, 0.7105899695123805, -2.436479798501936, 1.8204781405897315},
    {-0.05966805018829505, -0.9735139568742552, 2.695323752681857, -2.764115199021708, 1.712727586372213, -2.5374110617892014, -0.9637213287018727, -0.855114355826028, -1.192238946530862, 0.30977409318636095, -3.0721151951821066, 0.7092016946127221, 1.3937212696514945, -2.1218884467391756, -3.0934056738035367, 1.289108476549107, -0.3684706799341051, -2.087024033959356, -1.826331876675689, -2.1613674705625807, -1.2204299531929164, 2.6959473182403393, 2.1865443578467674, -1.445909853551023, -0.28279455633751954, 0.49000701009785336, -3.133420311744555, 0.08301553797468263, 1.0691287739583617, 1.0884222108779043, -2.0243688352938505, 1.7413281324645569},
    {-0.790971143235474, -0.18208486368074223, 1.8642074307977292, -1.2481724951159217, 1.5581164714495, -1.5440771928323986, -2.5257358050651977, -1.248025694225012, 0.2014606269555296, -0.21431199443413404, -1.33298459036104, 0.5113194987824522, 1.0785211556755676, -1.4563414169033457, -1.1681649727141172, 1.652710882167899, 1.609845228746403, -1.2254177215151532, -2.066768026992061, -1.4514984718375241, -2.35895504007748, 1.3160535270509348, 1.5571536297962318, -2.215113699470571, 0.41654419413204213, 1.1770059195032434, -2.0039689745936142, -0.8232708948415985, 1.3894625622027927, 0.9603340559205247, -1.6254846975988237, 1.7068078316177784},
    {0.045793268339887325, -0.3874846234454249, 1.1032946100167613, -0.31301996117773306, 1.573242092004662, -3.182393303110121, -1.158003476088386, -0.7029736852543764, 1.5774511216475868, -0.2897694366966508, -1.9692388594169936, -0.24862461568008962, 2.6081302647262716, -2.839298612507427, -1.985806042140704, 1.2260876354157073, 0.6636610604539175, -1.2306067590692134, -2.963671304215217, -3.906782172230048, -2.5912725675418966, 1.5260347533836331, 1.9209827977139116, -2.4085770572797696, -0.2546450086335285, 1.392026934123122, -2.816773668985663, 0.2907894806463736, 1.8554678322871214, 2.2515972648729825, -2.273079403182188, 2.7464337106376076},
    {0.029973643489820626, -1.0030306376873874, 1.6602216069093583, -1.2557223799716761, 0.7907544170961722, -2.3837097899375244, -2.9272253304990428, 0.7454179552175577, 0.8534412043543912, -0.3622628163260604, -2.6991529661347955, -1.3361903302766092, 1.7617821883779978, -0.6056592056322702, -1.4123697251308995, 0.6557014424193155, 1.7001130360945556, -0.8636818217766778, -0.8203212221466488, -0.745798568636092, 0.015829946237621854, 1.261074657209641, 1.0711935172981972, -1.0072909331964937, 0.7904898415375317, 1.0684004598803147, -2.87383645828146, 1.976558761878077, 2.158793026746551, 1.9099051159469216, -1.8916903773182545, 1.894726570539974},
    {0.07937012703891948, 0.2925488856700593, 0.20421227708900966, -0.776067210240805, 1.4256978460244203, -2.3179886683579203, -2.455192764573319, 1.4609813425115794, 2.5992401811913752, -0.45920449846701894, -1.4482535945931523, -1.746081184677534, 2.6181929238021384, -2.563916110470768, -0.22758293347946884, 1.175867275543985, 1.2836980259571953, -1.2145205336341278, -2.3312290886490885, -1.8686786670560702, 0.49984450841830186, -0.6384275900838637, 2.071668292904059, -2.2944963568486587, -0.832082384201647, 1.5240729067833834, -3.0311524511983654, 0.3755841776774991, 2.7104184351042035, 1.5436085342655341, -2.9577382371694863, 1.6874326539483937},
    {-1.6769154715933208, -0.09060771541213279, -0.06258821887442367, -0.3771760592362411, 1.9603856488776463, -2.5774254958287437, -3.129919969270053, -0.4504697650705137, 2.3914586361445456, 0.7156435332448214, -2.276972961968695, -2.0674551793800013, 2.2552295923613723, -1.4114466056216743, -1.3313129919911837, 1.5772118343850516, 0.42052462578278227, -1.2275269595975713, -3.278317159054066, -2.401288110435367, -1.7177693639462814, -1.1730303314822248, 1.986163583252718, -2.7680265738375605, -0.0784440274197716, 1.5824441647822354, -2.932905856750446, 0.07944231317869586, 1.508322124868449, 1.973960661001777, -2.656490174256255, 1.9791608034046155},
    {0.5402803736120008, 0.448691941101705, 0.6942263134143043, 0.4787868615221922, 1.376952570529913, -1.1494902228193824, -0.9338243628569867, 1.264598128478161, 0.3369939827252414, 1.2632092590267026, -1.9124185998288579, 0.4504175878968751, 0.7687781412645607, 0.19744074203363188, -2.4061740628085486, 0.5223857308330154, 0.047797970223020195, -0.4903127363289126, -0.4231584975284277, -2.218224426652446, -0.9207996938136812, 0.46882815310901604, 0.30373875209676804, -0.02804785093896494, -0.5049033486142559, -0.31756377724820334, -0.7116548815500044, 0.6385943511172019, 0.305407756261338, 1.3167724962450074, -0.226767555178853, 1.1415540096366439},
    {0.10399144369220568, 0.29273444487952355, 2.106266799815061, -0.5343960519340619, 0.7561473422311773, -2.1741201136445625, -0.8182432266777678, -0.4547013683965502, 0.4854473272454915, 0.978875284434579, -2.157128074793386, 0.22384496590158676, 0.7619923225760399, -1.3032532005534871, -2.1415677445425896, 0.12975023465799854, -0.27403075087933065, -2.4532442573373037, -0.30455028550965396, -2.1054851299676787, -0.5591778480291631, 0.9793638101048504, 1.1744303852199955, -0.7564957819526772, -0.5657972525006625, 0.776777746409764, -2.011853460976768, -0.612086146598948, 0.6560650954719898, -0.8202914032239081, -0.6385627867837715, 0.5053004844932896},
    {0.7924199466369393, 0.30209120824415325, 1.6818117522420404, 1.1867159231614572, -0.3507522712261959, -1.2578296911462135, -0.8973768838574285, 1.1832136812337182, 0.7613228217936058, 0.8342496645859588, -0.8496719590309731, 0.3307325670867079, 1.3490155060688533, -1.1199421036667543, -0.47806863820748924, 0.9492295441375848, 0.7170299772089348, -0.793485795440819, -0.105226807442523, -0.03995798647571019, -1.5858935213627852, 1.0729107928688235, -0.7454520926154852, -0.33696289630462467, 1.6346241414750202, 0.7013461772833331, -1.1294399669895074, -0.001408974508227219, 0.6550364840077474, 1.4206449323760741, -0.4427759771726177, 1.511009188695644},
    {0.738074923393733, 1.482388993496785, 0.17373676882510447, 0.1584114394237113, 1.633251408345895, -0.2045368233620463, -1.0587223999122817, 1.3807065806670578, 1.164970261106885, 0.5252791337429265, -0.5939944383660267, -0.19698850665999273, 1.6381631425256749, 0.22793207106640834, 0.17810077758476078, 0.8157897486365049, 0.9605253176037685, -1.7500332361623354, -1.241870597331733, -0.7246901987130739, 0.7282878926160241, -1.9937146925635203, 1.6963959241853022, -0.1385448121488271, 0.5840181583007907, 1.4725167457189425, -1.658890789619498, 1.191838775094951, 0.9284260557566145, 0.660675530216055, -1.824370854749869, 1.8046236303146466},
    {-1.0388739338899824, -0.3126493255594243, -1.8375304570852622, -1.8192647507531579, 1.2298377637056148, 0.15963735370668894, -1.1378330241318215, -0.5236174790165978, 0.44311947328588075, -1.1148900475764716, -0.8678514580006241, -0.4934954742513209, -0.2935526525719894, -0.1123044121784748, 0.7305900856673708, 0.25204490348968894, 0.4967376440275003, -1.189123480867745, -0.7482852142408412, -1.314477329036149, -0.07803199350323263, -0.20491785835954954, 0.001580325771491778, -0.8442801518231504, -2.1451094501528543, -0.8635574007438733, -0.16935380138122216, -0.35691647676413674, 0.1940933380949279, 0.33028216420255513, -1.0135017192951645, -0.17330578613206973},
    {-0.538469249900879, 1.1548769680946334, -0.49967654307203935, 0.8485598484621124, 2.161361685419065, -1.4608404527446512, -1.2939342208716496, -0.5293070627608587, 1.3915426444624248, 0.16468284357803395, -0.011076467223206115, -0.7969909367502882, 1.2573036885550388, -1.4864609734147152, 0.43472577933716333, 1.002675943582228, 0.9057354579708689, -1.5860769960798078, -1.2404610901304989, -0.9276956757457255, 0.27934520938644397, -0.6578976562791686, -1.2292167096792086, -0.6027496916130969, -0.6977940841534112, 2.31823821725111, -0.13072669473953727, -0.046944224815751716, 0.8581902083631177, -0.26459622370124375, -2.047914707741746, 0.948253636884302},
    {0.6560271491388354, 0.770191749133346, -1.0980834921309228, 0.10959046856765164, 1.8724686198193077, -1.3205265044907233, -1.6741664868645274, -0.9597137951428579, 0.5825592441282761, 0.35323690649967415, -0.23729480449708573, -1.6135190235024013, 2.110911310856798, 0.2324792200778931, 0.6911534643528097, 1.852937515744142, 0.7660614448959794, -1.1188678188173733, -0.8760574043456578, -0.6466628232402071, -0.6427468130758948, -0.5364682392085315, 0.7554949961696816, -0.15060242726798959, -0.7330727965227156, 1.3699126170885376, -0.31189703213869957, 0.9958222810399533, 0.6988822389127218, 1.2885313136765382, -2.3597919239364447, 1.3470895456713525},
    {-0.15752588752023194, 1.3406385399771916, -1.5625213072125193, 0.1567937771666616, -0.010439661675045276, -0.7784165865695465, -0.8139457589024174, -0.4646487371717543, 0.24468151284132675, -0.29753264410526703, 0.3752694404423481, -1.1078960279034396, -0.6945684946877331, -0.9684105877042938, -0.09338318490377545, 0.4023664207043974, 0.09268561054040507, 0.5983962809815304, -1.8872339768692354, -1.2786689456945834, -0.6861662095995756, -0.12133653146393913, 0.22375459006623385, -1.1295104526617414, 0.01745276470675948, 0.9783209068060243, -0.8206999105994196, -0.9376074503082641, -0.059324094587719006, 0.14538715990232878, -1.0000647988994427, 0.038925688940734546},
    {0.6454421070463937, -0.7122744248197482, 0.862863970078443, -1.6472044460652693, -0.48159363697643714, -1.905066382782735, -1.5584144282877606, -0.23663888930765467, -0.43143872463441446, 1.034481347871783, -1.161185102292092, -0.26620817560333443, -1.2606362694280877, -2.1605220495124575, -1.8372060817603453, 0.17839606182859777, -2.294271270899606, -1.7164447360225774, 0.430786365443464, -1.1924094224352313, -1.973892310468969, 1.690042969270314, -1.6139680447175775, 0.30089477761808686, -0.053354850375615964, 0.19941901104483223, -0.9200310395747413, 0.8467493300204748, -2.3562419347827674, -0.15111724435570248, 0.32131850303859777, -0.941378336829133},
    {0.6676604504239371, 0.5114392100188007, 1.4061680672085397, -1.2490293547109288, 0.6840235430513127, -0.664657737731612, 0.5372868358078811, -0.004570152017903791, 1.1679610122196478, 0.6806055770989007, -0.8850324325448028, 1.3212874109364918, -0.5632414531963374, -0.019561685765073576, -1.6513623837956077, 0.40946250797729833, -0.8233835250393163, -1.5018139150308032, 0.6307158073485872, -1.7447700816338196, -0.09025506351724957, 0.7988987709901988, -0.04859842624800475, 0.4427783812425745, -1.1767814214202876, -0.12805793941429172, -0.693314175454038, 0.19628931378649211, -0.5621703190518204, -0.011671271947037374, -0.40533734218658757, 1.2378752410047975},
    {0.16327128508382682, -0.07478443913698432, 1.425991185914327, -0.14313558773981472, 2.3090038247440274, -2.1911906436995836, -2.060634501050133, 0.24371530872473743, -1.163154417679305, 0.7434030936508429, -1.753008771052356, 2.1376110054828494, -1.042932003184076, -2.8796125297668707, -0.9215582522600805, 0.2546468977299209, -1.6720492485546463, -2.3242778278673684, 1.3700279414343972, -0.8005139873981375, 0.2885120322211373, 1.4660807367407758, -0.45429511981234993, 0.28010071458566566, -0.40015368206032736, 0.9935691136198034, -0.9474941705994769, 0.8895727812626961, -1.5184414336523098, -0.5363982507939885, 1.4893997162260497, 1.1721565329523829},
    {0.37934735274819703, 0.9184940516256584, 2.061546590225676, -0.6528684544318196, 1.7003648654788472, -0.3454328218406337, -0.7847846974054333, 0.2051298541116823, -0.04119055301557624, 0.7271047941107578, 0.1636652493727736, 0.2831605538298486, -1.1425448747895222, -1.735944192360451, -1.9151019510022447, 1.9043717864927838, -3.257419896513359, -2.0369608014527603, 1.0109837254606375, 0.9207213235527978, -1.6971399584065248, 1.601208499075535, -0.3384322887951167, 1.501245448662424, 1.0285740313543394, -0.4808659447915124, -0.39816646238469416, 1.5726139051456107, -3.4792769962291126, -1.7381880212933147, 0.9561086124279686, 1.909232594785185},
    {1.750026856450627, 1.658896607267549, 1.163995163863245, 0.8609343371401077, 2.3833229786302623, -0.996338480875411, -1.066270809165549, -0.058966745305054705, 1.3218722286157507, 1.8636447642169585, -0.6003025154092907, 1.6258196060442305, 0.333173725472153, 0.13418540113631416, 0.44218169616272335, 1.3721492838059592, -0.017957477080602486, 0.07839275544770764, 1.1223678267926123, -2.072686948451919, 0.2638700453919322, 1.4131593063056147, 1.1577312253704495, 0.5501278209541943, 0.861583286522411, 1.6111492824033768, 0.6614920958171469, 2.428915578539238, -0.315021085999448, 0.025443021956308702, 0.8063434593767832, 2.1531631448390276},
    {1.7318671151208895, 1.6547911552492345, 1.3209759104247696, -1.422320682013287, -1.093625842304813, -0.06801107599961448, -1.347316891156626, 1.0506742320071012, 2.0482252148624758, 0.9176104094880287, 0.0389513565142111, 1.8541040609331405, 0.6044767652727536, -2.0992251249921154, 0.020744866803756975, 0.9275440573476269, 1.514893819564039, -0.0512463894464532, -0.2350320162432696, -0.9617951711614157, 0.6323456996177482, -0.010399379700727159, 0.49679860232657025, 0.8114904485087392, 0.5699717962593385, 1.3035048586369427, -1.1759518640193347, -0.06843472925349432, 1.1388371635158758, 0.28485985196071945, -0.10976475152257703, 1.7967533277173298},
    {0.5352309725290865, 0.8686487119012819, 1.0605087700646736, 0.8439627390277457, 0.4643163412488362, -0.008545959472704182, -0.8503356948206388, -0.5796373355749885, 1.5033006823137045, 0.24818538461334275, -0.12081377070827318, 0.21307658278802127, 1.1447170552260877, 0.3620150579603153, -1.0778955981288698, 0.39132013276123384, -0.22018089506012123, -1.1805721082605336, -0.5610538828729856, -0.9146691789035775, -0.10807582230531862, -0.556668900460954, 1.029049031060604, 0.017488368438432805, -0.05587358162248946, 0.38970756424232555, -0.36636042442195044, 0.06193497339625043, 0.19865913254872583, 0.523749479465084, -0.268453781470613, 1.0979811078755004},
    {-1.2547330167222528, -0.6471866943738733, -0.2270011966643043, -1.120832640564641, -0.15154394142598773, -1.864871199528179, -1.4927625330433996, 0.8803798138035662, -0.1364127048980773, -0.45513582971150524, -0.8407009510769379, -1.8919550535453038, -0.1336722767568315, -1.7986114674798952, 0.12673902438319148, 0.18996930413033755, -0.17482262878888993, -0.45883365570805196, -1.7750546454121467, -1.5924218665454106, 0.4773437029060803, -0.7303958037770849, -0.4789036958436992, -1.584752204302217, -0.9930051912164652, 0.838521365122319, -1.8533832762248854, -1.344390847206814, -0.7610145971695083, -0.2985556526830516, -2.7128615546176067, 0.8912002791767037},
    {-0.14716703028134565, 2.616532347539904, 0.03661217976354214, -0.29505082618583606, 1.3746886075251918, -2.119007062553294, 0.046771740546485245, 0.38770236302657035, -0.224483888491335, 0.84537550200355, 0.8799190895122255, -0.24868237554766995, 1.9979912203984864, -0.7998694539182231, -1.8354169491365147, 1.7718047577446852, 0.1518098024040849, -1.122880814623918, -0.6107146108138632, -0.13862160476233537, -0.29410817955023094, -0.11542716108459046, 0.3055588397498566, -0.6125752516772792, 1.9070818078482261, 0.7746505846188875, -0.4714240227317092, 1.276570852915392, 1.034661988259212, 1.7424925475613229, -0.7747438176170148, 1.7908803847351613},
    {0.14764562054292793, 0.03991107057161594, -1.4547162290490385, -0.0609180900180968, -0.15549807823442025, -1.0938571649310216, 0.32581390447798847, -1.1025399764996076, 0.8055314585886397, 0.10801428457378717, -1.504697044635764, -1.3156941230315253, 0.9609296623626202, -1.9619901189674005, -1.0602134017911136, 1.0326233864897887, -0.013281106802351781, -0.33907280571951054, -1.921832842454946, -1.8987532709129464, -0.8837448251564503, -0.21785009247947804, -0.2559529275670908, -0.32127671761563925, -2.112394158376467, 1.5576216156764848, -1.344149325816604, -0.7451693615524483, 0.7709079592755316, 0.9786556706641315, -2.505662244399443, 1.3888847600033503},
    {-1.7800510580901099, 1.0471250976076456, 1.726860071138777, 0.6370602768152137, 2.1165664633409134, 0.7496619931253033, -1.4361948225498422, -0.3773914404416048, 0.9864780896982267, -0.4376794544414084, -1.8303837303165411, -0.9166336750672142, -1.2832404140819194, 0.5612792818548169, -0.6375949870006284, 1.7073889270982014, -1.3986863597072932, -1.3362938963968296, -1.4730266087834207, 0.15036483567728137, -2.3831562807676057, 0.29271408134471943, -0.007646583281774887, -1.7091068319528793, 0.14238228040099438, 0.5320016128590952, -0.8917434197040063, 0.31456090020332983, -1.4043100211800263, 0.19853344374988882, -0.5304631633383353, 1.4859465954597666},
    {1.0643431854641814, 1.4937046990994138, -1.0386225237020816, 0.6578941701721298, 1.5250378686015913, 0.8417792057844985, 0.8730876624304414, 1.313497854908437, 2.029875702171932, 0.749305567786716, 0.42733533877464475, -0.3841920191554999, 1.8585730050204188, -0.07781067368037144, -0.3285565788020758, 1.3505917531463993, 0.9647355509650283, 0.6025241074733042, -0.5728271781680037, -0.2632537776637979, -0.3389932596379969, -0.37144712182511386, 1.4217477731099877, -0.654697799445136, 0.6780599725134722, 1.5193556805148742, -1.6427471159378009, 1.5099771395696158, 0.9380771455958918, 2.2910038277386335, -1.013756708981635, 2.3294723976395453},
    {0.4403173657775005, 0.6530188626823467, -0.48770065577072125, 0.12394783968881305, 1.8910468577644004, -0.6758449502760117, -1.83667732120417, 0.4608831850228342, 0.8511969903705058, 1.7437004133381748, -0.6536809167165069, -1.3255206102649506, 1.5658226706647684, -0.046178939009558925, -0.043231231977881354, 3.064500550768983, -1.3787541445556264, -0.9219670797949774, -1.3563852846098579, 1.3568416130033416, 0.08716576909226548, -0.28828058692062264, 0.4732240068472558, -0.08395047315678092, 1.208453309999825, 1.013496573881788, -1.149017873618932, 2.41518136306795, 0.3115300374045153, 2.288814130500757, -1.8880993585033452, 2.691448447395652}
};

static const float b1[32] = {8.033806297649742, 8.158624620300518, 7.717631585012949, 8.098167439608094, 7.989277527923966, 8.180651741992254, 7.857330421938457, 8.19005886690467, 8.019539148011624, 7.739101874263038, 8.006525232558904, 7.881223142460078, 8.14638837566728, 7.941331049701637, 8.075184836913623, 8.057814976998829, 8.1092905093386, 8.01194333581488, 7.938002586648332, 8.007265808625958, 8.054774846092009, 7.8671548054249065, 8.287928162430644, 7.830726411644912, 8.156919704522855, 8.06500100586188, 7.863435781071796, 8.087682603613388, 8.06376218659453, 7.95762998100176, 8.04898687823441, 8.166892908655582};

static const float w2[32][16] = {
    {4.2422012835433165, 7.007308371778606, 7.439041616939203, 6.824755159969388, 7.515562214687359, 6.347300838206889, 6.945887116724, 7.212419626007077, 6.882226440746417, 0.01917804017375092, 7.09058922880913, 6.777975546401019, 7.490273229094471, 7.48600817649634, 5.583425711946577, 6.5250734889240904},
    {3.810827255101733, 6.527767275057514, 7.474991795163956, 6.564439871241827, 7.04221448551004, 6.383035455438656, 7.149188409998, 7.111121458297468, 6.573608990211184, -0.16314110425662112, 6.964172140344987, 6.87278995660073, 6.875549333788734, 7.039194251407354, 5.663144997726696, 6.837508989575466},
    {3.633691030228023, 6.883714712495638, 6.797216597963452, 7.064893948539369, 6.807212427548, 6.547635136305403, 6.836250069541897, 7.275605135512121, 6.536331483946237, -0.0028757618163126625, 6.185884091043657, 6.798713599254004, 6.900466468450376, 6.829601995075782, 5.473807738020788, 7.006032889231123},
    {4.085808845056748, 7.217847946056027, 7.226333570774798, 6.892936883028365, 7.079941571532371, 6.329081192282261, 7.024187537105277, 7.13191487029026, 6.8159942751880465, -0.26331404730217767, 7.145977959146503, 7.488239908296048, 6.986241152210704, 7.107027916503233, 5.491540947256643, 7.263409264140673},
    {4.072328102297092, 7.36917130445443, 7.718434722126687, 6.845460509309044, 7.221594540490744, 6.155698670453348, 7.35669944012566, 7.253975890514062, 6.768886283291271, 0.0021236252174026992, 6.719882435683476, 7.5280168804972725, 7.222101381971379, 6.676720851026304, 5.146277596432401, 6.818051845544003},
    {3.8844343563511936, 6.776265696435489, 7.092149618904263, 6.794013745923723, 7.0972565611331735, 6.279923472787925, 7.272634326082228, 6.954299624411654, 6.7904018812342795, -0.29749450883666767, 6.798990171787788, 7.561755764268738, 7.118093789688523, 7.18032480779818, 5.233873982491111, 6.220899850544741},
    {3.747615569103345, 6.7800109139097815, 7.2486625812232255, 7.071935760701424, 7.19431516485223, 6.197175935422509, 6.803030778026356, 7.273703811503375, 6.896745115472901, 0.052884680895219804, 7.141680509018446, 7.046172302356076, 7.310390200675074, 7.600931709952041, 5.9795640584172425, 6.19243875479932},
    {3.878391041606589, 7.52455801650222, 7.589434189700832, 7.328920277505867, 7.178744369515909, 6.507870730243482, 7.6669816475566925, 7.2036843287017485, 6.714432742013985, -0.4942467780397595, 7.313253955280707, 7.937051977801354, 7.499282204549482, 7.52693053563534, 5.722129128965302, 7.042443740365886},
    {3.7432808646099702, 7.516169439158608, 7.1134024758016094, 6.933724791891236, 6.948286018290912, 6.136450832796672, 7.00832510644048, 7.0294559463768715, 7.008831577320271, 0.23151016761733068, 6.808842748243215, 7.21520308814984, 7.4165524706923085, 6.956339146209693, 5.955961940952624, 6.593693802801119},
    {4.324185344786286, 7.523723153972854, 7.072051030445556, 7.529447839936402, 7.27188003287365, 6.495958077438485, 6.796990240884763, 7.308512669927985, 7.500552579856819, 0.4177324989710571, 7.237529671493556, 7.376463468588325, 7.461657342837019, 6.856396758751552, 5.473588256271187, 6.714876966622628},
    {3.9203457344239947, 6.992828058579137, 7.063449895435407, 7.149574628967903, 7.285529417017105, 6.319261865999502, 7.158051204096588, 7.282378662945318, 6.86818300152506, 0.012266662551460333, 6.99941893274438, 7.432725080725815, 6.4374800479032785, 7.00470952357128, 5.444876898123674, 6.710638401900138},
    {3.8435957182405387, 6.893039201796584, 7.333622445944117, 7.11028312240281, 7.2376628188438055, 6.432538103826891, 6.7561972127344765, 7.295836396991985, 7.0860888463661915, -0.05527619163834227, 6.949894339513098, 7.300056353330288, 7.091700314853902, 7.367160092121082, 5.919980104984318, 6.8347368814597305},
    {3.83140464897159, 6.854089365018125, 7.789596332544266, 6.731588039940291, 6.939564266532018, 6.324353413224064, 7.006451652945022, 7.082496757169355, 6.3976671914600995, 0.15111939625668203, 6.9894946136010265, 7.0391156559361985, 6.856413844229614, 7.1412810828982, 5.94348154092585, 6.790977530940648},
    {3.5297538267354653, 6.90363075662574, 6.847706127738597, 7.238607371251507, 7.379925143558177, 5.805485120505376, 6.854491986172871, 7.410998762397323, 6.786898128409158, -0.12073381416892263, 6.688064931099342, 7.040636735050301, 7.374410795817537, 6.895303375925966, 5.915760850727365, 6.966884954877092},
    {3.670693994548223, 6.59734404797857, 6.787303829924574, 7.036742638309106, 7.254459288463331, 6.255903558116041, 7.0518279252907, 6.5990958984542125, 6.943407412869805, 0.2144409194017698, 6.754752092871198, 7.042940127574191, 7.158501943601062, 7.2602028719704, 5.9177044405501835, 6.786336938225635},
    {3.83275150206002, 7.328839088101516, 7.4637896395557926, 7.332427344959828, 6.888294885065709, 6.510150817990475, 7.377577028232334, 6.78128591863034, 6.977944588581725, 0.14083111300914236, 6.400174893260489, 7.373115307331191, 7.195379362070463, 7.348974715768567, 6.254252538910836, 7.1147496247542605},
    {3.9920676980559775, 7.188651514277109, 7.536953446126838, 7.22863480754963, 7.286204808039105, 6.6673891018398175, 6.699010892552555, 7.529627160816516, 6.746043942999825, -0.40199981707140015, 6.7701474753238635, 7.011745715361831, 7.285667523198792, 6.941173889782797, 5.874496820460363, 6.432810570372575},
    {3.8188023919636183, 7.411679884424075, 7.429835249647021, 7.464109353018684, 7.13296726854394, 6.048966761951164, 6.971559008217746, 7.30977808654935, 6.757421954952214, -0.001382453876360453, 7.398750936718935, 7.4791245758437235, 7.275469326640738, 7.005676589125386, 5.648415748282344, 6.660207846372185},
    {3.511864122664849, 6.95845621289505, 7.355459491781352, 6.937287924516473, 6.965401984874986, 6.076641437111796, 7.863582692852606, 7.2653560755251405, 7.1444092811615265, -0.0334371740102178, 6.8080597745792275, 7.6510994086725095, 7.006975536315206, 6.9665488898096175, 5.146924623426892, 6.503930526801172},
    {3.8922779156596437, 7.187402259632298, 7.567626966283579, 7.2650780655600515, 6.920640444352633, 6.277709247883771, 7.248144865998936, 7.24173154246936, 7.2128735514492694, -0.26139488395667226, 6.902694174752382, 7.70020386431429, 7.514261312727985, 7.169857689529599, 5.379819022580785, 7.07308394007298},
    {3.9106747589298383, 7.135051609859261, 7.556378153490848, 7.3507291835520885, 7.294882244307302, 6.885206504238332, 7.407898283291768, 7.47560580372959, 7.225933718023514, -0.22531665170176973, 6.879363522038553, 7.508184773885313, 7.413658042775665, 7.180778711286866, 5.700381387522107, 6.745676447061314},
    {3.4292507671732504, 7.30024687055098, 7.378983169338074, 7.021289907373554, 7.110352460924806, 6.717175617623604, 6.620059700367562, 7.00101421642543, 6.9562795140819755, -0.3197571863377987, 7.0284677607726325, 7.122373236307828, 6.960376222412603, 7.087706916944459, 5.614653967406135, 7.041208026447856},
    {3.445050296273746, 7.285071481402369, 7.938383508994338, 7.574122388693564, 7.07000691659194, 6.71943843366107, 7.195444448307487, 7.091599796466898, 6.860600582484929, -0.38567085814533086, 7.096163138757669, 7.399742552069458, 7.096764484898449, 7.158420826265048, 6.076799382151836, 7.188600637621196},
    {3.317091245362941, 7.119319949509729, 7.154307032736813, 7.738301114596994, 7.662111992392507, 6.8433603823935165, 7.22463271970165, 6.736162322633115, 6.5593136592044345, -0.6079551727158092, 6.683547674979571, 7.231557750222416, 7.102814980711452, 6.674341148119155, 5.983810008791598, 6.674191179090837},
    {3.754954990675544, 6.887986446413661, 7.416218442443744, 6.951646120216564, 6.671621333754621, 6.420990588509657, 7.402188540617696, 7.222939267756066, 6.743659930689059, -0.29530826469109583, 6.8669954506197195, 6.8459320675499455, 7.412756600318322, 7.047770239534656, 6.038884944793091, 6.829754087997284},
    {3.779318100578416, 7.288050905898964, 7.3686846531105905, 7.178106103654499, 7.1396926160315655, 6.644728944413918, 7.024299192703893, 7.163704987719135, 6.860975212189135, -0.42551553516538926, 6.58011893613168, 6.634205165358638, 7.064882210509434, 7.247752335709388, 5.747247133519335, 7.094921990265637},
    {3.540697479382396, 6.781314401088398, 7.387937307108189, 6.944316443162566, 6.840151664952852, 6.223725381908008, 7.312304725896528, 6.907074100921326, 6.796797143906656, -0.2542208837357903, 6.31225165006097, 6.998381547359902, 7.070607647421537, 7.084891219584014, 5.130032918244684, 6.266897808288312},
    {3.917361240767904, 7.0684407894426835, 6.802711852602566, 6.954591372468207, 7.233617827265805, 6.176732856603596, 7.147821579120407, 7.158001842537073, 6.774665504695916, -0.10194074175099345, 7.383222908221346, 7.347945356684798, 7.343331738500116, 7.110001274616352, 5.766197348539183, 6.612280181269107},
    {4.109268467666895, 6.913657838799581, 6.612228344349424, 7.187377154027974, 7.368417694345765, 6.350987411236615, 7.052128946119601, 7.119983707707597, 7.2453223376851295, -0.17085410316390393, 7.247225268278947, 7.762270073178036, 7.4360033644504435, 6.978473887569151, 5.738666309033834, 6.477946545939501},
    {3.5395160107825805, 7.225695586958995, 7.341266451968388, 7.264545632295565, 7.010243922595162, 6.261526134822326, 6.980922937443987, 7.053120436985859, 7.102287582908521, -0.440479785124466, 6.899275382444321, 7.046263411557487, 6.885836530400872, 6.576890634739472, 5.9880150225223305, 6.673299554966776},
    {3.292148379124861, 6.94694337166421, 7.543817471312357, 6.879452278973819, 6.992370172755124, 6.540196827260362, 6.924126194742578, 7.47140859232516, 6.237328569912509, 0.09698007991955669, 6.610107706129202, 7.190715720686343, 6.8503851571163805, 6.690088065979141, 5.545975718011135, 6.255588129163124},
    {3.910986649441238, 6.982707351621384, 6.398471316664858, 6.669375846897484, 6.831258777944508, 6.169534952476102, 7.675487658696147, 6.919668661517553, 6.591670896226322, 0.08014815517519387, 6.8095537761113665, 6.96473128955803, 7.254357869538879, 7.135581449646732, 5.605380997290808, 7.171405604999149}
};

static const float b2[16] = {4.46395851810534, 6.653858943564091, 6.675274402767667, 6.754494370307955, 6.594507198426161, 6.969217022803712, 6.578535944320287, 6.765833222729147, 6.6226069288060625, -0.11285621796734015, 6.755456426505766, 6.779529230357492, 6.554328881223998, 6.662657271306124, 6.07737845061484, 6.815118879459251};

static const float w3[16][12] = {
    {-2.5578141481599324, -1.9746517595213708, -2.5266545494734047, -2.2687064633107776, -2.8115394798533258, -2.864639766964265, -2.2451056034816745, -2.507982750602194, -3.1336940788839596, -2.2604948834010266, -2.4256167812825438, -2.4242725881596154},
    {-4.61011001060867, -5.197645856042084, -5.40340984692037, -5.202182261959994, -5.175980113708153, -4.393159609515438, -5.355875232590413, -5.149824732582006, -4.901976778723858, -5.258618448439383, -4.630180873196665, -5.598398890641186},
    {-5.131924174367315, -4.885699247138433, -5.015539011764052, -4.821147136866336, -5.580070967150151, -4.973108525807213, -4.987489577045539, -4.718265888102329, -4.778020726235022, -5.065435075174961, -4.8436175494873135, -5.685323102013839},
    {-5.313078536349978, -5.880453078051667, -5.497493298044924, -5.514819606445651, -5.2461295214076875, -4.909448424880645, -4.848703318155997, -4.263370639421243, -4.962190625752609, -5.392197372479604, -5.237807340934657, -5.071632704423691},
    {-4.819404323340887, -5.077168476392063, -5.2614587280496306, -5.011982736250209, -4.7281227128362, -5.164474591755469, -5.227934728191796, -5.293788365444379, -5.059662949809102, -5.740439416694524, -5.337917298885493, -5.106588631680581},
    {-4.745138119314555, -4.495638471009609, -4.6875490401788085, -4.819441892023594, -4.558804374172658, -4.843190898882423, -4.982327633484098, -3.8911369150316313, -4.834383658399717, -4.827351605185486, -4.322909482063635, -4.365854800323904},
    {-5.009344415928513, -4.940781678129106, -4.756389634755965, -5.091142555638001, -5.160844238504204, -5.445132046958822, -4.995828659642698, -5.4297882389365855, -5.158276627333665, -5.6270860402921725, -5.597809185828919, -4.718098657901037},
    {-5.330844548055835, -5.320916334175838, -5.528364393036685, -5.304896746902045, -4.950291837233127, -4.932751543504751, -5.115851063919579, -4.986118368874001, -5.343643561324776, -4.662052461652055, -5.131915188748098, -4.908771745921741},
    {-5.07578645865638, -4.418214801388352, -4.901835734133745, -4.98851760159557, -4.543545491264357, -5.015533321173896, -5.512853525481349, -5.008147386477784, -5.086029379655054, -4.192597692791213, -5.450437824920384, -4.792957368772014},
    {-0.0005232209017260594, 0.20722576368093046, -0.07304323365937004, 0.06920027049560232, -0.05652255955880558, 0.4493646280902766, 0.23540249005480063, -0.4067163453176485, 0.06195432615120909, 0.18297299246826107, 0.014825411649824692, 0.4675149199924864},
    {-4.3578962919177755, -4.790622629240723, -4.926569985554401, -4.57382242471205, -4.8505404681157165, -5.08719447292543, -4.629856487946146, -4.9261444782464885, -5.223181914925642, -5.287559765847843, -5.278661928234928, -4.519822222964029},
    {-4.851005111687919, -5.72808454297416, -4.883396726694547, -5.129385257658201, -4.909514314721142, -5.113820261770642, -4.546627632915617, -5.336336723366007, -5.297568098419827, -5.028932401591161, -5.335776286273362, -5.256326361590767},
    {-5.755337730668917, -4.738049272882052, -5.354047671555196, -5.134614433696136, -5.613873477129961, -4.786040340061454, -5.35497592899073, -5.688001845095362, -4.7469745933344205, -4.3460643107993056, -4.812139103121227, -4.899189123006069},
    {-5.054035452738057, -5.19189316015283, -4.909665808310888, -4.978893470614577, -5.074914453512172, -5.481271465773307, -4.918043141681914, -5.434733138820365, -5.465389113811754, -5.003281802869701, -4.391621592420859, -4.750655106436324},
    {-4.17374603527696, -3.936839103316673, -3.5804470009981015, -3.809817977613439, -3.9987374492760765, -3.965620407483105, -4.305977594157518, -4.849643240520944, -3.3863809876669206, -4.268286624356584, -4.1045681083727255, -4.128615095516568},
    {-5.010240787314137, -4.824499345967291, -4.424049854770183, -4.930780890510941, -4.6755155544337335, -5.095274708187681, -4.71271174597219, -4.4773783888629275, -4.5872610203530195, -4.7211607054223315, -4.757031158877421, -5.470200418382861}
};

static const float b3[12] = {-3.182876769674996, -3.1588995953065817, -3.102324708654891, -2.81187817785313, -2.918857727510387, -3.3065616144414105, -1.753939924587165, -1.7724727529357458, -2.2459740579888967, -2.351790234805127, -3.408021667491404, -3.1447554216913023};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
