#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.2563643200160898, 0.3215230370471585, -1.289280798691457, -2.454084765778952, 0.9902137257705097, -1.6725443468595564, -0.5240857297662408, 1.8592693991493605, 1.0289830686624373, -0.22141169600195845, -0.8360726368521962, -0.9724455119727725, 3.452493524897362, 0.30417292551094716, -0.5895810924822603, 1.4469674087241773},
    {-1.3822658378186923, -2.954532828195625, -2.8528649487920466, -2.700829252325672, -1.4104615114490033, -2.042474561838209, -0.41654636533496037, -1.0979588533821654, 0.6833960039323905, -4.020521770129277, -1.726919447835141, -3.387411020176215, 3.554524436686119, -0.4203640472242765, -2.0460662833100125, -3.038320794483922},
    {-3.200651835997074, -4.203886688494205, -3.415920006281188, -3.2386633628383374, -3.5400033380286082, -5.125814349179058, -2.807753319057711, -4.730702236665444, -3.5207162426310354, -3.5677101606649244, -4.715091564521438, -4.783469687737638, 3.031836957669996, -4.028190741205228, -4.726667007139596, -4.083073006603857},
    {-3.0459081336544154, -2.741576160726768, -3.933213259673952, -5.246083909541571, -3.396625403482191, -4.562540764707756, -3.2885000198209537, -2.5978255403952186, -2.8634133194094273, -5.872213931594163, -4.159863329991882, -3.9490719514949473, 3.2285907638308426, -3.6528992793088615, -4.378840285489476, -4.467474587068942},
    {-4.170041467734785, -3.091501686708973, -6.051099965179089, -6.0365969858828095, -3.808580485822199, -5.738060492017466, -4.496043792720294, -5.400468880349338, -3.4750755858193014, -6.301416257589553, -6.2290186548452, -6.411962540397071, 3.655961600799144, -4.2735642166725665, -6.757236389341438, -5.023047342315446},
    {-3.580389339762373, -3.125248557503944, -4.306313438367836, -4.571528831826544, -4.6791174473489505, -5.427468274844045, -4.333790583390914, -4.924490903544086, -4.718361288009153, -6.134691163501461, -4.564550459488979, -6.5197437385924, 2.8824002751072624, -3.959603299142778, -5.873407082480933, -5.835794288055171},
    {-3.21394486786908, -4.174637723908579, -4.242372037362668, -5.07975199339896, -4.316777596338418, -4.170736900815131, -3.6196565015859337, -3.975961912218241, -2.6174725849980005, -6.289875757300567, -4.5455168416385385, -5.247817266791752, 1.8381240160893546, -2.8335117310759044, -5.062976458169119, -4.13730067215375},
    {-3.121344297127742, -2.2331281053364664, -5.081431870685083, -5.794611201478634, -5.490068339346487, -4.414422164041166, -2.9992292092285555, -3.722624039586953, -2.744686422744128, -6.2894329165631335, -5.587545975034947, -5.7111518724539, 2.8118864801509393, -3.251037993298785, -5.344962863684883, -5.515647124414963},
    {-4.059235871337522, -2.896848491087481, -5.00082559948922, -4.375694946275085, -4.596682232108413, -4.908293665789845, -3.177110786087297, -3.7522017849516276, -4.056010749766761, -4.5723918546294104, -5.230527977011498, -4.440081030609174, 1.586508954033009, -2.7906052033416975, -4.618289959621052, -4.330492114779366},
    {-3.287887432400016, -3.0971876584872313, -5.610038830369081, -4.629421062307736, -3.8831774701509367, -4.167308274628192, -3.590862309179185, -2.6228860457331273, -3.8851640163192203, -5.7611368670150895, -4.453106582961403, -5.954975577181561, 3.211531120668676, -4.158127269980041, -4.422224108382151, -4.223347584784256},
    {-3.4574561302650295, -4.612505637855092, -4.526142205320183, -4.614193414060902, -5.011312729109099, -5.492661374990138, -2.9445585389752416, -3.8126189323710293, -2.7238676207767267, -5.371634883386842, -4.244190276866467, -4.806192018615417, 2.431683686630413, -2.885123680572486, -4.508629289979139, -4.371191675760124},
    {-3.404409337653924, -5.02490882220316, -3.791353084066527, -4.744947891480605, -4.269363866220888, -4.295504188966665, -3.432507260715324, -4.040206302366, -4.052884104326054, -4.549042533184552, -5.5334726294658845, -3.410252230950464, 1.3028974226560774, -4.092714236359991, -4.174195987389608, -4.09216355483474},
    {-3.0849090751492936, -3.5591337854643528, -5.433251129928374, -5.442671012625841, -5.585931846397586, -5.185993731794543, -4.505833787930937, -4.453212944586617, -2.8432151771251046, -5.42077360284059, -5.415424111329608, -5.092156335058859, 1.951518284703756, -3.2362167379695266, -5.461652427236581, -4.105546181004174},
    {-3.4208000422762024, -4.877469865757591, -5.355613792959286, -4.923320419246416, -4.546570788103952, -5.465717977605734, -4.310361317400842, -3.909594590208578, -3.914669369593546, -5.083129894513223, -5.985603664465123, -5.190632011551974, 0.3618571341894999, -2.5698890177153486, -4.84077498832649, -4.343574534237314},
    {-4.0608245415562, -4.2226898890263, -4.5580952037827185, -4.678990853206389, -4.411286200171845, -4.147489883993986, -4.470334830745384, -4.915868336972364, -3.6783920256063696, -5.254275160780071, -4.738537049602543, -5.016932780510081, 2.5819996395583718, -2.064437178278807, -5.076107365515439, -3.905319956282231},
    {-4.662552758761558, -3.8941319503105922, -5.687150755882995, -5.404320535681807, -5.8634848741646595, -5.827455859327087, -2.1194945743371094, -4.9971635345930965, -4.250726205136926, -4.592703495771273, -5.479198146422249, -4.720426627055061, 1.6387580803120037, -2.956026069687632, -6.2731250608012905, -4.27345739359122},
    {-3.395118537151666, -5.148695918356814, -5.683229641932885, -5.9709391462434445, -4.509229899107622, -4.303166101348621, -3.540611194169633, -5.0685491048143, -3.7085694674123824, -4.971292421854251, -4.70246967584909, -4.4435256422659055, 3.971681485242689, -2.3312681929185755, -5.418498731208362, -4.661614848009698},
    {-3.7072287934941026, -4.154282653550131, -5.2240675829645955, -4.8256603557751765, -5.144142132856937, -4.7957636188924475, -3.781461110611048, -4.5765127282975335, -5.194982110028196, -5.228675587793, -5.516438672433849, -5.071298007823007, 3.238109822370259, -2.3194759569889216, -5.7511461153307, -4.859922211883599},
    {-4.005377650064256, -4.683855339469528, -5.315155600685644, -4.4706311831925545, -4.97597130216913, -4.110649257094953, -4.309943951958522, -4.869590025568501, -3.955170616074236, -4.000310446153884, -4.392154174367637, -4.3253582675109765, 2.3925039610061085, -4.0427515503379405, -6.14773228699971, -4.805521886797764},
    {-3.6540499115213603, -4.39115078698174, -5.089190649654783, -5.838359332242465, -5.567209185090731, -4.192740817217049, -4.79674085439105, -3.977595907363032, -3.419576338110614, -4.364735172172756, -5.807273151708368, -4.330703747691617, 2.719147194083228, -2.7950710796289804, -4.7915695248727905, -4.504629889500809},
    {-4.054273660000239, -4.9580941922012975, -5.29617226543146, -5.126744223706074, -5.774143679088157, -5.266027075714177, -4.824678351760853, -4.049125162750051, -4.637470545534958, -5.514266767532557, -4.124064742742368, -5.158385862404977, 2.9761895934351994, -2.6691729282659553, -5.881847086082583, -3.7854508641351976},
    {-3.1675855875478587, -4.576894110116131, -4.464255485344547, -5.050804492018203, -4.484305158793924, -4.344529800636457, -4.065652413081533, -3.8011413379699146, -3.079608428369944, -4.793342805923767, -3.8925204287826407, -2.427891580879212, 4.732901056505669, -3.122857365789379, -5.024128173799065, -3.874510642161128},
    {-2.3734978972363194, -3.3938075645040637, -3.909384101864725, -4.863536771560931, -4.097927355942375, -4.516509388377053, -3.5182879883736047, -3.531296089443854, -3.0827381200857578, -3.598525022906286, -4.217910517184338, -2.9972453337022995, 3.347620645655352, -2.9353609351251166, -3.2199041799671333, -4.196505556771595},
    {-2.435056483604675, -3.380399704018078, -4.022062733133942, -5.5366737019633385, -3.8785984681258707, -4.341831461452177, -2.3229188025024, -2.65388956740363, -3.3239760556243776, -4.829894999426539, -4.557072031605957, -3.075629685025391, 3.8617383513840156, -1.8339197100858413, -5.064627887234984, -3.1567139905764585},
    {-3.017026109712693, -4.951547193409734, -3.65659110843456, -5.894055585119666, -3.323208208034236, -5.6441108619250455, -4.130025210988534, -3.177447632821998, -3.938867469536156, -4.728178333287505, -4.773039765908393, -4.371121363310451, 4.206741184964129, -2.6282426293781764, -6.004613094145749, -4.223121943870669},
    {-3.652916536416391, -3.6108588119312612, -4.244177685853531, -3.656130242509841, -3.8360999915515457, -3.664357279833797, -2.32789452928957, -2.4195736890630024, -4.485431968661233, -4.949637693501454, -4.381860706691893, -3.3672172465785537, 3.574996455258225, -2.6998080007334293, -4.710606932871394, -3.328224715468358},
    {-3.215152768419287, -4.550073981791504, -4.134526646887909, -5.095566348169123, -3.8747739318080034, -4.486826579942032, -2.1711374150137672, -2.880864275672102, -3.06161521727495, -5.076130857355671, -5.702328433947287, -3.545643785879776, 3.72515656730995, -2.568414914783711, -6.246935821971692, -4.205106755507382},
    {-4.19844170952552, -4.959743947761698, -5.271445342991495, -5.743967594805239, -5.475508631692507, -6.435756197866537, -3.950907104723162, -3.3568336234914904, -4.692576570357918, -5.304987126976898, -5.863793859572877, -3.900048838186428, 3.531885055334558, -4.117741393250576, -6.408583792344683, -5.696938923038312},
    {-3.2490638126482505, -5.363619022309615, -5.1608399386786745, -4.735114617026545, -4.563123424333646, -6.012195795071715, -3.9659268758008706, -3.5844382332253146, -4.616828948145125, -4.644306376864315, -5.541550972874106, -4.049066951904874, 1.8258454119001115, -2.345711990180991, -5.586390288543093, -4.287568717597657},
    {-3.107003314084676, -5.3192088192313225, -4.7999535987567095, -5.4041232668152706, -4.849715820405953, -5.486594068759595, -4.16048567783955, -2.387778332128583, -3.9320149504586284, -4.9038061146367244, -4.68637509188512, -3.6509612514415495, 3.171513722974368, -3.9853190419062603, -5.683349325102844, -4.360693608327185},
    {-0.2258782403857844, -1.3088909164530262, -0.03637683207926378, 1.7561393066665187, -0.3029750094622431, -0.4982817732260809, -0.4320271572764074, 0.4712288512982259, -1.4527856338002576, 0.4906348479547191, 0.5121152732860963, -0.2593405441076049, -2.404436920557801, -1.6244817917281178, 0.8449790628494555, -0.18103028850013445},
    {-3.4304986888546867, -1.3462330910293379, -2.7502557779494143, -2.914184169564617, -2.2734329551440307, -3.8380702363278076, -0.7142797784382278, -2.017007817298484, -2.7598194946671217, -2.846227283891901, -3.6740742641641537, -2.9703805528295435, 1.2696785013486613, -1.9048713917045978, -2.309977210468677, -2.2262006726523573},
    {-2.363990374504612, -1.1687944542756232, -2.817154204057838, -1.8400533447913696, -2.2915806893882165, -2.1759288613936567, -2.7705243824219377, -3.2373566136336795, -3.7947593937399926, -2.731144585727341, -3.2376745147366375, -2.640139158410277, -1.5241680891143916, -2.706464462522365, -1.4578587902220355, -1.712011563345406},
    {-1.6988089334200158, -0.746938871858066, 0.40312581106931583, -1.754671576837097, -1.688366264493358, -1.3351231709792095, -1.1193116272770887, -0.626589096113483, -1.342879302593816, -0.04890592556047064, -0.8881228404899035, -0.7406132973502529, -0.15718322263875867, -1.2516475091543484, -0.19482073139637782, -0.33158212495323985},
    {-2.7608078787986705, -1.6216556473140409, -2.3462337318432382, -2.3571418701125113, -3.5824733552901806, -4.344752255902021, -2.701727200151196, -2.920264596192863, -3.863827371407165, -3.2631247638855574, -3.143652110347906, -3.087215494435194, -0.8743769189428764, -2.663396034079312, -3.964233107506784, -2.6235092807587086},
    {-4.0552228129148125, -1.9176736009893438, -1.6806890402954506, -2.170740388020132, -2.422470112236133, -2.0769780904224504, -2.266596099484208, -2.980354348650099, -2.6060543389490576, -1.7581797431314743, -3.9291154591782917, -2.1150565615062416, -0.24957273653775983, -2.329632788287777, -3.2144821710517273, -0.8970514550580307},
    {-3.1979411162402327, -1.2798494573265664, -1.0168854617633207, -0.1640417303489493, -2.0889868209129117, -1.8085916199555039, -0.6919161425952529, -1.8457863347713401, -2.0803990091815163, -2.882815200554897, -1.2771814467332068, -0.5479316177252038, -0.5973882275721116, -1.470286784711897, -1.2215714811612899, -1.4230044196470082},
    {-2.4838014355031617, -1.0882728262244556, -1.720705601383905, -1.9953919673018832, -1.5059873714999954, -3.557538189260121, -2.219362385101796, -2.1740257928203675, -3.337006792874087, -2.2430582076988586, -3.379313626658067, -1.9534803768611784, -0.1535319290300419, -2.697402133236439, -2.3865308144848503, -2.858194028242014},
    {-4.02659655061142, 0.05123279529443501, -1.916824283574442, -2.1208044095229353, -1.7592558381880545, -2.6332611705044617, -1.379923776081827, -2.2394840528054356, -2.8118842694207564, -2.3798381766653476, -3.22964733757284, -3.02616014519967, -0.8849895150879966, -2.0584843828277672, -2.535625983917617, -1.9584389056074734},
    {-3.5755503669634123, -1.2141954375233384, -3.6254835414934545, -2.0861799052620644, -2.8331878111136066, -3.467006067921727, -1.5768406463298594, -3.502079450289721, -2.821254795953543, -3.440091888602653, -2.3541562821790114, -2.328466925449419, -1.2123237502967539, -3.2096476679859656, -1.6439612915890303, -3.1389696436546908},
    {-2.990616650940172, -2.1923011675584863, -3.1040662136420316, -2.3927296953631236, -1.0105194164977633, -3.6483386683142935, -2.723788761933555, -2.5697858683382075, -3.694880850178319, -3.537364491339053, -4.099608371938943, -2.8150023384043434, -0.5142144095475908, -2.0228078009688093, -2.6086795704169568, -1.2811587127064976},
    {-3.8758253250188313, -1.2242042954062458, -1.1153926601570137, -1.2593600364664035, -1.6163425476066486, -2.0328585589292976, -1.3651811617893932, -1.8570377423712459, -3.596210349333737, -2.3145074170179254, -3.5121928331761736, -1.9808574066299556, -1.0152089409803084, -1.9521285930477272, -2.113239963510772, -0.757558855549263},
    {-1.8995274989560673, -0.5411850875077636, -2.8270356680545805, -1.2040655688835549, -2.4965213691054537, -2.2113800645127837, -0.3191489739022215, -1.5108943617732953, -3.149614394627529, -3.412182050611834, -2.2758726134165683, -1.5095309623633142, -0.31400654142437995, -2.7218841121618147, -1.8328362803821046, -1.8245257951297333},
    {-2.7687767397497254, -0.8202171040311337, -1.7593047233389778, -2.6321040466596712, -2.5786233528940508, -2.4892793413631105, -2.3600216694751324, -2.9389740251379117, -2.771535474783992, -3.453207854056754, -3.3305965337740866, -2.35642476736126, -0.28349768246052237, -3.234187385782347, -4.114674651601023, -3.293857158561952},
    {-4.489879603341742, -1.4193689969365848, -2.543766238029859, -3.2266898960436605, -3.557481120063848, -4.166609369415739, -2.0450887268195164, -3.0932782599510262, -3.948319192603095, -3.97250129891923, -4.4763698762283, -3.9251257388688514, -0.8272622893625962, -2.682034835865611, -2.8726608786165873, -2.303932603961691},
    {-4.558152069696208, -0.9306770945399321, -2.7551291682645678, -1.2585449623761853, -2.263777073509538, -3.4388773972630036, -2.593434971893834, -2.649768804380614, -2.692395090671013, -3.8122527882203996, -2.882387241950481, -2.8554562685720946, -0.989106920607919, -2.247311239106691, -2.4457815708608064, -2.47959986525323},
    {-1.5948583499838425, -1.417864102786044, -0.2481189168582421, -2.003390992661516, -1.2103963239181956, -1.1829935009935268, -0.49575003346666324, -2.160344026533275, -2.0282630434037383, -1.6310177717977528, -1.4209695611883102, 0.2947661331269422, 0.489302582423698, -1.6299498001094568, -2.339693944619856, -0.7429791476224522},
    {-3.7350841886200032, -0.5123586240191716, -2.478475927557109, -2.5935842495327157, -2.1970237132857275, -2.611470686577265, -1.0011266081312817, -3.6317322667048093, -3.2011832677998546, -1.5079887379204906, -1.907769538926927, -1.9648274431974673, -0.302251935445663, -1.3457851360766078, -3.7574587479748858, -1.6753785233555125},
    {-3.3648404492637805, -0.8638626056751161, -2.3979475293379235, -2.464629707515993, -1.8524399800532825, -1.8558586616709414, -1.1614303188400672, -3.740188302102345, -3.5518410256124726, -2.9926617646049443, -3.6840400063199974, -2.921996424943644, -2.0851658350269098, -2.4233996690375816, -2.2052066192099993, -3.1519743615943683},
    {-2.6742643561867694, -0.9992584366925449, -3.1856218960864493, -2.1092923405167627, -1.6982295394527067, -2.674239974405457, -1.2160355419423248, -2.6080005225512233, -2.8219713337678516, -3.7646059613991647, -1.8954653730791005, -1.8885642712719526, -2.081913561844856, -2.407601810136918, -3.0160106111033396, -3.4837122297872054},
    {-3.265507373636355, -0.928657050880102, -3.313409457571921, -1.3056665590168919, -2.8918815214222446, -2.5895711360983595, -2.2329798603089537, -2.404028671168562, -3.228706977653595, -2.7711363998931584, -3.800420020745068, -2.2229585604528315, -1.07343831080608, -3.2834493655725487, -3.4339098982394543, -2.2757098344731324},
    {-2.2789896493215713, -1.6721232624738729, -2.3777821270485275, -2.5637763776435936, -2.2250068425262213, -3.390807102229222, -3.075430428133524, -2.5148997795931707, -2.6938476437590877, -4.356846435545017, -3.4164831915256366, -3.984660188917164, 1.0131580167551058, -2.716188099014567, -3.1248371103175256, -2.09874298707161},
    {-2.059448987440707, 0.048996228002423356, -0.5960318030760486, 0.27657933146563907, 0.08860843016463499, -1.1032540760661913, -0.8678732073258423, -1.3658329144665935, -1.5540590140846149, -0.7161367664002427, -1.990254266433989, -2.3801533360560296, 0.6766415200233175, -0.7821082318638422, -1.5372002220245766, -1.181710796973166},
    {-0.9364344949206166, 0.42158558035770294, -1.3468208982652299, -0.4954780022483726, -0.924320147770752, -1.7074760196470513, -1.451835424365919, -2.441003299602082, -1.3432092940139582, -1.9046070491689147, -2.8288807178373, -1.2702821235124906, -1.2265091165852726, -0.4180639336704617, -0.16883499937952975, -0.3957875369984389},
    {-4.000358247170566, -0.5706425894403976, -2.0787831763267013, -0.786011686770077, -2.6431969437999268, -4.3040876603679425, -2.2554181588840727, -3.5554101518289896, -4.5176992047418745, -4.533184519646498, -4.046602852622614, -3.0604099132214206, -0.5976824319140488, -1.7813101266290845, -2.3203700275095653, -2.481898731515868},
    {-1.9168766282674272, 0.5316859650613728, -0.24658246612322282, -0.35967666169351387, -0.5162915470298438, -2.3881356119043593, -1.928609744444194, -2.2690385497624384, -2.5795143844769495, 0.03381471623483974, -1.5712799299388314, -1.9788153489578104, 0.3914743924310685, -1.8954451209147205, -0.35717008309039894, -0.87915030746084},
    {-3.1962905999541738, -0.2861098451286408, -1.3327496920299704, -0.42427665381603363, -0.930655937281062, -1.2119503072128666, -2.3884612887569605, -2.4396875856745943, -2.5642909020631284, -2.452660590461855, -3.225637181771933, -2.015174145665397, -0.2781740700055483, -3.0682652234194077, -2.77100493621671, -2.828537113291071},
    {-4.31797027920236, -1.6093756765329557, -1.8057754390593552, -1.5027754644686822, -2.2861677911837206, -3.2050986127340533, -3.123840660677385, -3.7183361719170103, -3.019835794719296, -2.94857203450599, -3.1077921741071552, -3.0931662107102462, -1.4977085127653231, -3.141830379673842, -2.5886425744535995, -2.3415622597143555},
    {-2.933027770002439, -0.00898561941490238, -2.476826529196916, -0.5512155354686148, -2.9275244248677192, -3.0323915459817417, -2.1950173189102764, -3.592278912976336, -3.2911018274499426, -1.4008521842451345, -2.654978526361978, -2.199490517723989, -0.0899364117554577, -1.7461855011479397, -2.5696023758715607, -2.326032608963543},
    {-2.4843107616552733, 0.793112806363843, -0.49130274509902133, 0.5856666510118852, 0.2523245191643267, -1.012611327391624, -1.4482775255249425, -0.7864864132388842, -1.5853940564526658, -1.6569285777509604, -1.4427551687627673, -0.5610425450303337, -0.7041880252270081, -1.4325487435259057, -0.8969261004808504, -0.632693036312243},
    {-1.5025919679029254, -0.44125448563181074, 2.287186652305487, -1.6010959220247813, 0.9047424570947457, 0.5249906822267936, 0.03065635484969897, -2.1536650884301274, -2.3793578961947373, 1.6909614686047205, 0.8656293006207767, 0.20672527834440554, 1.6892639731983883, -3.096363665142772, -0.7510722693535709, 1.8381912402750695},
    {-2.294523601315229, -1.5300010968104343, 3.0720391246317327, -0.39905347038487154, 2.09218942363491, 0.7371671635554136, -1.3351667913097416, -2.2625816598777937, -2.262628003195831, 2.604285617969895, -1.4741416285136384, -1.3454660909711949, 1.4414711206451256, -2.8658260004432434, -0.7200593576003602, 1.1022256788587501},
    {-2.957923306007403, -0.858457964727039, 2.3760222296353595, -0.44322779423252756, 2.7606833194608917, 0.17242436942263423, -0.9663624385181337, -2.9025552625544107, -2.0571575022842485, 0.811649168413267, -1.9755894358911912, -0.6110352983111911, 1.0140190160791505, -2.0151405281337373, -1.1304017063210405, 1.278396137292048},
    {-1.4906176719736215, -0.13042241716815675, 2.1975813938031408, -0.8613783926856682, 1.5293299728171446, 0.21334476959361598, -0.15151161766398172, -2.2062947910047592, -2.124985888718069, 1.6955471757596425, 0.548392998892291, 0.866115952947662, 0.9251072294762126, -2.241592809158464, -0.48640859963254734, 1.8108328290631803},
    {-0.8960093351961642, -1.0812513456043362, 2.511065984060152, -0.3995566590403916, 3.146388985491635, 1.9536493645486672, -0.33460403611389333, -0.7983725177944108, -1.9159060607060472, 2.4144951360823574, -0.71940879917435, 0.8911109239938904, -0.5102019229230893, -0.7763633590927872, 0.6403039445387241, 2.320566711332439},
    {-1.493647634866569, -0.5376279867934044, 2.0818458016877837, 0.4725607310464736, 3.079887983341582, 1.3193967189401308, 0.8581995903613604, -0.4680298478968692, -1.339637209778717, 1.954441555171318, -0.06001554658012394, 0.7145191476478007, -0.04960709669133218, -1.1197066226011483, 0.9575094438169919, 2.3166405051489782},
    {-2.855137233682519, -1.5102015897871934, 3.008573978832448, -0.7978698210866563, 1.91717797486243, 1.5295386691894055, 0.07811607618140556, -1.8426748661255812, -2.6127368719473396, 2.0473774678701586, -1.503862668476011, 0.4070124847308782, 0.3019590682927751, -2.0717998358619774, -0.8760956849904298, 2.573044481259959},
    {-1.6475119542245178, -0.05316465491874138, 2.931386726293305, 0.35452044623861756, 1.9940420445547513, 1.837489314183507, -0.18670402007794445, -2.010004589236606, -1.96372355458922, 2.588182431525172, -1.0115886895149162, 0.43076846461178914, 1.2527556081656894, -1.762141382109221, -0.707263592181729, 2.9487842035338963},
    {-1.4297003979665486, -0.8023659262858367, 4.160411685949912, 0.6807823992428245, 3.5540033916163063, 1.6318145426446025, 0.5695570746905545, -2.0749008249988385, -1.6010317963650618, 2.68390194995907, 1.093625893235975, 1.5197023583729927, 0.39519124295448965, -3.0724190081646636, 1.029609274079013, 2.773400984544268},
    {-2.745022815579742, -1.5422885433833675, 2.4128841161281644, -1.4948644145499514, 2.4508143903802524, 0.13709379453881135, -0.6464836824317904, -2.7618839722471478, -1.7956490564351613, 2.572896106374445, 0.15507608669076872, 0.0648417218574408, 2.11552293860868, -2.808796220258991, -0.028649572184157632, 1.722539167904562},
    {-2.3916722655081957, -2.1037888020507314, 2.5943469247113824, -1.0634605154698467, 2.4974998565161997, 0.9658929789045325, -1.3876749475518875, -2.1759561991204754, -2.657217464187116, 1.919834222345642, -1.6635806100407542, -0.49640607740820103, -0.06426854346418552, -3.045459569521801, 0.02078107078814487, 1.39914151959821},
    {-2.386744687434722, -1.5727751343778003, 4.057509211405314, 0.5300656308088423, 2.8549084758801975, 1.297795026538137, 0.05439505297527902, -1.7781043920631479, -0.880811745413332, 3.5970766009495523, -1.0639466938151354, 0.11735649568974825, 2.053487346903545, -1.8762994085296734, 0.16441678372784166, 3.2170065695327743},
    {-2.1994862643147073, -1.485523687507866, 4.123202871591251, -0.5292457044877702, 4.044069274059939, 1.5619027875380416, 0.06599970077099869, -1.6066862281806933, -2.5282632462416847, 2.2537305982777616, -0.9127127740873425, 1.4934219169718528, 1.9921870139009228, -2.2207872748888646, 0.8173088683990151, 3.800483635456886},
    {-2.65364270500411, -0.12455637769658814, 3.2828002887415826, 0.3777724382077119, 2.6272874630132366, 0.6136531381985155, 0.2726322612667325, -1.375441812766393, -2.834409904603067, 2.8473339062592946, -0.5893947061467899, 0.6162331925578867, 1.2134394698343347, -2.3666627286901307, -0.5384181233624113, 2.6665742245179618},
    {-2.3084485291763897, -1.5728370669765643, 3.5851470854495897, -1.5282428980522962, 2.3728592867905407, -0.028566345244617937, -0.6731695310575119, -2.454833799210996, -2.649924816589948, 2.0179322224238323, -0.07841333499753192, 0.37855637848801954, -0.16798700584057566, -1.9235937862007235, -1.0558286870906213, 2.5528042543298075},
    {-2.3673621047879196, -0.7739403597381743, 2.5780569459760865, -0.7815959452246561, 2.2773286185879247, 0.2940781683298809, -0.4365081253186879, -2.1556272509482834, -3.039702407729338, 1.7770067096521933, -1.0710902788080263, -0.8125085781543366, -0.016869901348109523, -3.6336138928163924, -0.6452890623510725, 0.8546426234375861},
    {-4.167642118202087, -1.0715553265961675, 2.7727711988494264, -0.7415556437649868, 3.1225539967449767, 0.06262576739365512, -0.8909861387544912, -3.5443487330937677, -4.107051018714337, 1.109406702893391, -1.0380043756832191, 0.08943081843440749, 1.5232766584486002, -2.379335510662818, -1.0612712384846357, 1.264291096079605},
    {-2.806936847094572, -1.427338501664742, 4.227006247028849, 0.36083153456388284, 2.594224807590292, 0.8763344772214318, -0.5199932138348865, -2.73371507762429, -2.5093546048236606, 2.237221402781829, -1.5913499557621373, 1.3951381060927337, 1.7441712530994682, -2.37893852466175, -0.794129214516054, 3.4251030428000027},
    {-3.658089034149262, -1.3684351702693258, 1.872179359594275, -0.7230826695084382, 1.0097763361750465, -1.2436237375975427, -1.462629323795968, -2.871369923854251, -4.460900512850047, 1.8204605929852795, -2.1101001155676684, -1.084586462824785, -1.1347872765639062, -2.6993420781072306, -2.354992594712273, 1.858082411389315},
    {-2.273807332118182, -1.3824668324805451, 2.950732948750004, -0.6015837686377132, 1.7652996055290453, 0.4950078873278712, -0.2385336970480855, -2.1171359305712487, -2.4144534914736595, 1.434868609154945, -1.6908492248473983, -0.38333407454215973, -0.04445444138694546, -2.030008156253962, -0.9252281591623889, 2.8887822413215973},
    {-3.3523275529834016, -1.9839983584762797, 3.6336230710611486, -0.4888143972746585, 2.5971848204733883, 0.6964115632030662, 0.16829932326364844, -2.065174957791143, -2.2469353425409744, 2.396089238231055, 0.06406577878060242, 1.0957820401717793, 0.774534706255435, -2.939179543605714, -0.043582592389924804, 2.234609144637965},
    {-4.162560568991643, -1.4424313499235335, 4.20963872393844, -0.8523961138338398, 2.5375741475420996, -0.4407544190777513, -1.3602671481754318, -3.186991167102965, -3.2903436233313035, 2.315133252281482, -0.8157053635997823, -1.0291717849278816, 0.6764482200074623, -4.212694985150354, -1.8095490177333153, 2.023188455702018},
    {-4.131618596626211, -1.5783780012483426, 2.847858021593911, -2.482951668631071, 0.764181099233624, -1.6106290007742452, -2.1074655616880347, -3.3906227084360108, -4.66791022617321, 1.9112327171865748, -2.110095427092052, -0.37927797050578727, 0.600765048779345, -2.570598951021834, -2.4969689970673636, 2.2749853177452413},
    {-4.256405006754098, -1.0572926992573632, 2.310020575412991, -0.28006957683944483, 2.587506081426722, -1.7639201199469652, -1.6432410743425363, -3.986782043306304, -4.050574206443544, 2.2639516021927033, -1.0187248847640507, -0.14847389695022079, 1.2294837877101734, -2.888183988908647, -0.23270703412891586, 1.6266458095423755},
    {-2.4775959901946996, -1.154512437815809, 3.00002644899573, -0.5752482460016467, 1.7543415765953752, -1.0680740575750014, -0.864059296321188, -2.3575532111750754, -4.0123493122014855, 2.145507645263582, -0.21996114711643155, 0.4382908316801051, 1.3753786045214205, -2.098721824613156, -1.3776310731136152, 2.457569035082562},
    {-3.4480232680248144, -1.4645627360710853, 2.2683353341540933, -1.1295290515299212, 2.0343691040762453, -0.47649427325880434, -1.4607436309983877, -3.9260836251119873, -3.0692473146500063, 0.8953754880885711, -1.941821063494462, -0.715977663844103, -0.1590075844307248, -2.715240129079548, -0.7153103172421971, 2.2711346765945737},
    {-4.3074744877560915, -2.2550923863778727, 2.639825476538816, -0.9886991774691563, 2.441544777403173, -1.278040715959258, -1.8011864104085022, -4.097196078632326, -4.469492825568228, 2.676468350408222, -1.432904353682749, -0.8160669886746601, 1.1118825156682361, -3.811042004030624, -0.1459232251831785, 2.352296428736636},
    {-3.567104367833017, -0.9313167880058446, 4.099408599421284, -0.768361769520066, 2.8159102041098953, -0.4541287597222111, -1.4222728904065052, -2.7771251671039323, -4.344163373664698, 2.031959968621072, -1.5754210179183679, -0.2690496685251872, 1.0480925048055798, -3.473765710758378, -0.8430087169386309, 2.677667300159627},
    {-3.1474411980811414, -0.6273766689804516, 4.149193696380425, -1.7597701827473418, 1.5380555457989804, -1.031889976218341, -1.591565911097513, -3.0501751381447306, -2.917028484536041, 2.5732474368084164, -1.0637397081256077, -1.405082899866503, 1.9148684921808339, -3.3990131678608426, -0.0830278844784672, 1.8724672356705978},
    {-3.273058478239111, -2.179715784832943, 3.173235378511519, -2.2675297532971257, 2.2297372971109137, -1.5038032028228028, -2.393172387461714, -3.327546802216828, -4.329368551010138, 1.3264094533334436, -2.339601393174604, -0.41930347150884073, 2.260209205194768, -3.549384458763569, -2.361969721932781, 1.8679289198063358},
    {-0.06347405066958632, 2.4449990107192323, 1.6212888357020239, 3.4235667081059313, 3.5076099314386537, 1.3659334265196337, 0.7334943128375683, 2.018630226312061, 0.25236012730993723, 1.2022949233009246, 0.6639087474705707, 2.617881508886638, -1.361850641450792, 0.4692346293991711, 2.4881162270949613, 1.8430693360503703},
    {-0.9997794420348068, -0.3120319592394506, -0.6570688690392363, -2.614370433734103, -1.560364290345571, -1.9013976450658276, -1.4255890308693522, -3.209780113151438, -1.8609584864214606, -1.89602376035854, -2.6664191975134344, -1.097801486644662, 0.3540075519186514, 0.10892433456008546, -0.9478096043312102, -0.6559209330855414},
    {-2.6227470684323935, 0.28262275360225747, -2.0887649309291043, -0.9151016241762308, -0.9822133100957482, -1.2422903771433365, -0.20487914492287262, -1.0180440867763645, -2.4691892176767865, -2.481304847573139, -2.4630161364993324, -2.504526238536458, -1.5030963673004432, -1.7800812879809074, -1.489207969486494, -1.450781053923354},
    {-2.483300449627077, -0.22308517802483638, -1.2178567310944437, -1.5173126393311158, -1.3899823317764322, -1.0110980988008722, -2.4105159135594905, -2.091776526894043, -1.5371810944629836, -1.339679412109524, -2.0229877397862785, -2.3836854263512985, -2.9914929147406855, -1.7970718331003812, -1.9767622999052266, -0.9860448046924432},
    {-1.7651400652485856, -0.2855985235497556, -1.8356654403225952, -2.1617388154263293, -2.9931153199229175, -4.123535762970906, -3.3253220601240887, -2.9934284129434845, -3.30673258395726, -2.339038906098079, -2.558427773900087, -2.832921412941958, -0.816886957303772, -2.735382414331613, -3.157505053402502, -1.8841741454783643},
    {-2.4367074270035642, -1.6721683945675874, -0.7603058291007821, -1.1207644032871649, -1.6047502845853483, -2.287473752359254, -0.8568141343145935, -2.674020266815352, -2.7410308983912004, -1.9659890698711495, -2.3279209221195223, -1.562020091783334, -0.09332963399150414, -2.975696412148484, -0.7745849217275562, -1.340248003357268},
    {-2.1440636127223107, -0.460828967748317, 0.2210713893905752, -0.6669405443184584, -0.39732337562346487, -1.7383237592875938, -0.8534501721899572, -1.155847317240254, -3.1552015434955734, -1.5166216329648718, -2.2761621538428414, -1.286122525209212, -0.9106623816056529, -2.3492905099579704, -1.493211856049418, 0.15079162668738372},
    {-2.640139362840169, 0.08211788522696338, -2.131449775684671, -1.0710476523745998, -0.5128138427336623, -1.3184794884752271, -0.31871604911538354, -1.6893188531321643, -2.219366550879407, -0.7283299437057996, -1.608500761213182, -0.3158928606851591, -1.683374294252961, -0.11011836384152478, -0.9955873133398202, -0.9102414250500197},
    {-2.5199993611708096, -0.5156078484389743, -2.174791224466716, -1.016080528963609, -1.737388685889889, -2.734391702697908, -1.5520830944349422, -2.822469978608458, -3.816818116755943, -3.232576931291103, -2.490206682468649, -1.6144189125702957, -1.5377676306360917, -1.562933338988943, -2.5558181384493066, -1.9312851622563896},
    {-2.69308255927012, -0.2390463080685999, -3.412306335875751, -0.8341967067185451, -2.6887426930618967, -2.9009692700567515, -1.9648941544833067, -1.5761127364354772, -2.6252789148879523, -2.270253403294103, -1.7832927475147013, -1.606352122438217, -1.428447178871521, -2.348166291903355, -0.45067121267405236, -2.0592338198548226},
    {-2.325021895358817, -1.3733810932113613, -0.21998474190320375, -1.1772067690925458, -1.32405394051468, -1.190605424188585, -0.4698627830229912, -1.75024813498046, -2.0915975188006697, -2.2709113462225496, -1.2508071256997912, -1.3044632289516789, 0.28108482609977087, -1.8893186427831226, -1.6763746183648525, -1.510737963028147},
    {-2.394680642068624, -0.24154662036005511, -1.8578525061232438, 0.1975000716680184, -0.6155052491594276, -1.3094011247515878, -0.43560026232189203, -1.102319988464723, -2.5450496827390787, -2.147096542042115, -1.9073814153885602, -0.6368841042193463, -1.2561375342681262, -1.5034003252548072, -0.4541115727689841, -1.2525128572495627},
    {-0.8252026093529496, -0.13320248383277666, -1.4831925286863386, -0.3648084303457503, -1.2286122463523155, -0.5684701976824894, 0.02583162261869043, -0.992784653578127, -0.08943044749134871, -0.9259834621928449, 0.19039807441000625, -0.32575056039199907, -2.195676555644709, -0.9576061478914116, -0.2265043765463448, -1.1481667372774387},
    {-1.1984972216306475, -0.8934522920279437, -0.17905531153197085, 0.6340705548713186, -0.7148770297865028, -0.3673543094409849, -1.5155649789652499, -1.1068628279992359, -2.068558208428404, -1.0854729834795267, -0.5798548022085127, -1.0839463115627763, -0.4145409455422579, -1.8623865660010124, -1.1159074105664142, -0.8927566783695585},
    {-1.1988917138934636, 0.04478485941300616, -2.4283909392686405, -0.38238430938808066, -1.3395015100690721, -1.289032574646172, -2.35421912285596, -2.383399400517916, -2.2556481419643077, -1.7220702580725213, -1.8323157267851853, -1.8233526813305638, -0.6684352571784279, -2.6088729762528398, -2.278996922109889, -2.197010071444769},
    {-2.3020054954638103, 0.48717193031404077, -0.3993175381332754, -0.30010180836910083, -0.23499600676304636, -0.18030550509017002, -0.5461806957535084, -2.125883411322074, -2.257753854419242, -0.18153850264541244, -1.9020637880931353, -1.4092861738014792, -0.622148234378541, -2.153225343352278, -1.2646198491685368, -0.9657682772686186},
    {1.3015195406497353, 1.2375998146552818, 1.0860755278030814, 0.7199896377024617, 1.2580500418965095, 2.117937618777939, 0.9077965633446561, 0.5445013901822391, 0.7571613069786598, 1.5640793863825815, 1.0372269551063011, 0.7153265871071651, 0.6192546216369265, 1.2443520796301437, 0.5707719387423422, 2.0584217628553256},
    {-1.2993384291439583, 0.9480868110593408, -0.5913623785952862, -0.280763788795388, -0.9513290958096006, -0.3197670594750925, -0.8069045759701444, -0.6187296964440381, -0.2526921733891952, 0.2349168073698911, -1.5704178324408589, -0.7439982301382377, -0.5073964469235966, -1.4581087410835618, -0.7779211025865512, -0.8419027263526111},
    {-1.129190544074435, -0.2965030597522008, -1.2583701972446608, -0.8953928544117388, -0.8321687897362559, -0.9243698129053638, -1.0454713977960526, -1.360193407305625, -2.5314284971840686, -1.2939024016442604, -1.7156165813508222, -1.1626023773846053, 0.04187557420481792, -1.1528481125322632, -1.8207683238350503, -0.47639160146955384},
    {-2.167384190893562, -0.890613395186903, -1.042336449055539, -1.288472841077769, -0.3141886885980086, -0.6864370142182703, -0.18474310363034285, -1.3870948923657866, -2.2562340967946115, -0.41395165643863074, -1.480514847822375, -1.333378934917299, -1.8686062208345087, -1.3064569168450229, -1.2734050044427798, -0.20769230448941062},
    {-1.4670173503893758, 1.0185773987815212, -0.37232058143561897, 2.04287710477247, 1.4154295969644615, -0.41884932199282915, 0.05595740246708188, -1.010856473921425, -0.7034442491961713, 0.5296988590755298, 0.41850968262991356, 0.5406991063098774, -0.4391662047053289, -0.008804250214449916, 0.24293426046736127, -0.6449833658896077},
    {0.5668035384671224, 3.1955009536956074, 0.8234859127454774, 2.056763133107605, 0.6823968454273945, 0.7638520268590978, -0.4324347055841458, -0.050372729507060655, 1.2805330745214936, 0.878768450120044, 0.5175507028125059, -1.3713639737334071, -1.0574500846440094, 0.11169614384319101, -0.009338395813972875, 0.8819726572511312},
    {1.534599682867832, 3.5803960547514806, 1.3436219315685893, 3.6528814817255215, 2.01301196944844, 2.3972362876709594, 0.6870168766094651, 1.1945812137267406, 1.9354453587091118, 1.518240221866445, 1.3391500741520859, 0.20814952030503264, -0.8905099227049715, -0.03072298476897889, 2.903586500763633, 2.2951942540892105},
    {-0.24906773889837877, 3.0356650270624064, 0.9028951026468803, 3.9324676274838737, 1.2102023605600216, 2.0498346633294493, 0.5010234022051325, -0.006149247968423193, 0.12398816690671852, 0.9361935915473727, 1.3798015998546327, 0.6444689664716398, -1.9645080720307024, -0.7409328120549039, 0.3803252154576251, 0.6198954764538606},
    {-2.577415496655456, 0.1930347745426854, -1.8242007661148698, 0.43487083676982236, -0.5016418927711609, -1.9831094451097016, -0.7339022721355164, -1.26722066875271, -1.9975757420976625, -1.3816067159153989, -2.393858673067132, -1.1758819280635828, -1.7841585761228214, -2.204082563788731, -0.36366807419124825, -1.0661636639922072},
    {0.29202407270932035, 2.501293858764368, 0.8421983880708188, 1.7937168831405392, 1.6283660842020982, 1.343844455552134, 0.2524543062218395, -0.38146268585765286, 0.7356932236989943, 0.8998525369151636, -0.35215583882224666, -1.0383557578092117, -1.7874614920426164, -0.9116607016609987, 1.3215305281809333, 1.420414892982748},
    {-1.119506530461074, 0.9195699651847199, -0.9096591576765493, 2.9674831112624895, 1.2555171943668817, 1.1654262134706994, 0.2551344676651213, -1.838813639431557, -0.7669004948730329, 0.43276858807018853, 0.8392799260893776, -0.7346496516886238, -1.256157210025646, -1.7882662629236317, 1.7981542671173043, -0.16736038036433726},
    {-0.7129424484235349, 1.626540342583095, -0.8590723528531947, 0.630311086598129, 0.5969555366600022, -0.011056324228667706, -0.4851425907019358, -0.9358978852082713, -0.728123671577805, 0.9067977098617023, -0.8004389125730392, -0.7558442192245423, -0.8045958226770191, -1.0953272680215895, -0.30226671911188124, -0.04355942268146219},
    {0.027246980747978232, 1.8358213569570607, 0.24430060165051246, 2.199655867456722, 0.6862408334500865, 1.5484329993142325, 0.2616911189990126, -1.4820942592748605, -0.3096393878075975, 0.6951150738857882, -0.16112147961314205, -0.8596536166530503, -0.8045136621155919, -0.7097351987599061, 1.435235129536555, 0.5229269275138083},
    {1.1317017396825237, 2.3710185717059096, 0.9541747635201946, 4.067966048739557, 3.5863491386967783, 1.8833572168770332, 1.0860922761389595, 1.4161349591764618, 0.3532970702918612, 0.9854846898331444, 1.920915480740289, 0.750240800846886, -0.5806143141861975, -0.2442318958567755, 2.0235105438132166, 2.518042187584401}
};

static const float b1[16] = {6.725312827032806, 6.309747520952125, 6.692007632002186, 6.557313866018121, 6.329581807877799, 6.402438488338443, 5.0482335924467225, 6.131592131197792, 6.5955430827796935, 6.701397320638253, 6.55273071209298, 6.704913171966571, 6.354618419190208, 6.769102853115994, 6.478630247431051, 5.975045347083962};

static const float w2[16][12] = {
    {-3.476069341755076, -3.718724394073784, -2.147712555911172, -2.7789404887003117, -2.982177011290052, -3.8438969345434844, -3.54975046366729, -3.3299384373795284, -2.167115031813853, -2.74172657177454, -2.7550737311446705, -3.3715710888987234},
    {-2.5136042213319447, -2.216999663422409, -3.4042308049678276, -3.6595600849213525, -2.7541693567461456, -2.623791783153826, -3.591018568524028, -3.4787027637922825, -1.8965369537010408, -3.194185053362154, -3.678181302820756, -2.9772078973736162},
    {-2.7596618261888786, -3.841631592744473, -2.945582015249773, -2.160043495571085, -2.8396759710933814, -3.964190229023647, -3.7932452808371373, -3.1890127049511228, -4.431955420891858, -3.6424681155067917, -3.757707286801158, -3.838684336593995},
    {-3.9493280502067614, -3.595788884461331, -3.0363570627663634, -2.9698848912400924, -3.420184878918628, -3.1539544467321754, -2.563910444566196, -2.6549455268248123, -3.130559862770409, -3.0514638187332874, -2.26135046920558, -3.104644863926271},
    {-3.2885979524834, -3.369145823742816, -3.8197193706283823, -3.737752940261687, -2.7831923940674446, -2.3983530176070422, -3.4882895567917838, -3.3340065028667825, -2.413280721909673, -2.8973681166699508, -2.886142778054102, -2.55634299237499},
    {-2.764147376813166, -3.4881812141426627, -3.9398722341278347, -3.0751711848716075, -4.1350868759486845, -3.370015419299295, -2.934355244220463, -3.8183534340017946, -3.3702286341366134, -3.7523692280141914, -2.8090714182610363, -3.6703211868224357},
    {-3.5324335984930677, -2.5826136044535546, -2.2387998259189597, -1.9056907351341437, -1.9689799805896393, -3.593449423357461, -2.3871343525170143, -1.7592387429538117, -2.43207964452667, -3.2519772077176934, -3.8204898335871524, -1.9171619129839137},
    {-2.5190470772928597, -3.270806412805859, -4.004674302329972, -3.837949396765069, -2.3599846023709445, -2.7938128946144105, -2.1087793427135213, -2.570934591275545, -3.03683021242624, -1.88384012225087, -2.546727574098911, -3.579973283524337},
    {-3.2868287142323416, -2.941160637648221, -3.501197484886743, -3.9269220218639567, -3.014138960726229, -2.323526075396626, -4.0007855606671905, -2.6522696327913864, -3.7285546579592177, -3.886228982764678, -4.003750247983291, -2.5793203644407914},
    {-3.7289837330982283, -3.00288288378094, -2.4480594897770107, -3.6644382120469556, -3.067475432213897, -4.16032780099192, -2.6489503836211012, -3.2348030771372485, -3.1570751598019733, -3.4332323101107622, -3.421017996607517, -3.379714952643185},
    {-3.4880754415187023, -3.4968994627909056, -3.811934739011434, -2.8354210191603113, -3.9151739222920043, -2.5638025865529452, -2.9383508967840557, -2.7197090464438767, -3.33551986743715, -2.8292962055593303, -2.7643273302847855, -2.4803243533078683},
    {-2.0785289378769667, -3.7009398406824396, -2.170790724426133, -3.4650323087766073, -2.2048002877948845, -2.5760407910503407, -3.64598871450852, -3.3967462626145912, -3.7756415272330104, -2.6808244441198434, -3.3829916540673244, -3.3950814616376985},
    {-3.8416223045260267, -3.7905260469672286, -3.6593957910700903, -3.7048998019028123, -4.000303327689716, -3.593862120847522, -3.08650978069358, -3.6947287967424964, -3.290776757441263, -3.3330972618604924, -3.409895089802621, -3.279007304625938},
    {-3.1071036493744204, -2.3532336378708556, -2.4756883722969754, -2.162367654664337, -3.7820751091727476, -3.2788231161397903, -2.455105037071703, -3.883760881079325, -3.4653186396142637, -3.413020113806132, -2.9319278724434117, -3.0142659300490995},
    {-2.51146171138714, -2.7085293619146964, -3.034775143858132, -2.5825627783463383, -3.065015786113921, -3.755136796708583, -3.7246377060190348, -3.7987246265274583, -4.066594180953825, -3.410289925223964, -3.042651083433013, -3.818393136747325},
    {-3.56078571683971, -2.001764403912679, -3.5941712251458933, -3.7869261695805188, -3.9180047562738727, -1.9931901045544549, -2.87803290104045, -2.8433397373945613, -2.2402596623184956, -2.5809600242348445, -2.8551188313733036, -2.6908195616368955}
};

static const float b2[12] = {-4.094884104696834, -4.0355636032036974, -3.3553704361999417, -3.732676484812384, -3.6388072859063536, -3.493758353781177, -4.248153181497207, -3.4141744913632857, -3.091096942039933, -4.124313156717055, -3.188474697265618, -3.885180275392935};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
