#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.8830063082494513, -0.5999918477434474, -0.7993385742014668, 0.34286765329548885, -0.9453273527928105, -0.9020600124758595, 0.350958752722007, -1.0744093647272084, 0.3317030907245175, -0.6638006272920032, 0.6475360293044972, 0.0525001536513198, -0.8724596772185176, -0.5479842746881363, 0.5513038654377185, -1.1496916612906587, -0.5980971582278838, 0.44107521456987425, 0.691919607987471, 0.3233732712911129, -1.1312032755383905, -0.7980386879357035, -0.009380278659573353, -0.955147407701827, 0.6252511814220226, -1.1492248771272469, 0.39256706527928736, -1.007136128865793, -0.4585940832575175, -0.7565315711179539, -1.1278230707913395, 0.42291205804004706, 0.22400630590137566, -0.8626710104284386, -0.9903953072414042, -0.8342326769541589, -0.9490669070797114, 0.556542015915521, -1.1782369621512883, 0.7524617313621436, 0.3370227261720094, -0.9120595052807411, 0.00909797310747294, 0.1329132124275757, 0.587068974490179, -1.1344036090747427, -0.9795993055369383, -0.3882346901684594, -0.6835357840637704, -0.3907396457239085, -0.8920097046163513, -0.8486518692045334, -0.9170128923007836, -0.9981236682586175, -0.3038036101379188, 0.4009705429114515, -0.7987131984586205, -0.5599752841011767, 0.24772570040406489, 0.23505131779972263, -0.9921127538668559, -0.9062288813096959, 0.5154546870503155, -0.8204764570296013},
    {-0.0962520527107275, -0.20193090648894446, 0.9172470429097095, -0.818867589842753, -0.5783945231243994, 0.6662933389435443, -0.7763130521819963, 0.03113729904964327, -0.8418578374978157, -0.04346260894943111, -0.9647178535463707, -0.6163865475685185, 0.0792866893716223, -0.5050241997861186, -1.0228685156054804, 0.6575337123104275, -0.3809421718242937, -0.3516676251051653, -0.6503426693272237, 0.009417253489277255, 0.827536397157313, 0.546058488338498, -0.4374145362786869, -0.02505602268395443, -0.4922383829047379, 0.21807431322931015, -0.5647104640623022, -0.011424268760046166, 0.5039576949309831, 0.5833374258148257, -0.19805230856678555, -0.3260911799116742, -0.8340868387455368, 0.07184944697107465, 0.8923516872539372, 0.96613556999141, -0.5463650617602301, -0.413297311761765, 0.5490469065945218, -0.7526957402515416, -0.004498108936929127, 0.4391014411492799, 0.13207779893969257, -0.4212423088221786, -0.7990669771148253, 0.40034240983134645, 0.7081760711444005, -0.593267133901364, 0.0008083413634524665, -0.3592184749415392, 0.4873472672228202, 0.17027256084500478, 0.11613772925026965, -0.06380003352375647, 0.4105866728331126, -0.531275228064478, 0.027555770406707255, -0.30951205085910627, -0.5816029382724884, -0.6500382406778255, 0.7969511528301734, -0.2245447419359397, -0.6831903849560952, -0.5248238721243963},
    {0.6271591962710874, 1.0011133306852669, 0.8945743475852566, -0.4990370259664642, 0.854382382213406, 0.47171453537684427, -0.11481160465678285, 0.4886325160559805, -0.07404855527759312, 0.8008783885738026, -0.03393901761618035, -0.5129835620489224, 0.8478307522917758, -0.19649643782753218, 0.17055152522690276, 0.2735234365771647, 0.677095467218738, -1.0041998467217506, -0.47667100984636795, -1.1461924162760677, 0.14300868631096944, 0.22472951019834603, -0.35599482768860796, 0.4333514287819725, -0.3940815489759339, 0.9483307570725542, 0.06825302380233618, 0.31781355096784036, 0.17829014069668428, 0.10351831602723392, 0.23526746399140752, -0.26569706721720887, 0.03489661995218406, 0.18905951875518687, 0.7003419706797084, 0.43130021418836356, 0.11512232189533529, -0.01215730266093807, 0.9249412261118503, -0.47863828252290685, -0.8469406838906628, 0.7406874932585167, 0.9250161683294437, 0.36755633475632526, 0.41493127135817176, 0.25408460562049, 0.47536644585646937, 0.1478329357253444, 0.7810826544725301, 0.9886229909339074, 0.06496720478173076, 0.813035647688755, 0.7439639821619829, 0.32868507170039063, -0.868863870493923, -0.23011596909272183, 0.27998568382264993, 0.058841479866983404, 0.17605677081554985, -0.2872697745536421, -0.27047398715497756, -0.010129443101554019, 0.21796090592560904, 0.5759918341929308},
    {0.9256832082631784, 0.7634362534031249, 0.3835996816045685, 0.8715440160104218, 0.8501371116821729, 0.43099606787724964, 0.8938683270819524, 0.12279646304651487, 0.5319396618666374, 0.5990425562040379, 0.6757484156788783, 0.5595844751123527, 0.7914770178154276, 0.8873625900181364, 0.579544381821536, 0.25767572706110525, 0.9739183976706484, -0.15087832970246812, 0.2964030082219428, -0.27451374027852865, -0.18919249381161246, -0.005437033953754454, 0.6206671089285326, 0.12515170199012918, 0.24762738940942747, 1.0493139656156587, 0.9249358943152912, 0.574159777132954, -1.0321921325486103, 0.7421003391470411, 0.4735453543492418, -0.03628999106928262, 0.5284242634718147, 0.4950596692947475, -0.1255817898883747, -0.11094893866596921, 0.37309056171097366, 0.6149736389363557, 0.26162146363496985, 0.6923219536021702, -0.09345867194005786, -0.16460760024531937, 0.618142314374431, 0.20636339494967357, 0.8988512786473035, 0.4251735363104105, 0.30324068447541497, 0.029143699643177513, 0.6474412021524345, 0.7742358579472094, -0.2971292833678297, -0.4447727456125967, 0.9883904819145031, 0.41198187052144625, -0.18801904086715024, 0.6004425860265706, 0.6572682119781715, -0.09254096731662746, 0.7217099090192478, 0.5679127586289875, -0.39191232712255747, 0.6239403304406689, 0.9176386664692369, 0.8396340287226409},
    {0.48673378264549716, 0.8183577392719837, 0.844872064209292, -0.10979231809442495, 0.7083380955851173, 0.5335243792617362, -0.011324069952848844, 0.8305499201917221, 0.19792901142585065, 0.7563225779921529, -0.5327121202241156, -0.5464915763921248, 0.9000302729816482, 0.10053359130389934, 0.4380720741737286, 1.1227597102402338, 0.8176591308506642, -0.7450529953709845, -0.20384080637676777, -0.8902267490322815, 0.3319581199588627, 0.5455689437848477, 0.48876596762102786, 1.0059936445797106, -0.36879434991176074, 0.9158505776288304, 0.0756172131279689, 0.7726080231718966, 0.08960423552772798, 0.4027275307858056, 0.48020120713616565, -0.5636419808349024, 0.02784794784606983, 0.7547365083003063, 0.8364642791962434, 0.8153084670039871, 0.7378276013796401, -0.03668938267729376, 0.7254267964244255, -0.5309676247396301, -0.6763446030427834, 0.6031402435576539, 0.2647613878433206, 0.4112666585372517, 0.2845566088912787, 0.7371850564683746, 0.6599469111603441, 0.7232017548034567, 0.6591073292525693, 0.9325126262404705, 0.39774215131522284, 0.672167695540608, 0.6880087222704232, 1.0134116838513636, -0.7232667628196537, 0.24930722767715743, 0.6607253617236768, 0.5107913013828412, -0.20548662318315464, -0.11360428497086351, -0.27445764823734936, 0.2600465869430424, -0.018309192922766778, 0.9300492049111224},
    {0.3707827809246413, 0.5166156344559777, 0.50217070102206, 0.1873831488618054, 1.1817701132956715, 0.3570074325901374, -0.14317771171767746, 1.1422747462906204, 0.6986536028084582, 1.0895705326302465, -0.42132569819445587, 0.23720401384725684, 1.505773483607547, 0.11197541301202667, 0.2439261661453662, 0.6515881733181538, 0.8117060577391272, -0.8876931559952199, -0.40359299912869373, -1.0125280010998605, 0.8029430119407686, 0.33305574939772314, 0.5533850946019077, 0.9166502876233098, -0.7563344884257214, 1.0576365083018915, -0.528400020107198, 0.9674538597103218, 0.460221885615459, 0.4591588128205558, 0.9531665655899793, -1.3818058768320411, 0.11630974240268682, 0.925749670123269, 0.7521213799478161, 0.6300967210789454, 0.6769719103460602, -0.35594860160921493, 0.891740841213574, -0.5583636163852322, -1.0481719140662191, 0.47697234726548526, 0.12355186180487837, -0.15280936408493823, 0.5726284013020213, 1.1824776777855257, 0.420434622458067, 0.7821695361687079, 0.905491808166931, 0.41312103978616016, 1.0791120276310624, 0.9997670355147911, 0.7355083000673026, 1.1228852512310006, -0.5720908604457458, 0.3552277683948925, 0.2966407362257183, 0.41198563103514196, -0.5178025842752209, 0.20253007797121877, 0.296792770425356, 0.5068341126771989, 0.27342919466687954, 0.5073572530260118},
    {0.5869099515945861, 0.7605217429757352, 0.4094397434286047, 0.04270539883011767, 1.0618004050899759, 0.8969142874361754, 0.34728770515660656, 0.8507516680241516, 0.8269475231120229, 1.174712834391519, -0.5187930205576239, 0.32331971191854525, 1.1800765381209046, 0.010216728736987429, 0.6875295385573518, 0.734895134729364, 0.8591869792127204, -0.8691452182690893, -0.28056879583232847, -1.0445579937374931, 0.7322696383190787, 0.516586109320277, 1.1501589745362237, 0.9145525701974458, -0.8853201062433018, 1.1552002172867635, -0.07193243379828984, 1.1085696575765716, -0.04524327306734685, 0.7602816798553645, 0.9769486268959385, -1.0372348390721444, 0.1805205046606778, 0.8357285640326074, 0.6764948631120486, 0.888347460082705, 0.8674911990592974, -0.09512977784430825, 0.901493221012021, -0.9403602300605577, -0.4457572486094395, 0.4565841347922287, 0.13136865433106665, 0.4028232935381177, 1.0064534199462107, 1.1724215331833938, 0.45041595803905865, 0.6358431835604484, 0.8218170510431266, 0.6818771719552871, 0.8662704041561041, 0.8492171705536435, 0.7607982804316958, 1.0977200410727082, -0.16299026258488833, 0.232276605245809, 0.5254769368741645, -0.02749860442751782, -0.16419471691682697, 0.654384617478608, 0.5445169372010792, 0.8386555778635373, 0.5424304674378106, 0.6839800262907489},
    {0.6543396036531544, -0.015820942704160398, 0.5707892511236502, -0.5210124788421179, 0.37391243741327557, 0.5073370000503014, 0.08362565347608752, 0.37492173489489883, 0.29067737608605376, 0.45380762889344406, -0.4477748665620469, -0.3541027069021345, 0.7983486718241227, 0.10733090027203837, -0.7403744427552194, 0.7780366094446391, 0.13796671024204754, -0.8873626158538857, -0.23832286221421395, -0.3799852974764825, 0.8233482308743268, 0.8595749426909864, 0.708249133287717, 0.6226899263764797, -0.0024319277854226735, 0.5261480788566135, 0.09903186232996673, 0.6008410386827728, 0.2573850782441191, 0.05919601664305701, 0.5997586714303371, -0.33623610601530934, -0.44242603985524664, 0.4624164050434963, 0.869642866587533, 0.826055793384281, 0.2250353749362662, 0.4209206545227703, 0.4510706801332276, -1.343138336636561, -0.4114244901357714, 0.6533462380580491, 0.3617321079889219, 0.15680790611702525, -0.4345365825918596, 1.010326376345458, 0.5600025369729535, 0.10723943479530489, 0.34113098364907224, 0.5301931145717905, 1.0298401260220287, 0.9646878028632537, 0.0684934859780289, 0.42515345045209124, -0.06353903604064338, 0.027760167533568435, 0.28178429959764456, 0.5147183452996402, -0.41506029630182895, -0.07416557809099582, 0.6468860829056902, 0.3600793258373235, 0.5662836704448475, 0.5053786088017573},
    {0.48679316357160374, -0.1049313120997824, 0.5771560049128056, -0.14942941924463113, 0.3440813610012506, 0.6807185136858971, -0.25876308658002056, 0.6179712654606214, -0.5360895910298565, 0.623630705781768, -1.040239831516973, -0.001965314004888919, 0.6758944055308, 0.37664854334381714, -0.43148386728695126, 0.7750788701956981, -0.2832455340363497, -0.7163120074248236, -0.16942864539045668, -0.6078089998187651, 0.630353622597876, 0.555233719269334, 0.2703309430195668, 0.3228685990284739, -0.4683080026513518, 0.5965780742265775, -0.0124640471018142, 0.48239850014500835, 0.3293840904717957, -0.01813318705098927, 0.4235835159449469, -0.804165135788101, -0.7755483988771951, 0.3979626514611851, 0.7441612145714567, 0.8602206852921762, 0.052575312732877105, -0.3817549032883289, 0.6349731877110576, -0.46647222786050657, -0.316347909019006, 0.467999806458295, 0.15133274328222818, 0.10112025138198177, -0.5473278564533149, 0.7440960627158439, 0.4443591799452645, 0.5530108918948914, -0.17156794319960117, 0.37479951958296165, 0.9400024639032857, 0.43638135491142926, 0.1704402106920499, 0.8782546801765908, -0.3792703962472799, -0.011788025019334887, 0.009950490454829977, 0.22140837264807703, -0.5069912219609652, -0.252583176113795, 0.4099368953181664, -0.12585193967771505, 0.2896073549722057, 0.4762823970416339},
    {-0.1914729609005864, -1.006131575275341, -0.1602305062758345, -0.07000904396614693, -0.7345202828258668, 1.144968216699726, -0.8369194207736708, -0.1336209771161343, -0.723316108854599, -0.16455157994716071, -0.9789175049813731, 0.27949178393594715, -0.17417310702440572, -0.036764995220289705, -0.7279772005736057, 0.12727736886619576, -0.43244592344073185, 0.05525616474100938, -0.8514866859868739, 0.434801296958808, 0.45843368589504757, 0.12362781851368856, 0.14885439835760267, 0.33257214598350826, -0.18039344501272003, -0.6864473037094493, -0.15162182649057512, -0.06024472516202862, 0.35867512677576896, 0.17296077192636516, -0.42296155700423, -0.2761915136920418, -0.4558908538723735, -0.13853783977249448, 0.26199398209861363, 0.5360660841618561, -0.5368344228675758, -0.1653738132922498, 0.08952363444722106, -0.5129214419277442, -0.3306964598320683, -0.013410422367461077, -0.8198364051179489, -0.4928729363893009, -0.8255600346734129, 0.3253563264558006, 0.6332727192400467, -0.45482592597437305, -0.8581063658761096, -0.7856838019157873, 0.27118478819487946, 0.008031720226038193, -0.8208613229110265, -0.5482124915880908, 0.9237579442614177, -0.4819561340545369, -0.15924770364979615, -0.7398401202918818, -0.6489828740917662, -0.7831691127453371, 0.2282207340216567, -0.07516668417233822, -0.7022292283529782, -0.37396457778443554},
    {-0.18958154225952345, -0.5154884215319366, -0.12925945544972686, 0.4125063894529104, -0.15896149569685733, 0.47006451333176796, -0.15706666534796007, 0.13118139665013862, 0.09453029843692776, -0.4019010849151792, -0.7052276889661605, 0.20374742960233042, -0.27843712676821475, 0.1624736558901759, -0.369880087531338, 0.03834039669202463, -0.4001009679219751, 0.09657697219279451, -0.8413669149826081, -0.07193442668642545, 0.8576076052510785, 0.120758176246353, 0.06822923107661034, 0.0742419715230096, -0.11701864431399739, -0.022099333966767977, 0.1910567413430957, -0.27875634294758594, -0.025749836693615063, 0.18103536833833916, 0.047945236206706, -0.27708046080309834, -0.1377382082756441, -0.3608501365135062, 0.28850970670599824, 0.1900468554200094, -0.04181040873300059, 0.5140904998990535, 0.3411919539018203, -0.20746467288852463, -0.3588540438933745, -0.294911875784889, -0.4734452095914599, -0.5441676997662301, -0.15836375408253064, 0.16894336834185006, 0.4657033417881658, -0.31611565027059974, -0.414896296794487, 0.1274825966204403, 0.003217222524648286, 0.054826747268019664, -0.2159816121530978, 0.057819694790211436, 0.2958953111104009, -0.2845125134802924, 0.38893114340979157, -0.483847861443281, -0.3219074028603193, 0.09044074503310898, 0.20034984344652138, 0.2209951111247368, -0.4799569209934998, -0.37649781002449306},
    {0.220960229085759, -0.18373129296266735, -0.5917401349558821, 0.019877336067011447, -0.6117892063940582, 0.2836850963864458, 0.03676829276049837, -0.48779396915875833, -0.4188889603228094, -0.2831246120781864, -0.48742106924982115, -0.011760586379109105, -0.37768481291513234, 0.48042376390349983, -0.12739106280457285, -0.5513454080020098, -0.6472209160031057, -0.054648000201793195, 0.3837824821446989, 0.07394140583980494, -0.8553021122429895, -0.07968485160382206, 0.059952796683797084, -1.1479359765688455, 0.30133051362569246, -0.6188331038655916, -0.19263248049255305, -0.12031735495519805, -0.6156202836764613, -0.37984929281178176, 0.1850541635303882, 0.4061612403665927, 0.007177354753086868, -0.5795940497627591, -0.21041652306450676, -0.6961376678194363, -0.6773751252725979, -0.12652212452273712, -0.19812145729392586, 0.3095540573112939, -0.10256925496023953, -0.4769831460751545, -0.44858685214802557, 0.057891402724608486, -0.18424693457065988, -0.40250048646791664, -0.10260417005359755, -0.5297444686282032, -0.1157107176366377, 0.4503483548586466, -0.16549733889160934, 0.007378912988410054, -0.04167058693830607, -0.4770214353412628, -0.13559925922867863, 0.3108913302758245, -0.6758353446175138, -0.4052808811852753, -0.37193617299688486, 0.03612490110498157, -0.16931656070211842, 0.4664112585280822, -0.20202181053705204, -0.1559852215831112},
    {-0.9727541494261195, -0.2951402340560843, 0.3069398824596365, -0.6246638526210546, -0.4754204511451915, -0.2966065651339706, -0.9142994473418008, 0.6489831443883219, -0.8830596324072758, 0.4580658766306497, -0.7082036133660595, -0.4890412201546967, -0.7858427486467346, -0.5336346042587602, -0.7951342313013401, -0.17479278136073473, -0.7082107211316583, -0.6060803742117072, -0.8283795458870383, -0.21518034727408583, 0.5305412655346671, -0.07535729877054687, -0.6118725074910158, -0.10548147783806423, -0.6084696491236357, -0.4898641091403107, -0.9692110149290574, -0.6255997666045381, 0.8372532597545779, -0.689979943511363, -0.5122023227800241, -0.5386912341319983, -0.6272877745425082, -0.8664508577297035, 0.5823547812441366, 0.6280129958791277, -0.7525350501249118, -0.7123435893108332, 0.17627197069856562, -0.6734050251897833, -0.48210389798772374, 0.8299213136875614, -0.10789480065626694, -0.7296907910687033, -0.4928132678009971, 0.13076723632881757, -0.43676186809355294, -0.27428203667919204, -0.15249066798353406, -0.7792054518022747, 0.8830407444671454, 0.6426837466334995, -0.6414408678111132, -0.17363133710407033, 0.26186851375465525, -0.857513544154224, -0.6546699769207096, 0.050354011013225154, -0.5195643711324117, -0.8517827131512307, 1.0586503223091925, -0.7738555597645363, -0.6286545075389782, -0.8621602089212406},
    {0.7005373050938444, -0.2922391331554481, -0.8611498555195137, 0.997927278634462, 0.3026036266912842, 0.14979238569176045, 0.7640374344936628, 0.2830413980189502, 1.0492216905005682, 0.505405027524234, 0.2041425682598382, 0.7210940573897732, 0.35017592250087876, 0.7271139129292176, 0.42436323293209405, -0.49032417293220854, 0.3701563428782878, 0.758618257828885, 0.45037917591354276, 0.6108837810093856, 0.08414033797676689, -0.33127356673668934, 0.6829521204618006, 0.2512521913845712, 0.22170526982428607, 0.8248107647609703, 0.36276424508672234, 0.8165011247347961, -0.48105767305465374, 1.024776011157943, 0.803498469894556, -0.3590977604846842, 0.17027983571939678, 0.46757746019142754, -0.4467521959026662, -0.07463631829979535, -0.6122357108507078, 0.5927787360327654, 0.41185863608368817, 0.6361299517057918, 0.0748338317901008, -0.5946422714027676, 0.07903445945285033, 0.07033573638729629, 1.0020492207047846, 0.018569202677676647, 0.49424319342176476, 0.1471692749203675, 0.6924167164719771, 0.9589306424329888, -0.14315403783148173, -0.6214464875207746, 0.9852263656406165, 0.31015195080799046, 0.5154791517451032, 0.5631991642211666, 0.7821007572060548, -0.1309299775890541, 0.5967193587812215, 0.6953990827336202, 0.6520790925679681, 0.9791843206600576, 0.5183825747096916, 0.42816692460576794},
    {0.06978589796444917, -0.24808371806033622, -0.7856984921311337, 0.9278115359318184, 0.39339250145382243, -0.33023356239155616, 1.0398521700863343, 0.5487832357627028, 1.000974335724198, 0.5720816124468031, 0.09264202296438943, 1.0492087806344528, 0.8292424897783145, 1.1323625621987745, 0.6653945253941813, -0.3568580866067821, 0.5244229707622197, 0.5400236373948253, 0.8249881130067753, 0.20885170606255413, -0.04050388202264754, -0.3901867799736514, 0.5795446197059592, -0.03310389762722836, -0.11682518130911101, 0.6147507678104005, 0.22064711329853345, 0.8164992969655361, -0.590496159264955, 0.8485793007525524, 0.8099217264415074, -0.2469806611792828, 0.600327270072076, -0.0026207090610065277, -0.7380780171240658, -0.6130437782008059, -0.07233388979519298, 0.3523457905033464, -0.0028341552562718367, 0.5966547129973734, -0.1195499758298465, -0.1097126758070774, -0.0564137782542487, -0.19771599695425726, 0.8569075104844519, 0.24821838637576543, 0.00046311983341620026, 0.5993661611009018, 0.9664008110319414, 0.5180817597939886, -0.19666766710059877, -0.4674779033400729, 1.0069579498713128, 0.3919054111310847, -0.13297515119020556, 0.3811336209133558, -0.06887775397112456, 0.7333530219201757, 0.3136151189372135, 1.2362699630250735, 0.9058973250395997, 0.8719649346086505, 0.571420570948434, 0.2297878251766326},
    {-0.7855387600638333, -0.9146676507130483, -0.6132375075839734, -0.24420790615541021, -0.30504765469833584, -0.8057928470051023, -0.31918043884784886, 0.8982989552981422, -0.041304262087745895, 0.4336563841464863, -0.3901529591448741, -0.09981180275106181, -0.5733489262636472, 0.08987519235985048, -0.6525710894900599, -0.5541373427975049, -0.49638127980974284, 0.3148468264439128, -0.3524956337669079, -0.158206752204216, 0.5731220952777467, -0.24643808765593198, -0.6227887814417785, -0.20972446486936824, -0.7574321741287356, 0.15360919561940806, -0.8985880847534544, -0.17026341912819512, 0.5800932096934863, -0.2089642479728712, -0.3410620410011411, -0.49973313524799806, -0.6061607742130718, -0.554297879352879, -0.3477299235932211, 0.12424281999088346, -0.49826940284589044, -0.6268320189456384, 0.2471281873146739, -0.275105059933114, -0.19211540745369995, 0.43455290678902714, -0.055745235988101036, -0.8821246254576329, -0.2870318393695859, 0.10762388170747927, -0.476594441790631, 0.38217619732207353, 0.23054482167817447, -0.3017751694071588, 0.6256217319716262, -0.0746929062739476, 0.41038487371484755, 0.32619748879269544, -0.1844442652047769, -0.5626993739328169, -0.5015227835521622, 1.166772403272899, -0.5507482029548457, -0.07679709687751224, 0.8870848515617, -0.43909422932165787, -0.6173362246073842, -0.6968820173687141},
    {0.5393244590129566, -0.5996901017713209, -0.49573467224056916, 1.1453085324628927, 0.9639724859883559, 0.30822452083685553, 1.056669943813266, 0.41207890398633684, 0.9032630481843853, 0.7480918734762193, -0.10137159918995849, 1.3807850354810571, 0.5990462333581691, 0.927503863519114, 0.6792799631161605, -0.10172458642349472, 0.44692534345436685, 0.3732330921871552, 0.22560506012815984, 0.5746615219771546, -0.11921512310650381, -0.19485680959811114, 0.907098545016883, 0.22471324981084287, 0.12224000393441739, 1.002878621574823, 0.6154003051793381, 1.0507029659622975, -0.5963967316096633, 1.039324876343552, 1.0813561005173986, -0.03971140181131501, 0.6983432534189533, 0.5649487625795404, -0.27495963179238697, 0.02416753489025845, 0.5137783019850385, 0.6863662869088577, 0.5725675230785194, 0.4518513117357426, 0.17364896821711995, -0.3255497902183583, -0.17578915806301199, 0.020969114332850498, 0.9192629563696346, 0.7339425793902978, 0.5187339205324442, 0.13744802741833076, 0.4987167864689896, 0.906748210633313, 0.18911005603827613, -0.05165040662236823, 0.9673035739442386, 0.5322571916356331, 0.6956048040812323, 0.5927800235473314, 0.9881120070287907, -0.21499877542782495, 0.47092606605651516, 1.2656050389037519, 0.434645799156068, 1.1445370177997851, 0.5163792088786813, 0.6740399698427607},
    {-0.3464569957386702, -0.6385158006714574, -0.42621831591145903, 0.7515706401319404, 1.0736139038193202, -0.4809037546108005, 0.6358827979761674, 0.8859267281420744, 0.5081006766399748, 0.715341791642987, -0.32545808385217595, 0.651538963023234, 0.23869279886412306, 0.6396625851991049, 0.39701594922718814, -0.18778735025546564, 0.08072845241652063, -0.42058254294216674, -0.09733037284859576, -0.17599216713064073, 0.4300363148789456, 0.06788116577396322, 0.310452581916837, 0.4932074733265489, -0.41704718615648256, 0.30892794245592076, 0.06741518925368749, 0.30038969611659716, -0.40016989523536517, 0.4326653232090388, 0.6744454558154648, -0.5828175242117714, -0.3282669378044696, -0.42400240371235814, -0.41088772578367533, -0.10292198657569583, -0.02906766907583633, 0.1822437244548116, 0.5007846637815034, 0.72146331667029, -0.00444295542363115, -0.20719831660615182, -1.0612488581403812, -0.0721691408715067, 0.7754000137319891, 0.09846754246283307, -0.23253963557222165, 0.13238938953743168, -0.04655286609991469, 0.05074167767620838, -0.15930682703586282, 0.22170073937163404, 0.45538388202743274, 0.5862269856327649, 0.20684695947086235, 0.01143957688882893, -0.04839379136479852, 0.03474678769010764, -0.16674506121747024, 0.8324138501678249, 0.1547642672322436, 0.7069390920751609, 0.17215327220869767, 0.13488649204257894},
    {0.25966757057094136, -0.3890561871699572, 0.054603372052250757, -0.061309398416476514, 0.34783287023724235, -0.45204999845717186, 0.3237703555517988, 0.7624948783056661, 0.4845930971709538, 0.492944789412296, 0.22429570018728787, 0.48657211921206106, 0.14073322424052825, 0.39577474496758286, 0.009583142835809579, -0.16667299857934842, 0.42239596113673533, -0.7876712717683908, 0.32438460723033613, -0.09914255845082286, -0.40890369146842737, -0.371461993971551, -0.12028776065436127, -0.3003159401580819, -0.42305580890314204, 0.43997792153902304, 0.13651015402405922, 0.4550374857788251, -0.8658655615410344, 0.19396783479060895, 0.5938583176329444, 0.10117598226551917, 0.20897927753312007, -0.44957167785472885, 0.09973771248640977, -0.09065311495320647, -0.09467099193705528, -0.0900181051277997, -0.022270483315959003, 0.15006857903244497, 0.15545347551638486, 0.35330476650810977, 0.02735549378442858, 0.5515296916634926, 0.44687614221964517, 0.018218361170398736, -0.38130632216389476, -0.2361516549444285, 0.4301535600733989, 0.6260635661403938, 0.3816605923936349, -0.13112207629198366, 0.3640150026244244, 0.3209538715119947, -0.15816807259802582, 0.06948101916054851, -0.19249851866296605, 0.22655939504248254, -0.3607492786903154, 0.8237279196178021, 0.3844613177346555, 0.8422266253944417, 0.23255586727343294, 0.4436812541995624},
    {0.7845234989581163, -0.04105482603933599, -0.07940649824621605, 0.9049858746503961, 0.022832629765051776, 0.2366218492371792, 0.624307021082673, -0.2565271520075721, 0.7023040499323925, -0.3677406612120335, 0.5596749721389739, 0.8468040056501789, -0.583515905623878, 0.4639834534638795, 0.5740704335328518, -0.14825656490176695, 0.16415594701582129, 0.0320668703531536, -0.02661090043647476, 0.3260492104275319, -0.06468120493272353, 0.2000512116980423, 0.4070073493173915, -0.41480401052517096, 0.30434983023911516, 0.23557991324012062, 0.40776917787244843, 0.7166405127211902, -0.37053749777202755, 1.078303261533067, 0.9095007031001869, 0.5214477439756245, 0.7732858386338979, 0.2366566606002468, -0.0874285188957788, -0.3915119275422315, 0.023922506721321995, 0.7138837586727071, -0.8437193446075436, 0.7195679742272957, 0.024384846716294487, -0.4455060853451773, 0.4270691362076044, -0.28930869833377143, 0.3625830290767909, -0.2399410465910516, 0.626513162457827, -0.44780296040345835, 0.2936104368540256, 0.6472371340780447, -0.6388170092838754, -0.3113324863013509, 0.6955899349435499, -0.41657204516992263, 0.41698381157127695, 0.5943740708005645, 0.673271928991881, -0.7263870357823178, 0.575057093640545, 0.9203841544340441, -0.11296252988986205, 0.7664419630586561, 0.6220551296425196, 0.6343882975240345},
    {0.7160050319377336, 0.2235472092520501, -0.4290960978330768, 0.7737466839272831, 0.5068836221990806, -0.46393067261172777, 0.7610617231149669, -0.4073535817050344, 1.323939445317446, -0.12148723883113795, 1.0183984305213873, 1.0552769614623259, -0.27278173251369353, 0.600645185907955, 0.4757975107801411, -0.04332427847520148, 0.474495130935319, 0.39859578185281674, 1.129491510301081, 0.6793835791509736, -0.5622644108276503, -0.2408572989524474, 0.3893223390977901, -0.8646585723795356, 0.5392912522351957, 0.35601693759560454, 0.6584897602676223, 0.7000388546088095, -0.9745704289951508, 0.4946755929616292, 0.6844318037266766, 0.5123024712315338, 0.7516878699102141, 0.3496227380446802, -0.8667197513045772, -0.34647054931800286, 0.24682823535021517, 0.5835315240518755, -0.6772742231822675, 0.8831080125995837, 0.6916326123565493, -0.6509011516909, 0.06604495298111548, -0.08331263043714411, 0.9068298885945291, -0.20975727967319388, -0.12337337484167789, 0.036283130681503246, 0.6463467199192748, 0.7329923540595404, -0.58646914046327, -0.5898692662526059, 1.056945174261403, -0.14682342542496293, -0.07459643908850469, 0.8810130787525658, 0.5671942163429786, -0.09246756798236885, 0.8164995916145119, 0.9272485376560453, 0.22180935622555295, 0.8948917018014059, 0.927462709425023, 0.7339153561732357},
    {0.6078937166813454, -0.1843756855306468, -1.0413934445136663, 0.9574070893688621, 0.2621259651802084, 0.09234202715222552, 1.2236935750286755, -0.5024380927351133, 0.8998558706436875, -0.3921370254181147, 0.49950334719946926, 1.0098020497666802, -0.17026363955105794, 1.0093256941255044, 0.6502433419841097, 0.5404533739059024, 0.6016495703790292, 0.7193410902589196, 0.6889382604537201, 1.0754649894757282, -0.2118012115473723, -0.2666177727138333, 0.6559336359105764, 0.07530430121013557, 0.7331813475177913, 0.3548462812067988, 0.7709836485501612, 0.6319183039223205, -0.9536742725178969, 0.8317850251911008, 0.9138850834397136, 0.778352247230292, 0.4499458524242673, 0.638069292415765, -0.8202365004432316, -0.30245197426566667, 0.5175379611536102, 0.5710991264851195, -0.5030038244056722, 0.6681360773791551, 0.6899871963059934, -1.1038622388226336, -0.1982653717266258, 0.18500894103780807, 1.117302611542128, 0.0965615347268561, 0.371803563116411, 0.40158782663574033, 0.2634249542192464, 0.6712390521739552, -1.0949732539923183, -0.548056688828459, 0.4639482902644374, 0.11999215975581815, 0.847638525041338, 0.9178204476665814, 0.4692459430736325, -0.631010967688501, 0.5954959403443751, 0.8618406214955372, -0.14952613619636815, 0.9369550794219393, 0.7001787244762075, 0.24490282348843903},
    {0.3478394236548055, 0.5775831824001825, -0.8006076615934992, 0.46406081298725593, -0.08650076254507945, -0.3439835872306049, 0.9991179849035638, -0.4496302064000317, 0.4902394556106695, -0.40005255973053533, 0.8874272770186327, 0.5018388280580094, -0.7317151069884852, 0.8778979608594615, 0.5439629405611743, -0.31100637872928555, 0.5650835639201606, 0.6948284610743105, 0.7767048489268816, 0.9314328684633147, -0.9896210191368577, -0.22665035266675812, 0.015381686292826501, -0.9018126211666303, 0.47042779185891037, -0.05757670974366773, 0.31844696394679345, 0.5069133394494778, -1.215077297701941, 0.8312952127284188, 0.6820827691223718, 0.7089405058460809, 0.8450228870070892, 0.3352223905787214, -1.1207506939541385, -0.8400808515986393, 0.016596163348182442, 0.43857899128904504, -0.7575610669700468, 0.07999121975137023, 0.5540809563697566, -0.6809697903432793, 0.5238293622222424, 0.3111118726464828, 0.8177527225275251, -0.6653042333266711, 0.22081328817776028, -0.9145306814357186, 0.5483307013467987, 1.1275317648399625, -0.7451577558537683, -0.7856938626881831, 0.8073095943986569, -0.2927433041609876, 0.4893740448846396, 0.3754256457069481, 0.8434571583286286, -0.03142325127552128, 0.982098037264382, 0.7788477312938061, 0.01442504465757362, 0.8303450410599857, 0.6726366073275453, 0.6789784273540784},
    {0.7434683382670143, 1.1342897206411275, -0.33770904524342577, 1.07688980144348, -0.04082551500499405, 0.5746001712533308, 0.769309769648823, -0.5602038754883504, 0.7266255330345885, -0.7922644050337427, 0.7938286486006031, 1.0073793890567777, -0.8740423750325417, 0.7009626861287288, 0.2828850765942733, 0.07419026944936809, 0.640058485006779, 0.7448297043124249, 0.277010646636044, 1.1095189637852179, -0.5588335236437213, 0.36916660455429057, 0.24309919130731794, -0.055642076352020675, 1.044548409984201, 0.19595023976649603, 1.1539413490925485, 0.43690498716526593, -0.8114040000480304, 0.7270471574314703, 0.4995360962083621, 0.9232834127353147, 0.7673505107049319, 0.9135252536118587, -0.5894501394590825, -0.7550208393479856, 0.5021890518708517, 1.225029566293737, -0.6978298911677234, 0.0962359633371365, 0.985667470425645, -0.5712928847284507, -0.23879476672665348, 0.6554304875376287, 0.5143904896635494, -0.2698508367153904, 0.33649837092399043, -0.4173446845849182, 0.5187284847712935, 0.4462911685415603, -1.0254216384569763, -0.34292486025497804, 0.015904528800621428, -0.21013978669404343, 0.8821879993835036, 0.9217382293612575, 0.9052251738547983, -0.465975792515566, 0.791848592310915, 0.6007079467876106, -0.14757270978680678, 0.8504240668827471, 0.45618519443268185, 0.6133893113915839},
    {0.9697521427985912, 0.6516055679645453, -0.5095569780284029, 0.880556338211668, 0.5749614985200862, 0.27375612169794866, 0.8733823808642543, -0.6225128032271143, 0.9053173430966219, -0.5992932459316294, 0.8436801015646452, 1.091270231888188, -0.20034251203493497, 1.0362445959505178, 0.6398728885387062, 0.10441665288109056, 0.9095436964881314, 1.0692575668126334, 0.5605501303675665, 0.7681300662760003, -0.8183095055448293, 0.3700030555771582, 1.0246520956875653, -0.09841743779796494, 0.9905705140914115, 0.280389470582283, 1.1319303680065547, 0.5834427189217795, -0.9387514254052008, 0.6776365174476279, 0.6766092483709127, 0.612954171538951, 0.9292880020339586, 1.2281971207652884, -0.6418074198598829, -0.3934200595418355, 0.3898595781903145, 0.9936683227743139, -0.34184824329289426, 0.9277485011347851, 0.8874142507714329, -1.1056689253759964, 0.04539388612421176, 0.9680964950295744, 1.0494626421545572, -0.24084303318124678, 0.8348214888605626, -0.38441321835445136, 0.26613164961258834, 0.7637760287044872, -0.9482400537943165, -0.5849692526248865, 0.38139741154924345, -0.21573861269277145, 0.9778177249712114, 0.9739132733643768, 1.0344569532232484, -0.7934880878572532, 1.1140687653716543, 0.9118336466512938, -0.8305653751820109, 0.9182676462294264, 0.6163390127945304, 0.8541186188802301},
    {1.0534240592508421, 0.9881053571708472, -0.33265175763577487, 0.6504931762780453, -0.2503932214961342, 0.22825610382489148, 0.7719779563398348, -1.043601755420071, 0.4830879644353753, -1.1334536358192926, 0.8894299307133773, 0.45082554539031183, -0.2112287879407695, 1.0026134637370805, 0.6886463485923755, -0.685224361118511, 0.5772919322239589, 0.833616584569165, 0.8702926034307309, 0.8944564224825242, -0.8146561197602802, -0.02296515183611664, 0.7839125529178608, -0.29206691443192767, 1.169226667700547, -0.43291170143227764, 0.9978056436529825, 0.29329378110998067, -0.9129048614788644, 0.5670337090603169, 0.04321533174661096, 1.0614719822840837, 0.9403812459545249, 0.9658103924026068, -0.9266428220904538, -0.813280179964245, 0.18452299681595294, 0.9494775493613519, -0.913766472621155, 0.6919099296104305, 1.0271611788253823, -0.8090364649502111, 0.4438406589983739, 1.0334402638732836, 0.48778337664539523, -0.4839240688148652, 0.4783571336421648, -0.8957385227276038, 0.3539206766844202, 0.5980497218392936, -0.9433163989666711, -0.7004435772750914, -0.005565087352207457, -0.6742288514959857, 0.8209615551250755, 0.9370722269301485, 0.756849775383742, -0.9486474720045617, 0.8022776025659416, 0.7618569936051298, -0.8297804324727125, 0.5921937307411398, 0.8038626870473344, 0.6511853764731637},
    {0.6172266193334642, -0.05862063427358873, -1.1559075811227377, 1.1506998843759808, -0.6130850834530795, 0.2018869433597753, 0.9043371690773054, -1.0454325633960535, 0.547134907595534, -1.1457578643963264, 1.0138824303255456, 0.9186782135944264, -0.799321022370349, 1.0249859326507524, 0.7319398748426118, -0.3654848240804832, 0.038235190858106886, 1.035083397548914, 0.8893575378177573, 1.0940562091738621, -1.1924719826311894, 0.23238167957829603, 0.4672450502866929, -0.7545433733841066, 0.9871181328676143, -0.3268096742438757, 1.0143309024478289, 0.17147016575959928, -0.7440994632554956, 0.504947344929423, 0.4289377180967572, 0.981867980256141, 0.9296250605391185, 0.5885530041458833, -0.8988309153214054, -1.192311328957736, -0.40097504205516793, 1.0261045270984674, -0.8966604398035739, 0.5698469486463473, 0.9627388228110725, -1.1969616788381963, -0.2878114873967719, 0.6893284592381137, 0.19630478243755692, -0.5475119893384273, 0.05453789476758424, -0.925721689916806, 0.032743616860267624, 0.14002576201553238, -1.1655480082971672, -1.3273468392888255, -0.3605070326268549, -0.9043174888916172, 1.0951466938237395, 0.6213850645131599, 0.8718869015127052, -0.7265032262214944, 0.7410313255050192, 0.8044517250955312, -0.46046014071205416, 0.9472735267644447, 0.10409295706799922, 0.2699766260378401},
    {1.00190245267764, 0.9054034735693953, 0.04770962532913547, 0.38171192390585423, -0.13556605109825706, -0.13134312120284067, 0.3341002526800066, -0.19924231268220818, 0.6103475213104195, -0.407315349251822, 0.6180307422112865, -0.04741934722119945, -0.6239781751222823, 0.6081279306527587, 0.3688319718546959, 0.012814354891796763, 0.4055175169405474, -0.02046406784884839, -0.32946239798942595, 0.6993578577744956, -0.3715457412414101, 0.822817999367804, 0.6147623783537911, -0.20969395962543122, 0.5457704544283397, 0.19289039831643925, 0.6158733463733559, 0.09744725968692877, -0.23167430128761474, 0.22080742565097075, 0.173263050107024, 0.43744328231144697, 1.0314996205396834, 0.6761443458825935, -0.26773880751912865, -0.17087846196948886, 0.3520017037081657, 0.8848390860381943, -0.8428435544936179, 0.24522162146735438, 0.828063555770742, -0.15552498169240184, 0.6371704550642144, 0.8225366689748251, 0.140131113998293, -0.33759859897416394, 0.24233380436935148, -0.6435795247674042, 0.37330955519457076, 0.34878386759999597, -0.36387573318327965, -0.3863379508751845, -0.4251172067248165, 0.3827616673610917, 0.7024917166120914, 0.6022323491893252, 0.6545977302655741, -0.5379519841735914, 0.7483065348341024, 0.40615989516944734, -0.3315653204831413, 0.3120394425216062, 0.711724202604073, 0.3903272690062257},
    {1.0568262556036492, 0.3844845020982936, -0.7015808064144359, 0.9330616223405785, 0.24505948335706101, 0.3593668833182125, 1.082189623034067, -0.705374796419323, 1.1191241164596848, -0.8974060830653505, 0.8787588216154044, 0.6918971049531567, -0.1629325980563988, 0.8875752025438826, 0.6144315804295853, -0.35879191736633764, 0.9344917871583641, 0.5710708992520522, 0.40093167621890247, 0.6328906733599905, -0.8748778042865719, 0.2771187136951734, 0.6969380986045801, -0.4187062585144516, 0.8121839820288407, 0.218853521469272, 0.8401137022814719, 0.45441508951274673, -1.3199336521999656, 1.0136671019058394, 0.419927922061097, 0.6187218888727494, 0.9999809964360561, 0.9352283297203494, -1.0329986315803956, -0.9286767475356383, 0.3799953409592562, 1.095554872983782, -0.3976810664948098, 0.31273878910115277, 0.8252506296757872, -1.0860615737256125, -0.14136440409350381, 0.9535781390470339, 0.8135025114088064, -0.498233749563477, 0.6182038798764777, -0.9259677215310497, 0.2818296822910109, 0.8134469072098073, -0.8520266973929909, -0.7463296327339696, 0.3869855546316803, -0.41864415619881534, 0.7934744011558079, 0.7954736090287167, 0.7907454714575941, -1.0105138989798874, 0.7494703998111225, 0.7830233023573945, -0.7619349942948866, 1.0529027539609936, 0.871299570878633, 0.8267223791169228},
    {0.6436369784049665, 0.12223607284277453, -0.982100077872937, 0.5834641202460108, 0.42386057929075677, 0.32933377616703974, 1.0365237395160711, 0.11140591246220821, 0.5578675205142897, -0.3504561186391647, 0.6978361337272682, 0.7956950814061563, 0.19686583605069202, 0.7679903089063924, 0.14664388198588055, 0.046501095928774806, 0.0918649344129578, 0.38931375862867906, 0.4116162305488784, 0.33077745789186747, -0.6427852911928772, -0.15189614060361767, 0.7408686069751407, 0.17578511573593222, 0.190829193039315, 0.4118945938765043, 0.3792322333843934, 0.5477910215413345, -0.8999916708452699, 0.5813446041344963, 0.7161396815579897, 0.03002995058495053, 0.9191037186856846, 0.7595237147118356, -0.6200453678296555, -0.6957848801346432, 0.16425842775462543, 0.17228479194590665, -0.3375461606737181, 0.19460771800436816, 0.13477736228523138, -0.5457977315737267, -0.4174367845401351, 0.6525963948071554, 0.4636864149099139, -0.09100763969263377, 0.12223941243697206, 0.030428602679907043, 0.2947672476861131, 0.4718899005635147, -0.49006788306433985, -0.4420580229144882, 0.27916640746345855, 0.27562383169108995, 0.49865256672948705, 0.3951444378016771, 0.6475433561545795, -0.5609743892045996, 0.41396930922045705, 0.7203642191668315, -0.33356653352012605, 0.7913191997533585, 0.743916285176055, 0.6395145742586469},
    {-0.30386751968101505, -1.0872526708622723, -1.1919026465648663, 0.6497963112037919, -1.1608252201720861, -0.9349330041829708, 0.6393233654477952, -1.1114512497951823, 0.45450764466385574, -1.1671681524073683, 0.1779735359992453, 0.567758090994765, -0.9244814545976571, -0.7601478559575526, 0.5926788733909122, -1.3477855836613286, 0.22638898746730346, 0.474241633771895, 0.20456399160997812, 0.31231862293320395, -1.430228404085588, -0.8969218789924057, 0.6009648037773376, -1.0081647320798268, 0.5336757010929706, -1.3032818459556381, 0.5803547161644399, -0.8861404035722232, -1.0734627033217312, -0.5653419398044602, -0.44624782993536843, 0.17057871373960265, 0.4903323315437691, -0.9691989007063682, -0.8778422219224734, -1.2255750925556717, -1.1678215746308385, 0.6889114494032814, -1.3144631982739665, 0.3512387019589218, 0.28081438081141397, -1.2880901360992993, -0.202352246546371, 0.37839321707599755, 0.36176245726800493, -1.147347064830236, -0.6740972504024675, -1.1282441714701459, -0.47692642802544244, -0.41907920207135635, -1.0032012690604641, -0.8239966714937859, -1.1393670508945233, -1.3594216439714466, 0.10600940701966323, 0.36964940524383244, -0.45522048391590053, -1.243718415951895, 0.21890433643678386, 0.6293411033218045, -1.245291647965279, -0.7240443812778896, 0.3330311533958844, -0.09288730810415811},
    {0.8943835137535079, -0.9396909421066727, -0.8724189241364644, 0.8796842964039614, -0.6194808270808804, 0.2446821675016395, 0.8959793419855844, -0.8676882089131099, 0.7359243286575367, -0.9262602843780361, 0.1957529318450707, 0.561842403869728, -1.0158220476389523, 0.4742120250172628, 0.45892294741747885, -1.3874191500211106, -0.2818662965768456, 0.23865145263728316, 0.28668807065514673, 0.48764169374878447, -0.993912539810305, -0.5733016237564905, 0.6207040388333144, -1.1722853539671054, 0.9938201630283723, -1.056141012666236, 1.0058038441807482, 0.22975309420890144, -1.1714397312755023, -0.13858706446492464, 0.09199601088037908, 0.37304953929979784, 0.35847572361360625, -0.7279558978172156, -0.8467553320508556, -0.913044965488731, -1.2377778470493066, 0.9329686038134499, -0.9517703858044714, 0.6645232248265175, 0.5434340223054721, -1.2865899006358181, 0.6249085085211484, 0.551942758588079, 0.6523636284790852, -0.7546240932049875, 0.025886960699348364, -0.4386826627972728, -0.09273518942681395, 0.06485172906212734, -0.9780170704003593, -0.6374871624550197, -0.4527071917965518, -1.248943145380587, 0.40454112495833294, 0.9607985716129662, 0.07196812700675786, -1.213348096740739, 0.6923303836419535, 0.7067973142148105, -0.4389056215806659, -0.05519884826599322, 0.8765686490616607, 0.4799510796008325},
    {-0.4175204493558251, -0.6163169855390564, -0.5892037467423593, 0.035757898303547545, -0.8591094666396579, -0.32594407502537, 0.4024299746749312, -0.5942413836020154, 0.5639731839169476, -0.44399604641429846, 0.13981549356518921, 0.24301390021595515, -0.4402632585327793, -0.533770194609394, 0.24202654671289994, -0.8568640444793537, -0.4446547945549603, 0.23063076688670966, -0.03755199821057358, 0.7374873520518328, -0.7789434661864157, -0.2123427193546318, 0.4372166399434903, -0.7315798693083583, 0.39206849325706283, -1.1401791582600913, 0.6471874486579656, -0.8827623139537928, -0.4728396519111924, -0.6331421376399969, -0.5838882739681962, 0.19711795158034315, 0.23973276641747215, -0.7716412646950862, -0.36632796166293624, -0.7074089995647189, -0.8603793306720352, 0.3717208190093644, -0.7599535149298936, 0.6137165848104147, 0.1889231524699362, -0.5815109776074885, -0.15714508334165742, 0.4760287907676012, -0.11957943294165735, -1.0499981526517241, -0.5229161414885494, -0.4294870472554939, -0.4896000211187401, -0.027156237355651917, -0.5786072432569722, -0.20465965536655267, -1.187692269253164, -0.7092035660369301, -0.3431198451063979, -0.10639023374095397, -0.8082326190911362, -0.553245362759144, -0.08845644195653235, -0.10498858324988591, -0.33532257189641707, -0.976035559684592, 0.1431485347730956, -0.08046977660466269},
    {0.17654456020018744, -0.31545082897141324, -0.43485534330746034, -0.11116444154396976, -1.1169925619976726, -0.8308836578052171, 0.4418577674870491, -0.6377075131768191, -0.021044995895632274, -0.6125675259782448, -0.5354798516692407, 0.2375103093915273, 0.08394279847243408, -0.32713221291699585, 0.6203081378663237, -0.7332791492706809, -0.2388768623143213, 0.1251413869155979, 0.2432673149880779, 0.015718408617493216, -0.4341758788916426, 0.035455028348565655, 0.2752614023444396, -0.7594829451831977, 0.3475726130238306, -0.5899954288442724, 0.5564274701240156, -0.9740408468403701, -0.4816254133943839, -1.0545452153543513, -0.5991526778961389, 0.42281723259068665, 0.1788042107591698, -0.7103804370292783, -0.1683220042153804, -0.6050682724704164, -0.8024935756289522, 0.6066254008968812, -0.7534042491232634, 0.5915066780933523, 0.5250848144195507, -0.6668961669857763, -0.16100723594373098, 0.3475452455661924, 0.21212890190258565, -0.5573514806281441, -0.12202565046208388, -0.14951676158019406, -0.9534639662451048, -0.7950846047800904, -0.44112242921636236, 0.02561537282060747, -1.0473896307457546, -0.5061204421045868, -0.43892831415153155, -0.051152490002683765, -0.7218198086123524, -0.5225232034597549, 0.7447697643317756, -0.030103150630446496, -0.25831366972738745, -1.0849301034408678, 0.47428343458112904, -0.3406509808405707},
    {-0.0053586636504542795, -0.4370102709142107, -0.7670529591552435, 0.46398962569265156, -0.17099369950284316, -0.29313306943116685, 0.31064795049171934, -0.2850890664912391, 0.6065085554643992, -0.42683214497716787, 0.0158145086252696, 0.44967135982203976, -0.899002625982617, 0.3414008446270365, 0.8404924751102942, -0.7262527420798027, 0.30815151769720983, 0.7901048994231733, -0.07742433406868836, 0.5250490063275896, -0.7570359164542924, 0.15628767214824743, -0.4569700301674181, -0.2296884446319616, 0.9250970426958919, -1.0054679705024718, 0.4425896446777903, -0.4628450254057864, -0.5250540843518178, -0.1991417109177481, -0.40473680884687896, 0.5287334456069981, 0.5475044941271409, -0.2805329535421715, -0.19569944320407145, -0.4080553672817927, -0.7269631583074199, 0.5249062713018663, -0.5741745439224697, 0.49847228907915364, 0.42717576426659826, -0.6593436151169079, 0.3020754903304922, 0.8452317812416391, 0.09877370486200972, -0.5633585115144373, 0.248141053571243, -0.5298139255485402, -0.5674182218819199, 0.00047985582837929816, 0.13240812095097584, -0.0031883121521108604, -0.54858712675583, -1.0872475872832739, -0.2780355924739084, 0.2981297103877297, -0.27078665530898754, -0.9537365635054389, 0.2759684841327694, 0.6396702105569154, -0.3543904907271083, -0.31479725334851383, 0.5510652363133804, 0.06944046309167413},
    {-0.589402249328641, -0.7228813065611457, -0.31093878779378537, 1.001226412792539, 0.0005353119657890939, -0.22778801358110157, 0.39880003775089395, -0.5010183398610174, 0.10728853725487014, -0.3641052823879486, -0.2482988420491376, 0.568169092221518, -0.33588186304115103, 0.4212119790497906, 0.26852375150324337, -0.4339905937252584, 0.6938740178433731, 0.127958126256139, 0.2955340274423629, 0.6260023499030645, -0.49740418573386463, -0.33188181309416936, 0.06859372199471983, -0.44562069707687274, 0.2298578366774854, -0.391111361301574, 0.44085833830027643, -0.3664941246587797, -0.21152589506914507, -0.22916102993268994, 0.023053281060182125, -0.6548239529482883, 0.09301188829245806, -0.7888697379020756, -0.7288303528523522, -0.28943054077388347, -0.5461261296654937, 0.4821144694309994, -0.3138929112659325, 0.5886524656740797, -0.03660464537790743, -0.547967752607844, 0.4989487524691682, 0.07643039575844146, 0.24886842286584718, -0.5027635174841198, 0.5872481890748974, -0.6225541315222953, -0.5813301683727612, -0.5024272268880623, -0.2915206442715541, 0.0598365475960564, -0.7620422321594027, -0.5272872008701308, -0.3946942606177892, 0.7688789716462151, -0.25021583060911706, -0.8284060104107039, 0.726086127244353, 0.09770263287588773, -0.48989398265887124, -0.5533275699369745, -0.029239319829949355, 0.3402881035094292},
    {0.09099208669955934, -0.001997904198153648, 0.39334958819150767, -0.04763916585200385, -0.743136265275888, 0.3953648159767395, -0.07655654709989672, -0.21031844349039844, -0.0833632440786627, -0.27395497004588604, -0.5144173057904718, 0.18271491173089038, -0.07186600587583004, -0.6330145517838106, 0.6104824931250351, -0.26960096801642247, -0.02185960493866449, -0.16821204559414113, -0.0780732364228745, 0.47927869081375, 0.16240089038955663, 0.01805151644724826, 0.648695031922198, -0.6440851846266237, 0.3076463910786512, 0.22975319624246957, 0.20357095279684007, -0.67799276855139, -0.3573837290058941, -0.889950788824191, 0.07616561560843588, -0.22975914629919986, 0.1479603810373454, -0.08928006524828759, -0.4196186382085251, -0.8072134627499372, 0.24100674728035612, -0.2544389476441692, -0.5355943451373237, 0.44194565039926376, -0.09164376957377024, -0.46428522625388735, -0.1575521019912784, 0.524697544781215, 0.14888173199435162, -0.21510959822559705, -0.28710766294922374, -0.4120871174706104, -0.20488353632949988, 0.008240124371894884, -0.7256951854742103, 0.6598169952944221, -0.45482323162214777, -0.7564286549384442, -0.4228013753466412, 0.02525106735491164, -0.5166483702436598, -0.6540254427849022, -0.7709545905802181, 0.3827900393101765, 0.19872506417162975, -0.39205410210635677, -0.138027705622952, -0.24633097655801897},
    {0.17375785309647757, 0.14377147731163, -0.7852984312629341, 0.5283456889015068, 0.30356643812184136, -0.5980694406777243, 0.43332283806319866, -0.03126600762311817, 0.29750219050717314, -0.33229501826269353, 0.10833386538113186, -0.002434708465225894, 0.19091473911491472, 0.14944068757312046, 0.25709534550952506, 0.06652843667953239, 0.09853098233796012, 0.539438519178867, -0.1311597301308833, -0.3861308962227374, -0.5900123677357808, -0.3446446157194813, 0.09094630003745269, 0.08672409499703183, 0.08438359179649539, -0.12076827137531693, 0.5349475018104772, -0.45557711560937325, -0.7573986802830243, -0.36167653329638866, -0.10340822277315552, 0.7057292144942303, 0.5352972039371692, 0.09448286735622419, -0.43915974344707076, -0.6429442597818772, -0.7122933069265915, 0.2962197966231717, -0.5366255391100503, 0.09664191117415387, -0.0027509355089194595, -0.662729913677662, -0.45510489258435416, -0.163190124187217, 0.4684300093347219, -0.6339556513960656, -0.3812051050970709, 0.5028478678100172, 0.015000769779627563, 0.2612362236498402, -0.25762105658983997, 0.007313180991420199, -0.4382582099566333, -0.16284111427578488, 0.15581478519200873, 0.16832354014492826, -0.6367093366844867, 0.10962187135219195, -0.26831436042694823, -0.0857279415860376, -0.6400382818857705, -0.3943328238140153, -0.06686240729742104, 0.01579680496622207},
    {0.357983049907042, 0.13419338764536168, -0.7741634183417124, 0.42304885876011167, -0.1343981755941179, -0.5855913815943362, 0.510852745513955, -0.38503191305409085, 0.1328480684808634, -0.3516960813161767, -0.12048997181434215, 0.2598110635575027, -0.1783205356283269, 0.5684073172670115, 0.46076250961554877, -0.6760270572682026, 0.1769702056463904, 0.39470625496824663, -0.23621406374766568, 0.38462980024474425, -0.5865655878709153, -0.6845768442666467, 0.42292075581899535, -0.007929215346858389, 0.4786061748587092, -0.4646663473579176, 0.6735283826557673, -0.49725045393833905, -0.842676683643453, -0.03291912822563509, -0.10511873913420801, -0.17512553746029214, 0.20085371425109858, -0.36477515276161515, -0.26056099874575994, -0.500277658465003, -0.7147909097394212, 0.24743187245050052, -0.7505728685897998, -0.11674310314294986, 0.29873049482763264, -0.34110738219865705, 0.08473783985867024, 0.31285554646164, 0.1976856504370233, -0.4661765349152216, 0.13716285536381947, -0.7274092424562039, 0.09032206552653599, 0.44568264302839133, -0.1847089316260894, -0.1534833567987459, -0.24726367747155467, -0.5187838871797088, 0.060030693414528546, 0.2319702109899485, -0.06603709163283406, -0.4493509138199707, -0.4004139616323623, 0.3456541364281455, -0.6300659464872432, -0.417301449392005, 0.4408928106606398, 0.39162661633262624},
    {0.05602064227913577, -0.5170654194761085, -0.34840067250948764, 0.12868488813716622, -0.0827135761381209, 0.0916846852575456, -0.303940140476714, -0.2600684498811482, -0.1183298225537576, -0.5110178228879012, -0.19340990832973118, 0.6864214670032537, -0.13479000489565895, 0.07160679281195681, 0.02069766571362911, -0.14973756455240483, -0.8401718225603639, 0.28112684549047995, 0.18018607368379488, 0.3685390148569682, -0.11561798461665343, 0.43278113374236515, 0.21821189507418945, -0.2392343132054812, 0.14503888779932517, -0.7725094321795482, 0.7108616843463808, -0.7124001059466809, -0.3890086538358352, -0.6621742889064847, 0.047312765652200106, -0.5139248024179014, -0.09424381220396748, -0.33355144164865574, -0.3693063422490602, -0.6208886725277358, 0.7551568367050386, 0.4579792583614762, -0.33953230053886924, -0.2490763436076512, 0.41955932790889594, 0.2624706980822226, -0.07650218055797836, -0.5610067047350157, 0.20110626887202396, 0.5519406373426445, 0.4746129211796903, -0.18257114445074377, 0.1390530672004731, 0.19607069359090093, -0.1991585296124443, -0.5412436320755061, -0.5962776048094512, -0.4620898402998232, 0.1633134866131189, 0.7998982943830437, 0.15846659118858128, -0.535261322564885, -0.39957440838588093, -0.28035203099820566, -0.0661667103648511, -0.39160992755578494, 0.24036804021067953, -0.18028508019575296},
    {-0.7620665787713717, -0.45748270283187803, -0.4588117291712533, -0.46601458224264786, -0.20701006844104608, 0.1331535876143695, -0.47479110274189484, 0.14543687891746945, 0.03545023642379807, -0.2283904186522171, -0.20301504904704723, 0.06585189944353846, -0.6824106555528754, -0.4661120349411427, 0.18205956223805506, -0.8707320536343087, 0.10762034240733989, 0.20496848190433845, 0.2704828621291874, -0.16473871822915817, -0.337023804243871, 0.4870150715725266, -0.38932301651313234, 0.039953742318629075, -0.04525151448311502, -0.3645909481308831, 0.10510015081554705, -0.4808989271653313, 0.3567819665287111, -0.23599851227942623, -0.4748836962930563, 0.7414476498519141, -0.048547664282083576, -0.5505298147788025, -0.6255152021841046, -0.20416636314333986, 0.022779267720655947, 0.19192867299393485, 0.10863591208509288, -0.1133519400991153, 0.12795213486606138, 0.136470632613713, -0.7515727331105443, -0.7284163018598232, -0.5203698357495992, 0.2771995349922118, 0.26295795401080757, -0.9742505873246523, -0.3014061831337696, 0.15734963839434044, -0.12623089196448187, 0.12693306509484598, -0.5411034726562476, -0.6638836871459145, -0.04023062325850797, 0.2414631116054839, -0.5541862762680994, 0.5118207499949199, -0.2757546868230548, -0.309195836785282, -0.6717601522036765, -0.6156605883056886, 0.04099383746299465, 0.3220724795102035},
    {-0.2830292575804199, -0.09171689793143821, 0.03334204326931824, -0.09372080532365236, -0.5456628559409918, 0.39622674087431087, -0.1926215117050141, -0.22738085376214015, -0.3102971665489717, -0.19198570547094218, -0.0040782131908064225, -0.3277650604675075, 0.09026118805177352, -0.15010681887867058, -0.008743198614127427, -0.817204360718981, -0.30538672597759914, -0.041353099059573385, 0.037723493495805616, -0.016174277330615574, 0.18957629586254615, 0.25004633272501936, -0.029477577739617226, -0.6330444785087134, 0.04629198714608657, -0.6871335085413707, 0.46183352334988426, -0.22911726316040765, -0.0010827407359069161, 0.49554368860210257, 0.09553860472294151, 0.33612045490040954, -0.038608709603887695, -0.08011615039936706, -0.48871111283404, 0.15515785505327095, -0.1330656018076344, 0.27552542565687793, -0.20855189271771876, 0.12178164620461027, 0.3504625129647389, -0.14689341926071225, -0.3216736081642439, -0.8143480773451156, -0.19475987342780018, 0.05570495376855632, -0.09172244258722884, 0.08392478683198398, -0.7522035749580307, 0.12283392632252679, -0.17030997464799413, -0.013938727457800138, -0.24985001114977654, -0.21775625738427606, -0.07994236136982577, 0.12433266142454653, -0.44286877453729845, -0.3678579796562435, 0.40528749782241386, 0.007285410748936596, -0.28973086040886054, -0.012441412303262704, 0.2757057236995087, 0.0708843302149391},
    {0.06645388879794357, 0.23590012908927369, -0.9174893094621517, 0.3691152640575241, 0.1714630095604491, -0.4591967834360223, 0.40683656067986734, -0.1677892371349181, 0.8086833961482087, -0.06452160551578025, -0.1515044751820066, -0.12119432556043915, 0.26588004684591776, 0.5322617068872985, 0.11835384402966719, 0.46213209648712117, 0.19634766472215634, -0.03537073556175147, 0.10366849306323626, -0.15322762507806514, -0.02762063487576762, 0.22785236964518216, 0.3961924224274687, 0.028349040272697017, -0.04804862603605296, -0.3257886210456522, 0.26169847823036896, -0.20632755769282515, -0.5284479400484332, 0.4517326721783615, 0.035537659723738325, 0.0007463373182777622, 0.6620546236792915, 0.2687393915335355, -0.07250197380105783, -0.18843250702920167, 0.33950184839810466, 0.12292613226485558, -0.29854075050724366, 0.040623570255214056, 0.8889674982480446, 0.0021460320895945566, -0.010962822992515995, -0.3332255398908377, 0.45243169168557446, 0.1138740086461605, 0.4072921868199118, -0.38906247289370144, -0.3083617338713475, 0.4223103373687102, 0.25534429989112734, -0.6220718815180537, 0.6609231187408754, 0.3254246614744586, 0.09107758665270851, 0.4475602003699811, -0.48580588580467343, -0.10939451961315803, 0.3995685991359791, 0.18926759228377105, -0.23693804563286475, 0.15394904570637477, -0.26595576121495995, 0.6868886330851983},
    {-0.6111257099680572, 0.14235574411583507, -0.35720879776937714, -0.36064316309690303, -0.06799166446373879, -0.48693068198851686, 0.18405343330761284, -0.3795395931015821, -0.09214718803050276, -0.4171887082585337, 0.4153105451598052, 0.08323653127825621, 0.08884412815747231, -0.2993010799020298, -0.11950939503650192, -0.42916445476075205, -0.30719793055934785, 0.08729070953215984, -0.1520700431240326, 0.26528989830584443, -0.3766692353720838, 0.25315445004617304, -0.022471308198908375, 0.6457454004238944, -0.16515004257736526, -0.1494223018227277, 0.30105673068606775, -0.2495016653482436, -0.10136474548170012, 0.1906195368816966, 0.11621478051600052, -0.10324802106937202, 0.7022194755516659, 0.5088195095055649, -0.4730669696215889, -0.4165207445447616, -0.40851032712751106, 0.1667895845361928, 0.11910250728457303, 0.3748254416889829, 0.12383009599606948, -0.1754077055690052, -0.13216700188112096, 0.15050730971779278, 0.43791942655997135, 0.5894799386857107, -0.1699220206547266, 0.9161376681883798, -0.4522407818233165, 0.5208555047613166, -0.008657486772414614, -0.5192973799502569, -0.24835739241854318, -0.31428554561463107, 0.1264187090879077, 0.25648428851744975, 0.008904356226799184, 0.6268448772479097, 0.5203369469089026, -0.05611364757249023, 0.17412657918680793, -0.008133040364409568, -0.5605388382539622, -0.1473819361657095},
    {0.29318744274126185, -0.020150754436511226, -0.17583510036616204, -0.14926591085207558, 0.4816754051050537, -0.6186712987744607, -0.24794277026879097, 0.006198093675555881, -0.300591474410317, -0.12315621392503842, 0.09546228720960868, 0.5728817166667904, 0.3547089745213837, 0.2874036240257523, -0.10323738013853667, -0.31944176659816104, 0.019970039219522395, -0.4983458643759466, 0.0046874470091363505, 0.531297425438574, -0.5318167817944787, 0.16043334826034217, -0.10363926415907881, -0.03727953293381602, 0.31352180245283745, -0.3408994171099203, -0.2721898494269826, 0.3111629961755166, 0.501918259361133, 0.15180222148981487, -0.21669267070559461, 0.38896296593481405, 0.25647233471389835, 1.0045480542456726, 0.4156473641568108, 0.14488470914634238, 0.005038904798574263, 0.4583495081987412, 0.5690537327505631, -0.5268911399439865, 0.3281298651251357, 0.42357879574479856, 0.13517744565129458, -0.3028901942933352, 0.4909954854380153, 0.5513460427112201, -0.2247819941893536, 0.2617627256411372, -0.6999589625501462, -0.3693801539691884, -0.057446079898897336, 0.2662346623630274, 0.09006671621970155, 0.4923882047287884, -0.26021821839654774, 0.6118769088846749, 0.4757507813614917, 0.360687683020548, 0.07348625416694857, 0.4343652361525076, 0.470929635864102, 0.5510336432903484, 0.6882210769532546, 0.2074259065070739},
    {0.5625504691725319, -0.23154030823959634, 0.10224428496306703, 0.016375273193793522, 0.21126776925735183, -0.1620272302548504, 0.9129660046260668, -0.05829010385043596, 0.13948283038204304, -0.2905655571373432, -0.05421620415120665, 0.4830160656090832, 0.329289126226751, 0.16910759627718677, -0.06740096100617035, -0.794331941875646, -0.23623384625152738, -0.04902936597355567, 0.03486579964935116, 0.5386730141465405, -0.15383483403427564, 0.3767544616478166, -0.33041061915453906, -0.7795782000483704, 0.3088910446025811, -0.4765764414325859, 0.36800345087852226, -0.2393711201889049, -0.5132559076876488, 0.7819811539535199, -0.20489970364357815, 0.7642560561065559, 0.42162689537066717, 0.6749753199015119, 0.04937369143362769, 0.2066277942722219, 0.11683697161809728, 0.5259469548172467, -0.4884335097896977, 0.18539551084757605, 0.18913640313806465, -0.5818196891827322, -0.45581635651001573, 0.5252332854517155, 0.46072290421205747, 0.18614832628859096, 0.13352062394988673, -0.19616304831923292, -0.19060737655316476, 0.5314672706509307, -0.4610482926387975, -0.21064931315240884, -0.30261139882288207, 0.11383502008249467, 0.38811778574571765, 0.6667453750075821, -0.10770877332656084, -0.6195464287898473, 0.13825439152867625, 0.18049716457104034, -0.5285770914070933, 0.8433226365960056, 0.8708758822620274, 0.590072792670831},
    {0.08709526748581481, -0.443576708170531, -0.20488631928202927, -0.4187092961688247, -0.6518175487383805, -0.2708839615460543, 0.06651426530878189, -0.2875944214308651, 0.19240603187008026, -0.02188397602704159, -0.20123070677448912, -0.00154185486950747, 0.40802628136735225, -0.005569247036151014, -0.1736390477457328, 0.04774912872646031, -0.30093637360774306, 0.19802170667130362, -0.5299378204041063, -0.05859702545515892, -0.0862319896169467, 0.32306937447056344, -0.44651089842532315, -0.504232321919303, 0.6374373958871759, 0.22176970466809506, -0.44679345459657127, -0.3043341700868578, -0.16418063838101013, -0.11156941304939128, 0.0274995024988669, -0.00041581562978863665, -0.20412291497197463, 0.8243867118593159, -0.3797334005348398, 0.25802421681076043, -0.014885304344829276, 0.30822043386307635, 0.07655681196364869, 0.1958041772629372, 0.12282304689449233, -0.3370972035288843, 0.03411649937000485, 0.23721496893537652, 0.1332845626459896, -0.023429886687005554, 0.0711173153500748, 0.16612625998292913, 0.4024313983869592, 0.09641936869100519, -0.5126910676776779, -0.3861140472444053, 0.2271325843156798, -0.03850811201376722, -0.521242204770911, -0.08383870600333491, 0.21044573113847648, 0.05490351339538295, 0.10415921222142688, 0.4682530693034764, -0.13052660521474926, 0.026069378690571215, 0.11909478509947156, -0.11950303049660049},
    {0.29237507248345046, -0.4437977763301334, 0.1717228629429542, -0.9558013042874989, 0.013121179761202641, -0.4038737481878882, -0.2668373965068412, -0.5122085869942866, -0.8200483166790989, -0.04885794003953846, -0.030207386186682637, 0.046175362597967125, 0.24135438433618306, 0.04343735226050457, -0.44743682274776975, -0.547922722590326, -0.353044141700684, 0.2399340032444157, -0.7993902793853326, -0.39262581934200536, -0.2606353915111106, 0.6999020541336797, -0.7909328942098959, -0.44912801230934934, 0.06807811119595765, -0.5096299731357963, -0.29463367824391407, 0.1037581424881945, 0.17614191256538328, 0.08215857875036706, 0.10276768614800046, -0.2883804102848504, -0.724918084250899, -0.23281397985391383, 0.13239024982440123, 0.15372054705095906, -0.07733149218355, -0.7639918017548076, -0.2888157092041934, 0.4804792211644948, 0.02160325473844424, 0.07877819177213789, -0.006168928957155494, -0.670304934692555, -0.22050764645020143, -0.15467489955450983, 0.3705029502766615, -0.16437481686662475, 0.21601959803906068, 0.15459490399219666, 0.1623293431111596, 0.3100786251080769, 0.1686795511471563, -0.16697457830653353, -0.7408866212068447, 0.45277264658213817, 0.009804723042166947, -0.3108444832514927, -0.16793644750443648, 0.279187761595846, -0.15144292034585716, -0.17244613062596695, 0.8614530259355333, -0.10031258044449456},
    {-0.7080850257351092, 0.35335645679833577, 0.008192892290512514, -0.13596364232587727, -0.4782924842788916, 0.5297187045927775, -0.6300545750195455, 0.12113314767865035, -0.14488290609702154, 0.7462690020392849, 0.028628150815497473, 0.09988919445732228, 0.6598063794337368, 0.14763620057717214, -0.1635807960498963, -0.11805030875609382, -0.5953552961466088, -0.40510033183720573, -0.549994071492192, 0.30457674455984746, 0.05080173378698561, 0.216745549466021, 0.16690705282944493, 0.11493027469532949, -0.21418528113561655, -0.04201482021319088, 0.05114820219839121, -0.6769012117068891, 0.6253482555410089, -0.25837171496585243, -0.08736497976865351, -0.04868683330583104, 0.1654945007963034, 0.1279515333538737, 0.46603945332137525, 0.3036812099280472, 0.3611479146671781, 0.15003225504137443, 0.5784246001079679, -0.3850508197783834, 0.2169755090092615, 0.35167242887385747, 0.957003167755952, -0.8016053147798334, -0.6285708355361393, 0.049343636020097996, 0.3319188704482199, 0.19986974391250256, 0.4694971306959438, -0.13591873629111215, -0.18571982010886443, 0.3427741922776303, -0.03256913357020722, -0.5178753357750453, -0.3616143515894234, -0.4210456525021077, -0.053573832950535846, -0.09678497443632582, -0.4144574931213577, -0.6168139426928255, -0.22593435778312737, -0.31125659232379876, -0.2681122318969422, -0.39083395635114054},
    {-0.6419978539777738, 0.42604293498450796, 0.5793369851010143, -0.1476041039366435, -0.38110583989860347, -0.16561029955333562, 0.13149638158411117, -0.12799388923121305, 0.05359878699796569, 0.2599883509911598, 0.06411420952229145, -0.29797128779939425, -0.7326555121056472, -0.26029712487334505, -0.5780517658694596, -0.2261312845089611, -0.19774785746454526, -0.514639715158528, -0.271540018631612, -0.4344271182955512, 0.12759706482212388, 0.186020346690816, -0.6714975234264989, 0.02171211476178491, -0.5398472371344566, 0.19634575135445928, -0.7447956629873667, 0.38224306200097413, -0.16799740824241505, -0.4598903621341294, 0.027299553538336678, 0.013637234510432819, -0.6855715753678021, 0.011258090278362233, 0.35076629189022496, -0.0365014419211039, -0.4903940808717052, 0.029204259229321884, 0.33142152649621914, 0.01803697068476665, -0.7713682345210243, 0.44542144914071674, 0.5578643193008633, -0.23791043587593438, -0.5987799600211693, 0.04728028580950823, 0.1223184348193025, -0.13952309859363748, 0.11557363374475901, 0.022848506637588997, 0.6198313615533078, 0.2886239478920128, 0.26273857708096315, 0.3172159893820121, -0.586938894971587, 0.4935620656810639, -1.0193016610346017, -0.1474133466732265, -0.7114896301669401, 0.16304886368171445, 0.11561244851423187, 0.03156559159632135, -0.41104637866379123, 0.22136261895462497},
    {0.28151015109553235, 0.5527264936590722, 0.5883471661855709, -0.3291320886383852, -0.7546439227997772, 0.6891002402331631, 0.046811220132402395, -0.21618774906298244, -0.12082012524041542, 0.15064829532779267, 0.37297622749536824, -0.13344412441749012, -0.07531268979145508, 0.18605054421063175, -0.15495548340687784, -0.08094721264713246, 0.2580361445347048, 0.4427621498887422, -0.13520842828300633, 0.1564589573104474, 0.20641510708017577, -0.05269493985996654, -0.17710948436875723, -0.4891453472053104, -0.21453483493715741, -0.13595227773437896, 0.0015724549740700096, 0.0979031455359927, -0.10758016964539947, 0.20913347392598466, 0.21279065857597654, -0.07333242709540878, -0.4512671923064371, 0.2743512917447649, 0.3195067479932829, 0.03199849336256324, -0.3241227367195576, -0.11609585996248525, 0.5072364567924663, 0.12361527832009644, -0.4356320667231393, -0.07522348205484297, 0.2941602430795382, -0.304345151767165, -0.12659645367413927, 0.004515907705548079, 0.3432557925766297, -0.256412073377053, 0.1947557347843688, 0.22021029498296477, -0.002068884576895459, 0.07293749128985547, 0.13085804948488142, -0.2470963858056174, -0.9736146810654709, -0.33497755106012256, -0.07976101036552426, -0.03627497217372361, -0.026305978395058483, -0.12269784542560683, 0.6225859467601854, 0.016560834512825792, -0.3715106477915478, 0.38391478100141324},
    {0.054235701140162546, 0.2643669227473284, 0.4128466530907793, -0.19495816044687697, 0.004854662723975285, 0.7240919764381331, -0.06222304553817838, -0.20858548685086167, -0.2574853041866011, 0.14146752436066065, -0.40483824370086985, 0.0405448437848793, 0.615287720815393, -0.20318234313630376, -0.18237286491099464, 0.060796987927830046, 0.20609866808021104, -0.0434557096707224, 0.07893682001393998, -0.5435190364218581, 0.12780842976211693, -0.3732603215472151, 0.1906762925503897, -0.6210308786476929, -0.23538242997921677, 0.31871695674322303, -0.17216993497913552, -0.4739282943284384, -0.07744276091016829, -0.6013194211595627, 0.25347671745657496, -8.180982012624817e-05, -0.4947526390549016, -0.08818928535676958, 0.8981687190246562, 0.2360552945721067, 0.4096854960529557, 0.3056812675975379, -0.05143934651046388, 0.3395922123335146, -0.2686727276770597, -0.21216012969907774, 0.9159357459065496, -0.44090984128400806, -0.2507893075772657, 0.659439647832265, 0.4253809076889945, -0.3069517813830188, -0.03965096680672623, -0.024345592522099568, 0.3730223257739436, 0.5979003835269456, -0.7055554866036264, 0.04174881518972935, 0.2793932439216206, 0.08483227212072113, -0.5168851800264533, -0.6384194716642673, -0.9436607112413146, -0.13719626591681278, -0.4750846430752683, -0.7034744785020037, 0.2734985724959614, 0.6785672024176841},
    {0.0937605661730469, -0.2742513334354987, 0.016412342217398675, 0.08151964123346157, -0.09757545292278914, -0.5513447496381767, 0.15827357744457357, 0.32055455148889483, 0.32221633438930225, 0.08970352034330015, -0.5577672570174087, 0.04265108948389831, 0.33858093914854553, 0.3564780513553665, 0.45410598742982156, 0.37957637741515476, -0.25859535868585987, -0.16426231854931717, -0.7652839282946778, 0.4045249506196811, 0.4009022839418574, 0.025513732309270336, 0.24440794909986474, 0.23479251578780228, 0.47322541452161043, -0.5194920671951975, 0.2583807260016133, -0.4454170621280286, -0.1139058495955138, 0.6738811134961323, -0.14811280500302806, 0.21403538617259565, -0.04537464056868509, -0.21038930177882653, 0.2487875715705485, -0.3379435011964808, -0.33276642584895316, -0.04947800871506156, -0.21340124682534642, 0.09780274066334729, 0.6948305278834693, 0.055942459431022946, 0.6515719141112098, -0.5196376518923238, 0.251316102686426, -0.01577554709673404, 0.8833716501514273, 0.3575071589801488, 0.4888157018895927, -0.25072107340955097, 0.2326040950095466, 0.20834426712104342, -0.0855078487088362, -0.14566128286766117, 0.1885187560521044, 0.12648825907641448, 0.3722055346201537, 0.2674850614375506, -0.26933492144699045, -0.3877850652317727, -0.008099295487851014, -0.05081589013272517, 0.38098423175848983, 0.3113389059529444},
    {0.35462565150677494, 0.15341280403093224, -0.3278476323855834, 0.2921321344919477, 0.7833438626569483, 0.4149302876485872, 0.5861885374847883, 0.7763051710090976, -0.07776980741662096, -0.10851292161368539, 0.03787764030532274, 0.17288874159806433, -0.38383674141438295, 0.09127530891877339, 0.2291802967187609, -0.1402041372670684, -0.30945472288238507, -0.2022897942426635, 0.0829281735446121, 0.0341997238188726, -0.2707214460293688, -0.10874511143413139, -0.4755836671444943, -0.032824871298674965, 0.6592181497319358, -0.1360148963708619, -0.38267122430137657, 0.23666252399651974, 0.1123589173487179, 0.25702527552119503, 0.008368257098767404, 0.16043036162152113, -0.5871249637250504, 0.029010992186055445, -0.3105913086740888, 0.03879948664608765, -0.25069234883740876, -0.16462068121847329, -0.1658167330594187, -0.3645658561401381, 0.2832710904456031, -1.0614949666099482, -0.18118028452241924, 0.5463932168003062, 0.16148403247650864, 0.1925612852517259, 0.20931833926004326, -0.2234935266005246, 0.2068512044478811, -0.36347599663378755, 0.26734428547535594, 0.35163474428103175, 0.23654272916373636, -0.09018368091890971, 0.1643244614431202, 0.22790619660174805, 0.13113725251115757, 0.3695288559872778, -0.47795599995368804, -0.3216387407369593, 0.011680641181291768, -0.12365166540055327, -0.19753087300284256, -0.06215120939116035},
    {0.4723142415300482, -0.3873125541114741, -0.4098872598797782, 0.01521332433085437, 0.01621650069440554, 0.1510270090348106, 0.25518741877454226, 0.007276955794173785, 0.6556037861872204, -0.14664657581424298, -0.0700743381532992, 0.3377167473038284, 0.11397153075293028, 0.1822780267340755, 0.01766758300958821, -0.24933571281018205, 0.6203537905268948, -0.44895831489608495, -0.02809285637757332, 0.03905470967966013, -0.0951935176096214, -0.24207222820870183, -0.2652338598658882, -0.284441152228402, -0.43934998410706816, 0.4859747718337152, 0.17125298510184178, 0.3640017378510417, -0.6848303287658281, -0.22170799278793146, 0.522166306107187, -0.6868860669655753, -0.705459099536164, 0.21003384927120974, 0.17013549876646, -0.3899024261892748, 0.07036810413026408, -0.37970166889137874, -0.24483016340677446, -0.048171214482774734, -0.38607789533649184, 0.03262889110065647, 0.6408954215766426, 0.2089536340496043, 0.4593546279684425, 0.446983770577682, 0.680597911065358, 0.1772125106384747, 0.3211114844400262, 0.2201902527088196, 0.17377533746446422, 0.15021896648053237, 0.28849627074111256, -0.4331436944229995, -0.7142341085268572, 0.4987426905776818, 0.3833511958267574, 0.6444779302530796, 0.005027364296716661, 0.20876772677744693, 0.40746073741531624, 0.6436721036112213, 0.22221241930116445, 0.5580577503268346},
    {0.6613353579803214, 0.19167789279751432, -0.18917690579254587, 0.37887204445238715, 0.5842293653130799, -0.2971734834190943, 0.1696500156622771, -0.03724919606701237, -0.21730154506703245, 0.27943549935009787, -0.7047566702198029, -0.027599685066711076, 0.33928787058168275, 0.8278842564527341, 0.4081761363120519, 0.22980041221910003, -0.38188629486956627, 0.25209355946434825, 0.006846077077236417, -0.347366314847622, -0.08536777479763022, -0.7076950267489541, 0.36747635820926694, 0.8908598957193936, 0.16317619479175702, 0.2165501252349353, 0.2418979659224476, 0.19165451992395044, 0.2132584442994352, 0.4709547828965499, -0.13158348283872293, -0.033425097855943275, -0.6644720886619793, 0.16932703206570654, -0.3298597549780716, 0.4269545016702683, -0.031819948567659836, 0.7572622226589493, 0.18849591454119838, 0.6236420359322747, -0.24570403713902558, -0.38871067922791097, -0.11554870546456507, 0.6960821279326205, 0.12078809889054087, -0.2604445934466502, 0.88610718743335, -0.39336289835780447, 0.29309459274484, -0.03668750652920942, 0.026150019487325104, -0.5231723337152352, -0.14595540911247668, 0.15272112403711857, 0.6518018046700416, 0.37959312391764277, 0.6909977924363125, 0.4091362879411453, 0.24450645804725468, 0.17610916041379068, 0.2687225172822181, 0.05762645981866133, 0.16621113098636278, 0.6950834195033311},
    {0.9711786180485401, 0.5375816058039309, -0.4089278434760593, 0.20866740330222605, 0.20212805026721656, -0.0563526284895019, -0.019961776746064013, -0.6087053295648781, -0.25237890107964145, -0.4839225158664934, -0.10791710928083953, 0.1417485946262098, 0.4388366199401187, 0.4124215996083135, -0.14862940828973775, -0.7613803849904136, -0.27708365847891514, 0.32941631844826236, 0.363030396785887, 0.7860026988873932, -0.65073462666579, 0.18768150347109916, 0.16967924146039348, -0.8571341519278107, 0.18118552940577606, 0.16516694054209427, 0.25139826207883964, -0.4229973801221381, 0.3762533978395561, 0.11095084894086095, -0.1580564544993397, 0.46948573512100106, -0.08532575854930417, 0.15482799514959833, -0.5436436490277409, -0.5467987727342649, -0.7556814820419929, 0.409547825985765, -0.2836727169630119, 0.24573523017351173, 0.3282435570438465, 0.24798617453119517, -0.4387093124450026, 0.17206708778739477, -0.1367596573733651, 0.11623282363865034, -0.17013862580142972, -0.4852455640984062, 0.17511516052323686, 0.08845513642587517, -0.4193971982550668, -0.8094542255516745, 0.022422935902880328, -0.09362725592163083, -0.30367762843160123, 0.6378687570385582, -0.2292174323970235, -0.8429902357303749, -0.08135323863997666, 0.4029632699062845, 0.5269884352407878, 0.35785868005257815, 0.15108374966899973, -0.2962147610339584},
    {0.8681061541352473, -0.302315215878941, -0.4288400026124956, 0.24150151462307312, 0.24418464674203996, 0.1985189547156669, 0.12734176102346179, 0.157929540047666, 0.10465377682002508, 0.11540014962421406, 0.8168956971874326, 0.6361489908743845, -0.0694290400939763, 0.47197572303146074, 0.38560369006271134, -0.36589336102777337, -0.24815851370252032, 0.42307921559600525, -0.17944985369897973, 0.14227755961631408, -0.3366435990003433, 0.8189103446559032, -0.01156902515013864, -0.10771627947739772, 0.48305971563585776, -0.035176670907911066, -0.054399889475193496, 0.4814068475135586, 0.03326568096559116, 0.5912611237354054, 0.36195518996681986, 0.576668988384114, 0.14965345167355576, 0.5563594614800595, -0.8105521999792591, -0.29943961725302, -0.6527706476569225, 0.07023723631859255, 0.08259636294781172, 0.35029976818345915, 0.3428177754598006, -0.024081569930881477, -0.3008360464027534, 0.6071588929645908, 0.1313284205910564, -0.32604209976527415, 0.37948198281696266, -0.11103718308308148, 0.3221665896154022, 0.3800131448025096, -0.5570001504609433, -0.5629445895894267, 0.11565817707683966, -0.36088529587131474, 0.18567770042025078, 0.3890781815847424, 0.0732027641454052, -0.2898786360926591, 0.32770656613548654, 0.30549626263767, -0.02625017789559329, 0.43286177996115277, -0.39602053672910137, 0.020374027955346742},
    {0.5026595950173589, 0.21463493527611127, -0.4121281013540137, 0.028993674798668802, 0.6338808623757851, -0.19446423163157872, 0.49701778079319375, -0.4467231468514191, -0.2674994513346943, -0.37499563630619315, -0.12952140885682076, 0.9868960804595291, 0.02535873717715875, 0.9420817658181961, 0.41637500392228477, 0.10317514025939986, 0.49749151146340875, 0.18073507084119994, -0.31942623894201627, 0.19648873722447988, -0.46310844453692046, 0.15783523646894307, 0.0625008768629492, -0.12087916099045543, 0.7692406793206651, 0.444986007683877, 0.349405004192073, 0.3241659770339218, -0.4264627257221127, 0.8941600477470808, 0.22585142003968847, -0.18494572224064304, 0.25561386481583315, 0.30625876915575695, -0.14855329539658504, 0.03580964617375391, -0.37790687853335153, -0.018575989334937742, -0.052335894137227626, 1.025767231341113, 0.586215864802152, -0.4500024480926273, 0.3650395061523219, 0.08977752001923944, 0.14118208134560273, -0.26549102001615327, 0.3484783438996518, 0.10181034197642198, -0.055037188860628077, 0.676409795516673, -0.3572016276869317, -0.5910958372194434, 0.2264038403375894, 0.08724246020611356, -0.06254253143322534, 0.7605836003094159, 0.8301667114753906, -0.4863417028995691, -0.11549831574775012, -0.0020662992022768296, -0.21482403854978624, 0.13001803228931239, 0.49962568014906816, 0.6660951532266083},
    {0.7968661275494363, -0.02376928483390363, 0.42241944177791607, 0.3633853889799273, 0.2660666105711965, -0.020801880649942803, 0.36430396711343294, 0.40019183416715176, 0.6083541702597438, 0.4285672829167837, -0.18224588156113156, -0.4036550924934854, 0.6828669495047305, 0.34206800015995803, 0.5513356013704189, 0.8564050419924513, -0.045099587925616164, -0.4216308986528755, 0.24226591778565074, 0.37457157488022336, -0.16612147752656775, -0.7582395324512271, 0.6852773000760037, -0.023548987810647213, -0.061784397322540145, 0.27950080689746626, 0.2500751768296547, 0.2822053239096731, -0.39647701377391764, 0.15084774113411234, 0.470302899930487, 0.36263908643006976, 0.8929881752923706, 1.1404016033226492, 0.36446141920638125, -0.028856812164622415, 0.12418416413890919, 0.09531242610538813, 0.17599172906896046, -0.22696840151638434, 0.15140676596663638, 0.27168353214130875, -0.3469299462925178, 0.6425673477610357, 0.578267449899357, -0.31453469538479256, 0.6661462284570165, -0.04315167018548987, -0.4010928408919184, 0.18241867606337175, 0.3903408025295227, -0.657300510545965, 0.48251229547825014, 0.15852795592894411, -0.3339783990369479, -0.02654738665069188, -0.026515882651714378, 0.2726971513162806, -0.45591629947157725, 0.22441965473775288, 0.215589014476457, -0.41349521037904413, -0.08955817071759938, 0.1149763428012174},
    {0.040415577915279256, -0.3028575177852343, -0.17972324463308978, -0.3589659688046984, 0.4246811917699484, 0.5295080952507544, -0.17603527392929133, 0.15700716733495973, -0.3272644872948991, 0.49294642311288184, -0.18747151448253355, -0.4853427414025873, 0.380751454131801, 0.5752691965401973, -0.02271940359543106, 0.3126581345144847, -0.4085734323671887, -0.24851832898716086, -0.2823782206215591, -0.00246364256035755, 0.035641902020969236, -0.34034065991152546, -0.17434677507619054, -0.3547960131357487, -0.18554669158306641, 0.623610649408414, -0.09563976917934448, -0.08766415127522277, 0.39331339094530504, 0.1574520669893948, 0.1412881237908388, -0.055122990709121036, -0.12494238610512384, 0.04534877691280057, 0.3863369521059263, -0.07250531412476542, 0.3026177721055505, 0.13490992596841125, 0.3130604942492483, 0.009470054036721154, -0.3639445687928937, 0.1474358882743041, -0.4096386894619, -0.2347569216581742, 0.22094982846857955, 0.2932657552810936, -0.12315117394542655, 0.47787864932139495, 0.05255869216622953, -0.10546272434199411, 0.12430095577372355, 0.4385333027784287, 0.11991449166822232, 0.29400840136013634, -0.044667449730210626, 0.04322718759270069, -0.08117650972153122, 0.22460476302680546, 0.21314408611163152, -0.07347451131026757, 0.703477333822839, 0.1601976494101973, 0.012504193894556497, -0.017661701364109748},
    {0.06408683934983798, -0.5532742988266534, 0.03041922448152328, -0.10049039874679938, 0.5151725206532085, -0.30446384665840354, -0.0007032078203540805, 0.04537799449345496, 0.16610628798054583, 0.26451723286393103, 0.21510848685907055, 0.06981363153688588, -0.3439353630357923, -0.013072549878784161, 0.21759399504659438, -0.19540681840309435, -0.22232556463506067, 0.421109064094249, -0.2280083432755367, -0.35002254096085833, -0.6691650522909519, -0.39993355804114106, 0.2940930822369588, 0.0005518760717805561, -0.3190571971506085, 0.16259858782328498, -0.12678572195600177, 0.23054479800361563, -0.4679312134983052, -0.10089531593301464, 0.012424109452405971, -0.09460688757672181, 0.005616258386936341, -0.1697491652544377, -0.09075995765422021, 0.16860061035324128, 0.33593709978717173, 0.12537948559149495, -0.18979367002830577, -0.17809200015846896, -0.4860199493081453, 0.023790415244254303, 0.17218250681258015, 0.016810624802979575, -0.012487714066622618, 0.4542930695780399, -0.5643690403642809, -0.22585334159241863, 0.10519264556598094, 0.1624003967277017, 0.10996212362243449, 0.15507289437881827, -0.026014569516690882, 0.3847845521103321, -0.1033726544564494, 0.06281666723881009, 0.3584565254349882, 0.7686901583168418, -0.2586640899602425, -0.1487326224825188, -0.08137752200931207, 0.45813495525893744, -0.031105930906810603, 0.510138354380578},
    {0.07476269398926888, -0.10087419545194636, 0.4975535222106767, 0.10897971010935373, -0.20942682843506483, -0.19894280078364165, -0.20754676103806902, -0.08499519030945027, 0.1722299732756245, -0.14148683469806342, -0.6670423261647352, 0.6409249458771623, -0.5140859880155594, -0.2512424918340354, 0.08468843223128544, 0.4221590524224336, 0.06318632579831501, -0.17295705690499197, -0.17352508046276563, 0.024495395743019215, -0.25126375997415623, 0.4108955631667906, 0.27509150372904073, 0.3313547818979637, 0.37607013176480425, -0.13495058792279743, -0.11352005679715958, -0.14491266486619273, 0.2358127486280869, 0.1471347329191167, -0.03502327457127791, -0.12206723567643996, 0.11527765073204967, 0.2473227977930658, -0.17813172607534608, -0.23862636502989976, -0.021610496028500775, 0.05779629264942723, -0.4344571249553893, 0.14362589781358417, 0.17203876208850907, 0.08370375662775904, -0.2649412944172946, -0.22559463919899972, 0.22614276710865422, -0.3224076954122405, -0.4699630350020251, -0.30291345149176785, -0.3787962383576724, -0.06650672176500227, 0.23004725879684843, -0.18879281660718508, -0.15211787171624847, -0.6411342742552364, 0.46375324096850606, 0.29939616208131203, 0.5575216066456351, 0.08035466917313473, 0.046637563682465535, -0.4195278110548832, -0.24966718147693398, 0.3326641274184066, -0.012418425973711407, -0.7177724610586469},
    {0.0069277008390223405, 0.2714220607764398, 0.030232645040868013, -0.062385725003832306, -0.16735488975752882, -0.05176206297459876, -0.027987067032495996, 0.45259622426463597, 0.17014533309188415, 0.04881791439877203, -0.2412071719790338, 0.49910677404044446, -0.1739568740712107, -0.0369825611112059, 0.3517498893958922, 0.37604984454507095, 0.38603509246879414, -0.6860062819091554, -0.08385595787698971, 0.007884947224752222, 0.007685298968843401, 0.6136585374990909, -0.18068519839955693, 0.06849907404366945, 0.7137256448288921, 0.3150861506648761, 0.2603355021908027, -0.06224544217052288, 0.3499554905460464, 0.1858426972498373, -0.08518607228154056, -0.49994152611298875, 0.4290921466984166, -0.008554273105056293, -0.027242368441471345, -0.440128371069459, -0.19188064302572197, -0.19084131777555755, -0.4696955103071118, 0.3166121364818207, 0.33549365337666637, 0.3589465660644413, 0.239512148625441, -0.10091747140693652, 0.3777881662850583, -0.4205504730456741, 0.606834120959204, -0.179318077733838, -0.009504724641613095, 0.43461910619801075, -0.23483056367596114, -0.732884167882964, 0.6999089909566015, -0.26977780954998704, 0.2248218938921132, -0.15659857688701015, 0.28808024651715575, 0.16307863470574116, 0.5775752933501267, 0.06864997617921398, -0.15960035002776118, 0.03305094857304881, 0.5772057073232648, 0.2354912969981188},
    {-0.015168580263053531, 0.21742094240654744, -0.1831056115919175, -0.15687167668245303, 0.0290168522015884, -0.5640911999632653, -0.1937969617781766, 0.2722999387616253, 0.365906745150663, -0.08590396530823813, -0.3258988266925744, -0.02422604368397665, -0.23292539764053444, -0.2172029572815407, -0.023172542064963216, -0.12674866965468945, 0.5358946101781381, -0.2897149544310345, -0.5676430586699553, -0.4731333014750016, 0.457182749699403, 0.38691456617855896, -0.40498632347277735, 0.26027913817819937, 0.18208879199217184, -0.5638762757464468, 0.06797841399529549, 0.08096852712526531, 0.3526432569373315, 0.09328529392882294, 0.31638731191230135, 0.2732036442226208, 0.30700170921608627, 0.2956606604973922, -0.15430372717947596, -0.0778138498008677, -0.12087558189670691, -0.5036359806832255, 0.10722480143411418, -0.5209424689306428, -0.027438755079581226, -0.15276045806729832, 0.49736135132691833, 0.19373744779957078, -0.22549404007391116, -0.46234885748706467, 0.6386460694853604, -0.1389729741529459, -0.04601768347718022, 0.22335459678568298, 0.16248505556300039, -0.08780737301495614, -0.04192796972524598, -0.14156405428465552, -0.24614488290282033, 0.48997926841705264, -0.4670888176569764, 0.00922278825371546, 0.403958258103728, 0.3998832404133546, -0.0016190586603690986, 0.38469642852872865, 0.39646519669382735, 0.002719485878445831},
    {0.42992287961288617, 0.23456705351069218, -0.00832894081458231, 0.3437448618778207, 0.4086896185507168, -0.16209207176397292, 0.09141055983486075, 0.19956760087424472, 0.314961415532465, -0.03461526654671684, 0.2502245085436628, -0.4266600911292948, 0.03360652885686925, -0.0938831353231193, -0.012691086723315323, 0.10701950861304825, 0.868223575923793, -0.15605669613090298, 0.49703197537028315, 0.04659043428113051, -0.28294072009758403, -0.2893655202019666, 0.15323120886700523, 0.3801242246195535, 0.05197998456865483, -0.6031391040262098, -0.5115351052935435, 0.42622916386920345, 0.3700802108059992, 0.5254255131216649, 0.19687855590124165, 0.43853268814451024, 0.4061808986617645, 0.061329259380584415, -0.18846291550546335, -0.030600058502528834, -0.4595783874540748, 0.010869362090766565, 0.21862258232433482, -0.18060941462854305, 0.052586395894884334, 0.048371538485797255, 0.6746327818362806, 0.2662301431425893, 0.15537205685162958, 0.35870730089116376, 0.16461357640384766, 0.12671960054177753, 0.22919304418890682, 0.4435184443006039, -0.07279466655019057, -0.3409502143560022, -0.07630841592757892, -0.11179979451734305, 0.10075976404564169, 0.8245621451422794, -0.3703171443554822, 0.001987398852008873, 0.4470874797378301, -0.11811212485835762, 0.1352987201219515, -0.29129516002399186, 0.09812403003949276, -0.004138304862264276},
    {0.15610676616872324, -0.15167307493725912, 0.19223349169141996, 0.14961603940335996, -0.0300951723960489, -0.42900398550571867, 0.16500182312921716, -0.27382786756975613, -0.05631599384803, -0.0933090824548594, 0.03167406628696064, -0.16684147900984883, 0.3056747679398593, 0.21691393487742344, -0.0018380119755159246, 0.2088774073094577, 0.5628875500928189, 0.11766726404479791, -0.06499710122280632, 0.22809457749759582, 0.33669771418905664, -0.4406236995792427, 0.09480715619582648, 0.01600726045650737, 0.11883642840493465, -0.7756226304081821, -0.07759934657146861, 0.08159235915747357, -0.010693853412595813, 0.3788122501776556, 0.16048902335899978, 0.5221899550381984, -0.26151244050819067, 0.511514152646754, -0.218859576769453, 0.41333387549351835, 0.02231536880338738, 0.2030559723492073, 0.07712743631290149, 0.08052600206510939, 0.597542594828003, 0.20836369617284278, 0.27709108104957103, 0.23169071371972305, 0.3679248097286029, -0.2450179807012767, 0.4891210138417201, -0.4118876729990972, 0.24181364472167716, 0.008980968237273268, -0.1127811796070068, 0.17070568347278833, -0.5058471468350605, 0.08519708515419826, 0.19485451942522053, -0.10382626292527751, 0.11404125040242506, 0.3744613741633833, -0.31714600691105793, 0.2680358912322789, 0.25306878124086923, -0.43954678949961407, -0.5751848117664311, -0.4586261114816685},
    {0.09306546076469042, -0.23561328064450296, 0.06809157082641577, -0.2986984489153534, -0.32962938025454214, -0.1898587240241374, -0.1280995443104175, -0.4002280203815155, -0.583768776681452, -0.20268507184135443, 0.005799683966811218, 0.19041004534228415, 0.030357069999225446, -0.4640237245495453, 0.0851375148474257, -0.13290777565545156, 0.5206333166111191, -0.47033876876284963, 0.01975931566221427, 0.16835475745947534, 0.15926663746944333, 0.22829591347576395, 0.5297260222400252, 0.10958505537389025, -0.43725913869392335, 0.3287605097565062, -0.2802264288678002, -0.04923250077150223, 0.030747395496510097, -0.5455297857887965, -0.5212755675882937, 0.1725534363003973, -0.3919042507626834, 0.163019870104991, -0.04487119545461386, 0.16015514823146987, 0.008738196580522313, -0.7963560232169182, -0.14993422774786744, -0.013820171969005956, 0.1104177511323542, -0.6495289552939146, 0.3877295340397934, 0.15022825842290286, -0.44796074875769726, -0.5178836857810762, -0.30392196654029574, -0.06557837091085168, 0.1038963892172726, 0.3533691825218215, 0.17677215239904376, 0.07153525153077991, -0.14833044734690065, -0.2652426153412842, -0.12329464405870727, -0.3515995991967435, 0.4268071424784011, 0.03707218955505238, -0.09673970336812993, 0.019059610261984543, -0.5134409067183735, -0.19178998626262295, -0.6125360167655897, 0.23651770273531106},
    {-0.41759481922451847, 0.4976188652255544, 0.11782365580219935, -0.277853312718851, -0.26147343457423644, 0.44199403799804854, -0.3201179337675201, 0.24025237118055146, -0.7544583079492572, -0.19049872683624378, 0.11725371125335493, 0.4843835961407989, -0.22588319635720472, -0.3242678261400383, 0.011046921828017617, 0.025204369390881273, 0.19770013241715728, -0.4820118150095567, 0.03261304441050095, 0.2473179998397033, -0.1664962584535994, 1.0076518242875416, 0.5993729461336164, 0.20062751636727472, -0.40060829977231577, -0.0249161620253989, -0.14314942514128481, -0.08651941541397104, 0.2963445764138807, -0.14087353155886123, 0.18654427266024423, -0.6405875808835447, -0.23048161444423426, 0.26531919593067516, 0.10414876972637373, 0.18193937562107448, -0.20241807938347703, -0.4654258076498098, -0.3223540155009623, 0.3092377905019855, 0.06808395295591706, 0.10360717214083999, 0.19876914280432514, -0.06956720892838635, -0.4133701131512389, -0.04220358817753986, -0.04729898629675067, 0.020976566085855217, 0.2716640044587122, 0.2136552834221788, -0.1515258079524444, 0.01727256614477299, 0.023926441573436825, -0.3643748674790001, -0.1875974499252716, -0.006272287010004884, -0.09087060009078213, -0.521987495202282, -0.3403664887166736, 0.015156482614233574, -0.22869400848915736, -0.2180298015891567, 0.005570487496713371, -0.26325262425435725},
    {-0.4088828915120862, 0.43612824217408597, -0.04699137365620724, -0.08044089592678547, -0.10404304344501737, -0.12411228896907239, -0.21835495129141086, -0.011359434442819883, -0.13656834635626, -0.878891026754067, 0.12292798097156778, 0.20927168081517758, -0.7199538774667182, 0.04612413191122368, 0.11345800936191139, 0.341434823089782, -0.266493913392723, -0.1745844597413021, 0.061164470606920956, 0.10513808541568478, -0.07351107913510949, 0.7512315989029545, 0.17525249570877105, 0.01668498254831789, -0.22001206376573088, 0.08472434019249664, -0.02213408916348179, -0.28401232613686783, 0.2985809269192694, -0.3814932890510242, 0.4942391774286521, -0.6982096435505748, 0.004367390004090337, -0.1899198741745486, -0.14943784268828073, -0.06562192210597861, 0.1486187791165497, -0.09489418411011592, 0.23556319378111665, 0.05727415795764893, 0.010851128756831098, 0.16366103241492166, -0.5066667632594629, -0.722221193428022, 0.34018090716014154, 0.08063698392895452, -0.6718179555920695, -0.34214244175767305, 0.3520656042928065, -0.20449189180900526, -0.12003005260292039, -0.03254415015792268, -0.015431395252851848, -0.5045460716257082, 0.49827012942927695, -0.015531043800857444, -0.2520890221406332, -0.5124133873089736, 0.16828375059068795, 0.07007993978416453, -0.023853518956768058, 0.007118286244370679, 0.35482280008597317, -0.5097002652410624},
    {0.1934928675699844, 0.5695148545085329, 0.02402079901829895, -0.03530500936714679, -0.23297139728364527, 0.06988449571468457, 0.367234515301768, -0.0656471382427491, -0.055016178810637174, -0.6046763491018614, 0.03172653917014071, 0.6646405847490355, -0.47765045706881837, 0.21490028119986437, 0.348845020777003, -0.07216438496457804, 0.1087969225867355, -0.07373052499676738, 0.36389884686291135, 0.14744532464683197, -0.034078925827458716, 0.5436438468233594, 0.11988762411180305, 0.058334372755285066, -0.0026718960809487204, -0.4982423346741743, 0.3045340226247896, -0.06341758444618485, 0.08282433206887366, -0.17685008764685528, -0.14268460348859058, 0.26512230341403803, -0.022752932747494705, -0.8359093262587236, -0.3095969357213743, -0.00684685885526841, 0.020089846181570458, 0.020735684040689557, -0.048271982308728624, -0.18642895045277275, 0.16617796110376912, 0.16356382535167424, 0.12779856703562978, -0.0934114898618061, 0.25010474679715083, 0.2523080164031409, -0.3738051960736736, -0.03791957196912006, 0.19013898876252597, -0.1439993268045306, -0.1041314398594926, 0.0216829841779227, -0.7432434459200695, -0.014979192218400817, 0.13940423489192705, 0.24000550113104574, 0.3453147287797023, -0.08182356997250004, -0.06845806502020022, -0.12583540344917704, 0.07286826205856499, -0.06783072489402536, 0.29569842258970586, 0.06537176899587238},
    {-0.07412881870824599, 0.005521345147738486, -0.13844929374901993, -0.5417103991700304, -0.5326378603404666, -0.0698064350824022, 0.4487499521448457, 0.32771941818044126, -0.08091709805699779, 0.3030498706371226, -0.33108923947370905, -0.2608946996997712, -0.1603046840186229, -0.029254787305256803, 0.04997191968402004, -0.5127417976372229, -0.051874098015253126, 0.2599040702793541, 0.10664411531047471, -0.010401985728089511, -0.7443260565788644, -0.4014112656286917, -0.2548847008039296, 0.39227065689038365, 0.19389188201292676, -0.5379855655007849, 0.064808128134853, -0.19283668345342161, 0.005481890580848019, -0.05807749243320445, -0.34175446211996463, 0.7395595940546305, -0.028115427551718104, -0.7125819477281924, 0.7186879259645647, 0.05431268607614895, -0.06511350170526728, 0.23032086162905235, 0.12366340173031183, -0.12237382386028638, 0.19784399524742424, 0.1682899993580623, 0.4235920266576556, 0.08209664862228341, -0.3482084066562484, -0.31960431547886703, 0.2635253954957759, 0.20783203004394718, 0.2387310255588034, 0.6883276912097465, -0.18826741260344776, 0.266976219863952, 0.07609740616236908, -0.1561725480288397, 0.05989255061349509, -0.24697171326649198, 0.3037254857423562, 0.26849414539613403, -0.31863427949993256, -0.14226238692819532, -0.26597069341223284, 0.1997836594168083, 0.07341865779490604, -0.1646614469337726},
    {-0.11031086740112309, -0.17839596433670735, 0.3861764903516528, -0.08849426393570456, 0.3272801407727296, -0.08457219826779613, 0.3495198989666979, 0.6653559073612817, 0.28979026423751153, -0.06719840613909941, 0.2139638351461098, -0.5288647323184942, 0.017037924626183858, -0.6117835869834679, -0.3654526453826759, -0.007570308679441935, -0.10022759925377431, 0.34676599280107373, -0.31251025856212206, -0.08724030349124035, -0.25104499767889543, -0.3116891437396787, 0.0052679976001653766, 0.17542324046902696, -0.4351053575947203, 0.421252287964261, 0.4020792831696964, -0.22530417327361532, -0.010016449469767154, 0.16229398095907732, 0.22197248690107818, -0.3359998293676806, -0.12498884290156195, -0.22394716998975145, 0.7515378115727639, 0.09268651414260905, 0.08372623056798234, -0.1159265334181622, -0.1575802125285982, 0.19034022729932867, -0.3148150556194041, 0.48441746200436436, 0.3746546284209487, -0.28987770070429153, -0.1366663008498394, 0.7142125694288688, 0.07236355883008659, -0.0407902343554341, 0.25156773405377997, -0.08620688416798371, -0.025584709002877907, 0.18501910043695435, -0.09673922277438103, 0.058672138659046566, -0.09005786583769967, 0.2005903737756239, 0.4113035511858551, 0.0753554830827337, -0.8577959201398014, -0.14150265963153302, -0.277035694701509, 0.014876097480375806, -0.3572300097708426, -0.2864129452580633},
    {0.5065119879374911, -0.3354891982768519, 0.0834124812913563, 0.47668960082343587, 0.5858039234299736, -0.1483859030936507, -0.06733931210384317, -0.032171497084338176, -0.10220545299082659, 0.34974337797060706, 0.17119669034180296, -0.24963239788413483, 0.014680413231223188, -0.013061400103702062, 0.03858621122166868, 0.30907751298154656, 0.1960989534410249, 0.06520750392584153, 0.023305882213176077, -0.4142404159279294, 0.3831333671521399, 0.1419331011356996, 0.07629735963365676, -0.23999939210165774, 0.10420969822930631, 0.3847039944929535, 0.6644022088419258, 0.19783524144630837, 0.17090587998430284, -0.14884621013579635, 0.382940393453011, 0.3451906577862064, 0.5816705922058899, 0.1089614251407946, -0.7509890425385574, -0.3662320791166794, 0.0352191273957404, 0.2294144976974554, -0.07588573649516986, 0.28871158898084825, -0.09090610250749857, -0.14862041541198762, -0.26716133025250655, 0.22142517192795413, -0.4134015416739155, 0.15197564035053437, -0.03943887745885641, -0.1169292724943902, -0.0810475694052929, -0.1569419858533163, 0.14061836509416994, -0.3992544294878163, -0.05307537460652475, 0.23801615123622907, -0.46626898775233705, -0.3105720926239843, 0.20664863039789844, 0.08020635582603262, -0.09675823815931184, 0.3503965392643082, -0.10220296569035736, -0.206417269313307, 0.04018185886378611, 0.2286134469149962},
    {0.12952853684632645, 0.08462791065903764, -0.306829128449089, 0.18525145889891834, -0.262325918344664, -0.4265259986256256, -0.060903432891301915, -0.23404827484189702, -0.21345945425435076, 0.8542303839536988, -0.17472292198821573, 0.06836559983948758, 0.12740111358264755, -0.4219654334631317, -0.08875217831683078, -0.18531180551128143, 0.4746514420262477, -0.1756502685610834, 0.08543706498923692, -0.3600897130680002, 0.06406485134003582, 0.07749454949919754, -0.0835269678027598, -0.1353362032126686, -0.043795971416616904, 0.34383411991079055, -0.3687328950739657, 0.4169198859391355, 0.26113708688450005, -0.037979086937139306, -0.08090069417652408, 0.1644509903740101, -0.10766055560877254, 0.5077497671128037, 0.06312955391187786, -0.09269537822188192, -0.15478346393798173, 0.02898490257257751, 0.3938944127100497, 0.07086851076454619, 0.23769878055134633, 0.09688316800099164, -0.45247932768970534, -0.10854004397820674, -0.36334777539955304, -0.5691242094733381, 0.18119891800345506, 0.22794941593110638, -0.13608388499193508, 0.34640359012612154, 0.30884372746107336, 0.33043217054818286, 0.47274577900684966, 0.1669732041127211, -0.3591244283491724, 0.1230894573470048, -0.26044832710881, 0.038540502362562935, 0.6734899168885967, 0.5535404526475696, 0.09969201855012318, -0.24989831944633717, -0.0036406911766488923, 0.2198305550561696},
    {-0.4685953025204949, 0.1843764220722652, 0.13731724426558856, -0.4347040263859383, -0.4519763425940188, -0.7609908332785048, -0.05575768465085643, -0.12030820465745064, 0.13605905044830696, -0.32631376380011534, 0.07719325293466839, -0.03016816258249253, 0.09065571393814031, -0.40415366687172855, -0.3252760985917535, -0.3193165007682456, 0.05021478140155087, -0.1998801373667141, -0.5123281252904116, -0.3057678851048519, 0.19437616453752268, 0.43637064440406265, -0.1243518408058071, -0.17244216423136532, 0.08420498316649104, -0.06659978230204563, -0.3730377959394869, 0.07835284244981316, -0.26274713237628633, -0.041663410341955594, -0.6089410338172302, -0.5183255666246444, 0.26201627717591996, 0.2332799673885442, 0.20263767628393584, 0.3222654290779008, -0.45959744189860235, -0.13299524252464484, -0.17369629426512165, -0.20842190371249691, -0.0566328467474322, 0.19699783741915444, 0.5499175369361142, 0.0639999570021016, -0.2538142330114442, 0.24982499627209545, 0.16232652796114916, 0.24323864807944634, 0.36921795774537336, 0.15725929484219675, -0.1270072722458221, 0.27404212714283094, 0.09216755672457418, 0.18929107536060855, -0.24370296354164314, 0.7692531290197075, -0.5744356349057949, 0.07494176696850251, 0.1917820744941478, 0.5624316600606725, 0.4347144344869978, 0.3262325083524183, -0.10217742889906987, -0.0058791912228428785},
    {-0.23148736908125897, 0.03649284765496142, 0.28821094539110054, -0.24060698206101702, 0.082531857319446, -0.04839915979402139, -0.03824036524657518, 0.7723202324025135, 0.2630245773131296, -0.04370874722224969, 0.11269057996143575, 0.21474024090059243, -0.08034406316940218, -0.26319355808905925, -0.29242183592466764, -0.4494505908007821, 0.1667938840321229, -0.42338794994397544, -0.31557103346740506, -0.025846493686729626, -0.380236021451223, 0.15698312936957862, -0.43655211280690664, -0.22910572579728566, 0.1647465982840272, 0.25029843823458064, -0.2636297202968645, 0.15052204147090012, -0.06111357777387118, 0.4318502811086162, 0.0729496256398977, -0.01946975207974735, -0.05891761558202609, 0.12635885585419224, -0.21331623610401543, 0.4081093105568433, 0.055437304799994515, -0.3166551649289278, -0.3937913037725901, 0.0679854882969718, -0.3216356592553868, 0.24289998821635853, 0.19354687601367448, -0.10987208339807862, 0.11513988110871969, -0.3896306486406116, -0.35833259068751666, -0.10336149514813008, -0.12234038086756213, -0.1644310425633749, -0.04941634483645701, 0.11785050871253272, 0.12503881680240791, 0.15518032030161275, -0.14523313677581606, -0.019927404435248364, 0.2853450794011032, -0.08215592329158468, -0.013998360247869272, -0.10147427100464292, -0.2539723337063377, -0.4627414589050245, 0.013379157448524715, -0.4583560835252137},
    {-0.15295009591077732, -0.4756942384378666, 0.184880277836514, 0.08222783788165762, -0.17547297722610178, 0.26309174276289127, -0.21916957205606716, 0.29127723235171427, -0.49361321100868155, -0.07341358561149101, 0.06301655137689523, -0.2540912178642526, -0.013687279443327798, -0.06877137170855761, 0.03031047690541881, 0.05992601767155618, -0.27343719984823245, 0.11521129122930475, 0.4434255541516437, -0.10122864480981153, -0.19773812381715192, -0.5253191108480858, -0.3534107240703414, -0.4409473869799396, 0.5891615449344665, -0.31454739686341765, 0.09557281172990889, -0.531796783055094, -0.03610273367623519, 0.06387927653263703, -0.33851849015427965, -0.005004347363696459, 0.10227078168474057, -0.037573749853241176, -0.6990038422588392, -0.1465048506269321, -0.031034205720331397, 0.4924560365298293, -0.5140399911220008, 0.2054177846263754, -0.5718573359971328, -0.19253328282621926, -0.3277490422223979, 0.22265475546025335, 0.2534995271683153, -0.22172845169161476, 0.12295840517998566, -0.2447597849180339, -0.7038903082592094, -0.1255523269242415, -0.3055230256081907, 0.2642044111458474, -0.13146076053250422, -0.10148629036506102, -0.30197633688678255, -0.28331439971467876, -0.5774092878163515, -0.05001238400241365, -0.5470779153630619, -0.3865316443707746, -0.5433808424208313, -0.6276390352125918, 0.10006888077126672, -0.34987304875220393},
    {-0.13729840643000232, 0.2854000601909464, -0.19359894716035422, 0.14520610101779072, -0.40360618466261916, 0.3858343938250002, -0.05045402322057906, -0.036287138772418494, -0.2573706647185271, 0.006480220564591522, 0.3666141690977149, 0.09774994425949719, 0.08381343813998071, 0.4906991423607943, -0.2323410870052292, -0.28016274299317206, -0.3182812436138727, 0.19927946792085938, -0.38906814452612376, 0.007338753981941698, 0.40608949409114525, -0.22470342138096974, -0.529847091784803, -0.5334358492503165, -0.5420313287024804, -0.26526455576970775, 0.2184608004379599, -0.34767581246423973, -0.45502823286828337, -0.34824710535862163, -0.07814027857770094, -0.25853008905141683, -0.18592834509171247, -0.21879050499308692, -0.5024764492182459, -0.12538618746567687, -0.1830300051897106, -0.02824171989579634, 0.49932573354149556, 0.6455228921597793, -0.8235777517352205, 0.025980840699758766, -0.4769373455648452, 0.3586202397752006, 0.2729914425727872, -0.20301938885833934, 0.1574834779751201, 0.037238680614968746, -0.2963792237726095, -0.08115335841571072, 0.168382296679632, -0.5460885175502703, -0.3386578281854057, -0.18261165703752116, -0.7214975818336671, -0.2944281038208362, -0.058055610750696464, -0.30619378576130096, -0.6680733153211554, -0.7474201969827027, -0.2327261078336146, -0.34760737696473265, -0.1718133747697532, -0.38126046249926027},
    {0.24322129159569927, 0.3485034919809551, -0.25901344005469, 0.039408095963249595, 0.33114695536672956, 0.44206518667642103, -0.22403059723171664, 0.2989710212685078, 0.015922621573450372, -0.36911486029193064, 0.41534726670904554, 0.4357202502207922, -0.0535502236278617, 0.24121143199527698, 0.08696548643740758, 0.10964150358720863, 0.04131264566466726, 0.1829593638175152, -0.19103506369223908, 0.10042206670057613, 0.21493795405151495, -0.32522875280095753, 0.035554861255264046, -0.1104348604314078, 0.0013606301018380285, -0.11300903362597035, 0.455420646476934, 0.03937423151412314, -0.39563033575384404, 0.4565732548921635, 0.3710106257279865, 0.4371847008013534, 0.02062819141902814, -0.20304822956162796, -0.39577243423722225, -0.34154737282589565, -0.06507935523550964, 0.12198283817545016, 0.06063095467278471, 0.3589540195846121, 0.18045142745760007, -0.11838392055262487, -0.9170543295989926, -0.08033606185914506, 0.27351121160065983, -0.4210484723498472, 0.3048831751777033, 0.13512038932910492, -0.08781272465153835, 0.17510210082201838, 0.025069886421328326, -0.23407662127022877, -0.2878376342159441, -0.0352640650650007, 0.2778608572297849, 0.454612259922707, 0.16145362436328048, -0.0645924570701795, 0.39186141160603977, 0.15352654572383745, -0.01211101351504062, -0.19678877432301017, 0.08347672886997154, -0.15114202703514126},
    {-0.017041977059337635, 0.3962547091460129, 0.05433642495164737, 0.13046546972969109, -0.25603503833286545, -0.009006901149287105, -0.23470041445729037, 0.045345987137320305, 0.06387682824821414, -0.6157513074407305, 0.03406334802366063, -0.46982807642397284, -0.09059056454103115, 0.42157766465388774, 0.03932738578667396, 0.48571504781427005, 0.4129900977308556, 0.32813899188718954, -0.1203938514528173, -0.09326792610952737, 0.11611994821103823, -0.03522656011376863, -0.0473705050257179, 0.3897759187624067, -0.4107077554802067, -0.1800831377816855, -0.15771941732408026, -0.027562644973892932, 0.4448308954562484, 0.4422619341532301, 0.34845696144714683, -0.009854466886871716, 0.11983904721294839, -0.09912582003392838, 0.31755037493857585, 0.17616444572221254, -0.1695028850432145, 0.30029709470551996, -0.11598747213512318, 0.14645869904946693, 0.42778593354570765, 0.188604503993558, 0.1826212713658388, -0.25584554991853414, 0.13248315983992523, -0.4268757385181559, 0.44161176584932826, 0.705155378628949, 0.08032844844186625, -0.018215338818808633, -0.03578348456798717, -0.30351239450594936, -0.026801557780542266, 0.43706292993836393, 0.03263123164006735, -0.2234308205561362, 0.25085419089156014, -0.030511704432647394, 0.7152948052060668, 0.1528726412692281, 0.2207113619002153, -0.21889603905736385, 0.2940632763133657, -0.25003855535358926},
    {0.328027130091258, -0.13862949455043494, -0.14152312061309014, -0.11570873911953705, -0.2400955874969794, 0.4824434910251763, -0.39374914371959513, -0.48235058926728197, 0.10886829775243301, -0.2601126308138777, -0.45977980325359985, -0.1803264565745429, -0.07103397258600969, 0.2828285208836238, -0.17099613470430147, 0.2638430483980667, -0.1088494164220844, -0.4139487692251785, 0.2809128975894261, -0.08840316033006317, 0.18663211149971926, 0.14495471275587052, -0.8796691266991609, 0.3196645348784604, -0.3959639878694246, 0.36524243357453684, -0.14618493340488664, 0.11486990803164313, 0.15844472437290558, -0.04100017731339293, -0.07223672127538965, -0.6083592134558483, 0.2504893749833967, -0.30698666252071066, -0.02478189184128753, 0.10656429516414195, -0.013312106656806225, -0.42934838603098596, 0.16984730218755897, -0.38743503181863775, -0.04775327948445232, 0.1782620175649016, 0.45961032570262117, 0.15668145265761227, 0.010705216759489619, -0.2909656710620293, 0.181015952768166, 0.0841859626402329, 0.5000030626378588, 0.13416390905008782, -0.21108300012496795, -0.4005567647002861, 0.16503928708012222, -0.20048329670671564, 0.04835746260546262, -0.29317442462624316, 0.029035660207471142, -0.44363738432738525, 0.2691746452594417, 0.3951993620848056, 0.4088928135558902, 0.4226461109243686, 0.26845076570261783, -0.20134500790656001},
    {0.5796505060186393, -0.3975334760609678, 0.39162337595348734, 0.1935495436314356, -0.09728798457766828, 0.7078144017997612, 0.20440138303154873, 0.07774402239865787, -0.04316490070129773, 0.28790751546122395, -0.4962036929320626, -0.021693039296757657, -0.043888326094038525, 0.26877441543894354, -0.3844228094173119, -0.11317475733134158, -0.7496059307313127, 0.23523371799601558, 0.2263765377367444, 0.4210384915707746, -0.1702729722423662, -0.2532946055545473, -0.1534419905793765, 0.22259183597166438, 0.4103799002984254, 0.09271025034726427, -0.007874703518957084, 0.18656757569811924, 0.05949695710304561, -0.068251889933365, -0.39438549345591, -0.11365995297519683, 0.351894423947651, -0.4331054599168601, 0.25292833970013817, -0.16741886164322484, 0.12276680907072574, 0.31751629202194187, 0.45525817503746363, 0.13657772150574496, 0.7276211783640119, -0.3282759461485913, 0.046454549493521534, 0.2187011714404242, 0.09768155408947028, -0.7170040625178438, 0.3279428971159572, -0.15241131193783156, 0.29788277598041507, -0.02659032552241174, -0.19276917678069663, -0.05795336570253039, -0.16313825850909974, -0.18458678725735106, 0.2706934809114482, -0.07337889055472174, -0.16245398267780112, -0.25974741936526596, -0.12824648383985454, -0.011613311983420702, 0.19779372190485653, 0.1026914079859237, 0.09092225891102139, -0.2802804288754242},
    {-0.5328514513677729, -0.479986940733445, -0.5226781960395076, -0.1759960471650305, -0.2453522185231747, 0.2811659730718477, 0.6141735184617542, 0.5318335551974679, -0.21454996765978052, 0.08779241840109124, -0.43779380228682735, -0.546395994196485, -0.1392685239455364, -0.16774881373073267, -0.5016307248913844, -0.43960698186238306, -0.07787419410243868, 0.6403194706526569, 0.1841626220883027, -0.34009973941057053, -0.18290073049076047, -0.2556071891480438, -0.12347519580536358, 0.37920728886066263, 0.05517508389490358, 0.18501857538023467, -0.029328070023202736, -0.20793292307666514, -0.042039558517596436, -0.18504453466895418, -0.10665913219891629, 0.9724092098147921, 0.5967580259613487, -0.7357615778988791, -0.0071124685780728815, -0.14087058216199033, 0.04075115237319938, 0.16536037826003477, 0.05651959183958864, -0.4869528431253012, -0.2641657572885362, 0.03976764460567501, -0.24948855947315565, -0.10165996793215566, -0.5150513253079975, -0.10162048386485557, 0.4676406073107999, -0.0324447501437659, 0.004513914181944689, 0.16462358984768286, 0.6012177555893675, 0.19101739424090236, -0.19918460718223557, -0.16108577604260965, 0.05760717543058606, -0.3912086480388096, 0.7752896380577939, -0.3383474471373303, -0.49560371724769525, -0.10457972520793755, -0.403669488713647, -0.40816332151075535, -0.0480633623639177, -0.32874280394125566},
    {-0.30381110152557045, -0.6238595816132805, 0.35032370313514466, 0.08902529882412137, 0.17637112944879238, -0.09273190629988917, -0.1320384712227739, -0.1897141875381999, -0.031309873572328784, -0.015630686446816044, -0.7173630791585643, 0.19615120979985382, -0.3326242112159335, 0.009663446895355336, 0.10740641658333025, 0.030544707340056557, 0.5756229883917653, 0.045010047459722084, -0.3108484272716655, 0.02509870333034476, -0.11491266566199318, -0.03393568556643026, -0.21403359650987616, -0.058512045626410075, -0.14247102068373607, 0.23158272242846367, 0.19614423140743864, -0.13269002864151297, -0.2035761423947295, -0.5594062220003013, -0.10351562915535031, -0.490623384772551, 0.16958068542191723, -0.005065333561706562, 0.08956703702475592, 0.30963592158135483, -0.37929752744072875, 0.05566615535650051, 0.11368121483179412, -0.020978722102322264, -0.22096297874360654, -0.3159530336601483, 0.13035314902110928, -0.32870874728431587, -0.09429350463666117, 0.6964394857735408, -0.2587303689719694, -0.015402633736469008, 0.5956863426423868, -0.2505263007445387, 0.27293433590428606, 0.3117211999197684, -0.23468434760035975, -0.5141671434926985, 0.030714440972035486, -0.1517287742243055, -0.26140189090209426, -0.3093476373853044, -0.2161695937836744, -0.017469690281773195, -0.19460835045951774, -0.1706377973124699, 0.033206791379796666, -0.32902257063954166},
    {0.3277168981001653, 0.15843754087469486, -0.5722682892044335, 0.13699501768688888, -0.10779318799464196, 0.2231859611171385, 0.28928801124037995, 0.07502886728857776, -0.243329505768112, -0.0340900580718192, -0.4368675602983136, 0.5905674296902863, -0.2053508815018113, -0.15912021617356167, -0.26474889346822006, -0.19079920274398005, -0.5444485410641461, 0.2818492816030667, 0.6151110486132727, -0.11970833703137002, 0.2559676530860066, 0.1020041507485254, 0.39595285304334366, 0.21852030409377612, -0.12872294558168046, -0.06319817522284651, -0.06922358118866503, -0.25151573380133013, 0.051646493712741715, -0.05979246182023431, 0.3738421240888189, -0.1598411520138723, -0.5732829698528369, -0.18843943175297376, -0.07372818410151649, -0.054289994164911315, 0.06874571149226771, 0.030570335340742112, -0.1529382552098013, -0.029742472194465783, 0.33054186056601287, 0.15845078001780824, 0.39643625334578997, 0.09782722970179258, 0.4218732885913212, 0.3902076459057742, 0.18837139398895902, -0.795403277846388, 0.1429434281694896, -0.25952320507246374, 0.41659762787259474, 0.36723207247956074, -0.21580894764286906, 0.03972027429572142, -0.09117063281444358, 0.5423442056461103, -0.033006954527000386, -0.008664704608961, 0.4674243674059469, -0.0593865575611657, 0.07170259242956144, -0.3255101502014251, 0.10912684189292403, 0.34613187770284765},
    {0.5072477604608662, 0.2001051739186887, 0.05788339852372292, 0.5600668889160657, -0.31482957231927067, -0.2960618537241159, 0.15692229593015605, -0.07858433574725206, 0.35059446409740525, -0.4014550258768758, 0.04070168803126895, 0.156278973025967, -0.19804709224096842, 0.19961496808845164, 0.2549172605335356, 0.02629305065434222, 0.12515402389186592, -0.04244490905567405, 0.48021365688123463, 0.057549998369510975, 0.020870338637437463, 0.04458982869773509, -0.13231876348034022, -0.0605760378120221, 0.28120641157628046, 0.25823916661813734, 0.27587261398604784, 0.09882992743509013, -0.26904583367097556, 0.36807001089564767, -0.07939403328174124, 0.17663971018928246, -0.1442046208122603, 0.11931723153355892, -0.1304470575981219, -0.1666107373639344, -0.39316215438915847, 0.14748627207573517, -0.43266598521039495, -0.08483905048557179, -0.19918030031656703, -0.9131471634831793, -0.5136963898885057, 0.049796630321019504, -0.023205793220349012, -0.22945114477713935, 0.44284557861234547, -0.39901192882165726, -0.07580371411244358, 0.42128611614850836, -0.025108331529213098, 0.6341446500835606, 0.06956029663528514, -0.2169681090112484, -0.1798803751368951, -0.11982032996074418, -0.4298081719825005, 0.3109677469147103, 0.13724783259971518, 0.5312084194437888, 0.4606200447350262, 0.5498272066869843, 0.5070647269156698, 0.04752832249145401},
    {-0.12829615054595686, 0.3213337515225627, 0.7182647676177233, 0.4161803128007136, 0.07055471580376887, -0.3725750418452166, -0.0684336406287485, 0.3748420167018269, 0.1720272503268351, 0.22518946552767083, -0.18434707914713014, -0.08465140510736513, 0.28121370045589406, -0.055841125214274645, -0.10297150553352984, -0.2922934698641222, 0.32899664820775804, -0.06973322189216452, -0.39773429236511987, 0.1613158939657349, 0.01532202892354946, -0.16287521797919932, 0.8742528478965368, 0.28977560043399425, -0.21771096238742757, 0.44179685109882466, -0.1639169735225536, 0.497950929759599, 0.2828018707856031, 0.03864137380644098, 0.0002866277548148511, -0.5424154650668678, 0.33003499870975955, 0.30325823320425443, 0.013429501261229675, 0.3166132317391076, 0.1636095444298434, -0.33510261012325554, -0.12521194743979347, 0.1870627788581452, -0.12201429504842172, 0.5112675932250355, -0.5281533139653085, -0.07641729247818049, -0.18393045049640372, -0.5648645673083253, -0.05457232766214022, -0.2754413916289276, -0.1746958951625832, 0.15464258916120255, 0.07917403796671814, 0.3132525579457722, 0.14802970677491864, 0.18197785856750118, 0.010932904528810199, 0.27127839220022615, 0.07622188943647885, 0.17069153550448526, 0.1721407622457935, -0.006499900568711687, 0.07989759925083767, 0.12599731351335344, -0.029597262405096657, 0.1027720402749598},
    {0.05176141381382536, 0.32805219725805174, -0.23453682037342843, -0.27295558852778995, 0.3127755341361703, -0.07534991606830738, 0.6169658242141088, -0.43028343757969345, -0.1641821323133244, 0.3422008686221032, -0.09205225088216872, -0.2224962634154936, -0.41332642850961904, -0.049517233744500885, -0.13123923468069557, -0.43395363499035766, 0.029696329394470915, -0.594578097622687, -0.18307159611394488, -0.3223969843402194, 0.21931714396007684, -0.17498073385271454, -0.19829434054588035, -0.19068260794174102, -0.3714748597480602, -0.21702403255917802, 0.010962402673551511, -0.3427574520768557, -0.2359149925651043, 0.03457338606010871, -0.7712496286363902, 0.3044190141460691, -0.6767023030063485, -0.10295100449731669, -0.018011089745819702, -0.05894119723678047, -0.26357433063629176, -0.31206873324523166, 0.08480175162984158, -0.11985553690494773, 0.10469108445794352, -0.14159946365454762, 0.02287220368089792, 0.4045724429409083, 0.058275292458329006, -0.5369861905946219, 0.1836839463933842, 0.34095698661570983, 0.13376657263119102, -0.3759827962459568, -0.23399648583877788, -0.5041738349992428, 0.1454010902719217, -0.031398022151514375, -0.3698011934275714, 0.4921649569268937, 0.062278961963330805, -0.1664960022240252, -0.2394270295508861, -0.2097501110281716, -0.3205681028277684, -0.23857689874308607, -0.4435730342049971, -0.25209748037997504},
    {-0.2885687304486925, -0.30573382089100515, -0.12887773346781017, -0.1498153452731753, -0.27206069077396766, 0.45761487685949065, -0.0823704542833301, -0.06441748493105387, -0.14809374282738996, -0.006989167264554567, 0.4182153835578561, -0.2737905361322417, 0.23445083335493713, 0.22946196787520476, 0.07533526989933019, -0.22496711953178153, -0.5389710557350618, -0.034672295224244865, 0.3133551701866537, 0.0991798071306529, 0.290277976665052, 0.3820675294320453, -0.4033122128928591, -0.6883908144052221, -0.16801217467977503, 0.010146730735674488, 0.5680469853269465, -0.141780307960232, -0.5866833227812958, -0.14602420098571528, -0.0670934886523104, -0.1884439335703348, 0.463494833711874, -0.422181843451512, -0.5855462768985522, -0.10396692888548609, -0.07151057044499888, 0.3624152324569309, 0.17714252761462496, -0.09791673707581885, -0.2514146937265953, -0.3312814782399163, 0.2587759278987419, 0.19597726678681882, 0.09559137806453098, 0.19037421848824043, 0.2315751620891967, -0.31006028365801247, 0.10484506704873167, -0.14345153824704457, -0.5829738400018267, -0.04637581271201407, -0.23158824016014226, 0.02784056672219105, -0.12972971365535427, 0.07809204238182992, -0.271032358597511, -0.242054900963115, -0.2298131207686604, -0.20503734838396104, 0.3557779907439912, -0.6884755325804655, -0.32706119775568493, -0.0790331337996426},
    {0.06214286864122716, -1.2730741980205151, -0.8813764044740993, 0.6156683981695975, -0.7101728137665104, -0.08221139208615333, 1.0231915654813335, -1.2925616500256476, 0.5399476220318837, -1.2124048225245165, -0.0029426395639575204, 0.587355999045637, -1.2158647756017762, 0.06288964984177355, 0.41946374161544286, -1.0131798956457307, -0.047674131172377954, 0.498896508511216, 0.15955197332969243, 0.1805865701826828, -0.513414409788277, -0.5235404946783043, 0.7154693336234506, -1.0459976976072374, 0.601256325417003, -0.9040961199148462, 0.49945519451053355, -0.5517086489744945, -0.9987579971381778, -0.1407123019895778, 0.2925570101517062, 0.46833579251508256, 0.6076572140530963, -0.4690094492566132, -0.49466403038646445, -0.7701442425460084, -1.0556346231697658, 0.6161541845423986, -1.2992797553405193, 0.3839658216033219, 0.5170084638002684, -1.326590512541281, -0.10481818435592237, 0.49002635728121824, 0.26592682024475467, -0.7127519537623146, -0.09966992560981358, -0.9550296203939747, -0.1589848896831656, -0.3816048657921338, -0.7914395927986494, -0.5713982826409394, -0.8104728937178916, -1.1734348869277704, 0.3880183892500808, 0.5176371730127998, -0.08297110878235156, -1.3345722577437578, 0.7187745826996057, 0.5354313304304533, -0.6432665458182596, -0.06501825188081997, 0.6907691917107256, 0.2233990798689329},
    {0.6821463896676482, -0.5740964446912581, -1.041360384956849, 0.671164945787416, -0.4474794723599378, 0.6033248136391618, 0.6827298382259839, -1.1030981497822718, 0.961336640863486, -1.182153847823249, 0.21377574790444887, 0.9067480215911933, -0.7571235098798356, 0.9852337203498813, 0.568255857112499, -0.8553578155834981, 0.29354782229031395, 0.4303964733644378, 0.36618975652832525, 0.6952718116913165, -0.7813175613421602, -0.0507867125087188, 0.6164265992101893, -0.8370682427443912, 0.8181546769233167, -0.6784122976654597, 0.9802392939416101, 0.32428808923584995, -1.241749054597287, 0.4182750967280004, 0.2454981783404615, 0.7425445208416377, 0.5465080670993564, -0.2527320119854273, -0.6887155962628241, -0.7009894567682605, -0.9978553662548235, 0.7149597251233749, -1.4061769235262351, 0.9783850303261143, 0.6596735571174597, -1.3996859815740792, 0.6116285522681589, 0.4627549511047801, 0.7155253577159402, -0.6055763733334545, 0.796927897988523, -0.7670789963098954, 0.33282015852060504, 0.14002207843691206, -0.7615865908385793, -0.7361066161069069, -0.22408383307466054, -1.214919145966671, 0.8840079048183399, 0.9873586541383388, 0.5473468900072672, -1.141811141441501, 0.670952499934416, 0.7652915199964145, -0.049604870758535334, 0.5657739477385219, 0.8768277411864055, 0.612870941426246},
    {-0.44945583943335143, -0.44599266655260456, -0.3603221236140318, 0.4222954506840571, -0.6399122129899036, -0.006466833900660506, 0.37704252922331727, -0.4984967769288954, 0.8183505617933663, -0.31161864407628725, 0.14139982568429688, 0.6585035277202028, -0.5769090872665742, 0.09920761262753995, 0.25811962256255166, -0.7061842449470155, -0.4605866569849541, 0.20722353951297126, 0.3340183917660716, 0.9679544826216451, -0.5423587524498907, -0.2071809738394726, 0.3603100652722339, -0.44396362658052185, 0.49978690901096623, -1.0075203587043156, 0.5365214998615314, -0.7595308599441198, 0.1835330787912901, -0.35498297895945674, -0.3810952318953965, 0.33629895726631237, 0.055953579710451784, -0.3888085941901164, -0.032291787561765935, -0.5046962784202437, -1.024087986790426, 0.5298149416555956, -0.6010531937367678, 0.7163549390105436, 0.30635767823195703, -0.5323339958535231, 0.3804972639469872, 0.8866128255164629, -0.15141947110210846, -1.0734282769106165, -0.23747582963269537, -0.39727655075260315, -0.42173381963373063, -0.40388311081990896, -0.8575712695991672, -0.2641970300335125, -0.9924588359734033, -1.0367213106023725, 0.3839070495659165, 0.023681051617555002, -0.17323149450922296, -0.5577351857897241, 0.5795961500813049, -0.026244900921165146, -0.06236864723336067, -0.6922988277587336, 0.5278467723084279, 0.02666448264852779},
    {0.02248602703117695, -0.6464001934873057, -0.38866074119073235, 0.4033016500984107, -0.8098551309709288, -0.7159292826111205, 0.38520390489759104, -0.2643710474671848, 0.10008102923558079, -0.5344895571261894, -0.006811003009539488, -0.06013163930321611, 0.299571852583464, -0.3198590398612938, 0.5522509135647039, 0.2602890763901732, -0.21339289324276822, 0.6389389800348203, 0.48204250032684043, 0.40752993139007637, -0.19782792892691745, 0.0572520607740039, 0.5334652460167051, -0.009467145615845954, 0.4727139083265739, -0.5520989014498844, 0.41235046010958354, -0.6960515281605284, -0.5935025994826951, -0.49050615419243593, -0.4689971425956176, 0.7811738197522022, 0.35507844035539515, -0.462798107214653, -0.1590189170417484, -0.36389701291686594, -0.48925895322320717, 0.33017398452438135, -0.7253397467610582, 0.554972144576097, 0.8475605438907065, -0.4348805023892495, -0.8127465399720794, 0.47249463848830964, 0.4476332740113518, -0.461897745845041, -0.1108375318468949, -0.1373042233864577, -0.8087438503087492, -0.47261115166817114, -0.11549605438433877, 0.10536573912379502, -0.6096849471901581, -0.15463113461207628, -0.08206646888334676, -0.10195525988490976, -0.3804534243619975, -0.12828186398878313, 0.5320246194140564, 0.2878786791485546, 0.122942350665304, -0.7806538345009681, 0.24779540956941226, -0.24477076787860513},
    {-0.16105658254931304, -0.4142518111688562, -0.4536053139778017, 0.3807309117820858, -0.375704955712208, -0.1816540402224298, 0.18679803356438304, -0.15102099147383544, 0.2654395255663497, -0.2739061784447428, -0.2368422877921312, 0.13459231127449506, -0.3932110794661819, 0.5810235189951575, 0.49953322482040313, -0.4675005292594246, -0.09694340556937793, 0.723665971046863, -0.11571951282433045, 0.48675364606219595, -0.30912028311846884, 0.3032092552870956, -0.08132499767965055, -0.26323847573159576, 0.6332420230139355, -0.47539369491569766, 0.6431362920356879, -0.515224573101966, -0.554310094343973, -0.6140118889284542, -0.3278438709043158, 0.23832022552906593, 0.6625330962618325, -0.20588604369681085, -0.09957201410687068, -0.018927946192631905, -0.6176717985999403, 0.5104175867489779, -0.39821120131112325, 0.7166702854871433, 0.4791747317222931, -0.8745873221496503, -0.18682946241152776, 0.6123805024671299, 0.3950573534003326, -0.1641661785954455, 0.24266071488806076, -0.13703903095300285, -0.278213656875985, -0.04725591887560994, -0.33613158463693277, 0.07696005239423534, -0.3040774706717296, -0.9789275899820912, 0.28520989306095273, 0.37103612290186444, -0.04818375972706081, -0.8760516710848486, 0.0498119230559787, -0.1430519329331676, -0.298617689446837, -0.2618426611062688, 0.007329801804363692, -0.33211005519621206},
    {-0.6513323745494277, -0.9232465818293922, -0.36362299030189776, 1.0114592574569738, -0.13418950453424286, -0.26099536312520244, 0.38331524291454666, -0.3051389420475879, 0.32167076834392594, -0.4747967030137473, -0.11826715430739151, 0.47127934942714816, 0.038016616494416816, 0.4954872213801587, 0.303677966846116, -0.5078340682553081, 0.6102764047068303, 0.008475029765746364, 0.5326785508202299, 0.5995458001916795, -0.5509562459894317, -0.5264411018591434, 0.29972034554430677, -0.00918786890475819, 0.32096525208951204, -0.6202717290206133, 0.27827495648566664, -0.6091778348613505, -0.28232398710341555, 0.3317134410563658, 0.08788947958267353, -0.456980023529577, 0.2726989055311945, -0.41183431818259336, -0.8054241976457653, -0.2587522262815253, -0.5381786712189975, 0.6476865998317045, -0.2557877492843861, 0.494087396283535, 0.025559330673857884, -0.36667222117876014, 0.33865688475800615, -0.33270329348776667, 0.33482650393083646, -0.334405030168981, 0.9675883546726333, -0.7172514490282311, -0.42961111514163847, -0.6745015256698218, -0.3056996155670055, -0.46545989004930716, -0.7186316161428677, -0.7769639005181938, -0.01603782293656114, 0.7567446400131144, 0.04604691791178586, -0.556983394165888, 0.7172570089326634, -0.08664017550538419, 0.35593565574477487, -0.36682125268655436, 0.05609070132626804, 0.2982766010791928},
    {-0.14950301958532966, -0.33824874168715563, 0.24512818175906959, 0.352457066898402, -0.24819774460713437, 0.3939097165584532, 0.33550635041813875, -0.009950910457068739, -0.07968082738931095, -0.32731232254756626, -0.47272604155163656, 0.24927308541615614, 0.2477383911819827, 0.28631189832056264, 0.4507420025519009, -0.2991318867639696, 0.15972819985898815, -0.08685033017753188, 0.16106226428896478, 0.23608887378364182, 0.3410452901940188, -0.17464328312056537, 0.8311980522565406, -0.3390711260516482, 0.3627001847882841, 0.28477166530166576, 0.23006196109747967, -0.4406809476032931, -0.21846161426334257, -0.4743160399342643, 0.21188349553985095, -0.1579131816168989, 0.31597552261246986, 0.042560814240492795, -0.3888223983030673, -0.9287670740306748, 0.08340739584133332, -0.14836732442021663, -0.5167571395544506, 0.6230100555278104, -0.21958056050556213, -0.5035696830176465, -0.51738295065925, 0.5280291490838096, 0.30104905019470257, -0.11044428670518079, -0.1237839900964689, -0.38160232338806993, -0.3427981664605763, 0.14090514596296477, -0.7870428951383005, 0.47319777439870864, 0.055733547894649495, -0.7945760615326565, -0.42209431634229944, 0.5714519488621048, -0.5983132998973548, -0.4703928890169454, -0.6681426005040408, 0.17085793438955463, 0.3528511270490334, -0.4231957444908949, 0.2507623822428134, -0.21486209060363742},
    {0.10350540489416948, -0.14247961201028958, -0.8197514719104516, 0.8338464727597551, 0.29631983728731165, -0.6081398110869906, 0.45802951407079867, 0.14093700931510186, 0.3912371679520592, -0.15113041206817307, 0.02220180636382093, 0.5744325452214227, 0.4867438800287523, 0.7342744013189528, 0.6020514260952936, -0.11396446999797959, 0.19388123999544904, 0.5627790525234257, 0.16095647749393877, 0.3758860677591329, -0.14587425753221903, -0.20012864495165997, -0.17470087888137584, 0.13419324406906977, 0.1343198955327705, -0.0780888350843097, 0.5890657443207954, -0.19754259532088778, -0.7889726666365744, 0.09341386903542916, 0.15333338183829126, 0.7389851914136872, 0.5112543571788387, 0.2578673785074591, -0.4241511276851831, -0.3377727949041005, -0.5699492539314578, 0.6344300657726206, -0.24734386628043273, 0.08069804410038645, 0.3908240072762453, -0.5018578859324933, -0.29829515792299766, -0.19029904163366357, 0.7971495358762831, -0.7600296268299552, 0.29294250810131933, 0.25131487669322694, 0.26499721812170757, 0.3780090404481397, -0.24118690015310032, 0.11681608274035717, 0.17267497943393145, -0.1863825996848063, 0.06721259499150785, 0.5178906046223138, -0.22261075249814938, 0.46354783958137313, 0.1092673722668272, -0.12727819030145207, -0.051908108756243104, 0.010547159329226855, -0.09951155173169363, 0.20114229316703375},
    {0.4277732460113631, 0.06820298765497074, -0.23676085114996515, 0.500394416417048, -0.1315650761119156, -0.6408528010177582, 0.565072895131978, -0.106442110647513, 0.07823221998222443, -0.5257759868626982, 0.5825162141817815, 0.7417608666537873, -0.1718850527189405, 0.6226855111988907, 0.6144362124466837, -0.4785504532757214, 0.07296701844110105, 0.7030801427997805, -0.12690800984631437, 0.38938664133576667, -0.030889055833591278, -1.0893115885357545, 0.14956644743589334, -0.19031256084291637, 0.27578649143994377, -0.01895901262438674, 0.35649346847010716, -0.3762247372278761, -0.7474355351170994, 0.12413533820411801, 0.2799252738120844, 0.16582810557709615, 0.35832359190309804, -0.20104742202440012, -0.3683421325181855, -0.25620414204433584, -1.4153283595639672, 0.26134127137123064, -0.8838741347843727, 0.3487885881971712, 0.32543947086374125, -0.08516469956467593, 0.5071155926719825, 0.2932515074370531, 0.13267179741029003, -0.36915726983630714, 0.17215527013409135, -0.8713207961950159, 0.63343033857876, 0.23817341830416616, -0.023015256682959846, -0.2556921658126399, 0.1373079520194111, -0.6909888007631882, 0.40230774591137375, 0.40994887401993435, 0.07347863789456895, -0.3820715281533613, -0.12483660801352045, 0.3202931345005712, -0.28414029386661954, 0.021804840492288206, 0.5469535295662943, 0.38913089718766214},
    {0.06823204669447133, -0.4903073284128567, -0.09620724941128281, 0.25172986797144753, -0.18126433719219096, -0.34636152021908695, 0.1946495933738797, 0.0770795428461073, -0.18830803424611733, -0.4033391912299086, -0.19031856170460024, 0.8441957647714018, 0.14829184988905153, 0.2504711566578198, -0.3741293756006193, -0.1500476193552154, -0.6057757852911928, 0.5321242961292533, 0.10583284904729887, 0.5908022368124283, 0.3685402417620199, 0.4898868400108946, 0.23421148257112914, -0.4776970820906624, 0.3660914816408087, -0.856699554425463, 0.42131028850921753, -0.8072959354204969, -0.6509762278556682, -0.8388549947054835, 0.3728376338551294, -0.15289990874773118, -0.16255350046843628, -0.4016150162396224, -0.00947054803490782, -0.41771031046231966, 0.44236016719139953, 0.9561499171186338, -0.1912749271596734, 0.11182174193134262, 0.14819856522803299, 0.1641003016996905, -0.15401359764818429, -0.3480762751248731, 0.22695005668595386, 0.13983359062581718, 0.17381769492680563, -0.07328496612306563, -0.4292617340405611, 0.28410932440845865, 0.01699234222280327, 0.09949444433488897, -0.2893164644533897, -0.24575802192749766, -0.17171297273173503, 1.0372656050616516, -0.1515045500475154, -0.45880246433177957, -0.682403569011684, -0.2996141516853482, 0.4017685788406621, -0.49400544103319954, -0.22166140503395443, -0.727228691840243},
    {-0.20477686676878953, -0.29057416009522746, -0.5263138620249872, -0.5321316427047269, -0.030672551154244304, 0.26942167107634063, -0.2818118714115933, 0.06804385167928449, 0.18867992708956882, 0.14127031683949798, -0.15828881379294163, 0.47764856933107835, -0.7833859831668294, 0.007109957172950679, -0.04110600298974564, -0.3277086773854721, 0.38640366684872135, 0.37710429509383875, -0.0321557165688434, 0.14226227069159683, -0.5042230503410826, 0.9855167667246444, -0.08042075164827305, -0.12585357372286207, 0.019028145063025564, -0.11707523444324137, 0.11582528933655933, -0.28318036145355413, -0.2013671516331404, 0.12708256611519284, -0.19542697803212608, 0.7662798529219138, 0.015136929299619475, -0.13511568349714664, -0.057933596837781876, -0.22063647711373943, -0.0104346819830861, 0.13542674637390842, 0.06550491011133008, -0.12759363661790626, 0.18944455972437363, 0.2658290154719626, -0.6246151452967916, -0.3495291361499761, -0.0009054261999305918, 0.2580116093844928, 0.4295739420168712, -0.8840185340798695, -0.345263721407746, 0.6210055490722047, 0.15387194162116852, -0.03137927621927437, -0.501925400349499, -0.5555896649062765, 0.3485995984012611, 0.10188294889474209, 0.14069216394712003, 0.14892922173190137, 0.37160856394129643, -0.14380569692207393, -0.6026639155058738, -0.6026940224137203, 0.2821634998197916, 0.07474947211122572},
    {0.050391197151864006, -0.381525243758663, 0.43620994184137346, 0.5405001066010474, -0.3869583051917573, 0.38539295744393953, -0.16608880104737392, -0.08860661631792832, -0.4679619973250011, -0.3010333313488901, -0.09814763772916583, 0.08130457195661288, 0.29917016666793295, -0.419870577286154, 0.11252065247415126, -0.5477014829544927, 0.0825436541073313, -0.1694071198072592, 0.24422691574825833, 0.07976299849188684, -0.06053554037715195, 0.11466458255663088, 0.20317203624620025, -0.348775903538274, 0.2289566843124256, -0.6430818221116827, 0.2719280844681968, -0.14781777875531044, 0.16702537165770215, 0.30863454895929965, -0.10261961361817717, 0.27584708956818604, -0.12245492936629676, -0.0009800671986225835, -0.6791065812987873, 0.29430847317166975, 0.34769766242967987, 0.34877476612469094, -0.22753984785124895, 0.6120510061972512, 0.36201900485518723, 0.23101918892733778, -0.28340452486571976, -0.3180273738689942, -0.006018633063759691, -0.10982975109980704, 0.31227404298560246, -0.3682923005015863, -0.48073923331180024, -0.1160325228627025, 0.12643597587960528, -0.30762951065141303, -0.08011539498423592, -0.09715951504020279, 0.0742062856251991, 0.1843630115640169, -0.183873494253357, -0.6076124546042551, 0.36645165390862394, 0.24502752410442868, -0.22118076689001046, -0.4570796156931821, 0.5490349591530351, 0.2464989420237469},
    {-0.03471579858776526, 0.10269072913131409, -0.29124926049355265, 0.2540791438285474, 0.07717109708496861, -0.6116214466051421, 0.8353741612240133, -0.27518102649401716, 0.2864347927307186, -0.37557028965065287, -0.20442564329542526, 0.20221856154034698, 0.26825792255552294, 1.0011389929248502, 0.049535043893785984, 0.21393985870481164, -0.08142080119575108, 0.3726994623598448, -0.16441972156028964, 0.05695980615274752, 0.16843268857194246, -0.03170766168845562, 1.0189930214870953, 0.4427995317842045, 0.23813257517166037, -0.17181513568286355, 0.17696754036432025, -0.3425508707295733, -0.09345424933781735, 0.23542072646597043, -0.35344816213767877, 0.1757229231260072, 0.6359406123375008, 0.2024562330433473, -0.2879586210719714, -0.42883413689401667, 0.28682486734564533, 0.5438909651498763, -0.4622887299568872, 0.18560670861579742, 0.6815372088415969, -0.174480634980907, 0.22614637960170092, 0.09718321614052267, -0.012511282108959321, 0.2506975296052145, 0.4668250319011873, -0.3058449056363508, -0.30943526471983906, 0.6197750396731437, 0.0014549750332102857, -0.37982878518929314, 0.3908466264729621, 0.019996075755144678, 0.014036308829271956, 0.2954639911473858, -0.2560129276847003, 0.02672803385319168, 0.18081748799199382, 0.14633792234283108, -0.18305849758656523, -0.1508976226097629, -0.09159192982589068, 0.2812139514411315},
    {-0.3794873435917192, -0.2385784923689525, -0.4771320855944838, -0.47250302252214793, -0.29966857539841796, -0.4468492547101079, 0.1763608629776204, -0.5903520122220928, 0.014219192436788876, -0.09471767629141058, 0.7080797393391493, -0.07824912238837128, -0.12551820607040276, -0.6733947110833238, 0.14083040302851108, -0.7348805910802123, -0.43897026742636375, 0.35522184271274243, -0.42160505546164373, 0.3446760265681384, -0.6189569380548907, 0.3964192029030995, -0.16066409841856025, 0.8189373711661821, 0.33090825488615794, -0.04024731770656028, 0.18672309121460434, -0.42559016968523933, -0.09987998460806004, 0.3315941751938477, -0.05231175418859086, -0.4357782057776134, 0.5118770662751333, 0.041845411536194546, -0.7299287804096487, -0.6418072626743831, -0.2043634395548895, -0.08362659452425827, 0.04526629274482585, 0.6219229974558169, -0.1313408809497959, -0.2923031064842865, -0.05406654067623145, -0.25874982638809985, 0.2569888230326892, 0.5052713844735538, -0.1702219756119581, 0.48090018822075054, -0.5445043467199981, 0.10174359540447893, 0.20177921757374442, -0.37660025778766193, -0.4770329177230282, -0.1890232723495486, 0.060689336742017506, -0.16542407694569222, 0.06654676557229483, 0.4770703784494397, 0.20158453758629988, -0.5650862868241322, -0.2588692131798594, -0.24314176461605, -0.23907409308830094, 0.1067309899795906},
    {0.17187177937346138, -0.20661448789699188, -0.277925369157925, -0.15581618854278015, 0.1994811260866738, -0.715491318628544, -0.15195885843016188, -0.12496190240450415, -0.34317982693588084, -0.3354425161833533, 0.3028753458868192, 0.6752639089142896, 0.7274316227596136, 0.1693781472039082, -0.1997350752771658, -0.05981359802389247, -0.18905449720536457, -0.09429258639909102, 0.01968573107899703, 0.8704384396133955, -0.7817922037852036, -0.08591321128210616, 0.28402402970224405, -0.17999783921657658, 0.17404504371686905, -0.033895073012925055, -0.24733442511721745, 0.11068870677849654, 0.088326744888116, 0.12799012216293446, -0.15098806392289915, 0.7374709974249968, 0.1840026285620869, 0.5876042612576527, 0.21381504715737268, -0.111335242329299, 0.17828359677622413, 0.3555549168199863, -0.11909382290314853, -0.3596783058406666, 0.456455890312864, 0.07128073845846028, -0.189815129515373, -0.513385334198754, 0.19325091906429345, -0.17066927041364474, -0.30155082635404556, -0.3131293300565579, -0.31876903425310243, -0.23986327907261018, -0.09614634295565704, 0.06755405859376928, -0.1602723537249438, -0.0378592192396607, 0.06432304760202864, 0.1257619559413638, 0.07956097902563351, 0.07846983487292238, 0.14656184423202384, 0.3064676564145496, 0.2835189655004483, 0.35913604179726216, 0.12487367401484518, 0.1728503802176662},
    {0.5187648636158696, -0.27805295537847735, -0.20489735999870895, -0.11976174778755477, -0.30409401230199834, 0.2253146061671787, 0.5041612605393574, -0.19303064732148792, 0.44383086808741995, -0.08589530779549355, -0.23681353371221545, 0.4666361577964904, 0.4959797352374413, 0.08963790791396341, -0.038926278799199056, -0.7483594661056597, -0.5218953392173777, 0.036882792446544015, 0.350526198620421, 0.5562171526102424, 0.10031182021064013, 0.014491083747121583, -0.1130545133291492, -0.6825487499048836, 0.500040710782657, -0.48965818007674133, -0.033699989829718335, -0.05020911920153831, -0.43542792838192323, 0.7181704665903553, 0.23670688819388633, 0.4982842952682646, 0.1433869633334098, 0.4828062641826054, 0.1378367676553977, 0.20752973297655175, -0.1595469430495075, 0.4029974975596667, -0.09836382015057826, 0.28561086490804194, 0.0435907819563986, -0.595903570048225, -0.5267164954508498, 0.20679583378128077, 0.425494871632152, 0.0945467394704166, 0.334067008507574, 0.08867495208927874, -0.27781642170659904, 0.2766909821829975, -0.25960594184998964, -0.04323065119254433, 0.06847099035878042, -0.00848410421208389, 0.3348390552777889, 0.8953243029324766, 0.15405219638922912, -0.4070376367238545, -0.20095710600896566, 0.2679086405693206, -0.14306777281925748, 0.4472376443806963, 0.35628608074652757, 0.628068361367674},
    {0.33794848118466025, -0.5550550335954544, -0.11865168212388119, -0.2762796519627276, -1.0188933310123796, 0.47724749280899575, 0.011990498148817787, -0.7075588479459801, 0.6371846250564837, -0.4209776980486351, -0.08890590776649107, 0.40178220520383595, 0.13175099806380025, -0.0977640327470522, 0.04088622136527319, -0.3142123566900844, -0.6965435184549159, 0.5922309031717203, -0.4378882158062545, 0.1216970094083663, -0.09751885548011056, 0.2581044824542559, -0.4135074933281819, -0.4184918554736727, 0.855972768002218, 0.17672639302442356, 0.22312479851950093, -0.05026663062425011, -0.6006414630549269, -0.031223132685984745, -0.033841286827201986, 0.06445863769526518, -0.40652519118298586, 0.8708314586127505, -0.14105766425249644, -0.09031868820107092, -0.005935795583337021, 0.47496463946740675, -0.20350063447132624, 0.3828734931543759, 0.4019264770241264, -0.8382650773252599, 0.09143588487508814, 0.09791383925267685, -0.27960407772965945, 0.11282330424147526, 0.20191951501648675, -0.1689598613786388, 0.037223988880655846, -0.3619508464511293, -0.8367541445026391, -0.25194298792399566, -0.16207895196434371, -0.6195989464297295, 0.0920757927325556, 0.4478118254426192, 0.03174032273700821, -0.029220621937128266, -0.0626384749280751, 0.028550048170981227, 0.06437886144249362, 0.34468781842614726, -0.030326872787643105, -0.0387012980223418},
    {0.3479486866762445, -0.6721954871443369, -0.3077138269585275, -0.5833825746721073, -0.27696094359208884, -0.6255434979926757, -0.3696089356644872, -0.37247863049100405, -0.16257397023275638, -0.5351141389547606, -0.2614521738935663, 0.3745667840842126, -0.04459512425767571, 0.27170578662398126, -0.19136611610028986, -0.3833553781911257, -0.4179961836066751, 0.1946225914645868, -0.5550870892013414, -0.1843111702647674, -0.656418942733376, 0.21392733672319922, -0.7945135486362848, -0.6342286491636796, 0.25175566071395716, -0.614999616960919, -0.20349932769754522, -0.22984173056896295, -0.08891884877694575, 0.40303486113810383, 0.4199832150570353, 0.3381064595430627, -0.2713521702311622, -0.5307301154397407, 0.22418661550046515, -0.30760693504836584, -0.48943911060908485, -0.4832584642561136, -0.38391655727742957, 0.26019103367362617, 0.21260747686096676, -0.28201449688588537, -0.1254117479383679, -0.5228308152899753, -0.3491590448995481, -0.04464116587897609, 0.5206431626900986, -0.2965302734919438, -0.3127464369588693, 0.31338883477922397, -0.02867841052667034, 0.4299160412252969, 0.13331107641445095, -0.4618405256470891, -0.3790620604003941, 0.3982291376320494, 0.07319850986130029, -0.3812073191957547, -0.32301118602095164, -0.04958116411753009, -0.6355951038075145, 0.09521178455482708, 0.7288052873867903, -0.3472004226673291},
    {-0.4826584963731923, 0.07359559473294872, 0.09208836730036579, 0.30017133162006693, -0.4503132614069866, 0.3121284469126777, -0.6952095742013373, -0.03558412930837089, 0.16902044367990463, 0.017247581398407392, 0.19144852161063566, 0.13978839036327104, 0.1583166093586252, 0.16727451751460456, 0.21073562922832134, -0.1979695551546598, -0.48338584258810596, 0.24700508105970082, -0.4039930752196129, 0.2633743213622601, -0.0797423295417189, 0.07377945158056327, -0.049358315442575976, -0.16190547744117748, 0.03138267252701207, 0.008589949873110998, 0.1848285360282101, -0.2750959353951151, -0.2534845853012135, -0.2467889384775608, 0.2843461868728134, -0.01720832812820056, 0.2240394031224141, -0.051464285233192866, -0.24348570130205088, 0.4119941535577241, 0.17404826626423384, 0.49080219445745465, -0.09549495942120473, 0.08154321528747355, 0.3142311364670873, -0.4619007211571372, 0.5770699067003905, -0.7431210492937234, -0.4957624367913769, 0.003581775492908994, 0.2576578169323767, -0.12681778642555974, 0.07510739784400436, -0.040078895297002794, -0.06363801121875967, 0.1521364277247417, -0.4990717233346012, 0.0038985073877458756, -0.0426482498054132, -0.1064684843130145, 0.32991800005818245, -0.006122932569319773, -0.3055872790282771, -0.3446875437654483, -0.4619905190329552, -0.24770474463375847, -0.5421375620281881, -0.3702185458166486},
    {-0.34973351749962023, 0.18454159759771643, 0.3816000933248538, 0.1329172000768443, -0.8326329950131962, 0.28634110842879645, 0.2872844309637864, -0.15643775680713579, -0.12255565024613875, 0.3856159691698538, -0.24296118510034062, 0.15503190236126543, -0.9724146442445787, -0.14459176993152031, -0.5911466950022892, -0.31087313088805085, -0.4024554596172806, -0.27400723879850725, -0.5200595197674716, -0.030467976413499763, 0.26398160159879724, 0.16102060631273787, -0.5553831533241472, -0.35811262062584803, -0.023340461048391783, 0.016047104520807348, -0.4578684454657242, 0.1305522361768827, -0.008193205004842266, -0.17393192628711537, 0.21389350630700543, -0.001615108020634121, -0.28723993013379995, -0.30692038641393593, -0.29069258283895727, -0.14379830891136983, -0.5748652476839404, 0.6209084269586298, -0.27042297729782394, -0.29163641919260674, -0.4164175356210013, 0.01748721966717989, 0.37843285014952815, -0.49674946796053676, -0.4304758977326059, -0.04519685087623772, 0.7405229777726893, -0.07966955594560837, 0.015435736536307913, 0.2333989806403685, 0.5112721174155334, -0.12393504137632609, 0.09202465311759485, -0.16672612485885735, -0.24829219382132334, 0.1732213562883717, -0.59642290716366, -0.2843584858836993, -0.6904979436615352, 0.37182276636540523, 0.4990058165792686, 0.11627929374792197, -0.1403372312518268, 0.5687563303966464},
    {0.06634938224708051, 0.811403996319678, 0.23344597061201458, -0.25771823923648707, -0.4939811091975083, 0.1972347675404413, -0.23344644867913283, -0.4513518208135869, 0.03438077078167191, -0.26157503634646206, 0.7375628040460599, -0.20760785971754955, -0.4725325647280696, -0.05208247067931893, -0.24938391038918675, 0.025542017276243258, 0.20772700902333574, 0.3422892863326655, -0.2929041838165498, 0.17581835733873594, 0.21892076262682775, -0.07517466903929806, -0.04693730765413377, -0.5013421608325807, -0.24027948667370008, -0.03673564206817642, 0.2531681851157981, 0.010042728614432124, -0.23647196302135487, -0.2782890631969724, -0.2441154565490217, 0.1889892086302451, -0.27461812373981825, 0.3702090209742936, 0.1038945126863858, 0.1856557249357887, -0.6089908389830222, 0.21479454285405833, -0.005753357933191945, -0.029398818627919345, 0.007356985114801724, -0.04224266390967111, 0.5367689634668241, 0.23755251864934473, -0.7773565521340218, -0.12990196646649219, -0.019815951106428815, -0.06117679216040517, 0.4335258391275042, -0.40345959938688086, -0.07770105920367537, 0.03713773352567926, -0.10438882818859961, -0.33959654771640924, -0.6933100498752938, -0.015208150032102503, -0.06963630521984877, -0.5140358301010272, 0.20150462663261567, -0.04223816083276584, 0.25040280655911573, -0.045424494381015035, -0.05823261649850412, 0.41607897289525736},
    {-0.20434278218204566, 0.6786847356314997, 0.6841819592937098, 0.1126210657348863, 0.04526403825889415, 0.7302039370957646, -0.21654368698657392, -0.22764315424560824, -0.4739658826403664, 0.04305132205594139, -0.18421017532896175, 0.2740959096216874, 0.5932644846685066, 0.4261150940036197, -0.1545527533131475, 0.36770071176567376, 0.12960593424346428, -0.016130783099591876, 0.6613293142440188, 0.06562482265513439, 0.2358612896921516, -0.43832677236512846, 0.2691759025067072, -0.5400442596993, 0.31999822857672416, 0.051363994926092144, -0.06472458730279412, -0.3224956482204435, 0.09020098237728316, -0.23940912906369155, 0.34407605491641857, 0.4236748522167438, -0.34481938988743926, 0.17348560138561342, 0.5036984536509955, 0.4570246962664314, 0.4500290625641953, 0.33605529989525673, -0.04180514012874384, 0.5197616238078945, 0.1997341682206784, -0.0797407017409632, 1.2440155231748902, -0.05543604433112772, -0.14340583428239473, 0.8312208906482252, 0.938398715235065, -0.03852312987573936, -0.2279225283022744, -0.2950965715743637, 0.39985601941209337, 0.45377610785949213, -0.4724396215243934, -0.34287275222249886, 0.6705273099566329, 0.5285544386827893, 0.2114783748814473, -0.9052415136541463, -0.3178314686394265, 0.4212031569461192, -0.3717389725728376, -0.32311686435849, 0.3479755402800747, 0.32825178691761364},
    {0.1457566206310396, -0.22041751794532674, 0.006647347155490515, 0.07974695798816027, -0.46534878502887095, -0.28622103167011714, -0.17554489576666008, -0.4012324097109866, 0.50695189074541, 0.03414914050890352, -0.2857415769842043, 0.5021190466130667, 0.10508251679644857, 0.20068894880732904, 0.4380822894973916, 0.15060611791972756, -0.4624524171575464, 0.3802057999197874, -0.2802345150141597, 0.6353851714594926, 0.2023202910368898, -0.3784657456522555, 0.13821590128891434, 0.262359768385143, 0.7218175085263002, -0.2137201385731291, 0.42289278181746187, -0.10421949727842865, -0.0965761551842985, 0.09666876516599124, -0.19448860348101005, 0.4054821457360847, -0.08084342769626938, 0.19450977022655716, 0.3176056535916091, -0.22300826272435265, -0.15009012549769962, 0.043480135820633495, -0.23992007823699876, -0.34846460899979403, 0.5725575031962081, -0.10504207280979695, 0.335061035898063, -0.7112870172360766, 0.34923336452342196, -0.10749707255857681, 0.6934987170121203, 0.3218894269227743, 0.3183570501756001, -0.322051402585856, 0.04630239729580835, 0.3437972204361838, 0.02350002117018787, -0.20357587953571335, 0.48855057432500576, 0.34380231755357904, 0.24890459935486234, 0.49609702595459426, 0.3758855504253311, 0.13694614258230917, -0.2771820614940544, 0.06894828465796476, 0.36917137450716353, 0.35622846758326887},
    {0.43537699129774154, 0.47202738654559784, -0.37902596234191505, 0.16273855517409935, 0.4832443206281974, 0.32146742771843195, 0.2685555608401346, 0.6052366135984001, -0.3356054623227193, -0.2713913767810493, 0.34498142659327263, 0.03069549862263661, -0.5222248029354278, 0.0226213839466202, 0.45329740920164746, -0.22565545761136965, -0.35710993060546115, -0.13879094925082602, -0.09177063675370485, 0.49601281479817844, -0.028538239748697274, 0.048580573452161234, -0.35704347278816695, -0.24102575432064272, 0.1708233800343538, -0.37541144459711806, -0.48586235208381884, 0.21028592084242995, -0.5851869779035761, -0.3244735414233579, -0.6591703259710185, 0.07373828184314983, -0.16323217312389016, 0.15221028859622612, -0.2003110470206965, 0.18044245849506063, 0.2103948597042976, -0.1087120343022587, -0.16753088475111036, -0.40190631660734893, 0.43999461246975496, -0.8822614434368062, -0.19348558320616, 0.02850120162408025, 0.5940497046186272, 0.2755316392607719, 0.43369405266811906, -0.33999090670857457, 0.09281508300104133, -0.2590656353217475, 0.03415050364014364, -0.01373198638198718, -0.18999880740120534, 0.034226191598876125, -0.13352937546219573, 0.09017190363873494, -0.16391840798673157, 0.4217407464557464, -0.38492990361159035, -0.5043202736265742, 0.04575290308823545, -0.013606207796220775, -0.18284544504831568, -0.12592291421197438},
    {0.15980423576519817, -0.5862752150667844, -0.47935395704895456, 0.28036854080379836, -0.06280914344475275, -0.2440323569053582, -0.06954205604944175, -0.15455859875622216, 0.4785031520053637, 0.07633877049280893, -0.37879550454017485, 0.6355275891510366, -0.623269417314871, -0.3398968522953506, 0.16282153187134177, -0.2557810780720994, 0.45800074932754486, -0.5426074047770958, 0.13207890101202535, 0.5624696281239715, -0.2852605251382544, -0.43585587099997086, -0.3464136504434601, -0.7859296288435516, 0.11703732888461607, 0.39632871633545824, 0.19433912074889592, 0.4241592492911021, -0.42640438605804215, 0.1454341297270537, 0.18388009701452496, -0.6295102954737273, -0.26928593787044874, 0.4586651454308768, 0.02973035998170632, -0.4119596645526327, -0.3362725735770092, -0.18326123189582705, -0.5493305690653868, 0.07468028200487556, -0.3875337637857753, -0.5550590268133122, 0.012542697387111461, 0.2189367853699167, 0.03323765635991544, 0.33249534882994497, 0.4363023726653753, 0.03613108320499435, -0.00862943045707784, 0.0889485457780958, 0.147523677966667, -0.35289296212441973, -0.20887351685425387, -0.37599601991834075, -0.5114109850665303, 0.45780000331625326, 0.42226034541813756, 0.1819250934312487, -0.5850865644343543, 0.139518059720426, 0.23449076392615284, 0.6024911659700933, 0.4687960839081543, 0.8472954612451845},
    {0.6697886982661005, -0.4019203681629926, -0.264173359677262, 0.6018889037395291, 0.6274485894167386, -0.10723862007352815, -0.20686338132473286, -0.3250405334302088, -0.41319770573950143, -0.007700101379973468, -0.6025230429995054, -0.12394813444272562, 0.21500444548079675, 0.9654454556187994, 0.26600449961918204, 0.2056514079833909, -0.45487905443864196, -0.20576648699759542, 0.45429210656025437, -0.2172795999667099, 0.11060657867720514, 0.10466998608775922, 0.22603944029935424, 0.40638434824113817, 0.5565895131035345, 0.21637076060350233, 0.055864882919296234, -0.035696497956973376, 0.3425831383486156, 0.5177954516408035, 0.12885230955588403, -0.10346322385092638, -0.31216702672546065, 0.6035663674775971, -0.4498030815821524, -0.04443388873070661, -0.18320289040274645, 0.31868403216844043, 0.11458677342603975, 0.9297237372733346, 0.09613818747450868, -0.05746503239153664, 0.22766132578510115, -0.02938018853345247, 0.11786653139555198, -0.685006994974333, 0.6457365709772879, -0.058592896580509, -0.09003180815092629, -0.06821596200368134, -0.367459852324942, -0.6588013573876031, -0.04833961393238671, 0.13215434051830993, 0.38019942945549584, 0.07012114434426403, 0.8029885823405857, 0.3229261565205441, -0.22770117037891444, 0.35413173047686186, 0.07698910472339893, -0.15207423854901939, 0.4941025281315532, 0.5000710079380742},
    {0.24201760789231339, 0.26510509292595913, -0.45722236495846164, 0.4723297940261939, -0.08834295289846425, -0.4712106809169815, 0.11286399144315205, -0.5406197196767016, -0.3472199228150643, -0.34146987512896176, 0.17345363604491382, 0.13166415579132731, -0.17266284791756953, 0.4746501861852003, -0.17941991870007498, -0.4659042122362437, 0.16342210433720725, 0.30233947586603455, -0.28263357693025054, 0.7742137411419877, -0.5121361225926748, 0.09997047271245987, -0.03592021675434238, -0.9093736634562685, 0.4405657324267897, -0.1945499954368996, 0.38166613989117987, -0.7074791071170458, 0.6115335417822089, 0.6854252469386672, -0.7576533343102536, 0.036394421243426116, 0.03698098420244714, -0.18906196671839107, -0.1859135014094582, -0.5949637291941147, -0.6375285497770049, 0.5831190929348105, -0.4087664083683028, 0.3947703537976121, 0.6355564483817697, -0.026145955965890203, -0.8427690165059551, 0.060327340178958334, 0.18676645822256244, -0.31686501718068283, -0.09696914280968331, -0.24114685028944433, 0.12741428798043067, 0.10480503480346541, -0.542778630093601, -0.7443664764722232, 0.022781736332750088, -0.04332665286131522, 0.0581208715222224, 0.4255166240123394, -0.11355673856911519, -0.5781722653152939, 0.3463504433012331, 0.0998476412986157, 0.48876202599214846, 0.023632045171437705, 0.08951066755678182, -0.6247498606382829},
    {0.4441281708453464, -0.4260477824462548, -0.5656897679779437, 0.21033332077868877, 0.45619885533001187, 0.25347699359095544, 0.11644420494812192, -0.05992778350652943, -0.12212256255081487, 0.018916226027840943, 0.32866276202059036, 0.23917973214295207, -0.345618437639397, 0.549436844538572, 0.3369020806366413, -0.10375973018727114, -0.20984213309023844, 0.21031180019221196, 0.030516532297481483, -0.0454662221153547, -0.10276943462797032, 0.6543258078447107, -0.04190955815112137, -0.4873029633374417, 0.34812578443152936, -0.1101320245833917, -0.21744731410087909, 0.499919498762811, -0.0704071378289182, 0.34595598475643374, 0.35681955015182776, 0.9704858151095338, 0.28240437123166195, 0.16284141122541418, -0.5380843301587558, -0.3837198351293009, -0.3026665723655442, -0.12934581359919456, -0.17363049850743004, 0.19566467929178036, 0.13272310920942457, -0.17478086096139428, -0.5892405417368674, 0.1974095481365032, 0.20300254465575432, -0.18375826513855992, 0.03150709109964006, -0.2042622543705926, -0.38809907417710504, 0.03425714968825866, -0.7873396792429422, -0.6070008808698458, -0.03547436054569133, -0.19891756654026607, 0.3183855381255051, 0.736418548932008, 0.4625995451235501, 0.2261481072726857, -0.3753967015437828, 0.34739999670503136, 0.05966010897537952, 0.7764957384638882, -0.2204149762328173, 0.34909690005439026},
    {0.4272842166854312, 0.48365944289450225, -0.005475668265162545, 0.16058604906642532, 0.7060805917120884, -0.2431198529048977, 0.35611721660909035, -0.7090316066407776, -0.34813135132621376, -0.48223627854594037, 0.11917173735576658, 0.8088855020936672, -0.2403922074538246, 0.6988707920313906, -0.1311370325421903, 0.1210952308326758, 0.3960115517317359, 0.3293050359331025, -0.7545736943939839, -0.24372544457549716, -0.46907208265209227, -0.08305755843093457, -0.13757158467975147, -0.4608556100884132, 0.5689267707764913, 0.4603530130089753, -0.035836675367063454, 0.4034821580929194, -0.4387560313374894, 0.44340236614709094, -0.17037464940746153, -0.13038297561428952, -0.09976894908345423, -0.168898315193336, 0.029970234809803008, -0.461079784638742, -0.6973509772340064, 0.12587925755157492, -0.05269458110201395, 0.7926449607301148, 0.5709597720499395, 0.06766465597949672, -0.20480827873392207, -0.29621495349346055, -0.4088393466676099, -0.22893855172526006, 0.4521271852901653, 0.035672792675141625, -0.4972556614258521, 0.5472497653219343, -0.30364802420682674, -0.690599570207195, 0.3036854375268962, 0.08437430041849464, 0.14133771963227237, 0.4367059750498404, 0.43257808821247395, -0.23679541512413685, -0.28787982247769656, 0.12411377842141552, -0.1330053678036512, 0.22248992641661983, 0.5221825526579351, 0.36596071470358976},
    {0.5477929527534361, -0.0954757823347977, -0.37065263537018645, 0.10327243762615977, 0.3274167395943198, -0.12815476145357516, -0.04675942631195368, -0.08323486796155512, 0.383219930022234, 0.10645159209772224, -0.36683562144333015, -0.27930683109391, 0.13087985708187275, 0.5674388825508593, 0.5360629158338619, 0.3539578955231636, -0.3950581510657909, -0.592186808705407, -0.4118528259672572, 0.011309718232062747, -0.047104437760334156, -0.9328074425532167, 0.2348271198768634, -0.0016448486758938472, -0.014425340954371505, 0.3402225641894911, 0.2693633236420866, 0.03889835163519126, -0.6155004396355733, -0.004167749820501921, 0.4453685701979618, 0.5412774558482746, 0.8173899207867041, 0.6284169058227, 0.12879380144835081, -0.07895653234174145, -0.3651489667811106, -0.4444908269940845, 0.029026690071664234, -0.012134043125907074, 0.24361702223718218, -0.19114165083128376, 0.31167155485415227, 0.6838311053730673, 0.42930409431589683, -0.43410725814920076, 0.6108410915921867, -0.09702178303036749, -0.7216513963242113, 0.21703446300916654, 0.26065125337156775, -0.7870012680236355, 0.48785653398616524, -0.03738275277580196, -0.4216044126137665, -0.0792089104809993, -0.18009332606752496, 0.13088075882227154, -0.5000567969814622, 0.32476112627684556, 0.31984689546885053, -0.17241171879213749, -0.005895518160241423, -0.14993751883824333}
};

static const float b1[64] = {1.299535597719748, 1.2721805636602173, 1.3552590222582976, 1.3065164477025688, 1.3083938675654736, 1.380041328486888, 1.3207242298773176, 1.2782339626613077, 1.2779677706111285, 1.331220368155409, 1.3534285536685362, 1.3452957636862546, 1.2805596036906106, 1.2735224605044477, 0.9355561727013386, 1.3853622506147796, 1.2526928370509127, 1.4426690033727976, 1.232845439614139, 1.3398552578226721, 1.3910492527440328, 1.1765553511721927, 1.347869413028862, 1.3657897262716667, 1.291288427848362, 1.3280147765596144, 1.19173661758496, 1.1244859197291366, 1.3612577194514561, 1.2974838049571658, 1.0515743842339613, 1.4008793052147757, 1.2583860395021136, 1.2930444571410251, 1.298979676360316, 1.2897120843982521, 1.4034238140898359, 1.2555278254058313, 1.3932295851091785, 1.3722421151277813, 1.3372557834716499, 1.405830472022307, 1.372310985468558, 1.315811657771831, 1.2900714934354398, 1.365374682429473, 1.3508792886468302, 1.2641903005793615, 1.1373647416601262, 1.216596085652108, 1.2733149561479593, 1.2835551637551226, 1.2549519813514183, 1.3174653208908782, 1.3598426736539666, 1.3090332190525782, 1.1993281210749198, 1.3689906455320455, 1.2874125378927295, 1.2111503616484214, 1.3816634979128097, 1.3262303767110035, 1.2255331581125084, 1.2000508819940883};

static const float w2[64][32] = {
    {1.351200200812798, 1.1951749317108098, 1.406507170168435, 1.1796452051374755, 1.3726497179864388, -0.2968480640929868, -0.32781805126401575, 1.0908041614265338, 1.0802896360741463, 0.8044392469412514, 1.0209015952230862, 1.1494304130478816, 1.2971503593017413, -0.28253327320138627, 1.1073890651788187, 0.05283715706128746, 1.0762299487899598, 1.317338642613886, -0.1488641232445554, 1.13584113256503, -0.2761772217966888, 0.9721943570021565, 0.6944351414461024, -0.1053709802789462, 0.9715894054095197, 0.944209214728887, 0.7691290297163078, 0.9934422571779314, 0.5687214128581896, 1.015115948741839, -0.14307425335154494, 1.0687904227683969},
    {0.925542151895284, 1.1953890130163827, 1.0676494718100304, 1.0470181686423428, 1.1915174882994934, -0.0853187969355692, -0.10301705178397012, 1.201032902644003, 1.2622170017405037, 0.9871768675931589, 1.1447481265851638, 1.2871558430918784, 1.100138483980195, -0.011706181981305987, 1.067341721074334, -0.052081080461686406, 0.9901635861267163, 1.161250828008101, -0.12368075182841101, 1.0892975964188898, -0.10865945111648251, 1.1700052694878276, 0.5570739611875445, -0.02668891184492527, 0.8186233059598227, 1.2131936180359053, 0.5688747451170171, 1.0583451421365315, 0.910556226917376, 1.0866385384093542, 0.0067235565556175575, 1.018853069741125},
    {1.0436379504047475, 0.9970777063455503, 1.4407466874914845, 1.0702874125093016, 1.2266158497018274, -0.2760430040491553, 0.13577758021005978, 1.2476716735388826, 1.020514451158059, 0.8686954786890859, 1.1091906908612383, 1.362487612852667, 1.4148219125583272, -0.414658061342713, 1.1004055704578855, 0.09104148284537981, 1.2607279252560624, 1.200942751167931, -0.3818925311040474, 1.470866278877339, 0.11910999384983018, 1.12098448767172, 0.7294871681262508, 0.1745559754347261, 1.1757491491147303, 1.3478730210103047, 0.8017664567853023, 1.0503184215779386, 0.6332479939379022, 1.246386687052034, 0.03433899552901104, 1.277482666517944},
    {1.1828493625973764, 1.048093092998897, 1.1221851216358474, 1.174965147251669, 1.5148535738036573, -0.19571956394171414, -0.14886529967877452, 1.0689272002240262, 1.5474769159773005, 0.7622901436155364, 1.0197561103989712, 1.1804370003339413, 1.048336380956057, -0.11630198174671723, 1.2606445150094718, -0.06330915588838092, 1.0591431993876403, 0.8981343667180873, -0.22566797763357785, 0.992724577467883, 0.05674287113919914, 1.20384160769933, 0.43932995034773403, -0.2217382277222753, 1.0753782814192852, 0.9029550969984493, 0.6933062258923708, 1.0731767170128528, 0.4267885457749036, 1.0775138943298164, -0.22160439989904723, 1.181515258063186},
    {0.9099636885220269, 0.9866158983633564, 1.1535479911442674, 1.095084572924436, 1.2748623312824037, -0.04279891841353932, -0.3184733117293104, 0.7411046274510876, 1.5024251138675646, 0.9735667092106678, 1.1810984190193083, 1.1987782731243235, 1.3174723151839727, 0.15405772836673434, 1.2389489732930712, 0.019690228382952518, 1.419671069953821, 1.2799458427394221, 0.28478019813692523, 1.434218473333335, -0.14164371544745655, 0.8835108290142942, 0.3799181196538269, 0.08136025372723694, 1.285950569201692, 1.0159348977880973, 0.6587784845406218, 0.9684289797790356, 0.609874800288706, 0.9504254052370965, -0.10399003423184543, 1.1363155019056097},
    {1.1198095228412746, 1.092482268412846, 1.5008335078374075, 1.1767080553065967, 1.0945698444773175, 0.006538885373865931, 0.053457143954770935, 0.9465650713555372, 1.4391458134192439, 1.234372191634189, 1.1922469984773485, 1.290197763395744, 1.1674656915303476, 0.2273121784378574, 1.2893585025566152, -0.16171130739580797, 1.1106635218525724, 1.0307782758054647, -0.023595730939060453, 1.2274746332091144, -0.023593929956317934, 1.3922605711737952, 0.3782992097780451, 0.02461518892187155, 1.1052820617586723, 1.3374441851305128, 0.700639674197664, 1.4628011254366962, 0.5879663981160466, 1.159954133571011, -0.1968735155914741, 1.1512431105039618},
    {0.5357473079866185, 0.8520203849410702, 1.139550104551378, 1.2620796021602638, 0.9494516248842062, -0.131313316582118, -0.11800931559752355, 1.1219368765793827, 0.9889975662404599, 0.832145837191491, 1.0358531226437544, 1.206037166760251, 1.0507984266992174, -0.2271689743558547, 1.2504832349658135, -0.14289724978016655, 1.2188637091212355, 1.0766987658046345, -0.020329846465779886, 1.0144417802991847, -0.1808594302803118, 1.0994424655928703, 0.31558471832741697, -0.27180566268415446, 1.244292715481273, 1.047962115500711, 0.974424837127306, 1.3468866631505396, 0.3652118751379778, 1.145104890551762, -0.10264451032483099, 1.089779301874157},
    {1.1649300327899492, 1.5048101804722989, 1.0382278264223, 1.3407649387155782, 1.1475632167629446, -0.216824275604474, -0.02156205860160978, 1.0415312676849664, 1.3650392166210772, 0.9617874175369348, 1.165701999281844, 1.0587371874861897, 1.0744022570944656, -0.035528308466375044, 1.4545484469156795, -0.15342275363703142, 1.2489427307158847, 1.1422040165775382, 0.10651045806084816, 1.096826463722573, -0.11705823546167869, 0.817122171248527, 0.6461092882382218, -0.05006635311310436, 1.2297883661994171, 1.407647662895263, 0.9093071956892615, 1.3697937285990731, 0.5975355909100893, 1.1510911943796436, -0.04558511841918227, 1.3301864436839337},
    {1.1670131603787441, 1.4037034419198178, 1.0744800687271154, 1.375917129924905, 1.2243129626162252, -0.1169621634637054, -0.11104449300927499, 0.8942493209008522, 1.1566066140234694, 0.6491806384752993, 0.9673857847478249, 1.340433062433961, 0.8765434514857018, 0.22195454436306367, 0.9547932487949259, -0.1957033811283801, 1.0311234920529218, 0.9397107352827779, -0.10931807699066373, 1.0858782242790748, 0.22026067201441435, 0.7703139204404258, 0.3488216721279799, 0.13396194839368675, 1.156984511955655, 1.108556969259806, 0.6086601880082192, 1.0704531779059991, 0.46636985493547956, 0.9385680296986543, 0.0010489422952655767, 1.2125803884324062},
    {1.0735526563258422, 1.4533915371595503, 1.0272063065354997, 1.201322172205892, 0.9950771857853461, -0.2161515578208337, 0.11763017869652138, 1.050199839655918, 1.1844495651442457, 1.2322790965077062, 1.033383658225206, 1.5334989590560681, 1.137445586975001, -0.10472037027767271, 0.9789477420895697, 0.09095454137019955, 1.0571708754243445, 1.102334314687285, -0.4049813592493397, 1.229069907522185, -0.15435076812420198, 1.212169476347059, 0.4026814962134607, -0.163680580931661, 0.7925145208261293, 1.153136497754638, 1.2042094471010827, 1.4781763584021737, 0.5478738676832425, 0.7171259826750668, 0.2644123191164257, 1.4300253116537471},
    {0.8439396376349038, 1.2926340907681941, 1.4169559616997025, 1.2792264250656562, 1.0556678589267692, -0.23576762369417137, -0.015663851752869537, 1.2017142347821512, 0.8933382629019937, 1.0805169357009827, 1.2590110919202107, 1.2368215637048066, 1.4610343273846078, -0.17502641437843444, 1.2086886346895445, -0.15080745060438447, 0.9878871374821742, 0.9025135383017303, -0.06893869020114093, 1.2324045864365418, 0.01706023274489518, 1.0346554124367529, 0.5839359474618624, 0.2516015039610061, 0.978274499219464, 1.3814919225328912, 0.7963833628212104, 1.121434963864002, 0.7778371623722196, 1.3022706997434037, 0.05100629203434709, 1.1072318917961232},
    {1.0044201528293157, 1.508985378249243, 1.0170031912112156, 1.1119247735485998, 0.9076628643708592, -0.5253563399785266, -0.09848047695049332, 1.150011213220612, 1.0946405596176967, 1.111541873320471, 1.3164018633844392, 1.4960340866126287, 1.1749702465965646, -0.3066518535398227, 1.1824133166978816, -0.24199026142366198, 1.1969716708824643, 1.2402982843106913, -0.2893030185382014, 1.1703090383512715, -0.01781458510509565, 1.2173961736484018, 0.28349537713944495, 0.031925560960602235, 1.2603913073570263, 1.2803056621959608, 0.9998141109228674, 1.0849310535130066, 0.5701029439890981, 1.0559977437476773, -0.4335825150455026, 1.371081905221835},
    {0.8358647746769365, 1.0992602192676322, 1.5289426298007678, 1.1174612308378267, 1.1409015977581691, -0.3153059081307833, 0.03236451078299008, 1.0296613783272657, 1.31060674686222, 0.8681232648305656, 0.695527901034903, 1.102248738993995, 1.2114476405650745, -0.05926422398641728, 1.2516989621149306, 0.2207147908299526, 1.1676724918719406, 1.379194982893702, 0.046484676690526215, 1.123547798195971, 0.05182609579790165, 1.0478763133221587, 0.67779507825559, 0.14977642750719802, 1.2995596764242692, 1.0552737419683365, 1.1178735332491305, 1.335628879031144, 0.7140013537613484, 1.0295815143567293, -0.1431736336190346, 1.1536189734058142},
    {1.4447529522243787, 0.9949782674725599, 1.0411203555491453, 1.3967933067705038, 1.1205734333588466, -0.02238215546537191, 0.016361518511474788, 0.861388296299565, 1.4071946601370973, 0.6508387198274275, 1.135343420883001, 1.2194476793468387, 1.1854581695989481, -0.059134349025036545, 0.9828801090999476, -0.11961891954155732, 1.3131270700521274, 1.052480545878405, -0.027990136243579437, 1.1383715347530556, 0.03495445979188477, 0.9904719057610308, 0.4631915420126905, -0.05926780841417072, 1.0500636959175238, 1.14988119399181, 0.7362093878676182, 1.2307528475170522, 0.33487651865119156, 1.1092858529707756, 0.2230819652415256, 1.0077046480690979},
    {1.0574390873490271, 1.1714261503311478, 1.0984068293920282, 1.0290622419436932, 0.9182908280134445, -0.049227646016612406, -0.1848475753186149, 1.1409250874307844, 1.1550517188525184, 0.9680824866077875, 1.2844459099688836, 0.987207518920784, 1.3678286880843422, 0.08382680686368411, 0.853462614880893, -0.09842097107708624, 0.6829080259898994, 1.208302857524372, 0.26505723323793196, 1.066070268360205, -0.12278101111103394, 1.1154109842422977, 0.4946534209294323, -0.21450181625215764, 0.9907169909275969, 1.042280999447933, 0.7992573047124893, 0.9854090018497745, 0.7656827063444379, 1.1734682297000953, -0.3323991090234899, 1.2037465228068642},
    {1.0091245634576256, 0.8084101816118359, 1.0066024033704168, 1.2546813722522467, 1.5295264100759243, -0.4312139260618941, -0.16925390391537234, 1.0367920859124982, 1.4975221304399164, 0.9855032420227229, 1.150131132701397, 1.374327302456165, 1.180190451186539, -0.22400912332396028, 1.0983126369880658, -0.08540110438776961, 1.291494138794768, 1.3162363084661166, 0.03834511315885956, 1.4646728088798229, -0.5112698529138264, 1.0452091566476174, 0.3704038833542446, -0.3400391197567629, 1.1025072081970857, 1.3028712481814904, 0.9661397613610848, 0.9227575933814722, 0.7474190204063074, 1.0457499367911094, -0.15409840950414747, 1.1850455116844543},
    {0.9845475399313641, 1.323819320258432, 1.2393056775973128, 1.282675316966815, 0.8643005472450385, -0.11500317425687832, 0.008339673349702233, 1.0895923796975868, 1.0125696653444456, 0.6402050870497528, 1.132549838876471, 1.2560908444450993, 1.1634750717576319, 0.08295176150919757, 1.4612259465888602, -0.2795382189861467, 1.268444587456692, 0.9449871561602495, 0.03592009138052795, 1.2759492867348594, -0.1875273607610895, 1.0866730613729563, 0.5100750320365166, 0.0081820356017006, 0.8920012411503351, 1.1978354803063063, 0.7166611708546076, 1.0892528311708967, 0.5200018750574115, 1.020646580045536, -0.14976543123778438, 1.2258751892038298},
    {1.1940333457276096, 0.8920158372783928, 1.3613636730782697, 1.5035299075701873, 1.3260811716899048, -0.43254236720336575, 0.019265838798775376, 1.014139124646606, 1.4765738753206323, 0.8804135610407708, 1.1941355594995593, 1.2460745705190197, 1.2700720720612972, -0.09138256215086939, 1.100645624225589, -0.2049658359428627, 1.1526195310918679, 1.2246241241176434, -0.02991920218131542, 1.2771722009245605, -0.09792537720788691, 0.9299138962719504, 0.9942582997379886, -0.010908384205076126, 1.1654777495593573, 1.349392360465033, 0.9686603526156994, 1.0518101461029077, 1.0088429395757965, 1.1917938798906627, -0.11481277226822689, 0.9209729367306863},
    {1.2888579255433705, 1.153293227258016, 1.1142721592068048, 1.2911085207529231, 1.0399489518392186, -0.17967720955804403, -0.11639775464703991, 1.3027274389763024, 1.190091995776364, 0.9101350258283492, 0.8972304689553465, 1.292499064420296, 1.1124855867056676, -0.03722094104222555, 0.5567905196234644, -0.21594300170012443, 1.4112507506423653, 1.1058999506796652, -0.028016409020894754, 1.054912447001226, -0.07354189838833389, 0.9868395603209846, 0.8136379988128523, -0.28340257793335927, 1.1568500800170525, 1.1999143439491646, 0.8365201768583657, 1.2542997011481256, 0.6809416004228085, 1.0869810564642437, -0.23294121667490406, 1.4502766280848773},
    {1.071553521683501, 1.1930797552294488, 0.9799748730827041, 1.2935420896855279, 1.3898490854159122, -0.14104428890433407, -0.2867406141034, 1.0360215837240798, 1.2307792778545654, 0.8624893200936254, 1.1671223999373546, 1.2282246502855176, 1.3077506130310426, -0.1669189112084253, 1.2956623736468977, 0.011001715560800927, 0.9435398238648497, 1.1133781246757029, 0.1856559382271758, 1.001373712227748, -0.2951565902941854, 1.0510716033108225, 0.765140079413949, -0.27796496202363763, 1.5006527178593243, 1.2309028064595362, 0.7826308115296126, 1.3768110981659887, 0.6062355132896904, 1.1945006899508934, -0.3389409114038618, 1.2996227436952157},
    {0.8881872634925276, 1.3576732592894443, 1.3281437213380682, 1.2273112036948368, 1.3614594814802383, 0.0009243028091252279, -0.0718225622710807, 1.0275041929839686, 1.7961593950640116, 0.7346384198053898, 1.403873431656062, 1.2596549585324812, 1.216689683481564, -0.15233178787435706, 1.2211587185629036, -0.10586962878031643, 1.3553680441870115, 1.6209340726193773, -0.027242479432252695, 1.0374887755398516, -0.0035562085404799875, 1.089761507687384, 0.4958519159541374, -0.3891960804792024, 1.3534250954149798, 1.6613419450792037, 0.7759029595467967, 0.8802893433657837, 0.6028983592450482, 1.0784555499081514, 0.028189139128172128, 1.3854906197615613},
    {1.1322265950982744, 1.0582054302146688, 1.291034275854789, 1.0977553371128608, 1.4132796178110902, 0.1886265328861183, -0.061430224906499534, 0.9811261962659723, 0.7971648032326496, 1.021793838676805, 1.1315471227551157, 1.011805064907668, 0.927928830973956, 0.07691985843161786, 0.9490140556875103, 0.24900409313547814, 1.210428947799506, 1.0786200664047094, -0.011241956402123035, 1.4683135902386255, -0.36839133373754707, 1.233633325296221, 0.5014160562528577, -0.07886357392429495, 1.6350272284864202, 1.224041855632742, 1.1904337258074624, 1.0515311542580927, 0.4035712871676689, 1.098868317455541, -0.021350193325024847, 1.1462569378517087},
    {1.1755163395924095, 1.132193145239375, 1.1233789261277052, 1.1107350215203167, 1.2692120480233227, -0.0964294453708804, 0.14035551141051003, 1.403467559170215, 1.1681514631420797, 0.8245725259493116, 1.1772587014340727, 1.167180681005117, 0.9023197932655029, -0.04912111244648507, 1.411649121977574, -0.5816515079987338, 0.9590401470977584, 1.2849792181308228, -0.1782990745164633, 1.2016075358347604, -0.1023505213996994, 1.0027600923260729, 0.0820177388190378, 0.1370116484250138, 1.0677097831921176, 1.3950507959675431, 0.7884147742984888, 1.087264396334272, 0.644155866862443, 0.9087225200609653, 0.10431255835920059, 1.1361494440388347},
    {1.1119485962224922, 1.0176634097830222, 1.7069793054559828, 1.3626519473340717, 1.4133292896601797, -0.11746241813968279, -0.14581975902376137, 0.8365668888180827, 1.3223322658720245, 0.8976534900932006, 1.0588700046090949, 1.319751648745703, 0.9540201208728907, 0.20619154553876617, 1.2824209433749598, 0.130788507616295, 1.2559576802783796, 0.9999130467762088, -0.15303149757934464, 1.6134727517395242, -0.09196771833485806, 0.8726164636727274, 0.5628551456023897, -0.06736170388995755, 0.9225871856187854, 0.9670027060077134, 0.7235033957977568, 1.146198519105568, 0.5656624240651403, 1.1497313347046374, -0.28965673766904393, 1.2504074154575264},
    {1.3614133877831136, 1.0224914038272346, 1.2364077003426526, 0.8946302398655138, 1.2460970573466315, -0.33724580350651095, -0.30938022950341154, 1.1096185779169614, 0.8028944722691168, 1.0338997429355046, 1.3974952399707732, 1.3430853030271535, 1.1599096831588105, -0.04036504043194248, 0.9596592679223777, -0.09348620665662953, 1.1728867023778813, 1.2367011930562937, -0.27939765023227175, 1.3879903842574752, 0.28815863962956495, 1.1503442977082312, 0.7880663446508321, -0.06524889908973303, 1.2447221886675337, 0.9960270958677901, 1.1359212038147382, 1.3566613344177294, 0.625463313109387, 1.2943512994500155, 0.10705862643060195, 0.8755369431984314},
    {1.0496934884597753, 1.0437310258850674, 1.5772051942863983, 1.2008963912861486, 1.16448084982241, -0.2368315795183529, -0.11841934256391641, 1.2014177568566484, 1.0961558336718327, 0.7710772547993383, 1.0965428773760915, 1.1648857712605467, 1.0291205949821638, -0.18094560551306363, 1.1316426138029443, -0.09023971854542957, 1.0664523758518671, 1.3614187346602158, -0.37836820360993284, 1.1287667893902653, 0.18219619782460122, 1.1665886222997104, 0.27515736294799126, -0.02966723197333914, 0.9637164329345574, 1.3135330095238982, 0.7674775423833741, 1.1269689147166733, 0.5508396596199153, 1.1025741626285515, -0.218794488962532, 1.169923008589541},
    {1.1640745888627801, 1.1776855023358563, 1.0958117299811028, 1.2286445456875077, 1.1969802633096345, -0.12576397055708202, -0.05434044525508598, 0.9622690077231101, 1.3421785617358626, 0.7156134923270088, 1.0074290577906462, 0.9522537052796544, 1.3548915115756837, -0.10472225618881563, 1.1152482355520814, 0.30087060615351124, 0.97144229756569, 0.9005753307141181, -0.14099549170532982, 1.1668185635695918, 0.026858304769235935, 0.9909242417462383, 0.4987996411387829, -0.15046721420520778, 0.8510882259747542, 1.30244864160009, 0.5645762344059108, 1.098197698714103, 0.18232016929514597, 1.1407891321488774, -0.03276370977188613, 0.9003721904479387},
    {1.292373662472874, 1.1704967275216036, 1.133155301917263, 1.2072130939135468, 1.2380843604890055, -0.16761005306581528, 0.010646131521592307, 1.0891389455302403, 1.0598853084759667, 1.167446973882479, 1.0643117172732495, 1.217386197434527, 1.1430451566806143, 0.06788264085327952, 0.8840510598111418, -0.13704103324212102, 1.1458534940835572, 1.2130512855292304, -0.001405102570055798, 1.078585445718646, -0.22571845546159386, 0.9053652694677372, 0.3519332103416075, 0.017605017725535577, 1.17833362637924, 1.0565561965397452, 0.7200538927392605, 1.0048854174650874, 0.7217523068868794, 1.0467547585229262, -0.15201176703104488, 1.1062570943334198},
    {1.3271155608458562, 1.1236520427625376, 0.8974105643042857, 1.357650378847352, 1.231221148721961, -0.10995166929785812, -0.2381233736956845, 1.1407479487483307, 1.4140201911876984, 0.8314480970977065, 1.4266659628863048, 1.1818828484215829, 1.2097803731432293, 0.11466644563085303, 1.3207896481031736, -0.1258855132205801, 1.2931113153648048, 1.4694147229169983, -0.22421435411521984, 1.393759011487635, -0.29812287123744674, 1.1606691737672123, 0.7290424669142508, -0.09091993652348826, 1.1642506603338652, 1.2772476030441247, 1.1341925268256565, 1.2810176120962835, 0.8527262510936677, 1.134056438856371, -0.30419829551963895, 1.4123663420100703},
    {1.124479596905211, 1.280011409611492, 1.2326977545677158, 1.1733955801731313, 0.9293923871865295, -0.13379429173099244, -0.13230782031410573, 1.0698124091760028, 1.0503313778788377, 0.843146528481913, 1.1556570402716189, 1.2499620098253574, 1.0234006999987404, -0.18497689004190163, 1.2908669235942696, -0.07674983654567903, 1.169330912276726, 1.1162336814321558, 0.05250875118346273, 1.151263405761056, -0.22753272992614795, 1.1496978918143055, 0.68676495406707, 0.06585632817706742, 1.0627214285248374, 1.3869865405818713, 0.5183505152343881, 1.3631496431498307, 0.6158256911051981, 1.2164568182730158, -0.2764888921751988, 1.3453619407000341},
    {0.9915275503068955, 0.9958132190296614, 0.7276599422270276, 0.9530080366148738, 1.2203109297806862, 0.19203010460526407, -0.11899571487783915, 0.8984141528603874, 1.0659900088468823, 0.7951550240493773, 1.1624570116989847, 1.1586733109602803, 1.240495322076395, 0.009209969429121872, 0.9558939475995137, -0.41768336192518407, 1.2488182037177649, 1.0935752695166825, 0.17075118917871104, 1.1243811358306364, -0.031001983066788336, 1.262527471553085, 0.37682359904055857, -0.059459894589294404, 1.273320837749761, 0.7339064266220989, 1.096259487679617, 0.9529987015858168, 0.8041588568927096, 0.9644610660820848, 0.072867454638321, 1.4224058224719554},
    {1.1046851573844527, 0.9357701373286715, 1.3538170230363553, 1.2860380299888734, 1.258628034553465, -0.3111018238565757, -0.28052358685657947, 0.904161684077588, 1.6344084318509913, 0.9961183292484076, 1.356792125152494, 1.1757816810960362, 1.089057606965911, -0.06075172646415716, 1.3011504274240637, -0.003951653387843129, 1.3311104724168354, 1.1428005335369629, -0.18011135190823097, 1.2681268668739976, -0.005933114965937784, 0.8072701452072968, 0.6930764483452855, -0.3189180178689689, 0.8957272664036497, 0.9385359711142496, 1.1761404370162878, 1.3301456695497484, 0.9920072780840344, 1.3079298787167177, -0.13149648287940421, 1.214909533183656},
    {0.7475466104592983, 1.1079988614422318, 1.1490792172939963, 1.2715408537772341, 1.1154638140077704, -0.07019358446591484, 0.041090990981238314, 0.9994798569206076, 1.345681656656642, 0.8413467423875699, 1.188912708190941, 1.2115171025700209, 1.1278614612515427, -0.05898440152548263, 1.3781405288515705, -0.2852336011388202, 0.7728444034159033, 1.318990527265238, 0.24273445071197886, 1.0175435929884198, -0.13001292327183533, 1.064497989474911, 0.13476636874936096, -0.07322042624649844, 1.1704950843597774, 1.1066167360751344, 0.576919730888918, 1.1832630981403205, 0.6809699711073893, 1.230967688136884, -0.19400180524773417, 1.4245017405134033},
    {0.9484430281107381, 1.2457925846718831, 1.2132605629363933, 1.3660546800580273, 1.406010021961609, 0.17412937069918172, 0.020046777385500904, 1.3291925171789714, 1.3690445656725665, 0.8974580066310132, 1.2547158175764095, 1.0475382924111114, 1.0457496305179177, 0.20475153453238865, 1.199262209260312, -0.08175087002949574, 1.166130212240363, 1.3855359684739543, -0.042255870465032125, 1.178003358465186, -0.05428017896707916, 0.9189716618361568, 0.722849300921246, 0.10190599384219556, 0.9832508414563473, 1.1855480718682305, 0.7927165399452881, 1.098216117937008, 0.6587306997293447, 0.9115698219957653, -0.18821928556946216, 0.9603171986556525},
    {1.3151580011103592, 1.26739366013114, 1.2297884928545384, 1.2169931883768825, 1.431713110906278, -0.0812204270577624, -0.16608240577655572, 1.1945535089069668, 1.1167582747413927, 1.0038080375558402, 1.2584545507923282, 0.9730369402139377, 1.1233105232916953, 0.1044041611628596, 0.9907881287168309, -0.11416372343732066, 1.0854298761019088, 1.0268235222421285, 0.12325097722566704, 1.3318641019360142, 0.06767665500437067, 1.0953769065624888, 0.6256263263704055, 0.01700435327147817, 0.9777435092428205, 1.2785445284006722, 1.3130691253013358, 1.5393399859291896, 0.7572946401259761, 1.1678342126872836, -0.024604350486075517, 1.4844260603277621},
    {0.94905267401528, 1.3585707343326874, 0.8984100463726385, 0.9520292491049407, 1.2634157461245499, -0.07291962126261223, -0.05328149704449546, 1.103209855118574, 1.2103608736670526, 0.9877980125949101, 1.3916734972115177, 1.3742188539998177, 1.358377927996988, -0.14085508811204683, 0.9660389447697796, -0.19728792216798563, 1.1318549075113902, 1.3160565126102843, -0.19132891713298644, 1.5137179397369722, -0.08066978116327114, 1.246840423610852, 0.5429132881360579, 0.07120262878261654, 1.253215481949564, 1.391381178885825, 1.0089384868785156, 1.0517869744828297, 0.6683589548106489, 1.1292719473767254, 0.09033306100945715, 1.2780643159159728},
    {1.0127677037943248, 1.0027886590654782, 1.2084040645065905, 1.2015237758414656, 1.2144817042176264, -0.20337924738432958, -0.04719646365857103, 0.9580626124659533, 1.076781513275015, 0.9214421433958433, 1.6013426988632506, 1.3512150268445589, 1.3444819380711042, -0.27511339563401116, 1.1697727574697776, -0.1637134997073591, 1.285587058098494, 1.192203775488735, -0.03213303102791378, 1.1006686083332542, -0.022668554632666604, 0.9279122144078689, 0.5353341273930297, -0.1396397461806284, 1.3303572970504494, 1.2247328119400391, 0.6562009353974687, 1.0954731854056257, 0.8590701647003718, 0.9904586808933814, -0.22181236116746383, 1.1463980594371797},
    {1.2933578933836145, 1.103930329246268, 1.0572875890548676, 1.1340874992631498, 1.2422482107376125, 0.06711518736544414, 0.1877533640373826, 1.195997651600945, 1.0763214142937738, 0.8201641463938988, 1.1773620492425072, 1.2947886051578243, 0.9969313120642804, -0.10891581280491394, 1.1717329094164843, 0.13542077234628958, 1.0670663734566317, 1.3969993657902946, -0.002461381241457155, 1.0868146413858955, -0.33502886332010856, 0.9433316044065924, 0.14361158044013095, 0.08631116887236162, 1.1627420440864984, 1.238158566101349, 1.1391938430572246, 1.1288865278074622, 0.9530318128732665, 0.9744719565988318, -0.20629203454055384, 1.3667632076363567},
    {0.9754009869241665, 1.296671922817872, 1.2542922222088024, 1.3443557448059387, 1.2765331339154944, -0.5092472850245399, -0.08863258875949057, 1.0841806943682952, 1.4062459721185678, 1.0857009101620365, 0.9887071352390345, 1.5268507026483749, 0.9908662582241936, -0.10170591274958257, 1.0485050706122037, -0.1942100149480315, 1.236860907706427, 1.1445998114168734, 0.1901088741541155, 1.545477990000482, 0.10537256791032654, 0.8949504698637951, 0.6569813620570014, 0.04049335057316296, 1.1825082230892912, 1.3131185759537787, 0.9586054957969069, 1.2416218406042696, 0.9653966744695823, 1.3027056328564537, -0.1435799801771628, 1.390636847088599},
    {0.6529243223701784, 1.0399597692351434, 1.2791533577105951, 1.1651866833636386, 1.2591744870199222, 0.040430699958521214, -0.2939701489909151, 1.1086377246815842, 1.292509814621294, 0.955698967673526, 1.2283384377066846, 0.9182758334830656, 0.8133694682319637, -0.0793557987315911, 1.092181326834205, -0.06110065137488522, 1.245781514243313, 1.0925013134793784, -0.2930794122033786, 1.3158203840214235, -0.331350635630649, 1.1490135565987498, 0.8016645031298343, -0.15159875973006168, 1.1863747088955707, 1.4105474221031713, 0.7525421409147979, 0.8299054536791781, 0.8090971399766558, 0.9848745784576675, -0.2051212630755404, 1.20511735807946},
    {1.0710392005596496, 0.8200513446379664, 1.6321621787598422, 1.0222239284940675, 1.0389139851208524, 0.14814747099227812, 0.19212901589191456, 1.250346507068142, 1.2047764055756638, 1.178620650952278, 1.0546335968017955, 1.3660764891693624, 1.144425238722633, -0.2186203837728488, 1.090987978747605, -0.10495689960715682, 1.1708764457543226, 1.2467049081117878, 0.009013934055806973, 0.9691236357558813, -0.10084619234968184, 1.1100348536357265, 0.46171484478091596, 0.10981731014514219, 1.081987795896968, 1.3651689003875869, 1.0658833087397577, 1.0593562594951225, 0.8959969943350499, 1.2813894910278776, -0.32676049987917954, 1.128565097751487},
    {0.703439297895228, 1.204741249473941, 1.0417951293173708, 1.3220826783405177, 1.3107255578741115, -0.30605296317037634, -0.29198106912443056, 0.732891589618687, 1.3381305817347149, 0.9405200825254165, 1.3030731854735425, 1.2595243160993017, 0.7518657675378383, -0.3908588123542507, 1.3699832945911414, -0.06621056573300602, 1.4674320312010711, 1.3726491978166706, -0.11188388453339934, 1.1697006892763928, -0.16724792566201718, 1.262826938350357, 0.53636545779353, -0.06400661856268672, 1.2614768132823908, 1.37636532075704, 0.9296065992886408, 1.144149491218091, 0.5665539583218471, 1.2875746326429807, -0.2336480941560748, 0.9745964122582739},
    {0.6260197420743728, 0.962238974086403, 1.2070779112430456, 1.5479329552194838, 1.2838017301587992, 0.049732264061918004, 0.11654822578418564, 1.160964061229221, 1.3751240805823242, 0.88050587773071, 1.004861722590415, 1.2819687578595471, 0.8188922274645283, 0.0347873050707839, 1.1586678552245782, -0.22729200823149878, 1.4623464526847754, 1.1854105315411838, -0.258245033546306, 1.3119746408506425, -0.5144834264414562, 1.226740667358906, 0.38176790679892625, -0.08912544758552828, 1.4127335593727386, 1.1180221899885934, 0.7137807482758666, 1.1474010930591525, 0.6176252955881307, 1.2924099256416155, -0.12497634287299447, 1.461065211766084},
    {1.2540287607311682, 0.8214883987047495, 1.2438756789821788, 1.419599792143826, 1.3338861729468512, 0.016511234881207777, -0.1903283528396487, 1.1110431184443197, 1.2913903286680875, 0.8161599538396754, 0.9650845904105554, 0.8921958586334641, 1.0801689698569945, -0.12173208870768956, 1.304783673366363, -0.3494010866899182, 0.8395473989614661, 1.4208840560829492, -0.15248685293315387, 0.9442426925846816, -0.16380403255249842, 0.9712480437934277, 0.3814971525350338, -0.03389597554039011, 1.124820543676711, 1.0447873234917067, 0.5573719866952674, 1.3198429254057809, 0.5290852606316089, 1.2454630330927667, -0.04179211033458915, 1.3452661856506873},
    {0.8525812815299165, 1.054869819246795, 1.107751300485832, 1.2286482938538767, 1.2075270620031109, -0.001202752220904924, -0.09148890807144676, 0.9167917379094642, 1.1866129020624139, 0.8891429106367111, 1.058617444812377, 1.2475926370354902, 1.0900025174128107, -0.15827051069189232, 0.856651452668605, 0.07183676250470648, 0.9353349192567785, 1.0116397618500763, -0.32675774116991013, 1.1207104162651123, -0.08922230449516173, 1.3409745646223277, 0.5640795490741345, 0.005444344031617224, 1.2986262748593733, 1.2811112713401769, 0.8700854960703044, 1.4455546518964149, 0.5359164352025869, 1.1457937820731605, -0.08474480974085434, 1.1391134112425123},
    {1.0049962034508513, 1.2310376334753828, 1.3406646700538292, 1.1764541580423689, 1.1962833285500745, 0.276916205281165, -0.04536842558678302, 0.9710184668015635, 1.4187977193577335, 0.8521117365519407, 1.1637037146599152, 1.1917185637748138, 1.470190674134111, -0.12426472576997678, 0.9897829863018609, -0.0491893259323688, 1.293269161056965, 1.1213722841508855, -0.3080830991262519, 1.2044957630780075, 0.1683505389964188, 0.8463543965386126, 0.4458527153562516, -0.09190696683738438, 1.2264244589564417, 1.1652435906783734, 0.6722017340652782, 1.3935076124983294, 0.5001407032043714, 1.2084809228843914, 0.1395178756209928, 1.4703812120265052},
    {1.043403956023518, 0.8781351338077239, 1.2743928089928793, 1.0577201538933934, 1.3882810057206174, -0.024650634929580736, -0.25515358128727944, 1.2236173687755922, 1.0592221402393154, 1.003663777087656, 1.5201183049912295, 1.4763170562133223, 1.2384894788202783, -0.18713963577646048, 1.0706444436737632, -0.31088262365698527, 1.2244919574885889, 0.997844364874952, -0.12045908515875334, 1.43831750918205, 0.22499967228970424, 0.9728342892852099, 0.5713578828068903, -0.10785780873377314, 1.0603222255223275, 1.0699666091257916, 1.1168842232310894, 0.9482354807843371, 0.7071153862077714, 0.8496018628248969, 0.3529623501672268, 1.2645144607375622},
    {1.3798500463850476, 1.3023836665793034, 1.1785765528886059, 1.2398802668513265, 1.2343431762471622, 0.07051585319214632, -0.1949682426182774, 1.1891978595722021, 1.2345028527016926, 1.1517645453118979, 1.2361473665825775, 1.1758788891217369, 1.2139256282958772, 0.23984639527097126, 1.4389518980389469, -0.07284963028325216, 1.4170499683374622, 1.2845144637798749, 0.14694820286707205, 1.093824359348066, -0.23894802170701746, 1.1631448108256315, 0.5796825561576034, -0.010810557585062218, 1.239440179691821, 1.3915412983619646, 1.1621916967305406, 0.8740304288456293, 0.5530806761937161, 1.134896243055331, 0.11362293311911723, 1.2808569133392609},
    {1.213627907286972, 1.0433484535386228, 0.8846398263169214, 1.3882334936609935, 1.1461144326956099, 0.22356721173700442, 0.10615078132614361, 1.0426880815087622, 1.0514875683935656, 0.8255826098761915, 1.0127840255783047, 1.0894124897234345, 1.3089182107569413, 0.012930998341380342, 1.475848277813409, -0.2809896121949089, 0.9211433336569884, 0.8256098543188418, 0.02606839156776257, 1.120332326369912, 0.06929878560129735, 1.0482708078262866, 0.2376633623288507, 0.026375546616156546, 1.1778451715779445, 1.3933298030571002, 0.835723840933645, 1.1766222239589736, 0.739178978887594, 1.4946816582490543, -0.07601960793393411, 1.191013209214136},
    {1.1587949644402729, 1.0377010339761816, 1.1441598001677578, 1.0222166114145534, 1.0773093471327881, 0.004521116583321062, -0.12859959762379414, 0.9874039070193834, 1.1730665567976075, 0.997097640584037, 0.9364393676667783, 1.1077200206720312, 0.8488061285147706, -0.09350791573390471, 0.9654428031667457, -0.03639679525548968, 1.0608935071872279, 1.0047810992493544, 0.04100910895408372, 1.3195984868452573, -0.02403430990543308, 0.7315154364712848, 0.5647876492052094, -0.14491352294339369, 1.5836758331132115, 0.8383146645713218, 1.0719507678340885, 1.3246429467946468, 0.7670763720521878, 1.0026409234225375, -0.16131014549014772, 1.2127191434479434},
    {0.9790460698708265, 1.434527596778253, 1.1331850059778843, 1.4556118316593734, 1.0250148476913896, -0.06173443191178133, 0.142160613656432, 0.7558875364317431, 1.2943242879403265, 1.1231830817814903, 1.0874421054362562, 1.0568513165196036, 0.7724999136442147, 0.017447780608019506, 1.162159740416488, 0.09667862097203542, 1.471826651895305, 1.2693000894003044, 0.11316605051147692, 1.0019934031990971, 0.023816311088367, 1.2671286136073772, 0.21809293853823059, -0.11802753648268083, 1.5386325388954714, 1.4023265909575042, 1.045049329102744, 1.5068746968502436, 0.3490808696731105, 1.186823042923555, -0.4075655450293625, 1.4093310469213107},
    {0.9092399259009628, 1.0463182277880116, 0.8822025039729756, 1.2009416905200472, 1.064796907668245, -0.1547692638514038, -0.2083490433966484, 0.7309031325421341, 1.265714831076137, 0.7736732731551906, 1.5187485719047, 1.2846198052346578, 1.1493041714998418, -0.2879858009847837, 1.131035271138585, -0.21750789249221283, 1.0756993557988423, 1.5871665466217029, -0.1569052913797833, 1.378230341432078, -0.3466688697567587, 1.185153517406159, 0.35465650012081396, -0.16439654687705613, 1.1766717209648856, 0.8621521760634764, 0.9777215422322671, 1.118897176086975, 0.453953913467539, 1.121179523831977, -0.1207980231642551, 0.9094730035281582},
    {0.958385255923859, 1.110584131132364, 1.3994737376886695, 1.0448362679539145, 0.955266079621432, 0.16972014639459077, 0.020883288368459787, 0.8309729135426038, 1.104982773086128, 1.2378122835378824, 1.139443457864082, 1.1235733791810003, 1.206563958677956, 0.019538335207756226, 1.3770623607717232, -0.08582841906313259, 1.3497018742726705, 1.4697781994470605, -0.03119504392677184, 1.503629312318886, -0.3843001805443745, 1.0643872262274414, 0.10764140065379744, -0.11417032994087607, 1.2990738528915875, 0.9588755881958028, 0.933501752157313, 1.1159936230971725, 0.7612682011104515, 0.8161139506313321, -0.12861300677835083, 1.7357317981721203},
    {1.0544692314788948, 1.6190414780575664, 1.4894043276980204, 1.196117821386704, 1.353648006668072, -0.20244202323903207, -0.15102936759125388, 0.9816663899664684, 1.1923373935065071, 0.6687136050885144, 1.1404511401462534, 1.06095724705785, 0.9020285279298681, -0.11798952437076762, 1.1840130668312028, -0.3992886693047597, 1.5089806057154138, 1.2050055740886254, -0.08523059875600965, 1.5684329331485722, -0.12816812523810753, 1.0874516896518196, 0.1525742036752294, -0.23205821028497955, 1.247636090904463, 1.2911685232008403, 0.6092418364360557, 1.4273485174930876, 0.22244903001941466, 0.9558456013666604, -0.1548186225083861, 1.1462163828004461},
    {0.9682723902086523, 1.4332926235517354, 1.5617269271208436, 1.7450379874538235, 1.3799671038131724, 0.15663544437735333, 0.09027842247958036, 0.9342276927831165, 1.1608618180025931, 0.9287763771261668, 1.2322245938976766, 1.4339165228697799, 1.3415333130197271, -0.06524919051129553, 1.4872554670819498, -0.13693149809024327, 1.4909103375033768, 1.362125464135493, -0.019442254876733272, 0.9670903814625749, -0.09097644652015535, 0.7654562307113031, 0.4068679602215271, 0.026493373613404883, 1.3178087965416914, 1.2060844485508122, 0.6973524332993668, 1.1681842416984942, 0.8530102635085997, 1.0793559557569001, 0.1760374235969093, 1.2394069050942442},
    {0.7589433095142541, 1.141520955607875, 1.0397248375319894, 1.2546107735289662, 1.1969545737463025, -0.040029173807145026, 0.10575555836706962, 1.086959511276069, 0.975806464508097, 0.7136995253666593, 1.1901475074912242, 1.4714273378236928, 1.2053948316878542, 0.31376886264862186, 1.149011899359001, -0.09135520276186357, 1.3175667122859729, 0.9967195751457831, -0.22801225100350545, 1.3075145135290478, -0.14343900306578708, 1.2012375708513612, 0.0036732037650721878, -0.1538932192971003, 1.2433287561007074, 1.0435241773730841, 0.783049385051114, 0.9454938047233499, 0.43635821037187283, 1.0494437689693557, -0.03675555405737224, 1.0448378582145863},
    {1.0731479789258769, 1.2949533718616295, 1.2618283231922194, 1.040792930179558, 1.4152841677828536, -0.12733343970178782, -0.0538568508296122, 1.0965076573781944, 1.268538974774059, 0.7618324186196559, 0.8940528865385003, 1.051145923646629, 1.4361338955808287, -0.016401012048752016, 1.3470300880288797, 0.19907852002091236, 1.181981240241188, 0.9194436636584549, 0.01188435381832739, 1.0040282197047508, -0.06684012330458178, 0.9204570368194568, 0.33480096583686564, 0.22801707804699164, 1.12394928838506, 1.0072393138088986, 0.752073367446006, 0.958996326334963, 0.6372558589282634, 1.089443095672064, -0.011630544283985259, 0.9827623590885723},
    {1.2158065051096203, 1.3556198145074585, 1.3787982712868918, 1.5971868096445911, 1.3977085713736541, 0.11825955399688272, 0.14932386032768938, 1.3915748666554275, 1.233046424792102, 0.8206700461035754, 1.157820581084605, 1.2552272968882519, 0.9458885310395558, -0.41852293161534276, 1.1639545577229027, 0.028897052783898224, 1.62789210448932, 1.3390643879150514, -0.44234469773615903, 1.245855652515213, 0.2087794217723459, 0.9906243747787994, 0.6411474892578473, 0.011861817009637485, 0.8175359887503594, 1.385031672861388, 0.802804129158506, 1.037496384414621, 0.9826716400183549, 1.205533261303015, 0.2749370368329707, 1.5365493096446692},
    {0.8664957991611278, 0.9709088710896239, 1.4363310479190747, 0.821906680729738, 1.2764290240112623, -0.0372497172006174, -0.27472206583332814, 1.1239410251828235, 1.052193081021023, 0.8328822249233743, 1.4149842541306719, 1.3126205090346428, 1.3006774154997034, -0.12628179870882802, 1.1646221869907496, -0.34580052813632817, 1.2233389982522949, 0.9851919094033107, 0.22542531864455956, 1.1094898985300814, 0.1757406193649347, 1.0579051162271487, 0.46851502971301, -0.22236188252915928, 0.7524383138331169, 0.9949775493109069, 0.7674703264076349, 1.014440169795764, 0.5827823149912648, 0.9140798655188941, 0.07697363285559697, 1.0230020691920947},
    {1.0673499421965853, 1.0889095126749564, 1.0801809476347364, 1.070782021116976, 0.9710730475114836, -0.05906789483735134, -0.10372645151294846, 1.0103767627612759, 1.1547422582424407, 0.7054783567959715, 1.2107394205797886, 1.0706530100230491, 1.2719981445135051, -0.2390316907365378, 1.154592014288329, 0.14072836072702205, 1.1799400189002442, 1.2306433035489135, 0.16887608950389854, 1.2231514515329842, 0.08453353078459912, 1.6224044347098414, 0.33772888142513247, -0.23637978907614915, 1.0785945573555866, 1.0062941029279717, 0.5624564979126312, 1.1895416263611107, 0.3925406720307787, 0.8447604571449844, 0.1313267099086143, 1.1943681425995294},
    {0.9666878369804444, 1.1556650690154364, 1.2131758582989034, 1.2748868977947527, 1.3448111101864588, -0.16512138291218822, -0.43563290656537096, 0.6009889616580714, 1.4478738210958866, 0.8564662597360363, 1.093906719197051, 1.0438276491090737, 1.6112021389078743, -0.1501305846388381, 1.1101330636505018, -0.09366043014719953, 1.4783916009268196, 1.184035465698674, -0.036010490014347904, 0.9005117832537425, 0.04230879909115218, 1.1300839936340483, 0.5401129291059306, -0.261719529594038, 1.3185564922993167, 1.1730221149423203, 1.0855257886179994, 1.258463067541513, 0.7059394761969698, 1.2454914634464502, -0.3281181540369198, 1.1407030916799858},
    {1.021352781883737, 1.0221565984350829, 1.2069707886581837, 1.1102913104333476, 1.1718294829048115, -0.2370166253680436, 0.07372460960415103, 0.9708090240032262, 1.3128607305593691, 0.9795466932218195, 1.0808889207139822, 1.2820986634776657, 1.4269036704721583, -0.03534780099772112, 1.0405217620018736, -0.08308334422821408, 1.2168405766215942, 1.2529175462168896, -0.08022666502371363, 1.1675011922795062, 0.10703912785626668, 0.9595423092555945, 0.6291617088733562, -0.15988531317776425, 0.7515975540729917, 1.2405150533288603, 0.693344352454983, 1.2495300590098977, 0.5898955905870816, 1.1987771153496791, 0.02653281146635783, 1.1763097740345974},
    {0.6720414200729588, 1.3124761464964012, 1.1480432183247806, 1.189872005937066, 0.7495509234867135, 0.0375447384937687, -0.06598672886160847, 0.9991295366953136, 0.9641451341427334, 0.7189661121502597, 0.8917252248349419, 1.0642616713757103, 1.126156564023923, -0.19073876195467046, 0.9843145538968517, -0.17218435006184848, 1.0769399401455826, 1.2416062705479693, -0.0809239912017297, 1.3023250965626607, 0.0977156246479274, 1.0045028128180133, 0.4395838838048764, -0.11245850367899748, 1.2313577723373825, 1.2055835193629048, 0.4969898755355255, 1.4258171272647908, 0.8645874624523922, 1.0302614840066606, -0.15803798416308876, 1.5150191122382821},
    {0.9901529816163875, 1.077779626189741, 0.9200621171169242, 0.9147896413907739, 1.3673476061014194, -0.2548312303248233, -0.07314484127922279, 1.3092786104887952, 0.9945602272579556, 0.8721606155137445, 1.1237857998237981, 1.0887549312358098, 0.9364287550204962, -0.0028435446613349832, 1.119120451750728, 0.043283382082038545, 1.2106781787735168, 1.0773612490873596, 0.20176316123202767, 1.480429980692797, -0.20945778038864254, 1.236772108474982, 0.36484257055104896, -0.02912585621152433, 0.8180691821602668, 0.9616434451387248, 0.9464590625030869, 1.17137581022502, 0.8077624065522138, 1.1489049504035806, -0.14392501235558225, 0.9777430270300886}
};

static const float b2[32] = {1.0265510679724903, 1.1023194218537866, 1.1957228414204017, 1.1927526879394212, 1.189621448266753, -0.15017576370717348, -0.10204353824491526, 1.0965129151680384, 1.1836352808400301, 1.0216399065381676, 1.1415279989120737, 1.1923938585535738, 1.1517627317533203, -0.09922553640658931, 1.1398862074063911, -0.19400903493880556, 1.154194479837931, 1.1798560290026807, -0.07880885075967556, 1.1861483463375662, -0.15010491438484758, 1.0977425808322707, 0.7035903574617794, -0.07496170175164558, 1.18975581531958, 1.2111887500268605, 0.9711738964164877, 1.1542912558118645, 0.8578675631913281, 1.0831215966678627, -0.1289894297656687, 1.2171707135248442};

static const float w3[32][16] = {
    {0.21160515427956694, 0.9616357072427879, 1.3105914452627436, 0.4528827770358383, 1.4207889167896113, 1.4276354380119483, -0.34624520159010885, 0.27265719234868213, 0.15329391002245027, -0.3629744747614648, 0.18752678465967906, 0.1052054710219836, 1.30953482194894, 0.25991798353946854, 1.06026681285145, 1.2430563290813799},
    {-0.19739831424501392, 1.1757369101208779, 1.295906953233424, -0.16915160930484716, 1.780561120663911, 1.2036003322378532, 0.20758916122377744, -0.4830404046861845, -0.11878642992382149, -0.15747789087770736, 0.2074740078647698, -0.24639905430947723, 1.0114896854618858, 0.34171290268656773, 1.061138101799686, 1.1352404217775445},
    {-0.47689261769440566, 1.2520631125605461, 1.2602342721435147, -0.09633787358510931, 1.3659346964134709, 1.4338805289362726, 0.10228729934417993, -0.2343055259884721, -0.2932215107667304, -0.14372817106087324, -0.24562433295279565, -0.13403766242306664, 1.4234254171296548, 0.20069332990768518, 1.3749204043948504, 1.6890080897117152},
    {-0.10170497703518587, 0.947556515878503, 1.2375852806089154, -0.07201699557674128, 1.2365952725041478, 0.757745098261643, -0.28997895578805466, -0.0010589281206639803, -0.2567080904381455, -0.282656419170558, 0.04603705748033797, -0.003372726270380769, 1.5732046117160408, 0.4120329325259531, 1.5981882009717636, 1.524371643867414},
    {-0.41320543009527566, 1.9770153366396674, 1.3567798459439258, -0.3226030163413029, 1.4877525132016138, 1.1694091565255296, 0.19852955087142676, -0.09163964803948235, -0.11718535083384544, 0.08581556415149472, -0.19577187620778616, -0.5451197407690286, 1.1242223166701746, -0.3408771479136119, 1.1915170423307184, 1.1089566819730914},
    {0.2602414335383034, -0.08914647263106915, -0.20382991087430669, 0.2945478317560389, 0.21570488172269958, -0.12815908135040927, -0.23563287532871138, -0.3460829670539711, 0.3941657256563042, 0.07739087485355677, 0.33177903087599725, 0.051924711030065886, -0.10410000201351126, 0.08952075644760374, -0.320137179653155, -0.0910908324959068},
    {0.0321005387259269, -0.15912942122297202, -0.30708310218696805, -0.05184010932624411, -0.015432976739089528, 0.05810393135750459, 0.225765703485985, -0.22485256881880156, -0.24777494395386732, 0.19176723783100885, 0.09832403628464416, -0.113569044880971, -0.35771342706834475, 0.17566226534373103, -0.06260797929236599, 0.10934064876120213},
    {-0.08864199522429228, 0.9677711800539774, 1.2195314832807667, -0.03286587290414051, 1.0028768543196507, 1.0899233325992048, -0.5965154854948, -0.29362819818901414, 0.03472392180217643, -0.2909571170356324, 0.013846339009131901, 0.19972596226737901, 1.5181432348053427, 0.0981962715508577, 1.3547839947792415, 1.3922604943410823},
    {0.1876080112305624, 1.4038958903934018, 1.337752542273261, -0.21222834041662325, 1.627300452358492, 1.2791979321367102, 0.051665640983017805, -0.16079755537236418, -0.27063112699421626, -0.152714946140925, 0.20478533239006805, 0.2870466645956738, 1.179485575002975, -0.31239754298553996, 1.4481592470846747, 1.233134066433515},
    {-0.0704301182364163, 0.7988117314870825, 1.5675933435371012, 0.3075280205270333, 1.41710501071521, 1.3477066063824976, 0.20474698749293202, 0.22856058123818274, -0.12172832829802234, -0.16607990361019542, 0.08048413851876575, -0.11020897032295099, 1.004167606625069, -0.2159105250274449, 1.2798350624428319, 1.0972037374292842},
    {-0.03342743573732485, 1.0821974792519151, 1.5435510244466895, -0.16003172576324853, 1.835180114461424, 0.8920160651677882, 0.3513847004028714, -0.13223979617694645, 0.09334842162401548, -0.3120726570890029, -0.2789515525404591, 0.030183119921368882, 1.5687650600216971, 0.16735544795573695, 0.9311801588432104, 1.0392425913581484},
    {-0.09949938384971031, 1.3041052511210396, 0.8356144639236955, -0.1258115686482662, 1.6587766151752388, 1.3157969396259201, -0.4860029479680235, -0.2991946058819802, -0.33904061218209874, 0.037058870829187074, -0.05349975643331667, -0.12658136666373115, 1.0252380483562364, -0.36268692060291485, 1.4409288803393407, 1.4384343342932133},
    {-0.14448532139762182, 1.2162327148133347, 1.2214686092971847, -0.15910899270818246, 1.5163922935506635, 1.02601369517925, 0.1170008162736967, -0.36189621253007503, -0.25833439222122245, -0.09074832138007295, 0.06456977983837171, 0.14988922256757312, 1.2117094896921647, 0.12233756115278555, 1.391350174412085, 0.8547128940991905},
    {-0.048375888432197874, 0.004963943683371825, 0.05892635850291988, 0.0657051917191163, -0.03920817038236823, -0.25604651568589887, 0.4806410551879709, 0.04027367395788306, -0.24351495800218192, -0.0965178233453041, -0.4476084348755906, 0.06710671062662864, 0.11995205075555666, -0.18697512591814774, 0.015002872671784882, -0.3892594205128901},
    {0.23855776673500734, 1.328429096442343, 1.6909137567715304, -0.24224408241882542, 1.6227019081192315, 1.1084969935789994, 0.3456406525023418, 0.10615837003386751, 0.2286912812220198, -0.04435304999753985, -0.17471535980151232, 0.06854421027226812, 1.471339649014292, 0.06334159728816967, 1.300575383263022, 1.2895638371399358},
    {-0.38781163379103717, 0.10030230695343387, -0.31869005111905047, -0.13534025555584608, -0.2198296072808043, -0.005074929772481199, -0.037914725215436075, -0.04461956683464274, 0.018284471475081266, 0.024250183123356476, 0.13198537350502362, 0.36857551773648645, 0.10904067638733739, 0.07339604367507585, -0.21960176575765306, -0.19109735461572525},
    {0.4199246924178579, 1.2282171926741732, 1.1260208340349138, 0.043400209826779335, 1.6045552878464844, 1.4065597854329563, 0.05271798226181664, 0.020681807786958772, 0.4371879048503838, -0.24175419448539326, -0.2951887702933098, 0.0034976693939492865, 1.6074750480049529, -0.21656748667620884, 1.5205942498970562, 1.013528237088834},
    {-0.1651067344000037, 1.0174493114827292, 1.1289563684049018, 0.30628918439973607, 1.6070215272848163, 1.2462118542250387, -0.02002490705020892, 0.10278640592379135, -0.2307318502980154, 0.15195077718388422, -0.1689679182431633, -0.344521149571396, 1.542561661616586, -0.05015903047393675, 1.37005614229826, 1.3424866041904475},
    {-0.1862637168234378, -0.32759436617961807, 0.011125116983694595, 0.32024735411292427, -0.3264942224317555, -0.11419066251844877, 0.08108663985801377, 0.2827233196376797, -0.093895189270777, -0.024845047456383093, 0.29834748724983035, -0.34798317936673945, 0.18229059414132892, -0.46233157234294686, 0.16080343723776358, -0.1407020028676532},
    {-0.20981846861430375, 1.644343591452879, 1.3166351920411719, -0.12976288861945362, 1.2483883204929398, 1.2878413963288973, -0.1732954845895348, -0.3633984406799735, 0.0423436367417234, -0.07660004413840021, 0.008565463637526529, 0.19334699832956478, 1.156014623472552, -0.13722473814392763, 0.9619050922293023, 1.6547156176234827},
    {0.06370659738910979, -0.021375713247057494, -0.029984637730218228, -0.21859082186945772, -0.024283949898289033, -0.2986357300877337, 0.07616764502495045, 0.305744579072025, 0.2629872060629604, -0.2326412729368152, -0.023837540377140455, 0.1927263461903284, -0.1002889954282782, -0.4484676328556477, -0.12228586557602243, -0.011710531340079138},
    {0.18067637992994195, 1.4739669021160813, 1.071716217926741, -0.07237375103817022, 1.116676161177636, 1.062756768067189, -0.3031044996796531, -0.21632019381763987, -0.046020930426473074, 0.1832954825319165, 0.30318970449643307, -0.5287990096575802, 1.1286187623848547, -0.05232205634412363, 1.0868044821489575, 1.6553673867957583},
    {0.017726968177147175, 0.8659913172824251, 0.6415798385075119, -0.15343052725982556, 1.0558908357910102, 0.535398498888389, -0.13016811480126636, 0.3164962659972193, -0.23852951719769003, -0.27217156196824227, 0.0643159691623468, -0.251364558178899, 0.9118358627472797, 0.18058608277939678, 0.9906741847553511, 0.32319110499735815},
    {-0.3345257721788456, -0.0579533155935863, 0.15179361263501784, 0.21596058628493764, 0.1581512088669029, -0.16373664030985136, -0.060624632066228104, -0.08566520614114183, -0.04324223406637336, 0.12186820048198539, 0.1641052724509385, 0.2536616165124603, -0.035355750920728984, -0.8665010371457799, -0.352628674226847, -0.15635056459847943},
    {0.12755999077672242, 1.3171660999379802, 1.3167968538922161, 0.03062467426941964, 1.6178567372488044, 0.9712474855591819, -0.17499732684296002, 0.08364173963174683, -0.4011404854328726, 0.22050174985664456, 0.1668828255563689, 0.1004313842743997, 1.0861861117280827, 0.07490496798004374, 1.4178843792923401, 1.7625069377888374},
    {-0.0461645698541851, 1.3490300080827144, 1.2377941972135604, 0.15795140280237507, 1.124376449648381, 1.2424913604638013, -0.7080460009176437, -0.33542062256724753, -0.15335006158588516, -0.13205622823798774, -0.07273385143698215, 0.34493629618817695, 1.2303690969146033, 0.16189984900775412, 1.8186060044650794, 1.3219079120344912},
    {-0.44469775371067805, 1.2399054524057862, 0.5549223383713853, 0.1416605357398748, 1.1529235963359732, 1.1801519721717082, 0.33447200044086417, -0.08948412072707125, -0.641526233882721, -0.3004191116389862, -0.26818192626721393, 0.36705087971613504, 1.186325703135396, -0.06825985530545815, 0.9819104791066019, 1.2369003637294516},
    {0.1500464788966915, 1.604508598168039, 1.1580540211441075, -0.06262253956995047, 1.7870373361713037, 1.1287546687023555, -0.06601190580694004, -0.4757624060588476, -0.01482492943485167, 0.3971941083265137, 0.14259573377368667, -0.3984477538245033, 0.9051460095642166, -0.12114727919988388, 1.377667393448799, 1.7797788486093051},
    {0.1480509730014253, 0.8636374738592103, 1.0217521105387166, 0.4250461679701287, 0.746251118183856, 0.8879805443192692, -0.01173119773190581, 0.021546786592343353, 0.16516225603316523, -0.12090266563573339, 0.40269307457241343, -0.15481950893383967, 0.9452520408856988, -0.5364841749592084, 1.2180699237733432, 1.1140927402102772},
    {-0.10229914807960032, 1.4255779741219041, 1.1807509505839893, -0.08534217187240069, 1.4188801575692, 1.0073392571940125, 0.07573327284877235, 0.14949830997713318, -0.3029425129574723, 0.3302911482769413, -0.31633066676347477, -0.14355853928581325, 1.262378555180709, -0.28858568215484315, 0.7701203456223391, 0.9565413071878355},
    {0.04568726322449902, -0.24555594083000637, 0.018148196841662217, -0.46004163861787944, -0.28704994726199956, 0.16704350297622578, -0.17487478768189235, 0.22786989590338894, 0.2790900115660066, 0.26510011539726075, -0.19720705428660765, 0.13216235562840078, 0.14423517954465853, 0.17256412628998505, 0.03389696091695408, -0.16969232086780217},
    {0.2284637607233937, 1.1748280395754664, 1.2188056695366538, 0.07501163838654569, 1.3868429361797525, 0.960279005722199, 0.06575460343776374, 0.09744161058599225, -0.10325010222574274, -0.07143003482901107, -0.1109935141278269, 0.23371449128929306, 1.3115860896125155, -0.006574092394059865, 1.459636464441984, 1.1469376677081897}
};

static const float b3[16] = {-0.02858322528889731, 0.8599131974406738, 0.8891295304139418, -0.024275370636896432, 0.9391655401899711, 0.8092315188596991, -0.041185498539789235, -0.03526193405791406, -0.020786111072507933, -0.032531344832215245, -0.048604438981823275, 0.034291036562433215, 0.8701052377667842, -0.06645878115950307, 0.9196498811515427, 0.9225554836729022};

static const float w4[16][12] = {
    {-0.5171226342377679, -0.321777753097745, -0.48658234633348346, 0.11166766839151045, 0.2596454902853149, -0.11209549444543881, 0.11566528802560742, 0.11397049635013816, 0.4270354317727146, 0.29581787487073097, -0.015024192458709467, -0.6533308006234613},
    {-1.5654978287269128, -1.7136353441049823, -1.1361708467898552, -0.42048948824423554, -1.5025999738910392, -1.3065046544254093, -0.6011052931395049, -1.2422781627215596, -1.2062310223677664, -1.2119087332482457, -0.7734733789536052, -0.5734905955589571},
    {-1.4842136620396773, -0.6826238227560171, -1.3518467480296135, -0.980958023262949, -0.9882171498751223, -1.258719569825811, -1.3135254235684524, -1.4001528521415663, -1.3343956381511404, -0.5763162487481418, -0.3926649172066775, -1.496992648163678},
    {0.4350189067550365, 0.6498210270319222, 0.09021942818525261, -0.27355962556728286, -0.32291612340878456, 0.5465166653386754, 0.6456524789900148, 0.14515912326151695, 0.2279328637938862, 0.40373610124985637, 0.2764463593812395, 0.38377649206382053},
    {-0.9037068071579527, -1.2439034408576568, -1.2466972601293953, -0.870054320051087, -0.7825484751952343, -0.753771162364626, -0.9982263727219587, -1.2512059202267984, -0.8882062157196564, -1.0405459252886449, -1.0498522892893027, -1.1843905633031142},
    {-0.11050155027682255, -0.5612003960731401, -1.0543732540418966, -0.5089312179031281, -1.3976026641066959, -1.1893779305718868, -0.7900137541560976, -1.0886579677575785, -0.5510911131423692, -1.0877338611476663, -1.3101144594178153, -0.6434387816348626},
    {0.04890633268718643, -0.39970829976168715, 0.3609892626224958, -0.32636420878945105, -0.024131073253076046, 0.5815381823505222, -0.17713851197943647, 0.5711757964590672, 0.34925304119330297, -0.24578089325683894, 0.42830740070632317, -0.38261684472760676},
    {-0.4921464829565741, 0.4464223479323269, 0.3370727243588082, 0.2337148001229779, -0.2134796306958664, 0.432304839585584, -0.31927608422553083, 0.2924018077648564, 0.2364305985086614, 0.311458841078437, 0.38694907009399326, 0.32630146477992894},
    {-0.06599050521930937, -0.44798797735958534, -0.004686454006331455, -0.2340433201339136, 0.7859113806985507, 0.6013248975864911, -0.019255826870181413, -0.23721460112864298, 0.1794429983323765, 0.4464011118439503, 0.1989897515483589, -0.4835337679486172},
    {-0.6544873279149674, 0.5296773605456492, -0.33117769048225637, 0.12604335907601563, -0.18225394644007936, 0.2668789985970751, 0.10959572738564448, -0.37216893746897334, 0.26686129457900304, 0.020154808007072575, 0.0978682058658133, -0.019520492622283156},
    {-0.1899618119531318, 0.9962014268151352, -0.5089849439348548, 0.05276116601073772, 0.3540513759432463, -0.41903529486037117, 0.5446538120356682, -0.02114831094524136, -0.08048828698396282, 0.198934843244265, 0.29015726049735685, 0.2659546606041102},
    {0.0029335614260928007, -0.22498583727126883, -0.46210227012259875, -0.8608680504002326, -0.6201623221873577, 0.040076919623133714, 0.45714985322500956, 0.2684080445817258, -0.37421460585191735, 0.0036870562876383938, -0.27746874756447837, 0.3117312545632282},
    {-1.2765975583482712, -0.7769655186132567, -1.0666081214343488, -1.2793699845076472, -0.9262551226172503, -0.8142657856751615, -1.5567425510603423, -0.20523923667320074, -0.7542232753293101, -1.3988567113112629, -0.916706062139713, -1.2579313579920173},
    {-0.08568827860487939, -0.11908667454475957, 0.22194739118664128, 0.16280854835515945, -0.43907817869578575, 0.34286208084368314, -0.06244014469660952, -0.11625780553396459, -0.100743691903239, 0.3828134575090823, -0.06458126030393274, -0.23960318448137996},
    {-0.38242666395266, -1.5283525613849418, -0.5874934604825085, -1.5557197511651677, -0.9504744997865899, -1.0530275232686457, -0.845891138252284, -0.6442419626685476, -0.9528650891721113, -1.099128295263406, -1.596356047747035, -1.533146697652901},
    {-1.4699198849896498, -0.7147526668861189, -0.8408730970687882, -1.5544417296427528, -0.8870495773669566, -0.9652093488693778, -1.098957288785575, -1.4445344488831091, -1.632960823997542, -0.8605176934681222, -1.1186520988329325, -0.5230079140540792}
};

static const float b4[12] = {-0.41335778194439843, -0.45304401575374476, -0.33978099490251745, -0.36070465220791476, -0.32393832507633086, -0.26860618640769524, -0.27779821832630736, -0.38494696179740256, -0.33170391761082546, -0.4262712774120721, -0.3915818898400437, -0.3881795409413182};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
