#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.7127561437676242, -0.9657120478231388, -0.5054061125074103, -0.5066808279323246, 0.20366548341238244, -0.5182967444111254, -0.27557449099374054, -0.806750670207544, -0.6887361225317072, -0.7214777128958338, -0.8593604616573949, -0.8071321488920185, -0.6845349273489396, -0.8071920747627873, -0.6869791763980444, 0.03911948540976946, 0.5522094141318157, -0.51067268123686, -0.6079340177725429, -0.020013003017371786, -0.6003214081005177, -0.5786374525130893, -0.4476579210299712, -0.7750178699500844, -0.22312848689129292, -0.7294994170886343, 0.3337853793597898, -0.607882147276768, -0.6962464089104033, -0.8916023261584032, -0.940077028544606, -0.8068715695604848, -0.25202544998471677, -0.9308114023152427, -0.9159888905009969, 0.4884565906219951, -0.2753328494087754, 0.30183761546056076, -0.9261621382091373, -0.6510978143666577, -0.7315794446443924, -0.48847315747730313, -0.10662504972195795, -0.7589941919225375, -0.7038517257985256, -0.751824005979953, -0.15895578076064515, -0.6770012811036902, -0.7431834959468354, -0.04358299353530496, -0.7681127710450018, -0.11090846136993152, 0.37682345791432936, -0.9987082173518423, -0.7476317012859545, -0.7877443866048156, -1.084643376964181, -1.1400751256743356, -0.5294349281108188, -1.080882593164988, -0.20966561722370414, -0.9141899214563591, -0.49218845782709836, -0.3281415369292303},
    {-0.46745810141970634, 0.6513790577021383, 0.19947637815959623, -0.051962348606409574, -0.42293594734085627, -0.28666453437008926, 0.060299473817165196, 0.23139839758129105, -0.3374536303519787, 0.7670400860660485, -0.2067664811696069, 0.20402763704379984, 0.09684688759900882, 0.6057632735896208, 0.49788961253431335, -0.5610098617269086, -0.5545959891968224, -0.14583145495219565, 0.5030484710230456, -0.2877556968315601, 0.03939255414839051, -0.5671308569233976, 0.2371395479080584, -0.4558631855607512, -0.24219514910774667, -0.37203454174212414, -0.4875502276241544, 0.23343477487595388, 0.4256812804888918, 0.4319974734702711, 0.12246920213960441, -0.032519297899645534, -0.518485597515354, 0.8998159002566246, -0.08012697598810557, -0.24308291568536794, -0.3024927448232669, -0.40527993070866514, 0.11205997549714888, 0.028881187881366555, -0.24964992691808147, 0.5262024200766383, -0.7032861146453218, 0.2466060634095039, -0.016549333906777628, 0.4134451407323199, 0.3776315397019761, 0.12702194813788395, -0.04485522812534275, -0.7607332732628009, 0.08768590115720751, -0.29687125156578165, -0.3636736730677545, 0.11603863778870027, -0.3661235567481523, -0.05581154414709017, -0.30817214836477647, 0.43195972270960026, -0.1035652833569342, 0.417848429357338, 0.3829790981827905, 0.7791310557736528, 0.07338217119553679, -0.64648882949448},
    {0.46915307589568106, 0.4333231068113995, 0.42524679994047526, 0.5659359019968158, 0.381484180964603, 0.9254060346510212, -0.14500231051519866, 0.22979440628866862, 0.054786916566546696, 0.4900258404861892, 0.7798400927418347, 0.706973419603243, 0.44219102597511034, 0.42025183122536286, 0.5015877014732784, 0.6193276250411865, 0.42257299246614566, 0.33624247884601366, 0.35028789913363245, 0.18928641553144862, 0.5443957796969537, 0.48870966272964866, 0.4730697433557692, 0.4446861593756299, 0.4389343540987281, 0.5495794436661475, 0.6013560599951209, 0.7969964920967111, 0.718469210572772, 0.43910865877016864, 0.5133053392553686, 0.4803061740060977, 0.1719801910745289, -0.2972151126319021, 0.6389954526849786, -0.12405756872320649, -0.1452268808772681, -0.02221473946526434, 0.16742363325881285, 0.3259993074529235, -0.11195872715497342, -0.048107393770500786, -0.06891272236696099, -0.5653698616021882, 0.4885852136541084, 1.0718539106908382, 0.7405514708136285, 0.5390078519906153, 0.4784779517734595, -0.2687613654613423, 0.43806154661209057, -0.47560867803413687, 0.6496928489599597, 0.5131899523859705, 0.8639016051781021, 0.8203916710761433, 0.7419516407776621, 0.4113749603738856, 0.4086226054424583, 0.6106614862767542, -0.4037633250253231, 0.6856128414070009, -0.027679538092329297, 0.8144361917491233},
    {0.9664836991712401, 0.17761226543831984, 0.09094590037211077, 0.20969424117941865, 0.6812350924236396, 1.04799860852254, 0.367855017936517, 0.5557284260369082, 0.10923443513191136, -0.250346291890022, 0.6272163050600207, 0.6799303546720166, 0.6859606829746466, -0.7051769661252605, 0.545277283198721, 0.8851414466215891, 0.9889377989564627, 0.7905326000131186, 0.3386276532282778, 0.21435062073484967, 0.5886372779007142, 0.2936320033307991, 0.4951608725425291, 0.5032772753955924, 0.6195529269436515, 1.0660912369929167, 1.3219000847775675, 0.08722827096499634, 0.42897994329736955, 0.5948176732734571, 0.38021424664480596, 0.286864941902354, 0.6337406103978952, -0.2755488093630937, 0.5231588907236253, 0.2029078271753243, 0.27776359965675745, 0.6290916652626315, 0.6059299992664602, 0.9543395886774662, 0.5404554798642629, -0.13867613416977376, 0.260648352220677, 0.016846174375585294, 0.4743488931796971, 0.5226985020779893, 0.573636743246474, 0.6718238857400377, 0.5185555492773835, 0.3530993141143014, 0.8207476289067598, 0.2636671630180133, 0.8607506352936206, 0.5658175069658703, 0.21632630580598788, 0.613852395346094, 0.8593064100837398, -0.5551768388321673, 0.31140230202475333, 0.5269559221580333, -0.33091123987889404, 0.06410130741793633, 0.47545378219859125, 0.6955935808937733},
    {0.4058942162747925, 0.4956908848997287, 0.65824081465969, 0.5769833346202029, 0.17798796170990347, 0.45545467366838865, -0.3889511596158026, -0.1992129984957861, 0.047601065508986996, -0.3957450864709146, 0.4008785539579255, 0.29921279844679366, 0.21914556309763406, 0.08795992642664835, -0.22070109201747873, 0.3350006707021119, 0.33157647950044106, -0.605059211557498, 0.8012655401293493, -0.7770883383014762, 0.8066780014607022, 0.4656676723559703, -0.6027050218640025, 0.5915981193453641, -0.3207132890209519, 0.27076413029524776, 0.19232697541255264, 0.011548297742982952, 0.8842727051479855, 0.5455800600388447, 0.22706597302720477, 0.4688664712999758, -0.2503279886784205, -0.7896508361524032, 0.7325615630242628, -0.5418435155903671, -0.3599154397874501, -0.5126998369258307, -0.04913808616440421, 0.133876662894706, -0.19396734608087296, 0.13867313439223888, -0.5717342808606686, -0.207973245965827, 0.2348711125708422, 1.148024934131973, 0.07704197838343761, 0.3628283322121325, -0.07841394915627807, -0.5826737830420787, 0.7105744788320856, -0.5296357407316126, 0.23707634036252723, 0.5038204216566524, 0.7405162415550847, 0.9804138782648006, 0.2849000380262831, 0.7582785079342925, 0.9626111903229968, 0.3651219789950704, -0.5567633812818927, 0.6498373504240949, -0.061308366112148224, 0.10183780853334999},
    {0.560475333353939, 0.8130684341565007, 0.9102452579315055, 0.966552322914501, -0.23455833562333464, 0.3624738851945195, 0.02986170123420361, 0.28501115160961565, 0.6390944722762336, 0.5539559792383919, 0.7389324152317953, 0.37403755177078923, 0.300837310769992, 0.412037979138103, 0.2041126959849163, 0.045144615585001, 0.0894247678295707, 0.11819494248194368, 0.22128845518887075, -0.5539316133933836, 0.9696468494129751, 0.6000560267239308, -0.1807828608822066, 0.6137023897644295, -0.22831042979932056, 0.04733704029414032, 0.3258067059118435, 0.8962138907153543, 1.09850034257745, 1.219797961619205, -0.09805639198180781, 0.8036912003397646, -0.29881380300815086, -0.3971457784605021, 0.5987736912190311, -0.6772752323420551, -0.5699185839279526, -0.3426953958211822, 0.3698282125211003, 0.46553387757595893, 0.35651537159024915, 0.24929178395988694, 0.21469321598324725, 0.07345490874110608, 0.5022070184196339, 0.870014570692068, -0.4110901029835, 0.5338086795248109, 0.7069722288678827, -0.5603292410140512, 0.6807675597381391, -0.5400613206583653, -0.08920764993860177, 0.8251515096820295, 1.2183707279553855, 1.189622327701284, 0.2988451547750617, 0.9598938264157817, 0.8887260308836179, 0.9456694247128402, -0.36927887768988266, 0.46510479625248874, -0.03132946921299259, -0.07254776500232177},
    {0.38718837294796415, 0.6829264610152213, 0.37391255366310405, 1.0026363314637663, -0.02476753782574078, 0.8496540211597702, -0.21758634619726142, 0.4152276576073441, 0.49583276022148265, 0.7468777095670588, 0.5805485058176072, 0.8797388244470712, 0.4295442636809738, 0.6836311863528242, 0.4992506184426958, 0.619611755491838, 0.5821315900484708, 0.5820101159243563, 0.3948250839035571, -0.21198633012726795, 0.8266666882620929, 0.5026611873426087, -0.2100625422965249, 0.6375340856501995, 0.40996370008028715, 0.5448202325888976, 0.18562713171067646, 0.8737117964294047, 0.9512276673511477, 1.062714391324191, 0.034733494017665754, 0.5150912335146186, -0.2584105950618247, -0.5596673318528737, 0.7191712384765494, -0.4807782186419017, -0.33459865960396656, 0.028544177418963618, 0.5897133066359243, 0.450670322348825, 0.7793712535061471, 0.350908411814365, 0.15904585330466722, 0.25564132717152227, 0.7517632497242386, 0.5826846968412163, 0.16274418265537727, 0.6391519099418965, 0.8039804328596686, -0.3352373597013924, 0.8155779975160863, -0.28344528724459306, 0.1052931972096367, 0.9854951421990502, 0.6789033848358534, 0.807487383583973, 0.7548248194207584, 0.7275448078994413, 0.7964136202907751, 1.221786913766133, -0.007002388538999868, 0.39146877986661205, 0.07221955118032648, 0.16992371983734042},
    {-0.33158490282887276, 0.04258402966966505, 0.5310335626465392, -0.6191974620377545, -0.5108235679751382, -0.3373757200523548, -0.34343410357134485, 0.2444637012756527, -0.7500481941401059, 0.08205660063230702, 0.09063408400893379, 0.33177799292671606, -0.2564690620471178, -0.04684410138450275, 0.07117343420576625, 0.48944217797952677, -0.045255419833279735, -0.7151790013515494, 0.3114988394308156, -0.5630579287765606, 0.4997866753137257, -0.3789099554610783, -0.4417631282016905, -0.007732867748847884, -0.09419834208909335, -0.555816097370345, 0.040092406950007424, 0.5890704018572815, 0.2898952100202756, 0.33222474889190684, 0.2233417549133424, 0.37883043513914305, -0.5159969682935919, 0.11031551171771672, 0.3141900710569765, -0.39367604073680607, -0.6247198223505099, -1.0814375901623614, -0.22888275830549148, 0.31218260558763944, -0.21161218559017034, 0.3288054659828232, -0.4752054054379203, -0.43859774894854303, 0.27632046553392625, 0.6627420691198467, 0.12412357276747295, -0.038718953352772534, -0.08438052822680202, -0.7960581034810308, 0.2026785791023804, -0.2156288574914428, 0.19738321536152903, 0.2974340951215287, -0.017630552289810482, 0.20316713780307133, 0.31038873927011945, 0.2916531418702729, 0.19689786406204177, 0.6376351267743462, -0.4578082482112489, 0.6560676365492322, -0.18175350528607537, -0.44818510192480354},
    {-0.2813367627047083, 0.389102925111369, 0.04047910963455484, 0.10179352232095466, -0.6240762458914324, -0.3293805779307404, -0.502609748441337, -0.17337352964547362, -0.5720302859438399, 0.49359675606503417, -0.3432176819228405, 0.3332723594119846, -0.15084149147061995, 0.08077234504593764, 0.3753671218774723, -0.21560565113017968, -0.34410853745779985, -0.7563977563847616, 0.27773182148576714, -0.326350635914017, 0.11248747694315711, -0.49081532175629894, -0.6010610846969554, -0.10795477717128506, -0.03303747040783468, -0.484872002010113, -0.39578245147345265, 0.3736724540233189, 0.3143025375961865, 0.1482768658611922, -0.41481909581972687, 0.18940686985706423, -0.7360527048781234, 0.021358971854504017, 0.201064210645928, -0.3885366802384916, -0.10696890480793007, -0.5521549084354159, 0.2698066748934583, -0.07971764359526307, -0.5058726871358544, 0.1922276753301916, -0.4512080537276634, -0.25378884132399554, -0.014267371753076524, 0.3614521917854499, 0.3259251099892987, -0.5587130934764829, 0.13401231423763485, -0.4607343802239844, 0.4140450008796993, -0.08728331076951072, -0.04394186662840473, 0.5184337474732313, -0.3028016874450195, -0.04803277445252263, -0.262339440033274, -0.5041844024736362, -0.16135026388461124, 0.6119632194841805, -0.495019737857888, -0.06777804898400258, -0.26212651757676836, -0.5304804735967396},
    {-0.6261021595244733, 0.4160986154342352, -0.14057432122278485, -0.1255022375297024, -0.05695666179918546, -0.680146393355199, -0.23540735630368378, -0.0344128352097298, -0.25683370020441304, 0.578536216140855, -0.0651976617202159, 0.3387244471979036, 0.12312892983705394, 0.4346375564583654, 0.5223161139631266, -0.46953192255397663, -0.4366120847056625, 0.06027437580010696, 0.40222921847519133, 0.4219553572209445, -0.274719489133303, -0.3303679873343258, 0.4232989415244268, -0.714816501514193, -0.17726903169534214, -0.4634400183571829, -0.6223063939043627, 0.0032896753054912262, 0.0470948029222273, 0.029885189085094202, 0.7003843215167338, -0.6239076089169245, -0.22105303920356692, 0.5678014101599496, -0.24816650586378214, 0.08169041897776412, -0.6071622324779601, -0.22551450551622768, -0.15935769764155472, -0.1591392147645658, -0.09430702073350536, 0.8487516846323429, -0.23441592791448437, 0.36916755961602876, 0.031545948774143476, 0.09564003878486965, 0.4477568847643512, -0.12371771353775708, -0.21036808851010394, -0.37635920282044244, 0.47111618609400724, 0.3776048087106424, -0.03364539688896948, -0.10892453430854966, -0.604878563977674, 0.19849915416334626, -0.2509173080765755, 0.43993528758262984, -0.4405397334476329, 0.3758117596158547, 0.3478226630249959, 0.2580781410544375, 0.67959584689127, -0.7378171244526347},
    {0.2950388563380255, 0.36253187541314735, -0.018366560194046946, -0.3306871526968822, -0.07239984616997096, -0.28580822210729767, 0.29341596888402316, 0.40114845330878124, 0.2577385739357611, 0.4195372481670692, -0.009630774995853542, 0.037521701945402566, 0.22581251554565612, 0.030358980710624546, 0.8080922030777189, -0.4995659640045124, -0.19869396862254948, 0.8975314093241898, 0.19928024102196942, 0.28373708678408827, 0.23061125697525428, -0.3829977326429514, 0.20829433214314108, -0.17117445248450583, 0.6471300602850527, -0.1917613862002836, -0.250659340971153, 0.3652755940732568, 0.048892738404883916, 0.21946453173139574, 0.4329667591885979, -0.503860111988771, 0.35898215543628, 0.37535095948948644, 0.10360087494772977, -0.27103371294748335, -0.4487600376916836, 0.15816308314639, 0.4480266641853768, 0.13677652365004037, 0.24246168123363587, -0.13039868562451765, 0.012403269532088744, -0.13017688103516956, -0.5704440385179772, 0.05199358584866708, 0.07083529520967535, 0.08623237895162116, 0.3275674092286158, -0.37998344887111396, 0.29350447907953003, -0.06845343765021178, -0.19294413505438543, 0.09828048286939842, -0.3292424595073926, 0.08413586252916327, 0.47118979747454665, 0.1044273139190174, -0.2810706091678094, 0.2457740454158718, 0.3350760550273447, 0.35671471177723235, 0.7682160645036464, -0.10198578646261855},
    {-0.0333376224258686, 0.3094743777886089, 0.09570415787068635, 0.09662140259813529, 0.5032529245911851, 0.26448421679572925, 0.3834938706433013, 0.8601958979224711, -0.43272177349508134, 0.2563244616478467, -0.34650956286438567, 0.5313242027193005, -0.06118975901537174, -0.11445211990289689, 0.4832185720993314, 0.3999992242352526, -0.15677129429440073, 0.3192318386687351, 0.002486159158335953, 0.7461593354621797, 0.08421191738043522, 0.5649102687695954, 0.8666303016164053, -0.38513716810261245, 0.1962176020148318, 0.7844629970557212, 0.22984076356305688, 0.14131241706265266, 0.09281846654880856, 0.2003094728329751, 0.23465225343977777, -0.41586700781842223, 0.2531651678186852, -0.09569319300700019, 0.5788271757819059, 0.6037387953818895, 0.5815829884333944, 0.5176472475449906, 0.3668770609275339, 0.06204271989910028, 0.549631232387497, 0.38718140369077186, -0.14360205965224734, 0.4593436740483227, 0.6343295845907566, 0.2720091611498632, 0.8097374496153289, 0.25800924496568317, 0.05666606693852493, -0.12050749406106417, 0.15954037888070963, 0.3676240131505477, 0.4757383589625396, -0.026176518706744648, -0.29250543835128756, 0.10582469412895947, 0.18149160938560985, -0.6173464115618712, -0.39807286851394647, 0.24059412776069938, 0.21550365681529754, 0.263854571243095, -0.0841919170466963, 0.4191532292267846},
    {-0.3768445158920966, 0.029814186870220066, 0.12966257101181347, 0.5478395976549836, -0.10447978819578321, -0.5308774350771559, -0.20443833480338297, -0.2824185093224088, 0.11130363133386398, 0.7112799783439436, -0.506365913093336, -0.3655861054897012, -0.11560747207658632, 1.0796663656482421, 0.39900343954628564, -0.5150104665544474, -0.9153485009136578, -0.2518017690484934, 0.4123996449286716, -0.17133384546661015, 0.6579017066009899, -0.18984498730650093, -0.23920389051095295, -0.6748260747418159, -0.6585743849054823, -0.35645564897156407, -0.8566395621377515, 0.5339311503262492, 0.47038292093976203, 0.058998480937571054, 0.2019574234307829, 0.08823471377019317, -0.4401567838323535, 0.3187297349356408, -0.3513732666179751, -0.7241426868774871, -0.5904035896425203, -0.4642506285654724, 0.1714431950891738, -0.2427450587433933, -0.019311760474501165, 0.6705013545572166, -0.08317948151579942, -0.42324791497801584, -0.06430317593547062, -0.056808298666829245, -0.8285197380828324, -0.37090672678956355, 0.12659286613397355, -0.6228610385892648, -0.26167950399168177, -0.2071363198307861, -0.5217748569109385, -0.5513570897993405, 0.7278658343292735, 0.05200005974274556, -0.5220161132001426, 0.9307827193703796, -0.3623464483300204, 0.5761638395424437, 0.2586894576859264, -0.23182624234687688, -0.5271768057430153, -0.5156973364701688},
    {0.9685676188629151, 0.16653797216564165, 0.2626376158016983, 0.5384326149547426, 0.13041995459461525, 0.9414326147118826, 0.818179507043625, 0.8923088915940911, 0.6826033345567827, 0.4443939463510299, 0.6058447793011014, 0.431853858300193, 0.30314540018304087, 0.15790326630915777, 0.6857786751469448, 0.6407289459189415, 0.24239904642553195, 0.8811167451755978, -0.8011226188063508, 0.5841077163144011, 0.4308026442045535, -0.25158719248498623, 0.6027575011216232, 0.08456166706136613, 0.8748671619063384, 0.5455364613535315, 0.5703702543460565, 0.5392795228037469, 0.19507735725291062, 0.6763151466240234, 0.35315855785334216, 0.2602771480052172, 0.5261369307320216, 0.3993076151848538, 1.033746169777038, 0.5594773602064911, 0.6230356415817948, 0.6553215574018835, 0.9193267075919324, 0.527018664590695, 0.782374352545881, -0.49890061021018306, 0.7041141751540431, 0.7763191731081955, 0.8235798327219415, -0.24352309721846543, 0.5970246658934903, 0.6331104021859892, 0.8982189294476048, 0.5301701604821816, 0.8197872150742967, 0.22037275474184412, -0.17853073323325971, 0.7781022051743878, -0.18991254076858785, -0.19150591697062588, 0.7722411590368705, -0.32781488647820467, 0.1355407841505452, 0.6903575889556905, 0.00035943180502260127, 0.2842325921849016, 0.7886284861635549, 0.271984650157754},
    {0.7144243281485548, -0.6232203051613185, -0.42796686389425836, 0.8084155017129488, -0.17455712397281906, 0.7089576307167671, 0.6165663837376377, 0.4781404847817726, 0.4853909128078169, -0.24347376642666557, 0.6658591200428651, -0.10437157913802285, -0.2425688196707174, -0.44990608363566803, -0.04050762099037095, 0.40076528842538944, 0.5566090557517445, 0.2955502938880984, -0.5245833370208486, 0.33456186722919523, 0.5210972682248987, -0.23130465544698897, -0.48162300793952934, 0.2919407630368605, 0.34270518746737066, 0.7401098706284039, 0.17524679579227992, 0.2744999514609904, -0.40431311093946565, 0.10622477682703521, -0.8064952867479289, 0.6948295906393763, 0.017031345236192402, -0.018630914273893, 0.4605933539182476, 0.1465713108310767, 0.5610650465690064, 0.5684325392633228, 1.071642908647078, -0.24397788262103848, 0.9516402370125817, -0.7852219779129109, 0.6326961730649641, -0.010004741701619734, 0.21877769019244425, -0.7696816744233324, -0.39712592283119846, 0.16301323830819778, 0.8845892040505194, 0.5450208225972495, 0.4981638688175587, 0.09157323081605737, -0.24114523601675175, 0.12768923680299246, -0.21786773149196167, -0.6449838756663832, 0.3832740174739423, -0.364714118379058, 0.1706342329592294, 0.4549772158304617, -0.7260055595846238, -0.6819251759287205, 0.33882898948675155, 0.16508747831107187},
    {0.303030711322531, -0.022192286227081727, 0.18278311173149045, 0.832439526735234, -0.48058672336720226, 0.1345343043371205, 0.16613605055233938, -0.06823875161297784, 0.6756593681914106, 0.2937777755793339, -0.39842358062627586, -0.4971462729684058, -0.04284880342556489, 0.2533325518623245, -0.16219941466259738, -0.6808020989661988, -0.7832079601799813, -0.14074085896124858, -0.6746546936467643, -0.08217539596941714, 0.6527109067690109, -0.08995080372308885, -0.29813853116084965, -0.9576079016454144, -0.25642460011783696, -0.20702229810700087, -0.7374985491972241, 0.7206655092758973, -0.176049632997852, 0.09380998332814752, -0.6607215597345195, 0.7723582766762224, 0.01695716925549332, 0.6716168052614485, -0.28994315404383014, -0.3552996688075733, -0.225366464982094, -0.10302399758166388, 0.23223655939454382, -0.6475501426659808, -0.1724470439473073, -0.35868456865023546, -0.23756714562552328, 0.36266196376022186, 0.1734013284914957, -0.6824538223989364, -0.9259791316495845, -0.5266637652197053, 0.546327553547374, 0.10944943291760278, 0.024317266459948302, 0.23467961451233174, -0.8654663524448166, -0.45729736268360277, -0.28720641773716693, -0.5977300242768905, -0.45711804853056326, 0.437613383152416, -0.2548881433704882, 0.26409854110328257, -0.07029919019631, -0.6055888548969551, -0.42928535039452953, -0.3643274487670717},
    {0.8054929421592686, 0.19615162714435505, -0.2959798958059788, 0.6920979675811477, 0.08491424971144576, 0.7901024918314731, 0.49863042711414074, 0.8695223147383477, 0.6700794886938073, 0.40546908759567213, 0.5363357073465687, 0.36141986310372115, 0.47168289363018284, -0.16641945606077752, 0.718468664421245, 0.6485870343847522, 0.6195990859810038, 0.9419044703853946, -0.16074050501514806, 0.5730641330490559, 0.5829406788782524, 0.42974637856054937, 0.2990723401649803, 0.7647416694795038, 0.2817771919684248, 0.5143011659587754, 0.27208288133882513, 0.7172907543121878, -0.04048365090604489, 0.929928169262235, -0.29904716269621245, 0.7058840460070032, 0.7038717407046736, 0.39094978506129485, 0.8235520816610337, 0.7158130869890692, 0.8255520434191402, 0.8546945010671682, 0.921454074642284, 0.7054477912980353, 0.7744783654412498, -0.5996507495832971, 0.7909420587159917, 0.37689211724919186, 0.791353875844757, -0.294853595237038, 0.6419185571017573, 0.6325704195417061, 0.7745577797656965, 0.6653374915192377, 1.1475034800524204, -0.1606747073984118, -0.23587179053115984, 0.550356308454726, 0.15206151862507292, 0.13842724133506004, 0.9520088136867274, -0.014462936401659389, -0.19488285655677354, 0.8759502445989715, 0.11483862017022377, 0.31653855592382324, 0.8112058768477907, 0.5112533547477726},
    {0.5470103812691945, 0.18407198644587305, 0.07593500076879031, 0.86358539538982, -0.4569500337496895, 0.29146542815431503, 0.288055555719139, 0.3304783252228296, 0.6913394130425331, 0.39470175749269415, 0.3557213170167863, 0.4735068021926828, 0.24583518799062865, 0.17637652595066383, 1.0820581889975738, -0.2747963469823353, -0.09442858293083181, 0.8858468467972601, -0.12966457319303984, 0.6801551924854016, 0.7045256095013601, 0.37128641519214567, 0.33540142133585604, 0.10135491475176904, 0.3010231398609225, 0.6565808830481907, -0.2807784148188039, 0.7117159579903766, -0.24773541133693355, 0.6573326074946397, -0.18524041738995026, 0.6181981281215687, 0.8633940277169888, 0.2950426444621894, 0.5538637114383634, -0.2192467495828665, 0.41877929838465894, 0.6839884904282559, 0.7182537779821732, -0.03653286172211941, 0.6312835620752337, -0.34131575882187043, 0.7544103020403202, 0.46990300051013156, 0.04908551289376972, -0.06016920341966324, 0.06995518962492958, -0.18172213808482285, 0.8400359928304166, 0.5966764236050366, 1.2320773362583322, -0.3170941262913568, -0.2256187147631943, -0.04779594275026871, 0.05758148548511376, 0.5871968350019571, 0.21145547207754967, 0.28596472958640123, 0.13775349438073037, 0.9265286134507537, 0.24491186922298525, 0.04204838337292156, 0.47910994120157996, -0.017588890026610002},
    {0.6473080916227707, -0.10200260130096706, -0.3793099180823522, 0.49752168434553606, -0.024951555966545334, 0.37473961223223873, 0.9484933154218078, 0.07565049253719705, -0.23419456413840267, 0.23289089178040778, -0.2810508134247683, -0.1883714829559505, 0.7534792642921038, -0.8362551630995794, 0.37318933025024764, 0.5019289109632639, 0.05498607060364243, 0.5255659531169057, 0.14394836419508533, 0.5273746011310553, 0.19414555098130082, 0.23289336370628633, -0.5834495834495453, -0.02183411506704918, 0.026885820824107214, 0.7521294541315536, -0.05330023913415623, 0.32421796076385956, 0.05126144198761721, -0.112990702752753, -0.5345960248010716, 0.6307604223808849, 0.13753517542666527, 0.37178835166435853, 0.2262088957781659, 0.1487963584379425, 0.19667165863131017, 0.13931192390443123, 0.48238130954762176, -0.07811459669291847, 0.11035118710114247, -0.5174852252210392, 0.5447420946146287, -0.008927176993988078, 0.0703161947821659, -0.2005939793329707, -0.17103937627701477, -0.09243391924121373, 0.21558333096025387, -0.11479246838669636, 0.20670941607700624, -0.01962144138812783, 0.003980725591200424, -0.2209056553722112, 0.4080222475604483, -0.0757282768910167, 0.3565199178962174, -0.01767580776264461, -0.017784524280775264, 0.5320412220163478, -0.4414479372617703, 0.047103420985394495, -0.4520931010218468, 0.4510552133807084},
    {0.6530906241337852, -0.049689054299697305, -0.6701379512188129, -0.5373846025344876, 0.4167452923571955, 0.3170157141194149, 0.5581398236337844, 0.7242517223052019, -0.09087610243183337, 0.22974098414971483, -0.11733627746627755, 0.50283235033361, 0.42376902698115226, -0.6028207663778671, 0.2614936751568098, 0.8075487526559312, 0.611408379510185, 0.6890327702892025, 0.3855627343459731, 0.5391978342793284, -0.6716693515788061, -0.45174029221940926, 0.44591683788442127, 0.11443527747161591, 0.804535816866763, 0.41257754465674396, 0.7081119266175485, -0.09492335389906761, -0.43899149099357127, -0.16968439046899442, 0.5227447576035009, -0.6690246413600504, 0.90239360322317, 0.2232292542446738, 0.18008279544718678, 0.517991482978136, 0.6918424524001978, 0.713584321897755, 0.39460766532846725, 0.8687257944932122, 0.5073633699103005, -0.3811644186752318, 0.6995371958803152, -0.2576045909770452, 0.7664237672432517, -0.18740408405198514, 0.5040594723463786, 0.7552629285410092, 0.1718942643982525, 0.5201358154568353, 0.19891602352021567, 0.02288791668785114, 0.38535795519338717, -0.03578943626312877, 0.037604676604145106, -0.7952652762155222, 0.6514942229006305, -0.365390434600766, -0.44326138475837146, 0.13929288518795752, -0.13148919814885215, 0.3702737977641941, 0.4763171079820906, 0.6046720995235396},
    {0.8811159826967508, -0.5557807101595819, -0.3121005192583497, 0.01820905366964164, 0.38621736696203446, 0.8272684134213981, 0.790323120571481, 0.7626515724028466, 0.3995670878118074, -0.4258284997722139, 0.598602937664398, -0.4006566806842782, -0.012063826159077395, -0.7870681588437122, 0.5053609672393923, 0.6559927218628809, 0.3299228998841075, 0.7296485544740663, -0.5804665409500479, 0.6713994168193083, -0.2196316508597077, -0.05613559887778332, -0.3015172386118392, 0.4883548149222608, 0.27960739930496675, 0.5552819563453748, 0.6421698866434373, -0.00761774287328957, -0.35528147055367737, -0.43652759515340783, -0.23187310770913774, -0.15153731374394294, 0.5259683246358382, 0.08920379360720466, 0.05939952215662769, 0.2333716159321173, 0.41838244589711215, 0.8321501418926395, 0.7668800549025404, 0.40869124398761547, 0.43820797742945367, -1.1150829481293458, 1.0159284491822642, -0.08781038825636767, 0.598956327701387, -0.33907435982226825, 0.45326784807319825, 0.42213353931649866, 0.8078221207374966, 0.9205759141827001, 0.3467439601551927, -0.17496946958970153, 0.6862558051612367, 0.06373996524455612, -0.14303825733292447, -0.39722117095956566, 0.7191937650092962, -0.35581444817055025, 0.2922336504012345, -0.523672303624708, -0.1850515799575082, -0.03921176798168905, 0.43073397516700546, 0.7017794809851178},
    {0.7094404195919053, -0.41821226260281863, -0.7251684305119086, 0.004051141419362078, 0.552181822298616, 0.5327409833303338, 0.8002527466859214, 0.4264961810896074, 0.44082346573154263, -0.8687642237464761, 0.6927809850875907, -0.1558244590415655, 0.39555813760735503, -0.772731421930802, 0.3990822025498784, 0.4795686796210915, 0.3157087636171491, 0.715701408965484, -0.6951229438192527, 0.08024048269426036, -0.3621406446823697, -0.1991261995146032, 0.16922735532264616, 0.376266677810773, 0.829197049758459, 0.4806722885021994, 0.34804334481109667, -0.48343698415790454, -0.6955057698002645, -0.07983238166426733, 0.09047769797816653, -0.4437243151792031, 0.8459712079893882, 0.18744206906701655, 0.597379840976282, 0.5552568392707731, 0.4748822996734726, 0.8973697475532074, 0.6403661438568631, 0.21698948315207967, 0.94418344634024, -0.9971993220630132, 0.7091671166245258, 0.3062985187013604, 0.7674491744618818, -0.7935216102173229, 0.630974171565851, 0.37050132881774483, 0.5714388352446054, 1.0026659748598568, 0.33587580311967635, 0.4991207939711451, 0.4941617257373559, 0.37096406983462016, -0.6294326909488563, -0.44213804710285404, 0.7388406439487205, -0.640794719034396, -0.28692800672900426, -0.5524540742523855, -0.19817600452061934, 0.01939287535868558, 0.5874498272832888, 0.5253355083142989},
    {0.9710057292643982, -0.49905450569001986, -0.07074586089441741, 0.3498436528468202, 0.45068023813328445, 0.9764455252522292, 0.6860507564205502, 0.6997677218463186, 0.5062313503140422, -0.2901783681777444, 0.7442674313237534, 0.38102164009058764, 0.5594205031052061, -0.7003693832931905, 0.46520358774114534, 0.40270711335480364, 0.47967609992888577, 0.8774918375788008, -0.7354801870893778, 0.37823693082785087, -0.3347213935669935, -0.3954663465871381, 0.6884673417747748, 0.6648466014349257, 0.9153751267978898, 0.6045447775224297, 0.5459555858384546, 0.012543225332525675, -0.47671979847497176, -0.30475179817803855, 0.42333206105339716, -0.04765440724800423, 0.5145523451371646, 0.5260973024386659, 0.3660730025495351, 0.6562267637959057, 1.0408950710313165, 0.6511623726828569, 0.39580196153294245, 0.2817436498530308, 0.9248948271179972, -0.626031458661964, 0.771199987223465, 0.5849749366628388, 1.1363860988555274, -0.43855611573556463, 0.3053858925904724, 0.5233304284311651, 0.7244257845065761, 0.8171163257278842, 0.44880167686443323, 0.6074530432632174, 0.6819952082621358, 0.44676190091047385, -0.47561086935746344, -0.4638632564711807, 0.46478791262923436, -0.23390236479149074, -0.12514113150489437, -0.11607304326395795, 0.37916544554447407, 0.19618357899478195, 0.6624206744502477, 0.7119348272541399},
    {0.5615392342404107, -0.026271222229994624, -0.23285219856206055, -0.5316964434997259, 0.3606994120262117, 0.8949236942291539, 0.504850845803614, 0.5443955422376305, 0.1570863335048113, -0.5426723081374852, 0.47570277239690184, 0.20306342466752286, -0.02965345564131389, -0.7583934658692154, -0.15936552023383124, 0.4040184319831631, 0.45940445616002634, 0.26901928172501016, -0.3042014471610988, 0.1830831760626413, -0.8304762732074095, 0.09763623223602201, 0.6830943873087131, 0.48734951800606974, 0.47019714495798015, 0.4714903405108731, 0.27838188070314296, -0.7196058855619514, -0.5019549760046862, -0.22650718148204435, 0.6078168935085795, -0.9835170093161208, 0.6647619712130299, 0.561897731471734, 0.0903029724982917, 0.38755505856439726, 1.0112657196361525, 0.06199717631391039, 0.09238350426242666, 0.7135344253655393, 0.5209101150856836, -0.48080704628488347, 0.5417459415303822, 0.4317751404817053, 0.3175349424880742, -0.3242711452161286, 0.6079548977958936, 0.16293443403730967, -0.2891174704834066, 0.6607354244150722, -0.14162610218360544, 0.8016972190894595, 0.31589491603643666, 0.280652886784512, -0.6436474510488623, 0.1762442099120274, 0.30488688417480264, -0.5165953497275625, -0.6548765544572615, -0.8794018442229652, 0.8003456684110053, 0.519442583295441, 0.5545296174411269, 0.8164332546016967},
    {0.707230347498028, 0.5126995249871223, -0.0509151468006934, -0.5601584386654942, 0.7630137232455675, 0.5933650922868446, 0.3343074651780455, 0.522979869954964, 0.4917214011284243, -0.5560726775036818, 0.7064846132688386, 0.5738007660508926, 0.5461295619212195, -0.6584716713787143, 0.4814299663751981, 0.9803503351765646, 0.9283759394731692, 0.952211073638444, 0.11480439136201565, 0.6985958642653023, -0.8192040672919099, 0.48171019211217625, 0.6802943293446878, 0.7059674720002032, 0.7965370551846693, 0.7650369909489964, 0.7172984474144434, -0.6808099516363958, -0.34641485574924197, 0.05571085553453913, 0.6001697408338987, -0.785065486282191, 1.0969148057793754, -0.047056055309635, 0.9418958512220589, 0.7811302872195865, 0.7346360990580054, 0.8073434918017326, 0.5838416557426972, 0.6116197791167292, 0.6599602886680771, -0.33629258180177113, 0.8142971770288749, 0.5105137331150386, 0.6385531808931044, 0.09993060831178291, 0.8794456323168895, 0.46984349671300263, 0.22564816432667015, 0.7642592139465764, 0.4767419137047402, 0.7570731387030094, 0.7284016171082435, 0.49801040108135425, -0.34725728965345126, 0.17066081048152643, 0.9963740276890645, -0.4756750342862602, -0.199821491871492, -0.685441805804557, 0.44143594698946337, 0.6962098949427347, 0.7352696362665894, 1.1328041375125355},
    {0.6124067721130105, -0.3078571568721532, -0.5599735354335919, -0.850655332739955, 0.8087546436331708, 0.4504791966247409, 0.3234340836981573, 0.4418378576047322, -0.21647590195084843, -0.942102787753547, 0.3354042585767307, 0.5041826996073074, 0.34367981348410603, -0.8532064376023831, 0.5956013062858995, 0.7179353903535547, 0.8415915577241055, 0.7403369419734932, 0.03891089560538346, 0.9344977007594919, -0.8912054520636651, 0.19939989898601787, 0.4466070488156818, 0.4876801865973029, 0.9960889970362073, 0.5088303330358235, 1.1012311076691497, -0.7636055051793049, -0.5131706963230821, -0.4669980464196688, 0.618672142376687, -0.8916094989621207, 0.8122321239764206, 0.5846911455354219, 0.37762450937646225, 0.8762624408952294, 0.7081276154794737, 0.486061418059271, 0.29685365412564807, 0.8025424364926902, 0.41105741663804907, -0.08002799203227787, 0.6840826949793256, 0.036464676908282735, 0.4926738076107558, -0.406826438711379, 1.1162329353042209, 0.016962527864370695, -0.26410678802886156, 0.8597453538304528, 0.03494339754545718, 0.7431825440427277, 0.9506930378617389, 0.08201409211701816, -0.5825957612769866, 0.1381139542642603, 0.6622553737188973, -0.5113565928366559, -0.7374360925157426, -0.7757610524113733, 0.6925344694714989, 0.11396324650934248, 0.663553248145209, 0.9785121322221222},
    {0.7362969017924744, -0.4702787667803034, -0.3858601552229444, -0.8870528642194471, 0.6134304272299408, 0.46013351853237944, 0.5642497879621149, 0.5469894735548491, 0.27182840294950666, -0.6935913578633369, 0.3840073957798898, -0.0694279640448522, -0.644369478581284, -0.4883464936978774, 0.02476046309205057, 0.6290140551985435, 0.5646405885288938, 0.8340226792661525, -0.5724747717657372, 0.5977022053379069, -1.0091545563642383, -0.18741837984995707, 0.17590363725821465, 0.7670782477730828, 0.6667721086731122, 0.8449652497169897, 0.672138679034148, -0.5849584005240102, -1.0279181305149272, -1.1104714112452845, 0.26369253375112506, -1.180076252332304, 0.9711397855589763, -0.10454714466775138, -0.15994317902574384, 0.586995349447038, 1.0314367684049144, 0.791394563600134, 0.17941876696263181, 0.8474739873913076, 0.7298399739081638, -0.610698912957102, 0.7240897239689339, 0.7051595145961014, 0.280656481736336, -0.9144493527135156, 0.5795366539054742, 0.44558167269607435, -0.44184005691159134, 0.727516692745259, 0.148151199265165, 0.919777255433024, 0.6635425201066888, -0.20270872475925025, -0.7174155071245315, -0.8905020721698207, 0.7851167554127065, -1.0109096781000344, -0.6253827321960271, -1.1016691942718708, 0.1143360273125599, -0.22919815589665726, 0.6885944105760013, 1.0762094353020084},
    {0.08105915276873081, -0.2332297262201823, -0.16995390625418433, -0.19807293510575233, 0.624776967689137, 0.18964627688426297, 0.12981405124500126, -0.042227315644988, 0.19636186806778863, -0.11305796891379177, 0.18904800475351666, 0.402288005938549, -0.13428211147233113, -0.31309958791005127, 0.12187239979371146, 0.18922637691134225, 0.3216473345573012, 0.4690981698678649, -0.20109976005783298, -0.3972325557283128, -0.5599833284395785, 0.3446347355134509, 0.07535228279707436, 0.6099154015100153, 0.6667348465551806, 0.6218965499067175, 0.4907559444813036, -0.3091913122201781, -0.43393609364581825, -0.06671536287068922, 0.43232889896026805, -0.3776536498749542, 0.47721913908615166, -0.3356510224183187, 0.5746765384876, 0.4652692799619975, 0.4818713229717432, 0.526106143481163, -0.045034393353521815, 0.6109905996488922, 0.653599652175644, 0.10870753966337907, 0.8299705298031139, 0.10905193983831517, 0.5072318264426564, 0.19465897382898956, 0.2332206235247643, 0.6872890254049882, -0.2782105334600796, 0.07717505886995045, -0.17613381386771712, 0.4666988871230155, 0.6563786061393242, 0.06929815923772997, 0.5733639637525212, -0.10802410315913713, 0.41988612578494916, 0.12520981046391227, -0.25692985991086387, -0.4598327300892007, 0.35655410277299243, 0.40699558067927477, 0.47392169590257677, 0.8979837588490222},
    {0.8003390628503602, 0.05455484929540422, -0.22573113539267844, -0.259493366548517, 0.7607824845364038, 0.6110635555101626, 0.8856986883014211, 0.9190610065914515, 0.5881880197793165, -1.1617246400766612, 0.7429362775108914, 0.5953183143193793, 0.2923617032179766, -0.8572192587558883, 0.6542343724816811, 1.1151743518555042, 0.7171598643939382, 0.7819775061906366, -0.3642794460384757, 0.9380275388003614, -0.5092957467028257, 0.7119461133170314, 0.7782085114340633, 0.5490266274917338, 0.8285674194832421, 0.8724201253448377, 0.821896452761866, -0.48758648442351965, -0.44589269633214035, -0.1152068298452738, 0.5990253810223148, -0.5234893496600725, 0.8698539049951901, 0.04856289305494472, 0.4290281568074391, 0.692634859745709, 0.82425108240056, 0.6518713672839213, 0.7105335794582255, 0.7860253741343839, 0.6441752472012169, -0.29995118457911013, 0.9294838115164927, 0.6737257505187291, 0.8836223192052116, -0.4131160688414271, 0.7026679626461625, 0.8150099949191382, 0.17198860493895418, 0.792444728519474, 0.6920824474016097, 0.5207052317276841, 0.7210591334314511, 0.6863404237771816, -0.45558141805293095, -0.09278361762134514, 0.7182641141667472, -0.4812995287054739, -0.2919903778078815, -0.35310944075200407, -0.062047022841149775, 0.3741879849223252, 0.8133277390151432, 0.774734500692255},
    {0.6300447825553844, 0.3100530774730517, -0.02234417736128885, -0.07081557113961352, 0.6598329209064054, 0.47806190262694953, 0.6716932144616938, 0.6530289529159922, 0.5203406154860118, -0.4221835956221899, 0.5511066751106123, 0.2953540389426289, -0.34240198492366397, -0.6739360414614994, 0.12142498544540414, 0.11542853460129758, 0.6128260659234035, 0.6018577929486182, -0.49843189025053963, 0.3118635489112641, -0.41621442460506747, 0.33036731938863, -0.0808607754677342, 0.8581826387140578, 0.9200140611470745, 0.8016660333877523, 0.13464583448404804, -0.3337549200345791, -0.1722255652837836, -0.13496587960065165, -0.3473861356339691, 0.21216588754062185, 0.5371480970570792, -0.6749654366490496, 0.49788264913526337, 0.12179327070143585, 0.8229142964574396, 0.9087100959416716, 0.5330835438249178, 0.519212736102586, 0.8894964976927033, -0.4867016987132823, 0.65877924497375, 0.5391224530760957, 0.978343481594423, -0.2891944091811977, 0.6367186625758561, 0.8786184083489943, 0.5647403061493989, 0.4390470549973417, 0.5551149575429601, 0.6170456091229344, 0.5283344012314104, 0.3457230342863726, -0.3755952532446414, -0.3174735929030875, 0.9449805917792105, -0.060057708628736446, 0.10709051259524047, 0.03556349946259719, -0.3794221374119257, 0.43433477082301836, 0.41181210437149984, 1.0343635698000493},
    {-0.5591407771632949, -0.6172770454886293, -0.39269008850200077, -1.1023690803476658, 0.48361929204678433, -0.7422583823105955, -0.11620967237935029, -0.42039417627862924, -0.9526103986452178, -0.6705157379663822, -0.801463977529236, -0.9462218281706071, -0.15004261117961384, -1.0720984572508054, -0.2649905626877044, -0.4817083523847525, 0.640712299202614, -0.6907683274927221, -0.8112951274108844, 0.28805880506453363, -0.9714709372047755, -0.9232778879071479, -0.7630415757577378, -0.18372178292447686, 0.3272302054522551, -0.7644590985915368, 0.04336424809187731, -0.902810768535041, -0.8343434124033242, -0.8423295267123271, -0.600740541921576, -0.8157357042335691, -0.18117108938244342, -1.0654590156100416, -0.7444467327436555, 0.09404050806226805, 0.18884989810714187, 0.25538281255715334, -0.5620173748223114, 0.18311189336443304, 0.20666462660325208, 0.022655733756969516, 0.4987624407637125, -0.39503937341714424, -0.8165124620851446, -0.474651015880657, -0.08457118030092772, -0.7908230235069564, -0.7459443149096334, 0.4911326957791003, -0.8466188690585185, -0.4815478138112054, 0.5255772875410172, -1.0340547713046466, -0.7064318831893511, -1.0872241856830975, -0.6800405806866336, -0.9600275720563742, -1.041306160899309, -0.9049440041578882, -0.09618393070069292, -0.5895347755698259, -0.1610561806822746, -0.6969167458342581},
    {0.0181325581408353, -0.7328350132522202, -0.7915043343891721, -1.1385672754924747, 0.2661771471997928, -0.20693720181913994, 0.3422412441141139, 0.1329993883939419, -0.9153715637669232, -0.8032009417545511, -0.5148301715061184, -0.18360239563228078, -0.2757293241505475, -0.9154307621639095, 0.24548221466023332, 0.622577518934452, 0.5721049035854341, 0.1552864697598843, -0.5162506770129648, 0.6122036156559455, -0.8000538962827155, -0.5473830555116949, 0.2040126550515124, 0.11452179848427414, 0.3719749313328361, -0.39337070499967325, 0.6229661706194182, -0.4054239097743892, -0.9964540816801075, -0.6104527843671237, 0.24206278311162382, -0.7442129185314114, 0.4369982712979848, -0.34981658261993887, -0.25583706020113517, 0.9115066098404587, 0.08477454167055166, 0.13352903781214157, -0.2967315986904499, 0.41585652726882394, 0.2857864631332827, 0.34470836946433786, 0.6954085517201145, -0.44925666936695324, -0.5232436095920957, -0.48878743401455266, 0.7782573603439463, -0.27864446267449006, -0.220501089774167, 0.6702088860716409, -0.41124157096660974, 0.22168050137376177, 0.881549127055272, -0.7365857757529205, -0.2205110679612511, -1.091216282547253, 0.37792632108831337, -0.9236076731664619, -0.8303759911706112, -0.9064749745721116, 0.058488161993064454, -0.1944792281949825, 0.2786594956456005, -0.20703819083552913},
    {-0.9004502210424066, -0.2546532824194323, -0.39600117954362574, -0.7207379501792763, 0.026586503969084324, -0.7855293921103127, -0.14976666906080852, -0.4110395256715549, -0.6026794678901873, -0.6528954743374779, -0.7174718510814919, -0.4225791659826866, 0.13962879130060066, -0.3514945822016337, -0.25422074567204256, 0.1115188076797217, 0.5969261846857596, -0.9261518552259523, 0.47491480237011235, 0.5626292116005525, -0.23452525111393163, -0.27469317703593404, 0.0048892111963054, -0.037409182831112685, 0.2848757277255149, -0.6030406849267544, 0.41623582350417876, -0.03767381843201272, -0.6584455544784682, -0.8277398723918236, 0.14991820710238726, -0.5792969890969529, -0.22887479300739752, -0.511629361232915, -0.15911162112763427, 0.5840920808886861, -0.36684985891992294, -0.03836058911143507, -0.22743722845430075, -0.42300462811239337, -0.5059184934967613, 0.8739475403438494, 0.045259796525963035, 0.09101782919694346, -0.43377317819791456, -0.3106865296200393, -0.09470217885784732, -0.3931251814428803, -0.3509035783600379, 0.16509297351421848, -0.8001383602893448, 0.04482132796970951, 0.33180023243687456, -0.5418017921790375, -0.45931444814954037, -0.5019474126632154, -0.5253869698865872, -0.5162640700937311, -0.7178615768413961, -0.6820054617213198, 0.17580353553817507, -0.832249007111048, 0.13957155144335312, -0.8066300717598133},
    {-0.4877532066674108, -0.465556376482957, 0.22051871784381066, -0.5314304797778744, 0.4443925377434811, -0.5172875247662657, -0.07170894428708559, -0.5266500244901304, -0.7688256668045317, -0.32473386026067813, -0.8808734700759682, -0.6566455195186066, -0.32420509641913103, -0.10823073899259485, -0.24565841999469662, 0.5023764488787411, 0.5021073677095372, -1.0224363809964947, -0.2380726602273425, 0.42242147413858167, -0.4184260907288726, -0.03143443565736114, 0.08207226404870271, 0.4111936002436107, 0.19332337843101474, -0.6231746271521782, 0.4344877515236646, -0.5037016191323834, -0.7393711677080074, -0.8537608074238887, 0.0932620910456576, -0.5002457825650027, 0.06145356252978869, -0.5596214760986956, -0.47950164330668715, 0.27259106780206843, -0.37302095581752154, 0.604534910514558, -0.3642079394225776, -0.4354109816757127, 0.11997613749117136, 0.17837057114496938, 0.035739328128185026, -0.03728448503502528, -0.747544943157546, 0.14368052828460656, 0.46715393079190487, -0.8888058825913504, -0.7079538548718936, 0.30262823568215674, -0.7431665639877238, 0.37934489778609287, 0.12206134873711531, -0.6522004526073139, -0.47138202502793225, -0.5481281657226527, -0.042506389996120574, -0.30578849854063034, -0.7734951888462118, -0.5157193648386247, 0.9149561109295089, -0.4204751355310458, -0.19936747080418393, -0.27368849542042206},
    {0.08096328865480514, -0.791243227224058, -0.2487585341807409, -0.6068235326324989, 0.47344226929356414, -0.3710943299880589, -0.4783824239429113, 0.3096005118729869, -0.24442836985707475, -0.1206777457086894, -0.525643336434431, -0.6045144373041241, 0.004776286337478101, -0.5120352062864008, 0.3487753001896796, 0.025040399174383606, 0.2206686157545553, -0.1937559214676255, 0.000579609868941034, 0.8763774626093498, -0.4284524345772013, 0.5734975058578679, 0.26476521549540616, -0.05641616689779568, 0.24239358694829793, -0.10719396150011436, 0.4808541190383749, -0.21282607720904295, -0.42821263486731076, -0.5887732807634418, -0.007631490359116722, -0.8969875680569152, 0.38299525182868194, -0.4624814833451829, 0.02940631013233458, 0.5832618628428878, 0.38347668883234093, 0.005523138305108903, -0.7888309231736984, 0.051248118272644104, -0.5310004932257507, 0.6350131221142309, 0.20925112196066106, -0.05103604004155098, -0.1957797480346707, 0.4309852346586519, 0.27754575305834567, -0.4111482666125169, -0.1467333826872505, 0.3205328649757781, -0.3899484102680624, -0.0730057073078721, 0.3869579164499939, -0.2855116301143996, -0.04296668691892655, -0.21293776838461462, 0.1059619859673828, -0.28440979474468925, -0.7037383647523648, -0.4717689797802663, 0.005916965253868413, -0.4243770088936197, -0.07564629420179365, 0.3774471763364712},
    {-0.2906594162843114, -0.07122362884685025, 0.05503419690973818, -0.8818582928271061, 0.33110585829576306, -0.5463941984330722, -0.31846103584057783, -0.09307063415541822, -0.8960343800494337, -0.42089212641590934, -0.250735328234031, -0.24505409274223175, -0.16901986377590555, -0.2810699245664193, -0.0033212923658446, -0.37880265691590603, 0.46926998172472373, -0.23997918946826954, -0.22461015771104245, 0.36538068719210465, -0.19715622581630024, -0.1562041376762072, 0.7077801745189166, 0.006446071502619717, -0.13235563862310787, -0.5994312278337466, 0.4547407585054913, -0.42742091536276583, -0.37303848113442595, -0.8286804415387443, 0.16252966818475864, -0.4285514410784836, 0.1784540661366546, -0.6677122473040071, -0.619206407016027, 0.7854798892256224, -0.3310176645281075, -0.47985426791971036, -0.7349346179034586, 0.29059561319864424, -0.34562990911997593, 0.25598696385198305, 0.5067148972366351, -0.5064153316671771, -0.4176121153468074, 0.041128219625069296, 0.6020574942194938, -0.5345018660581886, -0.0007745894885524686, 0.40856621274016885, 0.06187340254685085, -0.360643283106502, 0.43742563651265975, -0.5263559181011873, 0.289661295968139, -0.3309687224178443, 0.17378993353819758, -0.1467979102185344, -0.7041460916607964, -0.6827040974977129, 0.4843003033781912, 0.1745508567973578, 0.24556820005228625, 0.5952079453350113},
    {-0.10207615735802161, 0.12266770233376861, 0.29484583035426093, -0.2573850977732593, 0.36120880444533743, -0.26512200566311456, -0.08077311909526325, 0.13256915840799133, -0.03864723748172489, 0.04297041137026766, -0.5050511156660914, 0.10874313882892822, 0.4532417753159301, -0.2655507744279232, -0.2723349669364896, -0.051126020717886266, 0.3033022429174811, 0.3325921128108339, -0.38866218043552897, 0.6433215725560629, -0.38242649606883866, 0.655788290921027, 0.27554591173573856, -0.04681823604240556, 1.0317929086051225, 0.06545498456072531, 0.11042838604425025, 0.25351127909698723, -0.10203787614369458, -0.650135711401068, 0.21972982402176158, 0.015140917899739075, 0.1887819021691976, -0.5808258977512252, 0.047594991226798646, 0.560774191993183, 0.2010639445021506, -0.04688033831503014, 0.1720251562743852, 0.002469090419698502, -0.5356674263295153, 0.6375438582452999, -0.2037367863969314, -0.04898512447001697, -0.5510625444927778, 0.39088600377241556, -0.17520710463206932, -0.17942035264763223, -0.052810122721438243, 0.05033741917116583, 0.1661522543352338, 0.08129340743214727, 0.21045084480691825, -0.303138706513691, 0.4918965827392264, 0.44317111893457534, 0.5322320377458064, -0.06503885705791482, -0.2448112369668842, -0.09591879025560665, 0.1330060219957958, -0.4367855991393875, 0.5067978201481192, 0.591718045785691},
    {-0.44061230852445626, -0.16539800157794424, 0.55226426172218, 0.06308663948118406, 0.1747081881222294, 0.41778586543877366, -0.0033185698887834582, 0.4090556468886215, 0.18755515136489265, -0.33549734620633015, 0.17664333473107835, -0.13142831263958396, -0.3812199825856592, -0.3649551521780623, -0.7784095429952588, 0.22007223051409186, 0.405311257816737, 0.2032245090203132, -0.7121136391307672, -0.040762896239592825, -0.4042782986907474, 0.26425292873441314, -0.07108787658271797, 0.3442721496451984, 0.10465536257136408, 0.7271953581927634, 0.11178970679645418, 0.08906386659669241, -0.5598809531729332, -0.286561177034398, -0.7163398196801455, 0.21018252903565568, 0.3223277798410932, -0.35044821270984006, -0.013662293674706909, 0.3304797625142747, 0.3019744313289569, 0.5158156073980271, -0.3514632465202188, 0.37514323835217106, -0.08583310423735481, -0.44744526586634553, 0.4327341020179741, 0.1781095097643895, 0.160655949465864, 0.3095842312116624, 0.17067171079357096, 0.07754340756983388, 0.5457459130756221, 0.06972141287245259, -0.2879890306925177, 0.6852284827570891, -0.06213852324283666, -0.2677071852880835, -0.5202831495137782, 0.07636219233702109, -0.1375129748112963, -0.22737081362911557, 0.2320049483015462, -0.10714497165216474, 0.7122161016666162, 0.19636695294518303, 0.0036167861555592186, 0.024495173418590754},
    {-0.190753218095974, -0.12485043969176153, -0.4875617352817058, -0.20544251033523753, 0.4025685737977677, 0.2710433461428728, -0.2554729515630935, 0.6393521849236701, -0.3718264026848357, -0.21988864157300997, -0.37386148877140285, -0.6874045920084364, 0.10600608649519848, -0.9740900480399172, -0.16767268725512333, 0.30619076369728127, 0.42736486709169197, 0.17893817321976194, -0.4754718292148279, 0.31149102542993407, 0.2553527801331357, 0.13841793207616493, 0.10495090852642469, -0.501809283849661, 0.4015033062437044, 0.04062652523246459, 0.36994994347152094, -0.11233977536533142, -0.4797846551861404, -0.7084315747180115, 0.20413470258756544, -0.09218993523847052, 0.2371058962777221, -0.5547380387896209, -0.17041497643612039, 0.4335899759095807, 0.1444412907704045, 0.7480896541858225, 0.09365988792460155, 0.434787962542457, 0.2577612806555156, -0.2042968244141262, -0.08196139062535117, -0.29460004637293513, 0.41436469651190716, -0.16460473091051012, 0.30569074871862645, -0.38622511982267366, 0.3683403170044075, 0.590141957837515, -0.6378371984726071, -0.1229011208045522, 0.38399742359435485, -0.22578691804488626, -0.0164511074609674, -0.6721951389959819, -0.011870157620915756, -0.5613480808617559, -0.6048724056668219, -0.6614456924101298, 0.5948461537953481, 0.033585763289849496, 0.7274521603749121, -0.07387383248085361},
    {-0.4061400666612214, -0.006522505567469076, -0.8512610955674974, -0.3680556814486338, -0.06536413368118983, -0.34558228909057354, 0.13722206301986992, 0.28064545527663126, -0.3559432647341237, -0.6274746676722194, -0.19399059861696427, -0.242343393193416, -0.39492375215378234, -0.5074551909192646, -0.38660298115836395, -0.2745656546075654, 0.5215881748458139, -0.405886962546243, -0.2636312662805134, -0.06766139615084801, 0.04378793572298702, -0.13400007761184884, -0.11778614735899551, -0.5255037213648744, -0.4888831057076578, -0.10008531127709644, 0.18333902558129406, -0.23104229271137022, -0.47897053059789074, -0.1141920366792431, -0.12131412886494242, 0.03303875805122064, -0.4079742572161785, -0.3030771160458267, -0.14449858858179265, 0.5872935285963242, -0.2764254627836508, 0.4048568899555541, -0.2146769238754925, -0.622092571723222, -0.4209195299856892, -0.24927363753275028, -0.10965006824556853, -0.21992829264652564, 0.5004847611919053, 0.10429368356920979, 0.5212950655281565, -0.7709157496763337, 0.1619614166080853, -0.4177123500437757, -0.6834862135413268, 0.09476060223304444, 0.2816522615273263, 0.5171142090967455, -0.2943695472056181, 0.039115429388905734, 0.4197454745422926, -0.15649738635643629, 0.11247072950352736, -0.29165532403752253, -0.21910534921196517, 0.45900610275660336, 0.30852008867365477, 0.013106299007501135},
    {-0.0015860530801654654, 0.5501929575640331, 0.0614011367686079, 0.12091205959040562, 0.5716318692010199, -0.0637551455366569, -0.42557454442161535, -0.5195124510485656, 0.4340011741502497, 0.15173342264866616, -0.27519404585683854, 0.9174277089130644, -0.6922847152875647, -0.12012809909073281, 0.15289940973060837, 0.030662984917205538, 0.5465057550860185, -0.3613064000453262, 0.13083305714126836, 0.15534326408226318, 0.17804562098845592, 0.32595740869652307, 0.5543791269221107, -0.06378387111034003, 0.02098948503848847, -0.1301693119640456, 0.4832147303651895, 0.15960556640306697, -0.13476245046778004, 0.0005016207549578146, -0.3372091273775209, -0.12737115677028463, 0.40927716688736093, -0.34577073996477226, 0.1833395660701318, 0.669709684260436, -0.2481716676561951, -0.20907500299240586, -0.12480789608786953, 0.028641474893066444, -0.12034862459945646, 0.05258897220314571, -0.18553354751311282, -0.2914984090910807, -0.05392121852371935, 0.23373983043955315, 0.1919971512766222, -0.009251364048707513, -0.4758466798709634, -0.5393749386767296, -0.15237727762725933, -0.029178117940201205, -0.031066770153093354, 0.3893794118976446, -0.2614925899044852, 0.04732845404949288, -0.26623149183323686, -0.16310933377968095, -0.31025849681606865, 0.04900075310078346, -0.12207013751085938, -0.5077986644447574, -0.2425652898451281, -0.03478018485273997},
    {-0.12566672748683613, 0.5363007205889488, -0.27308165299289033, -0.20331295626514778, 0.7078769858677103, -0.3748212450792004, 0.11176329175987162, 0.09671464559608683, 0.06490487916265539, 0.06474581496153592, 0.14320181944375027, -0.5290521243904307, -0.18044088753412868, 0.303099426692793, 0.5692825365778247, 0.12225669083159109, 0.10344577757631883, -0.010248355959560118, 0.047462248156105245, -0.07565231237817636, 0.12513781221632453, 0.36997385021311024, -0.20928887202301275, 0.5045633846329403, 0.1692525565412959, -0.0757634294674122, 0.24312058405242387, -0.6884090707387053, -0.1315207589895524, -0.4756287969867035, 0.14694572542867865, 0.23198447678056838, 0.49026547568317563, -0.27579092656042725, -0.30618963243188074, 0.44102314102885226, 0.433454282993304, 0.13753562360845245, -0.6185447247666763, 0.3975239858444858, 0.1329155060863875, 0.22849863471535803, 0.016093388481124585, -0.49192670579159037, 0.0931897685637168, 0.1386019694351311, 0.03342298059534066, -0.3769924322863442, -0.09914697994780135, 0.12303707865807938, -0.2727491045828731, 0.11773787839583087, 0.3793520521631167, -0.30519338660841366, 0.5051303667472493, -0.07388887926941315, -0.12116822985791628, -0.055870215870499396, 0.02046955036771499, -0.4333860573200784, 0.2654508566831415, 0.19754242690504223, 0.732375268141567, 0.25285116269930186},
    {0.1291396144049647, 0.11908551213323557, 0.16471931824174915, -0.27277185764627365, 0.294602543356281, 0.4083911076065757, 0.1893873292751329, -0.17450635207808562, 0.027971993508443156, -0.7556416459063519, 0.37217738801718375, 0.7074173456668272, -0.43949074438214486, -0.4859769036349888, 0.5000223788310582, 0.4921605683061079, 0.17220599613796234, 0.24988301032244964, 0.1459894525530112, 0.7188169441949563, 0.048396301929752195, 0.3440878361992377, -0.3060959770389067, 0.08695185012799957, 0.49114334140662774, 0.1365895297279322, 0.4649726048070412, 0.18276415051834888, -0.41140062122750354, 0.024619272041226936, -0.06564086129045639, -0.017559975877192293, 0.28829238037718297, -0.6920246687111126, 0.24264245567880355, 0.20384923247909092, 0.48069718372761094, 0.3100814302806861, 0.06729535524418763, 0.34847814048334674, 0.26918639979479075, -0.12249912136760203, 0.05132853824966285, 0.2066265409782978, 0.2855408553290384, 0.38970737436771874, 0.5414448518812964, -0.18752589008372025, 0.4121457858975611, 0.30087071884195793, 0.43195433473148953, 0.6020629149046592, 0.24190977634808464, 0.057095060454696984, -0.40596224956262605, -0.1515678179307334, -0.04001842569631173, -0.930506554269201, 0.07957692803172284, 0.050820825730280995, 0.24596465821831193, -0.6074773802890137, 0.5251125408306125, 0.311883456414342},
    {-0.18683517453224216, -0.5383567231542923, -0.5967172367031207, 0.3236248899580875, 0.26822560019023134, -0.09438346192757066, 0.4241905179059663, -0.08450250696160214, -0.017777401783409648, -0.7181777118718997, -0.1885976301107924, -0.14272954613116787, -0.3638357496686877, -0.1412753611242931, -0.4615225201528061, 0.2322120593743194, 0.5276769343832312, 0.27720417147011, -0.06868424900876678, 0.21651254912473253, 0.04214820481466023, -0.41020359157906927, -0.0008670623444806145, -0.02074606525295724, -0.20690105183831056, -0.13883763135282962, -0.02546240286787502, -0.29351792235521146, -0.3303272681789917, -0.5294109029130524, -0.1405439677965607, 0.45739634662090217, 0.50575517010214, -0.32652501990602384, -0.48444788557753754, 0.3489756098902267, 0.6185369195424997, 0.42667614280507526, 0.22374902443649183, 0.06107233614513664, 0.8195788670666173, -0.1822392969269863, 0.1495673715257007, 0.2103081868882817, 0.08307171845628086, -0.11300432583283904, 0.09797411981164625, -0.4110187770857755, 0.3849043433779232, -0.052118641819774006, -0.34870676326417954, 0.6963101202988965, 0.0921992893645258, 0.02930222274687023, -0.13502262043780233, -0.012000354198755985, 0.05697616714793929, -0.020863617494527534, -0.2703457988654752, -0.15225887010372657, -0.6945353849904224, -0.3363355102077714, 0.27435877291309796, 0.020254900421550828},
    {-0.4007795048142803, -0.15219787941029572, -0.14257970573237272, -0.3694267534042108, -0.38798488640047424, 0.21368488465836716, 0.7366553026631949, -0.11715116615285401, -0.4030365636967401, 0.25782192276613636, 0.11963595895123111, 0.3026532166561224, 0.3074690561671208, 0.10517015533359443, 0.28516446806037204, 0.6689096379339832, 0.5589835604245826, 0.05477849078373506, 0.34017445230944665, 0.42700867079522437, 0.22900200029738282, 0.6498826958889913, 0.3890755984248306, 0.4874724021561483, 0.3350960993599536, -0.15929898005000714, -0.1368769108368563, 0.4800253357924003, -0.4370034760857076, 0.03700970400269704, -0.5666297134760945, -0.02458398471122784, 0.13494682447526848, 0.2442049993168997, -0.4055371402112422, -0.3676628414750723, -0.031291607812711286, -0.5305560605794206, -0.2731558286452848, -0.05090614087153631, 0.6301700941125086, 0.4098659741207989, -0.1733411806780071, -0.47926842249462787, -0.19076212031468387, -0.08630310573205952, 0.5096196362340982, 0.440543055896095, 0.3279319012641742, -0.16880206301883963, 0.23008090714033907, 0.11352925788609189, 0.44467938759203557, 0.36290539261684357, -0.21327687881781998, 0.29024401608197564, -0.5313604709710034, -0.024117412749361983, -0.05641912588625466, -0.2608786206518669, 0.7859462526403175, 0.09096599006307206, -0.13970477923905872, -0.3827086632741967},
    {0.2383653590411136, 0.6930969492948061, -0.4479891559527326, -0.5510045611405072, 0.07216646287039664, 0.08745196452177804, 0.718055062638767, 0.9158932438376637, -0.4194354753517413, -0.4495820295036579, 0.3622676728969137, 0.2505737193046622, -0.23517120997202526, -0.6246248604358935, -0.06512785311741699, 0.8407907058581625, 0.5823975041922023, 0.3344469197854676, -0.02912554644660583, -0.17604261902670063, -0.0936095627616937, 0.05987825910702387, 0.275511171938144, -0.050471732542785135, 0.5320186662969641, 0.06336973817404641, 0.2475064517800968, -0.4232074136623067, -0.5458258817131361, 0.3491193629648598, -0.011989039360513674, -0.38579848640061076, 0.6994200027505401, -0.0384559041903199, -0.22518040062657205, 0.07084794201877247, 0.10587043032800854, 0.1744838956824806, 0.3106512816468271, 0.12578051699626677, -0.06406835880024087, 0.7114683255542964, -0.18885671435260012, -0.10089566630322193, 0.3129737206026724, -0.4344370916872088, 0.8378215142465112, -0.0023904780324116807, -0.1949961779085717, -0.270832244604864, 0.37072246349442156, -0.03801713977193658, -0.15861566885128073, 0.115537968122348, -0.3816173965006913, 0.4304069902529661, 0.042839062693327094, -0.7795727211203036, -0.11776639913896587, -0.02174405772985044, 0.23759035220888866, 0.15668407849030086, 0.07653021563800806, -0.029004766791766598},
    {0.371604998648041, -0.309130006662503, 0.8236051030081142, -0.3328084739599253, 0.3383461670224158, 0.006547050400084854, 0.3786790552199441, 0.582110153453025, -0.29484817064393465, 0.06625559438215975, 0.12662392357052468, 0.3761475822950392, 0.27797074658589926, 0.08502041027586686, 0.055572592027741924, 0.42738429653807897, -0.1795232379217321, -0.3056409435190819, 0.3515468340706922, -0.5508137075097902, -0.27025491785468264, -0.7223593656625868, 0.5555911410101567, -0.21448763576399119, 0.5896151710711195, -0.6457131963792477, 0.4309460389153792, 0.4482948809077887, 0.24299517819386038, -0.08042043636029245, 0.3632741281129941, -0.17435902440067072, 0.425547853270449, 0.1200314486683512, 0.17721052801971227, 0.34121316813584607, 0.33564085702837776, -0.92813370787863, -0.4213421141310888, 0.3519798031014961, -0.17125258614171063, 0.6967867664982602, 0.12132732108825749, -0.19565570242340974, -0.21210221373645294, -0.3592658502321365, 0.7478798378549258, -0.03434040628298219, -0.05026827684638637, 0.5841021837816865, 0.3187559971779276, -0.11134180362054523, 0.39658948723049353, 0.23228075339392013, -0.0351371409251653, 0.0595408205987558, 0.10004259610209412, -0.06864190475298934, 0.4721766184897988, -0.5674753366630994, 0.35969619125003344, 0.2221761076838409, -0.15609293568742091, 0.15337150905162691},
    {-0.09514870311159046, 0.4035520605117708, 0.4881674286926094, -0.35214293108667766, 0.09243318540318955, -0.535803895914126, -0.610098539458522, -0.3524208152742383, -0.49410775088514436, 0.2367613517966445, -0.4692505702906302, -0.12559859156745493, 0.30749444660411573, -0.016921652543755633, 0.209625873458829, 0.5471910960972421, 0.33121791523028604, 0.2537370622072499, 0.8655981715259117, -0.8316346783062102, 0.42114317391465206, -0.5608875676709707, 0.0721815743028398, 0.13003154709353093, 0.13978251736176273, -0.647035623997102, 0.28369818901933885, 0.0024422848895167917, -0.19781186568705778, -0.5464652732170165, 0.3561421346604311, 0.1334398861908986, -0.4707845378932383, 0.09043692528254307, -0.4250357833135546, 0.7049011625050594, 0.002695444487740052, -0.7475549184324958, -0.31097701779825243, -0.4787776082354, -0.04587885944966448, 0.05656774938325177, -0.29298152828590024, 0.36758906503520633, -0.7981274638130863, 0.32679569046173795, 0.04336918206736497, 0.2643379300217634, 0.4279339727872132, -0.26915755835028893, -0.4759441903856027, -0.5075116721384318, 0.4153900368212112, 0.4407336875217443, 0.38477018122337625, 0.6067705739830606, -0.06370458628803491, 0.18970495171824012, 0.10439839099916737, -0.503592617602928, 0.18835689994931526, -0.317772244250312, 0.03891690586846449, 0.3402497067916149},
    {-0.10360968506943477, 0.22030210600748887, 0.1477629160581022, -0.37716605597496256, 0.37394020523076893, -0.09084500759763418, -0.062239434965939706, -0.37515499694331617, 0.2555332056120342, 0.12689947869404578, -0.39833885109721545, 0.47873545846229426, 0.01957286602669934, 0.2824857815389246, -0.11721887349701586, 0.5271889149480241, -0.22884020612634182, -0.09084305530372086, 0.2054406955775883, 0.18867098096684104, 0.5795745806690848, 0.4549762701451012, 0.6228021371254446, -0.016938048972490037, 0.5034672394309088, -0.4164908258938071, 0.22084126661103776, 0.5435732181561514, -0.057668768696666504, 0.15842615863643655, -0.19424146347163782, 0.5599072545044578, -0.2986479756359156, -0.496948501072085, -0.4342149840842299, -0.16062931292288146, -0.4318764953615465, 0.04584485475317672, -0.18551016857033953, -0.4035040592011898, -0.28034923594410055, 0.27181927423503616, -0.8138510227629618, 0.07829460772324899, 0.21436322852521275, 0.2868544889331873, 0.18801874183295486, -0.2126355434533793, 0.07393783470541183, -0.560372550482934, -0.07825290783960266, 0.3735124912832155, 0.36538623654730606, 0.1366490024668203, -0.2986771078053891, 0.21939242572196227, -0.4510987127727294, -0.11410469324908488, -0.11420247609186926, 0.08601891828061001, 0.08639934183295092, 0.242310736827433, 0.33140012168017735, -0.5154406781099238},
    {0.32427015179689717, 0.15540830078934523, 0.30335806969837004, -0.004444315047900303, 0.8315348509996001, -0.27471226972012974, 0.1871843798651851, -0.5931676241427032, -0.4857229353759777, 0.4961406463500479, -0.37203578099524576, 0.35751637609220954, -0.7899725174636945, 0.3070433154397751, 0.22693482817634258, -0.14303954183348533, -0.3477929053870233, -0.151337820596677, -0.09014929672421391, -0.24741643760412074, 0.11009054140781546, -0.45974395227969234, 0.45788482221157495, 0.055321034859394165, -0.2638163456284955, 0.2627836407288385, 0.034398473381023885, 0.4404030755649407, 0.273956849233038, -0.018630567112855028, -0.028866872444106597, -0.13973462009316265, -0.34003768396273976, -0.35192729293665237, -0.005867141366134001, 0.3274095032439834, -0.7334122379672576, -0.4826526276548218, -0.0707822682325971, 0.25407677546994684, -0.1364581540531957, 0.22630197166755062, -0.3430083575146791, -0.887540351050475, -0.1375147015659773, 0.09558412629261939, 0.23097223265354297, -0.27505514727753216, -0.19550872123785004, -0.31946835715650207, -0.21066017659043504, -0.08594330803075874, 0.3108608036168035, -0.14801697476287595, -0.07586012715879709, 0.019220058581993087, 0.23697830666732406, 0.4803859002613822, 0.5123416030369111, 0.05538478590274321, 0.35155900451692607, 0.5330133722400456, -0.05737840567849574, 0.011286950058470788},
    {-0.17125171855815013, 0.17702633090989678, 0.18669819330909673, -0.07653299558823391, 0.3199627887717003, 0.2798915225868325, -0.05104593023475628, -0.20361622560881987, -0.1235282944587505, 0.38917110061947685, -0.14972182726231723, 0.06284208728556816, 0.3950342654666214, 0.3346794434431273, 0.44364183507299887, -0.23924609465377292, -0.2565899735644766, 0.049105936762699406, -0.08683262134077421, 0.3106181455500538, 0.3208702436702993, -0.655968316415595, 0.4399510186347935, -0.37240639046888596, -0.08421939151641618, -0.17713241422193657, 0.46416503841773316, 0.5341828705513337, 0.4693136648694745, -0.5142435251092646, 0.2072423757553313, -0.16954024103819365, -0.16733807640097415, 0.2946309699419078, 0.4148107352376577, 0.35247955386691804, -0.324882962620923, -0.38639560410094026, -0.22595665643040258, 0.6592802604364717, -0.4288559516892297, 0.08278519824939831, -0.0896407204946805, -0.09645095281055012, -0.2494901054292577, 0.2367307141289033, 0.5120211512160754, -0.04828511615526312, -0.14561487004692847, -0.5714793795549084, 0.039037464847453955, -0.38374976492579366, 0.339639179720399, 0.07926095150769989, -0.15117328057089988, -0.2439814473321632, -0.1853543263666977, 0.29322267545260966, 0.36630159991157585, 0.16687226013580334, -0.06259501511625906, 0.034670646901489396, -0.6561118356800918, 0.28564408822057624},
    {-0.45083598968151983, 0.022743285901220867, 0.6347016108723466, -0.2888135330062521, 0.44061384458983305, 0.17944952462432795, 0.4558472464650911, 0.5682679449235855, -0.5521334015010431, 0.6399970918932278, -0.22981399509738384, 0.2567984257951402, -0.2740814532613591, -0.21264763771644488, -0.3990363972333135, -0.23827646822230122, 0.5956445476242413, -0.3513000907679851, 0.2218249864176845, -0.07825788466328876, 0.33294016251279984, 0.25873470394465986, 0.21675660605629113, 0.6815509629620998, 0.22999490742330608, 0.3225441617848257, -0.051785514233156395, 0.5040573331145486, 0.24453891955967066, 0.18980244021579562, 0.4890800715064925, 0.08616964948309044, -0.6691773789263984, 0.5855191518571073, -0.17678355835145637, 0.2253409929169017, -0.03583163543691453, -0.29258368686335895, 0.46198378599661655, -0.4090482492462866, 0.48407748575146275, 0.7482452914063109, 0.11664069694341514, -0.021736687877454395, 0.024176227355316226, 0.8260685804768018, 0.08758054162239941, 0.08913966269377074, 0.09135211341441572, -0.35174304233659043, 0.17155134384360624, -0.41949840468088206, -0.012933751637648367, -0.666881438674313, 0.7654054378028872, 0.3177701122677486, 0.01297622262096251, 0.3551761281408268, 0.295271436998041, 0.3609921866244041, 0.08555043097631729, 0.6430529121710216, 0.13975491998964965, -0.2051508578207267},
    {0.15507186220061828, -0.20456367418764076, -0.2077695019317217, 0.17138055773779484, 0.06926319732210556, -0.16948151931944144, 0.14138290761900169, 0.08499090597961637, -0.31332576546569774, 0.4699089546637269, -0.6176315587378985, 0.19954820107408125, 0.4173936012940111, 0.5753485737029339, -0.06008291342185603, 0.5589665975323609, 0.2690016948547209, 0.2094505216820918, -0.4538699195725036, 0.4242157348501977, -0.09337933528432484, -0.40090422188813307, 0.4155513875084523, -0.15615193312065462, 0.5050154608534365, -0.20029882080024758, 0.6246330342667196, 0.24965036183384412, -0.2016396878891108, -0.06455474710238777, 0.7560395231576481, 0.025445382164430257, 0.10308776185867527, 0.20230982003511935, -0.35848107207049185, 0.04788814918019337, 0.28719840479034814, 0.1668984066209334, -0.04666780106071831, -0.02579880444224762, 0.23268157958194788, 0.08854223112530629, -0.029889400396918276, -0.24765231475156949, 0.0910314403308831, 0.5517919554547582, 0.09927599178410118, 0.4972611088122967, 0.37390174296167744, 0.36830195966040147, 0.10664097692410227, -0.4958925431709937, 0.3104776129564582, 0.2140795987742211, 0.021580688412049118, -0.014654841251084, 0.444698475885084, 0.31808060639140223, -0.4345938441252763, 0.23673835634495566, -0.11219747623404207, 0.6146235157545189, -0.05558537680397091, -0.7240848309835513},
    {0.3181905759813281, 0.6283084112089063, 0.37042467044871896, 0.22376950696462858, -0.15992020312332894, 0.41175791919283455, -0.17738825771181277, 0.08211506322647216, 0.20888174999861708, -0.40662439044404813, 0.3059071315289018, 0.5201621422047894, 0.6277796402650063, -0.055849525610210504, 0.2247602553620152, 0.01838166469345439, 0.06327991302730342, 0.2999480618590765, -0.6047839061835598, 0.38977589371110244, 0.5660773591112447, 0.7014210590164384, 0.2871599111035726, 0.0878379643826764, 0.22338673833585082, -0.3133121182310812, -0.07796274394716504, 0.15549500043106584, 0.31068372247650805, -0.10941663580679373, 0.1440611171594533, 0.25999954495218774, -0.04234827547914918, 0.2557968947970806, -0.142103462830834, 0.3841447703507228, 0.6526815458637969, 0.12007250885358427, -0.10022089091238014, 0.19037640116662446, 0.5328087568681464, 0.24013708983257046, -0.4658527221420171, 0.3688068820834872, -0.1931523389434547, -0.7835221147046271, 0.1738394482796144, -0.18545929114441348, 0.8064537937318508, -0.14052360334605946, 0.5450386759453336, 0.15400317147296566, -0.03890682866981995, 0.36992813901855337, 0.22308504763839077, -0.3697433406585291, 0.18762051935213456, -0.4285955999981801, -0.2637946893059416, 0.35646975258775976, 0.5489911317977577, -0.15443590129945334, 0.38312462622407095, 0.26422594390774834},
    {0.33408053671750654, -0.0894460454854754, 0.4455148130565589, 0.28650074760188937, -0.4740318806225072, 0.3131955369846417, 0.5608480860222844, 0.5038756886674807, -0.3228246150818955, 0.1700439699548956, 0.12135902437719995, -0.1936649475941333, 0.4161398889774293, -0.23926264309284456, 0.026505912669984862, 0.2827312407932144, -0.1430016176662084, 0.3893593238255786, -0.6231487754777145, 0.014529282947722027, -0.07692321315850986, -0.04854862125809046, 0.09052481707543628, -0.2256253032675811, -0.25996524649436215, 0.10040727881944289, -0.026312119737815425, 0.03946110417632513, 0.07331909885557207, -0.5563254554352195, 0.09601728224927567, 0.07107607899425478, -0.5760943717203881, -0.06667303949123443, 0.47914374574978785, 0.35126977455727426, -0.15764270214334106, -0.32334231481951137, 0.24863550413845426, -0.6027701872153721, -0.09249947123028834, -0.4936721911855736, 0.3214274270503577, 0.25197514895075634, 0.056320417046669256, 0.0675197341914113, 0.01854496346264389, 0.19187923866434436, -0.14883450776503832, 0.40882251409776904, 0.04967980166854826, -0.3117857112745489, 0.5189312951596262, 0.42722131100446076, -0.39410003255112325, -0.40170094935225653, 0.053222094242632266, -0.1484007948236378, 0.06089878354893937, 0.43269516193077556, -0.38179610025494765, -0.08696745595905399, 0.05023036293724885, -0.10972334151977015},
    {0.09444900512361601, -0.40888752674080786, 0.038252691360385525, -0.0862676033428203, 0.12725851522362513, 0.1842153224991934, 0.28804345434870166, -0.03757998334379544, -0.3738337297742373, -0.626737048867399, 0.29634741605047216, 0.4989533352455559, 0.21358669429409324, 0.015236778327936436, 0.3248319287163317, 0.2430650907703091, -0.006311171053813144, -0.3767461047055429, -0.3866118533649674, -0.18582876087645112, 0.33181517911850805, 0.4869028479435681, 0.23663091730542732, 0.2833079740621858, 0.295521529795743, -0.3812670394626278, 0.6171484499896199, -0.16833856324981206, -0.16241367560870312, -0.03183618610274458, 0.5537325302376563, 0.07586950423095412, 0.10293648772486813, 0.5675127531138864, -0.023650339747596005, 0.07050446387774, 0.08228694284627655, -0.010401635837245468, -0.19134379634391155, 0.0011729855080095661, -0.2635718891880383, 0.4445714506783407, -0.019873105621128425, -0.022425690339560357, 0.07616573044307257, -0.2058839138658085, -0.22629233360064255, 0.23706927251732546, 0.5262799453213292, -0.22786064095897335, 0.08523484718748171, 0.7218853140209042, 0.19102784889639887, 0.623392908606043, 0.18016895069113623, -0.07189785134492128, 0.005652423177253312, 0.038840149084361314, 0.30902319456548766, -0.360104370453356, -0.4816693223577064, 0.7026803442660201, 0.884402460317589, 0.003432686706048479},
    {-0.06032243264393758, -0.3091269193479798, -0.5483282740181098, -0.0687081844365361, 0.07379408488157103, -0.056049452766125, 0.43577417997003515, 0.9025834568307322, -0.11773830844139847, 0.06537496348345016, 0.010667295681138727, 0.16621531485317168, 0.395773641360257, 0.1552154987659905, 0.731385865946381, 0.034149355698668976, 0.34761311729391453, 0.42583570587175545, -0.6052677869671614, 0.46404872649882145, -0.33004790202028744, 0.14483601768360355, 0.2603256637017304, -0.1199979242311305, -0.28106184220054947, 0.02715787727715372, -0.05084627027293521, -0.4602163835508835, -0.34493448429014484, 0.048352518596139385, 0.11692620207038085, -0.043881565614615946, 0.47613513295657184, 0.11557225666678707, 0.276426438633401, 0.2573669184149171, 0.39486760856730313, 0.7291505595192992, 0.03489693924840711, 0.3309144818623761, -0.04079676719102729, -0.08264524936718931, 0.36086288977415676, 0.6624786228907618, -0.05470877642377559, -0.602889640856283, 0.2881708355459325, -0.48570073747728054, -0.18435594626622526, 0.4172989596720767, -0.0439465781420496, 0.2302339451047774, 0.06672798713953404, -0.15513075550950747, -0.4285075422731237, -0.2541534783190783, 0.22386252604482523, -0.10869977648478249, -0.1163463429044142, 0.2800594808857337, 0.23241982030548317, 0.2986103622686293, 0.2677592869436672, 0.4409551548732703},
    {0.5235149744701162, 0.44540785299989905, -0.31567902899822725, -0.05375110848299655, 0.018496445888153634, 0.4057288355216433, 0.3820273097884292, 0.2917584420492262, 0.264123477821208, -0.22719407377036369, -0.059566694752484224, 0.4332646417864944, 0.2938271225283217, -0.35331327009876856, -0.19362180756519598, 0.26332741518456204, -0.1023976727435511, 0.831471518814842, 0.2901224608266009, 0.18169078634118263, -0.18894003591713693, 0.03910589994449579, 0.6277205185492466, 0.47061720000448765, 0.2517363066622811, 0.42399257201597745, 0.6061964323337701, -0.02826893506777531, -0.33563307131187187, -0.0832982671551486, 0.6908880872876915, -0.4495525807014379, 0.39668086755451865, -0.07904562202882136, -0.056788582628767376, 0.20070631619719778, 0.44323491441760976, 0.11822537133404194, -0.38121200538144373, 0.02973660792022904, 0.03349814671760673, -0.07535132654760471, 0.5757798065380872, -0.6937365611492988, 0.09827612526921586, -0.6033969733342956, 0.4359715472203066, -0.060461068012285075, -0.20621762472116595, 0.14075842287845508, 0.6273190219525802, 0.6377240447309597, 0.5571063373900739, -0.11569386605340812, -0.32228079489622036, -0.7389124494347117, 0.087528110375533, -0.016087075192285676, -0.09299422953226014, -0.38868950901510235, -0.07676065280559864, -0.06691321491169204, 0.3907759892297027, 0.555500367666733},
    {0.15166011284440495, 0.24173682812441996, 0.05627292681936184, -0.5564441195814798, 0.17451008867647613, 0.594286318108003, 0.6729292284798554, -0.02786016197037662, -0.5962464625246424, -0.256431537721657, 0.3305865912749506, 0.021747231267654345, 0.0985387528715085, -0.7814979358141684, 0.0993134939113406, 0.4130557374690214, 0.6396231055879487, 0.28613691288667764, 0.29715354259912946, 0.44769295694499966, -0.3939168209351581, 0.2553096908130241, 0.19146139408902774, 0.5669796685882428, 0.495780451519498, 0.08561353031266451, 0.1367690772467482, 0.06283217127152405, -0.17169674641085983, -0.0032446154865685573, 0.28609784073516836, -0.028774880241957172, 0.4778368652984202, 0.3867153602094477, 0.07237377947641363, -0.32189678527374743, 0.758695415672992, 0.2980046319117305, 0.0081278658879904, 0.35138948814286486, 0.19998471971431306, -0.24030649161833206, 0.2221908203125879, -0.4761738462051726, 0.4082713840605324, 0.4017025568574908, 0.009736242742082759, -0.21283816549130796, 0.5134103483267237, 0.3047751603988959, -0.04099289313177929, -0.27701391404251163, 0.37914505368906914, 0.17911313393862552, -0.40508783001699, -0.04574081854536125, 0.19647791473581652, -0.40322056527620276, -0.5390173879480683, 0.047565206884433, -0.2126510284580337, 0.1994379174616486, 0.7114205976731092, 0.5607133970896288},
    {0.5480122492207172, 0.11727220143781114, -0.10374177897110028, -0.19825860835599313, 0.5667357117606255, 0.07395846582005564, 0.5194498612708048, -0.21929856257042057, -0.3013307401751948, -0.18256937319202907, 0.16489780231631396, 0.4712358949997412, 0.7801980135941288, -0.31484443137287393, 0.6848377018043676, 0.7089905649100708, 0.1758056634081665, 0.14588898377301093, 0.022107331343221463, 0.2440220173790168, 0.28738307000447966, -0.17719783737623235, 0.43194550848013613, -0.04592810659113647, -0.4867366805539719, -0.40087773879335, 0.2868128918658009, 0.07834129785918319, -0.12548892650391597, -0.26109849754416453, 0.3841839023502244, 0.22587291661269307, 0.22807363105085318, -0.3009802927357496, -0.012335668072935487, -0.047968088706195074, 0.4870135249329495, 0.338650412962246, 0.9634739704160448, 0.5671881196451669, 0.13105203234596668, -0.41482013144791385, -0.02005389572055713, 0.6681643277384451, 0.5016764243461856, 0.058787048531065915, 0.49211677708281265, 0.4604350073402233, 0.28516819493109946, 0.14222979035639202, 0.32206175708222057, 0.5208894741377422, 0.2021683412050384, 0.401520698105322, 0.33050368102480276, -0.1780807319644341, 0.6305730675612741, -0.11419469614670827, 0.103811570743731, -0.377590943224278, -0.01892944108493298, -0.21964818967945096, 0.3127115613688143, -0.20972650182124197},
    {0.4141295518858557, 0.008783100315244674, 0.1614693748123541, 0.14120425337990933, 0.007106874518020851, 0.10663623104951951, 0.010037343419671645, 0.2497111172263407, 0.4181649484721881, 0.06808786325747808, 0.3745763431111024, 0.03967574888632855, -0.3868980510202584, 0.15879725244752765, 0.15017329059459228, -0.34921460884972905, -0.14300333059659046, 0.22182922732484195, 0.3484017126206119, -0.28387093294360666, 0.20700583597876512, 0.14451865662585978, -0.32850421895699605, -0.3577396492609342, -0.47168472840674763, 0.25274886246691197, -0.41891747102722665, 0.311530466168203, 0.6265176240874172, 0.428068835304377, 0.4504424572724921, -0.12974925545154256, 0.4604188888706834, 0.17827932584269543, 0.35784826768568273, -0.20604499281529318, -0.4167038260756242, -0.21671086793138425, 0.019670487030172806, 0.5207716739764925, -0.3041249461239654, -0.2891495057187726, -0.2912234593511282, -0.069471720613418, -0.06389028566804912, 0.10448517718739322, 0.4332765962433485, 0.3639732501470582, -0.32413133631705016, -0.5132510021040227, -0.03959616329778717, 0.23633115809973634, -0.3046654277368025, 0.24731522960860966, -0.08898000445107342, 0.4303375813735515, 0.20938749403109091, -0.05025508837925104, -0.1483549200553569, -0.19262333693551853, -0.31987721412374404, 0.2568619201960687, 0.14372882126625663, 0.3122981833987209},
    {-0.13271331367482705, 0.10691790601373648, 0.10086699599022153, 0.2653352035617431, -0.050967612483002134, -0.13744083489750902, 0.20582870024070787, -0.32990394097890163, -0.04953737456791119, 0.10812763171738751, -0.0028467730790979373, -0.14782977588317714, -0.14441704309365883, 0.10696501736105342, -0.31298268845020455, -0.030813306395138216, 0.003715775045102842, 0.236514673460201, -0.6266519351291032, -0.02629555846181758, 0.3809875016096732, 0.39429008239081814, 0.130134133586417, -0.3425063140706046, -0.21222298292848193, 0.06255827011791229, 0.31837108513555173, 0.47358970531413896, 0.1740412171788887, -0.3626899759386018, -0.13688735091290946, -0.36339465152003975, -0.19733408185107054, 0.1823461307986841, 0.47554892141564503, -0.3320807794772486, -0.3476737016882358, -0.25726129258474306, 0.5829637256789243, 0.06276649653834876, -0.04098049890980566, 0.4378440360125679, 0.2792240128782321, 0.43036584744758016, 0.017151645033157418, -0.12359167598652437, -0.07626088049418452, 0.4396054609878583, 0.5248230562996025, -0.2184715045292727, 0.49489484918035453, 0.008874759208408661, 0.053167161417666794, -0.7293119633383541, -0.09367145917167259, -0.20480876929768735, -0.28927025169537424, -0.09618030804527833, 0.8752815998337072, -0.24834922122856776, -0.04050435914455468, 0.14585383289382323, 0.3062885986647471, 0.3077592561082732},
    {-0.30482831669774385, 0.3000820854444044, -0.025413351585510228, 0.03520980789281904, 0.0608163300997291, -0.16032728550686323, 0.37608510265567746, 0.04950173735011281, -0.22146835696546052, -0.003467787267779121, -0.174395684245859, 0.31359598177715947, 0.030705928919131827, -0.07699792609218903, 0.025275486373110057, -0.28722832259577635, -0.18285214947409364, -0.29198626979760295, -0.2639308562770051, 0.0004851479053704648, 0.1811008836640653, 0.01161125464881075, 0.25489940814423495, 0.022998734313089183, 0.005581667742303155, 0.08010574500127599, 0.05184538701483338, 0.11900381672447202, -0.5393288271175966, -0.2709352718666197, -0.24500779239938952, -0.03935982085736643, -0.17678592815283684, 0.12873251622794518, 0.19543711380172385, -0.33786507545695815, 0.17321630547971317, 0.23287736310890855, 0.3539930997190877, -0.287182310912314, 0.06689459127111272, -0.06683624847416274, 0.33784758564939654, 0.3505142482277851, 0.5821922755757802, 0.06517617103599219, -0.29611153914763716, -0.15065028981602352, 0.44755644672322586, 0.30813082315902923, 0.16608979923717776, -0.1978200667312473, 0.019639359347943416, -0.05065038063022232, -0.13259994281163068, -0.5298817451352074, 0.48951871536685176, -0.15719502603935037, 0.239443229652578, 0.01308660415096523, 0.6302373222932903, -0.21648550189750881, 0.7886409562461074, -0.37095257205258264},
    {-0.12350187978271049, -0.062238354359607125, -0.5589495021430799, -0.22110135639726006, 0.10743833983638547, -0.35882878266419754, -0.10463439778439029, 0.07080433310667543, -0.04483953239378815, 0.2738012800277099, -0.31324875372249106, 0.08564097214337245, -0.13584828048568282, -0.019519818423853183, 0.31112217623395494, 0.35820903497571943, 0.1203165025574474, -0.1181678564870642, -0.297376843191594, -0.029823216141341282, -0.15557000655852896, -0.05519894093239974, -0.1486609786641236, 0.3455257509754929, -0.2892196758130671, 0.020942512547427874, 0.08866094438146638, -0.07614354763606355, -0.05774615549040834, -0.1832270798126674, -0.2842817676822965, 0.178336478987282, -0.4458081509240513, -0.29261580994537584, -0.13715810516199348, 0.5331917163399532, 0.6490070389284028, 0.19920970514782194, -0.1497653062324052, -0.20668600764322914, 0.31741303991421066, -0.07970359620268458, -0.18434039522664236, 0.09756201148875578, -0.28337745542431547, -0.32804217457845364, 0.2222443897479615, 0.07530460633709819, 0.24601989799833704, -0.031854993549634204, 0.018575491017313678, 0.4715105426211034, -0.03309836599689664, -0.19355332844878614, 0.2685518742226113, -0.19481793102273953, 0.5302206451781767, -0.1891348892746345, 0.11187619163474032, 0.0405794999606435, 0.41886799292141036, -0.5749747495811867, -0.14764949311825187, -0.1587835506691799},
    {-0.14973304765035178, -0.5331380480117212, 0.08978439147139322, -0.48074531334895015, -0.08590437555495618, -0.4433403850545257, -0.3581491081509749, -0.21421350130618327, 0.33788425464818655, -0.3392411541836762, -0.35380730346132844, 0.15230180189905287, 0.3661274418090216, -0.2570290177177902, 0.36448635809270985, 0.13526722103362057, -0.10159230367488561, 0.1559911071908979, 0.05206047610752292, -0.35207598939715995, -0.10269312437821744, -0.4670355610969652, -0.32839376816226085, 0.37875730418630327, -0.4123238911124212, -0.6051260505685924, 0.12422996049614064, -0.38612042342823916, -0.05960316589756697, -0.04865233888713977, 0.0393587317026614, 0.12439640239798028, 0.17684526621143057, -0.1951705765141923, -0.4648676347316722, 0.36070440614106597, 0.005556873993135509, -0.1856570306525683, -0.16396851448579966, -0.20333491194819922, 0.2863515149470022, -0.032062256454853354, -0.25897699870501223, -0.11893600202102307, -0.35946681613031506, -0.17091504007087188, -0.45335992632332733, -0.6782135910192374, 0.1430913098807895, -0.6193333456869476, -0.2905681859586447, 0.005348838706590669, -0.39939015335784367, 0.08866472982630812, 0.2244951681624417, -0.059012813202286594, 0.20029340655605632, -0.16442884223040788, 0.2319859553712448, -0.11826299540263378, -0.2857483783452413, -0.4188666540146366, 0.1561991989709798, -0.25481594152636905},
    {0.052882171813625825, -0.1296917724020747, -0.12912457573634362, 0.08712839142588702, -0.19608745357932278, 0.00023788808013558158, -0.0578945338263312, 0.4149794637388193, -0.5086004975600925, 0.18039029247305505, -0.06559139338740753, 0.1761417608009174, 0.10970669219295834, 0.11982243570856808, -0.30967679705632184, 0.2549767893177653, 0.29296483071762075, -0.009356289191688653, 0.4575413064733907, 0.15638266336441595, 0.47704502894205714, -0.1434833877758183, -0.5730488664208211, 0.4077352617255707, 0.679833402093537, -0.4153534658252459, 0.3309055080626895, -0.1519272343394171, 0.3320072068701643, 0.03409864207979519, -0.43058957380510016, 0.31624442264251795, -0.38295934652344854, -0.5624494563336064, -0.13528989675101694, -0.18787618608933035, 0.2432753004229207, 0.1629326057364007, 0.34013770207463573, 0.11868981105648978, -0.07875321247852099, 0.44926242989623916, -0.16538797868988475, -0.04193965096902413, -0.166869659819845, 0.05558446111783809, -0.19492755213520596, 0.21887938457480766, 0.6744278089411538, -0.6099518469845752, 0.10789594908276966, -0.4378026967034899, -0.005107125773745093, 0.3678807935131391, 0.016311586830947137, 0.01857141010691307, -0.26699856664155686, 0.11533419647064934, 0.3456876811943169, -0.06751952722775369, -0.081247049195378, 0.34223073523548403, 0.03574744297162383, 0.08431501556565309},
    {0.2974278116871408, -0.6465067460604191, 0.31041704947696375, -0.052879452436876064, 0.0680548327163021, 0.352063856802164, 0.31539642777541427, 0.21349448592520592, -0.5948919921927674, 0.025926090172104337, -0.3215153354578462, 0.4874045442206249, 0.20292929820749797, -0.13305668003507579, -0.4428517962354779, 0.2671303809482821, 0.2785702901561002, 0.2304662681389386, 0.05728082746435301, 0.5365971931843256, 0.03718207936232355, 0.20188665077771398, 0.7657100033225017, 0.212050048046243, 0.5127017957367657, -0.22915736824982855, 0.43922730079135025, 0.16418218699165577, 0.011593360811005354, 0.45985488207162617, -0.47826382263830997, 0.17066072148885394, 0.24588928105519683, -0.23146722426318167, -0.2756265730339733, 0.05297033168226611, 0.6249023676146233, 0.15810558014231343, 0.10009275353815404, -0.5703452090686879, -0.38227693139799584, 0.354699278400016, -0.10632241873100659, 0.14194690420374576, -0.2950056257179403, 0.19588789420787156, -0.0472101682864626, -0.10704196407796586, 0.22258412731263322, 0.31381056463682566, 0.30597808216369926, -0.1176277037127026, 0.23554048100473676, 0.1324924142601159, -0.4023719355826782, -0.13636100012746474, -0.6184718463279828, 0.05025119437384015, 0.3314317136577978, -0.017768744451402585, 0.11669797553036068, 0.6942318187338216, -0.4669666244253616, 0.24614555078486097},
    {0.343397976945015, -0.3665132921668644, 0.16278486208788528, -0.32108017398066724, -0.1819306833814123, 0.07097205721462993, -0.46798071544477227, 0.689364915654029, -0.5473892488829718, -0.47250218107190134, 0.19358898566552943, 0.3328887943605592, 0.39630748307306485, -0.23228921427768467, -0.29154130665782707, -0.06548495988914838, 0.09214735502220427, 0.18557256960729612, 0.008018252522572076, -0.4050904380254795, -0.11901207820381964, 0.06943747671171677, 0.5434264684457556, -0.6102904314824104, 0.30390085781338017, 0.019147707893824892, 0.07271683444604575, -0.08779269777311413, -0.4152595649526738, -0.25774592625657133, -0.45513897970149636, 0.3425176270875679, 0.3767456735560218, 0.08465036539772015, -0.2622647295384395, -0.0553940716608987, 0.11773592880045548, -0.01142304518483637, -0.7026163773256903, -0.8126562702373575, -0.4414634801610246, 0.3074170562837705, -0.16034959305409033, 0.07835148419694545, -0.45744981879319013, 0.10218334147494545, -0.4230836743606277, 0.08356412356085066, -0.2672152757315472, -0.3027709753613333, -0.14404885037562842, 0.12129851715391338, 0.2908999095969759, -0.2478659501287714, 0.12130473312691868, -0.2614435894314618, -0.11571375339500618, -0.22515241835946478, -0.20767134676893922, -0.04272113914752373, -0.04875299174635769, -0.5014341764398403, -0.3075815584935109, 0.2777521530554715},
    {-0.005161533625389024, -0.3422107824046847, -0.2576477254798981, -0.31516631199328815, 0.20224584076433413, -0.07242212693539052, -0.38189957772392397, -0.07872442394887115, 0.1773594641363419, -0.5102279669662675, -0.2214534695551421, 0.17059142825473658, 0.12381188648320166, -0.16600715098379834, -0.019006811497013866, -0.5088493063732249, 0.03487016845435928, -0.3716853080817504, 0.2234499501893344, -0.08287900108105009, 0.19777811727463804, 0.3676405671499333, 0.908804581534855, 0.01277391745419138, 0.3499570948748751, -0.11085841932769915, 0.04800091300348483, -0.2514016113832018, -0.11161313135503857, -0.1672532525912927, -0.39484896386557905, 0.060209749433948495, 0.14011806110396477, 0.3346949705565664, -0.48577271454627563, -0.33851344074645834, 0.342858567243786, -0.3958665908120698, -0.49130472564997346, -0.01567971351996474, -0.07298241786839732, -0.21614346596431153, 0.16942607862355463, -0.5165454002335591, -0.23928435035791135, 0.055568547446687475, -0.17975867395646236, -0.011031695018940711, -0.3220458038774323, 0.3348113450290124, -0.30592329567893084, -0.15978753049805727, -0.03396480564581291, 0.44377661368011545, -0.02831529889028557, -0.28710817373670633, 0.05687609730743496, -0.11782873473626215, -0.5056945487085268, 0.16441557478455135, 0.4481789586200889, -0.09258467799486064, 0.04923853237915548, -0.5152352108414507},
    {-0.25145938118956745, -0.37175116742920644, -0.2446525761155113, 0.035122555823071104, 0.30286127918686856, 0.08347777071500091, 0.0726351373898337, -0.41181768213020703, 0.3058401890167758, -0.06391961686161758, -0.11631900315893898, -0.2780706272615884, -0.5458669748019868, 0.24536212403265042, 0.014623963873005097, -0.3242012075146837, -0.120179754984113, -0.10136568953834033, -0.04351990496824411, -0.22876668027041083, -0.1089293111990792, -0.004144067077976037, 0.30939920933322024, 0.29267496873918336, 0.12935031631260485, 0.3676705112344955, -0.12222886691942562, -0.26532422525159194, -0.30165709143411035, -0.5496794742559661, 0.289862110154693, -0.46452415905961386, 0.03104682690703995, 0.1438566302242099, -0.43922357901429093, -0.1222305123942919, -0.12611550611646713, -0.07543817206311579, -0.4561841461818656, 0.45521387254203394, -0.28845353007278235, -0.06907829924353853, 0.38649024392306, -0.5515859674216393, 0.22827709057546555, 0.00622119741636908, -0.03409425182904679, -0.2767464711267327, -0.2412173762520645, 0.4941428302288815, -0.3876741413178177, 0.10455064756976733, -0.3492120970365896, 0.2009462982741812, 0.0005714642085728292, -0.24374514615315815, -0.07923158821394467, -0.0790401985666027, -0.4322025045782327, 0.05058883933158046, -0.10845001445712237, -0.17938161135684694, -0.1289176501436939, -0.07765406445559365},
    {-0.7539596425365053, -0.31637031483662337, 0.4523655800460182, -0.03065672426455952, 0.2983460757594016, -0.44003223012742787, 0.07004103384501187, -0.47096247368869126, 0.15520562671002056, -0.375906292804543, -0.06370720410335898, -0.3333467225701593, -0.14274145494791193, 0.11615565361521547, -0.0972208579360651, 0.1787280340752798, 0.08222438201213399, 0.061657318997174464, -0.31223894790984236, 0.26600124491636673, -0.24928013680349081, 0.04144546545598342, -0.01993607430697905, -0.18827574764275434, -0.20248756957545253, 0.5450371722240827, -0.17745143965195578, -0.30005622915028257, -0.09936794785168164, -0.0815410260191427, 0.3092314180739452, 0.07567201472578973, -0.3157780199309083, -0.09100711940092178, -0.17285309200365068, 0.31502475611661185, -0.5118649706202227, 0.09969943407611975, -0.28001154324138805, 0.4285919621544679, 0.18020141534753922, 0.3794760965885345, -0.30477544724879707, 0.31100079208555653, 0.18337423719524606, 0.09379221004371127, -0.19029839189126938, 0.4982082193767643, -0.3481413220011129, 0.17721441963564666, -0.24322157831065164, 0.12781063002687812, -0.4607209499066046, -0.1444231029618937, 0.16843151721659694, 0.25378254338271744, -0.11430646544381624, 0.20214097297355807, -0.22327290663952104, 0.07618731308556019, 0.24709360460747676, -0.21538331736396266, -0.35765286940262503, -0.03817916581704817},
    {-0.5880165050583209, 0.3496130854034039, 0.195901816499095, 0.31815191590241015, 0.007691961319610681, 0.0421919827830183, 0.17390230683602143, 0.5103351474269694, 0.10346442813378938, 0.117685634967814, -0.0615162291688447, -0.12769518443251096, 0.6979911989332243, 0.0032460859037774345, -0.1078203819239467, 0.5804949173475361, 0.1698359669801804, -0.07488679885217056, 0.37696874989271506, 0.09231833681824238, -0.18460088232988686, -0.2779279525909168, -0.24263715931834168, -0.3981874840086809, -0.4001517067376909, 0.16613637128913694, -0.21995855910097453, 0.02223599969566881, 0.4387135166507466, 0.056105804538330396, 0.12586966243121964, -0.0899914856477148, -0.07618504495837636, 0.30759032446211415, -0.3766140524774251, 0.4722844509329912, -0.3480056359227956, -0.18181205202363326, 0.005961836823940546, 0.04848927001061256, 0.4981803804367709, 0.5165190858125016, -0.3714363737989852, 0.5091379555156879, -0.372526918920408, 0.3323462694951415, -0.1713915017390554, 0.22003125581082655, -0.5303358295793825, -0.17366934768098202, 0.16481110984014966, -0.15917107321261037, 0.24588464675616223, -0.18324215871422453, 0.28271682627002914, 0.09143032604442902, -0.11243207706074765, -0.1445495779832059, 0.03844309938024449, -0.36281049547057265, 0.39781435787628494, 0.6040442114141448, 0.1978808909219158, -0.13835274254367777},
    {0.4906190624164296, 0.17454183659539313, -0.4438546797842703, -0.44224480217489903, 0.022792514108616446, -0.11089816804735003, -0.32327942357549044, -0.08240451436397396, -0.03139943273324818, -0.16871549570209438, 0.030747666813992172, 0.3760476515833783, 0.7512992117823691, -0.33039657729487165, -0.2716301300276409, 0.3181473208636023, -0.1538196473768484, 0.32539022620167274, 0.49581765610541007, -0.4863832651481155, 0.3996785422871527, -0.06591214703391345, -0.2958338682718315, -0.2928359614345724, 0.3461425023084491, -0.815618840094166, -0.13803884525304527, 0.1382138416724448, -0.062316305324227175, -0.05100911594061534, 0.06326004797925777, -0.2180022187989277, -0.3146966198076082, 0.21711898475068048, 0.1135436610736305, 0.2220420779020845, 0.3954261136756645, -0.1641453865693331, -0.09102509850457073, -0.2612167448609379, 0.28624021669045524, 0.18887303940749336, 0.11640744735627678, -0.2774601260151363, 0.004733057290055553, -0.24839176181328199, -0.4112202714062234, -0.14724787943228002, -0.05092762686254404, -0.29072901933992024, 0.11223970468220976, -0.042321129460732736, 0.45735128317884244, -0.19650748780324792, 0.31563270668369187, 0.034682267953964, 0.2727562867068794, -0.13530628154887572, 0.2480747469516083, -0.1478889036330022, 0.001425998266599159, -0.06488849587015894, 0.3324693546989361, -0.03412661605861079},
    {0.33891750155387346, 0.15755070284245262, 0.2732896437310814, -0.06514140830881825, -0.12893475316923503, -0.4306952227913898, 0.19109667773930997, -0.04883600838995761, 0.04288787666485437, 0.11509111467462349, 0.7261842286039174, 0.31436608586338227, -0.09111096537907963, 0.04623076210838025, 0.07852327243796034, 0.4829447707693309, -0.32870334317967503, 0.4102519839281471, -0.6919476257992428, -0.12364258180649622, 0.08174854847920295, 0.3653217943917006, -0.23235533092901267, 0.1475069104003173, -0.1728572915349738, -0.20783480693900294, 0.21270729339059627, 0.03478688461149758, -0.22659103468418684, -0.07396947635723054, -0.2271032568073729, 0.19563761677642785, -0.47200211553541116, 0.1035467235560376, 0.3397783186420991, -0.15568596229734893, 0.2985760003260284, 0.12366293624168592, -0.23855062779986347, -0.02985296661094795, -0.02375871650860148, -0.0689132334358524, 0.34989442712160523, -0.2990946636852506, 0.42017895864147, -0.2957477693966875, 0.31483984327538683, -0.4872455709883439, 0.2350298494843304, -0.1257388989893086, 0.3484399880603223, -0.008573981524858679, -0.16296690165908218, 0.025945411091000337, 0.24432265105349488, 0.3197178104053998, 0.3558629518191061, 0.13772203857203588, -0.23628957194972222, 0.01387283756214896, -0.3553041107721091, -0.17697428847113547, -0.01554463983904203, -0.16928225783118062},
    {-0.12201021883398744, 0.24488693311785553, -0.07152957337720971, 0.5656517386565231, -0.1646999653140711, 0.12111571705684486, -0.03827074896751502, -0.031681582009648844, -0.37164917694883476, 0.7648033618807735, 0.3179758341789327, 0.11241117507841723, -0.23099529002294478, 0.059993762495561584, 0.29045464013787975, 0.21634557813669564, -0.1773449117670834, -0.1449693221961917, -0.16065306525741052, 0.0713943292798276, 0.44685365051537496, -0.36332220122555803, 0.07673142967363118, 0.49504844765287037, 0.13290643362298327, 0.25334828215500066, 0.49323153552108695, 0.3015783218107907, -0.34184759880528115, -0.05196200847934261, -0.2076753602015967, 0.5658062320570052, -0.030540160948402915, 0.10106088621640492, 0.5937082644660179, -0.3773279805886153, -0.07157422935821137, 0.019557687920293252, -0.1670833751621815, 0.044568993957105445, 0.18047325048546892, -0.03364447882560279, -0.10400933448080406, -0.4344359368559736, 0.17793738154527367, -0.44861868725184123, 0.08567840288367977, 0.22311580095367103, 0.7647560228771489, -0.38354205363344673, 0.05353619795662965, -0.13305945216458073, 0.01833887104989422, 0.49474292646523965, -0.24541305661520627, 0.40387065141654577, 0.3661864681504132, -0.2183879450988718, -0.09472949099351209, 0.1892594688649884, -0.3208150719047347, -0.12681822947342195, -0.1407336425194378, 0.10234435390871842},
    {-0.29862647985822055, -0.3446045977851835, -0.02565828666018882, 0.30158927668253904, -0.2368940625571172, 0.04980694061568392, -0.12457508052652118, -0.19831148347828167, -0.15226577397991, 0.06937075068246878, -0.1313393307517724, 0.10558854259617659, -0.21101340698809834, 0.5352193623613577, -0.3770588076937387, -0.5655942335465997, -0.03756094468036933, -0.1733113182738444, -0.1981456088645957, 0.23625018499528117, 0.1564913780764313, -0.3289595141770455, 0.10246201808716468, 0.2525002605738743, -0.05840395109410824, -0.11615645731108509, 0.18226498849197195, 0.07823635628673867, -0.4862912542414917, -0.2341424560155972, -0.13374402189136456, 0.0659487934792695, 0.06228558354452935, -0.035756178930722804, -0.013193419733571608, -0.13725578310508288, -0.02436623448275781, -0.0015515532902810067, 0.0029481071958456324, -0.4569692190500259, 0.37969064042546696, -0.16645363848540884, -0.20637306588681895, -0.09854988568339892, -0.19429945220073566, 0.197682880592797, -0.10027976977079144, 0.3763589557310014, 0.1679503956063937, 0.6099999410443366, -0.04081886805517947, -0.22471958247454285, -0.1977252916244778, 0.4319361858453312, 0.4765327774907321, -0.0011460160745533027, -0.6030194249928116, 0.10900888717198932, 0.3331931124890208, 0.20940185373266043, -0.6783082333251742, -0.3253149101822068, 0.18177719974083426, 0.5763881947521359},
    {0.2105673692059367, -0.1594925769829567, -0.262227273430938, 0.3182902874093758, -0.1684675540402379, -0.045759424436878714, -0.24576447726840528, -0.12806803232895927, 0.023829360801444238, -0.25823043674089136, -0.043217406441567185, 0.2738543340935589, -0.3039465576640742, 0.3212747502756475, -0.28723993476499365, -0.06085777764167134, -0.2687672136411418, 0.1416823209464782, 0.5242263181137397, 0.1370013475064857, -0.052187946651665894, -0.13234861585680005, -0.20701925164981588, 0.0056244253294803264, -0.18873890549951347, 0.09965425814477276, -0.6327327571054583, -0.19115163178206512, 0.2115147522901193, -0.21308609652367463, -0.26245528925454936, -0.25401468153110224, -0.20252381499269126, 0.5708053949132075, -0.38097060501664354, 0.4025118610409662, -0.06072184953629499, -0.07995869484405796, 0.33074482912736863, -0.35093102194043113, -0.1810389110570196, -0.48080190483687385, -0.3794113845502134, -0.01383871169090032, -0.279205555632913, -0.6276319890251427, 0.11079633331058168, -0.026690178655196264, -0.5770228147328504, 0.3833557620950944, 0.09859788593241732, 0.23676388542972207, 0.11061536309996745, 0.253890795239825, -0.09991769701335437, -0.137416224445166, -0.4131670764789751, 0.3091585573232727, -0.09935661380081089, -0.1501202177586142, 0.37931791713062574, -0.1987603617301794, 0.1510522362533711, -0.2971250743715108},
    {0.10376956838036688, -0.03483725786221394, 0.2668486682349689, -0.08847184324657907, 0.4879461052704027, 0.016678801251986758, 0.2642637002643018, -0.269407856483582, -0.23724927816620237, 0.20063381852134865, -0.016353647097747188, -0.06997984788633244, -0.1872472721131329, 0.17158466630991318, 0.722551523899757, 0.3582501145776214, -0.4671001112973101, 0.20319736731306476, -0.27128029479987636, 0.20429113254340933, -0.5751130165051691, -0.06990489417010003, -0.028385704234457076, -0.2845697200695033, -0.07261976951802597, 0.29061639955530555, -0.087189273041998, -0.23654386247648712, -0.24213288042159542, -0.2102800913305763, 0.3081686359541484, -0.14891145295418928, -0.16957523506005687, -0.02028499242309151, 0.1654459118092399, 0.24838102713309615, -0.163833076897851, -0.033305494454497805, 0.26431898900305434, -0.17357456938037447, 0.4687809940339363, 0.3836699901534846, -0.07161009168851049, -0.2177738317745268, -0.5208663597822533, -0.17810659950517463, -0.2831782375173395, -0.11987874500913924, -0.17296637535597864, 0.2754405634296317, -0.4444813504429333, 0.19707287429465248, 0.011094208228129326, 0.14007459324737992, 0.1712966674198589, 0.011804605031101686, -0.15425446485618663, -0.058104328389221443, -0.2114362023258165, 0.08403930744483011, -0.03316497816688078, 0.20688297271450085, 0.1350826125655161, -0.031088438354127664},
    {-0.6721258455621736, 0.41928995207343184, 0.4006790217167535, -0.10355771424134182, -0.08475199931032185, 0.3141249315477161, 0.37100487155518985, -0.18874757079769758, -0.3188147109843522, 0.2794783752476159, 0.007901537972732001, -0.15791920743471385, -0.48497396843063517, -0.07168365945680041, 0.3661951979943004, 0.11835736556566602, -0.009018860622090615, -0.2767770285525393, -0.3809611992691285, 0.1674439801818911, 0.1022328292910559, -0.3446539241304689, -0.4419536347116498, 0.0396613233467314, 0.25509986901908294, -0.3061642424775136, 0.17325301718824496, 0.35100938813411486, 0.12297541713268172, -0.23278708697843123, -0.16909384700445537, -0.35280396782890594, -0.13945797285364797, -0.16178836860011228, 0.08203009016666726, 0.4941419431230711, -0.47698496594049494, -0.07254049127028243, 0.3975499587040755, 0.058094951756723204, 0.14829411244078375, 0.12687784262021543, 0.40645555800203176, 0.4193417745411565, -0.4211992315368451, 0.26463535991123893, -0.19809559700339402, -0.057324502851328084, 0.06877880309443539, -9.397155879035559e-06, 0.17522433086023154, -0.2964239985594258, 0.27492375973343175, -0.05429252811082255, 0.07744295558047413, 0.2721753055550364, 0.05207345701773211, 0.1808581977825387, 0.25197892191712185, 0.350113565157949, 0.27512959193819553, 0.11496865178020133, -0.35971673723359915, 0.5898988011491949},
    {0.19286646392784382, 0.055801724712960264, 0.00013651287481140505, -0.2810699634859218, -0.45554468899020584, -0.17939788004980073, 0.5939551524670745, -0.0887928577274278, 0.14217485508273564, -0.24364752516700028, 0.1036184435550318, -0.577683779397314, -0.35066956282272627, -0.13532905135039547, 0.15923150123093716, 0.26456122532626436, -0.1669088018611758, 0.042229927563090776, -0.1428442472664955, 0.34243553500986434, -0.20257612401907582, 0.09881388241072384, -0.2694836304289151, 0.37529115473830993, 0.2223344265751676, -0.028793854786857254, 0.02504324236088833, 0.1470243377584808, -0.3995347662549377, -0.6345434865089952, 0.22303596324886082, -0.10350367463806605, -0.06493468535693353, -0.11295523837298932, -0.21930592550873573, 0.18456743515907714, 0.28161433072229597, 0.658118528134197, -0.2527918055638237, 0.7394436770515646, 0.07123334461786715, -0.4141447905634302, -0.0607625522770452, -0.09372704339858617, 0.18982784764416824, 0.18884499120751894, 0.2397461527847065, -0.35307331442527895, 0.1584185633470842, -0.23779818806071287, -0.08628424438835916, 0.10667991053575632, -0.026233338896860907, -0.35719032796653044, -0.26985288203304464, -0.47887982663455453, -0.1611015081571933, -0.4703244341029444, -0.38150735963100435, -0.3775441216490921, -0.4161564076615071, -0.3190085283119878, -0.22777615486140307, 0.4004976114013253},
    {0.12909475132539977, -0.30157048257762076, -0.13340416251950354, -0.13948919878539817, 0.17433788680425574, -0.04549441023155277, -0.03435203341924589, -0.215417473920177, -0.40028385310674763, -0.19836737256180528, -0.04789221243174597, -0.3990740028775365, -0.6749512776347175, -0.28378546273543126, -0.4125229653413126, 0.10045712162085693, 0.09136196014654045, -0.3365296953399446, 0.0018538167707980396, 0.06642612658462275, -0.05343935589230346, -0.4976216362171404, 0.04139404949775257, -0.02213235278481068, -0.32106437592738885, -0.11506346639147877, -0.33097790474985056, -0.21433626136834216, -0.1440057618689048, -0.3502856370672185, 0.2641408967204586, 0.19213887866235238, 0.3450382119971471, -0.050109461869084784, -0.018966546364871203, -0.21534239536406666, 0.2064834740629696, 0.1761137340072911, -0.37296456377966936, -0.10448101190071238, -0.1885708543689184, -0.383824809824721, 0.15211275801772314, 0.32570833422332035, 0.5871033252296854, -0.18325881166439362, -0.29509355735571646, -0.4506758271338531, 0.21863077021592434, 0.07590645895545849, -0.38183001426245305, -0.12869007675740637, -0.30382204027458737, -0.2158156584917454, -0.12550858418504388, -0.015366354745292696, -0.4163403719994863, -0.2987915918864016, -0.06499645695836308, -0.35983830094973, -0.14133349894746725, 0.33008691770713733, 0.05489172715877192, -0.07331939994833686},
    {0.5367383521576399, 0.23973890610004012, 0.09142021199711109, -0.12187507983463625, -0.3907960027008145, -0.24173713347375145, -0.3025441374623351, 0.09601095459086768, -0.2445106025054875, 0.15795861640316058, -0.024058671263734146, -0.32918423651193407, -0.4046639487262938, 0.0987364923646529, 0.34811786567926667, -0.23578826774988673, 0.09572976101573649, 0.28016076082381014, 0.6652226883129627, -0.03954021799762434, 0.06771288824220498, 0.12648175412620824, 0.20332835617449052, -0.24003469712734898, 0.3902472154126759, -0.332037745641475, -0.2739911601853517, -0.0050636922643170846, 0.26693096106253095, 0.6394928480604571, 0.37414973651108974, -0.17415617325615915, -0.33717995076710805, 0.45006751992767385, -0.3875231807179026, -0.6458968064973633, -0.26582979260726247, -0.4327943864280432, -0.4191294660701953, 0.04425976581247649, 0.22175921021490613, -0.09053015257931352, -0.06848071114649909, -0.5198312197257685, -0.0658211670745738, -0.40661205899203823, 0.15303674907285997, -0.09723366628289233, -0.39866920056370253, -0.24669811002017117, 0.13488313525219356, -0.3654846489250518, 0.2499960502915759, 0.19387157637979374, -0.10741221379594348, -0.06188222347365772, 0.18567690999687694, 0.1171896791534082, -0.2955867091230446, 0.09092318874872278, -0.08732472335207456, 0.11074025119304733, -0.1462396353933497, -0.498456446473704},
    {0.3484543768888623, 0.2796628092250564, 0.03138347633322212, -0.09159364558044943, -0.08585285178930491, 0.03209753666415715, -0.020289760838891963, 0.7079306738943585, 0.24373765613354517, -0.2152493818498387, 0.12676310880655084, 0.01752489094065182, 0.5398119899676704, -0.201022812023246, 0.41914741761415125, -0.04888949749330948, -0.12928937129051254, 0.12288404794160444, -0.19660297628821988, 0.25520018449062715, 0.250365433450219, 0.01277019642643754, 0.20511380201517257, -0.15622897146603104, 0.23185448530362193, -0.058630931967417206, 0.34933700403437185, -0.02776674376774571, 0.27390650954994533, -0.04653634095472545, 0.11524086230694015, -0.2744568564135526, -0.1574410722855497, 0.14658320367783753, 0.45421280052968854, -0.045068644516401565, 0.4720607660861576, 0.35943498209684216, -0.5248090392194972, -0.25659171342771603, 0.6400801696713182, 0.6203879796895201, -0.338227182618805, 0.22408888178777803, 0.5294809487229231, 0.16866214878168587, 0.6228725154612109, 0.02613844651943761, -0.4997646270675152, -0.3368868282239105, 0.19070213786331897, -0.13693646790164438, 0.25359351681868464, 0.4192421169967947, 0.0366845483487359, 0.1728440905281259, 0.10868024168892708, 0.09341730020007331, -0.20753403105084656, -0.2425505979576917, 0.12763816428863942, 0.216377530214644, 0.2839523264760598, -0.03260470729874354},
    {0.1587401973920122, 0.26837960603969185, -0.3367055809846457, -0.6231800451985555, -0.06250181982837734, 0.4760026038301404, 0.3133381643186253, 0.30560115437095403, -0.056556021275378, 0.43461314837893994, -0.3738409097103141, 0.2716292974173568, 0.1723244232979878, -0.003001112713732413, 0.07939324749661608, 0.48554017800270866, -0.09183654846454122, -0.08773375248464735, -0.45475468507044436, 0.16840089639711084, -0.08557460194335915, 0.36760322796676237, -0.09847286747402817, -0.7259908138276968, -0.3358785538379956, -0.3795425701010248, 0.11303100777416036, -0.2580200870103153, -0.25471199162241354, 0.24158125359481847, -0.25949451308809074, -0.14785412450783023, 0.005370811157944839, 0.2447947558224308, 0.1049593998007458, -0.1563427111290823, 0.5209348297686704, 0.07174615344125246, -0.4163620098564362, -0.16566267573175653, 0.2805419125242235, 0.12486766886825328, -0.11707164061345444, -0.19130060809023877, 0.06808329096695517, -0.16388604290958567, -0.06148647519086572, 0.08352635326446708, 0.4099119582994028, -0.12938957901557288, 0.3328570787441059, 0.3360430455422253, 0.3053468561267728, -0.2950196501539941, -0.1282828565110031, -0.363870498744192, 0.018549261471136818, -0.14816474545993966, 0.2417641877966901, -0.24869177251781113, -0.39939124463742404, 0.1786750454623056, -0.13130858740315224, -0.6124355444472763},
    {-0.19416982493455626, -0.5124463042344708, -0.11212323439374589, -0.10289004403089685, 0.06292678700022808, 0.22247283236739787, -0.07568745794336224, -0.024381304055232703, 0.04569585607709534, -0.056769806323462284, -0.2023926049730064, -0.0830221659562427, 0.6634039346106132, 0.05963598436433411, 0.43484625325514475, 0.025031986752055292, 0.20281568897886987, -0.359721826099201, 0.047416879491489636, 0.28696458060828395, -0.09818124745589468, 0.16797616621140726, -0.26735068692526903, -0.1279626729870616, 0.5236312332222366, 0.2785164827836802, 0.3414293774786337, -0.11467779060950874, -0.4401043569447777, -0.2072463284875734, 0.5426714752752554, -0.005709199487480989, -0.2414908116442775, 0.13755433838431613, -0.06986228436210927, 0.19611128010422918, -0.03606019948154311, -0.256071813680609, -0.1846152289021938, 0.18232950168975645, 0.05026380587507772, -0.31165740509645795, -0.0331938111782755, -0.68573835274853, -0.1260682966456738, -0.07812518582124724, 0.576370166642484, -0.06638482340202405, 0.3815930105139644, -0.2549737014199332, 0.0908334751641704, -0.08480631369263177, 0.018057204502610898, -0.04924551877305946, -0.3292381476130727, 0.5274722615535928, -0.1460979770484274, -0.016491125099379278, 0.20293015440577256, 0.34953557831978027, -0.15617112665885244, -0.22196322194357232, -0.19467757082932233, 0.17335855789864535},
    {0.46238910764986974, 0.1752112157798891, 0.09069054456509168, 0.32200585721709923, -0.05896893702172728, -0.029183410426488515, -0.5770864126315218, -0.21099089926702405, -0.24328563228631653, 0.11439738177052818, 0.10404020049023571, -0.08761200982109893, -0.17159972510061242, 0.2740801252534478, 0.1027339555208851, 0.0487414661251151, 0.7071154284621121, 0.25715101289085684, -0.2309931923463762, 0.40441568828938435, 0.3651935993803339, 0.6507038315030695, -0.28588477202111484, 0.15432005043889682, 0.011131370724267281, 0.32762269439887537, 0.3739482171944942, -0.5965567343133945, -0.3978767299522686, -0.32530839003689543, 0.06268122067535577, 0.12001229426468486, 0.27737868435030555, -0.1232039698406635, -0.21889549858962046, 0.08200613982551265, -0.19316493083781983, -0.08014818491585075, -0.17172775389313688, 0.29901048693410315, 0.24385675965186931, 0.0212698688963632, -0.048410573571258775, 0.03607865431819368, -0.11580689299575145, 0.3416506300779919, 0.3896624783055122, 0.5257164643737268, -0.7735907997845369, -0.3042540752835697, -0.13675636479635495, 0.3073698064293103, -0.2941902877747212, 0.3264881719524486, -0.017206807045375777, -0.2263760855929811, 0.43851057679329974, 0.08078177242117783, 0.15728789208294242, 0.11888620607293317, 0.5344326640296783, 0.5982235965661865, 0.3978151988034725, 0.14869953430219282},
    {-0.10500405064684362, 0.17305858565330706, -0.33320571192134824, -0.310486162797469, 0.2868384266740314, 0.11410554545604282, -0.19729563504077277, 0.06385127093896989, 0.3056577105880612, 0.1313347448427242, -0.04103477298007558, -0.15166777038980464, 0.4321542277086864, 0.07565313080431506, 0.31473532299522594, 0.14855779327855823, 0.30047123218970384, -0.3621845421229147, -0.43949476293398093, 0.15659364463393854, -0.240900864629172, 0.08494928955389494, 0.3857871574039914, 0.09240606113371468, 0.27061319610580975, 0.03487718836993275, 0.013799169834439965, 0.08537071944514038, -0.5409002537910201, -0.2745180924457259, 0.4835946448031839, -0.4857774594504935, 0.35729549171488845, -0.38976763684511184, 0.27824170637990364, -0.2667434076209754, -0.06506030246831929, -0.07682301892610446, -0.03490780377023859, 0.34264623210361445, 0.03908338792486844, 0.10143288441664539, 0.35257236303227296, -0.391272719602212, 0.09948190280281925, -0.26359934962687226, -0.03689881936239184, -0.0441015131595664, -0.41430593034172003, 0.0793204875574849, -0.21328468883375987, 0.6759538123444961, 0.07116320134481557, 0.2618308718783012, -0.41713622602993006, -0.07954651680718841, 0.23551437085473256, -0.2752212896087271, -0.47852006572423156, -0.06755100047823039, 0.34296062697385593, 0.09917809220753972, -0.12507573743133238, 0.33277748347818453},
    {0.2072549111930795, 0.557112330928082, 0.020416038352650063, 0.6964165236421169, -0.35512368540305533, 0.4229330692783905, 0.3439294309762738, -0.4716755769787354, -0.13420826848663414, 0.058750755414564926, 0.008711791084300292, 0.5491259968414246, -0.14010315669589254, -0.17695871668873137, 0.36985928523455536, -0.17578345251756533, -0.14950454397001767, -0.1531115778633625, 0.15451518504274525, 0.21837330215298587, 0.19014989353052628, -0.6828564223108546, 0.3824900373270593, -0.39072923315304237, -0.31067777742090913, 0.0021028609484786335, -0.512410909170786, 0.274293696824549, 0.31274758741635117, 0.5233503876858635, -0.333091395101869, 0.08715005987993493, -0.21368035320825865, 0.4395752741315995, 0.19576960003526991, 0.005316211488052579, 0.40103191439389274, 0.28246111659059914, 0.25763615175664467, 0.18734284823502145, -0.36120524063984677, 0.023694762991127865, 0.005517595686547198, 0.1239461318464717, 0.7174701781203158, 0.002591340357120853, 0.2870558187429058, -0.30862236026985224, -0.0639334711596684, 0.4071544019981699, 0.34942077393952564, 0.012439491621079168, 0.4884185776174599, -0.377551701097548, -0.08504794233954528, -0.1337051472523155, 0.015491446404292933, 0.2533261562500437, -0.37550606982031176, -0.024173161489659666, -0.061915521512895276, -0.440510547263914, -0.41926104216462134, 0.081663774316798},
    {-0.32136034935000757, 0.3079191824997184, -0.18432519089953717, -0.3797298858136291, 0.12230522171670156, -0.25234168437767984, -0.5264904205522271, 0.1997056916681591, 0.1993090823365074, 0.11029091924548377, 0.12980126309231774, 0.5590813385720976, -0.16782139410643707, 0.17226175592785395, 0.26622126072070595, 0.0903402408337112, -0.3482791338567716, 0.14601085197145888, 0.29883953623461385, 0.06641824023001844, -0.21009824663207022, -0.07112938245557984, -0.17055256230649177, -0.27001752116139077, -0.36459176933293164, 0.025925992345201716, -0.18469801438216246, -0.030372975232304394, 0.27596826119621415, 0.02720964691027808, 0.3426221773274378, 0.030354543660437612, -0.3110848821711472, -0.12313359746652158, 0.3363359200569159, 0.10306171240827523, -0.3829470392409464, -0.007904423769924226, 0.704941647243207, 0.18218791661736009, 0.08352023662515214, 0.583496359609491, -0.3327677496552994, 0.35402189376062293, 0.11317375486085976, -0.41279894552585344, -0.09777384624514639, -0.20677493062158742, -0.11012238395830917, -0.0691708930446489, 0.280285761572714, -0.08230884720261568, 0.011004367086789889, -0.49528216861811386, -0.13629003431937553, -0.24840930930204289, -0.468839867848634, 0.12372772685412857, 0.13024685103529937, -0.3582727727815595, -0.37819642615635607, 0.04271772172231072, -0.5239169069063485, 0.3032971416981647},
    {-0.4065096995423661, 0.059223993205960015, 0.53594039965989, -0.028829752399481677, 0.3889680423981651, -0.4944201645737259, -0.019968731889802995, -0.09240064404417773, -0.3157549839588876, -0.2985572750218553, -0.6845065656433491, 0.08502191293598049, -0.2644276399704319, -0.3161085632458119, 0.045081764115807006, 0.049559221714024576, -0.11468688492204474, 0.07556093479440706, 0.28585816731928276, -0.42763834276079676, -0.09890434570486077, -0.35248202520297583, -0.13547410908499455, 0.43041161759233515, 0.15834676427478908, -0.0783506087062294, -0.006123404053448268, -0.29530348417777985, -0.13344538623856833, 0.2556427681072482, -0.18972257778154117, -0.028382324012631018, 0.13018320045195184, -0.036959870093741146, 0.36998280061442834, 0.2863087711083675, 0.44865331793117424, 0.41511007872492944, -0.27940996593633566, -0.11923196657400675, -0.104747258675492, 0.29451332905654504, 0.22934915160257263, 0.1819309983345084, -0.28687385650277136, -0.2367366883379446, 0.007035862488105213, -0.35155505445180246, -0.22388422775060973, 0.3821331380852391, -0.3431552760131198, 0.05890383550291838, 0.0027398635608843194, -0.21415872614624776, -0.016251716456804115, 0.2910327389654984, -0.1101411704637827, -0.18363933676959676, -0.11416664454661955, -0.23054189676036477, -0.04244691531671566, 0.032953068639466586, -0.2228236990121779, 0.08174785695185302},
    {-0.4597503213932664, -0.6501765059284875, -0.585098327713175, -1.0427482539310922, 0.4249732893172102, -0.5890696589992203, -0.13770328843674795, -0.032278217750768154, -1.0932201468690899, -0.7889218830200411, -0.8719997878925134, -0.72183920968263, -0.036773977085058224, -0.9898587978964338, 0.0016075703158192217, -0.14396373214241667, 0.33932734837678186, -0.46324625779439527, -0.6528971062024811, 0.3589398461094125, -0.9781045128581358, -1.0968660464620297, -0.20676425091002595, -0.1756122589497173, 0.5082504940812749, -0.38133016720721513, 0.14043519945378, -0.9250820064796026, -0.9301984093620705, -0.776937653673778, -0.3388097593564599, -0.9358965919157141, -0.05248774281380848, -1.1414152828876074, -0.47218217599657564, 0.25132116490661394, 0.5309510043621593, 0.010807985162858637, -0.032302538448922724, 0.30913527138446756, 0.2511236772879222, 0.05389759522200659, 0.07399721441946783, -0.38025545088466045, -0.6520479094781206, -0.5713448252807208, 0.5578082433003098, -0.801930122984937, -0.51147259687368, 0.1515394756186678, -0.5586059341384197, -0.5222801841038348, 0.532203715110799, -0.68464914818676, -0.18973953364831248, -0.9470671200783238, -0.3525636766865435, -0.7847136045793667, -0.9757601109338915, -0.7845986943119326, 0.14740671899150634, -0.017160394333726597, 0.2678541242942881, -0.33715562258659626},
    {0.2773935813299799, -1.1197901091386897, -0.9944425061380259, -0.9347438519173691, 0.6394467102185255, 0.06889293064924587, 0.4658454823710256, 0.32737918296832186, -1.1589071858049265, -0.9526252897982784, -0.4377892502733086, -0.19037283823839843, -0.2334652221138747, -0.9458228078022854, 0.49001186684851694, 0.4839563721996242, 0.7038868337118922, 0.3466885527373664, -0.20693584286127167, 0.8569192947980464, -0.8826007251484944, -0.7812775715714021, 0.14850009247011373, 0.23561523160637335, 0.66772260307957, 0.0442974799953387, 0.641149308394954, -0.8519928815533714, -1.0915847782470993, -0.8575996575042718, 0.4578685845545909, -0.9503840779351068, 0.5303551219776479, -0.39863211127102727, 0.1047348920917221, 0.5420056533405138, 0.5048043702986355, 0.42224204013955274, 0.15597148143345266, 0.5277728732070897, 0.5893606352775161, -0.15418465919687185, 0.3811021064110433, -0.35142257869586, -0.3163270601201244, -0.7513023873914173, 0.8450749647127548, -0.21356043559960983, -0.3600339992956555, 0.7399478513525665, -0.6544579004765726, 0.22176785402222823, 0.9289299921783128, -0.45803004237532585, -0.291873807774206, -0.7574706631276544, 0.5392924082102822, -0.9393979129271802, -0.6261355405460576, -0.9331110327102001, -0.07112483508337457, 0.27394348914339056, 0.784209096276468, 0.17682469738979423},
    {-0.7327899885278613, -0.3077521684700622, -0.39423688498377213, -0.7554430642528732, 0.00935577407130643, -0.2395921457178227, 0.31926009355759616, 0.20362573162087064, -0.2629672702542768, -0.33392296511667097, -0.9026144710721374, -0.031545789216071735, 0.036197962896092, -0.3034297282165034, 0.16931598851320445, 0.29675961602368783, 0.22702387263907675, -0.7288010989693278, 0.3237937954185003, 0.350620553128911, 0.11949281998517432, 0.0009692079062127151, 0.014089500001273042, 0.24046000006810733, 0.5720983208389214, -0.2332649165094379, 0.25976139629113065, -0.14339183879533673, -0.8760105782757909, -0.688530884727566, -0.14266986898447465, -0.47483087053343026, -0.05548751302845091, 0.09781307017392497, -0.49428561412493954, 0.45511093110938244, -0.42845822842993314, -0.17898640533213678, 0.23048541018241017, 0.09870258918886313, -0.4600398163812737, 0.3608034619204636, 0.18234902157289196, 0.5671025976784462, -0.4235045843977062, -0.46871965945118477, 0.03710880285591851, -0.6089348577530715, -0.1719337384430005, 0.27798348828302394, -0.5819875699728984, 0.01897580573944847, 0.10123212947035361, -0.7384996130635054, -0.22488396702686897, -0.6023164828465742, -0.23947674872542293, -0.5648626623848283, -0.621933236853809, -0.6699274872917272, 0.08699117967631033, -0.8347633626101636, -0.04606419968330046, -0.6577466793837525},
    {-0.7016806829120334, -0.1582313574008079, 0.514806896552633, -0.642292812969329, 0.3346097065896533, -0.6326132371516983, 0.4574147175131521, -0.37183732427549876, -0.8995637909148322, -0.6330496425666035, -0.7816507135181844, -0.3944315525292597, -0.09015403028707418, 0.11146630583164933, 0.243493807560012, 0.3698231488342451, 0.3713765123225387, -0.47747859411897936, -0.26605894679448455, 0.3401880054143387, -0.7343691524745428, -0.26755859406461946, -0.14733058078834074, 0.1215129092070789, 0.16710179657376173, -0.6933338527155355, 0.3733844231261776, -0.3215205720046245, -0.595252147437199, -0.4978463959017057, -0.051598403665347375, -0.5018890787108353, 0.18366000740545052, -0.5809978745358189, -0.38970579909558567, 0.18132861825136065, -0.2471508243680809, 0.3841011743374536, -0.13748482432178222, -0.24687747328017234, 0.09301371197721539, 0.13680878420158146, 0.38832437942848225, 0.06991003445566664, -0.38189324597054364, 0.4274350830759774, 0.41061220500441, -0.4924138354819596, -0.3049049154293767, 0.21414220337373402, -0.38370516276912375, 0.23255733679617657, -0.06838564058394812, -0.3862049922094141, 0.03875086789991543, -0.08069958106179125, -0.17625396871532084, -0.20397892437779286, -0.7732294640456325, -0.2577681187056748, 0.46232360423387875, -0.004333638365905409, -0.026552787316591723, -0.19190636465726407},
    {-0.0015589810989825165, -0.5606458655564992, -0.08636969048735993, -0.5514162719124104, 0.4968342335987599, -0.12448310089132664, -0.07501558900643084, 0.3970319519667495, -0.015466879414016945, 0.20166112965033794, -0.7724806322114784, -0.7551006188670316, 0.4838630626556207, -0.15498557064846194, -0.20876923255054755, 0.0699308588904541, 0.3673195392141828, -0.24638497121602998, -0.01873877130699119, 0.743690603697437, -0.4972505139749985, 0.4022361389791235, 0.38198626353081444, -0.17439624318908722, -0.1799935003608989, 0.05502595285885299, 0.3895086896812906, -0.06081054958018315, -0.4563039555228813, -0.30577518233510903, 0.23227603674558306, -0.6989482864454922, 0.3254221347793469, -0.26080809873174077, 0.05854591536579665, 0.6242280077193127, 0.2613627124606535, -0.41314055471095246, -0.3129289310592895, 0.2840564584803973, -0.48108708824859514, 0.3580839313537003, 0.4603167860819005, -0.007620210287941569, 0.2786662704094136, -0.21007693111439454, 0.19802700194926443, -0.4717808776682181, -0.2706155515480611, -0.13540809070665516, -0.49457765229486195, -0.20221441663831213, 0.4638083517013025, -0.29722925010564716, -0.08942710631881, 0.015327553580238937, -0.05505792857479133, -0.31069214719361765, -0.7906178628215556, -0.2850862373841422, 0.2051926323447896, -0.6834701673128496, -0.21946715870067865, 0.2432119249289947},
    {0.022025872092039673, -0.15989018767797994, -0.3146950722661043, -0.7701865099757739, 0.3966739672552775, -0.5549186786262046, -0.07224092913643602, 0.03101298741180808, -0.46573019660184267, -0.5329312578622465, -0.38141417294706115, -0.21138900720875534, 0.184593511154584, -0.24234238792751242, -0.2934341355525318, 0.05243842280395947, 0.5451877929494005, -0.45025720339024744, -0.40975061018470166, 0.2857496632161703, -0.052723546559905216, -0.14874646296762, 0.3167691386775306, -0.01662717957244164, -0.17921124699200636, -0.7825056508097329, 0.44022054908340064, -0.2529016994836717, -0.32732765860010127, -0.7505530234910871, 0.2529474305246619, -0.2616310231719405, -0.13393292935661769, -0.4009838401493806, -0.7165469766261615, 0.16425043015868118, -0.2782935207940839, -0.32192369530220943, -0.19126760450931773, 0.0029817865725349354, 0.07861061066147026, -0.1819889106780693, -0.026178093517090325, -0.679953924528958, -0.31552655633989285, 0.31128559276459006, 0.015011901651232293, -0.8200277277464646, -0.20973496086323087, 0.3300876822678094, 0.18382342445294161, -0.40444390024856636, 0.8839787313104477, -0.16228632479736882, -0.039580164208509495, -0.15458923467535965, 0.16319396967549385, -0.08918878328799924, -0.6702500956800966, -0.7949207883652971, 0.46745313231095115, 0.013457060203426819, 0.32214584183934736, 0.06760806789213387},
    {0.16352184554349256, -0.07909746832992101, -0.13526275791505074, -0.16826746469739673, 0.3314856695172642, -0.18715498770551384, 0.016662045698835653, -0.31330496514929435, 0.11208032493814936, 0.07582127724876234, 0.32080155311358594, -0.15321228709780954, 0.6437275560088546, -0.12550650371656058, -0.11005416266007696, -0.011535919763104672, 0.23781589685174967, 0.05397643476463418, -0.2400087266527412, 0.3675689320343073, -0.23719590585244557, 0.760484510136182, 0.18455268484045195, -0.03166041585833576, 0.3608635025451948, 0.13901164563011906, 0.20153004941235478, 0.3766550757139763, -0.058094940077076086, -0.5250648647666956, -0.18593595152882314, 0.2576790244976699, -0.11470832657421912, -0.3964765980014694, -0.10752135830660074, 0.2680204264691211, 0.35893146942076953, -0.0011108938961575685, 0.064769744632519, 0.023924659556578028, -0.10237584383485196, 0.202981842357559, -0.05605994389715494, 0.1371886037748344, -0.5576650847422073, 0.16099639028544763, -0.2479619322218087, -0.2791879847917018, 0.3655291086914204, 0.10689756375843842, -0.02674218051865124, -0.06887188354337008, 0.48741245638762654, -0.17763432740196253, 0.5363521874092267, 0.5541584609425105, 0.6643698518975673, -0.6234634852579286, 0.0012470377743093281, 0.03927765251457207, 0.09447112245460493, -0.5409973530355262, 0.4280255559575423, 0.2632364599393777},
    {-0.3671027680881992, -0.15425360061204502, 0.0671128794342281, -0.14212814700681586, -0.05750217657346096, 0.7352833229016493, 0.45107399074039123, 0.1436921961323339, 0.47738458164893866, -0.18049550596625183, -0.04480749102847278, -0.31676606481068786, -0.20094403202169847, -0.2324786600727048, -0.3953104093048145, 0.6267557330888639, 0.4157904227357804, -0.27540731371224264, -0.6569259809105561, 0.1689353215295443, -0.374776567295631, -0.2219172975829409, 0.016732291424227563, 0.43944309026532075, 0.16599132319907522, 0.10795554852934414, 0.1979343057465163, 0.2995934052297523, -0.6084808283895401, -0.2500120844678012, -0.331227794429364, 0.3050983446655382, 0.49138745043827514, -0.06807719534844667, -0.4490312937361878, 0.2708044740986136, 0.31783008687284375, 0.4845639588026318, 0.008011265586023109, 0.015153123739254698, -0.056173007863851515, -0.33071589784416766, 0.3465418179834019, -0.24018115864734602, -0.442271651568649, -0.13493286241489155, 0.1467037913071012, -0.2570214296047791, 0.6242858583429004, 0.40270901049501323, -0.4098708202739288, 0.45100024662949123, -0.0008743622805967056, -0.3169409104749667, -0.5844164097776436, -0.16181706911697766, 0.32844142119961256, -0.5887001841681859, -0.15281075375680936, -0.15658598978229787, 0.4301846170219152, -0.09822198346318153, 0.002674786084048892, 0.02764161399651822},
    {-0.03467732576255867, 0.011944961338717383, -0.716014240637422, -0.1964615222110207, 0.28844994529147056, 0.33357104655843994, -0.3775934942481715, 0.6513439132708609, -0.6349683003706449, -0.19357450853638014, -0.8403155511300391, -0.8639644659265137, -0.248717901597909, -0.8371960520579554, 0.06139247283315534, 0.15586736299964926, 0.16684027400173762, -0.01017438777837671, -0.23221310578264742, 0.23645587716066196, 0.2131932066166649, 0.1892895660060547, -0.08574247494256046, -0.6192498893853465, 0.5068356544665614, -0.005812692471494031, 0.3662675430675233, 0.10841679382726621, -0.7269045717122695, -0.7024600777835662, 0.09861858619091685, -0.3963186752412191, 0.3224759655662507, -0.5297089594861696, -0.375663067216374, 0.5157893698715028, 0.2304532936844845, 0.4116191509809949, -0.027781929814511955, 0.3049141643069328, 0.4277491718015196, -0.132321569885905, 0.269732295518454, 0.008384341901575776, 0.13919533349932517, -0.6336985344937097, 0.40471413540775425, -0.7569255256514814, 0.344071803092845, -0.10324894689884866, -0.25279559086303105, 0.2854454364734807, 0.20625887571361026, -0.3005296895227606, -0.0690697340408244, -0.4951177084928308, 0.4841365718529373, -0.4778703012328983, -0.49115791008300397, -0.7936913977521602, 0.40422015853260723, 0.24489146822006352, 0.3579035247545239, -0.16173046602682328},
    {-0.32847883925511845, 0.0101857963612416, -0.6623581443379017, -0.3017410053502492, -0.2676022455466699, -0.5469244267581553, 0.045570780230130836, 0.25667673296050525, -0.5212970201569465, -0.07614276487369816, -0.16928139496239283, -0.37615943360479526, -0.4122952665270111, -0.5532028534342385, -0.7580423304871888, 0.03461375689473247, 0.3628952321749526, -0.22362505749522227, 0.27481135146885344, 0.11417618084864109, 0.14062342875896902, -0.028197215406572974, -0.16253598836795688, -0.9339892449263749, -0.250007359941899, 0.08014942918959546, 0.15428449959050247, 0.21830923407411, -0.14009829434638946, 0.15028138139892347, -0.27740303546578876, 0.20685849390021163, -0.2382006728679638, -0.2169748182271043, -0.5409863967447016, 0.34084883298059826, -0.042577590720922334, 0.2875668908295397, -0.1298307924458497, -0.8995096233036746, -0.43004407115812493, -0.1381190797102353, -0.2480936766741251, 0.04641240709237257, 0.46353318123607673, -0.11423720047507979, 0.1300375403250953, -0.8660254002508971, 0.14905611023124435, -0.360612229410065, -0.21459228765450167, -0.19862317408146776, 0.3082500526658703, 0.38370661970686104, -0.21443872048867604, -0.23626279206330136, 0.5980411685936365, -0.22742785333731924, 0.12364014058436955, -0.2667638905283407, -0.08643310212153808, 0.01427876370321469, 0.3316851945274617, -0.17795153471559783},
    {-0.32361602833366915, 0.28140042366046286, -0.08070022606955128, -0.13302960168377334, 0.5503365413702284, 0.19565841597244513, -0.3509324320388206, 0.18459553705259216, -0.021544058129624264, -0.20872707669223936, -0.4803452052500808, 0.7765387836131077, -0.8308523718204821, -0.19756601785337, -0.5249983836026174, 0.015851709266392452, 0.39598434836463964, -0.19027109905961703, 0.33261477842174125, 0.2875825772498968, -0.005491256501990953, -0.19086823761669525, 0.5165381508384472, -0.3274630907446385, 0.06922426850452397, -0.15780332267043426, 0.2505263668546756, 0.12110006596174869, -0.502618615495297, 0.3181439932494712, -0.09731981853892464, -0.27709512350248167, 0.23408751277823564, 0.210725298238635, -0.009573589024792101, 0.5881143588560855, -0.4234087755235622, 0.04890502189097632, 0.1559568696156465, 0.2991714444978621, -0.13234275352163433, 0.23745590606047468, 0.013239265799958573, -0.5472684726043193, 0.18728524716792785, -0.338126856600457, 0.29061349474569603, -0.07755309853588457, -0.771565200821137, -0.23942864450131826, -0.7792806002833502, 0.6149062325112571, 0.2891287329500644, -0.11776091116966271, -0.13812007389095954, -0.1863340062622179, -0.08027840753731823, 0.3553630932277513, -0.7437290585682209, -0.03138153207843663, -0.21490246536438276, 0.2651437550793572, 0.15260235682379983, -0.3539254579167677},
    {-0.1425299546768508, 0.8921299750220983, -0.2575104300036022, 0.12348598122139351, 0.7809288365675823, -0.5538771348729429, 0.030270531104440057, 0.29003554616348554, -0.1259218432641776, -0.009988825842683185, 0.4626586647952921, -0.5490064374089435, -0.029126146896935264, -0.07082275233264083, 0.33119073625895423, 0.3411647840702475, -0.271160454015649, -0.015203602716516898, -0.19121150363742562, 0.14512974578032956, 0.005004028318904278, -0.22890604349731977, -0.18160854778666766, 0.4851700863442226, 0.3139547965199161, -0.048919067203165675, -0.06882141015211331, -0.36189637408833747, 0.22768668674060813, -0.5071989145517102, 0.20261800747203731, -0.09459814347271644, 0.148588830042314, -0.46884179284344796, -0.48032886703356453, 0.662345962038177, -0.04342490818645143, -0.2471230233122081, -0.3257863751077937, 0.3662844053218241, -0.031469632900991654, 0.16845766933215428, 0.24701587686758805, -0.5452908760468801, -0.020469295050517314, 0.02289908523908145, 0.4900429698298582, -0.08274483781716024, -0.12016361255893912, 0.07174531676733392, -0.13299890697141098, -0.19278591932591796, 0.2932481020183586, -0.20882457837037846, 0.1587610199324115, 0.31372404546520977, 0.10144249668004157, -0.23348771555667047, 0.3161951738201691, -0.4876331001269137, 0.17948859858673136, 0.5239918585632392, 0.42801592631717406, 0.6093997111365396},
    {-0.4534830230128396, 0.3384211961763699, 0.34104284353029457, -0.26631655433573265, 0.26079206396328064, -0.1636005765821744, 0.4879245408627935, 0.30510906889321165, -0.18208684629060634, -0.5680574337680765, -0.057574216247787635, 0.4632072135360812, -0.8241729344993998, -0.736971901275505, 0.420658949311313, 0.251801766787732, 0.7464930755793389, -0.2630783135356553, -0.28191537615906476, 0.7314621411418748, -0.14164359459568024, 0.15675619840373517, -0.5874292514861641, 0.22605601445740645, -0.27317823259866986, -0.2066457231519404, 0.39402318011893134, 0.07286045626109211, -0.12204939965059797, -0.17393155156778195, -0.009565808064983403, -0.2571433444017138, -0.1617173095630858, -0.7032588452650559, -0.22198014078961212, 0.45778710691590324, 0.5367347592263618, 0.5955690347662544, 0.10228731603859362, 0.24450800869129427, -0.13537106647706107, 0.22969762960492443, 0.39596792335710623, 0.6951578352145293, 0.5088409235021449, 0.011565026891613818, 0.46605865914656674, -0.31127668327208774, 0.28641959057236854, 0.2300652934815869, 0.3443644269568126, 0.5124108421320727, 0.20678496915803246, 0.15898960907037724, -0.19878485785267716, 0.08269492227528982, -0.19808391205661413, -0.698247174572733, 0.20841882195329678, -0.2787162421326526, 0.2263943301125753, -0.24596636500499247, 0.32892077891932753, -0.33741617594761497},
    {-0.015746201177905986, -0.48369164093741956, -0.4870463079193939, -0.1719237953414105, 0.10533853975174846, -0.25756876145493074, 0.025608122288340147, 0.054840779724008644, -0.07655038598659322, -0.41238424987549516, -0.3582185899826759, 0.17169747603936303, -0.43506611960872477, -0.2579996652565279, -0.5986495820290447, -0.014346040577740452, 0.26551148636344213, 0.24200721287402427, -0.4014063603344771, -0.1469182792948415, -0.28955459503542147, -0.6384833127551186, -0.03298545080583504, -0.30772396756068415, -0.05317225707495276, -0.4708269918370225, 0.1962210123807754, -0.08821416372742229, -0.29384604739782433, -0.29299229845812136, -0.641669133469012, 0.11263985984372099, 0.4017559433443614, -0.1910242282881872, -0.32612017617152017, 0.5335840802275057, 0.5151662606005133, 0.1462383631386485, 0.21035683598383803, 0.34019891005789327, 0.342293682360108, 0.04099103296766825, -0.03406020212954483, 0.23238522888475818, 0.13854638755142212, -0.398083682691468, 0.4057230334373754, -0.5317986899615079, 0.35025671013939813, 0.10199279694428198, -0.6635232766776633, 0.7229679051734405, 0.06942565537753422, -0.053650725637382886, -0.5597441485864723, -0.04657939773430523, -0.051580137909800206, -0.5692962040071993, 0.3276377682686922, 0.028934117302186892, -0.7114040141507464, -0.46200019568731177, 0.2072188434048175, 0.060242155913893},
    {-0.005138426033087779, -0.17297872955151136, -0.38792485235600804, 0.1785781226485414, 0.021881539442482445, 0.4784540964115679, 0.5264429426589315, 0.4910180146000276, -0.45048533268090707, 0.07222808949486295, -0.25661312999574976, 0.6042918387145603, 0.15803983675957164, -0.28407221795959436, 0.3788578507457341, 0.6467866713628017, 0.22312431626764045, 0.27228541838519227, -0.025292733607597876, 0.12111206769794287, -0.05503878399811173, 0.34380056402329756, 0.43390645621839036, 0.2893370096107952, -0.018323028899268092, -0.07107488708376251, 0.0048788635931158696, 0.4054566788976694, -0.5933534138125227, 0.24840591648431637, -0.8343369365374435, -0.03611592066899663, 0.3052241369171972, 0.7869098928544338, -0.5157000410551342, -0.3090313603510813, 0.15697123743614236, -0.09190882650262891, 0.015618378422695275, 0.0709296025048445, 0.35169291119905477, 0.12520512958417596, 0.2890809481059864, -0.2765520918553009, -0.15840319257873148, -0.21490153151112565, 0.43626983532957536, 0.6313323979369829, 0.5674534441278595, -0.05616684824038283, -0.06337758426774014, 0.3666856408514944, 0.49568153334681897, 0.40425882606433283, -0.26664273954657514, -0.28236205599120756, -0.2652052339080811, -0.23757254354161209, 0.153624247810037, -0.2876360536655465, 0.6230890928496284, -0.05944227668581857, -0.18932015343640676, 0.1607686507687409},
    {0.21057892759178815, -0.06932233479366774, -1.0203615966468935, -0.42039759412273425, -0.3278558185268966, -0.2245955622378854, 0.4017475061838238, 0.7722310116549418, -0.5582150427698735, -0.18316263409080083, -0.09042045930225089, 0.09697993603561432, 0.09194578621076313, -0.8718625645251576, -0.004486426011127745, 0.5052294143343385, 0.6643143559175612, -0.09157217066789429, -0.19807349931763316, -0.12477958162591349, -0.34188219761099164, 0.07008168956954014, -0.08639691890178988, -0.30240070599318414, 0.034921745645825175, 0.09069255186804988, -0.2253345114974517, -0.4808829897831309, -0.5818738967979424, 0.14557974031667836, -0.05071054678330325, -0.5987876382028382, 0.2686859781104927, -0.32494877521779875, -0.37394590149004936, 0.3257045028996586, 0.2574207826818876, -0.1278722538824809, -0.09306636247967938, 0.3885931801666832, -0.14017865482227368, 0.3111490276835801, -0.015388736535424736, 0.17383200091537038, 0.409617460937728, -0.6021660264312055, 0.3299506066901709, -0.49706118802722765, 0.0023759741651952363, 0.09299390245405047, 0.2740494312542599, -0.2346191458436745, -0.38263873896454426, 0.6211393444600756, -0.551730310000276, 0.08045288607626211, -0.06409828452740472, -0.672572735063889, -0.26368652847722107, -0.42354590386946755, 0.25597706725812974, 0.22429486920963193, 0.3373781434314193, -0.21091053427822504},
    {0.025279627190237346, -0.34644323892580603, 0.17537814171725516, -0.5868977340822121, 0.20348265700237322, 0.17731093769168452, 0.18396861112383148, 0.1679797992921103, -0.6848326117720052, -0.24637991712453136, -0.14022146186787893, 0.009057143111587588, 0.06933845807860484, -0.012538247265293867, -0.07788194811904144, -0.07310448154729074, 0.08508426334973931, -0.34813254726110465, 0.5252308293565624, -0.0492146431638436, -0.5097486154340187, -0.5586252884841445, 0.47408577343174046, -0.06486516158004113, 0.5794391112351006, -0.5195356193044205, -0.2760509383363771, -0.224346552881336, -0.15849436692105062, -0.6404751863563397, -0.03111624785562711, -0.6796671592646955, 0.514306207463921, -0.07662994658919822, -0.22408697138864567, 0.4284741034116776, 0.2119571217893318, -0.5002437552442424, -0.289071530792125, 0.17592001293688203, -0.17130361549620976, 0.5574220025577532, 0.2787715131903734, -0.02121880506016304, -0.09616401854741656, -0.5604983218930457, 0.4203932358965408, 0.02697586109341632, -0.600521608850945, 0.5974578944324976, -0.00013498580420922922, 0.019720476671609508, 0.441273170409161, 0.36536771419338543, -0.23183328581062548, -0.6346606196032046, -0.21238909934076, -0.5096933239155642, 0.0036407965409582027, -0.285760453633986, 0.2650615007964628, 0.16836139343802398, -0.1382691241804461, -0.012930114954865853},
    {-0.056896236956549114, 0.11470028053487984, 0.1227571246372403, -0.6970442854383321, -0.031829577461019956, -0.43699872406589557, -0.6489935170062383, -0.11538388834722485, -0.7701344473658178, 0.1620343849289427, -0.6570260056338871, -0.29888098283405706, -0.06952847911705447, -0.21826387455257262, 0.14941058413917818, 0.48688717031824513, 0.5305703442020949, 0.19524453330186942, 0.6024425453183122, -0.20141667146469597, 0.18797222026843274, -0.20424705727735987, -0.22614652794512766, -0.2736407289386691, 0.02289294482960781, -0.43444692127971757, 0.5469126803820585, -0.37765601870519194, -0.3728502055507304, -0.5427006557557701, 0.28355688006011076, -0.016948981974858685, -0.2753240894260196, 0.5983057506181128, -0.13070949347001964, 0.6436691209313259, 0.04324806534140251, -0.49920943756665276, -0.4281123095058779, -0.3570855550046041, -0.20501163061216385, -0.0448281246021886, 0.22542647163222979, 0.42812602626680557, -0.3503629796979032, -0.13346666662105044, 0.053299664477589326, -0.2363713475539326, 0.5599936641904162, -0.31475580958404203, -0.4122293271543476, -0.47744682541577277, 0.43828693525746854, 0.3533628487607673, 0.4208549983120846, 0.27905046128174754, 0.05520300486398407, 0.0029908112561553095, -0.2160592092512797, -0.18335395829486847, 0.5441867671261085, 0.09498674157875196, -0.056949916373600376, -0.23523517954464915},
    {-0.0285728571714347, -0.45951256752399827, -0.3364235843061277, -0.5662063779299162, 0.8271152020723176, -0.2596698266030436, -0.1472431033841275, -0.061203493661762184, 0.07873851794830353, -0.046060125350177734, -0.35909558490113785, 0.5549388101900548, -0.17856374736764719, -0.2572767445226665, -0.3200424878751604, 0.3744066139588508, 0.43049084196752174, -0.3810743171557308, -0.28796502286178444, 0.21381869269068557, 0.09490900795816884, 0.5018786404518633, 0.31204948749457867, 0.033855679677893595, 0.537772239084129, -0.1762966655625394, 0.3541978790894027, 0.3689397039975965, -0.14303449883655492, -0.4169337900515659, -0.18354205971728396, -0.17511964279490863, -0.19831183770242175, -0.6254416111803334, -0.10084841780688054, -0.2379781375616943, -0.3414180178113406, 0.35136647719611575, -0.2553002686955128, -0.19324169503067526, -0.12817665815483287, 0.42717067366709405, -0.5164645895180047, 0.23810902478351578, 0.2204527253136963, 0.2195421126780881, 0.3245587433963468, -0.37033664741989136, -0.1625195154131495, -0.5248315763924228, -0.45127826939492205, 0.18677211633124105, 0.3301384744805718, 0.016245398246743713, -0.7191064681247804, -0.0596984177956428, -0.4601779628162431, -0.3841982532185799, -0.1918396883814803, -0.03044697827257492, 0.3507846195297693, 0.16632979377310686, -0.14568907044901208, -0.45925360269103344},
    {-0.004003753951178701, 0.06231805948452858, -0.06086619347261728, -0.15884788753005102, 0.42724351396862614, -0.3132000192275985, -0.21038132662441195, -0.1296021684460151, -0.03713106498904034, 0.11328500276716112, -0.602270922964623, 0.034492778038073914, -0.6994505502602789, 0.1787627675349492, 0.3018471101731149, -0.2960015792170805, -0.11522462795184034, -0.06683840673577396, -0.20502493677219627, -0.1398481756727235, -0.4633713138715194, -0.41186711519462665, -0.16756053929107972, 0.2564351632997383, -0.43131653772339884, -0.0005540646950026243, 0.08378069319103684, 0.19819375846952256, 0.030680844260723112, 0.026195213146964904, 0.5279523192911577, -0.6197220797555533, -0.41858633771446113, -0.2979737460870846, 0.19820543978525143, 0.3823153989991154, -0.6865716304481823, -0.42522622054536546, -0.09454591364068823, 0.22538959411678, -0.23149686811096076, 0.6811574651848806, 0.02877645897351582, -0.6831866300950155, -0.13196483906589623, 0.07041668148263205, 0.42952520200794897, -0.4158677308592674, -0.0723637849341844, -0.19480007517752104, -0.03941269560405802, 0.33712160285359843, 0.6722486172233749, 0.2179957222196111, -0.30361677811797466, 0.5930293107084129, 0.443072677053122, 0.49551856899256425, -0.1867535832255714, -0.45522370985905447, -0.193622913275383, 0.5564279640646582, 0.41785438824699095, -0.2298165500998778},
    {-0.48301709591863906, 0.2224134170985006, 0.10154693962498733, -0.12909262988661127, 0.4061132012583463, -0.13605608204444034, 0.15005509989617397, 0.2958039848913731, -0.0799828077885129, 0.03937419057533791, -0.28827547018681804, -0.30351422889396407, 0.38758265620149057, -0.005339060224551623, 0.06054621035624713, -0.3723865467871957, 0.1171630529576794, 0.20684941394444012, -0.031108578262666883, 0.37374173338046146, -0.41500456419890597, -0.33803076824878425, 0.39957094403984067, -0.5853525456330064, -0.38511810072190505, 0.1698929192988991, 0.528482774117415, 0.3651235826659629, 0.17345532372389044, -0.12024116786553428, -0.09715503426343347, -0.29452492184006207, 0.22590419503049222, -0.013477655889119195, 0.1399438634769558, 0.40058922861531526, 0.09807122379382395, -0.4941611734973596, -0.32850074442392024, 0.7293778084486281, -0.37917961629629154, 0.3191483339659895, 0.15885171899322142, -0.25549303230036735, -0.11313460800574963, 0.10856557237035096, 0.40137074786524835, -0.350187456391466, -0.3316368568641135, -0.2599642417341222, 0.2266311589051277, -0.10492221226290463, 0.1931599704953116, -0.2561386219768719, -0.4121216668409284, -0.4244812902464221, -0.43880027393085247, 0.3224363416733791, -0.30696731270724154, -0.25607131248067977, -0.17849105300245038, 0.2709740715039029, -0.5118717831588075, 0.11434152168225545},
    {-0.10385632514301466, 0.09509765528561583, 0.5181777856544579, -0.42844196933066814, 0.6250856374892012, -0.11407336150750448, 0.5845169190759867, -0.054948793091413706, -0.6034354862406608, 0.2889821078412591, -0.2543037702447978, 0.4217556242397125, 0.21104470487379964, -0.03707960196570011, -0.18107335999632157, -0.15103854020968926, 0.4368744379143537, 0.00031999496361366465, 0.3066367503582999, -0.6270925931460202, -0.031192510691987165, 0.19132533572415042, 0.26362459208672584, 0.30465802577118956, 0.4345195754024637, 0.30838807662783263, 0.2692602079298431, 0.11426681665049879, -0.2114520643292952, -0.13853930806919246, 0.7790517523923685, -0.1814562347429476, -0.2776734703873245, 0.25363693071483245, -0.1644545151088343, 0.53996580946084, 0.24317983801518003, 0.06996070145259962, 0.4130902461920504, -0.45335847670423574, 0.10479354686124748, 0.31963582724116535, 0.32602455057570284, 0.032961319142181436, -0.3247379053238293, 0.5377489070077266, -0.009748013181553895, 0.2870096322213902, -0.015850633113445454, -0.17226300165603597, 0.016409135917849486, -0.8375294946049064, 0.005309093436658132, -0.5422179692854785, 0.4817407110076314, 0.5196735232300134, 0.1770331411144173, 0.028056401588731676, 0.4328150847322758, -0.05028242228828054, 0.16201191277175025, 0.5879161646480731, 0.6201677411830423, -0.17918308263547217},
    {-0.021089418545608894, -0.2037708557374959, -0.6143337393460884, 0.07707141348970827, 0.001631473595083054, 0.005084666777528008, 0.3445777400334219, -0.17615100037837098, -0.18822279812841494, 0.4744789563547258, -0.1688012967137203, 0.19488829074658243, 0.41085501498406135, -0.07226520326180348, 0.030307379623107766, 0.5047907931634066, -0.2691526746326224, -0.023899996723013017, -0.8176955407904738, 0.7314408044782662, -0.4214140141070072, -0.2491277272045565, 0.6636944171143901, -0.04381277746039755, 0.3286559521709909, -0.050126973793206596, 0.42763396003865306, -0.007960615021578223, -0.3757577861128986, 0.12118943504791861, 0.861449762669601, -0.1174260592626733, 0.09865250586438981, 0.5643177303985258, -0.0868156308158443, 0.11056376944347047, 0.12279393855936775, 0.08416050894387343, -0.3360931125873214, 0.20951955926471755, -0.04490482090591889, 0.43948987097407216, -0.06874146626741987, -0.17396910738821494, 0.046425016946245005, 0.4866912486497499, -0.11063062181309272, 0.27329830681144396, 0.19964695682954142, 0.165782272450729, 0.1503858482896963, -0.6549193135044352, 0.14055571041954873, 0.07766087576420991, -0.576014778899827, 0.1342057672942357, 0.3048820838507163, 0.4252565605079161, -0.33213709583731166, 0.4088940778366587, -0.09058638461418914, 0.07125415549560987, 0.31175064746089687, -0.6027178295335917},
    {0.042848000277224685, 0.2667375563246263, 0.2974532903684176, 0.4907250114905348, 0.13144003475730204, 0.12999268367356903, -0.0820787308992146, 0.19659602731863554, 0.07091749608146007, -0.702684971361339, -0.46568627842945165, 0.4470527822064836, 0.6752700912117034, -0.07252169724198523, -0.4495326129557202, 0.024628700656805592, -0.00023390541561728732, 0.14481804563143352, -0.44585693451195946, 0.10855467978125566, 0.23605184421386427, 0.11361665893759428, -0.14166619696642563, -0.30256742216586086, 0.07039204551079588, -0.2026034290068049, -0.19756933034222823, 0.23378965363264628, 0.08042715411268772, -0.27757849486800834, 0.11586562886828317, -0.06855430013626881, 0.0163698057458084, 0.0005323858113921331, -0.30594581183626535, 0.18937229331804542, 0.5698252385420308, 0.17940699340194893, -0.4710756487932054, 0.3372242587548575, 0.2854744131655059, 0.29005212692080984, -0.6537102116564824, 0.5616933877746321, -0.06736480567194968, -0.16827091376919548, 0.21284574272109838, -0.49944087608876786, 0.4645802728393618, -0.38844199624887077, 0.13023222623880928, 0.18371142152488662, -0.14084410128041225, -0.16342667618208828, 0.3717090749552794, -0.38718945146339767, -0.057973165646128984, -0.43699616779638367, -0.17693384947700894, -0.5687592333238216, 0.23926624058617313, -0.4063410719719832, 0.17664925588174898, -0.19941970525310726},
    {0.055673960240806133, -0.31102232509063377, -0.27960050393154334, 0.023703053057334045, -0.3573001972097971, -0.18951049437422784, 0.7159382804567811, -0.03325442251316235, -0.20753862574578538, -0.43627522900465127, -0.11498520913125834, 0.16822820263421162, 0.02853479571060024, -0.41431951185231886, -0.22025735958443032, 0.3130011767641676, -0.4312875500980387, 0.14526107835193144, -0.8687178691604629, 0.43043488970112254, -0.2568116469949625, -0.4353075038254253, 0.3388131648651063, -0.38218856628111053, 0.21967731665294613, -0.07872130744140096, 0.061317614221228445, -0.41867522195454615, -0.1480097637624249, -0.5509228615969304, 0.0007213439287888872, -0.25892800392761234, -0.6394396891485781, -0.021889063667308754, 0.24581145327088486, 0.40967778587004117, -0.029103544000316037, 0.027524730568790488, -0.326688345345368, 0.38803238631353276, -0.38638983501972607, -0.22630058501975792, 0.1616891040539312, -0.06811549258632037, 0.45359181962017325, 0.11530594544922694, 0.22609451485856366, 0.015175130636417131, -0.3337352068703644, 0.6790554033584391, -0.10374021909094625, -0.08854733404343115, 0.054098467976201645, 0.1311657831432063, -0.5807150291092552, -0.0016148154333212688, -0.5431728855891054, -0.7311565944165317, -0.041063643570391356, 0.09949479452865123, -0.3652785445822335, -0.17770981154565496, -0.12261700782049627, -0.005518066749259552},
    {0.07203565703361307, -0.11918467971655869, 0.050384765476453555, -0.07475545753287843, -0.16106336382965275, 0.23057370556339152, 0.2685799977453254, 0.04057607465611553, 0.04285102947826175, -0.5083165204001137, 0.27583242044069284, 0.4570727908208105, -0.12330185303877832, -0.10818860972588991, 0.23509110377548703, 0.2770989401975034, 0.14558596312721497, 0.06671264634201993, -0.17924141530372842, 0.16131796474257726, 0.19347914198145078, 0.38800412651075356, -0.0462809336575332, 0.29013564347294774, 0.07297257621713048, -0.4161518965600729, 0.7290120884589806, -0.3074823739176733, -0.6599035164254895, -0.4940963055587547, 0.1535475709347631, -0.060505156361069234, -0.006552648252029742, 0.7420292665944623, 0.17791315305118757, -0.14228229394148134, 0.07915990809485347, 0.3167046975040314, -0.3270952774219795, 0.20454113349528832, -0.059025334818643665, 0.24155880593797238, -0.0453542551744533, 0.03195138416117525, -0.11373795448924814, -0.24382107968160682, -0.3099325520149032, 0.0962366897176448, 0.14685093261279425, 0.09301561930873269, -0.47154911793993254, 0.31381488988656786, -0.0430939955713352, 0.777345879965439, 0.3418857390951714, -0.1360096056555118, -0.1217280515579699, -0.3960140579844, 0.6463299062131568, -0.352127960496546, -0.6393953607016466, 0.2698636654553023, 0.6654806267755158, -0.26571853411203405},
    {-0.18776956256650784, -0.5225465627195692, -0.631377149375431, -0.007346165780519682, 0.534599412779802, -0.5740863894111649, 0.06746258852683074, 0.6156020974214595, -0.3682217875702331, -0.2638017885943917, -0.27838670513501124, 0.06678590626381563, 0.14587527035762504, -0.06554175918469586, 0.47740397667225204, -0.044113044115549914, -0.22472243863625108, 0.05636975170145528, -0.5154941336831991, 0.6677638602629585, -0.33331211725858884, -0.21205115480495296, 0.18232911071216873, -0.4166524560232221, -0.2309674218414487, -0.07340978666874849, 0.05899420993525873, -0.25355442932853556, -0.6409960789400508, -0.012318657576746578, 0.37315709561302624, 0.01276762442858664, 0.5880797290421003, 0.2399018163992795, -0.08145792990323064, 0.2660318145030063, 0.23875692441990354, 0.519369583971621, -0.09059102619936168, 0.23795464381410106, -0.48256891648831746, -0.022845922845048685, -0.05518210502154623, 0.7971103492761497, -0.6207149181441877, -0.5642630801515556, 0.1517052358371698, -0.29163231128371536, -0.11130266475925138, 0.08956069260347416, -0.6440706594542227, -0.18726142479063607, 0.0021156831691474844, -0.32873716528691055, -0.680424319438075, -0.45609609621048597, -0.3270145045530284, -0.14532584461940984, -0.30535844975292564, 0.11746906634816526, -0.04809284983509028, -0.2515103242209223, 0.6352460284356513, 0.3667864052316845},
    {0.13572380382886887, 0.027966894513228206, -0.2897682629487247, 0.012397035348332896, 0.3934340768882285, 0.4228534068805973, -0.06663396460635188, -0.07920137272715193, -0.5295161085741177, -0.19489468341852212, -0.0434677768090855, 0.4165169411685113, -0.11253429216555089, -0.439900258072137, -0.373084137838671, -0.06187996561424516, 0.03246183433269944, 0.3146199512055986, 0.40321934678321364, -0.31974146464702763, -0.11688179986575506, -0.143552568361034, 0.6354350681770468, 0.38921571763287377, 0.36369432258111495, -0.04816444622345538, 0.49969346250888336, 0.04345093905804146, 0.01954465417283581, -0.45202675208302273, 0.367783208382882, -0.8181554545792395, 0.2921209354208805, 0.4307061105450447, -0.06718003450440252, 0.329423334902189, 0.17041060826029486, 0.2094666218520361, -0.3159472413514782, -0.023760562761859068, -0.24716395237178265, -0.19809040921474722, 0.5893392881513416, -0.6301217507625927, 0.3923163945360662, -0.4689299597098063, 0.3482001763414551, -0.16052386784385161, -0.7443203719927912, -0.08493193817581621, 0.6836975264156255, 0.5183566452750459, 0.6311180509149904, 0.050986441124122234, -0.35398023146574886, -0.751166767967271, 0.2245488529224486, 0.30274996495006706, -0.21816762852134264, -0.6350030302662143, 0.0869504551176553, -0.6189718953893797, 0.22336783680762493, 0.4710375432266146},
    {0.09692201026317898, 0.17901746660900264, -0.27595942460429534, -0.11738190378826842, 0.059871020148925695, 0.47187521671980415, 0.5943940882054297, -0.3718899012558973, -0.4294451100906639, -0.1348201875559734, 0.21055048074282692, 0.02133186572209771, 0.2689635159273575, -0.5020425228474722, 0.15848611228672022, 0.16791299386431982, 0.6902531530409142, -0.06794366640551612, -0.23984863068618922, 0.3803363215530966, -0.45626853941417833, -0.1558515439773953, 0.46335907169206514, 0.5502595654908189, 0.16489830175873166, -0.09520821578043454, 0.0864539879944646, -0.010816458895210851, -0.275142133888151, -0.02838720009261104, -0.017282957792706753, -0.09979158128700506, 0.36508758189869145, 0.2227006095691653, -0.22986104281551167, -0.12152491472799007, 0.5157847371020594, 0.018441265942954626, 0.08897657579374504, 0.21818204966535362, 0.1295893721177694, -0.22327004326253866, -0.12888068278515313, -0.7459720818245856, -0.11698412768925077, 0.0390587128427475, 0.2919866836592472, 0.06753804168615982, 0.235736272649246, 0.05878237475604369, -0.40798076944117617, -0.47167371798154395, 0.2144770082382047, 0.050125052108609694, -0.4362953559719516, -0.6654474700920733, 0.10979704948404574, -0.5113566099711769, -0.5536032958340807, 0.16298557312816322, -0.2351550030514518, 0.28626627560011214, 0.35615655955713166, 0.32979336154527816},
    {0.7221701432575364, -0.15002917539039748, -0.022092345373650128, -0.6368735766133802, 0.4616239547638882, 0.1881396208340582, 0.463954072876764, -0.2946415789547064, -0.3371643929914646, -0.36941381902892306, -0.0057800602706609095, 0.8769127380266521, 0.499366080240457, -0.18095096620850482, 0.5937497742851885, 0.1286058792202521, 0.3872089345664224, -0.30388610437680635, -0.10294386634823639, 0.2169351043027541, 0.41872019680368705, -0.3573085378723952, 0.40066424204502604, -0.05840877987143426, -0.4953870747869244, -0.4574275767056817, 0.433369034563926, -0.015510592882773837, -0.014382001997064357, -0.6153685968015704, 0.3911044797492204, 0.3638285477563913, 0.4559727373390071, -0.06991697487142802, 0.03610286319199802, -0.1946979307766485, 0.42773655222595386, 0.04170346952187601, 0.2192303360015187, 0.22254784203692562, 0.11046271030845264, -0.521602548212314, -0.07016447851475117, 0.4969276079778797, 0.5548490778369906, -0.27673807271422574, 0.43835161148331053, 0.5079827773268344, 0.1679035698844484, -0.08941954749144261, 0.36395388565237186, 0.46834850613056483, 0.05574479183740781, -0.7608308815854682, 0.13939637675419853, -0.0951224047388596, 0.5188257009723759, -0.06313399167399145, -0.05307076420321215, -0.21285372611736325, 0.23899326575343957, -0.3302342134625746, 0.4338791209036419, -0.27483206633755103}
};

static const float b1[64] = {1.0328715169758191, 1.012300581852041, 1.1039870975854817, 1.1035694803165383, 0.8961823819255534, 0.9987283229903051, 1.0502293673564707, 1.0221424367078227, 1.0876189868013149, 1.1240670572633376, 1.053538819314094, 1.0792663196011019, 1.0875806035494078, 1.0746243145776253, 0.9984402065932517, 1.0509729108374937, 1.037545874510907, 1.0267982811858456, 1.121677719993464, 1.0845604238082094, 1.1073117775754024, 1.101633404672938, 1.0242495592656056, 1.0674973733239816, 1.0630628806787061, 1.0867870042589558, 0.9627812499371651, 0.892381511804178, 1.1041726019052645, 1.1022346520074926, 1.0484112595013562, 1.1086505549098862, 1.0387375683261943, 1.113471411666754, 0.9794824755246253, 1.0048482964959322, 1.0625992871815533, 1.0464343295682752, 1.0014489655234178, 1.0147208089922244, 1.0378754253979476, 1.1260662082995125, 1.0020124786073248, 1.088568161509897, 1.0725223884730721, 1.0500048911774982, 1.0033100129541936, 1.0756231348789749, 1.0888312637026978, 1.0226280126294889, 1.0436927568382637, 1.0577579685877367, 0.9338093884237451, 1.1007487389897535, 1.1325846202322658, 1.106960104651214, 1.0199533444802327, 1.1174623038842857, 1.0784532082996845, 1.0902896427303603, 1.0341134641848941, 1.0655879109528938, 1.032919764017264, 1.0796977483278813};

static const float w2[64][32] = {
    {-0.195873500523307, 0.7955920505562821, 0.3553355776388598, 1.1748193135386997, 1.1359505575878666, 0.7560589515065613, 0.8308744215058603, 1.1485785863155749, 1.0547670218528375, 0.827761752598545, 0.5509697013982346, 0.316613139474045, 0.5619628083981746, 1.0366858153302223, 0.9804767968797118, 0.7433119205171528, 1.0291590969899025, 0.40210053755632624, 1.2006807124497096, -0.276251006315332, 0.4140668767110151, 0.9478086443756243, 0.9248742796590324, 0.9469839961243588, 0.8280687402696876, 1.1950449924352673, 0.898071937578737, -0.012047728620119647, 1.0928512033179403, 0.6905667284085102, 1.1581754972973684, 0.5602341354259031},
    {-0.2716416185820962, 1.0074363077931634, 0.9196424790234601, 1.1189973077377853, 0.6276186573652579, 1.144314247618766, 0.8203911208910493, 1.2289855180164186, 1.1991545562301094, 0.6830528188021519, 0.5085683573149401, -0.07819559909278159, 0.9200926486173548, 0.9104859602113267, 0.8961163342667084, 0.8838476511201678, 0.9478450910359495, 0.8056563328312631, 0.9275851497945191, 0.22084514806234487, -0.15670356242555689, 0.9456271397774103, 0.7871047729007905, 0.8307568012295528, 0.5468527210813053, 0.8770592738341689, 1.0262017160929042, -0.1475667248247203, 1.103617033215151, 0.8497423736670647, 1.231528477490027, 1.2614522928690561},
    {0.24580475595885926, 0.8122648515288188, 0.7426669462412251, 1.2546099437144822, 0.7628739087359521, 1.029459114552795, 0.7926529130987523, 1.1913389122357834, 1.2577635953536082, 0.9335704331914831, 0.4382928080786848, 0.3415682553030757, 0.2634867480983349, 1.2774439924094128, 0.8302256750671991, 1.1175463966572148, 0.7663179799681827, 0.7630547657057256, 0.8823365593976318, 0.04567033689805774, -0.10666014500674312, 1.2670949602311183, 0.6154262476642643, 1.0400052886830833, 0.7025177864684089, 1.0030063990337394, 0.8706413130319087, -0.058802388896217986, 1.0439407846363702, 1.1369165514502682, 0.8734061216662302, 1.1420596905583456},
    {-0.5583589575013425, 0.640522297104153, 0.6249605729281061, 1.0831103806297127, 1.0871418009175706, 0.6933426162079348, 0.8226737042606752, 0.8151265927814484, 0.8864910121782987, 1.1067425878578578, 0.5869187616496427, -0.38825759312837294, 0.7612957625433217, 1.0242814117083558, 0.907691424921905, 0.9835120786511536, 1.0425549631417774, 0.4842880810327371, 0.9377727007851476, -0.1958713958096646, -0.24391135233940273, 1.109532528395562, 1.0440937377696486, 0.7888853506019565, 0.3326825037377878, 0.7732250378018045, 0.8925342975392203, -0.11771903852561413, 1.0402741800526405, 0.9087911126147902, 1.076414705647233, 1.011838027151599},
    {0.1699336920993358, 1.3316893092718207, 0.6353197197165422, 0.9918859964950318, 0.8602408820063036, 1.020282368507776, 1.2750271993126852, 0.9806377057345819, 0.9220612553866221, 0.8314060922260637, 0.5299614227776691, -0.25458791386448554, 1.2888678443069128, 0.789707737460184, 0.9247015988605299, 0.9417091212135219, 0.6924587967503, 1.0940247463352204, 0.9095051960304084, -0.08694100570246356, 0.07933173939653593, 0.8443036526859429, 0.8763448200298787, 1.0607078172138902, 0.7500705261227468, 0.7295603691898283, 1.0775969921269224, 0.16825167260883747, 0.6440155959889055, 0.585667406127064, 1.154838867277576, 0.5494701502390399},
    {-0.07787988998587522, 0.7432459730572332, 0.5433894857343629, 0.816665052300491, 1.1480866166231343, 1.0416249789483505, 0.7845795628455037, 1.2302321655180442, 1.3237061670280403, 0.960611137591596, 0.5593458257516405, 0.20570110151663293, 0.6703477836395634, 0.9059626105689081, 0.8777652792846763, 0.8696666241401428, 1.0764078589614614, 0.7355908372408805, 0.8542852309463707, -0.15156245983061667, 0.28420463126574697, 1.4322041326551882, 0.9538968903369412, 0.97151838323069, 0.8044474047887681, 0.7892026517532594, 1.0276183085098398, 0.2445625306972723, 0.8426384377112924, 0.8577179241337785, 0.8240595883581832, 0.8928479012792032},
    {-0.19219528833167474, 0.551072840530364, 0.7855132067004164, 1.154541302582702, 0.7372003778349613, 0.9730810589924206, 0.8891646128910303, 1.2615414505271463, 0.8005640688320291, 0.6485001645300874, 0.545176289835027, -0.1766222085007073, 0.859186528431066, 0.8771670071119626, 1.0778955245513413, 0.7491460336019149, 1.1177183939516835, 0.4695535319203783, 0.5777862907942057, -0.055660978237294004, -0.14520075348802255, 0.9392081032228613, 0.9076027989431669, 0.8834554129003549, 1.0862357551892297, 1.1144284913302471, 0.8899767179936131, 0.024546109121350402, 0.7054435050032448, 0.840166847960088, 0.6644995378008476, 0.5006743433511509},
    {0.20299180042778417, 0.54577025437764, 0.6035750712992738, 1.182493738769405, 0.9121074627188338, 1.1195075381217081, 1.1043031807774621, 0.9481606158129408, 1.0009257456263132, 0.971181202512455, 0.52245521056361, -0.11342109705546088, 0.6923690288891503, 0.8069642815640213, 0.9276359499689053, 1.0024661650152284, 0.6538802845166726, 0.6731882163730246, 0.7472207064894887, -0.3459222564419553, 0.3080250280431341, 0.9357139503861649, 0.993706595297925, 0.8130455727951551, 0.6873985536883078, 0.8488022165195346, 1.0076214690780476, -0.026014711466670788, 1.0864944875598446, 0.8484273337338076, 0.8023282306707433, 1.0502759832146258},
    {-0.05422096879968417, 0.8476616660466756, 0.5611728973791, 1.0075574301989771, 0.7281612717715389, 0.9686423150030969, 0.8638787764132683, 0.7792864124940985, 0.9019274932586617, 1.2366575666516415, 0.41678548352868605, -0.3253230806404557, 1.0109233687844892, 1.0447829781976352, 0.9621382118907442, 0.8592835829970438, 1.144218718793296, 0.734644676346589, 0.8880856156690399, -0.2030415514666967, -0.15704760208317672, 1.1000661975060895, 1.0592518748335984, 0.7541297210703379, 0.9888516508766027, 0.7109730872921471, 1.0449457346723456, 0.03859863936103477, 0.844387866320329, 0.9358288866774952, 1.1258067118859834, 1.1238985022274757},
    {-0.09206808951829568, 0.779867832732566, 0.7340908374404144, 1.2273304363158268, 1.0793920410611038, 0.6878601424583387, 0.8616614849169314, 0.9691994357909625, 0.9620660606525757, 1.0901003089559074, 0.6984731915237692, 0.13788158738278894, 1.0681893792994797, 0.6764418551618926, 1.132613650434065, 1.0355941908372759, 0.9551905506061773, 1.1015571044541426, 0.9340961699722227, 0.1889371549874664, -0.7238909577390666, 1.0403505439173841, 0.8409686165311779, 0.8943114165662314, 1.0498799491441337, 1.0009420450305948, 1.0539747557550856, -0.2813078239746109, 1.1566558079314113, 0.47003819784852596, 0.9137649440971576, 0.7583143024063863},
    {-0.10301111728878203, 0.6648246376097003, 0.5384281133083306, 0.9634125990748966, 0.8254157139767689, 0.9053799123619879, 0.7801289948605167, 0.7635836668352961, 0.8015888238318416, 1.1014110440281502, 0.42150397172950027, 0.015360034200075439, 0.6733903803754889, 0.8980877134964899, 0.7097678636779577, 1.092897556767072, 0.8351010559788615, 0.9096610800141176, 0.9645612061938996, 0.16856992714712624, -0.032095451646488485, 0.9782088169338788, 0.9145067040425269, 0.8432764022977812, 0.7898522571004367, 0.661076775216396, 1.2157950990459274, 0.1738142872191266, 0.8495022492881151, 0.6830076425267596, 1.1272943654478695, 1.093067331886518},
    {-0.7229344413569837, 1.0537164570784736, 0.8341721682077841, 0.9401013699360733, 0.8272029234212088, 1.1428680032234628, 1.0924626876965344, 1.2059597713692953, 1.2704333404298591, 0.9219007187099271, 0.3315398590665975, 0.012904338374538986, 0.5360209170257135, 0.8712824602952183, 0.9146206057714509, 0.9755687782510866, 1.0470465205788126, 0.9253361248588765, 1.027925568333398, 0.017645308279567024, 0.01509455579692139, 1.4357006172714155, 1.1182277488851453, 0.8630198224609306, 0.6193273434305635, 1.0469471331437172, 0.884798180440542, -0.07373480204382464, 0.7569430339046928, 0.9939963740705371, 0.8339627932470395, 1.0236505854189542},
    {-0.19246436260584435, 0.6159708165836895, 0.8022712120247447, 1.0287095579099943, 1.0980364196056822, 1.0316371817122765, 0.8199380735797872, 0.7133306948259373, 1.0631182376591355, 1.1847805591070584, 0.4794102740535313, -0.2154593411949347, 0.6115137083831197, 0.6755624872808917, 0.8996357730022775, 1.009629296468935, 1.0038718048687427, 0.8097515987814273, 1.1686237831953799, -0.15848929111829924, 0.21027430424448126, 0.9887767141864817, 0.6696447387759255, 0.7716070990301894, 0.7797895643364718, 0.9202432484255589, 1.182317989414367, 0.05639435397048862, 0.550929233593142, 0.7306920768289767, 0.815419520175969, 0.9562023333194488},
    {-0.4156431327400208, 0.6664420419673593, 0.6022998134065614, 0.708673907509599, 0.7272370210580397, 0.9970408607817212, 0.7892148929350141, 0.7988867068462024, 1.0446216360179998, 0.9051231185671246, 0.8314383045926147, -0.18723201691746366, 0.8419571977527898, 1.0571507265212692, 0.8670472654239916, 1.1853652252039293, 1.0801732214025586, 1.271117542153741, 1.0400409006815423, 0.07631204329594131, 0.35534787571298115, 1.1869768156625449, 0.9279721781337492, 0.9137956548681982, 0.9370493826934888, 0.8914697121969538, 1.116261539070415, -0.0644421811953541, 0.8370648875937022, 0.3743465653639975, 0.6787184814129258, 1.0065905750707635},
    {0.11569341743402312, 0.7925813522910241, 0.5626536713583459, 1.0520896348793658, 1.0792361323694273, 0.9933928275042804, 1.1530372537407085, 1.1948448406365166, 1.0346925061141043, 0.9767910975414004, 0.6240199994417167, 0.1270008029727584, 0.693924312587776, 0.8285267855326143, 1.0268938875833524, 0.7816279802794962, 0.82249588237526, 1.4038059715349789, 1.105566825273463, -0.044788795938879127, -0.06870072774530718, 0.725196079407617, 0.8886217305167897, 0.8679138172919671, 0.617675634886265, 1.1104722726203131, 0.873214260176953, 0.1554797766606776, 0.8183354059302967, 1.2276632922251047, 0.9528154905252653, 1.172159644245668},
    {-0.27918401387155295, 0.9189989222584275, 1.076711471834235, 0.791326728351964, 1.0481505484813496, 0.5456390520464883, 0.7302844679034317, 0.8398630024914165, 1.2012068239350813, 1.0802397215534467, 0.6328054348006831, 0.039169579560256004, 0.7524742205617064, 1.3012108685948398, 0.9564240556685805, 1.019594797841051, 0.8932689223811966, 0.6676236203330421, 0.6148346282064375, 0.025259245614679657, -0.3891869858819498, 0.8108474749132902, 0.8091405030943682, 1.0114597166568673, 0.713560222843986, 0.6842937506116343, 1.031497663449003, -0.2497788481277422, 0.9318181746862776, 0.829354563324984, 0.891778566370994, 0.892632926840342},
    {-0.07250827851550011, 0.9785890355108993, 0.4977385495237004, 0.7885573565708767, 1.0546434089409238, 1.1004096331184687, 0.7187013843455837, 0.9786621656407127, 1.0014224812044608, 1.2952293415116958, 0.721908829530048, -0.19129228153016872, 0.9443495371796738, 1.0066079679992843, 1.2631052920396313, 1.16275771300616, 1.0918845472001681, 0.90409239938344, 0.7763955141809857, -0.2594323673975611, 0.38001848113869263, 0.8625464198342865, 1.2050792797531618, 1.3179249962002668, 0.4994692831883851, 0.9844724305808853, 1.1377228398966548, -0.20470872485097752, 0.7919058048512578, 0.6609828231416948, 0.7819320658650308, 0.6692105737678553},
    {0.19514500994890457, 0.6662778224946927, 0.6523612084378768, 1.2697090256284216, 0.8459151119112737, 1.129091715524262, 1.0883291682803051, 0.8839392202508868, 0.6409857736142804, 1.060596824961694, 0.6503086402941693, -0.08259922255343548, 0.8220044333462053, 0.9550274473738491, 0.7435430229861575, 0.9911653087777873, 1.3048262821031162, 0.6867802066889499, 0.7675961205929688, 0.2619196037178748, -0.36629223405478395, 0.5222463889333453, 0.9481103826958219, 1.0026803945686618, 0.756604632569702, 1.1002949280371375, 0.9582145531184717, 0.18269288332537967, 0.7502474395634733, 1.0044123943075518, 0.7291695190765051, 0.8751683398328229},
    {0.1713564527868461, 0.7374804882599084, 0.5314316459811984, 1.3385313155617686, 0.9524626757300928, 1.127167023175677, 0.6690828030483552, 1.1576006190342394, 0.9965973095193142, 0.852587695116699, 0.5194663996255993, -0.19390464360312326, 0.948688068997062, 1.2701343908225524, 0.977688493112338, 1.170706927469515, 1.4284192818357928, 0.7835959509376025, 0.6609686972003174, -0.03463705331419144, -0.06988968931643391, 0.9603246921269872, 1.0747655207883235, 0.8814930145037785, 0.8122927502774671, 1.256446179341458, 1.0121664620205404, -0.050971441386901704, 0.934935150367968, 0.7734909401126014, 0.8508061751080822, 0.9349108901831483},
    {-0.1230980127476371, 0.8340965018337831, 0.6685086152718749, 1.4161544972358309, 1.0076912754077496, 1.3044933668328271, 0.9422798668460353, 1.1147871864235397, 1.124871319237265, 0.6391456783321772, 0.4868685641544312, -0.32892628469086443, 0.7018078568411124, 0.5944964506484371, 0.8867944654379267, 1.097054018481517, 1.0780077586580383, 0.8234066356044945, 1.093472911473, -0.26728372273932305, 0.030676825787866124, 0.7429330966163666, 1.0312398709690354, 1.0221052648232807, 0.5948315634542679, 1.2262961675571775, 1.4048585676888907, 0.030600077476396533, 0.8334411489119695, 0.6899668296851666, 0.9165199865804958, 0.8130589238325596},
    {-0.1089822152191333, 0.9035872254514203, 0.8058965519195609, 0.9036849125437236, 0.9536800428694876, 1.0806575271887853, 0.9318881514114711, 0.9041194444093583, 1.140326716848998, 0.8821160599232428, 0.5294169999021513, -0.07518060155106009, 0.7673345991229784, 0.9646130105641196, 0.9517243575020787, 0.8623292404608103, 1.2284617789596886, 1.0522468419251594, 0.7088517780683512, -0.09832547455019514, -0.33187797966870436, 1.2234106955149495, 0.9113234456421095, 0.907822971404374, 0.942333811920739, 0.9992333130929928, 0.842255500813561, -0.039948819299028035, 1.0352234141775005, 0.7677450602213309, 1.0715427601984073, 1.1824366978646794},
    {-0.14455144422607144, 0.683976520637655, 1.0492734845263778, 1.094739386632806, 0.9083128435296265, 1.0378367327652336, 0.9580625596142615, 0.7220837068668842, 1.0866513210902344, 1.0237292730900271, 0.7311844167619055, -0.12543955939916074, 0.6913873103299866, 1.2249087898462026, 0.7422474318687942, 0.7229513157227867, 0.8743919910431008, 0.8234688357040412, 0.761579006780689, -0.16391625558235562, -0.04701662481770122, 0.9356045055959716, 0.7330965391792987, 0.6267823892128209, 0.8283159719155244, 1.4519381895989418, 1.0160012025196548, -0.18756966779283146, 0.773462574990905, 0.7563540841334448, 1.327681375074709, 0.8026732984541208},
    {0.1493653669903589, 1.0648125376091107, 0.4722888592319941, 0.8678270940824906, 1.168131724651054, 0.9093982300924559, 1.2680177878798993, 0.8020205556943739, 1.0399125292946372, 1.1549260448518897, 0.36080570112433674, 0.07411698575540833, 0.7937133573865802, 0.9863486385688051, 0.9719177469500287, 1.1302688927623035, 0.6449885515061412, 0.9809415212628495, 0.7586771424102634, 0.006574212562952059, -0.04730444910114953, 0.6316889171335851, 1.2707469123646404, 1.0506056098637853, 1.0215620850682683, 1.1550346037174894, 0.9956479656205879, -0.08291558789139393, 1.0193055232395565, 0.6536219055140648, 0.735776442435658, 0.9741417106965823},
    {-0.17818919979059117, 0.7789332351882721, 0.6208307063456288, 1.1006541693537508, 1.0846419238706286, 1.2009105797847681, 1.1697317187293543, 1.0249785700091176, 0.9808080368013451, 1.0799462931118462, 0.5244317810751138, -0.020133683136545896, 0.3611323377692978, 1.1158010129784186, 0.7289856784109675, 0.9876429439661691, 1.099369098300825, 1.077112062615872, 0.7514239236291023, 0.1405999303162243, 0.11430117437885666, 1.198980527792152, 1.0284413176291778, 1.1655101304726314, 0.7885861898195998, 0.851756917243781, 0.7042468237722125, -0.06749626615539943, 0.5064033549267846, 0.6728674772028582, 0.9147632685666844, 0.8650262875589325},
    {0.061540345434094784, 0.8732884437170764, 1.1650963771768132, 1.2247868235337485, 1.2452363236756814, 0.8796651941255523, 0.8810480547786883, 0.9109203597250368, 0.9483384165190482, 0.9109124682331763, 0.5409902921593558, -0.39874693151787644, 0.8913569592462149, 0.8893861304720337, 1.0259365915097964, 1.0038223482683164, 1.121848577157101, 0.97641045060527, 0.7054366757341759, -0.09202762727560575, -0.07068601118884517, 0.7605291995873125, 0.8931814703103069, 1.1010800398921239, 0.617190636158195, 1.0608811561109284, 0.8952326061740047, -0.28918082030406445, 1.195103568019674, 0.614329342251028, 1.112561074325925, 0.68461356560608},
    {0.033736081506891065, 0.9036911039242567, 0.6196156771738598, 0.9640839649130987, 1.063179276331109, 0.9179344004363545, 0.9587700810017039, 0.8464921041124589, 1.0863595610379224, 0.9669969569642799, 0.4201830505247823, -0.025555382136068557, 0.2847434927185005, 1.09583946927954, 0.8902003829546324, 0.7686479109680044, 0.9067838924527353, 0.5947240569507612, 0.7408658318266482, 0.0877039518964102, 0.11418536261408745, 0.8900112880789889, 0.6842778832409613, 1.3967251177777988, 0.9055437320866356, 0.815529835674135, 1.1954726538877405, -0.015560701219284616, 0.5808554670657508, 0.5706139996090499, 0.777242476323773, 0.9598519829650868},
    {-0.05912867973387224, 0.8098642785854546, 0.637315622228143, 0.8886838436557566, 0.8095802207203437, 0.7516744850125205, 1.133946854503481, 0.6446335947584892, 1.1451513953663806, 0.7947810197523486, 0.5784223742741522, 0.05131863803988943, 0.6782439649795587, 0.8845070436723768, 1.1702239093828908, 0.7845893467870104, 0.8179754850428566, 1.2420948800726817, 0.8517325863316937, -0.05022520580405444, -0.2760406242647585, 0.85904884973173, 1.0871532795500976, 1.4279645994240877, 0.7321852625456039, 1.0629614041951048, 0.8361335331297145, -0.05046458930157204, 0.9636559640955028, 0.9428364054093304, 0.729704357817997, 0.8503205636793307},
    {-0.1918517607116754, 0.7487557607457889, 0.7071099836015402, 0.9216662800969367, 0.9198596266470754, 1.015822068569151, 0.6658954779457139, 0.8467677886494743, 0.8919322367888649, 0.6928562118937256, 0.8830230381949503, 0.060629806797165335, 0.7668507172827761, 1.0947841331471564, 0.9683726952165845, 0.9006142141692403, 0.7778910197335341, 0.8501866863180247, 0.7184218841850416, -0.24530659013282569, -0.08872949110083837, 0.899630537517913, 0.8693787986816497, 0.9231881092868742, 0.7571904180360403, 0.9666904693767275, 1.0843973447562618, -0.27008588363938685, 0.6690578508842261, 0.9394199668889701, 0.8636651205600115, 1.157065009449126},
    {0.015004949271963728, 0.6235349702705193, 0.7096177690125709, 0.9138564130500347, 0.709164183416618, 1.0306615161444324, 0.8290202723289046, 0.8635169274630942, 1.0798005531773838, 1.443665933213446, 0.23132779422889044, -0.13884013709481285, 0.378722192670898, 0.8720561786876372, 1.0650197823326015, 0.7929413238648609, 0.8987117308579992, 0.43488519265809017, 0.7567099095141809, -0.06040256400000104, -0.3348045659291516, 0.8982518560886742, 0.9130610951816105, 0.7350687281471131, 1.017878209309495, 1.262230607653292, 0.7919765903735053, 0.11843731157046437, 0.9219936919130761, 0.7940457296535463, 1.2011779780763023, 0.8046749642989535},
    {0.015673907925430594, 0.8794194056626391, 0.2984856248878874, 1.0195836303700454, 0.8360416615392762, 0.8920831391417385, 0.7771067486353412, 1.151191903518075, 0.8003682152734893, 1.2892716827240815, 0.5212615199399214, -0.04886335546521254, 0.649910088179877, 0.834038391780759, 0.9542043430697822, 0.8409832432440821, 0.880024119530258, 0.913329199640637, 0.7423360817255468, 0.13713208688864692, -0.0890867368008661, 1.0344220607835892, 1.4670489590848106, 0.8968613304840092, 1.0045361950285732, 0.9234798228795655, 0.9756637459424351, -0.24401997081257557, 0.8536047585129751, 0.7865073689911897, 0.8282796968121062, 0.9895955190389955},
    {-0.1909286369310112, 0.7241353637100981, 0.533469925205859, 1.0513287774382363, 0.9872375469854467, 0.8130067287343916, 1.217241956207878, 1.175742984750418, 1.1615703725934925, 0.886211546644469, 0.9558619936506283, -0.309149427773324, 0.6676840946456969, 1.4308740776536597, 0.7680546454013223, 1.2627682392708053, 1.105917847892846, 0.7125805109678404, 0.8467415005358762, -0.15690474025505532, 0.10784761589925478, 1.1826377630583214, 1.0787280075022352, 1.1124440323540254, 0.6362314922174593, 0.8420064330875617, 0.9570188697581543, -0.0005516093917349993, 0.646216710896197, 1.1510003479310011, 0.8384619047455187, 0.8275179848696578},
    {0.052874327298973046, 0.7981381108448595, 0.4438998209413396, 0.7308273219014109, 1.1668586188288579, 0.7977214946163111, 0.7628356386695513, 1.2888333874277156, 0.9675105368741137, 1.1793909179274005, 0.8127935020216543, -0.1456970028969847, 0.5258593418379052, 0.7336361142793245, 1.1711209285566415, 0.9421794322970789, 1.094868113637634, 0.893231231615484, 1.1653585668773399, -0.31103635776536903, -0.2231646712490628, 1.0763779806730074, 1.1840279644714566, 0.6915863182446903, 0.9749330424081228, 0.7765763885348879, 1.2446331969050615, -0.04034302575313191, 0.6481260486189974, 0.6881187434166902, 0.5358301569753733, 1.0439104402784811},
    {-0.0018550580282648817, 0.733722221499986, 1.0728397643266372, 1.1897436592249442, 0.9471371882968876, 0.8090547375093784, 1.0326171931061887, 1.2333556325379376, 1.059787545064559, 0.97881341423968, 0.6226555082759442, 0.08595387514595587, 0.8373925846887033, 1.1324496895981353, 0.7907245884981022, 1.5252813316179197, 0.9381586248346513, 0.8503689688668633, 0.921721245964472, 0.11570494972983386, -0.17459426129991545, 0.5865838390683138, 0.8975272769879618, 1.1979016169285566, 0.7840732601569885, 0.9506341704628766, 0.6603537212232348, -0.15915784671940394, 0.8105708373529124, 0.7643795731415577, 0.6053718213129822, 0.7338933886168368},
    {0.09602926006352056, 0.6130139987829233, 0.7505105038864286, 1.184927834254864, 0.9483716195942417, 0.6712985054486706, 0.8708645577264352, 1.176658409609336, 0.9937932140300338, 0.9450280287059469, 0.8193491766510986, -0.1454156730308885, 0.8371350009197759, 1.0231988398357927, 0.941068265132949, 0.8799518343655774, 1.0429034601596945, 0.7003447165751655, 0.9384720059906468, -0.17899109996438478, 0.0007504702424951964, 0.8408137042967772, 0.3971142133245565, 0.8680332244747435, 0.8302738096018372, 1.1741089058130398, 1.0250284105485266, -0.06962205376505956, 0.7964322910607436, 0.7698628616089389, 0.7349504920948096, 1.2263029282276645},
    {-0.041795325169780226, 0.6395634015794781, 0.5748430876933244, 0.8587431200873099, 0.9529395524738707, 0.9343705656030864, 0.8648942959193938, 0.7470942428075287, 1.0858242886803644, 0.887100171823461, 0.7024032160278093, -0.017540358311252658, 1.110057047298428, 0.9405781337066552, 0.791138746452404, 0.8556657688026617, 1.066243635389497, 0.7237168475039698, 1.0491102554190141, -0.09979281920467663, 0.15244130992017912, 1.0401877054050241, 1.3571741135610682, 1.109344346959692, 0.7142202652950878, 1.0958595040768495, 0.6388690274943277, -0.15765842286574652, 0.8159579760550034, 1.3350863392687125, 1.3286275426266545, 0.7554576032140488},
    {-0.4377235787946598, 0.9461347415812087, 0.8802037585615697, 0.9600150821201703, 1.3379126883283057, 0.5978822170863184, 0.6455820927368467, 0.868116228086987, 0.8880852934935258, 1.1193559508591895, 0.16979636555865515, -0.18113655219467129, 0.7906739775363383, 0.9491566546136314, 0.8808037006716293, 1.088602997288609, 0.9133613523404935, 0.7293890802084095, 0.9190766316153096, -0.18895344778122392, -0.0766710996132634, 0.5006378490153869, 0.7855957402625081, 1.2143554172395952, 0.8165788506455867, 0.9020278873141985, 1.0037602686986644, -0.15377862129883305, 0.8913599971489169, 0.9675728091015143, 0.846449357236856, 0.8743232117290739},
    {-0.2812677565865906, 0.6268300838822369, 0.6292892639915885, 0.9143564106421167, 0.8687130400010005, 0.9262429018026662, 1.0804265762154222, 0.711184591756165, 1.364978624900535, 0.8977326654090453, 0.4321077925177534, -0.0746118620261059, 0.5293439044836616, 0.8691578583859586, 0.6452813204526404, 0.7399309799121463, 0.878875966376519, 0.8144959430929578, 0.8877064899958464, -0.13192313949554607, -0.03677930849151529, 0.8811265703249395, 0.866102149714828, 0.9128779359641787, 0.8619066696533215, 1.1228224557569821, 1.3704142162030712, -0.25146735600698966, 0.9871788584395315, 0.9461244715415479, 0.8208523482553695, 0.695912909898584},
    {0.18939450006600167, 0.8787673688974758, 0.3990304362939373, 1.1529264171303344, 0.5813539043741525, 1.2867264025243448, 1.1498773865016034, 1.0966065781695478, 0.7279534762206957, 1.0181048299365443, 0.8256006221413006, 0.25907185508462893, 0.7520000513607283, 1.0679931484575689, 1.0068980671033778, 1.2536565280926903, 0.9168101739812632, 0.751343909278675, 0.7320033552802203, -0.2324511880732769, -0.2842933474981177, 0.7767532491767344, 0.9595320045436844, 0.9144648498876559, 0.5497157870984165, 0.984277891992117, 1.0061896905967023, -0.19817252751104952, 1.033603894271377, 0.7498652401070763, 0.7479442773057181, 0.6910969367487395},
    {-0.20564419631584877, 1.0396173551019285, 0.6314677121822012, 0.91128091880545, 1.0272079709822952, 1.047799729539693, 0.875887202060789, 0.8644390097283619, 0.9406796560874462, 1.234254840407963, 0.7135709280221838, 0.04310533899283904, 0.8181737879883852, 0.8593081734400407, 1.0686812984767673, 1.1082967399468164, 0.9158706728891898, 0.8198783432117038, 0.8859108259283164, -0.19232157613836504, 0.2467565028959783, 0.8456806043832454, 0.9924226724941815, 0.8397650226724758, 0.8486244249217798, 0.8486150893138376, 0.7816190728354211, -0.13468540416243718, 0.8154008475847804, 0.9029532236995207, 0.7696704927037501, 0.7839699958615308},
    {-0.09702132686234581, 1.0307496862783803, 0.70163343959219, 0.92743700206103, 0.8675621424176255, 0.7951362751373608, 0.9683078274698931, 1.04756701703251, 0.6790691457208843, 0.7801357950130868, 0.49327026798882184, -0.014228007340487198, 1.0176945070847951, 0.9991582382820574, 0.8424894332685227, 0.9569338725325304, 0.8161557655504559, 0.8811690552176453, 0.584365076851241, -0.3024881646568541, 0.17467110186520204, 0.8233848606611615, 1.0705836213058286, 0.9449485599771774, 0.8598469613365963, 1.1885980354395709, 1.1650283179636411, -0.0923352692325376, 1.0601767623604248, 0.9934920659683063, 1.1342202403545605, 1.1306619493173773},
    {-0.2920605673256102, 0.4050503645880828, 0.724079197535891, 1.0176613062093132, 0.7002968221877489, 1.0625393640719905, 0.8084769511764087, 0.8753059620661573, 1.0180732323564832, 1.0909817855035273, 0.6046187351320753, -0.011458809395096442, 0.973328347341946, 0.7382662580094389, 0.976609221068727, 0.8698797265997754, 1.0178233269078627, 0.43417409067504725, 0.7476608500421448, 0.09014164414702461, -0.11965331178430973, 0.9571422024878878, 0.9920768667665277, 0.930901608340888, 0.6580184485574174, 1.0121556438565764, 0.8609880914789023, -0.009097035438296708, 1.187518252523562, 0.9644020929144204, 0.9268441155637123, 0.9022651886493801},
    {-0.09627849520999822, 0.820171997393635, 0.6822286561583287, 1.0361567521524944, 1.0518010359762333, 1.125304376743455, 0.9732247608042449, 0.9581222756301608, 1.1975845571214951, 0.6439353206951893, 0.7298985626063567, 0.04798245468956695, 0.6266107690286249, 1.128160516205904, 0.9597128191406865, 1.0899643301866535, 0.861345711058607, 1.2679124316830117, 0.7972708133066063, -0.24872355454147949, -0.20956151801390868, 1.2351766941028075, 0.9676126742451989, 0.6363780790149377, 0.833620029313396, 1.2210026151928999, 1.1346635025275111, 0.09277349558653233, 0.7225915790385045, 0.6266363394018232, 0.9855968092827119, 0.9891490219926992},
    {-0.2577320787308859, 0.6281898781286765, 0.6767468136115573, 0.9801684333979815, 0.9150356707858706, 1.1515833078792244, 0.9381562849473898, 0.8745609563856102, 0.9410907515825822, 0.7019138862292813, 0.2972618088796548, -0.36994725552125274, 0.5845900873438197, 1.2510256285155195, 1.0558246908860451, 1.0074316862767252, 0.7339980455710086, 0.9505430555157988, 0.8674145669188994, -0.051002164792704696, -0.03526462081381377, 0.8353078307651054, 0.6847829832699796, 0.9538373088546731, 0.811114745052936, 0.8744285482945481, 1.068906095339313, -0.3966544496463895, 1.0766015388538615, 1.0823008413058322, 1.099428292459842, 0.8299260737386301},
    {-0.4622709900690559, 0.7399090546113087, 0.7730856180600577, 1.2244986054950315, 0.5735110722956108, 1.1143661537941325, 1.19866085944844, 1.1878097763533502, 0.8801544356621093, 1.0237772041000808, 0.8810257126396809, 0.03484271714880755, 0.8445736571564504, 1.0722838256073384, 1.1318856397271464, 1.10627447896717, 0.9876063708431376, 0.87178840760919, 0.6915925138470475, 0.3550235557638323, -0.2920930332183403, 1.1031592117014304, 0.7743181217685685, 1.317918973606651, 0.41674254966244806, 1.0906428118662124, 1.0860353583054863, -0.057157391287459086, 0.8694932781014111, 0.7104590672602272, 0.7832070186466483, 0.985647932539764},
    {0.039874506835663, 0.951761031127512, 0.7721867352146868, 1.00630059670935, 0.8301911206379481, 0.6694546952304516, 0.7690423368088858, 0.9599497090116974, 0.9759854984066013, 1.1129830403598953, 0.8258587469938702, 0.04215422607171854, 0.5811061206935322, 0.7439878650572658, 0.8778922508010402, 0.8064958233324392, 0.9763778348650988, 0.8383869499153717, 0.5645436679659895, -0.05626819719156086, 0.17440041277705567, 0.9465091575893096, 0.9800789440510941, 0.7489683371534739, 0.5307280665305617, 1.180732753815668, 0.7929033482202621, 0.08834898685265093, 0.8417495261691558, 0.6600524909440313, 0.8518629582460581, 0.8118685250348444},
    {-0.2000824388132999, 0.9008603740789327, 1.1056441091949805, 0.817983381064163, 0.8281776904627377, 0.9822737266051442, 1.0534007135276025, 0.9340502687226522, 0.9520579032660449, 0.814350943010592, 0.35709305496874216, -0.16662516791221307, 0.9734683068356974, 0.8638001755345933, 1.1324483311759062, 0.634659397701272, 1.108066280659183, 0.9037745892200031, 0.8693601568788494, -0.3220739163813478, -0.00241292307203917, 1.0951945636261773, 1.0165318863820558, 0.8298150310164788, 0.9382305817811691, 0.9183030144607915, 1.1374261995982904, 0.016502507064519435, 0.7649813643869336, 0.5199934988177854, 0.874524087097025, 0.9033509770602604},
    {-0.2106898881428857, 0.8218956693423748, 1.041593072416859, 0.9006973568200365, 1.116808360135378, 0.7851489537218264, 0.7692550765553363, 0.7507081431430582, 1.0708874402293018, 0.9442225185690123, 0.47910278649083793, -0.09931835799972645, 1.0202956007705366, 1.0598546607415795, 0.7739150359838348, 0.9276315154577557, 1.3552526152715858, 0.5623295589873343, 0.9774716628435748, -0.10045882747747334, -0.28891990978977994, 0.9454767975322181, 0.7933817854312354, 0.9786044843545398, 0.42881951092999065, 0.969384435019176, 0.8452569393060354, 0.24415338911648388, 0.7889003397810137, 0.9323291588974363, 1.0516052817274562, 0.7847454405503204},
    {0.2058089405854742, 1.0178665968924374, 0.6082544061478272, 0.9029109989525513, 0.8709181887539011, 0.8367917485265768, 1.3051956642416347, 0.8741860205993477, 0.6453989575726481, 0.8962609131291753, 0.6235838131554233, 0.005053036361101171, 0.5483976477086212, 0.6121370362594304, 1.0601759054022124, 0.6679415944856044, 0.8451974619374667, 0.8571748767789578, 0.7743799461254209, -0.26194561147601875, -0.1151670523769428, 1.212948251636889, 0.8330403349751189, 1.2033310529406938, 0.36116297989052765, 0.7677476225816934, 1.1383831801771382, 0.008874513489987601, 1.08533910965992, 1.1740350646969628, 0.7236382814882765, 0.6218411265896324},
    {-0.24976432181326833, 0.8309880817348214, 0.38473224696225844, 0.9572102717312213, 0.7953572664417211, 0.9556927135358185, 0.9051832618878957, 0.7734736003058506, 0.8843017402355077, 0.8560377734758945, 0.3856917539076838, -0.11001082599037232, 0.6910045028756959, 0.8047503041967012, 0.9822612383064929, 0.9625822563161328, 0.990512763585059, 0.7130492243236597, 0.6949025133676863, 0.11530795776963569, 0.12522266022389172, 1.179017920259077, 0.8133203603440449, 1.0390133455778299, 0.6531679996676188, 0.8656477484361609, 1.0736190868682445, 0.08886213884216657, 0.8511331570777724, 0.761954801636205, 0.8846936660886981, 1.0529211760705888},
    {-0.13065768906733538, 0.5355909862501175, 1.0835959032294251, 1.1102097857654247, 1.3869170371958233, 1.0192826316280055, 0.7081723496745282, 0.8887867804970968, 1.0550411547550131, 0.9703435849480136, 0.473147157218599, 0.05101322654505021, 0.4983076951559383, 0.9202976771946357, 0.9046337553027537, 1.3274750886083484, 1.057198491362567, 0.7089685262046282, 0.9441600630274934, 0.002259872484457588, -0.22116583057570582, 1.0819314683751322, 1.2404634028299761, 1.0518671327899312, 0.6755820287561396, 0.7489909616324137, 0.7064548766497837, 0.014828419830135837, 0.8687838602526776, 0.6270555550978922, 1.0101633957053744, 0.9173340724877015},
    {0.022187812210747254, 0.7821499226413171, 1.152746676915672, 1.3010010659369171, 0.9178554028147312, 1.0913841118543561, 0.8794593481378216, 1.1093241340810673, 0.9169244114579558, 0.8603717424335406, 0.5946688671926432, -0.05740772795412093, 0.89914677437523, 0.9059923946975492, 1.4761785002786785, 0.8985274964361449, 0.8948922286215311, 0.7442676300655231, 0.8573985630528785, -0.036381336141098355, -0.05892811247577438, 1.1165845589325107, 1.3867918252464135, 0.9361383801689432, 0.41808429335039426, 1.0402454347907333, 1.093810249919816, -0.13502820696597537, 0.9460748857223943, 0.8762442708750103, 1.07457613421968, 0.7499766809366996},
    {-0.013872225373468617, 0.8392844907431674, 1.0198923392778654, 1.2633448839533348, 1.0128523167436099, 0.9478929292849374, 1.1923363023303637, 0.960224392897491, 1.1916424057108945, 0.9758260392319046, 0.5296998716697467, 0.014246389362928, 0.8012503922363925, 0.814795921238972, 0.9078511618926425, 0.8397691640295524, 1.375809966258383, 0.9257696370004271, 0.8521874720706124, -0.20235438581390414, -0.1091155763534336, 0.9229353974450022, 0.800161658840953, 0.9948789264218578, 0.9075526529804014, 0.7655651733609624, 0.8209445469233361, -0.07741785531554961, 0.7089917692301387, 0.9345264980841691, 1.341185651004921, 1.1931681614925975},
    {0.27666818671261106, 0.6993971016231098, 1.017430480921141, 0.7350400932704904, 0.9954145117857123, 0.8877774870616234, 1.0142625772453528, 0.6782976972055577, 1.0155255633571831, 0.9772142886530193, 0.6396453533258816, -0.12528831448482353, 0.8332021889157616, 0.9878242514767323, 1.0068919311806142, 0.8515693717657217, 0.8668494206719912, 0.7437041141561115, 1.1559182349005555, -0.044897781493843825, -0.1270468102645133, 0.9401039136878432, 1.095455787265922, 0.9977846874999949, 1.023421205534425, 0.767962530368496, 0.8628777781017363, -0.16633081702009392, 0.7151626514265386, 0.7032074573838584, 0.9294365766341925, 0.7758736841429223},
    {0.37689477012791994, 0.6633180842379841, 0.8103310598720391, 0.9676649265567769, 0.7453051956201706, 1.0916539735722215, 0.6929443429592175, 0.6835548410480775, 0.6170191118360633, 0.9313351086354091, 0.5115865103735429, -0.5443267283207222, 0.7599862804113078, 1.185810347041818, 0.9034734723036107, 1.1091600476256525, 0.9753275433049581, 0.783005435359968, 1.3216391684664617, -0.05142871018497057, -0.046713128668461446, 1.1037239223178152, 0.8921322287259407, 0.8616300821366195, 0.8234725921990383, 1.1703414231237952, 0.9992015311283745, -0.2741569614004351, 0.860115107299157, 1.2083024491807746, 0.6385505789752823, 0.7746264668489478},
    {-0.34285156722781734, 1.0404973478803425, 0.6440888290087105, 0.6489190399852737, 0.9464472827108341, 1.082710826770558, 1.0642155761162884, 0.6057795710709889, 0.8421470679018829, 1.179803713599631, 0.28683649034915404, -0.1119852464408473, 0.7283597244439555, 0.7792672705357099, 0.7252211100013373, 1.1722194723339678, 0.9178109431938267, 1.0982596000480809, 0.7493563895008801, 0.005731097712219762, -0.06186012929732185, 0.9640125663791999, 0.7595445225634416, 0.7488942712148492, 0.8891794772737878, 0.7852363237186485, 1.238095782179946, -0.06379642054197471, 0.8684242408469036, 0.9519613453332144, 0.7961539849999737, 0.7729512276887913},
    {0.16202416817617382, 0.8155930872113881, 0.9743819121617247, 1.128990985953232, 1.080518526997029, 0.9485314071513978, 1.1391608199322258, 1.0120626477248014, 0.9439770489385938, 0.9110852640528839, 0.7473980907336002, -0.11076877859751584, 0.7156096442835134, 1.1787028003649975, 0.9206050302924708, 0.8605512257143357, 1.0066150692062552, 0.9159640373079847, 0.6892719561073658, -0.11596270057985049, -0.2791126092732927, 1.1750269318162752, 1.2663832018377625, 0.8768426477249597, 0.7442538212717912, 1.0429554331656874, 0.973387344279412, 0.027897423546558144, 0.9905256799476334, 0.869275944502632, 0.9359879240725556, 0.8612016806585698},
    {0.1058490143491959, 1.009348786739217, 0.3652501341214397, 1.3668859455509959, 0.6929640709763699, 0.8266233231335075, 0.9613220670970145, 1.1414084649161809, 0.5690034490176312, 0.9466274928924203, 0.5054906252551321, 0.032450165726613335, 0.737828292784431, 1.049693819285139, 1.0280040044718706, 0.9595355404127268, 0.8940453261749772, 0.8982347437993482, 0.5249869633794801, -0.15846572696309572, 0.23639655961744227, 1.1605939106742187, 0.7144825725717661, 0.8720576821392269, 0.5633811083106182, 0.8989952057446788, 0.9365565707360896, 0.327144508423923, 1.0149195829203481, 0.8821299744871319, 0.8722315512220236, 1.1135521174890592},
    {-0.406386511230447, 0.8216901662390171, 0.8600851789148813, 1.3433621504692799, 0.7587901169240666, 0.7442241152478947, 1.0521775228149284, 0.9962667749117502, 1.1858987191902834, 0.9545462314981168, 0.24724010366117025, -0.1131209943153109, 0.8349088408114613, 1.1242524326548242, 0.9143657138788451, 1.1600565864822465, 0.9860429466150715, 0.8603697794607805, 0.8751215645505749, -0.15230305296231347, -0.31441649876491634, 0.935892944517348, 1.1928792449306687, 0.662073920918458, 0.7369679795073902, 0.7938769540193934, 0.9158199054290441, -0.17300445623081567, 0.6676253036303613, 0.6008333249005111, 1.292968830083451, 0.902423956991088},
    {0.13324484084690155, 0.9128305212136576, 0.6589879932835, 0.7846823520667271, 0.8628412085954357, 0.8992292236221137, 1.0873020879391135, 0.9846754987903361, 1.1307492915941544, 0.9894556740712824, 0.5382727760582677, 0.04307495542351785, 0.9190151892034247, 1.163838284860013, 1.0068617499649106, 1.1191244880498084, 1.0725825090051953, 0.6455861828522814, 0.9149991664106335, -0.23457557199982257, -0.07275251544416918, 1.2279366568300787, 1.1948912774902607, 0.9748343994243598, 0.7454912558092605, 0.9506971218949736, 1.0774226419068405, 0.18037268089164732, 0.7697044554260931, 0.7314289759132675, 0.7879819961887854, 1.135698716690843},
    {-0.1668387702169636, 0.8708944169365604, 0.6823359267728667, 0.7639432031617691, 0.929633087001271, 0.9072920626674336, 0.7737156302937861, 1.1666822418888652, 1.2800554372859094, 1.0611107717559956, 0.5911577170821569, -0.1586130151968405, 0.4341918421798248, 0.8485679949810693, 0.8310767023694746, 1.1292259734503027, 1.1567580443655652, 0.9923040289353283, 0.7341294766810977, -0.3645929710982235, 0.12337009392979863, 1.0828587931141043, 1.0192412054675295, 0.8796606702028003, 0.4608481004292259, 1.1004409849727523, 0.8143238810402598, -0.2810927671804017, 0.6275311307381138, 0.6601786799964328, 1.2318992398619357, 0.9296200044092916},
    {-0.2585041673951343, 0.7548288593197988, 0.6198320587083792, 1.0998546568048027, 0.9120071570617778, 1.1134271274007055, 0.9837984566583141, 0.7898240851151161, 0.7507298959997102, 0.9094113954541861, 0.5842781796828775, -0.32085814298687065, 0.6512149261865883, 1.0591713517310901, 0.9116145044624396, 0.8133766513086171, 0.9646547011654037, 0.8432072942494406, 0.8742318571510613, -0.05352649890061245, -0.13968623598061197, 0.8371575871776719, 1.1283650695938237, 1.1884001735255558, 1.1495362402400813, 1.1869277205840003, 0.881605732854951, -0.11644585525322312, 0.7474168152084607, 1.1247334325310432, 0.926001353822879, 0.8118955179005745},
    {-0.050076191599340646, 1.0143343117214012, 1.013015172893241, 0.8263379540801328, 0.8668700248246322, 0.8636983607014038, 0.8663127969275187, 1.0320661795735466, 0.92095341752613, 0.9507692606352167, 0.6482135700674946, 0.15382161935139674, 0.5381775811969893, 1.0410187187822815, 1.5211990182743538, 1.0206919861864223, 0.890554229389693, 0.9403750124790594, 0.9367297401647992, -0.1158091745639258, -0.14785210674954574, 1.021825248860635, 1.0649150329708859, 0.7816040460576058, 0.33000070340719356, 0.9426412785937079, 0.950237248779788, -0.22097309784623811, 1.198415577287274, 0.7756493779434787, 0.985068130421971, 0.880948040001591},
    {0.036262584176067134, 0.5696841605709727, 0.995445275400395, 0.9657553379457611, 0.7640724366327164, 0.7863940873592754, 1.0460275954198222, 0.6202275947605117, 0.6908727567396589, 1.2248472882822914, 0.15486868821188188, 0.10274455663670189, 0.6225329779864822, 1.0076705818864449, 0.8765299482941478, 1.0927949749756636, 0.9880230970583994, 0.6873892538428614, 0.8432780247527915, 0.042784879118015484, 0.3138822111486542, 0.7426273305569716, 1.037266250469583, 1.0951442150113786, 1.099360987275018, 0.9475807143914593, 0.8713487239620641, -0.30853197559698076, 0.9920447842965967, 0.8711348608383377, 0.7749313140017807, 0.8915154330611337},
    {-0.2893457680549636, 0.798116762659184, 0.8796955062599691, 0.7749392215099203, 1.1336315957914904, 0.43033607566774257, 0.7827811627202265, 1.186263332913698, 0.6500003024536543, 0.8649083454674164, 0.6951572033535183, -0.20924070690453683, 0.4949036118183202, 0.842862519141903, 0.8225251791999811, 0.9251476051471612, 0.9159322312987999, 0.7614590295381807, 0.6307776532986782, 0.11820824659259725, -0.24595727103166293, 1.0316342433154588, 0.782280698805515, 0.7958259316019337, 0.8816564126566429, 1.1296837786289415, 1.0299018864890594, -0.06923855711780905, 0.7737060901770171, 0.7610510277509703, 0.6383319327851681, 0.4914155705636351}
};

static const float b2[32] = {-0.07856370983427097, 0.8283456135653122, 0.7623706331270454, 0.9250243064294921, 0.8513180447577692, 0.8828915854781758, 0.9674807004932288, 0.9368353079169431, 0.911837719977921, 0.8718113278830704, 0.5441193182358164, -0.07190089920826603, 0.7252112342310247, 0.9555002761712427, 0.8752783054825802, 0.9040394085345903, 0.9466304576819085, 0.8795414496108671, 0.8191553241108359, -0.051137431222827816, -0.08784692027612306, 0.8594409933442155, 0.8899000739581796, 0.9266084634321967, 0.7334715652398995, 0.9125988743542366, 0.8903536233829245, -0.06960807857018893, 0.8344974754288232, 0.8037369129346278, 0.9044297909213946, 0.8893102295893106};

static const float w3[32][16] = {
    {0.3255378212538048, -0.027728394958127234, -0.1850685447605444, 0.14091506114940433, -0.21618235114155482, -0.5256521287594004, -0.25972674363903947, 0.08047890868580487, 0.22448725287177157, 0.40339010020372185, -0.19571579950983362, 0.05520692938250076, -0.41702031123605876, -0.3099421275986405, -0.18488071653219512, 0.13755222644701315},
    {-0.1732038209302646, 0.6207653271485185, 0.822623603156994, 0.639980512635635, 0.14275723080690397, 0.15038888474970682, 1.0262665600191663, 0.9778596180131081, 0.9936038059289741, 0.07330043964544035, 0.8852486148953816, 0.5219769009797072, 1.523176956120615, 0.7684785957495378, 0.032745814727351066, 0.810142161644728},
    {-0.2886052494153059, 0.5730254903813552, 0.9485573955999607, 1.188288068949635, -0.16576199338283978, -0.1175822308162603, 0.6644669327623819, 0.7683491583138874, 0.8670756452867808, -0.2502515430749628, 0.6513498444085842, 0.44821917343352785, 1.0369041325091717, 0.9053782413934925, 0.13014698099345692, 0.8745779572908222},
    {0.07235378417886873, 0.6725216614215844, 1.215392034539213, 1.2603784298251506, -0.37153317722869894, 0.08107398823704033, 0.828423127358715, 0.8580067909648272, 0.7685958040304965, -0.21634617795647312, 0.9270790709606651, 0.17298517975137012, 1.4112597070850548, 1.3168266592543518, -0.039620713611545504, 1.0899715305966986},
    {-0.08974540288139113, 1.005601351219137, 1.165581618945202, 1.1507790086980247, -0.4364176503866887, 0.1817999230129216, 0.9083151510885162, 1.3068507619137393, 1.1154621426973876, -0.32913413682851206, 1.5341662768072881, -0.17549015997922213, 1.097532279601729, 0.9052174263929204, 0.11414567734353076, 1.0494425099552973},
    {-0.39300710384735593, 1.118333871067469, 0.9685890907261665, 1.0519420574566796, 0.04424270632784315, 0.03283829808391769, 1.0704046967324237, 0.9963896403618233, 0.9845970719831028, -0.021284427488780764, 1.4003574129286436, 0.0052930770687375575, 1.0836827302686936, 1.0178553961569368, 0.0035429384898174312, 0.9186678695997976},
    {-0.15860775125135457, 0.4449376671681317, 0.6621626600366977, 1.2516823824375602, 0.3826309466111334, 0.07766967416267104, 1.2002994697886173, 0.9769089724034721, 0.9404010456978046, 0.15543062907845212, 0.5772738980427066, -0.1328699169057689, 1.312588646178433, 1.1424819118663045, -0.40686706440761733, 0.8008065733693145},
    {-0.8007010135561781, 0.526556556990018, 1.327964657689116, 1.001140573015686, 0.4367637440567252, 0.055948214588834054, 0.9191686245989299, 0.5825638235742667, 1.5063786103032726, -0.3604772402079765, 0.7153205100149422, 0.04779529832429402, 1.3118780878575964, 0.8145673405292927, -0.09574985116787951, 1.104826966870404},
    {-0.07289637207403729, 0.9289715780512697, 1.014690832478722, 1.1451217306388397, -0.3418930105498653, -0.1301931831441642, 1.135852656357993, 1.0148989048487775, 0.9490061515100271, 0.1395540847208708, 0.7872756518969266, 0.47347621106809823, 0.9760666647979234, 0.659349672386158, 0.04603423108878125, 1.1317422418773948},
    {-0.283101295766793, 0.888156373141176, 1.2719160515289327, 1.304380700337462, -0.3443614620121875, -0.16345341620145404, 1.255041623137158, 0.9465238323231799, 1.0970609065275927, -0.040869981180004004, 1.0273868076793695, 0.4330176362240113, 1.3787648424748902, 0.7967124045914693, 0.187150235959031, 0.8815235802203699},
    {0.396762366361219, 0.7355849668919298, 0.7412337888898496, 0.5432801516638437, -0.14679805367794962, 0.056373608293081134, 0.7062484237913398, 1.157539821288476, 0.6953868462608277, 0.2253377450375158, 0.7619455565436809, 0.014778287369894125, 0.4052646107825603, 0.6728852582744017, -0.22541325955529176, 0.6651823132982997},
    {0.0798964582676476, 0.5523152517848028, 0.17088443999790576, -0.15655407098660795, -0.200694510940822, 0.3013869668706409, -0.16001243989295255, -0.02515048380799156, -0.3511469874806833, -0.19268477438321038, -0.10401032213070305, 0.11567917061942778, -0.23096062529533537, -0.5603894013061096, 0.4103952376192764, -0.0732416649092112},
    {0.3973397651666146, 0.5095869789700647, 0.9842924376846917, 1.213319082615209, 0.3693255801722221, 0.18578958328283673, 1.0110438274558162, 0.6909870571662319, 1.0244330947018963, 0.09103636827397474, 0.45689765255900744, 0.1862576941063841, 0.6457612591076123, 1.0601188225126612, 0.15253255454591289, 0.39479017324902327},
    {0.024513198423597587, 0.9311048060447671, 1.0002329415635949, 0.9895325161808305, 0.12460982300738242, -0.2005560611654224, 1.0863927598803254, 0.7785693988714047, 0.8620858478221027, 0.043087456182776394, 0.940927796014817, -0.12750580936909509, 1.0591855340929273, 0.8402778191191487, 0.3348589086495888, 1.4132113425386748},
    {0.059827953599190714, 1.2729928749216854, 1.051683562554032, 1.1522852113713142, -0.2013399273306494, 0.39896892579427545, 1.004284500444869, 1.1563599171365309, 0.7435816433041659, 0.20978480039785596, 1.0747947640957554, 0.329604381133053, 1.0417756870277934, 1.0140862627336626, -0.1363236298327811, 0.9487992992228291},
    {0.011728469025428425, 1.2655291464399068, 0.9129553220963142, 1.0386134791858386, -0.34088591506181226, -0.04789828731841802, 1.0911127285573372, 1.5734582108145105, 0.9161803104099565, -0.35542527691426884, 1.22423151893361, 0.16147759156635466, 0.9594435640800112, 1.0213028565716025, 0.24417635238854102, 1.2232990372107035},
    {-0.21103422215834852, 1.0881832311803912, 1.137414920951783, 1.1837857760893031, 0.17221216222039765, 0.1703482496523685, 0.7887599667862105, 0.7657637132452527, 1.19176423405833, -0.1044574865152291, 0.7610981496369993, 0.002855840568489019, 1.1280845502459393, 1.1802063908356246, -0.3208034616561818, 0.9503494737733117},
    {0.10714367667623209, 0.9037150264227098, 1.133578251037348, 1.0970414937184099, 0.13655264059358366, -0.28284259007861434, 1.1352804875047346, 1.0547872649145884, 0.9597426232668784, 0.3174579733372445, 1.2833786937401928, -0.1439236261658233, 1.2018299076435237, 0.9485305452731095, -0.051368939626025976, 0.8584688035124665},
    {-0.2668157013084201, 0.7140841174308088, 1.0630224454383912, 0.9048031932482098, -0.1674237306191835, -0.47248919312360893, 0.8487955933082137, 1.2184576006788068, 0.7861557294730475, -0.3036939210670796, 0.7191357136023394, -0.12889625793812945, 1.1952460257701556, 0.8611686255421602, -0.09062644645282386, 0.8884438989672535},
    {0.13295860945542265, 0.22910500719409468, -0.08339350692692829, -0.4139076764403444, 0.010234559037624021, 0.1799504124805977, 0.05286394346522828, -0.3227846447314412, 0.10081165036318883, 0.1421902318093334, 0.06551176427191294, -0.04066086980296441, 0.027480131089593882, 0.127376326634945, 0.32108452272283544, 0.2775179000117623},
    {-0.12033139270226058, 0.11203727288377195, 0.06066481033564994, 0.1863447668952261, -0.13227259085837864, 0.26733213106814924, -0.2985798661109372, -0.08559140686711443, -0.31453727163998524, -0.49065572536281493, 0.38963567712755737, -0.2720788802257243, -0.0020932978783391267, 0.0833113941498835, -0.15486803866713061, 0.0940925474557614},
    {0.3173850030273129, 0.8092983278814846, 1.5000551360442063, 0.9675480144623803, -0.21772191047907524, -0.25672472790133244, 1.137451778951382, 0.7064961021894098, 1.2171558684965293, -0.3810909019479823, 0.7594103580979952, -0.04173365001952393, 1.347879439750629, 1.1739226625439527, 0.08338309023914518, 0.949235084032825},
    {-0.20909631138731294, 1.4326623561891407, 1.3122386086038307, 0.7425768229751694, -0.16059504082511566, -0.12583850916160827, 0.935725093498511, 1.1219523295647247, 0.8301507218416876, -0.25628109465398097, 1.4222623457756436, -0.3034705097381876, 1.3677514033978588, 0.83145249057263, -0.5627207801196843, 1.0638203743808226},
    {-0.1469115490540522, 1.2767118929539334, 1.0614456223587632, 1.0699740120721295, -0.07026078786306768, -0.2852678767928727, 0.9657742190534295, 1.1859551803030486, 1.0158688372228384, -0.4412398842654256, 1.127147567496041, -0.41252024287522593, 1.6560249061129264, 0.9524735428970704, -0.4480039635256241, 0.6970493416018619},
    {-0.06005523953335099, 1.3497981843271916, 0.875356071657994, 1.1934737503671073, -0.13617811676767275, -0.42083626236640076, 0.6771480789009788, 1.1380668667586287, 0.9874063058367517, 0.02960512313966375, 0.7505583959694097, -0.23142844838010596, 0.7410552595515626, 1.0274141043780776, 0.2423770896140308, 1.0336310284964574},
    {-0.22392463100124543, 1.2026435401787743, 1.6932114326963912, 1.0359516369443402, -0.270054948664965, -0.1154236336077901, 0.8828120608513474, 0.7957887385852999, 0.8338409939334455, 0.31166450534235807, 0.7938025597958858, -0.8660057571642094, 1.0393974347751886, 0.6189253538865819, 0.009142234676179183, 1.3968163488791128},
    {-0.1872900388755015, 0.9739150944051663, 0.9747250181405589, 0.9723648930755396, 0.10183107811284159, -0.28118103268160943, 1.1675059674398351, 0.842540953224712, 0.8305092374237437, 0.16844495501848758, 0.7829967679309018, -0.21710372704067704, 1.5893659043136334, 0.9223395589206417, -0.18603741283627603, 1.1922586243562738},
    {-0.20216994498788865, -0.17170177108877344, -0.5333397273605531, -0.15394239117332617, -0.10632698459561958, -0.35604057612460194, -0.1717361155159139, -0.02704657255911, 0.18680336591157093, 0.19415232386934944, 0.06223744043085829, -0.3625259629237698, -0.3081311539372287, 0.056268249926141045, -0.26258891181752136, 0.4054658114860203},
    {0.18012020950581323, 0.8693065577024249, 0.8254496534001616, 0.7754894762502209, 0.15188892892390207, -0.16052216871766997, 1.0292648341917736, 1.232577937128252, 1.0795964444521549, 0.050879699315682744, 1.2024177383201, 0.008541195374622246, 0.9854997312230581, 1.0028925229558374, -0.22036712295642555, 1.1488349322596814},
    {0.22524600058034366, 1.288659977968135, 1.0898802057641555, 1.4043575703744704, 0.012155354639257102, -0.23066917562538855, 0.8477409431218065, 0.6974555257036179, 0.6132855318327085, -0.11114837357996944, 0.9970226284043464, 0.0538180275456918, 0.8940272799629584, 0.4639608281331481, 0.38455502928219076, 0.6033516458574129},
    {-0.15907459466106266, 1.079512632947181, 0.9673904082486408, 0.8559521952783622, 0.16870820674389334, 0.210374027717689, 1.143594064723496, 0.5829115361490823, 1.0350800293820186, 0.2494352002820983, 1.1112337708733442, -0.32500766596450287, 1.3435938848613367, 1.165727789866594, 0.08097365134743302, 1.0783652651780973},
    {-0.04528984821723917, 1.4114138738732738, 0.6996186175931997, 1.2583646592569486, 0.2595244548072943, 0.14390163094195904, 1.084332758844338, 0.8173315814839454, 0.8702145676175675, -0.11628309387289239, 1.2051522999986186, -0.40287898953817247, 0.889720791401695, 1.1050418998683835, 0.16692069624113648, 0.8792015764675901}
};

static const float b3[16] = {-0.02995589373153543, 0.6934129362778693, 0.6299777914683478, 0.6270027171440987, 0.019009077226863957, 0.038110897946861906, 0.5705916263536452, 0.7307102575815159, 0.6217379395093331, -0.01938435653098097, 0.57773132935725, -0.03563944330708598, 0.6817830041455272, 0.6376543216121177, -0.058565311144660535, 0.6576335198211863};

static const float w4[16][12] = {
    {0.7739798426803639, -0.039732227068355504, 0.11373898983984644, -0.24691069865042384, -0.08330535863794769, -0.2286615215417952, -0.0387070766536475, -0.08498926521760937, -0.1261391932410821, -0.004732573373649426, 0.08688560553618314, -0.10095007744998023},
    {-1.186182754957056, -0.9319959694280352, -0.6082320624258508, -1.105199687302622, -0.5042730022506599, -0.17519457042315353, -0.5121247662296556, -0.6246439232056724, -1.1171463381675595, -0.8426678428391936, -0.8330159173929822, -0.8231093364888137},
    {-0.9001950937328715, -0.6713933617783051, -0.7876528065506833, -0.49247270008947264, -0.2516215899986595, -1.0113103534393357, -0.9963431241518068, -1.330138326975482, -0.8821963243515603, -1.1026668425807087, -1.0273515173409544, -0.8408784121010204},
    {0.3528822166749188, -0.932804859883037, -1.243895894677153, -1.1002084375943393, -0.8868268694058477, -1.0264904950315714, -0.7978737633992861, -0.9306174839998159, -0.8276391121592058, -0.8373659426258712, -1.1783804380121834, -0.8975202022102283},
    {0.5651702224447754, -0.31353937112397096, 0.6269557279091983, -0.42064663714179873, -0.6437562043906458, 0.1727866439204747, 0.39774809007012696, -0.634389169921481, 0.0128261465483913, -0.023048164549832464, 0.6516973659826638, -0.5049961721510269},
    {0.3546897413868967, -0.6257078908916328, 0.07543506199950237, -0.004679621135799892, -0.873735661091779, -0.322623154889367, 0.6406962617695853, 0.1679099139832101, 0.040239657724413944, -0.4613553283472404, 0.009647715529488187, -0.23252701007554663},
    {-1.2511449330824675, -1.262636483157275, -0.9203814696395893, -1.2960769029314951, -0.8128530515797167, -1.6842789925449033, -1.294972853851601, -1.281506455037849, -0.3132334299036471, -0.6923593244965994, -0.878120033978024, -1.1904351792272427},
    {-0.9168222692796627, -0.842130767667987, -1.0316050852891017, -0.38346588768363377, -1.4061019315594008, -0.6596248818259, -1.1678994574614456, -0.6152969116467679, -1.3548108296109567, -0.6529751562780464, -0.7810515293830864, -0.24297864244368517},
    {-0.6077368761109628, -1.2950893346160544, -0.9266772978742797, -0.4193963340464018, -0.6271613876860709, -0.3956601997133003, -0.18556522853444185, -0.47737211202776725, -0.8017571717365659, -0.6216423278368318, -1.3494287728367718, -0.9630069527163687},
    {0.48587575842621544, 0.5906376429091568, -0.2989343319605148, 0.03952779728234498, -0.45573155914187186, -0.13297176318004597, -0.2975213703710545, 0.14498192867845722, 0.40618086723868363, -0.3439816026328934, 0.04388907556779567, 0.25463711999147437},
    {-0.7006237423442059, -0.20223154827647158, -0.043994285617861104, -1.6265667015020553, -0.9118798039174368, -0.6300673350432358, -0.6176829444908141, -1.2987242402619652, -0.4932012156544426, -1.082478773704333, -0.8808464380721028, -1.2059287987285257},
    {0.6608333728784066, -0.22135980591591184, -0.5617314540992652, -0.4778232655786487, 0.6099106123312631, -0.10560811806774241, -0.17536771723855835, -0.8965029760905308, 0.40092086077253525, 0.08384434286145022, 0.12558015402815265, 0.20700390395740165},
    {-1.0289214232350168, -0.808608190327662, -1.2749975710874848, -1.2227360188052716, -1.1315214717134092, -1.2314950403660834, -0.8116836252447172, -1.0703745004250937, -0.9096624515658175, -1.257524443924853, -0.32031061655847376, -0.6962412927765986},
    {-1.3783596044505793, -0.4101035205767223, -0.541397242193225, -0.1910382141711379, -1.0964874031997767, -1.409443888531837, -1.3531566956648913, -0.5204851906164929, -1.3750740910273271, -0.5715477106379894, -0.9233732275026867, -1.0375620286769724},
    {-0.4330325909680625, 0.4916535198679682, -0.1191936603649789, -0.2745112452298749, -0.5590853070269224, -0.386612710610383, -0.13811712348626237, -0.4541145189636355, 0.1293177408085762, 0.156272776305904, 0.24839236007522542, -0.14740971194108135},
    {-1.1389958362916859, -1.3863558391685398, -1.2259260678129213, -0.7926133603648337, -1.142473375849448, -0.4255042289907296, -1.0236787796979634, -0.3912686200905045, -0.7663400342250725, -0.9450486521367505, -0.5749936570739776, -0.7983767497525813}
};

static const float b4[12] = {-0.23656068543796935, -0.25684476654642463, -0.2825743796288134, -0.3131547325325517, -0.31492991162475426, -0.39045764307864356, -0.32366762435056656, -0.4568294960208896, -0.22893056303993278, -0.41167988429205327, -0.20189767505699058, -0.23658370186743238};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
