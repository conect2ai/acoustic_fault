#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.0169060018085927, 0.37543010132046695, -1.4561208623773836, -0.6329434213273624, 0.4491897554351253, 0.09345333350469394, 2.094122046731191, 0.534091980737572, 0.7324292844510083, 0.8215665932246388, 3.8980282866132114, 0.5340235690584223, -1.168955247535729, 1.296942847553562, 5.617670221684684, 1.6876101604760714},
    {-0.09388200976411391, -0.9538240632711098, -2.322192713491448, -3.316639972091737, -2.1075168723289233, -3.809294077328869, -2.1100474826294993, -0.7304323956516675, -2.2122221658609105, -0.22172503701464302, 0.15497544455178403, -3.1407183402681915, 0.2050113537892547, -2.1009495877142426, 1.1009450967555854, -2.0437340953074643},
    {-1.8811288357315097, -1.3023583938833434, -3.170864071049268, -2.235333062883106, -2.9967178340942984, -2.1623177640355538, -4.219094463190278, -1.6685825534914784, -0.9962181184758432, 0.790217510925774, 2.6185341811760896, -2.1733308044983475, -3.7125428843249084, -5.538396501499094, 0.9116135173240114, -1.9321175466295508},
    {0.7229553605625872, -1.3979430080997597, -3.566692676603431, -3.1775378491353345, -5.040418284787377, -4.67550601048402, -3.25354245619517, -3.099822665656814, -2.92546190139526, 1.947804884631217, 2.5117689364165305, -4.1633535641355195, -3.964457553945432, -5.0450154909124265, 0.9982414374972501, -3.817628394349812},
    {-0.24768121428710416, -0.5410763970603206, -3.7531254858658585, -5.359877989498437, -3.3891937104220884, -5.555846405042705, -4.63451498384686, -3.193366860890115, -6.663075776080348, 1.7740665370069453, 2.9494044612947703, -4.267386821265086, -4.683461547478771, -4.807509860142426, -1.416317801500391, -4.517346010373184},
    {-1.4351305135186412, -0.4881669139046068, -4.426346199489671, -5.661570455588418, -4.353846271587014, -5.794292256294037, -4.263410734540944, -4.096375008150409, -3.9096748918399653, 1.7821581667265747, -0.3523714057911402, -5.495964668551663, -3.4474354426146907, -5.156150343761902, -1.7072563621709642, -3.8358522801291572},
    {-1.4692368799494753, -2.219854710860285, -4.1077992633393485, -4.049382332736217, -5.394856246871145, -5.13539566231713, -5.826234738787273, -4.027040065722852, -3.0878124080099467, 0.38784629255819486, 1.058864772202612, -4.081927990993636, -4.7977428993908875, -6.3191891670772495, -1.3718569995490937, -3.9249525376271315},
    {0.6032355210769411, -1.6442266024981917, -3.431243344714683, -3.7282601237298314, -6.260715881945323, -7.511552402421879, -6.919169826778352, -5.7762635906131266, -4.089843720468532, 3.403613800327406, 0.8502110049968529, -2.5576280855903164, -4.499903801818206, -4.084265447480844, -2.2635117978627117, -4.019607563099379},
    {0.926189644358614, -0.5394572403809774, -4.127628764263539, -5.491172975612438, -4.685812867984115, -5.467356655544834, -4.962611062092262, -5.897039981036199, -3.6067632440195267, 2.6684529791065326, 1.4192756779918996, -4.204678171145278, -4.705234347864531, -4.234556536339824, -0.12865323842227133, -6.6713088283928546},
    {0.03715791693740938, -0.3837868749748924, -3.181204765760564, -5.629457448574781, -6.47955299543116, -4.691055339154425, -6.549974606586579, -3.7720816107195456, -2.849290354812141, -1.155166659872891, 3.353024782241659, -3.7579533201941904, -3.7955713402754454, -4.932524845548259, 0.5950248476885632, -6.303440278193752},
    {-1.8416236664178567, -2.2975113629165067, -4.55716848901107, -5.80346822221815, -2.5868738167831755, -3.1514131129197676, -4.245167057493871, -4.152925703261075, -3.299455740317626, 0.6681472066893673, 2.1142491314710843, -2.162066842838899, -5.890211204383196, -3.1409775481520636, -0.5909558898434508, -3.932765439505708},
    {-0.3914781579373423, -0.1874603962858196, -3.9127579259432377, -2.8601313656431975, -5.461870401894659, -4.520651044283062, -4.541099537525183, -5.899215863857705, -3.6831083362745685, 1.2397134155600378, 1.2505954666550598, -3.1081391242639866, -4.585934983605779, -2.79211204932607, -0.5081559518989505, -5.272582489950117},
    {0.037520748698537776, -0.8271397849931026, -3.2643966526549626, -4.070004125080936, -4.325842001709935, -6.240632701181225, -5.2828589131119985, -3.2076734680013557, -2.6396761444125305, 2.930739813491564, -0.5466590735278432, -3.39677117966464, -4.026153235956528, -2.469058781134639, 0.3401000265271083, -4.1331140235297665},
    {0.24981185792100696, 0.7350077424681762, -3.69081915763666, -2.998853553924295, -4.295490731289918, -3.686541001540646, -6.269048092223497, -2.7507599486427545, -3.3898116457382597, 0.9110378686744763, 0.8513443861638068, -5.027522714719173, -4.116255051715248, -2.684518256763483, 1.9691177088612521, -4.417628539981391},
    {1.402225604157031, -0.1462775133196383, -3.4531273763895003, -1.7876734253073594, -4.882997155725138, -5.639114148766972, -4.353566922956232, -3.010379610826244, -3.4919822863272856, 1.6962386511342942, 1.6405825993019763, -2.3261051510957897, -3.524607764819869, -5.363493305646467, 0.2816610719491023, -5.3401440948961225},
    {-1.01047894922469, -1.3875431628570047, -4.268333222521054, -6.324309542606907, -5.017210038578198, -3.5602066007308366, -5.398295967327192, -4.745757347483899, -6.280086444416888, 2.4615671966107233, -0.4779157693354445, -2.335227432854161, -4.390118805823031, -6.6592154794143035, 0.4904609779803849, -3.469241752064095},
    {0.6674523542087691, -0.7490510358793955, -1.720706341203095, -3.279606499603066, -4.720397656458633, -2.927090085646743, -3.734285434073175, -3.1264377463051116, -3.197517373052641, 3.1004759343862767, -1.4750241399960422, -2.8024758358776016, -4.652112418882321, -4.086488173435332, 2.121136657088157, -2.5453401360099215},
    {1.0307224811472138, 0.4285895018350484, -3.3620979108600415, -2.3160440994900333, -2.571964059811544, 0.3090257373775189, -2.6200252361456475, -1.6339619292882683, -1.4226246777849156, 0.5779193202979424, 0.5776752816914579, -3.2524477609764837, -2.3170774189338617, -3.1351622633817215, 4.575306731792375, -2.1701018571126043},
    {0.47781670398969567, 0.48416412729422437, -3.2527818423647537, -1.8638824475035733, -2.950835192922232, -2.246288530927628, -3.420867344522087, -3.3797348655004127, -2.0262439357225466, 1.4865422382532198, 1.3701888273124063, -2.292333911711211, -3.144703548452453, -4.807242695394876, 2.6750821415411545, -4.940675254968969},
    {0.7781868451450077, 0.7945085737584716, -5.428692711036086, -2.3780088730911038, -5.91119305954451, -4.423455468455906, -5.695859973182325, -2.530304397534364, -3.771414292127334, 1.6878560053991252, 1.1297492387677106, -2.9564171175644365, -3.008907306798827, -4.183217912258633, 2.0499995685589667, -5.219362607254536},
    {-0.06876237058038899, -0.0036271668243835088, -2.4682345719147585, -4.488963518130813, -6.479793836976487, -4.838954714127186, -5.530648811975727, -5.651198572058735, -1.819068908127399, 2.0431015444644487, 0.9385790546486427, -3.836101879126496, -4.261509637875002, -3.3810354743555187, 2.9153260428883345, -2.4261109817327298},
    {1.3998813356285047, -0.371726359881293, -1.2909489194546342, -2.7327646683450464, -1.7357066363900167, -1.9680210803219509, -4.652700530144198, -2.0978702367580313, -1.4710817898167161, 2.781786362507792, 1.132740082005316, -2.1603244065619203, -1.2607026079773396, -3.0782488420693053, 2.847170791204441, -3.31245127518498},
    {3.7434714504213744, 0.827504986809389, -2.3356559920222955, -0.8344099512750017, -1.6299009986575292, -0.7309224682889406, -2.6724793649764793, -1.753310254869117, -2.5288811142233563, 0.675689505176031, 1.8932731656171267, -3.416369330496551, -1.0804197502619324, -1.7417664146427407, 3.004834186633643, -2.4756561987698897},
    {2.2550117354296377, 1.0910913815218823, -3.2132800047335652, -1.4802883800733206, -4.580200893319614, -1.3764428819878105, -3.371588267880938, -4.0547094968135475, -0.562153910536166, 2.143383380832154, 0.012960355362233658, -0.3146937642765213, -2.8105699022895667, -2.7398048346634725, 2.3105058608143176, -3.5631262025144648},
    {2.528615008237877, -2.3852178985777037, -1.8056305456224575, -3.1031397069032125, -3.5576932262810113, -3.3416517584848973, -4.063594852304365, -2.170065011435715, -3.00970434359809, 1.4289683233994783, 2.535408049472272, -3.626125299717008, -3.343481478077112, -3.743357619758647, 2.6346934349715103, -3.648038072355572},
    {1.0085924573893885, -0.09972818103109304, -1.104355422612741, -3.0571585460973694, -2.850343812761735, -1.3436078287116728, -4.9554830893881014, -0.7527204125085949, -0.9434635361097289, 0.6778825062550698, 1.8707771627360466, -1.2533368950077683, -1.4543629787108858, -2.24318418674031, -0.007983684757615189, -1.9295632804248348},
    {2.2567277821318834, -0.6130531827227739, -4.560316181785971, -3.766049403618499, -2.5845773814339443, -1.8121401986926673, -1.8571316767785788, -2.326448554271978, 0.869751085445294, 2.2216130686014854, 0.27644123545441457, -0.7348362763278569, -3.225485585414014, -0.21911775564261093, 2.5945357754218774, -3.7653901133687007},
    {-0.03555870116881285, 1.1134049602091656, -0.6400257138628562, -3.396117541648787, -3.5033092371738217, -1.488423836423586, -3.3449629455690157, -4.109688714008137, -1.532501188269969, 1.1222591430656113, 3.813682294189426, -0.18454589687102405, -2.790363092126192, -3.9696735418182603, 1.5927211539072295, -4.527418324179202},
    {1.1856020917909513, 1.5646420813889108, -1.3675294648233545, -2.497213956361983, -3.9068760276738046, -3.5451597632189684, -1.304451874502376, -3.73485577843541, -0.9849440337388613, 1.6236651993237103, 1.6971959738404536, -3.143080194464549, -1.4602433985068344, -2.860991623128506, 1.7371756197269188, -4.063140454856176},
    {-1.7656436205407748, -0.8466520150107276, -1.6830999539660263, -2.433627504247257, -3.4451339577757096, -2.6459111045181416, -2.990375336665241, -3.4234943213361126, -0.36067571706745866, 1.123501641543296, 2.0386970009830208, -2.6398066675691547, -3.048290998304345, -1.548000561103996, 4.098279578347472, -3.2087881346844056},
    {-1.3512146465247357, -1.205998502190087, -3.5999321185205617, -1.7329049395399423, -0.6251503665943868, -3.506678448984127, -2.758284144312515, -2.2032183491525816, 0.522114945618742, -2.9489127906300445, -1.9234621497917375, -0.41672618996997746, -1.666422583989653, -0.8820115864104279, 1.0208147115024149, -3.6479212375548093},
    {0.16630325911356117, -0.7768412782205214, -3.877533646158303, -0.7442786944189211, -4.502759041172608, -3.2035569337208476, -2.543374344849512, -1.7680487199376647, 0.6258617219962654, -2.864793869784319, 4.211023322241298, -0.5230160100691317, -3.599843565634722, -3.2078746319026283, -2.464223113023124, -3.6086999444745906},
    {1.2986790082174293, 0.4866805863499984, 0.14047328728407268, 0.8534650250592072, -2.6098082575754273, -1.23074919840672, -1.2383823925166053, -1.2793619908309681, -0.24399888627415522, 1.52057074065035, 0.5576533587169235, 0.42802159377719345, -0.03774939284804134, -1.7554050562574495, -2.0108569398423652, -1.8365849524629811},
    {0.3665425688945021, 1.4890769331661708, 0.21266580247440744, 1.5432195296036062, -0.9411856745807543, -1.7183976447369274, -1.281945278506169, -0.35333232367624906, 0.12449444606455208, -1.2797826997160475, -0.5670402286351489, -0.9242685094544799, -1.8447703676557727, -0.6674607793940944, -0.11738678096957005, -1.0140649563127293},
    {-0.643847600994704, -0.18399922874691882, -2.046686488710889, -3.0133482262882714, -4.321890295518914, -1.9380547686982899, -0.44018604188700217, -3.0469265560227594, 1.153656211872158, -0.11322322908825325, 1.5988127064564224, -1.224274950640277, -3.5340398635887778, -0.5501526236898264, -0.10194772287760116, -2.916754439639831},
    {-0.5196508995769905, -0.9842519371383951, -1.5515281311469618, -1.4197311941705513, -2.5318367827483144, -4.21230011254788, -1.7527760619126962, -1.057909539776267, -2.28982757110007, -1.1295746253042456, 1.0817496458841962, -3.4875824092995384, -1.7453217470429845, -3.4298161556725995, 1.1252883327182468, -5.34521890774009},
    {1.0002932827149464, -0.4799379217811042, -4.216067347355622, -3.04840887315752, -3.3599447943794183, -2.4277363635179237, -3.0893258165773214, -3.989275762038188, -0.9777184198195822, -0.4960289678007475, 0.2902725091856214, -0.5257562106933757, -4.890109261598691, -2.2181342784961737, -0.3710138848664596, -3.51475750175609},
    {0.17139517764979964, 1.5814816302102184, -4.066060970974389, -2.587911552170466, -2.1438150287839846, -1.944684824653514, -2.7904308912955056, -3.3344683945819993, -0.21538941409033047, 0.962351554193357, 0.10166197535184199, -0.882662785693213, -2.9381134534833016, -3.0205543227937506, -0.706684111679142, -4.120354155669816},
    {0.10634882871473791, -0.02243119322600716, -2.509875635886743, -1.146387245322677, -2.7219616755274427, -3.7585972957722356, -3.2306710831421057, -1.7605392524637469, 1.7231677539838426, 1.368281179320407, 0.0861069974207973, -0.1322175670744766, -1.6732279883978394, -1.015312233295222, -1.0418497969791696, -3.35329631843062},
    {1.5067841537207924, 0.021743023071213747, -1.7904277291096373, -3.4819155589438213, -2.5788611165930098, -4.298040795633211, -3.4068226548244374, -3.6014821636867063, -1.436065292989815, 0.15013859942959054, 1.1830824301526754, -2.1701416059061973, -3.1265818928697335, -4.593576938150123, -0.34496559316759273, -3.9480067537058696},
    {0.5324421062022416, 0.41136292138956393, -1.140598000752852, -0.22938240718098626, -2.2785733113377846, -2.885912495932969, -3.529845256831022, -0.1447219200326378, -2.4595071599632563, -0.6320901609645551, -0.1578288908658675, -1.624807023873195, -3.1633883403766556, -2.633083685954739, -0.680690071460612, -4.686015714218129},
    {2.170647480385564, 0.6086681236799215, -1.1277189610731977, -2.0455918164476166, -1.3816805557829284, -4.768246249453136, -4.362868776032199, -1.8604491780701153, -2.7263847878803866, -0.2020524802868473, 0.9663167160842961, -3.2913525637957517, -1.407739222474505, -2.886812963878304, 0.12510800946438527, -0.6880562314944965},
    {1.0897719931339553, -0.7870287370133531, -3.478063873948581, -3.7373539170903305, -2.587780846377309, -4.019056404823352, -5.464500578653646, -3.050107159574361, -2.9521035270386617, -2.12626049498764, 2.2423793886323486, -3.0203088256286934, -5.065734023583276, -3.4677834351587076, -1.7304732483912948, -5.522284342239977},
    {1.2304724460674572, -1.4476011214393656, -1.4267566590872323, -0.811236348418955, -0.610653212550045, -3.0880052670735063, -4.334183813966774, -2.4174929090380592, -2.0516176984685672, -3.222352535426854, 3.0525169510984815, -1.4615822483601546, -2.3230150726543592, -4.048760192015693, -1.7312629340782528, -4.441892984270076},
    {3.103579228169525, 1.0800789060980596, -2.5303948192849997, -0.9407309200300502, -4.053602744977315, -3.38143298636557, -4.955163144900841, -3.2681089182847582, 0.14107344685542741, 0.15427199059050128, 1.6118571282150282, -0.2668186909343019, -1.6465447869692065, -4.025570529026379, -1.8053134275883502, -3.001670991894691},
    {0.6050588490180239, 0.07052137588773227, -2.570731771037626, -1.1357966890625817, -2.1756710649832085, -3.3251840036884146, -1.841101839396267, -1.6435689073459805, -2.0717870925629804, 0.5649449324186514, -0.27776521276505156, -0.06581342487223939, -2.3823879005402273, -1.5373699301348163, -1.3820665498126736, -2.6983560579995833},
    {1.4497779933403099, 2.986333496138452, -0.7141013429209936, 0.37853262365093143, -0.6917058255004479, -2.450707862818466, -1.5453602533480677, -1.5824579981297207, -2.3855833825983677, -1.1843412143621044, 0.0029771642555413034, -1.35717471334929, -2.392865999918903, -2.1411092778730465, -0.2931737996432767, -2.5347727898550736},
    {1.017271542603057, -0.4375032339781747, -2.752214894052857, -1.6683622535188067, -1.179510970894257, -1.5854206219626537, -1.7683832242464161, -2.60548458816606, -2.132441924865971, 0.6954820322153992, 2.136404740250701, -1.8194111390053438, -0.1322480860564567, -0.4995441399163, 0.4458395012669593, -2.120058336704318},
    {1.9611471596786088, 0.6135195899752438, -2.0995040912074234, -1.342243078331718, -1.907408391680071, -1.2232693139237187, -2.5287195486292164, -3.5992718766022516, -1.4400091574385667, 0.3158657753314735, 0.6409019782658235, -0.21079707905589257, 0.4460516793766901, -2.651795151677088, -0.042536074690020256, -4.24770470068499},
    {1.0026052883942222, 1.8419763297284109, -5.147416031416185, -3.062464026764386, -1.7226285239918273, -5.17490039458902, -5.2828407213089585, -2.830388366327141, -5.595170891745391, -0.23221065996192183, -0.1418057222400919, -2.3303431288187695, -2.977907327906873, -1.7828154021272822, -0.6370828665394397, -4.467272251024865},
    {-1.4590893718775984, 0.7774458088165376, -5.471548982881016, -5.455987741780584, -4.882687289393327, -3.3976562653540014, -4.012662936630729, -4.613761611971775, -2.783388825722147, -0.26483021537374646, 1.7055137828981932, -3.494423668323799, -2.5530707198697273, -2.296290762581636, -0.393333121042263, -4.5934421118704725},
    {0.34625022713861797, -0.8575931408835642, -2.8649448180134773, -1.1295358351552347, -2.4778409272827306, -1.3029784725625915, -3.180880735019836, -2.658979499029101, -0.7394895958641304, -0.7856679894079868, 3.1875992599459626, -1.878364669323798, -4.194887597577507, -3.5494827092307695, 0.18216789097109018, -1.4204541058388742},
    {2.017506090333047, 0.5726771382176368, 0.037345545798246074, -2.744805484775085, 0.06028928016929861, -0.9663389641968471, -4.012744692557627, -3.0051658974204956, -3.5296302324912534, -0.10368126234325624, 1.3988569062732785, -1.2179697774545069, -2.5740891305541487, -2.0785694207639245, 1.5694282914832594, -0.371311345217343},
    {-0.05585958686037667, 0.7310471659081201, -2.327970142576279, -0.9470049667418156, -1.9825258916558333, -3.775494553021643, -2.725020738204031, -1.8632479294749607, -2.9791398934183575, -0.792137704768604, -0.36532529022955557, -2.1241759887806557, -2.9108708001974204, -3.5782576619969513, -2.7852462536696128, -2.6650429685498183},
    {0.31662704656260693, 0.4455087686470525, -3.51994004751171, -1.9208925106826338, -3.6666411190196073, -5.915653166020383, -5.006592060226961, -3.5535607276230983, -2.1238996931319294, 1.6231809503752708, 1.7536393176184943, -2.2963332831138157, -3.27570087149548, -3.116477451759554, -0.013730731491730324, -4.334500704849348},
    {1.763257197069979, 2.128161788148894, -2.1664957958093476, 0.8430223464924712, -0.5296533283562151, -1.1145584727298303, -2.0572641626902164, -1.7801578889498566, -0.6472430325151853, 1.645439274074662, 1.1783798919044526, 0.807519578942619, -0.7038260175480071, -0.2645087492389119, 0.5072825679862226, 0.29907209001686297},
    {2.132438997661393, 0.5834218942289293, -2.326920649918527, -1.517529158280059, -2.015123757096595, -4.92347289039782, -4.325099419063622, -4.2329637269901665, -3.4813499985890397, -1.927832278011312, 1.59865803943023, -1.5732219291217524, -2.854981534673235, -2.493870662963678, 0.867188543355506, -1.767218671053743},
    {1.706340157187524, -0.4723035541178991, -2.2411348304039116, -1.5863808190126212, -3.201363576606616, -5.384807246633132, -4.578599428212355, -3.353946145932566, -2.186241330872528, -0.18522611961008106, 1.739459319580284, -1.5492603892977177, -3.647048142607634, -4.116444839420623, -1.0870251561672153, -3.1100391705381902},
    {2.870095966188209, 1.901696130428844, -1.4719811510860263, 0.08381587069554905, -4.242620854717333, -4.11545545457086, -2.410029450129688, -3.0847349719223005, -0.4766656840546307, 0.7715026418047245, 0.05539413091891826, -1.4090399689398099, -2.9015736619061587, -3.1112112469142956, 0.7525389074133843, -3.2194554059212517},
    {2.461705420943725, 1.5098933795456924, -1.8354733951702922, -1.707200828479257, -1.6642573993913576, -4.038043412385624, -4.6047570843027055, -0.41691879051092073, -0.7439828984887524, 1.622551421548054, 2.014257446858487, -2.1676692378113294, -1.8214056142257076, -1.49293609951909, 1.8188532424550374, -1.9596352600882798},
    {-0.9669757210704206, -0.791621605195498, -0.5237471005657721, -0.15082066212098494, 0.20402926328509755, -2.1843512009010597, -0.44169099401779055, -0.44487613811965343, -0.6439909488094677, 3.5896584374569622, -0.81174909766016, 0.7893709690688677, -1.275992044951145, 0.18459063383708674, 2.977106769612903, 1.6616959731403398},
    {-0.9425731825733966, -0.7043548619672659, -3.843318903855365, 0.719757567731727, 0.2051543183692371, 1.1570530719430803, 0.25481065732381436, -2.482613178700716, -1.1982354509521518, 0.31386203330623375, -2.0624263842780306, -1.0426903034057504, -2.506632238614163, 0.9379856334738256, -0.6366934201569106, -1.0470053054819795},
    {0.11975691180963809, -0.8516418629740088, -1.8194021266415812, -1.22780770457625, 1.478812344452267, 1.6700551947834417, 0.9194515300672617, -1.7658854530625216, -1.6246873853521622, 2.370488678156406, -0.9029777895382298, -1.0207161011804113, -1.1123177835450035, 0.6480730863710928, 0.20440584233974135, 2.735750405793853},
    {-0.5355293516156723, -2.043455663823131, -0.16700806033144144, 0.14184833255022763, 1.3944186791431428, 2.0434800905904065, 2.264619950932556, -1.1824944756666487, -0.7044906747581843, 1.0259497451156994, -1.2976573927192006, 1.3750081433689838, -0.6185286723223304, 2.28451835054323, 0.8229406950604117, 2.7672923598955452},
    {-0.9940991372254747, -1.5910369420188433, -1.5767477868077608, 0.14609605524103228, 2.4785809590262806, 1.3218540617884689, 2.6338632753606843, -0.4776477411638138, -0.07861239672811403, 2.7327577308810205, -0.5296184570622446, -0.4197623241920407, -1.0688598952078776, 1.9315487151299136, -0.08826013608497305, 2.858467420615648},
    {0.16818351957913913, -1.8354055152665956, -0.848912938176487, -1.289443822438256, 0.05030715101322325, -0.9430560119546849, -1.6492443394147054, -1.4140443846555346, -4.102733394643571, 3.662226439125854, 0.8668054311373715, -0.7240380675087659, -0.6828007947856589, 1.9564228667514632, 1.232071400136617, 0.16730902405540868},
    {1.683350297037005, -0.7716233574967599, -2.2431762090552194, -0.4414366404779576, 1.6969113775939408, -0.7546407902378633, -0.4989608689459435, -2.023161893835906, -2.358283751673043, 2.5745805486982225, 2.265624348366287, -2.304787161058213, -0.9967437025497643, -0.7285240353954164, 0.9172581246154844, 1.0823738951115445},
    {0.9220787641169508, 0.9913713058132707, -0.07153349262237158, -1.0103817855439343, 1.2521817962241557, 0.025071062808044824, 0.010740093570825344, -1.4968793708302666, -1.7626626896417252, 2.880202784598809, 0.5931170633949897, 0.3953620813704498, -0.9959384588875244, 1.5069329205964388, 0.46017141841615394, 2.1222008045941267},
    {-0.4167801169301403, -1.396830864502989, -1.1179697226133813, -0.5155934036689207, 2.2142116463426076, 0.5574142887222684, 2.4874325187861355, -2.804908601747944, -3.4623333309240674, 2.8568012322178404, 0.9746161969685629, 1.0460924212266476, 1.566380543062911, 1.6557960845319528, 2.0835440272854187, 0.033136132754897143},
    {-1.6428646362677375, 1.1389571490827801, -2.6594309038936927, -1.4969003419584304, 1.7420814128495028, 1.0787920916686138, 1.9274483600692045, -4.1881379645905845, -3.0931454906536353, 2.235825792916147, -0.1737686905327053, -1.1978018728298419, -1.3704428902439965, 0.5683849088755781, 1.249036081423723, 0.6247097768014027},
    {-0.4775022445262194, -1.832517279465834, -1.722375514054722, -1.8122520454364908, 0.6405558623356613, -0.3901022110677285, 1.9979513376652216, -2.1550248763972517, -3.832055106447457, 2.2896493573307155, -0.21410037526156958, -0.4398942816670431, -2.6767501530193956, 1.0885595211505057, 1.5014643350334664, 0.46227147610934866},
    {-1.8924884249099647, -1.9459396900936639, -5.0371370785031315, -2.2311358880239385, 0.20645030616513343, 0.9525006632886943, -0.6115351872497446, -2.7257097748114507, -2.4110088640609413, 2.7143987654166426, -2.3262688783238072, 0.018237782456890242, -2.645471347450322, 1.457784549704857, 0.41486391383867804, 0.9610912828198435},
    {-1.4749872627778577, -2.480125272067761, -0.8101138035314164, -1.1866557089641765, -0.25377092218550446, -0.8236106086845457, 2.0991199210619587, -1.9462499487801808, -1.7542892219131268, 1.7385548079548103, -0.8104677204164993, -0.8735927370314066, -2.041173444012308, 1.2216393763171816, 0.6251186126777541, 0.7758050770077084},
    {1.0777769214146198, -1.2660930689334533, -0.2354886916952907, 0.4626139291785085, 1.7592192107806128, 0.5161757542938501, 1.085989201134158, -1.5484088087304542, -1.4287657173769697, 1.0779550205454693, 0.37543868573928124, -1.1107436607311525, -1.7263958636617527, 2.3435227120797038, 0.8582299397248427, 1.0720849915469548},
    {-1.074943659571635, -0.8829923680677363, -0.9008337364705731, 0.3859538566845417, 0.1863199879201064, -0.6595003228428117, 3.1947632538704847, -2.9393243194752587, -1.6573401612634828, 3.7105355719478488, -0.603495177188997, -1.4915073636278924, -0.11798438792216157, 2.6488420321185178, 1.883242625520384, 1.4615038120022714},
    {-0.8310981226663009, 0.3984393774771588, -1.667979187764629, -1.549096676820217, 0.9688032025569934, -0.22428875350301108, 1.430205770532035, -3.77308080398212, -2.537399035007196, 4.152435250282989, 0.27790951082071275, -0.434326322618234, -1.8906240639210619, 1.3579237110885183, 2.3332397409987062, 0.6952167387768361},
    {-1.4800425202457823, -1.2454248071100558, 0.09800867674231893, -3.1042146196000977, -0.1850483797084898, -0.23885342739993187, 1.5044918610320062, -3.044128108325803, -3.58371917672418, 1.7294989890621009, -1.0919979231516537, -2.251720080097315, 0.7222478359989927, 3.8411265655378175, 1.8790875600322523, 0.982898252729827},
    {-0.8675202034466664, -0.8692541793878003, 0.006316108390012418, -0.5980527435617882, 1.8759806618798756, 0.9891912305137572, 1.3322492987258139, -2.2908116934568095, -1.8716242128346998, 2.7511485895462835, 0.4749857120728497, -0.33661673467410036, 1.610574038725828, -0.7591944997233735, 3.1482738718432124, 3.1648813116351326},
    {-0.9149825006573185, 0.5870080130875824, -0.9270708471556838, -1.231044862243703, 0.2936525557951885, -1.83181024614904, 2.5217750296377295, -2.3135507509280684, -1.6866821811309816, 3.531521569705705, -0.022884723420532094, -1.5584142215723307, -0.7086319889716168, 2.664240475008855, 0.26894790954569353, -0.30019469251658915},
    {-0.9441643020949786, 0.7322399967094231, -0.24017064718309267, 0.047155034637621177, 2.2369469037835614, -1.8395633549117025, 2.214854914933189, -2.3393776012641916, -1.8205989584765285, 1.657474119774737, 1.5221763529574706, -0.8968290270015347, -0.28132317736980994, 4.281214830026345, 3.35841033736482, 1.2804827833440102},
    {-0.41680115941966284, -0.2938498396353875, -1.619054325688391, -0.7295353202653339, 1.9140453456789561, -1.2106930283851032, 2.0573018004295154, -3.0263451581312246, -1.9203741814799578, 4.205606668839946, -0.3033725402692984, -0.37538975394213464, 1.2696601579280724, 3.4312199584279606, -0.4366755028756513, 0.0916158239835733},
    {-3.1241032677741933, -1.4377579733066712, -0.46271431597732476, -2.478756421649817, -1.504372796511811, -0.16991804832145682, 0.28899604999280476, -3.690359330772819, -2.108422630000227, 2.6748056391511454, -0.23424531460152934, 1.0955163438536675, 1.6649386250488827, 1.4586031689391479, 1.4463540248438858, 1.6290279916779036},
    {0.7676361005058254, -2.689903851390994, -1.4836071484883617, -2.315656167719192, 0.2547942433596865, 0.5417336442287829, 1.760508430213796, -3.296535520996364, -2.6030415880007576, 1.2562680818111893, 0.7765870859459979, -0.6430876404660293, 0.7226297542905941, 2.7197156751554084, 1.01648953165068, 1.3045257551525948},
    {-2.4530219621992484, 0.5447247530154495, -0.6356970736617857, -2.2031155964721854, 2.4259669786379803, -1.0238725400792519, 1.9956875797590965, -4.832083485793011, -2.0108836605987053, 2.587444393238507, 0.7442167042214394, -0.18864644227861468, 0.5683522991118438, 1.7980982667487686, 0.45002078338290924, 1.7584106661676857},
    {-2.1921207486332537, 0.8158987075886576, -1.5908845293126903, -0.2698685533010627, 1.5480409947469929, -1.1803799820822345, 3.501018043506802, -3.7606237998843866, -1.9130592741879573, 1.76729409760223, -1.060546192767167, -0.3893697331726612, -0.913438590243683, 0.6997374225756959, 0.5954982377399443, 3.223805427896191},
    {0.7904531654233902, -0.2332862713835942, -2.1927215404654716, -0.9434381403302002, -1.0632004946827371, 0.5809432963657944, -0.4261509035970247, -3.4021791914780004, -1.1754025861665014, 2.9960747854051735, 0.6552090748389408, -1.2621110338046948, -0.06785717297167894, 1.2140108123734386, 0.573726428626593, -1.1449798100779938},
    {1.4613556270827122, -2.079403819269729, -0.9006566918306448, 0.17391537222626938, 0.776538002548693, 0.6450760508026163, 2.9898937134960932, -2.240903757594947, -2.289395422666821, 2.113272514760944, -0.3915809986721693, -1.1908983621435143, -0.18534216706312237, 1.3295778003493024, 2.586817453912882, 0.39465432741002876},
    {-2.5339260582514753, -0.17872426946808598, -1.352927950737952, -1.9461358337861572, 0.12814969054999095, -1.7541748251582174, 0.8065508820648435, -2.684259606772786, -3.2216414874023656, 2.2338765282929156, -0.12259637297072119, 0.12319454903435605, -2.723832829345998, 2.7661273734441147, 1.245575782486099, 0.4262183448718613},
    {-1.1318657103250132, -3.589443125717201, -1.0166545467096502, -2.0681638162362392, -0.006017997320834729, -0.6651275571504423, 3.872934700195869, -3.18808676720762, -1.6751182028048406, 3.507856392722321, -0.14631537083575574, -1.267886269273548, -1.3697687953652904, 1.3613491052291182, 1.6075084698104425, 1.8110956902160191},
    {0.3377256648701363, -0.37134249609983694, 0.6427739239480138, -1.9556110843897947, 0.9020707337770492, -0.3949855236523314, 0.04765321250384472, -1.4620229616017972, -0.33955264762998943, 0.7347362675291514, -0.9654722709362955, 0.10193020636473381, 0.08580045330156758, 2.1335248031783705, 2.2029512327924556, 1.0299933918319435},
    {1.8740801486366527, 3.046277890436895, -0.2013294430392318, -0.1005059518421085, 2.208149179133541, -1.8953796942176127, -3.9616702567897786, -1.4798414370924262, -1.8306871112058536, -2.896535208155898, -0.7124721905707125, -0.07780645407457294, -1.1281046944770639, 0.5818468378509891, -1.4206203403273885, -3.416675330126096},
    {1.525986014564167, 3.6275054352708502, -1.0814509901875535, 2.3772014857549086, 0.45568992071147024, 1.1239855188046648, -0.250008871185684, 0.10446299442361283, 2.6188948947374877, 0.8278830594333181, 1.6278288754909145, 2.8151526720195736, 1.9808951050056305, 0.7395644433708837, -0.8043683035248591, 0.15927273734860498},
    {1.036230771666567, 2.6040890162558896, -2.2717943203789335, -0.22013512261269008, -1.9392277804480262, -2.5590306969018815, -2.869988843888723, -0.3163178658978133, -0.11253669049463909, 0.28447019456449085, -1.1539352470261213, 0.4557844199904936, -1.1464790744482818, -2.682166289747024, -0.21571437063007778, -0.8163165779481011},
    {2.0835934199630293, 0.4893073400115421, -1.572717476348122, 0.2925304269517406, -2.943536152781041, -1.533120082586997, -2.6980545104436207, -1.811651856047092, -1.0491907396060336, -0.8317233116183905, -0.703493657979544, 0.03505715403719265, -0.17035259569038752, 0.3665874802401587, -0.9808790183881586, -4.797062477866566},
    {-0.7607630533600952, -0.344925615223731, -1.931439893353517, -3.1483800215719784, -2.5560765145635793, -2.775693100745384, -2.7481995821448106, 0.11683745176076583, -1.932220316689255, -0.6191937499429263, -0.6566394480388446, -1.0184651349466884, -3.3645428915321896, -1.7079966866201457, -0.9912923312396139, -2.3138159059961785},
    {0.6615359218584603, 0.5228113297491706, 0.4682625590068756, -0.30706058870967196, -3.9774819119123004, -1.7051040759645515, -2.379256025806642, -2.1315180634668978, -0.6096261167252062, 0.2703133599263314, 0.9960416847043462, -1.5176898509346068, -0.8457162679272872, -1.5233258920808848, 0.5493974944974953, -2.9732963022696195},
    {-0.4991173449133082, -1.5069185922064334, -1.1276781352512997, -2.4467273142874544, -2.8574886337500427, -2.202354903639165, -2.4248077095988467, -1.9784289561911423, -1.554511601924163, 0.7827136646374085, 0.990717468762942, -2.76781030329551, -1.5886764653525964, -0.3629691690720287, -0.2969924796607374, -3.6019745874857803},
    {0.799500104517761, -1.0720546555654864, 0.9162447251988365, -0.059536801992563934, -1.7264588798671894, -2.5247357264721084, -0.4227410269882004, 0.12620470837635223, 1.135674845252445, -1.1262457424456482, 1.3101202065461937, -1.0727886120061765, -0.274888315397762, 0.21060923222068784, 0.9639690250940397, -3.988184086435022},
    {1.7714333743299338, 0.15712636159278115, -1.3155954246393762, -1.6218683058103194, -2.8462725370945385, -1.5980889540235808, -2.882458809626139, -0.16847356147510603, -0.6922912958984835, 0.4438748212224236, 0.4739742353366422, -1.3175531831169354, -1.2335577829989886, -2.2657400611499776, -1.5463560571108363, -2.7905440021190637},
    {-0.4070625647235363, -0.1658549419348654, -1.9891789763655485, -2.164205792783799, -1.9273357983450436, -3.2888491327633202, -3.4688556482682977, -2.2372782540818283, -1.680964121115543, -2.8086337457514725, 0.7033683032860897, -1.7122627352785709, -3.552410297511987, -1.5566320300966936, -1.1953820344184982, -0.7774589983784649},
    {0.13828157359356497, -0.5133064722531472, -1.8379352962738942, -1.1784414099172213, -1.2976820378060991, -2.6204398798412276, -3.2866690959559897, -1.7819300534266478, -1.8545734428919365, -1.9305785855471629, -0.08976555156381928, -3.376339987517699, -2.4623897051161703, -3.6274873856356615, -0.338884548189342, -2.1021546882514457},
    {-0.1643247414905766, 0.1327221187633378, -1.8122459225431755, -1.5272062362559666, -1.1683792835055635, -3.585051689984962, -2.4525187852117316, -2.874864391485396, -1.25853416187174, -1.5587894983839055, 1.0867416169738764, -1.124812747961518, -1.0082053311763206, -2.2839750333189186, -2.9000287676557863, -3.405228061476457},
    {-0.7190945140134124, 1.048849710254167, -0.9528450086426976, -1.7959348002154554, -1.7581381767348758, -5.322685058070257, -2.741981532296381, -1.2973120315147593, -2.71987169289425, 0.20978533711820488, 2.658142054947121, -2.1132434145953902, -1.8744758775808195, -2.2825103194971903, -0.8254653048230391, -2.8382465571645508},
    {1.7857660110005382, 0.7470954961818662, -2.439120382529152, -1.2531038652164876, -0.5640133003052937, -2.0919850122000603, -3.28228583282438, -1.5936959326759037, -2.1979324901042343, -1.0627002995132995, -0.2687467243984587, 0.49625519833838466, -1.0158037915446207, -1.7911272954146995, -1.4679753226691394, -1.0638704269076966},
    {1.8928586881450706, 1.5345588769699159, -1.3891832070108525, -1.5365898604149808, 0.1034020947092511, -2.551744858818222, -3.319959727923823, -1.508341431363191, -1.6718188054779841, 0.024854420277651244, -1.110252488142722, -1.726644308491079, -0.9212619545910177, -4.269377749328471, -1.019478182184717, -2.2446872854725926},
    {1.3372145209414747, 0.07986266899741538, -0.39919501123589657, -0.34492039506928135, -2.534762985549274, -1.919033724617571, -3.596413534485305, -0.12683928736189964, -1.4393499479601142, -1.7748237954200667, -0.44920362068291225, -1.0239544322721394, -1.2974203202971712, -1.8568196581888363, -1.200005218358893, -0.20641583309562503},
    {1.1962677008157254, 0.4939666080970155, -1.468419956555904, -0.5323589178644823, 0.5340784062285567, 0.6064707131718768, -0.5814155308726981, -0.3920410669730105, -1.9692080056075971, 0.2996784290802431, 1.4916841612487288, 0.09428318302424327, 0.45553690672288466, 1.1798554899518054, -0.04172993112452272, -0.4608073115758554},
    {2.2019292965878003, 1.6562319034693456, -0.3089658601027765, -1.1662204860929666, -0.8874893647537888, -3.5265623950512204, -1.3725486524880108, -3.112670227387536, -2.3319726008452104, 0.29041013812133615, -1.5798398593366707, -1.6313565700313881, -0.5416649566409123, 0.3520196265854024, 0.6716906394565245, -1.111379442842291},
    {0.7078520529872104, 1.274205492195502, 0.07667559209058396, 0.38173366701019307, -1.0515088414319826, -0.7455653956437355, 0.149033248181009, 0.044063693295087254, -0.16772067050237802, 0.9766553016463457, 1.838430699327505, -1.00725174471141, 0.84603331870584, -0.7770047731899826, -0.329538870849406, -1.7093183995880332},
    {0.5498899883539901, -1.8525862820683172, -1.5572732164623426, -1.825064323224621, -1.3061879785905022, -2.616462178609493, -2.28713066034921, -1.834306792279947, -2.3269390543501682, -0.3073176169256438, 0.5164783928362232, -2.4319224659599255, -1.9265905846501645, -0.9150410102487646, -0.8366788276876881, -1.04141300725897},
    {-0.013190947336686229, -0.12655065173068827, 0.8616343940778757, -1.8339537643223203, -0.15287353235408965, -1.9259869064494184, -1.5680861595205573, -2.8758523756386163, -1.5789357644031277, 1.175974684186248, 0.3485742685974798, -0.09259455764620496, -1.319428102916806, -1.3982735708163343, 0.302293424317303, -0.9588202696820505},
    {3.2647218763778802, 2.595386036602188, -0.8178369044988075, -0.698998083360635, -2.0019815382760613, -1.1581773217256588, -2.3054035525491985, -1.1503027335431977, -1.9948655653708511, 0.3146025235935829, 0.5659974375550089, -1.6409295339502326, -1.9263484655097391, -0.6282147651021031, 0.6702786421295125, 0.4496383787368815},
    {2.9020374516576837, 2.323991748740004, 1.1788885519887073, 0.003440393790407994, -0.3799061943638899, -3.0608815169045647, 0.1413322460205812, -2.225388236385822, -3.818481996828329, 0.2506227381137336, -2.0121033344246193, -2.0000185796784122, 0.7349997540588454, -1.1019308383603184, 1.1051472989649307, 1.372470513620885},
    {1.4755854479632482, 1.8897700750070836, -0.8082710498903433, -0.09946410778673544, -0.27416967843878876, -2.0161704812250094, -3.773216319289775, -3.835809893799449, -2.2157705042604667, 0.26136158746764737, -1.7158586865410708, -1.9109115008117603, -2.6885815456338067, -2.941874729771665, 0.8045301841157517, -1.1901212734298032},
    {0.3516989279178312, -0.1851830890084505, -1.8884865140665366, -0.6790176021375719, -2.753609311443509, -3.990894177163267, -3.8522355284959455, -3.3830974841100394, -1.8485654986873314, -1.6899896511676462, 0.40898114548385245, -3.8451702611213467, -3.261975869070281, -2.4315172126963005, -1.6894141508942742, -3.4893287596271314},
    {2.600573605653141, 2.7191201563101326, -1.7084872718102622, 0.8341458898293468, 0.21700623661597976, -2.1919009284184368, -2.7190095211479046, -1.8435582358410751, -2.859950926509951, 0.3413711652506233, -0.6999050160819741, 1.1328945320980734, -1.3757337035783515, -1.3486009585035514, -0.161013714228223, -0.761584745062647},
    {2.8982707400657626, 2.4058778145085316, -3.578633937400218, -1.2729651655899226, 0.17599555147262513, -3.812042847486517, -4.488889713216608, -2.761958680620807, -1.9045847285018944, -0.40411808659800136, -0.07832558492089095, -1.5958515145170038, -1.39847434247823, -3.162208919294892, -2.684723473611474, 0.22685002091315393},
    {0.13777260469509583, 1.6125688981281656, -1.6130686661724178, -1.5995029137479098, -1.1405842306469514, -5.0028574363784655, -4.0603804192283794, -2.597900148896984, -1.7099838466980182, -1.0313889748934442, 1.1299801215559802, -2.365307797988403, -2.293180062638209, -2.1575664624224076, 1.3961053119446838, -0.2292922114335104},
    {1.9861934791307188, 2.3705451880728448, -3.250702990130072, -0.37027956903152276, 0.4802902308502816, -6.5885324725250545, -4.027047396354931, -0.5811499901225688, -1.4404378122559223, -1.7840185185913064, -0.972939464756293, -1.79401130313039, -1.758032542643246, -0.27115821450924493, -1.163658376335937, -1.6737567434773837},
    {3.0186574700558015, 0.4977873157488507, -0.7713313377068773, 0.63843672167148, 2.734151002668063, -2.291395333347186, -1.7877817173125985, -3.5969031287923166, -3.472707410960307, 1.9853158251943315, -0.8848199573810576, -1.1203077430406891, -0.4923923118154659, -0.017797491650838704, -2.0881467592277905, 1.299271214119629}
};

static const float b1[16] = {4.505165612703215, 3.8511329903783715, 6.691759148941292, 5.859038496594133, 7.013884141346562, 7.297370269019872, 6.99689802652466, 6.455647583467753, 6.151046327569789, 5.186386897062051, 4.136467864158933, 5.020765954943992, 6.053814835492571, 6.629089839584503, 5.316060946351475, 7.419264863381079};

static const float w2[16][12] = {
    {-1.9531634006121155, -2.406459226699636, -2.225121549828578, -0.9512078709196721, -1.9648488403566584, -2.2107029488254306, -1.5078768048402877, -5.204912715946744, -1.0728583739807018, -1.615379322597983, -2.4836326256612136, -3.2068411414102007},
    {-4.000237027733761, -0.8435927717397943, -1.8165297337934851, -2.3745397523884826, -2.593751391394879, -3.151648755147042, -3.676786284551041, -0.7984958580760504, -1.6137400236825068, -1.9390950604688486, -2.6656727223859185, -1.5487710512549755},
    {-2.449615139061164, -4.270161556988243, -2.613896250327291, -2.9885248418194834, -2.334115396438841, -2.9876006105771626, -5.730357580805668, -2.6887285607414704, -5.26374800386821, -3.0388607224943294, -3.1475499544991536, -4.599042083917166},
    {-2.4342678121422825, -1.210704067232508, -4.3694658722188695, -4.616204427960148, -5.300539556344216, -2.209950990843959, -2.889728201496886, -3.1229616258057367, -3.9601227329944564, -4.7722426547538666, -3.1945267112856235, -3.9237187159015554},
    {-3.4382441049507095, -5.648514129582872, -2.8395286969239413, -3.836509197583847, -1.9637878439953553, -2.698558992043123, -4.2570735932237795, -4.413289841111102, -4.327254289388482, -2.660490217018394, -2.132622497578073, -3.3975312978154295},
    {-4.16393187594597, -3.5663295256322285, -2.2686837201083963, -4.27433423547439, -3.615659188675199, -3.6443024123622694, -4.1904947725612525, -3.167941076393579, -5.032472697167208, -3.4355140208121875, -4.3090070284566275, -4.560760824099644},
    {-3.6233754681258943, -3.788669193601673, -4.169186556951866, -1.8867291721693795, -3.582957614954199, -4.4407450739777445, -3.4701183433357046, -5.219868367128579, -3.0568665633852166, -3.7219326607561904, -5.583359498035292, -3.5526806018161716},
    {-4.285309704916808, -3.200452552399901, -3.9648366746810284, -3.601560155987038, -3.4773279377054567, -3.8704321403959545, -2.872945588955031, -2.8870999999395575, -1.2226026933070717, -3.6633902157344767, -4.201898740097347, -3.0632176478410944},
    {-3.9478200201890523, -5.033708168903991, -3.9458105954209746, -3.3096214996990616, -2.7888822293046833, -3.3821063650552494, -3.0191655958897026, -4.011746718211039, -4.313924835404199, -2.560947352879025, -2.148526666029996, -2.7051250451719167},
    {-2.8271778232432214, -3.7995534048264754, -2.114862055123025, -2.106881277122318, -2.0716065657099354, -2.6497810558622352, -2.924594947263063, -1.2012710810240004, -2.3375541499279686, -3.066977592134839, -2.682824750483539, -2.522723983181786},
    {-1.9575490895628862, -0.7758063593811683, -2.2975237456862176, -3.3628021421436074, -3.2177986035283457, -0.9530129185210565, -1.9899754788644708, -1.8186296081627678, -2.238803065573729, -1.9007686437418794, -4.2723518284391115, -0.45878102946886445},
    {-0.9881267919891809, -3.6684546214035687, -2.869508180497179, -2.522378767642755, -2.3494680184169345, -4.874189223760707, -3.117246002814421, -4.201371683092989, -4.057381836254674, -3.0765675018635648, -3.1111028935174527, -2.981215705558701},
    {-4.179391356996346, -3.438370205969864, -2.981030082092279, -2.950454085359616, -4.417226824841679, -3.6046825520280654, -2.1516696298989273, -3.077932302416254, -2.8886964945394364, -3.9548324646429482, -3.5700819271106736, -3.241812263874363},
    {-3.7995782453560176, -2.1881684092745566, -3.949643209445801, -4.910061057528606, -3.4005691273535734, -3.5074238695205873, -4.0421338520890435, -2.6308707779025875, -4.044402612944622, -3.288579610137023, -2.4235105163304644, -3.855669379990343},
    {-2.5472112658047283, -2.92504492909612, -2.981353973596276, -4.1469011679538665, -3.9605035313367076, -2.7905953296949417, -1.3838166923138713, -3.437639063357154, -2.4584619998145207, -2.2962926908895116, -2.1176030492617044, -2.9850884446098003},
    {-3.964314114684476, -2.779019526977448, -4.377594720541671, -3.5052795487453317, -4.644316309327379, -2.934886835785734, -3.3939000029333433, -3.9594868556493386, -2.7411648257496197, -4.056630917287259, -3.922685633570012, -2.737599116300304}
};

static const float b2[12] = {-4.105236199443372, -3.9587658889927244, -2.940625995972152, -4.054165692345172, -4.073725400669404, -3.5202652111392982, -3.9443605194956164, -3.39612438181687, -3.47358298465148, -4.173271910547718, -2.983892473594742, -3.644685084213443};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
