#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {6.444902910391534, 5.524743193787702, -3.1955356110489572, -0.28517377134700533, -1.5795989190313044, -2.71194584778799, -0.07265380123905284, 5.278710526963613, -0.7363289182005722, -2.3961881794647053, -2.054968486606996, -2.697687708928306, -0.3315970894062442, 0.31819327631788946, -1.7916641130901692, -3.236605700700447},
    {4.746948677933718, 5.824792351604006, -5.944691222350624, -1.12864997471069, -3.0743530961775694, -5.3038451496916075, -2.581009609145215, 5.5080605907952345, -4.742638353891585, -6.010517372710569, -4.818402130604505, -5.812082333662475, -3.379401142757448, 0.7844604680993913, -4.8958720068608965, -5.551403687822353},
    {3.7771923835574346, 3.138499282497356, -7.96256439296367, -5.516906993417645, -7.225473623902065, -8.124962690934915, -6.796334253899925, 2.7143612054968096, -7.453506026776152, -7.855809730948921, -7.568854883082303, -7.944275757572922, -6.6369225053433345, -4.105355284432312, -7.681142553540766, -7.852904973555648},
    {3.478908895772014, 3.101666406931796, -7.992927238656136, -6.595663582295251, -7.444839115058678, -7.615847898752209, -6.878394345215564, 2.1275445346995974, -7.000927372794818, -7.523458751661418, -7.570510121346305, -7.679010703084491, -6.628261492721454, -4.391286075945632, -7.450980632170504, -7.96493071872713},
    {0.10606574108862829, -0.5592855274751596, -8.086311295813339, -7.749321058484863, -8.120768148091706, -8.16928455471594, -7.882279659732794, -2.685737204894538, -7.595820039961064, -7.970806246208454, -8.208322659099844, -8.210293574251907, -7.434385154987838, -6.602032971284729, -7.921353179225932, -8.00944126335472},
    {-1.5697030112758446, -1.8409608412267462, -7.8885247849277, -8.084607793865361, -8.006351384401878, -8.06140195442031, -7.735827869492126, -4.053685550147634, -7.653997145731994, -7.9536441679043355, -8.086764777225982, -7.786142010715803, -7.238467855475983, -6.862363609845753, -7.409816206757275, -7.808646513090029},
    {-1.0092194387324933, -1.398693596272002, -7.570549925327325, -7.871118202922967, -7.575294457315188, -7.595147627425293, -7.579443901091486, -3.2803700967987166, -7.607565680935111, -7.774877269045544, -7.731427526683481, -7.446411781365697, -7.067669541964097, -6.609615063839303, -7.211388212122756, -7.467793539211869},
    {0.2432676467446532, -0.7549262401567434, -7.723056107957887, -7.896125828863182, -7.750591762134111, -7.863830745559782, -7.858412906619714, -2.5724474476884422, -7.235875327608148, -7.600635998698569, -7.528664660065266, -7.516799854755204, -7.265538682193468, -6.2605339177450805, -7.2994414078984615, -7.811770284506052},
    {1.0414470650839514, 0.2516129449229998, -7.880001211165172, -7.262119781307587, -7.900177051015778, -7.589321108673592, -7.598425666643092, -1.525893595765925, -6.534624170638188, -7.3704028754389235, -7.626907543434001, -7.373112365272697, -6.939260003329555, -5.781587586030712, -7.10123469055403, -7.456331949097759},
    {2.948844389191165, 2.8665744839664176, -7.80508054289966, -6.898173400082955, -7.582315477172323, -7.633798805401566, -7.183445561652387, 1.0353368255285154, -6.731915554394186, -7.669360224224638, -7.7052191799210075, -7.437613832569145, -7.315852202286735, -4.67540783436016, -7.419198799514676, -7.43363945223039},
    {2.185490204505109, 3.3931544409777343, -7.442369370299051, -5.526729073059111, -7.066247537887131, -7.338301053004608, -5.92691761288395, 1.6999394741399991, -6.488037840770517, -7.23988340575272, -7.232207433009621, -7.369293647461849, -6.264705476058518, -4.120721878856126, -7.20772966240954, -7.099756500027371},
    {1.7703300352744642, 1.5290058744955697, -7.410001978336562, -6.351136922199841, -7.472406579996404, -7.591015139357573, -6.539056980588995, -0.022178207976849086, -6.847690722467146, -7.229459228258945, -7.421318630135174, -7.366784449639078, -7.141588070407543, -5.018276591761684, -7.619785319737832, -7.370088977440702},
    {2.1812214832480343, 1.3037445452578744, -7.839050078607504, -6.527228807363513, -7.583633484424365, -8.125024706639055, -7.4875947527241635, -0.030547010675170936, -7.2236673314099855, -7.694295597023617, -7.436352054846819, -8.199426160202375, -7.778878430499595, -5.6341305860247495, -7.7981529790385835, -7.950627678528383},
    {2.1280382809137777, 0.40397999535384477, -7.934136159575012, -7.123867842795126, -7.796562078241335, -8.145367738517814, -7.46695288193879, -0.6439671356267339, -7.400064916971413, -7.882520630141399, -7.573859025443677, -8.28260424532356, -7.58919747231991, -5.5467826168446575, -8.19925906374931, -8.18354659130447},
    {3.291655722912598, 1.2074689452465512, -7.8218096445018235, -6.800372987083359, -7.573696182013438, -7.920946513938525, -7.375201053124061, 0.10799584808525883, -7.508211296324562, -7.916791874785821, -7.395326042658863, -7.975361659962207, -7.5101073587701475, -5.519934312418737, -7.949966969965063, -8.05989022804189},
    {2.6557197224041005, 1.6055610758578982, -7.851922414472029, -7.188841341088909, -7.782847056007926, -8.156717984774291, -7.670466431877531, -0.17676712431359903, -7.632030205928715, -7.927500785593669, -7.662842956468088, -8.260755175554808, -7.632748583708219, -5.071916081769088, -7.840219788454147, -8.023624889694577},
    {3.3658114804754327, 2.1063403195078636, -8.039744700167434, -6.883532098910468, -7.997973348693748, -8.029148740017854, -7.772794589002519, 0.4640385828097776, -7.491102913148992, -7.613642042420371, -7.468289462058248, -8.287501229711067, -7.31191783026424, -4.960296785584086, -7.716159347738304, -8.118551465142309},
    {5.031917834071442, 2.3140391991550273, -7.88953994695322, -6.482888148828676, -7.812199437703003, -7.945585502192, -7.45867321450691, 1.2811636202851169, -7.168568893747289, -7.670765825405936, -7.57053905967193, -8.255669678737563, -7.22975272556118, -5.0330251072903325, -7.883059486989874, -8.037713159960102},
    {3.7923384827885243, 1.0286552056977585, -7.8666539421085515, -6.996501015953681, -7.947571868601721, -8.063771311345274, -7.32945759358573, 0.026214050517152233, -7.603918838287271, -7.609461950440497, -7.455349806697072, -7.888978660017849, -7.233541506508969, -6.066586242743973, -8.027112499441124, -7.901971264373941},
    {3.6754672249349527, 1.740644457899102, -8.120957872653188, -6.964425231116486, -8.09448077073806, -8.276102563233449, -7.749614926018368, -0.11104619184458465, -7.564383657383338, -7.733488158848484, -7.539753024401885, -8.183447209582226, -7.550119425850049, -5.584782583331892, -8.08930565248125, -8.136893663101448},
    {4.371365497261051, 3.2007748799347198, -8.185747943385387, -6.628693940424377, -7.756007692215309, -8.253920517755796, -7.448646107549959, 1.5148554547525057, -7.180719572278799, -7.683720065287104, -7.376316752528478, -8.080329233907408, -7.198826649975582, -4.667377214538909, -7.968921672209966, -8.188244864385371},
    {6.200579109585172, 4.41077908921392, -7.910779839070929, -6.035569351176221, -7.542032111914532, -7.797013049763624, -6.487582985488551, 3.534541810774331, -7.102332494644854, -7.515278994010029, -7.237074668900839, -8.174923658603525, -6.616363945284244, -3.949437860019289, -8.003886722047028, -7.725867607463746},
    {6.724282990265432, 5.169546098910027, -7.497565498257221, -5.085230204287267, -6.990804622746073, -7.553430010306575, -5.859155080552465, 4.4026961172635195, -6.980912116380827, -7.515501355076059, -7.018530383908268, -7.630888099520667, -6.359908915899127, -3.3441999582900674, -7.315173436524832, -7.808559508166427},
    {5.8363496020063135, 4.6698893972458135, -7.977325002325825, -5.934132801270263, -7.340833015232712, -7.917236571691283, -6.769204722387058, 3.751189155553881, -6.964428184457228, -7.413101471085623, -6.940618999952252, -8.07221969743597, -6.670579617626823, -3.8161333704471705, -7.813244417575181, -7.656072592605186},
    {5.045126875141155, 4.45085981262805, -7.903520655156516, -5.889757858261682, -7.503834689363406, -7.770755416319023, -6.498166705358312, 3.169100021179894, -6.880302362799836, -7.70676885809355, -7.318712090263342, -8.028838829845759, -6.963911173372888, -3.2504966690963593, -7.610731830882247, -7.986705352486946},
    {4.9737970751552005, 4.120184160360276, -7.728977381944133, -5.781733837395035, -7.534025570227534, -7.692040495904418, -6.545915755311366, 2.827646342785159, -6.783898689761766, -7.637454702754509, -7.084449304321818, -7.815484598264349, -6.829161238187464, -3.730843672285254, -7.425048789531644, -7.785404225017506},
    {5.432431372746577, 4.816422243668062, -7.85895682881446, -5.793075131619146, -7.568618598946035, -7.703665825488916, -6.819698884133027, 3.7764135523433313, -7.302711576922517, -7.683984722536936, -7.523314419445822, -7.970287279484221, -6.609203274907835, -3.9041264511772544, -7.911583993453049, -8.045218802121546},
    {5.458166355028142, 4.322143939105372, -8.250318881424954, -6.120702140194398, -7.478067203930813, -8.213098799555992, -6.966411890873375, 3.428906101477512, -7.3619929241392725, -7.684650865498761, -7.3192827577255635, -8.314780686356377, -7.126087287317424, -4.06236949507195, -8.039256441814457, -8.066705813053815},
    {5.248709426439425, 4.1134036898283375, -7.805605714747921, -6.00520475464539, -7.582582150780704, -7.973202638486779, -7.137844813487671, 2.590442540370269, -7.163409490698638, -7.997998469853177, -7.387306357328863, -8.21459818071472, -7.024802260105614, -3.925988772796634, -7.923199087989159, -7.84685915240869},
    {4.999460369939357, 3.6160681916816957, -8.051245949977748, -5.4370465368454655, -7.669543648727515, -7.787481538055054, -6.404745047963993, 2.2603711575720604, -6.950145014076045, -7.943850223305927, -7.2051011450457905, -7.999224973614469, -6.831391388679938, -3.669248429529439, -7.937174679749745, -7.919194651016793},
    {-0.2748185280632814, -0.8670889674896411, -2.578811765500853, -0.3345521366206834, -1.0718254691286617, -2.5310335006674762, -1.0026429558850967, -0.1609084798821246, -2.8103932005688015, -3.3656913532125556, -2.2705417137803052, -1.677223348751611, -2.4805426284694376, -0.6634157974002971, -2.9588470148180424, -2.1899779858744237},
    {1.5411342942811916, 2.0572347425271915, -4.422942590834839, -3.0819849838882694, -3.202511892374201, -4.338411158506909, -2.803959471682748, 1.6725291749697513, -3.318326925237414, -3.5646398858737816, -3.9579405850810687, -4.017142595359461, -2.7804054775620033, -2.6228912846775168, -3.415357039776135, -3.862454797307634},
    {-2.268880963480958, -5.087403506862891, -4.297059560394611, -5.22057876013112, -5.383060406192042, -4.561412214954691, -5.324973398977142, -5.340702819062171, -4.496531215939771, -4.052165037541741, -4.7573771346934235, -4.358986913533695, -4.713324956404661, -5.731656612093285, -4.884031276987722, -4.462634977721527},
    {-1.16763718247083, -3.2050764687036053, -2.6290304248739447, -3.9214196437570537, -3.968887211186625, -2.868043794559463, -3.594197259577081, -3.6000684935609675, -2.230551827695828, -2.7334400819830105, -2.9168905473025855, -3.3002561345105743, -3.1122509656970423, -4.364892440049556, -2.9771988303052366, -3.058535263250251},
    {-1.8850345873108374, -2.5992185639110605, -5.847156948097346, -5.4661538728595405, -5.416077536429546, -5.894925400262563, -5.478988384814029, -2.6733648389164135, -5.257241644022984, -5.492225980874805, -5.949835614160094, -5.524898743369184, -4.8993927892869795, -5.041314240447763, -5.609518304733091, -5.618412641640125},
    {-1.464719867828485, -3.633018378907799, -3.956178006748458, -4.4942363866256, -4.487229935072773, -4.051501418003489, -4.921167992808866, -3.446644504058403, -3.4537004628810304, -3.6627770712451926, -4.088738311780183, -3.590323950047111, -3.5839680987510354, -4.877497905240693, -3.6242908461504153, -3.589163869275588},
    {-1.9447065508530597, -3.0305900772036587, -4.431342191821037, -4.2981689291283125, -4.149645083565749, -4.587422957410108, -4.219479807413064, -3.340648641215371, -4.127447853816822, -4.636604258767351, -4.527326085232782, -4.3880633713767905, -4.4844804252768435, -4.598592785363085, -4.3618716797212995, -4.44813713286241},
    {-0.8183840562108025, -2.4105759089714573, -4.882889636161984, -4.605293566732813, -4.252234121493064, -4.6690162122070475, -4.259473431960161, -2.538984097696077, -4.599360664889865, -4.446164405627263, -4.424225780640633, -4.972233316847202, -4.347340941372605, -4.795478558078267, -4.57852425221335, -4.684980634918369},
    {-2.769989479901286, -4.199146714744741, -5.038891492422473, -6.083808686766032, -5.701643297247242, -5.293780348971008, -5.841036883888957, -4.609321131817509, -4.424935785881002, -4.64473925358776, -4.91157342522904, -4.601015457688335, -4.994565215888998, -6.067780756469952, -4.503887786747384, -4.582460369576077},
    {-1.133619428265898, -3.297252577467308, -5.917048851248293, -6.247708285218136, -6.346607842060998, -5.95887959450091, -6.101792104243691, -3.6284777189552693, -5.481790597231579, -5.990036163716037, -6.059353630710366, -5.610950656073576, -5.7608267948080165, -5.577636323968645, -6.0234957494058365, -5.990919574214898},
    {-2.288587844775451, -3.5640142473720378, -4.465707494092188, -4.437191225772366, -4.620064257464123, -4.518537717348772, -4.380409245851299, -4.003362973684841, -4.184907557958208, -4.164399170669189, -4.606310525921589, -4.527763529107886, -4.0364812068023435, -4.355071506748616, -4.189208610636451, -4.428656941872899},
    {-2.336382633542558, -4.170848682451407, -5.0923423841171305, -5.547199762852065, -5.66022986248147, -5.3408970940477, -5.520235309157777, -4.674820380015352, -4.687830140744947, -4.907777787393964, -5.074068732517309, -4.828443228160946, -5.053992283795948, -5.809917279943371, -4.784744406798041, -4.798222556859515},
    {-1.9318567797612012, -3.6389911048421166, -6.090897802250576, -5.957126755562121, -6.153230367137294, -6.25292025248539, -6.001407036594833, -4.376218813844461, -5.82123992992483, -5.71321259269053, -6.09141831942111, -6.039700417676014, -5.6746787414609035, -5.674206570561149, -5.679338294497333, -6.136626619293775},
    {-2.914223907154429, -5.1186713246456055, -6.267863074269473, -6.460249204596134, -6.584839277008477, -6.578985458728415, -6.454265212586403, -5.380061955896394, -6.093863401496276, -6.279265496471795, -6.259153091209139, -6.470982188866041, -6.118385073791939, -6.540333120581487, -6.417529223884668, -6.238136442065146},
    {-2.3995571738071075, -5.346457920685083, -6.19678054298773, -6.714596612936295, -6.424272713850473, -6.395293581374693, -6.396088697868499, -5.594504953914083, -5.810658567792336, -5.9436412320752, -6.26690037947458, -5.7037286805511975, -6.048833323958962, -6.427810862780264, -5.830182498725224, -5.8388810662449115},
    {-2.8906658186475673, -6.303635335432111, -5.74792741518267, -6.908421166616964, -6.553658213266392, -5.544306979471094, -6.843930846989036, -6.494878085167402, -5.123655762580508, -5.286945732419253, -5.445605151016545, -5.26572337987616, -5.539609645015747, -6.689612606057254, -5.301823878459994, -5.330424425962298},
    {-1.4458690027154801, -4.985337064743498, -4.478822828793183, -5.487445366182688, -5.252566852024165, -4.428420303967321, -5.9209715394976214, -5.20524310522368, -4.231115855214651, -4.01619613666662, -4.219284929493074, -4.5371372459385295, -4.26780152616169, -5.98321469934291, -4.417893782361848, -4.50975145186278},
    {-1.149205317749684, -4.707705874546116, -5.89073521519846, -6.286603243819346, -6.349428508671798, -6.099413423493002, -6.450012641668545, -3.9992536436844976, -5.852102162511582, -5.670144242982508, -5.646090711716834, -6.308960722303871, -5.7761571840980155, -6.260159506973946, -5.9063853113288545, -6.144768280124388},
    {-3.6934082116374913, -6.460627445106331, -5.545150194560831, -6.516086713453246, -6.315213918001853, -5.565819857230042, -6.496861472844693, -6.153886783004925, -5.302357553155171, -5.097841715363542, -5.493017213020336, -5.5693522241440165, -5.724353654843998, -7.044560545084132, -5.492599105222038, -5.533767106485734},
    {-2.471553815519434, -5.299796955128273, -5.514115503884277, -6.382769643221835, -6.304178912513586, -5.4984988429260175, -6.09677597348028, -5.376665610643968, -5.3116591332327925, -5.3666434656011885, -5.643987211702622, -5.610518233040525, -5.540081325553546, -6.07734306274087, -5.271132523296124, -5.231793139182804},
    {-2.0327787284986454, -5.210874015210925, -6.549787582700786, -6.81670750095076, -7.16431977525678, -6.915499087282962, -6.83641269813624, -5.831479661330699, -6.493879623480518, -6.631889739054008, -6.894741344880742, -6.8787933932766245, -6.780568564420897, -6.524660753801469, -6.494628812867156, -6.815844062345145},
    {0.02977431057796542, -3.737780691426872, -6.654616842152879, -6.982730080947003, -6.749338357020867, -6.923773597066857, -6.782978552993693, -4.678999056603558, -6.428725810814949, -6.659422916731028, -7.080783726436853, -6.304653305338713, -6.039600265434086, -6.94346919365985, -6.231514529507063, -6.631415739592467},
    {-0.3604236224922244, -5.277871953934637, -3.9374140124178374, -5.51766706362484, -4.545805360514583, -4.294518562182063, -5.447683310838309, -5.092367998949251, -3.8838763923342055, -4.02699727066453, -4.643977147492123, -3.696771020564994, -3.903330009066773, -6.298078354646676, -3.541876752656595, -4.227928870223706},
    {-1.534456750283409, -5.65625151036853, -5.024914303256174, -6.262704666600822, -5.662550733529295, -5.107532857500407, -6.246141706595089, -5.820657993136385, -5.171467601758827, -4.830413228266232, -5.381230774590705, -5.141747451880906, -5.4449776470521165, -6.530422331130383, -5.282548287055006, -5.287480579552931},
    {-1.5699656412277798, -4.814334334856437, -6.600053566462518, -6.668205501989335, -6.378502565502711, -6.668104618424735, -6.565665830338552, -4.972320114191149, -6.475835122287956, -6.4215257017433665, -6.538618986956205, -6.930772649211124, -6.549613369746362, -6.3561965577812645, -6.75637746904647, -6.629367031712082},
    {-1.9350846429946247, -5.910392414433154, -4.891436691364852, -6.074075719213079, -5.903560221929701, -5.294931625552088, -6.55631128922575, -6.047696309878469, -5.0959236775751435, -5.003131514195859, -5.531128225288453, -5.083573217527345, -5.842934318652039, -6.781560371177274, -5.020652190140991, -5.170110724122695},
    {-0.681107531264067, -4.558627173485356, -6.529758086383879, -6.727258146423273, -6.49690290943758, -6.567936216928446, -6.809814939375121, -4.336817716821326, -6.005524086853327, -6.393677246602103, -6.723192072704996, -6.333127520200519, -6.00398471515253, -6.6106486197966525, -6.3082023014263395, -6.449071167787439},
    {-1.122315477640664, -4.895434870052908, -6.031886828302656, -6.8841614562525875, -6.226704841501895, -5.722326771501742, -6.405363635255421, -5.056753446082753, -6.186730664057634, -6.1747041690163345, -6.2988606246966095, -5.879470364725283, -6.391070814842435, -6.484883770435564, -6.417619459336607, -6.076641090840638},
    {-1.2005414187816508, -5.9444902813251455, -5.7613455000239595, -6.635480522834005, -6.1755844588450275, -5.8795095498500425, -6.773993929796499, -6.297145581655569, -5.855472902215223, -5.817950349437216, -6.028301622086288, -5.4082729315303695, -5.918299408847133, -7.217544973338997, -5.920236976545508, -5.760650753119335},
    {0.03040481471670178, -5.115068296469387, -4.878912632267327, -6.472831581039239, -5.525950408043622, -4.797034284459071, -5.831558533191107, -5.4578042036987275, -4.6377896885320995, -4.848557926049117, -4.835609144503989, -4.639060032812676, -5.1871530846108085, -6.47063489053843, -4.747571767978086, -5.145777146530897},
    {-4.19833467748576, -3.522181317654091, 3.2040270700773474, 1.5541987364925478, 0.8696407946404818, 3.0205136942513535, 0.5483258323687966, -3.4034736359372566, 3.706501645996119, 3.6726397507381345, 3.3253487370585426, 3.620026076867343, 3.913612259839742, -0.8142423313663149, 3.669546067971856, 3.820518585019586},
    {-4.050490945792813, -2.98681338492851, 4.159269892912663, 1.442925808946413, 0.9019594975819032, 3.7913484484239413, 0.40874575858641404, -3.489017303320582, 4.480512385497696, 4.583192470864096, 3.998091712203122, 3.973154803704198, 4.2756175883251455, -1.0431147624542372, 4.522677741330863, 4.2074719683551445},
    {-5.800906957989508, -5.436676551186504, 4.653741142211905, 0.8613274177471044, 1.0008685360965233, 4.669493687803404, 0.1193075188728803, -5.138116256162825, 5.608366233045668, 5.190864141240418, 4.7994847829471405, 5.223934222704234, 5.331006342534773, -2.1228057726064615, 5.005607577301479, 5.28413775389343},
    {-4.825074892930086, -4.003117980257231, 4.772343797997297, 1.867217742662215, 1.7059286387042683, 5.011074153628678, 0.9593420477966493, -3.7970659689913546, 5.285717403081106, 5.207890900782595, 4.961527432128585, 5.395180659640462, 5.492469429966624, -0.49592060554582534, 5.247011750045052, 5.442438178185238},
    {-4.499315668774814, -3.3249810607168193, 4.653115161760243, 1.8976341520848048, 1.6308828425812134, 4.721064128295479, 1.255035383992155, -3.8267157572696964, 5.104726307167943, 5.1467374331796485, 4.6955051234741125, 4.899890310166406, 5.076935151719567, -0.5322584498888532, 4.755119683503063, 4.925667080748393},
    {-5.495980659162731, -4.348138861083345, 4.27598278572342, 1.2252243098898188, 0.9771768494555374, 4.465528611934119, 0.3600109480605161, -4.8850823887798125, 4.624552066532826, 4.981156721330345, 4.370617041263, 4.33180483713101, 5.282841944234725, -1.3368222917826105, 4.537902083899578, 4.771434711063192},
    {-6.140886801569585, -4.856754480442135, 3.9046839050887616, -0.029283465942658397, -0.16150891381078308, 4.113496618263065, -1.1081389144575973, -5.089057710960011, 5.044194162299904, 4.647677267014762, 4.520156545812946, 4.458245049872994, 4.980061469002607, -2.410390861033554, 4.341732476756662, 4.875317954425376},
    {-5.515863852428754, -4.253358598095982, 4.442230336745418, 0.8774510050951092, 0.7436884080921979, 4.373395096597125, 0.022250804655266864, -4.263157987229942, 5.46574496180133, 5.152846731302686, 4.893437235519554, 5.0378287674459665, 5.4765312457975215, -1.541435037206881, 4.8906643296681125, 5.101979981249798},
    {-5.746586787135578, -4.0463194991951195, 4.9653981378696095, 1.115616184405913, 1.1162018920973078, 5.077151495373877, 0.413297930115206, -4.39541143051882, 5.35923351213955, 5.529358332343493, 5.174656678330992, 5.17702112900469, 5.630705100173533, -0.9487568471137854, 5.439121139064159, 5.54163597645796},
    {-5.20191545890253, -3.9765825813383513, 4.091648050723553, 0.3678458507897458, 0.4270658704075768, 4.293488151766038, -0.5635796549956887, -4.0734280682351285, 4.967893347914035, 4.84887012451073, 4.5877788604057494, 4.872145290794483, 5.24615332917012, -1.8848177012195964, 4.691865008662239, 4.953487921009024},
    {-5.358308868538764, -4.392629582068384, 3.663853408845827, -0.19116164914301118, 0.09233169412015127, 3.5604583642557874, -0.6724280984162166, -4.4085261847707455, 4.485732099843724, 4.417983355598894, 3.9371456704039662, 4.15945610251441, 4.4619512760037745, -2.4492661912678524, 4.137962799805305, 4.558850851834399},
    {-5.570031698464991, -4.488757446114659, 4.386792500275558, 0.05156546453703202, 0.17800917080706127, 4.367232866178394, -0.6372617315185519, -4.62306305204053, 5.258392667102476, 4.844973217183398, 4.49985587754541, 5.080399092696739, 5.282954393045874, -2.61575110759288, 4.768236068405406, 5.0545824177458565},
    {-5.20139758274292, -4.034886343297214, 4.093557019391808, -0.2678703818989895, -0.2734966646758416, 4.113012406196564, -1.1414518889042706, -3.9106291135273263, 5.186965268410091, 4.888914508668432, 4.527566138808359, 4.784007330427745, 4.922211041225773, -2.5862401245381763, 4.6438111999488605, 4.874570187332192},
    {-5.064924396564676, -4.175203172574203, 4.226832562466029, 0.01869591880709737, 0.06687839550816524, 4.283662029076671, -0.7288414635543419, -3.8264302203299825, 5.1441404755375535, 4.958495657827237, 4.400532454757522, 4.782177534558613, 4.698077528680709, -2.20056033530908, 4.613613398676621, 4.845295370318385},
    {-5.578111221141093, -4.662263815195296, 4.32406767886859, 0.04110606324744322, 0.15231095410973625, 4.475525905949111, -0.9446966064033053, -4.75755342806244, 5.133723768584743, 5.229012423592687, 4.737842897023717, 4.8516261366274716, 5.274837229095769, -2.187809252529489, 5.0061509159789335, 5.284656621811468},
    {-5.405660508620858, -4.972570899454416, 3.9292501882631656, -0.3928542094841765, -0.5578310311878261, 4.237456248407015, -1.4485362658884327, -5.044315954733963, 5.0558444725311, 4.838860032233311, 4.314025223677662, 4.7414573172623635, 5.184382765845375, -2.670257637049036, 4.655624003547396, 4.812594056138292},
    {-5.177368412784654, -4.096498018510396, 4.422908666111877, 0.8823637443580854, 0.31158403104451676, 4.369047592394138, -0.5117803668438372, -4.50602334713468, 5.367605207540234, 5.291950772508361, 5.00101978457336, 5.161708555538668, 5.538769242730876, -1.6591022078243896, 4.864001070755969, 4.98759715257718},
    {-5.780009510696366, -5.000544061767941, 3.6733898390531556, -0.025986957939877476, 0.2541207791855462, 3.7657098843413555, -1.1430180266550782, -5.329156934403141, 5.10074074958663, 4.823158614634084, 4.7821630602901966, 4.795132667721946, 5.257013254293279, -2.9838521979822903, 4.488114666256894, 4.814206952409964},
    {-6.084387590455564, -5.3618741864006845, 4.023477981511083, -0.6262541574430348, -0.29868754415793775, 3.942218877149525, -1.6393867877154937, -5.426687011349755, 5.351178408343601, 5.063100311756622, 4.508717747610584, 4.86983101169077, 5.316698867847921, -3.158834650834367, 4.765540000308111, 5.2117482797086705},
    {-6.201134398804915, -5.287587426765026, 4.2892323961640715, 0.32388290710028095, 0.20633631838904157, 4.340827169576001, -0.761434551796165, -5.713596501849791, 5.668261267989672, 5.4312853846082065, 4.82218064432314, 5.215128436547605, 5.535713764042432, -2.934160639652751, 4.863946292503293, 5.408579063184011},
    {-5.981932707308295, -5.112410377623838, 3.909839769879563, -0.37717054760757546, -0.3437256319896364, 3.8577764802550076, -1.2462393437350314, -4.986381284431973, 5.134467945304489, 4.804025402620375, 4.544072755276736, 4.419658216440332, 5.025637211016683, -2.8271976164275427, 4.6169088887973375, 4.739644790380651},
    {-5.27376624525931, -4.64686944455532, 3.834193471908297, -0.2853646690857198, -0.5643484830173316, 3.6412811133638683, -1.3550696361439503, -4.8664313698331325, 5.280548679663855, 5.063751703759863, 4.418209464118458, 4.549111061929691, 5.077366593973727, -2.5735168866188416, 4.789167866020514, 5.198917075596593},
    {-6.026694236976075, -5.39735857481201, 4.306478105886966, -0.4443948758811346, 0.027089590537091344, 4.138025779221007, -1.1239841821099805, -5.360829475111549, 5.36839789025978, 5.3177108829750335, 4.775509403464282, 5.109225713010024, 5.247850985388019, -3.4628684679304107, 5.1452559047522675, 5.352154423712244},
    {-5.930527405840405, -5.390926793333664, 4.331498115940351, -0.7643834983761237, -0.5337482118356919, 4.198805396984962, -1.7572624871568108, -5.6004245725018045, 5.449547239738756, 5.111281939243154, 5.095326198004635, 5.298706694530639, 5.5755261018771565, -3.8953726738741072, 5.063561608102457, 5.271102346630224},
    {-5.9047553937915955, -5.427530825227439, 4.291248902000651, -0.5816911039495863, -0.4368598096998804, 4.129844750703136, -1.6948824147730375, -5.460222714543437, 5.554004477489738, 5.262723604099015, 5.107523168432026, 5.05070554223296, 5.707657411781077, -3.6370842227833213, 5.254991738368611, 5.546759395703324},
    {-6.517100434970488, -6.157207070518773, 4.163369681672673, -1.2826368165354305, -0.8115139993335605, 4.126291706981778, -2.3308271784017154, -6.080295116317888, 5.252744968485909, 5.212495444220518, 4.744244357775029, 5.019759028064833, 5.35320975842304, -4.583265665942247, 5.134948524670761, 5.343105009288422},
    {-6.151008785994342, -5.692475132255424, 4.325596692595547, -0.8443221867441717, -0.6932923818586874, 4.252500663025348, -1.9763071726499508, -5.854889743484506, 5.336405036285345, 5.368553131513323, 4.875430108018394, 5.171997605826436, 5.223605384617816, -4.126312592917289, 5.066700577712999, 5.418630797928511},
    {-5.857336201963798, -5.82992356382798, 3.9438221146245267, -1.2604747048676719, -1.2509413497837782, 3.981973021763658, -2.1727562202917845, -5.884761120115487, 5.339433823294595, 4.834459189924011, 4.411398109492362, 5.035407390048257, 5.484888533356642, -4.288990768636554, 5.007667489633067, 5.115658614224726},
    {-6.380354677750111, -6.170409001094161, 3.563294347576245, -2.129331264048434, -2.023331373680659, 3.4285289693487218, -3.103393930660792, -6.184939531129272, 5.390753624148785, 4.6899789801293315, 4.296665234669121, 4.303306155422688, 5.102119244215285, -4.971585633283111, 4.572704178849377, 4.800339730091174},
    {-6.331734747390016, -5.91008727490099, 3.8334416051855404, -1.2745251690101684, -0.9848818361092713, 3.6787762667941952, -2.045742544031081, -5.929916017050141, 5.572230705293579, 5.0458540240655045, 4.5596714353788395, 4.923938991677181, 5.220273086921521, -4.295484598228514, 4.623797115258494, 5.023807648034025},
    {0.20966481142323778, -1.166239052898025, 1.284799391302624, 0.6081791002673994, 0.7432046254518785, 2.3296835352555765, 1.038290920865388, -0.3657797583836931, 0.6683905071655429, 1.2506692680186238, 1.3593438327337213, 2.1582925819276877, 0.4919082317090327, 0.35039403525745905, 0.9512502514041357, 1.547812670562462},
    {-0.743767549860813, -1.537143065472037, -0.8735872599447108, -2.055855596492364, -1.686914711202159, -1.9057643600564693, -2.5525430491035053, -1.9241616424781083, -1.9865090125526457, -1.2865116689228424, -2.616165090164634, -2.0545072173167016, -2.0391020143850573, -3.3331404544098326, -1.9276967907983302, -1.2644074765797684},
    {-0.33081299129584185, -2.9408115819069924, -2.1378886287904493, -2.618897401873541, -2.962689956726157, -2.021027598499335, -2.9971753466299593, -3.2274492558615298, -1.6849721277768264, -2.312995483741063, -2.310633734318351, -1.8389935118933143, -2.4903724816004775, -2.4227546279668246, -2.4163058077690427, -1.975985817900822},
    {-0.4727205101009047, -2.3836554109774104, -1.5922777351968742, -2.754674602201072, -2.4095891425251894, -1.1893263952607855, -2.35711921850162, -2.0671841892892155, -0.8945631552204905, -1.2684878314019874, -1.6425708387245481, -1.1220540662725045, -2.074946133171882, -2.4836028033298763, -1.7686060696515313, -1.3949129836450995},
    {-0.9829578394608504, -2.1124997255643168, -3.869455877331938, -4.852747094501827, -4.533217817818858, -4.234090651445224, -4.823648603063812, -2.6483845619648942, -3.4671429646894376, -3.9734595798009735, -3.8469592681122506, -3.8791787675880154, -3.5788676428348456, -4.222270702573455, -3.5281252242952386, -3.755209567621637},
    {-0.30557405361379214, -1.9316731722668734, -3.365620298798633, -3.7824054871895134, -3.781041322533705, -3.5488967873711825, -3.6043029816762644, -1.7130207305967227, -3.0798102135867884, -3.2482439327740877, -3.3144207622729556, -3.211307795399268, -3.5061054476549756, -3.2249822855902694, -3.2639087620172655, -3.23921593730371},
    {-1.0312762336500998, -1.8813526984527038, -2.8530271996548144, -2.8112654213284856, -2.2499057392518638, -2.731515584989782, -2.425624819595699, -2.27430874859864, -2.75268596008045, -3.170905483766658, -3.246651707712281, -2.814782513817377, -2.7307754445653023, -2.67165564952126, -3.112582473716855, -2.896352124632802},
    {-0.16270449657649783, -1.6105483591966792, -2.7797335025952075, -2.5595557565271263, -2.3361128613790236, -2.6848057068912095, -2.6878222279975525, -1.756500911456005, -2.470129758907465, -2.8181543110411136, -2.5834036034302925, -2.636785755505102, -2.6580166196612978, -2.964351943500038, -2.7723311768469054, -2.510901652667057},
    {-2.4691743707366474, -3.7321637777979566, -3.4051280525246734, -4.149186746669765, -4.055886838447555, -3.4863209645511324, -4.437684941947689, -3.836516712580873, -2.670850974824256, -2.89341694482402, -3.471047981885916, -2.904382680526786, -3.1815386078719508, -4.673095848614576, -2.978563672195945, -2.9139864534162525},
    {-1.0169616722890766, -2.9270709537995394, -5.152968679964216, -5.5973819217757, -5.318696807462628, -5.1181134934045005, -5.497411154750244, -3.3382353248914614, -4.199173031770175, -5.204982150035101, -4.827925323114687, -4.5853109294496175, -4.4197608956675225, -5.267517243963885, -4.813966176645696, -4.743034517152073},
    {-1.5272052128253029, -2.5899676714476674, -1.9860861620386547, -2.6824456844412956, -2.8040337643203452, -1.87772752744476, -2.875346901156612, -2.6513069614931917, -2.365150098104459, -2.4173473899123454, -2.478574400697716, -1.9899101922437354, -2.3197301732526876, -3.123013158264297, -2.2423695152411485, -2.244914762467792},
    {-2.2294939297812797, -3.628764648462005, -3.908176325776546, -4.396746785994701, -4.331061399093208, -3.802205672495963, -4.420891042593024, -3.888492109568349, -3.6233626853698895, -3.725917089297235, -4.016583708661501, -3.6840301328733163, -3.594329779074703, -4.604896409038973, -3.71872301777328, -3.691819507491911},
    {-0.9748059463257738, -2.322477895159614, -3.756208566041143, -4.031998238148634, -3.9030328959286176, -3.541020289489741, -3.8321287025069966, -2.4478181236037173, -3.456979656170196, -3.715356033421827, -3.454187666649701, -3.3449820968519446, -3.5720571825626966, -3.9845982895376646, -3.5059003126096444, -3.3712795456587705},
    {-2.210931502860144, -4.399612204195317, -4.47167979936979, -5.213608261109706, -5.038767750896254, -4.633548982889803, -4.909725700296191, -4.692724995202343, -4.351393163965982, -4.314768646577471, -4.738550493748459, -4.166363775003194, -4.551609279665171, -5.105312147027566, -4.314913356235266, -4.554262741026206},
    {-2.1106484147471143, -4.714002796250052, -4.528536552278087, -5.312892478005629, -4.910300052945626, -4.6098953306570305, -5.106858230813277, -5.092130693520923, -4.2691029409850545, -4.474317141870606, -4.75460769099051, -4.083309318926906, -4.743880467070934, -5.549422024633027, -4.311925321110917, -4.401120029304332},
    {-2.3789631735097627, -5.04791179897613, -2.0144232988785387, -4.6951099259992715, -3.9552792323699038, -2.0808040378778525, -4.492069300102597, -5.113023489349117, -1.8180180293776615, -2.0771188091233945, -2.4364840840994, -1.5298422921331396, -2.2151402272140115, -4.660109338489421, -2.0997855162872665, -1.9504342956082883},
    {-0.8507382995353417, -4.353017313554141, -0.12694033461934867, -3.3831790601336214, -2.4389506097663443, -0.1430229960378548, -3.1086309082163326, -4.568763195170929, -0.37903757089835693, -0.42712748124338, -0.5395362238718562, -0.3247188802130583, -0.8696990567848882, -4.18191180372012, -0.19506205927722006, -0.4853144605091796},
    {-2.3422227947655054, -5.733859174123772, -2.798404150877361, -5.600841276937682, -4.926897108909857, -2.854128339631642, -5.642537142923701, -5.68618569422836, -2.765538057907768, -3.2817773453648726, -3.441874471629299, -2.7281594236283806, -3.6520859209183003, -6.066587234186982, -2.926384306142278, -3.0641828186563456},
    {-2.783200399260485, -5.56217243170468, -2.9209250302818077, -5.016619150077747, -4.2550691831648395, -3.1441465168172655, -5.196420859359406, -5.686075232925345, -3.023846470190736, -2.7818031091832522, -3.3458774730513037, -2.268631969045386, -3.7471443596863394, -5.824663372144434, -2.68920985458228, -2.505729822700946},
    {-2.2474376605539734, -4.626542281898418, -2.3526207826235632, -4.405327343903965, -3.4521138256899717, -2.28112251966294, -4.038187128861903, -4.691878675535154, -2.144936648995535, -2.1029106495562044, -2.7721265099375576, -1.6238861310195134, -2.9012577040233323, -4.473763921210236, -2.079885723764481, -2.073094750396435},
    {-1.9976128773063182, -5.057538103965045, -3.0227506870222385, -5.261193005773007, -4.836819072956492, -2.7333441734753934, -5.349550461034259, -5.395313585009239, -3.051150624809801, -3.1385594486532957, -3.0807064829949558, -2.668640255728526, -3.573985175448867, -5.82539911153427, -2.887125681334328, -3.0373186007465924},
    {-1.544873022673609, -5.965262507752135, -2.0543149540116983, -5.597502942074476, -4.259236935950921, -1.8608558006472042, -5.032628127754355, -5.97821764299704, -2.330664628639397, -2.406286075290143, -2.7682592743319816, -1.2874780779068629, -3.018033884096292, -6.222580617407893, -1.8954811475296327, -2.1033288571650552},
    {-1.0622676681317895, -5.717956162345566, 1.1593985231579382, -3.344615420557234, -1.5776169057230285, 1.274485253707724, -3.1699913290451334, -5.657223535875848, 0.5315845716313428, 0.7682185846377273, 0.5714626426147771, 1.7273475481036364, -0.15950020769851736, -4.920739148829603, 0.9770173479285262, 1.0169279529095299},
    {-2.2703854863185677, -6.105819007186083, -1.4461484068725594, -5.107231343658456, -3.729492511598229, -1.2257173453256032, -4.894781899747562, -6.068262684707931, -1.9687398174945092, -1.889829744948257, -2.4021284802591003, -0.8002614168182586, -2.960021471000467, -6.139721031172673, -1.4829883249474338, -1.325893799336597},
    {-2.5103173630359774, -6.023375819588166, -3.67858626941772, -5.904469188697259, -5.171679312393168, -3.478774913996091, -5.70301682159548, -6.152404007163506, -3.754229002139751, -3.4606234922774113, -3.9417250338449246, -3.3583242894298624, -4.061090392704637, -6.209718239700532, -3.582427876245594, -3.685492970925621},
    {-2.096046389389957, -5.9579314568393, -0.7733397142290143, -4.239209241614541, -3.6058761785530073, -0.9154199578650751, -4.430575078275811, -6.180886467390712, -0.9270023203179196, -1.2756712696045525, -2.0787402224816547, -0.09234179702512488, -2.3710808704990027, -6.2534207311084655, -1.0075467853206108, -0.8005587416309834},
    {-1.5232021058172205, -5.775153702589533, -3.122369942085142, -5.674104543757176, -4.720131249967746, -3.0052975515152687, -5.241865186537227, -5.756152969709092, -3.6284420931580477, -3.8780323351583736, -3.9112458142712905, -2.7629803192541744, -4.0546695296554605, -6.273526091224911, -3.7219844191327547, -3.3548428520123506},
    {-2.444032497070502, -6.617316847216994, -3.2194702709902314, -5.89523339404674, -5.19767768027554, -3.0105200646498225, -5.625001910741178, -6.553768060935415, -3.6582641734322032, -3.792094863835181, -4.092109491479933, -2.5410500187070157, -4.4086141700332115, -6.850277348708817, -3.3345249835575252, -3.103487707830319},
    {-2.446547894911603, -6.736600551135161, -1.4380746671954112, -5.297408207316875, -3.9441188604344637, -1.7858931686292996, -5.186933600762422, -6.811975495905042, -2.4810123835306452, -2.1549433980794492, -2.663127042152698, -1.0917103099026353, -3.280235458729923, -6.35755671996284, -1.9688995459188603, -1.7214084777011947},
    {-1.1415349026414368, -6.511420679137609, -0.3829894754231817, -4.232564120504572, -2.767092382119342, 0.4607687618474794, -3.6813993053538554, -6.414983019431545, -0.9340504015128654, -0.8726446571748355, -0.9617032761379477, 0.6256923376985146, -1.9231109114575167, -5.407305879508533, -0.34786854961439834, -0.10774554155421974}
};

static const float b1[16] = {8.895559789184144, 8.962231968041419, 8.535677667755571, 9.000308194071199, 8.739353129588997, 8.61302294478607, 8.699314392547848, 9.080382991607426, 8.622247310848122, 8.423347429953614, 8.65181354875342, 8.58339937167395, 8.649930850581532, 9.111993069620363, 8.539752124089523, 8.502074584115368};

static const float w2[16][12] = {
    {-5.981976664959575, -5.339854608740403, -5.708820598776371, -5.972305955757596, -6.055119925794317, -5.659314495014297, -5.563371703027339, -5.764879318752426, -5.060436984643772, -5.715310583175506, -5.475068500773419, -5.835812535256886},
    {-5.415841445626518, -5.527340203852112, -5.9811216306560455, -5.304450278155441, -5.565993402687627, -5.643289453556113, -5.7482665552752055, -5.067633306618761, -5.657184608701512, -5.547096463581695, -5.820988866886912, -5.433679944002772},
    {-5.552035359287533, -4.979520419522502, -5.106385047838078, -4.977172617872668, -5.708948403688973, -5.507750779441943, -6.0287045815804765, -6.009299614137864, -5.24413059784526, -5.20847424507429, -5.086905980695095, -5.283005183641284},
    {-5.965193952372799, -5.206430322013649, -5.2512553886602635, -5.427699151032483, -5.592781378043125, -5.796705455166052, -5.136774983678328, -5.54001827964755, -5.747133194315955, -5.231385809918224, -5.5620150647314635, -5.621994266526976},
    {-5.673115034696145, -5.434619849418487, -5.43017599976523, -5.1092942815416125, -5.1474468405313685, -5.685389915492348, -5.432013732115019, -5.088378425141502, -5.709228068561187, -5.560145526698317, -5.918635810419074, -5.1666965860538205},
    {-5.3018491938435055, -5.129135015569329, -5.624424563571366, -5.76102793068108, -5.12470498311221, -4.7689515196393035, -5.370541793868994, -4.947007549298328, -5.698831144252578, -5.76591221703682, -5.228595234984235, -5.67747254416296},
    {-4.734943732398858, -5.891184048291231, -5.834863095652504, -5.871633550170404, -5.540082444402303, -5.213209129811711, -6.1884669999079716, -6.021700351092736, -5.253153730384614, -5.695351091058625, -5.160245849933955, -5.806540147162731},
    {-5.318176419525877, -5.775740982813766, -4.812211246442293, -5.472697240781287, -5.027030322699497, -5.255437587935529, -5.250916736015011, -5.802672975000164, -6.1082425166125445, -5.300868735735011, -5.290544141796706, -5.3088931940151625},
    {-5.5308610488212775, -4.8872755551087055, -5.674196841237058, -5.301949725726391, -5.227913278217934, -5.500064486981563, -5.029263053169256, -5.205122857353697, -5.632906730935718, -5.030550101757113, -5.983602866846335, -5.76760865707927},
    {-4.622366488255026, -5.7574312408204955, -4.713582044403626, -5.6239674521014145, -5.121510430144947, -5.742713328961406, -5.089518113570211, -5.145149869644904, -5.63099624032023, -5.2116564681105775, -5.739734201929705, -5.093133043915661},
    {-5.669348192469814, -5.704800537681537, -5.1106847638161, -5.763156145166545, -5.847607635851769, -5.238421133460604, -4.538693774085531, -5.2650207245817215, -5.7132508553783925, -5.258989248612576, -5.1883988592178145, -5.7885201162137765},
    {-5.4180685649680544, -5.6678515724827365, -5.792659420991549, -5.704917153710607, -5.7417736676623345, -5.578112515011492, -5.707525244997499, -5.3333323800208445, -5.0216218415423315, -5.45927770788327, -5.02216006747455, -5.158792049534389},
    {-5.480687553243219, -6.091957308614003, -5.338111031018359, -5.546889755124652, -5.6640325801263565, -5.562954197345222, -5.558067549191771, -5.714303091295448, -5.230228552287328, -5.475313038394697, -5.425246204829427, -4.941704918746433},
    {-5.634542342505131, -5.566993435516156, -5.624332990707803, -5.400658281809047, -5.694093081843268, -5.581453844929947, -5.363101143566772, -5.309662676010515, -5.3661999308821136, -5.520510691575179, -5.6201789017628005, -5.457913527952376},
    {-5.682794691284699, -5.12790499559457, -5.803013331451671, -5.156214149233708, -5.074011083754842, -4.971796102594092, -5.952989916786961, -5.305491834212119, -5.123194476681087, -5.526652141786574, -5.927482787892844, -5.126536191295268},
    {-5.273996357291055, -5.1154461735195, -5.311924866398338, -4.828162470328053, -5.117688047136294, -5.430019704504975, -5.303139466331695, -5.602716168823795, -5.15313693076771, -5.575840530310487, -4.749518813792048, -5.671213397940791}
};

static const float b2[12] = {-5.738613959278162, -5.438888250034023, -5.085105109847226, -5.148670297872693, -5.696490658392847, -4.927653866094123, -5.3755679409005515, -5.194086106674959, -4.169598698142065, -5.898396429186978, -5.033951111624277, -4.897870808067415};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
