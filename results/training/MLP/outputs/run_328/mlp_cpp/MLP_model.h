#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {1.7691387782284784, -2.2933704495168765, 1.636062375768003, 1.968010513829794, 1.3119922024740558, -0.8106374701947462, -2.0651930466199926, -1.1859653035159377, 3.568309384549618, 0.5134711389024285, -0.7903952354833059, 0.2407329408726163, 2.0973926527745714, 0.7503941449029872, -0.9013674100939434, 1.2488655224670577, 1.1922640157918358, -0.11801007908175025, 1.5542570752538085, 1.0509424630365383, 1.2283867674422824, -1.768371284307467, -1.8769278147593935, -2.020913806961609, 0.7086248483283453, -1.5989633626540283, 1.0998916683524216, -1.107014078141756, 0.8834474149765176, 1.3366282063465933, -2.3398693065458875, -0.1319783702659802},
    {3.635646316859384, -3.7729752847903524, 3.6712234022615178, 2.708897448393469, 3.5315175610001406, -2.278479311106568, -3.505463652731632, -0.15173926138284496, 3.2329128399806484, 2.100429823943377, -1.1484630739391866, 1.9203038904345064, 3.3390266876857093, 2.0998497669411393, 0.8370270069431722, 2.6844149303398885, 2.818343660922678, 0.9179253379135727, 3.7465623894008604, 2.661364692217272, 2.722434186933586, -0.5842324604745135, -4.4633088843352775, -3.7524809674426054, 2.521489127781947, -3.0908113668712285, 3.131433221081112, -0.7336434936489186, 2.3172032079412817, 3.0814364304283983, -4.49148312248827, 1.2264055353877934},
    {4.110279095715037, -4.564668661814015, 3.8065593423665667, 2.8012343136610176, 3.533481707715983, -3.9077601922371845, -4.358758724415411, -2.179213448024604, 3.9575708489934356, 1.6362877125950495, -2.9119276020625415, 1.4313725742820913, 4.174590712377272, 2.1012679398939897, -0.9397183706724862, 2.2130766047522097, 2.3474316955218963, -1.0159300051015008, 4.211336895940284, 2.377919842899755, 2.653021029929521, -2.9546142934530195, -4.438649043104672, -4.827955535064842, 2.960194205342387, -4.19331812955974, 3.062956309250318, -2.46499665903237, 1.555485983222671, 3.043146080877787, -4.825115795388836, 0.41496822496631675},
    {3.252060111094566, -5.589797300777395, 3.23473963596598, 2.5066448560342542, 3.0703801849942103, -4.580400331354529, -5.231990501138916, -2.3491731428129774, 4.041701372216504, 1.1688543467830992, -3.8924148261704645, 0.784534670104733, 3.871434436371758, 1.6952981744502267, -1.682291099524634, 1.953743086645554, 1.9952115657362715, -0.8728791326901729, 3.2429019140489457, 2.0863126824016116, 1.8985192144280016, -3.2865103863067833, -5.391711520169408, -5.124323445797797, 1.980307481988799, -4.826444909469297, 2.2654569221362504, -2.657842241883235, 1.0643995623911557, 2.666194370061478, -5.685959763591496, -0.04356273941093112},
    {2.1493304393751442, -5.607046734712975, 2.177534960701761, 1.589689467274394, 2.148116317321603, -5.147027477549493, -5.418675757398286, -3.238838384708858, 3.688734306043389, 0.17645766344796363, -4.956708893227474, -0.2824370160105175, 2.563030074396741, 0.4437286993486007, -2.3839373659152856, 0.7719837887247228, 1.1644309169602327, -1.3323786669812046, 2.5782638385606247, 0.7976682132956163, 0.9763154591025449, -3.7377111788550046, -4.929938893173733, -5.570825825906886, 0.9834958919974319, -5.253266549974803, 1.6164773933218852, -3.07186860490623, 0.03607798230029827, 1.5272565725086198, -5.412233469500787, -0.6225270483601975},
    {1.2095955837355383, -5.2956854055680935, 0.9281587404611215, 0.5174275661241519, 0.9787195873514462, -5.037822966125265, -5.221890443220619, -3.3624871521985273, 3.087584460556324, -0.7355519635210995, -5.050121559858698, -1.1903601480716872, 0.897684511629637, -0.4905907654847791, -2.582453792211231, -0.23116661889330428, 0.23681684768803865, -2.0110075437423225, 1.5965521307989603, -0.47447885189166916, -0.1225147299947083, -4.186361403568663, -5.273444349985322, -5.476609183122056, 0.3698160079666661, -5.260059861764146, 0.7255004963385339, -3.038933224602683, -0.8577566729754228, 0.48988490454306816, -5.449182879586009, -1.374054037380158},
    {0.2968556220830086, -5.406708015274311, 0.6427847622622214, 0.303919416438122, 0.3940027276094834, -4.692490392444567, -4.90007914399418, -3.2370138802097945, 2.9896634336034555, -0.7046949043778902, -4.611922342154104, -1.2512752191388272, 0.49159994156963044, -0.6111264860113101, -2.262387384034008, -0.10866499195725199, -0.09158464044278919, -1.6230731812869732, 1.0676371589811338, -0.6879692540770564, -0.6622877229136825, -3.507855524516285, -5.375787124206624, -5.242271673687084, -0.06431137031037028, -5.094526639785002, 0.20916100538161772, -2.9959823906253487, -1.2863371471673195, 0.071105247044148, -4.962935271510578, -1.2750512375021679},
    {1.001014345420774, -5.428700890482706, 1.1138456449560308, 0.6132109702984998, 0.7494462147859449, -4.962175087586495, -5.322157073137698, -2.9006359382307694, 3.6462070430705027, -0.4548504524382248, -4.634536917760496, -0.7656992362406694, 1.1056673549154392, -0.2163685549059913, -2.007476154378014, 0.21766417877382552, 0.3171606032582157, -1.4637358923684611, 1.115683771178167, -0.10728157251083259, 0.25356627658182385, -3.615977365644499, -5.582158590018266, -5.552407527366238, -0.35815649289403456, -5.267776389227215, 0.6705395595246624, -2.660010781370665, -0.8870044993065066, 0.5458556815854485, -5.326044897846807, -0.9048801224605536},
    {2.0708870873282863, -5.56248407027823, 2.0323871005081102, 1.1884581695905445, 1.8210280770450256, -4.55895277733055, -5.5977769427739785, -2.5705958311455226, 3.7299826383130847, 0.13310400750860174, -4.651964927286527, -0.2042598199218245, 2.077114275196696, 0.418837206076715, -1.219793235541103, 0.6810996345607905, 1.2144888647913055, -0.6335286818057241, 2.0696898508676043, 0.6535139886546393, 0.9503824279682062, -3.403489435898632, -5.625886355093414, -5.47474548332269, 0.9318981698553399, -5.222002242154937, 1.0643531221032279, -2.402070102196318, -0.06915811434862569, 1.5393123807799298, -5.5124201474518175, -0.6771040350083527},
    {2.7768762246198437, -5.615660814410491, 2.9770546893722583, 1.5604570479477804, 2.7924010871744924, -4.303158615423567, -5.243153616191187, -2.4636132276834637, 3.937395904801298, 0.5237077256009709, -4.111493879813997, 0.3046684211619192, 2.608606858561759, 0.6926398355391254, -0.7795718044859721, 1.1419490977875562, 1.6750718379513034, -0.6467940795093841, 2.8223678144956525, 1.0874885440485127, 1.4094028749399643, -3.0604763574834513, -5.481245895884158, -5.220069912662134, 1.776541387268573, -5.335278533861918, 1.778718816886506, -2.0269415423870907, 0.45743182711922586, 2.1803345103946175, -5.853873772214047, -0.3101233284609834},
    {2.711560239895384, -5.2907220833833595, 2.6313508112242245, 0.8763552566484725, 2.4887130223548226, -4.370227982016284, -5.0852477569992, -2.3910575166623556, 3.189909103802874, -0.07148220282334716, -4.270777241626272, 0.21673178165092333, 2.343282022439379, 0.21602815120624141, -0.7043959971246565, 0.5867396915535126, 1.8631565157160905, -0.5442723052215348, 2.8946505151452215, 0.39723541681002744, 0.8968112486183131, -3.0012604450934184, -5.728451996733017, -5.025999000608544, 1.2950885333016224, -5.276696522168212, 1.963881193308102, -2.1011921996138265, 0.0029436367588151244, 1.7661227808149658, -5.670207183132036, -0.5116118917430686},
    {2.215160469352481, -5.322332718651014, 1.947572168747042, 1.131983535418785, 2.0674108895757946, -4.605197536651508, -5.168529976012577, -2.293284074129133, 3.1798289807183373, 0.3193556631243577, -4.154641094916395, 0.18790415526719154, 2.345983760806173, 0.5437990724253856, -1.0619334009311052, 0.7909718744085523, 1.0973695337275526, -0.8015950858729562, 2.426174932667097, 0.4530855061340839, 1.2591150258956796, -2.687820388464596, -5.774601998358626, -5.161769113700069, 1.060532894965233, -5.112802526338777, 1.3283225726114378, -2.0788643635839077, 0.3427819561560585, 1.5075394157664617, -5.585247166549864, -0.5386097339971152},
    {2.3627207837745834, -5.271304448072884, 2.589942334331734, 1.5576220492959745, 2.4637294357231196, -4.654878555836923, -5.251541414277969, -1.9439377254938082, 3.0100019407844587, 0.9392937378640188, -3.9886166532016882, 0.4219023453601618, 2.742549849792034, 1.1317293288719437, -1.0350636039540786, 1.2750108384539118, 1.289228375236317, -0.7723186885062641, 2.3604354535892584, 1.3128174589520079, 1.8132856319169532, -2.1932189878455204, -5.254898164028731, -4.990220505423296, 1.5750211289793064, -5.145667374585721, 1.6691717655648621, -1.9463478213686662, 0.5597347106446655, 2.0461395848108666, -5.439701701558006, -0.05297137935963305},
    {2.5630438784440135, -5.496610732593091, 2.6335264907164047, 1.8931008630961295, 2.633443655276536, -4.614794762174596, -5.229040829675219, -2.0733976795493723, 2.6933861431421042, 0.945380129183448, -4.121733484297242, 0.48841763474575906, 2.5328953338424296, 1.2422295113382713, -0.7000708307273326, 1.2338959209042695, 1.0939700964877637, -0.9176482422777673, 2.606432744989394, 1.3430478788696547, 1.7258496526944247, -2.60852702252037, -5.622868666168541, -5.241676361538321, 2.024425252257415, -5.3359817663434335, 1.8328238688033538, -1.9476877431601551, 0.5666446417877875, 1.8167938025615447, -5.571946756986755, -0.05755028639153},
    {2.5316009565818445, -5.6723346825915115, 2.627291942037917, 1.908012323982516, 2.6462495314990626, -4.80906675577763, -5.4028899820108895, -1.9764695044769212, 3.2791520366467193, 1.0878376165476475, -3.8829275369266107, 0.7995600721591068, 2.4618889712675607, 1.0589338664684007, -0.5321722399224285, 1.3616227423338132, 1.4895897800474893, -0.4935447295784775, 2.632893008070111, 1.4806283063262986, 1.6738355108768275, -2.46737150562041, -5.518776348291051, -5.307000935494405, 1.8574473609355964, -5.056768234856692, 1.8705752602599772, -1.9331872212003818, 0.8017800352905043, 2.1795593270011855, -5.50072744855045, 0.01586038406878366},
    {3.044648945994369, -5.582468808399738, 3.042788495483888, 2.3183884484888524, 2.979661666376796, -4.683129472265807, -5.435370277396656, -1.7687648873297375, 3.643463592430547, 0.9507951511710443, -4.248081624542615, 0.8966850380547366, 3.02829574184199, 1.6959200379525998, -0.8442853776197702, 1.6274932484426543, 1.7568010056162493, -0.21361670524409684, 3.1276106294354244, 1.4619125527748718, 1.7960846357386961, -2.158730923738421, -5.520003004089447, -5.260026006753734, 2.1447534816789706, -5.266051569634015, 2.082785184693274, -1.8446132737570469, 0.9725233857548855, 2.566729839475188, -5.520075933943262, 0.6256180089623771},
    {3.2985374110208157, -5.4433378273314, 3.147890256797064, 2.7135622998322293, 3.327476739729779, -4.492135130492957, -5.130649041244639, -1.4705976818329143, 4.326250854859618, 1.9447029548572121, -3.938056771248174, 1.5065663534889369, 3.709548990002777, 1.87992549194103, -0.440025869248341, 2.337429699168607, 2.2516191221518134, -0.278270424917888, 3.5257247322477836, 2.2939187953752285, 2.465949692617248, -2.1819990773789004, -5.350661026061283, -5.305434174918294, 2.7470668877946456, -5.223121611210101, 2.79827741660607, -1.6275012413126995, 1.6607226851084909, 3.0227741665836887, -5.71395846375941, 0.6588602889700242},
    {4.047033070353246, -5.061275072066489, 3.843569468496867, 3.150702528705413, 3.927288527077203, -4.036800266667623, -4.756506981411741, -1.3394702180641882, 4.527019805715511, 2.3760829521379447, -3.1005238780765145, 1.3612907523227689, 4.1666853554067265, 2.372089748733603, -0.6005214475437599, 2.351233397832932, 2.509519195431905, -0.4684705372661378, 3.787950980048422, 2.905077266665059, 2.9876673413854333, -1.9065442487691904, -4.810944359638821, -4.97211386632795, 2.8781260164472675, -4.433926849489272, 2.871412120003933, -1.7575452028984302, 1.9174542273955306, 3.2869325858394705, -5.205244640864104, 1.1668818809987558},
    {3.417978552033624, -4.944792108982623, 3.3159696781682433, 2.8967972727577918, 3.461240273356682, -4.24265057294681, -4.567159233553429, -2.088992418325376, 3.895206814383389, 1.8710158224121438, -3.574308479809921, 0.9591903260131847, 3.74512186818186, 1.836258488080396, -1.1532712153802154, 1.688178053611987, 1.8786016217347217, -0.8166279979972337, 3.458345635407894, 1.7193640714871063, 2.6651536594043796, -2.5747426689153072, -4.718398718413531, -4.859075541089047, 2.065952721576589, -4.720847860500643, 2.5369230259714883, -2.187773907577716, 1.4755381583975142, 2.84608161956632, -4.838964692603413, 0.30972583899190137},
    {3.5038025673150255, -5.091144277389192, 3.4343699680596234, 2.479279265887414, 3.532659189368114, -4.647307157188789, -5.136583924812528, -2.0396228522341815, 3.9240087193605855, 1.4134318556261094, -3.973055060250266, 0.8332807779667317, 3.6629354757401473, 1.6458317827984232, -1.2611889484848144, 1.9373519525481118, 2.090582289882245, -0.8931911414032473, 3.6041164979938376, 1.7650106911844259, 2.5325660975671025, -2.548662024458649, -5.415510510410873, -5.278133095212782, 2.5630280765293305, -5.076731285309329, 2.540252088162313, -2.4050663913607266, 1.1645466008888636, 2.912596849276771, -5.624954000931719, 0.37925317544876214},
    {3.8321853969316773, -5.558553823865021, 3.8773600714077716, 3.171645292780414, 3.961619124712129, -4.433216253655106, -5.210673608859859, -0.9745805781026997, 4.042528870719991, 2.3087353749979984, -3.2697068313842856, 1.9978364438575764, 4.391980841435192, 2.374980789188444, -0.13891386314124107, 2.585058317111236, 2.277497276180362, -0.04465145143845571, 3.6918159847936343, 2.523963386579019, 2.9803135089284947, -1.599757612047961, -5.364293500766896, -5.370823942415847, 3.1961404046330832, -5.063027786177415, 2.8511727419615642, -1.6271679469051628, 1.963962490799651, 3.3164678929523004, -5.548362031356415, 1.2555428871564187},
    {4.089995574417493, -4.829004562568543, 3.959359760630629, 3.34669763005542, 4.040890338458112, -3.713629675707896, -4.551674161621441, -0.9016984236524096, 4.799661127812174, 2.3747859269991416, -2.7965563827446123, 2.001411115969862, 4.336950590356458, 2.6783951151449146, 0.16720339449704474, 3.047440867160908, 2.83306657504346, 0.17328842126050598, 4.0408988544163496, 2.8952090152643204, 3.1434974197958767, -1.5768054218356544, -5.024884640046883, -4.849678591217823, 3.284422572807571, -4.4595481247065, 3.3443699203568795, -1.2413394996848695, 2.21516548485783, 3.649774429722043, -5.140574893718278, 1.341369365268494},
    {4.323207894349998, -4.385483542035754, 4.201423831994908, 3.6355883092242167, 4.4539214203919135, -2.924029814610841, -4.334652737505944, -0.9512704055307132, 4.876875051106212, 2.5937847383653057, -2.108170384177897, 1.951818588815178, 4.777039552443359, 2.8573585650136923, 0.1608105720291805, 3.1268291527870886, 2.9256387096138163, 0.5427728354445814, 4.3078182413472845, 3.1373676498368543, 3.071032582670157, -1.4013697910366782, -4.469631718865027, -4.322179816076649, 3.4019875896155436, -4.043088224521626, 3.3455424579750437, -0.9286984214830639, 2.400967460860379, 3.6383999505657245, -4.666119073633895, 1.260431937931864},
    {4.493664899772236, -4.886841822210541, 4.2832842737472765, 3.713649287219747, 4.249778229930455, -4.018049931031287, -4.701771593535388, -0.7709640889550295, 4.439287446317553, 2.843670119534336, -2.6426700153292706, 2.061467938550052, 4.639760428696719, 2.7155836808712177, 0.14935472191659221, 2.921407165751441, 2.974864258012887, 0.3497262130773154, 4.327118927612654, 2.857786827416406, 3.1160203034970406, -1.885265794069385, -5.0223044468964435, -4.745578035545289, 3.2401401511622696, -4.61930868109539, 3.4622055679093053, -1.3457654439742206, 2.5495107944676874, 3.677220255744568, -5.181010472537729, 1.5496648257742731},
    {4.2676367415943535, -5.098936502964694, 4.345625946985133, 2.9636967933311746, 4.064694520119452, -4.3974192137519115, -4.833100430832009, -0.993464565059781, 3.9805011132208836, 2.60272337752113, -2.6216129012062686, 1.8899083375100478, 4.282630755996664, 2.608485426621015, 0.15146809365690572, 2.6044217716429667, 2.8691561055130057, 0.48663305498254794, 4.015587870020769, 3.1943562731744803, 3.2637218270848103, -1.3644386187631514, -5.597800951854945, -4.904073977415095, 3.4539108685712936, -4.7108901435275214, 3.306276843973633, -1.3742700296944788, 2.055149881240462, 3.907300473282068, -5.406547380683072, 1.2303543786653512},
    {4.05869262521755, -4.721925015004691, 3.590416380777441, 3.1754317870610675, 3.9338896339209235, -3.85012190415941, -4.690816256551215, -1.0495908950854835, 4.085213346464352, 2.241447875725011, -2.766384306357004, 1.7951513127004595, 4.162238868140347, 2.3011197550629903, -0.06751474185736048, 2.516808400653501, 2.434569747613119, -0.253065092309272, 3.8948299193287754, 2.786887794029318, 3.107788212408381, -1.6143681908917216, -5.065303872642819, -4.729173258735943, 3.1673880995041404, -4.6863855495446956, 3.2494065389522993, -1.5104372682143696, 2.0678580885556794, 3.629135998209178, -4.941388537325112, 1.1327685598763082},
    {4.053006152246763, -4.968590948300005, 3.8339812087470277, 3.2901010635190775, 4.290969729321025, -4.172892790156768, -4.762098689499286, -1.5947734810288883, 4.0741931223883485, 2.075266747341154, -3.1047053653654832, 1.7512976127492073, 4.735624688815709, 2.2503166912742443, -0.3634353852878158, 2.8012573457924796, 2.7161159765558702, -0.16842849298983512, 4.282254804469169, 2.570948582199075, 3.1816273996587996, -1.9943788528455284, -5.352630108428847, -4.938953579157224, 3.4229455066501124, -4.71047632546231, 3.2860711590897367, -1.5322516725513158, 2.163794144052564, 3.721375092070531, -5.053305813946688, 1.2500760410734115},
    {3.9433593409532466, -5.2525000104850506, 3.7790220317726235, 3.2727598602058574, 4.148703926207644, -4.319535046286661, -5.146409778300478, -1.4968911842697712, 4.041032302958037, 2.441593428744443, -3.4634350681617123, 1.941601549798858, 4.239133545082627, 2.291806053730078, -0.395811300937908, 2.5613748028682215, 2.629488466026573, 0.11275843203003308, 3.964916320829753, 2.7762530738512146, 3.0697807691613614, -2.0416529496965907, -5.299018496519367, -5.018994348418453, 3.1903231099049307, -5.0197084049268215, 3.1358236352830344, -1.6193836869493188, 2.080838965555364, 3.38851314385283, -5.521643689724431, 1.0152636401485107},
    {4.510680020090585, -4.990106870993319, 4.27361350833793, 3.35219432819548, 4.530615207036088, -3.986671480800758, -4.874880959729227, -1.0242641888392692, 3.753908888283029, 2.4111318560216186, -2.5772676800023504, 2.5396230502606567, 4.590657424465364, 2.5365331444237205, 0.25966215440272694, 2.8851243129916653, 3.083918191649939, 0.27693879724431003, 4.239450685515006, 2.9206098745854, 3.4681250355373012, -1.6222125089642867, -5.130423762775532, -5.202033190504467, 3.636487715118172, -5.015533863522578, 3.5007745623156143, -1.41857601104824, 2.2208710437333194, 3.7354524736277614, -5.389646724572219, 1.2842308466083525},
    {4.235364829040908, -4.969800237098653, 4.004394437165478, 3.3050524065397364, 4.401053438882366, -3.8052729777646195, -4.997195862033406, -0.34159906095858905, 4.1481675289745725, 2.811669274509458, -2.052435996411517, 2.33781411606222, 4.258610948587819, 3.0487823965979928, 0.7650890467730206, 2.859951940677112, 2.7974995983975437, 0.7289343216413091, 4.241351547343625, 3.1145879593370074, 3.3848979893112316, -0.7287827320431041, -5.290820812434954, -5.072968048207524, 3.436300012051518, -4.795096166694032, 3.376950861516597, -0.7429204334564992, 2.450392092885025, 3.6914876495244497, -5.522811833879561, 1.6482894083843072},
    {-2.320598770599058, -0.525583264865135, -2.1721868828265443, -2.0147141326543805, -1.9558636495343606, -1.4512593682434218, -0.3795392886813851, -1.6845020207651882, -1.3226501100779935, -1.6065594026754855, -1.6845373873086078, -2.172416863290782, -2.4497305761714476, -1.7042489628040982, -2.051660830844584, -2.4419915277741704, -2.240126375065567, -2.1739370215977414, -2.0497263287406127, -1.9335685000300695, -2.666078682080238, -1.5017184744625471, -1.228758691673314, -0.9266659358102639, -1.5648507491410821, -0.4694001661644992, -1.7092085610025507, -1.1775413427164239, -1.9978263316110336, -2.016791865458523, -0.4714574186314973, -1.9225289742996508},
    {-0.2512578381949453, -3.22591772010207, -0.42310876565546807, -0.9223295158695859, -0.4970043574474282, -2.2178074187031833, -2.984628721916641, -2.556185933582243, 0.6028437874432319, -1.464711950781029, -2.5771466723350125, -1.2817389301408015, -0.40905809512689406, -1.6016019891181779, -2.3283471137730083, -0.6503264123369363, -0.8776146473987521, -1.2283477357090322, -0.1028464003425213, -0.8713526850790332, -0.9715083036093478, -2.908666506232385, -3.3140231352149723, -2.824478813780179, -0.6216789732321829, -2.4957170757821054, -0.3112753908273511, -1.9923233569565142, -1.5527370970375924, -0.8200932083739361, -3.8683775564469016, -1.713134000123715},
    {-2.9528460268528476, -1.4803744928239786, -2.8339663410002465, -1.883384978962376, -3.266540268653237, -1.9980630211104522, -1.4733229733374207, -2.8718600728312627, -0.3722847475346773, -2.3902287935691726, -2.833497519984423, -2.9486881546778245, -2.724152656881412, -2.661048709114643, -3.212923084793461, -2.7297043700441956, -2.8260853729491076, -3.1439678951527217, -3.1152438653350214, -2.510371459121629, -2.197436947152597, -2.921268581515042, -0.7010690110626879, -1.4656291418271217, -2.9822737730073823, -1.8644042298672574, -3.489380396327419, -2.6507794874666195, -2.6505574621781, -2.862612037910115, -1.0879543198413266, -2.551541514210572},
    {-2.122309642817237, -0.6798432515413979, -2.135553071774918, -1.3287663618749244, -2.101300848536138, -0.8680673603383914, -0.6386058348675125, -1.6608654875701214, 0.31096371352675595, -1.6291762105728689, -1.7007314107318643, -2.5192624210152905, -1.9602158123094684, -1.687859479307734, -2.1831435737605522, -2.3792898901145247, -2.1301070424733544, -2.011903094491019, -2.0402681218641225, -2.020767047880763, -1.4958589735081091, -2.19369652891091, -0.08996288053971777, -0.23675066231406486, -2.381013503134478, -0.46542482587726675, -2.457755560755337, -1.7570305784392555, -1.7046517700733341, -2.108047869526991, 0.04799553388892352, -2.18307704291858},
    {-1.5381258658763002, -3.4354592616673467, -1.5062668987927208, -1.633232442189614, -1.188793266951701, -3.1114923448340224, -2.7300672157818093, -3.497001823549716, 0.6251360050042751, -2.0098585490783303, -3.1570217150067053, -2.4437905408295673, -1.070419678938346, -1.8523001890423452, -2.8198335038025677, -1.697916109370464, -1.7986628583709607, -2.7642126824136706, -1.0617456644620302, -1.8864974684904228, -1.8265258716798036, -3.402267561164625, -3.2402991624160395, -3.1309621082438297, -2.0009721225754573, -2.683198848195349, -1.7688196198559607, -3.1666358169479096, -2.278128343302868, -1.6544885070549822, -3.088022071986823, -2.6974768698606346},
    {-2.0033754845316674, -2.804652771005942, -2.1434111485661957, -2.1784003318178713, -2.0873551897230707, -2.63782035133359, -2.2983038561843125, -3.276961728014324, 0.49271829344182755, -2.870704470551963, -3.0618705814219513, -2.550237426665932, -1.8706632668902305, -2.5206906751507985, -2.7198178006035403, -2.288558771807819, -2.4106074852388466, -2.791948118068553, -2.081033765703251, -2.410226282904167, -2.009236513616275, -3.6134738186495268, -2.374852731798813, -2.404183746797234, -2.8531265822796192, -2.3089758736976256, -2.2615013980099774, -2.8452627038860987, -2.376946087373542, -2.158967121056277, -2.3893972835156956, -2.6256698751700944},
    {-2.081661203752129, -2.973233782647646, -1.898932615372873, -1.8202300413607129, -1.9424750351637858, -2.778190584066394, -2.643579907813814, -3.557361909320124, 0.2902210899544098, -2.802191936424115, -3.5484580484220394, -2.974089124607168, -1.7841880865463162, -2.9055963827937163, -3.0123705884360277, -2.3371372684459666, -2.424025218242507, -2.9405286785198617, -2.1276156850614933, -2.6496205831785096, -2.3579943131874272, -3.624040371374588, -2.7599459552792296, -2.8328869205907092, -2.8984434969527446, -2.7146393551157515, -2.566326361803756, -2.9559507080158403, -2.7874657292157967, -2.2358823030584754, -2.5887006098073377, -2.827966741584898},
    {-1.8342454161390842, -3.1585991991218973, -1.435555603065265, -1.6083961469975092, -1.6506533122222047, -2.742580880136245, -2.8774735763093267, -3.275036176940577, 0.5559330974127696, -2.079142492848983, -2.963517719292002, -2.428101875219646, -1.8405538477783447, -2.287714058288604, -3.155579568248035, -1.905934435592094, -2.293905395008714, -2.5233400998508855, -1.5168618691149018, -1.62825162930693, -1.6592606514992732, -3.244345084008828, -2.8421400629181015, -2.5873801491893653, -2.771317393717378, -2.466458937849128, -2.36319862217104, -3.2645746283320887, -1.9522932458161482, -2.082917247462517, -2.5672429037721716, -2.7944626347462296},
    {-1.8924440589495057, -3.233745739856558, -1.709489670671637, -2.0514917343320067, -1.9897986462810813, -2.512238760105769, -2.7811124260336824, -3.1059498136586003, 1.3335955757016704, -1.9509691175348212, -3.1073658429281634, -2.9654705892690196, -2.088310251529776, -2.4441365331166605, -3.2167015505906034, -2.109070781017394, -2.468320525744157, -2.8444583375880503, -1.66970657241918, -1.726048682370716, -1.7576016964810954, -3.5751004287481973, -2.892810661892683, -2.494231955749239, -2.884716279309841, -2.3878872958086155, -2.4448327461343986, -3.126084197833904, -2.1044691432893368, -1.828443559207244, -2.838316503523678, -2.46393725140068},
    {-2.2406319913358277, -3.534815251668616, -1.9783189128757788, -0.9380761459536991, -2.0616933964943014, -3.2123300266155232, -3.1907724985391184, -3.36776663728077, 1.4354359856948316, -2.1952506815434187, -3.285569072038119, -2.815607676980696, -1.8405974306070176, -2.1022452578028665, -3.211518749814461, -2.075596633113792, -2.588229979335424, -3.043458174846651, -1.7920463109226599, -1.695938573380316, -2.1058195449556916, -3.4488680326547323, -3.0352841812787013, -3.2556288651883416, -3.1347456120979538, -3.250476107708086, -2.4535731162404746, -3.413108624633566, -2.286852937583624, -2.322829743808031, -2.7810478391526585, -2.600274477575384},
    {-2.4992034242104877, -2.9901022775569612, -2.410675031244812, -2.1724975302837772, -2.9382863208986376, -2.918140219821342, -2.5713577585689427, -3.2532885842876396, 0.37430684442491163, -2.7699994547432554, -3.042746648068493, -3.037038234242558, -2.3816657493684614, -2.5810585158747985, -3.278161763222225, -2.6985080053482706, -2.7058523238898347, -3.244222743100356, -2.3053257865342944, -2.6336509806796458, -2.631074600044696, -3.2123312499690626, -2.8472570242885644, -2.61399879080125, -2.7765688183599595, -2.5132638926290087, -2.9974108143628637, -3.0905696829198446, -2.518313811362997, -2.762083635570264, -2.0923236330766577, -2.795284654789779},
    {-2.490582668365651, -3.1067628052704817, -2.405523789656504, -1.9345504476637552, -2.5126670143643866, -3.217961291186181, -2.785385029132442, -3.4837190674199046, 0.9083475991751256, -2.78719856093962, -3.3292776765001326, -3.124238366213134, -2.4035152516756946, -2.6821402763746103, -3.1786030337792948, -2.41463778695317, -2.6495047900728643, -3.1798992420519716, -2.3283837472893354, -2.6414867625124843, -2.286784237287412, -3.3781501254447295, -2.6438866118461957, -2.518656056893757, -2.930581020169116, -2.790440715275001, -2.5510840795480725, -3.264118425674797, -2.743947139701104, -2.500177188026284, -2.3757144177577434, -2.905026584630306},
    {-2.75031403263192, -3.6470667852598915, -2.202363226137926, -1.5082819042332611, -2.320725983094421, -3.793165421972162, -3.502678005835701, -3.6952603593607547, 0.5573840954079309, -2.6469623973353635, -3.714019210563742, -3.0958738790702274, -1.6434541157531835, -2.7328757853308008, -3.4639559972089917, -2.3407042561523657, -3.2611139397112097, -3.6393873108172308, -2.557667852492745, -2.55064122565418, -2.350600014596905, -3.856550188499873, -3.483451328456492, -3.434727018337178, -3.3622489574050434, -3.5942464231066817, -2.8494061065869936, -3.795335816068833, -2.5277695215379037, -2.5137897122764246, -3.454123555224764, -3.1942994973384238},
    {-3.046081247833671, -3.4257867903383357, -2.87965848762639, -1.8228296916540576, -2.694834861228567, -3.5452345376065035, -3.2069229587404497, -3.605373676350686, 0.04217227826681925, -2.977169463923522, -3.4049356850838115, -3.3636579238765805, -2.543763380724968, -3.382962451918878, -4.127436957743955, -3.021953570067772, -3.3670122754165557, -3.617044298704897, -2.9898522108262044, -2.8964687395270374, -3.139519636924545, -3.8840238252652286, -2.915688122538865, -3.0974099323503403, -3.5145466092125095, -3.4217388827701405, -3.513142462844493, -3.8790371868332882, -2.9875277115347103, -2.832140074858122, -3.2446506192733837, -3.213578804217052},
    {-3.2409142386524334, -3.5388222769633906, -2.9179660804828735, -2.433940254788129, -3.0853853854545346, -3.331114500518245, -3.1714052600991973, -3.7335273605132158, 0.25118371791900235, -2.973898350244695, -3.365264184293752, -3.9021723462128595, -2.8744671106535034, -3.36340628137216, -3.7875935523000868, -3.2976286746953467, -3.437698855037236, -3.7107275173954024, -2.976066355097684, -3.157563186696081, -3.4467884584462283, -3.6673205801074142, -2.8385254026832234, -3.33502069927829, -3.8032316221871545, -3.220153927303786, -3.7608019398346273, -3.6405426677502195, -3.2585500949039243, -3.043066687825691, -3.218011350909423, -3.2546184454212965},
    {-3.3163601000201033, -2.7582655925184127, -3.2943004091757215, -2.698348326037915, -3.375520199987726, -3.079056783014931, -2.1358249023732285, -3.5791683325903545, 0.27966021233906385, -3.552045498099412, -3.3875423663354414, -3.4929543391734206, -3.0933568478523936, -3.413949853861082, -4.00934531910535, -3.5076002679825855, -3.7447775789417888, -3.814626870556375, -3.049267515415032, -3.515969631482903, -3.444672703289709, -3.7160278270623843, -2.1352374026666525, -2.609053135988677, -3.4259760329466395, -2.4245040630512995, -3.891410370578754, -3.5947417322068977, -3.5049822612856167, -3.420292353504683, -2.3750806217792837, -3.730428124343159},
    {-3.0542784140363834, -2.3982311306242, -2.5898761870851765, -1.3710106782940241, -2.6148738992676015, -2.71198664707416, -1.9944633172254234, -3.2885757435128, 0.8225315483833997, -2.80313774180603, -3.1294783693061357, -2.983228728503725, -2.440189191662481, -2.572913671800714, -3.788094369003042, -2.5185723126829243, -3.083074535376831, -3.3600688952590487, -3.291620459885368, -2.450200497514184, -2.4670461586228414, -3.509922757086704, -1.261620295080259, -1.8608995869303138, -3.251669280650435, -2.477139515680442, -3.4272680029829976, -3.258965821766403, -2.526401753731031, -2.6577746795619284, -1.9694654371142442, -2.8624622433143796},
    {-2.2250590944550503, -2.283839169794171, -1.971989158068878, -1.5243058526204436, -2.3727266411251056, -2.7326258005731208, -2.150987101132146, -3.5573011930551117, 1.0287784338856119, -2.2236083271346336, -3.211076696624954, -2.79787648062023, -2.107519933122563, -2.2185364190830237, -3.2502551904976777, -2.044282180065782, -2.450505581542861, -2.703519294371258, -2.187026686885981, -1.5365122189877627, -2.179265160974347, -3.6972808261718426, -1.6581204430467398, -2.2054735732192463, -2.8164041436396086, -2.2259846298802164, -2.5994116815633515, -3.153379737994715, -2.037882340687728, -2.436334289620619, -2.043176443628711, -2.799004203067243},
    {-3.5800658163765635, -2.306183221328879, -3.609619403415188, -2.568039229258939, -3.601249043019492, -3.1136670521331653, -2.0061829600075365, -3.895850977394862, 0.267308927663141, -3.425254379416024, -3.5631195304582026, -3.781795642322278, -3.3197480958101693, -3.5484474203370544, -4.136640207507588, -3.4043486720784086, -3.858419154797015, -4.042537933442117, -3.502539672711072, -3.7918721110784066, -3.7480597391155235, -4.021705536041984, -1.6619765273074185, -2.3494266175571608, -3.8796567291804127, -2.5517567324312562, -3.994698006234625, -3.8334867812769424, -3.4144124552208748, -3.615293802842997, -1.8606592024493513, -3.670007665528246},
    {-3.657158747386755, -2.9088018559837034, -3.1338239419891214, -2.2817942991357354, -3.1611586793239814, -3.591904187795758, -2.6593030181918116, -3.615212712996958, 0.09746999025242115, -3.5366037311186, -3.801265474267366, -3.7755281227943276, -2.748899895299313, -3.2861441462795637, -4.517302455114105, -3.2050813621695187, -4.187801499297618, -4.636689025420514, -3.53079435680725, -3.289870748362046, -3.521188093578267, -4.301155258664434, -2.4882945306154682, -2.8210846433584504, -4.017780615580982, -2.9219393323012435, -4.011979166334416, -4.558717169582351, -3.1665858614578077, -3.183580848863201, -2.1529936850926963, -3.46877109650191},
    {-2.646953412007985, -3.622911620457784, -2.188397753728869, -1.4465319899797804, -2.1165204857431807, -3.851715835093339, -3.336572789611207, -3.8595492985527944, 1.195031746129608, -2.622378702851455, -4.084048110515699, -3.128726377756353, -2.0449880136164578, -2.770179750196432, -4.2058827127091325, -2.3940370182106667, -3.20396896118141, -3.50457289997043, -2.491588236939004, -2.470422596823983, -2.2864491231582114, -4.207861392808551, -3.4091276014277963, -3.1526312410034825, -2.8509802617458497, -3.373573107826185, -2.96641889451523, -3.89794303500556, -2.838520966326468, -2.63451682629629, -2.7921125995356464, -3.178862967970782},
    {-2.4741234613440177, -3.001370888300283, -2.308100073491944, -1.3553513620511863, -2.415001656238685, -2.9416272294385957, -2.492223389551286, -3.992737633274371, 2.0271585615807437, -3.145590023636129, -3.9035888673086543, -3.6904206482268593, -1.7787750173041905, -2.9614476546352804, -4.248681312912796, -2.5303287539045143, -3.0271381082076165, -3.508805340958116, -2.160871677763083, -2.6688579478773926, -2.6595358535850453, -4.167299367988966, -2.0051734033913156, -2.9658051273902597, -3.1882717340934628, -2.751882564355077, -3.0098757793941497, -3.7218908279403085, -3.006154127666344, -2.6041790860336786, -2.6710456350263887, -3.5424324364730833},
    {-3.946248245334393, -0.8232695299442956, -3.766083540982021, -1.8771901594792748, -3.5135957422368556, -1.7467470924907165, -0.6131560133714206, -3.892072398894957, 1.5607378676037487, -3.2487318522365034, -3.378937030233982, -4.034021291847471, -3.2512779773433214, -3.4684504080033034, -4.362654651891596, -3.2018127454329193, -3.919205327673601, -3.7013120780793085, -3.671238963011071, -3.2843484643262815, -3.0784001871882434, -3.9645677482665675, 0.7279026152078432, -1.1677301351698288, -4.385360774302596, -1.4842630053830066, -4.0499097124487395, -2.9852038805764236, -3.4676692377070966, -3.5244687933957475, -0.03579745419247036, -3.7071984131499724},
    {-4.479684856298754, -1.9202130950910858, -3.8728854549133547, -2.304270755463733, -3.9185447314933453, -3.002886760812766, -1.413674977880824, -4.160558628212365, 0.5743121951320649, -3.2412879752886115, -3.8940950849064024, -4.266424347224213, -3.839836470416248, -3.4275906876707363, -4.532026672573113, -3.4943245997141807, -4.379105766061686, -3.9316153009599772, -4.194520418794518, -3.029648515025399, -3.462078331867426, -4.38364933434436, -0.7135403069064097, -2.1658317647451577, -4.747258104324647, -2.1180969295291674, -4.4019347397826625, -3.8770063370737944, -3.762633473191369, -3.6969613369615315, -0.8618839117361147, -3.781154555793278},
    {-3.7811981440235347, -3.2668704188336486, -3.5948903123900555, -2.547231957607762, -3.512775360808856, -4.1973077660439255, -2.9296916120802567, -4.411294605324744, 0.5199374210156661, -3.2623493772395102, -4.003118741629907, -3.9353281407807206, -3.439379161599067, -3.317519237710293, -4.759087490613194, -3.384556954864371, -3.958714840820495, -4.202246037252663, -3.472165431949705, -3.0858057622403265, -3.597109970298535, -4.214318739788515, -2.6482099540746105, -3.18398454496877, -4.206459676104071, -3.6626153422525953, -4.311038995454261, -4.137624265841224, -3.6179034675214283, -3.3549530921788575, -2.727574683654708, -3.8077795508391876},
    {-4.326665898949883, -1.352307343698719, -4.017484402412519, -2.2683998181676155, -4.048755455462468, -2.907790446666442, -1.6408526044381173, -4.0975207788780335, 0.3860340497428149, -3.60861759652248, -3.7105880752095115, -4.451296613058857, -3.715028227201842, -3.9141493540386834, -4.8943032077830235, -3.841991082914237, -4.303820949601558, -4.281390959748657, -4.291916247122313, -3.481835871027657, -3.5011464060279063, -4.120653787420065, -0.235589032902714, -1.6430722082321834, -4.441075366596257, -2.200013195510545, -4.603336978276107, -3.546397708965885, -4.0187358297774365, -4.098376202629155, -0.36138122256377153, -4.118761324508171},
    {-3.9988380009312636, -2.155557659923399, -3.9732392818297195, -2.0609495833602938, -3.5023900527204166, -3.2341777779198764, -2.253907914757106, -4.3973246310750245, 0.41341138023743434, -3.5294135670949096, -3.7858814437357817, -4.234072894009042, -3.4622939559550328, -3.6161320180559815, -4.583614683163733, -3.5658989453116923, -4.030961053636311, -4.283146521477869, -3.9480985115284284, -3.219511721888434, -3.3878493633748694, -4.494384606894225, -1.0036444556433768, -2.657272326815032, -4.170711690274906, -2.578673666717448, -4.279064623463489, -3.978383371924028, -3.6261109889744527, -3.7874547843603006, -1.1003510251678112, -4.151068280733518},
    {-4.287687964798114, -2.186782555445156, -3.9092315860180724, -2.274561352409567, -3.5697558238496065, -3.3598060056263703, -2.5804095136599114, -4.459304134934213, 0.5474010364279911, -3.780603357147444, -3.8812482183015486, -4.353960350373743, -3.7837010948472507, -3.863549971262123, -4.5332665841928055, -3.3749244997577477, -4.285104638382354, -4.473751906862, -4.0488829440852925, -3.666266353071169, -3.2747236296584514, -4.145957874463043, -1.6874346091391457, -2.9457601379396365, -4.517611711976529, -3.3181658644209775, -4.365976937307656, -4.130002905607989, -3.9987387390752587, -3.851112225376431, -2.062956781325678, -4.2910953745173295},
    {-4.372197421091957, -1.7264837067500527, -4.244137527406193, -2.643114201935537, -3.9080180599640704, -3.454338859087326, -2.065419653554495, -4.1880330581726115, 0.6144633207713502, -3.9243085876024035, -3.9614127377623873, -4.398788398603364, -3.783365665471685, -3.773780867326604, -4.987260562410063, -3.9558939048515644, -4.522171015512839, -4.39789517524139, -4.133319677848254, -3.724851793173104, -3.7822687246152293, -4.22396721025858, -0.9873030042706095, -2.5048809554913647, -4.43538304974203, -2.757116062066328, -4.2022899770114925, -3.8776922763773447, -4.023472271248969, -3.8204291952244027, -1.1877967241206122, -4.03951888169072},
    {-4.107766575193901, -0.8530140502558334, -3.766274523682246, -1.712329891581947, -3.537838351627093, -2.363658469122717, -0.9719816743498179, -3.936782310832604, 1.3545538328128641, -3.2548069306673995, -3.1846976489818863, -4.151802961886858, -3.3513183950133825, -3.6121207726885776, -4.45540222800347, -3.536579661308694, -4.1869933339242795, -4.008833913631518, -4.265616342300604, -3.199020985698939, -3.346471046522938, -3.6272140878613293, -0.3448122126580169, -1.2377602656897169, -4.3290917461940115, -2.113083670007644, -4.185397056251785, -3.516918007951508, -3.2473267310747627, -3.6480074140529117, -0.31563346429166245, -3.8295644509999196},
    {0.1087627679300011, 1.5638018427410143, -0.9739327399148677, -2.501541932333893, -0.9519361092650233, 2.3730543923236898, 1.6011269625333675, -1.672874786896395, 2.457644672971078, -2.2233920874870026, -1.6544848583069058, -1.8803033635278414, -0.30257866868206906, -1.8762049008268806, 0.9584489489074078, -2.091492455703841, 1.175153039323528, 2.117624956319454, 0.352946518447728, -1.9335032499889389, -1.3234910399412851, -1.4411591175914837, 0.44650177580803796, 1.1576945551210462, 0.226313248297117, 1.864358164976779, 0.9367322549148258, 2.516484691601905, -1.9082539003110843, -0.8538690952003318, -0.38471632265178973, -2.17152547980799},
    {0.361711115909718, 1.724622249770546, -0.42729188849023686, -2.7069374162272664, -0.7704776537556036, 2.8388224194405822, 2.0023696684300543, -1.4996294319042276, 2.0033210707836644, -2.199666891063439, -1.9000336485985272, -1.938143198356584, -0.1424001926114925, -2.247015799750963, 1.670723340592522, -2.2470322091539034, 1.6265990192459687, 2.708697643016616, 1.092409674451924, -2.025234361111935, -1.375515097867122, -1.636888926647897, 1.147269286243376, 1.8952440030490691, 0.2643721377056871, 2.3307896224494584, 0.959324255269928, 2.278512160624532, -2.4181311723779255, -0.9557387387265373, 0.4604165457963056, -1.782965731098598},
    {-0.3815898590088114, 2.6302932550636102, -1.4163058349329911, -3.305173328650174, -2.0237422639142157, 3.2635838570311457, 2.5292181555223734, -2.5841028478971504, 2.812415260971454, -3.155227533262474, -2.1406182713138753, -2.712017324325973, -0.9399235034292633, -3.2988534183458467, 1.4882887777854505, -3.00952343553273, 1.7983563942683587, 2.8464120012843668, 0.2996345238202255, -3.164196769835217, -2.6237696319878414, -2.3756010776824814, 1.3337223132268, 2.2365153676975336, -0.3418025768061731, 3.0056738246825314, 0.6206553925642989, 2.737719583160902, -3.1428481127222136, -2.1258180697513147, 0.6420628744483552, -3.11918686720493},
    {0.1541327300611835, 2.004258934042795, -0.7705857786755039, -3.0045681539453275, -0.8630681462005617, 3.17431833722904, 2.5157562774363518, -2.0289493648805608, 2.8130148339424723, -2.601661464682571, -1.9721902761624617, -2.2423002847184477, -0.4173206803825357, -2.487423286297799, 1.8887774100355974, -2.3310202022655795, 2.0801228839762214, 2.9742662985747215, 0.9658571244122189, -2.4097713408587764, -1.854199066009662, -1.6751788807364596, 1.3974886703362386, 2.1395699040494254, 0.4942170629766303, 2.3132194641004458, 1.158216945339142, 2.9151261670828115, -2.428179171923231, -1.5291228850046181, 0.4447678214689399, -2.181962203180343},
    {0.3958996438601124, 2.1494814639688085, -0.8771364927224079, -2.3724202904942095, -1.0133026491991026, 2.893161287390152, 2.0100249757256674, -1.9509308370235587, 2.6426530886106625, -2.41160940357106, -1.6513341278185079, -1.4511424497993195, 0.029683427205880804, -2.213435328274808, 1.9106506344230498, -2.1275191984172404, 2.2339360750008237, 2.994474617162785, 0.9864000801417175, -2.01363545127574, -1.6377182800408032, -1.123848271003717, 1.023086319710233, 1.7784553568194115, 0.6185907372905114, 1.7739775833059397, 1.4151055812097306, 2.606185994086153, -2.16414665330663, -1.3314187359215761, 0.5946852096455869, -1.466297459604896},
    {0.2489986307770968, 1.9115250751816582, -0.9703711520537949, -2.6870161332303453, -1.0442057222936363, 2.5323957240861055, 2.342061599768521, -1.995148505210205, 2.5459076691456977, -2.8510660135499366, -2.0713588150635545, -1.7402390684899087, -0.2959823265478646, -2.568271550514767, 1.758723958402743, -2.0758857920805625, 2.1289184290543326, 2.732623641326968, 1.2158759060460909, -2.4386745995514336, -1.9440941849129225, -1.6391553134993264, 1.499951839790097, 2.192065762224778, -0.12629773177753956, 1.9995818741979634, 1.193042988729375, 2.452942955931815, -2.184689412318657, -1.5650321825476314, 0.5524829023750499, -1.84172785441901},
    {-0.4011248405745443, 2.2149953193126777, -1.2327144457585129, -3.2971343213846223, -1.484587049499796, 2.283470571452382, 2.009079472810027, -2.3104842121896105, 2.3382956485379767, -3.010336012190124, -2.4273318282688727, -2.1924567204444134, -0.8550054671021384, -2.9684180079835953, 1.44799912431932, -2.734749277167367, 1.711139474807645, 2.409829909225109, 0.48423700387962737, -2.8017630283242023, -2.415270267818306, -2.357409306736578, 1.2570998911526488, 1.8525782130024044, -0.009036253040921226, 2.0734582156690027, 0.942765797871177, 2.5183075712590326, -2.98516692567418, -1.7946085007039663, 0.36003733739277394, -2.74674630410417},
    {0.09346804033943307, 1.9923583476400062, -1.293614864497737, -3.4003360188206733, -1.5690060549620843, 2.8393449008454885, 2.5379701078648056, -2.532390193740722, 2.617866859064185, -2.824399660992694, -2.2425184017368807, -2.0752194400459536, -1.0042028944562607, -2.912947040390835, 1.8061854507189394, -2.554675636651238, 2.158069806907257, 2.7706620577321655, 0.4862792958515129, -2.6160766868435, -2.163013497522236, -1.995933926252353, 1.4110297725531886, 2.149258053491792, 0.5088477084414256, 2.560881125332193, 0.8299704301334769, 2.8738069551418604, -2.956566370597893, -1.6632941562331762, 0.35738826639464655, -2.8864899489475278},
    {-0.11749597958772218, 2.5011716375358426, -1.5446439969694035, -3.336908294853755, -1.6400572527440507, 2.9070404987755074, 2.5374203847700305, -2.293290723913039, 2.3555783473648124, -2.8626427423085463, -2.257625738243189, -1.9606324227608816, -0.680707908660324, -3.028234903531532, 1.581621404463275, -2.8502895727574873, 1.7794043471714225, 2.802057041228559, 0.23228194752377354, -2.7994917751897237, -2.4840808343791103, -1.4592459722169933, 1.3126182090007674, 2.4519249747692227, 0.2805797677582659, 2.536235538213232, 0.6236203958339805, 3.308273427547961, -3.047788992938371, -1.9424335757213766, 0.1570080461887678, -2.7955378206278674},
    {-0.31117547990183203, 2.3557896138955625, -1.5297604949679038, -3.2785788161495244, -1.674219293085372, 2.791022980947854, 2.9160072692738974, -2.461460680544567, 2.886145557746712, -3.0597438019431915, -2.69581948440567, -2.1971740942206384, -1.3207370348513625, -2.9142676899746807, 1.1385742194699366, -2.9970142073046024, 1.8266167155771698, 2.843853179896661, 0.19031249331536768, -3.1306385803213552, -2.5873638076983587, -2.549696485275739, 1.4999335694921971, 2.400749448425898, -0.0728086177442406, 2.7385688904150154, 0.7221538498251724, 2.9760961743820333, -3.109703229592277, -1.9206748120156012, 0.4322977176997743, -2.605547941839339},
    {-0.19855512142061224, 2.233875871520704, -1.517727206147826, -3.3240029067131442, -1.6348498668290583, 2.746617646813726, 2.4416805496439395, -2.5036228562848426, 3.071033699071892, -2.935182145176114, -1.944168996015326, -2.109048069303285, -1.0336519166589835, -2.701999650479771, 1.096174460192088, -2.7005939270017882, 2.0245317912676013, 2.5942549501085166, 0.48890126225889924, -2.73762139859803, -2.3870403612021334, -2.2568221213169513, 1.2554928115397417, 2.4513870968608957, -0.17066055864379184, 2.46056816545948, 0.7020818710903218, 2.5774272064355803, -2.894571608957051, -1.5933996158684638, 0.8251647826357851, -2.4305391972368517},
    {-0.32847157592226073, 2.621555816487736, -1.6568325498585807, -3.50893902073228, -2.0370257868900894, 3.1863173378597254, 2.649060603057017, -3.151458634495084, 2.774102485424119, -3.38397008469538, -2.4018955402273034, -2.3240420240947026, -0.8557833081510874, -3.1383270663027694, 1.7969403638884733, -2.981320423620006, 1.4943932099202957, 3.014818371249349, 0.8481660908191639, -3.117503001055595, -2.610235587271707, -2.355781016957931, 1.180194571180093, 2.4347882756717514, -0.07973818540290789, 2.620897090786207, 0.5518484658005307, 2.7150016270342654, -3.253479247554651, -2.017683097754577, 0.7965338235761287, -3.0915851096278715},
    {-0.5110990197582436, 2.8485304421432867, -1.4755228083991754, -3.1708016919797526, -1.573786541048782, 2.8578008796320398, 2.7287082191118777, -2.83801770281713, 2.7011819189120736, -3.1605098657299453, -2.4727719825980876, -2.57956692241113, -0.7832915274625979, -3.271999396882003, 1.5743280993755289, -3.0477354354476263, 1.9077886419814747, 2.5235946453827607, 0.5522702900628367, -3.4346291346490685, -2.856361367036839, -2.2984819279597257, 1.3932706340082004, 2.306255147688868, -0.361949664342066, 2.5181405019365006, 0.6638229127092716, 2.9481272574928643, -3.092639120922231, -2.013577583119225, 0.3549595726435664, -3.1139396092511937},
    {-0.524163130052517, 2.426694101308658, -1.5624970970084286, -3.0751929903766126, -1.4929419256972956, 2.9385422527961387, 2.684620237500043, -2.393569157636573, 2.9874952098970797, -2.6403649265421762, -2.443607420312416, -2.177171345515374, -0.7513357921981091, -2.552721290911634, 1.2121266515908826, -2.6826542956410377, 1.6637732449719225, 2.442951287761429, 0.10757272572564114, -2.762517042244686, -2.107048218764383, -2.167543543829023, 1.3072751631859536, 2.647551587952294, -0.26608703369269043, 2.8832310206618206, 0.6993705684014802, 3.198970274300563, -2.655886544702489, -1.6750530407086017, 0.7612632563202125, -2.6750044007602476},
    {-0.6201216133851257, 2.3115915148245705, -1.9379957772491592, -3.257107273084117, -1.8683597965510197, 3.0151093535711078, 2.929408352135667, -2.269398851965366, 2.8774046468850654, -2.9843452749664348, -2.298735037373542, -1.928904606179467, -1.1173482149149294, -3.027681134389569, 0.9771856232349432, -3.1257989682823646, 1.4210427584974314, 2.5831131669613696, 0.03671806106540802, -2.536533134847251, -2.385371713080314, -2.235254943931378, 1.7425683609882865, 2.7981210541265824, -0.05817248487108463, 2.844770561581439, 0.6601276690313945, 3.042129610523195, -3.045837428911079, -1.6557461602461372, 0.19487472129834854, -2.6205407912139056},
    {-0.5777604234489695, 2.300913056529846, -1.7592886369322733, -3.6343911978642254, -1.9847786023201806, 3.0196836374902105, 2.87616495182206, -2.8046299884097863, 3.2731874437242414, -3.502214515379007, -2.792951665125726, -2.566134883480122, -1.3749888896009816, -3.487312447576137, 1.3327227017949528, -3.2997165239615507, 1.8682628569192745, 2.8007144375470356, 0.41065606810779637, -2.9784999006297666, -2.8898519681761132, -2.429198118720535, 0.9008140679032175, 2.3138231246491565, -0.04575966049154445, 2.8709563792356194, 1.1038296025386556, 2.853346037744313, -3.3878556173255716, -2.2764855001180315, 0.013374023861201977, -3.185741159259433},
    {-0.18266070309083732, 2.0973952131985154, -1.3068828824076664, -3.3787753690334843, -1.5915587951381256, 3.1649652184713255, 2.4208377460703785, -2.666398878775355, 3.6895211234187673, -3.1261327447024514, -2.7052131218660906, -2.5361709549179716, -0.482377565665372, -3.0514345080137013, 1.8717232336246419, -3.0647827281610884, 2.1030560013650654, 3.088508421204167, 1.309435453501502, -2.625598140017401, -2.536431822910764, -1.9934234067910965, 1.4597573966164157, 2.1881679172340402, 0.08098537700524458, 2.675638882530325, 1.4127338313897395, 3.1553424516508315, -3.0405528254238434, -1.48157738783953, -0.3855071149801731, -3.023257150743778},
    {-0.33692878165311413, 2.2192421825142743, -1.5914843474125064, -3.584568484661768, -2.043078202254547, 3.6255031429977826, 2.850098006699209, -2.8274088932925157, 3.1553621782456576, -3.2776381703180837, -2.872663286126569, -2.5357984131649123, -1.0848847265071588, -3.049063798633501, 2.1918821412541276, -3.0161824275949254, 1.8546019472136372, 3.371996669342271, 0.5232315072414281, -3.141233807168721, -3.2300233190133527, -2.0785432853847094, 1.5967209144810226, 2.59929468377115, 0.07570530007788868, 2.9663900354209405, 0.747197141424996, 3.3688990014051043, -3.154587539557971, -1.911902710681302, 0.27383207996467346, -2.999924821514981},
    {-0.23168573866273315, 2.525021756220643, -1.7609312827552326, -3.6396870663473586, -1.5996994449230784, 3.420890713606679, 2.838104340955772, -2.8102170555509844, 3.165912896760709, -3.2906962629025, -2.902485157232628, -2.225856749377177, -0.9998686234941861, -2.996254846735476, 2.1917363598094903, -3.245206515917004, 1.8520867999697446, 3.093122057093016, 0.893758116468984, -3.054833746959959, -2.414811909230486, -1.9453687594763347, 1.849313652111344, 2.527721142716373, 0.2773337243249336, 2.8416876728332756, 1.4236024855176994, 3.676494099882488, -3.514341391571172, -1.9832348916089249, 0.6689885738145982, -2.8459592471542257},
    {0.039933046991313115, 2.6374044406730994, -1.5526271420702744, -3.6555501064576332, -1.4642915880744702, 3.498241084522835, 3.0847357476217256, -2.7178019259522097, 3.611866013551045, -3.5170195078456796, -2.5947722859932103, -2.471906429020933, -0.6637828922978137, -3.072867137926644, 2.528850008529067, -3.5511366426355493, 2.357631823988723, 3.3806535447476733, 1.145583005466487, -3.325930131750705, -2.6360881234102203, -2.0228193283103884, 1.9084792705773386, 2.9049785484840704, 0.7479133430331159, 3.1841877492233888, 1.5261064390446306, 3.633886755496048, -3.4530515960889154, -1.4743297218669105, 1.0520066799305645, -3.1575254700354076},
    {0.7471418438490509, 2.9370167449953524, -1.184388526919399, -3.6912509892543977, -1.50388357721318, 3.208016608929811, 3.0437990254760634, -2.3947717017236116, 2.9158621581126605, -3.574188313233284, -3.003170693216753, -2.465954252165771, -0.4690032257510993, -2.9533449692816074, 1.8840944954377778, -3.051222907021588, 2.36814276947531, 3.08230004888487, 0.9960089826492331, -3.257608765790073, -2.5098926262941093, -2.217357162385282, 1.5243809422872017, 2.5526987956140768, 0.8449316371754036, 3.167509701716059, 1.7371430855301258, 3.47740990635087, -2.955677178662406, -1.3981211167736356, 0.9594981419605604, -3.04209568491689},
    {0.0908081384272697, 2.718475496452706, -1.1143100635378305, -3.835991085622497, -1.489361529403904, 3.455077893000746, 3.0638771236261158, -3.073577790670324, 3.688578129501977, -3.289626986863475, -2.8388344545854003, -2.5988967971567076, -0.3125335715155159, -3.317860529102263, 2.0427324112701357, -3.3302421143874303, 2.4057016628099865, 3.457531642160775, 1.042852755258179, -3.3485958832639153, -2.9755081865080935, -2.4692307389941965, 1.6822483242936244, 2.8847458505535024, 0.9430568389273667, 2.954476200225078, 1.5458091152282334, 3.7787087328478988, -3.576289981245623, -1.7031300847214126, 0.8809723578514486, -3.1734918389039963},
    {-0.4117424758595763, 2.8020311577477974, -1.8329244645018623, -4.32303267506459, -2.293526586289009, 3.750216817149096, 3.4685915456644976, -3.608020680565884, 3.686718236109331, -4.257851862687685, -3.150216180290407, -2.996878692487756, -1.2162801543836306, -3.977565115692105, 1.974327743453089, -3.815607382678767, 1.8028939358171667, 3.4166693138290816, 0.6129401806185891, -3.887786162921355, -3.4231955493711945, -2.740251734088936, 1.6665602529640535, 2.9982509136926074, 0.4675544310285272, 3.311894207056221, 1.3094312393718395, 3.9530210772907926, -3.6852844908537126, -2.220288459977927, 0.8236283489877071, -3.984355863570071},
    {-0.3945264809031951, 2.9006860242344863, -2.0686812791216345, -4.234441524873349, -2.4656947269266194, 4.09144122616358, 3.2020212482120347, -3.5330221933306527, 3.5023675413237436, -4.021791710550871, -3.227147971848353, -2.9699929351654086, -1.3166092613862745, -3.603577440953542, 2.3044921016584636, -3.6138352607714057, 2.3492685092862375, 3.8083855273046017, 0.633303390901068, -3.520060993676492, -3.194227794538284, -3.0357943309869753, 1.762946234517677, 2.699425602480604, 0.6448963384696224, 3.3663528055210077, 1.4540187974811791, 3.812596869304564, -4.016112867265254, -2.5550332647812755, 0.37276097547571524, -3.729706279496888},
    {-0.0003682141643054723, 3.000414052653756, -1.5661531143811867, -3.7033837321807543, -1.7873498194656325, 3.4588395758573593, 3.2905006384927917, -2.619707636128708, 3.347287643515501, -3.5290325762665082, -2.896159886985629, -2.7060651478712985, -0.5080513147659678, -3.143317187326083, 2.0194892879709463, -3.1867327953636755, 2.5509277010967395, 3.325685233399665, 1.2967139011304494, -3.357885800493285, -2.814502890414596, -2.8502997548014575, 1.6927803007677598, 2.624774136114316, 0.44678797006420684, 3.339092187153813, 1.678579911725533, 3.645830300042622, -3.6823891719363537, -2.0581080036164776, 0.6398630280178917, -3.282586351304887},
    {-0.7211080832468768, 2.799874799887049, -2.155043413845344, -4.444564297806953, -2.550362280981455, 3.7439181893235625, 3.270636226349338, -3.06225614179006, 3.4623762144294945, -4.0385663478399385, -3.707081097896766, -3.231981369198181, -1.1950794490422956, -3.668067132465553, 1.9894229759530964, -3.8706425324580627, 2.321686086186357, 3.3295733544013344, 0.6261655611673228, -3.6227264558374843, -3.692432149810359, -3.231536780774864, 1.6961498164345052, 2.8570881207800434, -0.08995044556562669, 3.4306070808744606, 1.3450843292551096, 3.7598363421896446, -3.7790781304653724, -2.4328404750482298, 0.3210008136350587, -3.797492629201798},
    {-0.027877992209434523, 2.9330711410126784, -2.17313197604759, -4.035478674008007, -2.3917402776843315, 3.876350854178584, 3.4163027655352285, -3.06792957188525, 3.700047538922998, -4.130776964502594, -3.4615760768158337, -3.0341868526841482, -1.1827523505374038, -3.7346821543052737, 2.271494284067821, -3.7465682375072213, 2.6740179238214736, 3.769643081793577, 1.0553603270961338, -3.7274892591272653, -3.3124124367641197, -3.0984063979037026, 1.8599867811539956, 2.936042413991356, 0.34590457052729734, 3.318134160740977, 1.4226181797448205, 3.588711015475704, -3.7674143271643206, -2.3738908917468144, 0.39397320918419493, -3.8476059220449197},
    {-0.6393653500208327, 3.262934857887205, -2.348280747048327, -3.9120385977394365, -2.4657251279691463, 3.814603059672171, 3.3883796901222762, -3.4673247804410234, 3.4598370770435465, -3.865773372410527, -3.3115206792458602, -3.0962060649427663, -1.3921824290231555, -3.6211397340600358, 1.7988239929787917, -3.6906815090468, 2.1405808451777197, 3.5492818142777445, 0.7494258085443903, -3.602878216537659, -3.517303144497265, -3.2755833406002433, 2.0724933065669315, 2.7979875338040343, 0.023002182222563044, 3.4049576898515315, 1.139943448696977, 3.6413324687871977, -3.7329856642174377, -2.4766836946987185, 0.5274854356247445, -3.637725761620363},
    {-0.9117332615868561, 2.8057512654016428, -2.2403763210955496, -3.9528443980860026, -2.077118643174521, 3.643673903441422, 3.1041594745956593, -3.6005485597431495, 3.5661073925645876, -3.954333258333974, -3.553234598751272, -3.3076344309364374, -1.5322680305673566, -3.8160773258180885, 1.9667513424767114, -3.545670188432111, 1.9298877271891117, 3.551885572604901, 0.6350177229437313, -3.6883639505950705, -3.421001856440202, -3.251469048345418, 1.5352802444185598, 2.5422752909209394, -0.299151942217016, 3.2412732507504627, 1.4839527963851658, 3.629046232011497, -4.126027405715511, -2.6221700210326024, 0.3686748782065763, -3.8849051679670876},
    {-0.678514084850459, 2.627094494219298, -2.582140631648825, -3.917210645426925, -2.561385626084889, 3.6275535702146144, 3.019281163311547, -3.662252790146201, 3.8297145177306713, -3.882824194693496, -3.431940399871981, -3.4525739419902988, -1.53482898552655, -3.650901821844623, 1.8710550347454962, -3.8462737635069146, 2.16662175641, 3.3986162352844302, 0.3996863869919193, -3.571164512382743, -3.4251666602490816, -3.290607573948683, 1.8395571784775409, 2.299364103948915, -0.06530084765131709, 3.290630667424034, 1.101382822038846, 3.7192671643919555, -3.987579311529709, -2.785440590824374, 0.5991543974822164, -3.6904185557456346},
    {-3.0396756841855788, 0.799977803439034, -2.7054740040389795, -1.5420586953630802, -2.6384953492185725, -0.663030876293843, 1.1242700198963023, -1.3435384801354882, -1.3601170919502104, -1.5159815213835726, -1.2883153987478655, -2.266346190534953, -2.7614720880898878, -1.6899456077222497, -2.1713820501054752, -2.406614102645301, -2.381392246730524, -1.995530388294864, -3.2688034211564303, -2.1215758194765546, -2.5099018498865986, -1.391929866002565, 1.2600640184236636, 0.9511336848127734, -2.6088283035210926, 0.9479613078929624, -2.7822748566305466, -0.6326759605392149, -1.8803461958356587, -2.500524629112479, 1.7765953429531436, -2.222271504509107},
    {-1.2812172125424441, 0.4136236555308296, -1.4688902814011813, -0.9323345561958412, -1.6050144179044041, 0.03108323841034742, 0.18589928276153023, -1.8119972532082465, -0.48249272640186514, -1.7783214150884286, -1.8970136925505547, -1.5549576772961125, -1.6950040669358628, -1.5000657765069692, -2.1743268632567907, -1.1386325551600918, -1.425221797778219, -1.170603882640353, -1.5346949978638855, -1.1753656061880529, -1.4766972276898864, -1.8637502123461296, 1.1405325385245504, 0.09431696653614285, -1.766797449547831, 0.0953630968459028, -1.4332441829614597, -1.1394858896943767, -1.4498300774365471, -1.0795944264775497, 0.24621863945876046, -1.566600048971356},
    {-2.73468088979488, -1.2999900574561947, -2.700223025894612, -0.8016361613216166, -2.802696043789677, -1.829872871600806, -1.0615018239435599, -1.947765045078119, -0.03485907260605777, -1.6327172873081912, -2.29619791199875, -2.4986292282787788, -2.443208283156476, -1.7743096984394453, -2.9887288197098285, -2.073736104294859, -2.5433231048377514, -2.7571497800558835, -3.481127645261861, -2.0717053861098256, -1.7913396934027466, -2.0744053070764834, -0.5179187684544306, -1.240640903657271, -3.0704832142202134, -1.2104570494755913, -3.6068799520156367, -2.1854535935342123, -2.012092066573457, -2.4946000781437, -0.5046458148237509, -1.8124309077772793},
    {-2.6026920119505315, -0.47545614942038317, -2.425651165320281, -1.4028849469472309, -2.267844384901876, -0.8889200427358656, -0.287755388866382, -1.3934865282907782, 0.14669965368011528, -1.2986393780544967, -1.2372282319980838, -1.9792059903907004, -2.3987761407732733, -1.7572878317199216, -1.9313781078866945, -2.0530530751883944, -2.083571330038699, -1.777165481313193, -2.553555839921386, -2.2953691964776692, -2.229656994544047, -1.94990440032468, 0.06490997415807657, -0.3625097434915948, -2.4977773085409085, -0.6064051012774127, -2.194041378817408, -1.399680790324187, -1.3129141520248873, -2.1871016408517714, 0.5623668052204247, -2.103993323685265},
    {-1.7465978607969266, -1.8815253000308212, -1.7605738969928046, -1.2585695666202363, -1.3564854958675194, -1.9730110747152543, -1.8323427550965379, -2.201274384520919, 1.1673768116229548, -1.8208714246425728, -2.6573365181801334, -2.1222512700800906, -1.2727257888008374, -1.8225479485804832, -2.3813419252061423, -1.4677567979245942, -1.6645561308526617, -2.106660536603348, -1.1381069374286836, -1.9454579367091327, -1.7218916485700988, -2.753780571508218, -1.4695750256686584, -1.68216413064912, -1.6768637590280804, -1.6111138085964571, -1.638554800756254, -2.6418966721475954, -1.7856340100564558, -1.5179068579613837, -1.8332254837111412, -2.1951197692231226},
    {-1.09941663360074, -1.504937120671873, -1.2576301166978752, -1.1084968031754758, -0.952206950176876, -1.276203249091257, -1.382395648658416, -2.208260820522068, 0.9553069634692506, -1.9595903544967375, -2.0882894032794654, -1.4552280873844923, -1.1778113794693266, -1.5031573772241504, -2.072998931285502, -1.3239906128776868, -1.4708069560808756, -1.8797118673137514, -1.2063851142723439, -1.4998878861565164, -1.1548961918230056, -2.9001456957731158, -1.2322212308033014, -1.3753138131203284, -1.7523690637779001, -0.8695398632869655, -1.3670986487895571, -1.5573920081722663, -1.1429356126398729, -1.4584028579146202, -1.2061764289789154, -1.6877514213150127},
    {-1.5546368600473697, -1.3721245069888448, -1.5268292702467423, -1.7475805165947496, -1.5998174604550828, -2.036123135273987, -1.576040454397051, -3.059545229744487, 0.5121982604198996, -2.493539559455842, -2.351976452079089, -2.140753149554961, -1.6291782818223386, -2.214830426805342, -2.4346696316019028, -1.3084325500539744, -1.84547043580663, -2.1716081448094755, -1.5932316482402222, -1.7923255486625422, -1.5107051562578528, -2.8210283599208195, -1.506879130136825, -1.2955179825427918, -2.2200790043911622, -1.2000008584087154, -2.2238523141151396, -1.645854616187837, -1.9438688708735081, -1.989730632947375, -1.4919568754753278, -2.154271423133039},
    {-1.6710382674103423, -1.7054902575467892, -1.231419648086402, -1.325388453855016, -1.6706707829431626, -1.8330004863896094, -1.2356362104031333, -2.5060617757796417, 0.4161039242563116, -1.6296969342319985, -2.122883303469681, -1.8110852871976817, -1.3968862559845705, -1.538734275848872, -2.3831477032306734, -1.258506512468707, -2.1266020677998134, -1.8635956533288696, -1.453970221132876, -1.1002189401759281, -1.343576753482253, -2.472153927678451, -1.076546990227896, -1.228680879150613, -2.172829404244762, -1.5307132971027488, -2.155172041607519, -2.2955318527663886, -1.3259851927911366, -1.740796498876554, -1.1997914399248202, -1.708364298894999},
    {-1.757710946573364, -1.9288840966030114, -1.5638993603120794, -1.1190944711356121, -1.8720709711879073, -1.7325581554734863, -2.1320173426949993, -1.9755157768952727, 0.8182024259450394, -1.8948511975116027, -2.2347292187936802, -2.481475597083389, -1.702218243182328, -1.7370286005596303, -2.6092543455247394, -1.5704494024241293, -1.8557207818940349, -1.865163682664815, -1.607145720115733, -1.399298210603584, -1.6129393084760733, -2.5559231925559938, -1.3552383922541018, -1.82624246196821, -2.1535383593707556, -1.580530673121371, -1.998285311319284, -1.8059321240815203, -1.461525611475043, -1.8829318173799423, -1.5425619378817759, -2.229592031084752},
    {-1.9703125793752472, -2.3619061403703054, -1.7097794926322074, -0.9102514453749044, -1.9235433807316265, -2.5119118799219935, -2.1942225492492775, -2.251737240964101, 0.897849011124968, -1.7072362807493828, -2.1431377062793553, -2.190360409456826, -1.941460578003625, -1.7004845030439462, -2.5495227363312685, -1.5481422690122928, -1.8614763284843348, -2.468779318945837, -1.8444907992095592, -1.7093824167584506, -1.7394930439839422, -2.717057281334048, -1.7808307508145846, -2.353438943597355, -2.52887494649808, -2.1647996127461897, -2.1603046421712824, -2.624308925215464, -1.8612219986493777, -2.1838107308343684, -1.2251030564905727, -1.9451569500759984},
    {-2.288359107643515, -1.0235513196414816, -2.5443207245374286, -1.9339409271570231, -2.8107043096928868, -1.4118682120858816, -0.6479722283258635, -2.2596179727724746, 0.4294125414427407, -2.139539808965959, -2.2285467258938736, -2.753254619371102, -2.2187974032261106, -2.187703721031238, -2.1469927138916183, -2.2944840228158476, -2.2984467059899076, -1.9894520745905768, -2.0707181366813976, -2.043265584446553, -2.506688602678077, -2.2735699133405602, -0.8182194060156612, -0.8174367897476865, -2.9395107698931557, -0.7437548208781155, -2.904355446522245, -2.0980224274190102, -2.4502842467187653, -2.456683914206121, -0.024597781852445166, -2.4851160427505463},
    {-2.272094048752078, -1.6845701891268288, -2.6243592830676947, -1.3412193543304742, -2.483059124723473, -2.372292220430368, -1.4742560845334205, -3.009820501194433, 0.5249909687693316, -1.975732833243251, -2.794219935110397, -2.6011884857359995, -2.418200652706473, -2.2006795593855375, -2.8833834180715945, -2.2933428046784448, -2.5900614591825897, -3.092248469450834, -2.146166617576485, -1.951786652449532, -2.6855181016480643, -2.556044961905658, -1.2405296477623386, -1.5395810077712333, -2.76096554605092, -1.7736392514722799, -2.9988766686935557, -2.4905199295639475, -2.292934837422646, -2.6710923581592745, -0.4616987822163824, -2.566179277112729},
    {-2.2998465211767845, -1.5761607430865605, -2.322008894822764, -1.149731734529699, -2.0686576283732214, -2.1392782355160125, -1.6607165179083525, -2.6894169140998434, 0.2705301308993297, -1.7869448183682553, -2.6053688671457818, -2.6387173545987976, -1.9975223051211675, -2.3055120256763386, -2.835218338652217, -1.967937126195585, -2.6057492694119855, -2.7299425863985842, -2.4682310588762033, -2.1642467589853873, -2.1833160673808636, -2.978200361828732, -1.6346291358769554, -1.616756452946305, -3.3106211073816803, -1.9872871438982223, -2.8253628045052306, -2.6536548633523505, -1.8644620640528589, -2.53826793883759, -1.180671446018517, -2.6783982682224083},
    {-2.9418005298720473, -1.3973975465071566, -2.7384455467223976, -1.4198731479396822, -2.285154096955436, -2.079424713700985, -0.9101460231717566, -2.8288062022651217, 0.25988287819493633, -2.203759873049217, -2.244470380070473, -2.7687302387093196, -2.3637687243882275, -2.2588730688006735, -3.3836750301289613, -2.0224062015626054, -2.8251589402709136, -2.8880595569275584, -2.729986134893477, -2.169726326175608, -2.163810161518622, -2.9148570791511488, -0.7326131678818857, -1.4707651077552333, -3.0514916410617365, -1.56920137151264, -2.94841598219178, -2.9605008561726436, -2.2393321865710525, -2.5604699459702602, -0.8151549314591017, -2.494800867762345},
    {-2.804455654221789, -1.823043314055457, -2.9545152258053884, -1.8175567381741777, -2.732768398368246, -2.1649189825779462, -1.4644436668783578, -3.055070546300018, 0.820168361512063, -2.738275237628168, -2.527326781562856, -3.079952252367529, -2.3646692398064735, -2.310765968125436, -3.3008625408683754, -2.411797914413534, -3.164189740074719, -2.97884170640234, -2.9451505217059704, -2.506057275874142, -2.6956282365409643, -2.8783061976842235, -0.6851405353250979, -2.1542965160524234, -3.538097360532692, -1.9300720229201644, -3.4564353242827406, -2.810109820885626, -2.735721779276695, -2.6819176761896633, -0.7056727665865956, -2.7149127166793567},
    {-3.1693151704324487, -0.5725983623403573, -2.8637120842963295, -1.5540002611740336, -2.742918886566619, -0.7837033211766895, -0.32973589860870367, -2.845430748622988, 0.6980867766863559, -2.719413006297278, -2.2081929069189155, -3.023974410763728, -2.423953828401634, -2.7813044391378585, -2.865603683587512, -2.73023291551582, -3.0548462680913504, -2.159877762314141, -2.9740330016856262, -2.3622727411317905, -2.8421460647166077, -2.729002231114765, 0.2514047976023576, -0.4470126517086319, -3.378282822767375, -0.9191948894670059, -3.483272422108303, -2.376991006597155, -2.667343075227276, -3.1947052609115776, 0.10915481781614905, -2.471038320587703},
    {-3.0602239905073816, 0.1622664959796798, -2.8445092805069767, -0.9346146635308729, -2.7669538582327724, -1.117434857279916, 0.3287374870834807, -2.672051716249475, 1.3108880918432297, -2.085367222134385, -2.2592113676058534, -3.008781707244696, -2.5514728873522006, -2.248798783394919, -3.321924281161732, -1.8233634861383015, -3.0211205300928583, -2.6636739567517496, -3.2499511054847896, -1.9013312324008382, -2.350244841471232, -2.5352355205060935, 1.0712981602350427, 0.18937174727065922, -3.2544640379384875, -0.7560255884401047, -3.6432702302804363, -2.2613044784484138, -1.9226220744511842, -3.1687500460756164, 0.795613768302696, -2.5573014894043595},
    {-3.347797863481984, -0.16833043972716105, -3.035907616330903, -1.4013497581796779, -3.1976467525404644, -1.4929256413438856, -0.2546804346641812, -2.8163533174183133, 0.895490848783198, -2.562388987270946, -2.8552528881295003, -3.372040656071629, -2.9108046386650255, -2.7099404068019397, -3.6935815111865264, -2.5441668414600787, -2.939846093051447, -2.778277888297127, -2.850991327527634, -2.3040957545307257, -2.4753565362881482, -3.2482533442788477, 0.9152450790056561, -0.4689014752361956, -3.6151001170031365, -0.9975635028069867, -3.3265250439404745, -2.3028889896145137, -2.2503802772895334, -3.382138371612908, 0.5079617882445807, -3.0170033388805724},
    {-3.704998624505183, 0.05602553439807494, -3.5293779268284666, -1.742301929565297, -3.706928372133026, -1.5544543535215098, -0.15667759571502538, -3.022057685003044, 0.8223354863103474, -2.727166941322904, -2.5995968581102016, -3.2821744894486957, -3.223598484295571, -2.993171231206092, -3.2632847172026884, -2.835946996942014, -3.2453442646999635, -2.920927858130917, -3.221361791231433, -2.520697100367893, -3.0752642639444834, -2.823019519570966, 0.7242591063402781, -0.7294254998607325, -3.6379318992636622, -0.6194490079852027, -3.154257021187905, -2.6192755876304012, -3.0275597856571483, -3.808214055565023, 0.4305592854794882, -2.7703268542389328},
    {-3.6370149845712576, -0.6710028360623422, -3.4426615764712305, -1.8633113997695574, -3.3523718388462767, -2.05898865764102, -0.6947998009224057, -3.2880507857175236, -0.04207614454637262, -3.1657851358186178, -2.8505995110157336, -3.3133845806094815, -3.424924715879117, -3.3760559601595603, -3.6097749746343935, -2.7807591576145843, -3.7643747633307942, -3.5130126444446432, -3.3352434599700764, -2.7778924440965085, -3.249241218586615, -3.321692887604125, -0.12589991593782635, -0.9751872641530805, -3.751142761075052, -1.0811157856871774, -3.8357571481461252, -3.1170629094290034, -3.07220990238065, -3.438660866816735, -0.2770549195412867, -3.2818397687139553},
    {-3.866737568406981, -0.13673223807756776, -3.7934565625152827, -1.5440470680280334, -3.4819015454598037, -1.90254540312156, -0.4035596077655854, -3.4221287380369128, 0.9183727671381394, -2.8200722936195577, -3.1344062777756743, -3.4174972070145797, -3.0158716675646313, -2.844097709769027, -3.898322844285853, -2.72973922594905, -3.6126480793543077, -3.0780943971086923, -3.8637472485070847, -2.5963170296749487, -3.1573763445534513, -3.6174526285073867, 0.6876265547812858, -0.09926526208132105, -3.9578811103241573, -0.8523428817792528, -3.9244811341598753, -2.6458174164559627, -2.8208906304308683, -3.337206407555959, 0.5775544606875205, -3.287166297047251},
    {-4.433281165382236, 0.21424594762476795, -4.138667322954305, -1.7438313454502647, -4.379782359439831, -1.458295371116389, 0.7722374109726403, -3.50373449043628, 0.9108739132367487, -3.384943341209598, -3.100083419451654, -4.409414517972073, -3.6010662929395916, -3.3783474465645424, -4.8341596235443065, -3.212319749583675, -4.2438988954848345, -3.6241346756319044, -4.818882306152531, -3.604492758309486, -3.516855503465026, -3.5389550466456745, 1.9866948810450793, 0.3921390981877181, -4.828540781803325, -0.4845762808900425, -4.633653732973392, -2.831006789777409, -3.2912771126056253, -4.132593483270551, 1.6838817973988458, -3.1379907537109},
    {-4.928972075839773, 1.96520015368073, -4.8783891531615735, -1.816699179142787, -4.740367110978801, -0.28985063332975514, 2.3022101526875254, -3.1031494107354303, 1.0790442590772658, -3.2764592779006105, -1.8988086485375542, -3.837091406670329, -4.283776795374525, -3.3197108920176266, -4.505659949384603, -3.4047649310611985, -4.292244354576521, -3.335855751570455, -5.092183943262292, -3.431785347493512, -3.7526307479429866, -2.8185924827758666, 3.7453065646186534, 1.699193460329741, -5.0293866328812875, 0.9639217149221253, -4.95831935716379, -2.0865286908617047, -3.3610457331047754, -4.415499987459394, 3.293474227015571, -3.3070047805357317},
    {-4.81584795916618, 1.089887604161197, -4.489877739730004, -1.9783206988164335, -4.455922894380617, -1.398429403163798, 1.1793016022808582, -3.506666595795117, 0.6303496241867476, -3.3133746782548665, -2.765110696466656, -4.143200473279258, -4.129716856872433, -3.3115744690626117, -4.639413655447927, -3.6491872041483084, -4.273126659483315, -3.2863180158460916, -4.731684620021436, -3.2347802262202934, -3.3957088272342446, -3.6352678436971217, 2.597447167937496, 0.7982709126993948, -4.833992036216749, -0.22154161063406458, -4.865902698666856, -2.6914714123182724, -3.492672088147479, -4.031446689500213, 2.2103183462512574, -3.2758472568195325},
    {-4.608120453958186, -0.7822964246383262, -3.9415259926493724, -2.2763046849203916, -4.3713322393899725, -2.46284601193431, -0.5045327558658292, -3.8435864349540734, 0.5664752585446728, -3.4419416185030656, -3.218898235132476, -4.415246836234074, -3.916295675128947, -3.417159483792824, -4.4947641582678175, -3.549523114379868, -3.9616797056409587, -3.4284855910157255, -4.304559645377506, -3.1473392942214464, -3.699688586877527, -4.121199924910176, 0.28460253588865214, -0.9402457253992407, -4.3957640228424335, -1.5517351206294543, -4.524545786339941, -3.4666458286704644, -3.8608881068208776, -3.924493380789369, 0.23035200661693384, -3.693491439588959},
    {-4.8353224223072715, 0.655730508539, -4.508656867683602, -2.2758597765750506, -4.603402159882202, -1.0003489984872929, 0.6891002665817579, -3.6812196554763665, 0.628990961478647, -3.599327525036937, -3.0946630104080612, -4.025052620681422, -4.212637547920272, -3.4889119091775456, -4.191765379655067, -4.0055119502171195, -4.478878528121321, -3.742693088251442, -5.067758980120125, -3.4877635539812957, -3.887126440485152, -3.4985607668921137, 1.9389603320921993, 0.028858585786595285, -4.890961367182914, -0.3419843656978158, -4.90924885340801, -2.657602576023635, -3.6477889185950887, -4.563842912218911, 1.7287124141146912, -3.6772997491093076},
    {-5.097082598383446, 0.31006071874369, -4.823614291186696, -2.2113705695406067, -4.578105695684424, -1.8501403054268075, 0.2730936912398466, -3.6823882099048504, -0.17290090352228274, -3.415323679564871, -3.005224822422853, -4.474473991886456, -4.53171444673317, -3.6852486606601196, -4.758723108988351, -3.687920453949917, -4.465675006894509, -3.7638552747795813, -4.962408101921091, -3.7225448210552265, -3.8964019241495866, -3.743024723726511, 1.8389637481423387, -0.26257146729922237, -4.956231223183132, -0.5274633144983695, -5.125744542328226, -3.1752556723574825, -3.5020967467180446, -4.437872276965202, 2.0965844018618123, -3.7658737673770024},
    {-4.940876160184766, 0.007661038946038802, -4.768687455996594, -2.3449750684194433, -4.20246457589932, -1.6324171155149862, 0.17932247681912833, -3.7347509287350906, 0.05414695038584941, -3.155552881448169, -2.930614603572513, -4.354813197162087, -4.443170241963419, -3.625857932015596, -4.401335781770226, -3.9050500780653654, -4.714980449701885, -3.7581573160101476, -4.831256507072109, -3.8506575675286774, -3.960690350803483, -3.5663090172170286, 1.6404623057635224, -0.05077326057790711, -5.026656742441671, -0.7387463445499425, -4.971841015521624, -3.062780813937054, -3.6872891956130514, -4.43523177401113, 1.6418320610305464, -3.867121952579351},
    {-5.1590103909899785, 0.7377588863083426, -4.834056310217642, -2.2438261244025766, -4.7485302666977365, -1.5525326652722733, 0.4671380116322955, -3.593231901364711, 0.306692396033706, -3.942636662745235, -3.016167024697614, -4.468869022220403, -4.467807274503332, -3.972506146523239, -4.8118196905794015, -3.844941181913246, -4.728713893800216, -3.600827246829236, -4.898682257326181, -3.633752655296606, -3.960491461278593, -3.1400559200368767, 2.1069727274830923, -0.005723962957855881, -5.249669228917472, -0.45491981890460764, -5.0211582042767775, -3.2866232462443445, -3.619736802213906, -4.737157448726243, 2.0947024302855017, -3.7061329943054364},
    {-5.2585065896189365, 1.8160923824364934, -4.651928303047666, -1.6265703971571068, -4.62614124626508, -0.7096764304081533, 1.6541618165071417, -3.1376342718014087, 0.4602368263349539, -3.4487804046952433, -2.4660923496057308, -4.264625785466593, -4.470047010087824, -3.53274772347101, -4.472712005922113, -3.3777799700807467, -4.558485426534749, -3.3952872812782617, -4.945083503243273, -3.261714749153338, -3.729959484987242, -3.237054160175014, 3.079247505987486, 1.4771730485544003, -5.092152420197992, 0.7514411565831602, -5.1115456175661835, -2.6759306581751185, -3.166397972161665, -4.375760066045364, 3.086667503980722, -3.25504026187695}
};

static const float b1[32] = {5.811961588828108, 6.377221556389687, 5.856599071566212, 6.191480933490207, 5.906505487123902, 6.221088334266988, 6.27039193258432, 6.081366394531369, 6.671828429885869, 6.11627063665063, 6.216766760127032, 5.8989048448575625, 5.638077440628615, 5.996168362576376, 5.960329505418577, 6.052037403240274, 5.908839217235068, 6.070268800883614, 5.875395102908718, 6.117149605666504, 6.087659443253719, 6.0661139624656, 6.448831119578437, 6.12075690167159, 5.858781905636759, 6.138238990846381, 6.014351628895869, 6.050740473751164, 6.099653350611289, 5.580542635947163, 6.516345046392031, 5.9725858632238875};

static const float w2[32][16] = {
    {5.1867579117072475, 5.5964247798500235, 5.263951177367409, 5.152545224182593, 5.106805169757937, 4.721500779328217, 5.048257990145755, 5.191071362975187, -0.2722839951510291, 4.601336545435849, 5.090399887169767, 5.093955567972139, 5.292223776749112, 5.465085647862755, 3.862840652884012, 5.14329388033685},
    {5.912902570975021, 5.495777700838377, 5.727602337888275, 5.414616683735732, 5.634827331085256, 5.253050797191071, 5.622991679583364, 5.7883880373116785, -0.09003398860378346, 5.159648655513472, 5.707165862782325, 4.674457068600396, 5.816116173791295, 5.460445344222437, 4.806462893041879, 5.276857790769216},
    {5.153259113390192, 4.9254672423471835, 4.921552860635311, 5.45157916181695, 5.438009964292743, 4.724701786965907, 5.0919104482768, 4.763481704918874, 0.12561152459505462, 5.309500746078228, 5.266079184678391, 4.9299730395299175, 5.277546758708461, 5.040912408610739, 4.5496154567690255, 5.392089584799398},
    {5.523683074953517, 5.153662360797917, 5.303994563860886, 4.6970984683343024, 4.808904587924052, 4.798542254933365, 6.12234217568377, 5.113631778980087, 0.47424683214104374, 4.486983766684169, 5.777909309597785, 5.001521323198499, 5.725046487960932, 5.161676946510873, 5.175205849162634, 5.2684087557200066},
    {5.609002179228961, 5.5206733317741445, 4.9994718703102015, 4.860531420194774, 4.994482344485924, 4.8221357854674975, 5.236914711363407, 5.033322401634233, -0.5133773184819714, 4.877815556482948, 5.07294745847899, 4.250368198389203, 5.228974867970538, 5.013253687625457, 4.216850830880088, 4.968547773673746},
    {5.56644265087783, 5.5125892253001005, 5.43279520978157, 5.537874175996837, 5.568803544574349, 5.11661464333571, 5.50227207297467, 5.456336848807396, 0.2931584508581109, 4.758863060830093, 6.005180260574573, 5.015386412378688, 5.2638655460885975, 5.414678617528381, 5.001818225174095, 5.751758821686815},
    {5.488477338482299, 6.124166064729286, 5.351039702600992, 5.734310331464568, 5.791445521329538, 5.242506024632964, 5.635551136048975, 5.7737789065940115, 0.4694799002666086, 5.013377149544572, 5.452449889327299, 5.021149361526052, 5.598581839284862, 5.655301870904686, 5.493554864445774, 5.295522529089774},
    {5.889573134810456, 5.850741532032545, 5.227360550722326, 5.715085861340895, 5.561821668434655, 5.014401174862616, 5.786754589760506, 5.546378386529778, 0.6557539753323424, 5.232824775484587, 5.561634938498567, 5.1133641689098095, 5.408382391299183, 5.87982704572578, 4.737516746280751, 5.318196756288843},
    {5.865717738951933, 5.514329970025822, 5.2841001870726245, 5.683419503372792, 5.876171792334363, 5.497769262107726, 5.846787824138683, 5.982706898967212, 0.17446566569623587, 5.688028387346964, 6.09949865611182, 5.169965528142984, 5.739557473177452, 5.168459202702224, 5.095916296396789, 5.403995280621967},
    {5.3016925996311794, 5.631473534804378, 5.298759679124479, 5.022251388185163, 5.110533793159005, 5.15609183835947, 5.759609716320346, 5.072714797071497, 0.48051393278244064, 5.026522387213944, 4.994849795377218, 5.115004874547347, 5.595786361619509, 4.9940788185111495, 4.649099939954096, 5.458173069523904},
    {5.557042410740084, 5.45062887049523, 5.819340730651722, 5.826625205328469, 6.0026605347425015, 5.153779290003534, 5.492305365297938, 5.719475901643415, -0.056485565453160955, 5.550373226270693, 5.3662435521388385, 5.049521757690343, 5.424882992311515, 5.307918626074337, 5.004210791187692, 5.707760958949174},
    {5.372870633948051, 5.248776287205663, 5.002235756671638, 5.67334424267359, 5.156097396528815, 5.31376950625202, 5.705045641782213, 5.256271204385212, 0.6488198069725581, 5.212250378671584, 5.438885694627616, 5.051657158422201, 5.076594750889574, 5.142407277359744, 4.579068239003163, 5.493971076364804},
    {5.246380200066097, 5.020762355307404, 5.472615370608788, 5.121621141206557, 5.051187876114292, 5.169375172097781, 5.636514514064461, 5.081265185604975, 0.15565746767035818, 4.966638799680693, 4.958866375520545, 5.481049904094213, 5.252290773630406, 4.974800498263175, 5.202280992488181, 5.48956087811106},
    {5.373440476814322, 5.092106840570461, 5.293294272730877, 5.1811576296829855, 5.210481216953902, 5.137384462437957, 5.542088091070967, 5.5562958910723, 0.10518829907976067, 5.1781153074386035, 5.095278853040286, 4.919631042643802, 5.066497320290575, 5.036842305327426, 4.898011005519039, 5.500414469348049},
    {5.39657327859029, 5.368879916742135, 5.687898519628407, 5.67303265701663, 5.546609472308006, 4.900987725717637, 5.7506927892263695, 5.804771318346693, 0.060778970385299745, 5.832537077056434, 5.41310020692804, 5.091915190216283, 5.264959245874075, 5.42452360778171, 4.686972528097656, 5.490272578304265},
    {5.039446319582693, 5.523580644528759, 5.717454639298427, 5.4290367585289925, 5.247632194290335, 4.695532521393426, 5.222760102167086, 4.941189760080995, 0.06241119460844233, 5.1056910349628195, 5.545484653174824, 5.062788221178439, 5.230521700363386, 5.34976580465544, 4.6481750715236165, 5.088016377261845},
    {5.716083405366579, 5.069294190592719, 5.336262179112842, 5.31066597955436, 5.412395143523255, 5.07883856172361, 5.649751755769453, 5.061819863697317, 0.4436663351193755, 5.211769407701809, 5.70038800693867, 5.748997888968514, 5.550735923833738, 5.234964359593986, 5.129224241985901, 5.2923785355197},
    {5.592575794480346, 5.920759713119927, 5.370654561653287, 5.560143128226631, 5.683801091703735, 5.274728539086141, 5.962144727021836, 5.58836055792418, -0.4638395860723076, 5.054063627100592, 5.214532205196802, 5.422056961153469, 5.622543954937415, 5.448427760993376, 5.002553662627312, 5.399621107111555},
    {5.731539185623773, 5.319310943967741, 5.528070295043775, 5.0953920445895, 5.229309385830271, 4.684733986756934, 4.993346199771271, 5.425752091466723, 0.22972524016450724, 4.858995207700197, 5.560760916361598, 4.461643059378147, 5.349775104039093, 4.962627428898273, 4.428507776174214, 5.076587729827597},
    {5.2337778754691415, 5.561809613071656, 5.310372406876011, 5.048774864113912, 5.20386500965285, 5.191758208155174, 5.572980815926447, 5.248523050724984, 0.012358092790894396, 4.703802841290589, 4.983229445910714, 4.843275615263114, 5.433178715958507, 5.212755148843447, 4.095196801470788, 5.359764201245287},
    {5.598087329781678, 4.869175630402016, 5.024476569887825, 4.793563311334486, 5.424199675898491, 4.930998180777797, 5.099184660587062, 5.302683135691609, 0.5247357323963417, 4.782873431714691, 5.108469190526183, 4.66612622177808, 5.4329272907981085, 5.228209874758514, 4.951593010168398, 5.905378530878937},
    {5.840624999927368, 5.459217943885531, 5.767156226914067, 5.6768207343865775, 5.582982713015642, 4.970022226686698, 5.7247416565632605, 5.499780471499774, -0.5794592522401613, 5.196889301259415, 5.587393595795409, 5.402271108190404, 5.3564034668752925, 5.291854621263952, 4.858829628228375, 5.8663855998064465},
    {6.3130312730529035, 5.506147893375662, 5.622361310266712, 5.8911081534901495, 5.617152328920135, 5.260071108266429, 5.833397342893634, 6.04506804430702, 0.14793834260547697, 5.509050955207255, 5.887339645453345, 5.745694718998346, 6.080842934800914, 5.606388425097673, 5.447592651558908, 6.16722156290868},
    {5.635045896600684, 5.438521778410878, 5.666148794776561, 5.724145946288952, 5.7202599459663075, 4.862899255893851, 5.512466974072811, 5.660913234243543, 0.17524852747729203, 5.446064392921491, 4.928368952440859, 5.2054236064657315, 5.7081905988398525, 5.309133262709434, 4.78222010995862, 5.736339963407094},
    {5.6396334906892, 5.101374699517336, 5.081607935537776, 5.013083628862438, 5.734146470947174, 4.780198715954353, 5.690687387036499, 5.313338514227382, -0.3376353365205911, 5.167650828884517, 5.225473991876341, 4.68621044486, 5.310857250231088, 5.110560988538626, 4.860745647752496, 5.424449787601328},
    {5.900109889600527, 5.72798188002764, 5.8623630382445855, 5.887270733589238, 5.481819417216763, 4.672856902216127, 5.584687888483046, 5.634423306722855, -0.012236266135017711, 4.960003218900324, 5.774367904531358, 5.8151383467323114, 6.0210390000770575, 5.842185314023529, 4.549561498468603, 5.273092869841677},
    {5.046304637834793, 5.482243046625739, 5.257546493756843, 4.991929684011477, 5.706338748125166, 4.897729577615851, 5.357771281183302, 5.142510515602643, 0.0997174025188197, 4.584210841034428, 5.298835506822915, 4.72479097435594, 5.370611468954805, 4.783190437787966, 4.63807160137916, 5.074968880791216},
    {5.723986290482766, 5.910028150055607, 5.481999577150259, 5.710063254004028, 5.913591354397094, 5.63143897059097, 5.881149121115492, 5.325104096647332, -0.11383744739369078, 5.4327475663384135, 5.261674871095929, 5.580212028322748, 5.599133294582352, 5.320648756160418, 5.1418801561991305, 5.646898787912404},
    {5.329503428226405, 5.358570033125198, 5.904897705659758, 5.235239329141194, 5.271063243247344, 4.993709454538082, 5.606628837896783, 5.567679944242808, 0.1970623427847558, 5.274678635788774, 5.355746172911204, 4.725159268283881, 5.376075284647865, 5.02803934262951, 4.283733424286166, 5.563774424934692},
    {5.436023253841791, 5.196130275477202, 4.9995614001024755, 5.2691366161748485, 4.95002865772893, 4.990775059335712, 5.153882828172636, 4.964881504102447, -0.00615507062304254, 4.854656314437958, 5.17242808176048, 5.106402898719851, 4.98503612829621, 5.05084451866587, 4.596831134987128, 4.878551689139459},
    {6.288804966746931, 6.214985873792022, 5.678851396182286, 5.515196150690882, 5.322962202321878, 5.592441889840137, 5.985247966455986, 5.801387295071555, 0.322931045569025, 5.539065168905417, 5.868727055324767, 5.235897264437413, 5.834453818051574, 5.8292771918162725, 5.334178140368013, 6.059849370958022},
    {5.293569362365251, 5.225967856400136, 5.311376739615616, 5.321443367075952, 5.400253356436511, 5.532011873013936, 5.578620821124133, 5.752733474833336, 0.36195286471808913, 4.892974987476859, 5.331043149862159, 5.14833785958894, 5.417856762524504, 5.15090542423848, 5.183454478731985, 5.192589290629263}
};

static const float b2[16] = {5.868719459017076, 5.699053287897137, 5.834260977745343, 5.783064123038499, 5.800406653622573, 5.829921176648613, 5.8703704016438305, 5.853162631823603, 0.37764202030162997, 5.813311717497866, 5.726665308503998, 5.673876551799685, 5.78064894905484, 5.807496638622086, 5.9357002196498145, 5.840827592044899};

static const float w3[16][12] = {
    {-3.949871453466165, -3.2722055091906515, -4.354032016035793, -4.076138785138705, -3.7205380338497664, -4.172063654409451, -4.240778336850038, -3.9608892178282806, -3.7315970085054153, -3.8352898491157608, -3.752920350597001, -3.9853141384997763},
    {-3.9586587018835067, -3.9950998368831754, -4.021780170036274, -4.041879531240761, -4.379731555619574, -3.2236488255029774, -3.3851493620882973, -3.2239295892358752, -4.720735136822487, -3.8936159975986104, -3.3710849849283417, -3.3219024299424404},
    {-3.892336756057178, -4.532964122564993, -3.1909126483477963, -4.11155464207532, -3.8523189896896346, -3.955026345455163, -4.132322251566759, -4.354588969036269, -4.261104150470853, -3.877799646892683, -4.061524618333537, -3.6945860396545296},
    {-3.7466126540107925, -3.4278731748768307, -4.363870670378505, -3.5598304188391725, -3.9256308654626904, -4.377362702691964, -3.859399466894055, -3.4805174313111125, -3.9391103375770307, -3.9630631795899776, -4.597957822110305, -4.2169947328848405},
    {-3.7099450118399, -4.5117407066285375, -3.4236628275788172, -4.394685492499355, -3.744273554093395, -3.514223137845238, -3.732336540634901, -4.435261881225688, -4.096785693059576, -4.067406583914008, -4.155905652190608, -3.832663217149318},
    {-3.1651152881585607, -3.216449057985495, -3.805099958249156, -3.383398501621318, -3.515719742883169, -4.271672391562688, -3.874794985433913, -2.914918699645658, -3.5013188491588876, -4.378152500559506, -3.4218755635146563, -3.6568458357526614},
    {-4.113936074595515, -4.038083103862171, -4.11380437477193, -3.7729471641437913, -3.613334788494466, -3.7576487287460756, -3.72074100648444, -3.435725395328439, -3.2809948074045905, -4.131463655657715, -3.901448946297952, -3.74006209122741},
    {-3.9637336392432765, -4.562136751227743, -3.449714357671984, -3.684366455331287, -3.615610593983869, -4.22484132138969, -3.913786927425238, -3.7100772157671624, -4.070664173567331, -4.0544244318345175, -3.7745561678331008, -4.047195699141532},
    {0.36980795232332303, 0.6563765065621766, -0.2349803711601815, -0.41001211758027534, -0.38306070739630815, -0.0027207927898657636, -0.5648116868970245, -1.0400399841493855, -0.01984209315942423, -0.5659113037104642, -0.8258300181582844, -0.7250837473159217},
    {-3.8022467034965945, -3.3541012422376117, -4.188362807629069, -3.554134606748035, -3.915466337986934, -3.3074665323441694, -3.0064906944084417, -3.3098153280314238, -3.838662166435063, -3.5657699769087405, -3.6306167968175895, -3.9516306291097227},
    {-4.348489667338545, -3.1411274765789132, -4.168766845299065, -3.2230265653119026, -4.361726343380591, -3.853551127797698, -3.9256570190068523, -4.193614369611755, -3.717701173017113, -3.847625062261114, -4.282355688799581, -3.5001532157060966},
    {-3.7056894177886224, -3.845454795383024, -2.990126798164926, -3.776556584221365, -3.3025669919058935, -3.8555933539555167, -4.023200852259331, -3.519532349004233, -3.6101018843900605, -2.9954694851158443, -3.411532914019724, -3.908701970825513},
    {-3.6264206438186446, -4.0062196524751394, -3.371377954821539, -4.085447673497022, -4.006525019092896, -4.462658894849174, -4.217195248301857, -4.412629907011931, -3.707253944864927, -3.910445672516779, -3.9833633785517497, -4.080967200343723},
    {-4.145047401676013, -4.0626770141239765, -3.774638019088864, -3.7744008762415344, -3.7399415971894507, -3.5682040060050193, -4.021802833070626, -3.730650606682581, -3.7187156495380718, -3.3609615722300914, -3.5272642126324647, -3.703543003334515},
    {-3.611658120543828, -4.321359070667714, -4.284222978073863, -4.29442517149605, -3.49731833358974, -3.1961914034034176, -3.2896557437455476, -4.08951786671461, -2.82748592811612, -4.329142226325275, -3.4115608713006056, -3.8267178880812485},
    {-3.6522017553617707, -3.2575101301472538, -3.9720203195725117, -3.7550121835279646, -4.176029677759193, -3.6421821776079883, -4.00589563386299, -4.585121045744535, -4.307093675751678, -3.308443650428918, -4.038134786777687, -3.9901378815799466}
};

static const float b3[12] = {-2.8023987417377185, -2.943514709618387, -2.47439868952238, -3.405869546969459, -2.217424684300743, -2.652269687485886, -3.372955050985074, -2.8575188420122846, -1.7533324416104905, -2.4537882607434773, -2.20813317876669, -2.513670591651948};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
