#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5463683054873021, -0.25257965817164957, -0.06098842895531818, 0.7603625735176658, -0.5649368785651622, -0.3024849691831933, 0.47995236964202725, 0.671436576098198, -0.32421558481345336, 0.9007341751943161, 0.09546206783626889, -0.20101790048793114, 0.5127936929766425, 0.4855661032150515, 0.550310919243235, 0.450110309595515, 0.07636542872658467, 0.3877905576558264, 0.6354022205286021, 0.8968746461943143, 0.5963097191288319, 0.6458712570967483, 0.2569392780885826, -0.001312717412476949, 0.3071435756499452, -0.23914795418196427, -0.20566476614039766, 0.14754093098456184, 0.1390725946458841, 0.365795021697727, -0.11405126180396691, 0.3284462631478416, -0.22218174919734957, 0.7517895446060486, 0.24235628534613782, 0.61977666414483, -0.20246904785896416, 0.07791743400536212, 0.47257460771669146, 0.5410044033227457, -0.23153645029844672, 0.8223309469626533, 1.1013207849211863, 0.6190129263480336, 0.2703075115181752, 0.04317965618032807, -0.0025588196000318007, 0.17250197113933224, -0.19028366568761576, 0.11621542672152248, 0.04861048344913744, 0.11328755027426754, 0.6956138477289759, 0.7178125809575712, 0.6302922165850463, 0.193644473504498, -0.16241477781303068, 0.22583494283735683, 0.22686950743980086, 0.28630335878402896, -0.046583405363462116, 0.8892356047996508, 0.7116662317817384, 0.7710377045088775},
    {0.5057917735868498, -0.7007580727317534, -0.3592241043140767, -0.40922464765253075, -0.8273240924180328, -0.690499954124199, -0.22672612376117596, 0.392077219592336, -0.36544599215539314, 0.230856474517104, -0.29017160217526156, -0.6951477199700444, 0.286982024339753, 0.22001077043797065, 0.5829360409097096, 0.5341198049179748, -0.7632570552217403, 0.5797782467478908, 0.08763708034684606, 0.4662875418821495, 0.6543196653460184, 0.5461004373277827, 0.36542618064462606, -0.14673009571873785, -0.22814209441468503, -0.8668664849666085, -0.7512790542923279, 0.21783560253866283, -0.12282621609523908, 0.6903539879180253, -0.5102432730502825, -0.27022862548914367, -0.8059369646058556, 0.6028331658997989, 0.2816490392200952, 0.13907776621040444, -0.5980999260070118, -0.5921714267404045, 0.37755311039697376, 0.20256049973337661, -0.5511965898024674, 0.8326390784786898, 0.6195738524105456, 0.49302295343104485, 0.4316692915478332, 0.014026815765651185, -0.6142758985483986, 0.12383696780360065, -0.5793039653493035, -0.30016915829636664, -0.6880994819634808, -0.08843076709018972, 0.40039541485422275, 0.46785974894374976, 0.5593138828994692, 0.763308451584966, -0.3683542966382277, 0.3181010017033279, -0.24343313064735558, 0.2972477363587651, -0.351714385195482, 0.7016024351504424, 0.5666367443623098, 0.1413262319060077},
    {0.7635677782124759, -0.8020343283989761, -0.39659518461017323, 0.05084371131964829, -0.4761938078410796, -0.48395906820702167, 0.13613096171128772, 0.8626263216001229, -0.47497657910338326, 0.5998645074773975, -0.500917732629317, -0.599073034762956, 0.20193821554182795, 0.7404967160964001, 0.4883389707943697, 0.6724795370943304, -0.37816767389544304, 0.574299300849046, 0.8755310203927817, 0.629456288968287, 0.8531073500447375, 0.8723105518404715, 0.053990696230508395, -0.2806868123759799, -0.4011207441343638, -0.6175898604051538, -0.6559584140459618, 0.13363836920787733, -0.043326223943434, 0.7170057175658152, -0.504280568847431, -0.051130460175198, -0.7914197370652015, 0.8945112019135733, 0.6183549483430195, 0.6763723454489279, -0.740497020008745, -0.6660576199504674, 0.4446778452950615, 0.5503585676987484, -0.43048965624663293, 0.8059109793142671, 0.8437664539110401, 0.8592157152413894, 0.1729226372867638, -0.1326323243475105, -0.2759680993191752, 0.08516809085190509, -0.2278572789795712, -0.05068477553810131, -0.5494927231131884, -0.1909588524665488, 0.1172846975570844, 0.4692924520485123, 0.8883318015283065, 0.6490741012344866, -0.5887507846694409, 0.1431784220137978, -0.7732272046242922, 0.5071301803405248, -0.36449758946720073, 0.6720200944758686, 0.8699248075104893, 0.35596314418155317},
    {0.12442645831201186, -0.6490935307052844, -0.5834057134499289, 0.17262277624175587, -0.8775425463600468, -0.7211482936621543, 0.030200551743760847, 0.44875267516715417, -0.8629160094744855, 0.6089834678761259, -0.9310674709648428, -0.9062156629180751, -0.21224080494660374, 0.6779163636955956, -0.14165423029390298, 0.15489361818727496, -0.7160750851982189, -0.2551043288158367, 0.8160224972714273, 0.5245040267188433, 0.9634151628934867, 0.7234114076697912, -0.5147031174741684, -0.5964497905917395, -0.5491788097977649, -0.7550983357761196, -0.8518971801202369, -0.652983002719511, -0.7174760964496738, 0.5630965000749865, -0.5546721159170857, -0.47416821829595146, -0.8811516819636305, 0.6579325160720338, 0.572439742176742, 0.5165947983543694, -0.5419327064037325, -0.7771164189066505, -0.0012146026658392105, 0.6371720249335955, -0.606806321159309, 0.6966603752498147, 0.8985356149987342, 0.6672964102183792, 0.37934390988886485, -0.7639844607809448, -0.6229927889233033, -0.5872081804239627, -0.846487815580312, -0.444089973634729, -0.6522031432420039, -0.4979796076328361, -0.05376067904679016, 0.5024514956469306, 0.5059483876080396, 0.2712252862072463, -0.6422764516539516, -0.24431361619061112, -0.8040591295499304, 0.6283599250043287, -0.9805423434577543, 0.48781990465075564, 0.6675025911408183, 0.07571220376108329},
    {0.09729125425999222, -0.824414819988018, -0.5432482324916774, -0.03977291854102477, -0.7377913821259678, -0.5153472023155135, -0.09124810422786214, 0.3094204529829206, -0.9507862893171459, 0.021014612628679347, -0.6600634712423171, -0.7969095708920476, -0.43333351301405965, 0.9753014544161341, -0.506818529902938, -0.1670811455494462, -0.7485237510919038, -0.48200494543410155, 0.40748461162109034, 0.34723223398174435, 0.5926838687308267, 0.5578339811557708, -0.501521632656756, -0.7556986119997728, -0.6593432885900309, -0.8919468140516887, -0.6633848671451157, -0.7831314069157055, -0.5872456511472436, 0.17158912053318026, -0.5240955960955406, -0.6597064826026933, -0.700267116272839, 0.869664197595766, 0.5164327436929155, 0.31993029334547596, -0.5259983679678487, -0.7891289732708677, -0.3154617427892904, 0.5155785508501639, -0.569238833862282, 0.42300681501032544, 0.3780667568837018, 0.4265079544759424, 0.15222188419938731, -0.9317239691183125, -0.7392863592838967, -0.7570703811804445, -0.7559281968181731, -0.5297431467100168, -0.726918680444227, -0.6801099331488426, -0.14837447333342924, 0.45730094373639263, 0.19728637714858283, -0.2604680579688906, -0.47612613497996853, -0.5800930663441548, -0.6381092513888373, 0.31666233238316704, -0.9211465430628455, 0.424292482198253, 0.3022040340527688, 0.2118888208961644},
    {0.18345220252614033, -0.7121626108767796, -0.7699252591935618, 0.1031879112424285, -0.7447335823959975, -0.6021055008918902, -0.3600910695025242, 0.29639100154282716, -0.6497314887920754, -0.1410426916471216, -0.8731294747781031, -0.654994090258697, -0.5572729760851652, 0.7340685042541841, -0.4858907408758138, -0.42877282722450316, -0.7577854485471607, -0.4552196294379709, 0.7365038042255017, 0.15410729796389033, 0.3624200540694146, 0.5095107715959325, -0.39390095095234046, -0.849514414993176, -0.7247568614624395, -0.6807346494742136, -0.7099727577061884, -0.45359459918627837, -0.664366729268771, -0.09807857488812313, -0.3796765229307423, -0.7229795839342186, -0.7752632433776938, 0.604282231315837, 0.4967105542432796, 0.448274061062075, -0.649384405017133, -0.6148214449745407, -0.5021216565857746, 0.0906011563232126, -0.5691571437111229, -0.08413010000649557, 0.6592117788414874, 0.7351554671335445, 0.12123554887473009, -1.0227383673585937, -0.732378600355507, -0.4950691007738947, -0.8248544257285909, -0.5628420928336816, -0.3184152470981488, -0.6523898671361004, -0.3192581182620819, 0.04673888924713289, -0.028060044543637697, -0.11868667365432166, -0.623547710172307, -0.6789663510333619, -0.7108582711005115, 0.1425095700093654, -0.9149415627451294, 0.3054869119744325, -0.14739190851392264, 0.09600276013484993},
    {-0.14916936101269773, -0.5655380605548294, -0.6075655603005515, -0.010090636581869747, -1.0859933990493682, -0.7060911837206865, -0.3092427327655832, 0.21727467279801657, -1.1473133271493199, -0.20463159480894086, -0.8362254910479303, -0.7142514742646396, -0.6146510307170034, 0.748034869148547, -0.6296881348815138, -0.34545449898272784, -0.8105561688727437, -0.7005518877165093, 0.36506579353488255, -0.11907646691857496, 0.10691575982896298, 0.4276267997834894, -0.5230130999854007, -0.7052502166091942, -0.7878018369921514, -1.1331967183439888, -0.40375013577752883, -0.8885083757357621, -0.4345691900851586, -0.24032454676641063, -0.48208616905675317, -0.7272019578810469, -0.82346147575499, 0.42786421948741826, 0.3909198019099617, -0.08280441610943111, -0.8581792370491679, -0.8805197965577591, -0.2610751324019585, -0.13761693733109437, -0.567970100253366, 0.08510482377285546, 0.20183734177766172, 0.5232601673144233, 0.005092597870234842, -0.733600518333751, -0.8212555697497963, -0.3801034890373168, -0.7079820912969, -0.5476245281366694, -0.6567398156539687, -0.7941027451785677, -0.6229211596573753, -0.10116121290151453, -0.10124556831817347, -0.4940565628454988, -0.5603187150705927, -0.6994109553122061, -0.8115753746238382, 0.05498878673200429, -0.6120823277789891, -0.11959222156245836, -0.29435689958272465, 0.027318874598869294},
    {-0.0838500562382286, -0.7347521106964101, -0.7822309960930313, 0.0012027968813423345, -0.7019934905737744, -0.51321899409473, -0.5846804023835623, -0.14365125521057917, -0.7828932494706459, -0.3377818353125761, -0.7991860074413472, -0.5969224837939215, -0.5462629861350546, 0.6284869652361166, -0.6015701482025113, -0.8067006813448611, -0.6774572986702453, -0.5813381796872802, 0.382366174012123, -0.16255008761855735, 0.4154434396593668, 0.3992126989471225, -0.5640170055424768, -0.6979221845599676, -0.9273283705457527, -0.5855009114078593, -0.8663462967892999, -0.6335431391551268, -0.7315043741679277, -0.08470320161240316, -0.38261281558258986, -0.7557269794028995, -0.7855746317041596, 0.5400072818148972, 0.5987577787664142, 0.016978002654457282, -0.7310222892211001, -0.9145180242946973, -0.4697583481331734, -0.08405464927118551, -0.477742980595877, 0.18365897730988226, 0.13201463784846176, 0.39885302400438405, -0.19246607044461997, -0.6985930121397849, -0.7620843093153432, -0.671411528895234, -1.1738573337558151, -0.5188582761576278, -0.5877080732442865, -0.8306233530149956, -0.3297333966158696, -0.20180731290589285, -0.1403283107756719, -0.23279369740892022, -0.719522074642248, -0.6185488103753101, -0.660175220509535, -0.03792630111472138, -0.8259091697624106, -0.4108005076918676, -0.03254823151135159, 0.25303508061789465},
    {-0.2880837470135348, -0.7748128470743793, -0.6065031720645738, -0.127886939294114, -0.6329114126140596, -0.666981633350396, -0.4405913329194794, -0.019245525302788214, -0.9111636463726788, -0.024473533247533503, -0.7321454397081297, -0.9754312175283958, -0.6289835495016943, 0.43381038382933534, -0.6531637558351563, -0.43235884732649404, -0.4751017299651536, -0.3030100875755255, 0.4722091106432819, 0.16945988771538467, 0.2252203571164898, 0.7072579845701701, -0.36876835610144326, -0.6583362968882018, -1.1018356649333119, -0.6461868189368278, -0.7773710607330548, -0.6186602388731569, -0.9128761516789169, -0.02208746013454885, -0.449339010354987, -0.8336708409412771, -0.8088554339229621, 0.4638968000446928, 0.8120062115670025, 0.27414544555552495, -0.6405894423515645, -1.0433561280486654, -0.23421538643253006, 0.21141045036609338, -0.8984619195415786, 0.1816064548719917, 0.2001586996847389, 0.33513700635574506, 0.005760988350754056, -0.899746060838856, -0.6910239503552165, -0.7399226763841367, -0.7921134775722454, -0.619045117640306, -0.9852707749076227, -0.821829882001869, -0.43194197720627436, 0.10006619127435686, -0.044546084196340145, -0.30339059966649495, -0.8972667884501685, -0.33196136591414016, -0.9127489596553089, 0.2714032971258481, -0.897398547954052, 0.09156021144089742, 0.22683127412024337, -0.06356795212074243},
    {0.12979477353787097, -0.6931485725548646, -0.756086857478989, -0.08576493410557025, -0.6123714976526128, -0.73906850134651, -0.47876477005305934, -0.048347157196627064, -0.6382715563418242, -0.2326472413033798, -0.8897505480237866, -0.7134075236749658, -0.24662843930645392, 0.5424208179214826, -0.3634730915052451, -0.259762576606812, -0.7636399893777875, -0.30335195213081667, 0.35023152660398926, 0.25697543266121203, 0.35045794937928837, 0.6158128836024521, -0.5008960233414483, -0.6503313654661599, -0.9107844108288993, -0.8465313456913952, -0.8449289655026656, -0.4824992880866238, -0.7050373149445124, 0.3466318665567091, -0.6336209955636836, -0.4714109512828791, -0.8259121883717419, 0.7541967281820162, 0.6403763375124847, 0.08456444494639433, -0.8662870474627818, -0.8403446899172569, -0.12662078412968464, 0.27342224321281416, -0.7763205345631271, 0.39963224778078865, 0.47463947436635656, 0.6864416176543059, -0.17290625341211924, -0.5740228362844484, -0.8278613800827537, -0.5883537161835182, -0.7446758180866193, -0.7397761309584246, -0.7881589949760011, -0.7316688560435601, -0.24959885076312127, 0.06754925940378183, 0.04964839238023413, 0.09591581831428153, -0.7496104374065742, -0.4459103166175574, -0.8295887935945583, 0.49997107397673457, -0.8999623167834441, -0.16612667677142662, 0.2868433654636915, -0.21903180412186396},
    {-0.28065795758336776, -0.7935771538475832, -0.6200875264541741, -0.4318895371866526, -0.8467818042014182, -0.7035412871914184, -0.4021113942797254, -0.5491535770627513, -0.8308511169898669, -0.3636025371569489, -0.8869061873548891, -0.9332789759069817, -0.3095307083924093, 0.21844324054169956, -0.6408173849961577, 0.02295748071905494, -0.6468734534893614, -0.27446844399941406, -0.04903259282877702, 0.03434178998901039, 0.18515792693835215, 0.6435594658659287, -0.4172879730555817, -0.7338160496095383, -0.7427515296014209, -0.797413720211432, -0.8957297049850078, -0.5622940934368955, -0.7293453940826692, 0.30886575316201814, -0.7543895449522179, -0.5755365652899178, -0.9380583148284356, 0.3229362347090513, 0.25043898363658856, -0.1816124583462593, -0.6627259621496598, -0.9012304339937263, -0.3417474674738003, -0.16782329269924987, -1.1833770447549836, 0.17116883881485725, 0.2475579512166916, 0.035822650640790335, 0.0169519599867485, -0.595525621752698, -0.7943138694504303, -0.4899148635751629, -0.7092567999429173, -0.5739151396469192, -0.7237577647100798, -0.7788946708696943, -0.10008919281010982, -0.29379715897049014, -0.21634943180149394, 0.1347857842067409, -0.5657433601928732, -0.4221166768840695, -0.8425689382837563, 0.38053220402661236, -0.8376892459056221, -0.28779158749531286, 0.34608645682875655, -0.24535492004912474},
    {-0.2393330293794658, -0.9157660537374653, -0.7688989933687055, -0.31464310933451506, -0.9118389277631422, -0.5577801176223723, -0.4360092054172575, -0.4131959168742956, -0.8429351789487599, -0.45231301941555163, -0.6834935004650347, -0.5845892147178167, -0.47038443334131996, 0.20022131251365174, -0.5585066312757916, -0.17983262611667175, -0.5813506401640248, -0.4594984200809592, 0.36448204991288546, -0.06491369330315047, 0.44345209295250915, 0.44444567729788054, -0.4649689733312777, -0.80207645243601, -0.905525866351669, -0.9701886597521604, -0.9969824795006395, -0.6073466514695288, -0.8877213141417459, 0.03788153330376266, -0.5091775993360667, -0.722466968921061, -0.9942785777887848, 0.08250512386471379, 0.2662839621672391, -0.05642163661309647, -0.8043709667821648, -1.0454843183134557, 0.08074958482875638, -0.013368728327561502, -0.7786565052855082, 0.06124538444576192, 0.10726308174327401, 0.0484400224358054, 0.00866108664731102, -0.8099807019319505, -0.8770984149193157, -0.32265719796594017, -0.9043832813598782, -0.8289297561568375, -0.9776504007935192, -0.592310218711749, -0.10061413175888063, -0.32929758322277647, -0.352782578269207, -0.4036391446373401, -0.4923921238631616, -0.5244504929447972, -0.6637333487028624, 0.16689308057968047, -0.98713759572792, -0.2694460261160058, 0.04085936708109772, -0.5991605388032831},
    {-0.30189328775835433, -0.8567141747613201, -0.8984964267781615, -0.26789719187281685, -0.7232771452868229, -0.5396817883429412, -0.30720603842569183, -0.011484313403981804, -0.8634524474625465, -0.46381808431675176, -0.9327085963144027, -0.6885752470603029, -0.29865971569003874, 0.1917537254301641, -0.7985179113028333, 0.03667343350147506, -0.8446458050784068, -0.20617286068963808, -0.01046032605219602, 0.1445221962495966, 0.6403736434887319, 0.6727080238327475, -0.5418444838436733, -0.845718423382737, -0.675920846074739, -0.8614441655217813, -0.8008115397942068, -0.5464961420728356, -0.6243424927098351, 0.31646581067501134, -0.7034263191029962, -0.8184170554343304, -0.7486159489149895, 0.1124244231906333, 0.41986010869700635, 0.010344741842124113, -0.8621115742309788, -0.7341812061076072, -0.29561889519903733, -0.1362645890793689, -0.7671110879083749, 0.49150318176547375, 0.35417114964105606, -0.07257923874013954, -0.0065895189139816065, -0.7618428495705362, -0.6212263704764339, -0.5661757793794058, -1.1614701940338594, -0.8213296666590381, -0.8626204522467525, -0.7288500620187288, -0.4618755939358332, -0.26786547676648803, -0.1378303672873346, -0.058440669349116105, -0.8896046704282169, -0.37700309695737083, -0.8519059828499462, 0.5324297175170677, -0.8813286894684912, 0.08172426642761992, 0.003910608194618311, -0.3070926262007344},
    {-0.265423980693317, -0.8127422678681506, -0.6637629790559573, -0.4513942254960386, -0.9469138840394905, -0.6505411117964909, -0.39517529355156655, -0.02703419229528944, -0.908042206846998, -0.07708228464310983, -1.2577275480360068, -0.714791733789141, -0.4779108290094707, 0.08395008330276484, -0.34499734811289906, -0.22318252256753476, -0.7424969678716884, 0.085573569999199, -0.014672609579420412, 0.17881209656010497, 0.6649749458063552, 0.5773541992427382, -0.797378926639266, -0.9333455158751587, -0.5570471935894613, -0.5614506004559473, -0.8148312641859433, -0.35485415834089973, -0.8431499910200899, 0.3787365279722253, -0.8538442150430737, -0.579318658562271, -0.8573305871785798, 0.04864035854371476, 0.32636823061444215, -0.4145284264759946, -0.9925324096858148, -0.7976149524554642, -0.21002122030879225, 0.08506651820566664, -1.1153703795584358, 0.45807247851234334, 0.19009725138233408, 0.14983014806799547, 0.12490901980665804, -0.5855724552369829, -0.5351741872833252, -0.6441160259108449, -0.6145443991434256, -0.7231009126134754, -0.8148340888468588, -0.8977190112387748, -0.230182008783292, -0.34607165406458457, -0.27677299361229984, -0.011577708040643881, -0.7056196563744541, -0.6212119121610903, -0.7549326414518989, 0.46579883690348617, -0.7874922770489594, 0.007855669468894816, 0.2266841711383636, -0.01095181090443215},
    {0.2534979167302174, -0.6628611667177311, -0.7923202300270625, -0.46628143176242587, -0.7766242125460222, -0.7387595825061966, -0.11715570384319822, -0.03690496848472249, -0.9827197651059327, -0.31682234312436364, -0.7395853758043796, -0.810691494502188, -0.49111929551295325, 0.46822080710603725, -0.4488346116753853, 0.12439092173172077, -0.5608954984907095, -0.191643917983352, 0.33052899944658537, 0.16528010792362793, 0.4918545343021044, 0.7811720274104861, -0.618193592124692, -0.657335687028991, -0.7978274899369714, -0.9091709677927134, -0.9140613575919031, -0.6049582841008524, -0.9856610009756022, 0.2678124049215469, -0.7460546512622321, -0.5171186144921568, -0.48826911655537414, 0.3769734438088205, 0.5413821659033653, 0.006303484856659937, -0.8894943390177739, -0.5040044687433191, -0.312894036263004, 0.20050163704252422, -0.7972606246529436, 0.7984463273126036, 0.3529401531955473, -0.0016224290448202312, -0.027778853141099548, -0.720325486905961, -0.7228302151260146, -0.427185341777072, -0.6944780741605286, -0.8382775011606711, -0.8636433241229239, -0.4974674490996168, 0.06460167381907521, 0.007793834837782592, 0.3284147203953939, 0.28861845622834476, -0.6718757147826572, -0.3789632448551188, -0.855125059878343, 0.34283736294214234, -0.4863390233984549, 0.2470470484684903, 0.2132344352547953, -0.13546971860075974},
    {0.12815028578257015, -1.0136254106831146, -0.9121205960550627, -0.4705565980137197, -1.1276027002383944, -0.7976322812370449, -0.2249527242109308, 0.27375980139345857, -0.5477498643774623, 0.1751308140363181, -0.8130365785909136, -0.7961690056381716, -0.3162882481516856, 0.6857019298191503, -0.19925799681647421, -0.07835578860744526, -0.9715247169905693, -0.16604376080502675, 0.29702489797255366, 0.5351793216486038, 0.6281865875297582, 0.572148122384134, -0.6560237571667414, -0.7490457229129991, -0.4710505614053111, -0.8054358779382798, -0.9993574520267939, -0.45896746614261735, -0.8006576762648627, 0.42410375337599593, -0.5591927880685429, -0.38138320987420027, -0.964520573888149, 0.40146831296458235, 0.5128828297447635, 0.053755942643893266, -0.8932747873087545, -0.8922191062581798, 0.014404886492190912, 0.2609892438906607, -0.8789377279945377, 0.682767839503366, 0.3518292853209261, 0.4582398865025702, 0.04779919656300833, -0.5973136902064484, -0.7965009860544525, -0.5390400215874619, -0.7005228199785275, -0.914408260834549, -0.7620021375617074, -0.723256147037518, -0.4531489184090678, 0.08417969603457516, 0.11720378708050212, 0.38160192670561666, -0.8646730274197901, -0.44721932788677754, -0.8013079036155423, 0.2424518337666031, -0.8821353537950646, 0.38439675064587775, 0.4001167903442242, 0.021547377792424504},
    {0.3209090803615906, -0.6029441593109188, -0.7917434376833364, 0.18326590498683323, -0.7170252812055224, -0.506993192105527, -0.10063318963260594, 0.6074497417687765, -0.7298998404280178, 0.551035503248075, -0.8230036858871388, -0.7485328756364439, -0.19776516318919896, 0.5221263006057246, 0.06782669583561922, 0.24926763541133104, -0.6920691167410596, 0.022588307186437145, 0.7595469525090753, 0.8167300912753249, 0.8894421877381841, 0.8391779783776895, -0.6596132391158949, -0.6600528669681232, -0.986838760345892, -0.8296908405155206, -0.7099684982805602, -0.5503308044164085, -0.7636588885191813, 0.5847919471556717, -0.5288976110067072, -0.5348224196281968, -0.6955764460978319, 0.6849706177486177, 0.5516423407705333, 0.3702091382412972, -0.8815632674663887, -1.0406643987054691, -0.16526098421054425, 0.7219954840040024, -0.6441981062185946, 0.8181502433734557, 0.7128598671440287, 0.553672709177097, 0.5280128836843249, -0.6505771821439953, -0.7714679936010943, -0.5219172080672712, -0.8282051743238037, -0.32611459990002034, -0.8292573482074553, -0.7170687142678444, 0.2062841142447347, 0.3233031373785049, 0.6080771543952997, 0.21703948379616805, -0.4746647871305232, -0.2727954460703232, -0.6337973509492653, 0.6842782322038787, -0.5531451931617417, 0.7196273239236839, 0.6272004291069154, -0.14295061095585693},
    {0.5376479844927267, -0.4652363435136444, -0.5948454095059963, 0.04173167935121169, -0.7612491163409111, -0.5523422577055961, 0.29527757731280885, 0.454447710359556, -0.4101878339123383, 0.8576784671137148, -0.7283095397596476, -0.502848074887753, -0.062154193453245375, 0.6610448150877355, 0.4010817480475655, 0.5476295593981628, -0.3134598641154867, 0.3480398153764914, 0.6093186878493423, 0.8333775362107304, 0.8350305022635478, 0.8172735648403179, -0.24702727091731844, -0.5918816372285006, -0.3327538424761737, -0.4666743628699994, -0.7781897229387023, -0.08065735747954347, -0.3698816864546395, 0.576179043581307, -0.6537750763315343, -0.10812017386393367, -0.6944171500389008, 0.8858133360866112, 0.5436557504566333, 0.8087754776233081, -0.5373330388522435, -0.3779492306674259, -0.014998585425483024, 0.7637760984467722, -0.602088108604511, 0.8139582870127751, 0.6639736528771755, 0.4446941267445737, 0.3973642128685151, -0.1400915354813976, -0.6788057969257636, -0.3534947106403202, -0.7299595224115114, -0.38872277039497355, -0.5728705731979619, -0.5020465697545751, 0.4056330060702513, 0.5550624159528473, 0.7891731005849645, 0.4022238690319745, -0.5512073067278594, 0.008395907828586907, -0.8813587566754222, 0.5573583479905212, -0.6092132676593308, 0.7132679913555702, 0.7902651285866238, 0.2133528745865738},
    {0.7590057321155991, -0.518732451968373, -0.7239042707600587, 0.4022707190101365, -0.7203604841277119, -0.3177427642173998, 0.1382973405506489, 0.3934004667133244, -0.601480434380375, 0.7343299579120759, -0.4802478028482051, -0.4963333275110464, -0.26283641841385846, 0.6609674126906512, 0.05908318070329397, 0.6835523707795468, -0.5344772139077949, 0.21940423386667418, 0.7645021833977664, 0.561947385516621, 0.884581697054182, 0.966376772565092, -0.04852423098371346, -0.529655625211609, -0.5259144666748692, -0.5944751239464835, -0.80105275971017, -0.29371865205373965, -0.40920166674315434, 0.6693486403213766, -0.32253141726698553, -0.4338591393504072, -0.603514573928034, 0.7113539796578884, 0.5347431789262692, 0.8214680958658607, -0.4322125135089103, -0.6575991280162337, -0.11228698049088481, 0.6654644887771753, -0.3394042368864614, 0.7617280856776174, 0.904721464079239, 0.8026278471345548, 0.5147046244377464, -0.4648338068349299, -0.4735221200814318, -0.48242433366853954, -0.4477649162518965, -0.4352539848583834, -0.4222948096367534, -0.45735343602219203, 0.4955417630765589, 0.6139776620229247, 0.7383819154369118, 0.5789724954189782, -0.5430463670095327, -0.3649925712459378, -0.6975936942482618, 0.5418290436424299, -0.7043179699689062, 0.6934596058408077, 0.7997267071551649, 0.2517865008159256},
    {0.5549554266718825, -0.7222906521783887, -0.5709554754421696, 0.03369572221019416, -0.7502081768114005, -0.5837154364152266, 0.22579022943807386, 0.5658973617571427, -0.7748565043901264, 0.3985462872516931, -0.6668824410114804, -0.7917177165517356, -0.40992497801590483, 0.5428032852210408, 0.060421447888469856, 0.36408385214450056, -0.5291042639420959, -0.07299846759933307, 0.8361456364796543, 0.49457962287784835, 0.5727111362421079, 1.034359790588364, -0.6733905211594352, -0.687727375448109, -0.7478412566594773, -0.792272649949209, -0.8134710797694942, -0.4563193178332477, -0.44680254585637363, 0.5553249236179151, -0.9116940992570409, -0.6607584243622269, -0.9018176221838083, 0.8976169688585278, 0.2387191736392898, 0.5943385059675154, -0.9211911065400402, -1.040370778398641, 0.0548259950447481, 0.5656873606532448, -0.5966233361610522, 0.7062295389743208, 0.5489172920299547, 0.5634098087727909, 0.5344177732600182, -0.844216583542195, -0.6957847387940398, -0.3642955215006062, -0.7904667550244164, -0.8457946781711564, -0.69975137535156, -0.26978975364876456, -0.08404043247873445, 0.05978417834954284, 0.5428280798264896, 0.33588874810449426, -0.5374290235425027, -0.30037835459927203, -0.6322612154347835, 0.3809136935646679, -1.0185931057134743, 0.6542294998953092, 0.628522196599878, 0.2343384478808051},
    {0.47522360103689193, -0.9734205276828174, -0.8857023568465674, -0.4001554672157869, -1.0180486442836123, -0.6980501597692079, -0.30489293604710505, 0.36337594829995085, -0.8964735363332863, 0.36696434608425177, -0.8000303713491551, -0.7438875806280235, 0.0006372788887704069, 0.48407660269274455, -0.11794265205205566, -0.01692243851572462, -0.8407474242218113, 0.10907451189351527, 0.7828220969642806, 0.5653926679597546, 0.5972178537706306, 1.030819911276212, -0.47300308561347987, -0.7068163456054335, -0.8242345170611807, -0.6842078269332414, -0.9335707506722891, -0.4432908801483437, -0.8279287832743667, 0.630246882383443, -0.6944438617268127, -0.27566956929114234, -0.8296733227608352, 0.8911898379200948, 0.5190066975963331, 0.09132252603056422, -1.0824532456500566, -0.6510942695377251, 0.1914766018373355, 0.698916562141625, -0.5498865425781787, 0.6518055743725196, 0.4985703200821894, 0.2585636241325898, 0.41876756165343276, -0.36646293074467823, -0.6043875544623817, -0.33145640380583075, -0.8572411379167779, -0.5425837053506192, -0.8025752419741801, -0.6101865316894767, 0.3938469456991936, 0.4543583830257732, 0.4207187555745151, 0.13263082282013328, -0.6654861631549874, -0.1423828625813397, -0.5937371751209043, 0.7467713595833892, -0.6431929837276116, 0.7285584385586574, 0.6850679020130382, -0.09499326318527045},
    {0.35719669295291845, -0.8702072031924286, -0.5147827942988781, 0.2275519530133852, -0.7707934085345547, -0.6002804046539143, 0.1547984156133141, 0.7364119461895746, -0.6677445640606754, 0.728485038144463, -0.7375238031352799, -0.8260328189267209, 0.3260163461931105, 0.7162135173624015, 0.20169074367764736, 0.34731269854417496, -0.29826953366007136, 0.23673910153967306, 0.8530753471636371, 0.9564209190019023, 0.6800932121493586, 0.8774714745007574, -0.3118062157571734, -0.1831420592353325, -0.5952680411059627, -0.7347291902093447, -0.8278667569412921, -0.19577562213535535, -0.622230008464756, 0.4374523621311952, -0.4010568220985924, -0.19166253270269573, -0.7322731451523083, 0.6166740321697165, 0.6055717654598639, 0.7521508356213443, -0.37734869864804965, -0.7611634897437956, 0.25804040514553117, 0.6841749428260512, -0.7807797813449177, 0.9464217002377487, 0.8229459407176816, 0.7348333950822278, 0.33273797125232635, -0.15612492080213305, -0.35312402814544724, 0.018531231270684498, -0.5853893304343207, -0.3058761636882787, -0.5997958058188674, -0.2698838923510815, 0.4679477519750967, 0.5674782127001795, 0.6907571592767467, 0.3517911846891249, -0.42126968760948175, -0.0011758536339296199, -0.7422214285784057, 0.5120258774947843, -0.48960998231088687, 0.6293597864784869, 0.7388705522065749, 0.2934033059875725},
    {0.6705910392675507, -0.6001664092180106, -0.4058702876216289, 0.3336186079684883, -0.6978858186542951, -0.41029910705423106, 0.3487943375529934, 0.6503533964679167, -0.44766611691195113, 0.999416358587296, -0.4471628811166353, -0.717420864024891, 0.3332270222137577, 0.7256122522370735, 0.26149865901602315, 0.6192601261701304, -0.34756634129182146, 0.8549851891945056, 0.7339671489288376, 0.8877407621242529, 0.8565073651070589, 1.0717725910219955, 0.30663821301193367, -0.3471907440377049, -0.12427375935078576, -0.6956243952048646, -0.7526652583475321, 0.012911884058866683, -0.28517893586566606, 1.0055275476251722, -0.4299334305324157, 0.23268891983083217, -0.5222569105863157, 0.8138250891717765, 0.5637007695163194, 0.5785914680526478, -0.759983297439442, -0.44293868203489417, 0.6166418647295349, 0.8903174711156592, -0.6006028041553063, 0.8270768683294513, 0.9264928959624064, 0.7709557574635649, 0.6825243616217942, -0.012501704618215755, -0.12052658141268484, 0.01379232353388849, -0.19624225663050562, -0.18568963582686146, -0.685307629860786, -0.230145071523198, 0.5788325276716431, 0.7718709267712794, 0.7579547785224866, 0.521028324513107, -0.2512293798158776, 0.35273214410892156, -0.5241731497544782, 0.580781060417522, -0.35275530142077555, 0.565609352300058, 0.8993533209212845, 0.4952523640875152},
    {0.7156724998463168, -0.778060419915664, -0.37062417637414785, 0.06574439313453481, -0.8257700858176893, -0.5800088974653922, 0.2572011455010342, 0.606436797867538, -0.28065614644790865, 0.6894546111964011, -0.656287754009175, -0.7264624113892652, -0.022325741794164286, 0.6115943221150133, 0.3777341012635948, 0.6552543924576686, -0.6354773636643989, 0.3694096577332286, 0.9481812946908927, 0.796498787501267, 0.7095927073420408, 0.9713091659937892, -0.18378368082068283, -0.5923879022452461, -0.25646028271027016, -0.7606726252840122, -0.7768197695374849, 0.05751001226122524, -0.6777689303053912, 0.6988448832211506, -0.5532651007554107, -0.06426303959708139, -0.9855432618872513, 0.8318698056372321, 0.6124942456577629, 0.6666759072442503, -0.8226919411270734, -0.5892467776318944, 0.5395018519919065, 0.7091889547101126, -0.6946754333614471, 0.6861641753561687, 0.8688928834680171, 0.6344975557980379, 0.4242042789255982, -0.034690659768870466, -0.4121712741616451, -0.07819224526187904, -0.5611511594901814, -0.43463831841852785, -0.6087869551536012, -0.5075161341387506, 0.43475225482410107, 0.2855573215640118, 0.5798955466997531, 0.6418476624018321, -0.49014545115052377, 0.14573880496419886, -0.7491728974937605, 0.4361813286018079, -0.6638268639834026, 0.5956088547699585, 0.7764600033998401, 0.33607606467608464},
    {0.46090573573438215, -0.8652518527328358, -0.7558880091515464, -0.11223965235762105, -0.9213240329710479, -0.5330271408338102, -0.1838529327468639, 0.310320462419604, -0.4511975978954348, 0.4556299842367735, -0.6727177170983277, -0.8099272908212755, -0.005803856970258054, 0.49740404961246315, 0.15363718104949234, 0.7064431895899497, -0.5392716274442855, 0.35173006647650873, 0.6552076306635561, 0.7394245567641409, 0.7950604792007614, 0.8657162256470835, -0.5645055208035143, -0.5078725948895276, -0.7227561570868536, -0.9040067372223144, -0.772997842919641, -0.21259605753886027, -0.6315233885981965, 0.483506557612781, -0.6923501523060797, -0.4776505924582389, -0.5106645681713033, 0.5081554779768069, 0.3483551197241812, 0.5271897038699207, -0.7576737304679142, -0.7823958762492357, 0.3910338166906234, 0.683151173719291, -0.67137470371963, 0.973170748515324, 0.8998152944819936, 0.5364596909446862, 0.25076559311286023, -0.2351275583492767, -0.6922366874336071, -0.21606145717033368, -0.5666184931184418, -0.6259497990500413, -0.6394538859644273, -0.4391152784623314, -0.003470356347230856, 0.538584173948543, 0.8089361097727573, 0.46399978361982314, -0.4974648124748152, 0.1173114534383276, -0.6122920489236865, 0.4567891251351268, -0.6422978624662381, 0.6492804207632563, 0.7255302671235743, -0.09466926762678333},
    {0.4484820923702129, -0.7347987324413796, -0.7117845676369808, 0.0874223185825619, -0.618322725184547, -0.572287224756136, 0.03098460890020682, 0.390477039303915, -0.6285467235129125, 0.643124343508914, -0.6969248072956119, -0.5939470564046998, -0.14241802331174688, 0.3884932597962943, -0.006829935450749178, 0.6525240899053132, -0.5695224497494035, 0.1460887682803508, 0.6227197839997201, 0.6944367248285516, 1.1784898252862526, 0.683691211891328, -0.2553686066289272, -0.5200076697657664, -0.6974195731296465, -0.823368329146133, -0.8334159330740698, -0.1727425633288963, -0.5889363216490788, 0.6367634358353516, -0.7242482098853518, -0.24908079933615085, -0.6602148083758256, 1.2794408009900793, 0.484237484641533, 0.5020086193266935, -0.7134991449400279, -0.866028490149305, 0.31662708557893715, 0.5080287789356845, -0.7294783480294569, 0.5529973338421693, 0.7194749435574607, 0.774752970887785, 0.3872459056565739, -0.42621970827432415, -0.549957322978057, -0.02375050018600131, -0.6687670110138572, -0.3242743004737662, -0.7110153343870731, -0.5746294271733245, 0.2861027869406893, 0.5633094553907005, 0.7507670163718393, 0.3715658092264409, -0.5799329232128874, -0.06728073141659918, -0.6357120608792636, 0.6690931470233635, -0.6573353874539202, 0.5616266126599531, 0.5273808387044553, -0.06522468379946421},
    {0.5576204921201768, -0.7110376549918358, -0.4587880923304877, 0.22557495490649046, -0.8660811953283607, -0.5102921156763652, 0.24510237936927767, 0.5692176653215417, -0.7012376023694923, 0.6207369020724052, -0.7995155099847299, -0.5274898645078249, -0.06903474740155237, 0.5258607838006585, 0.217302696787262, 0.358546051466385, -0.6740698857412409, 0.371592923110097, 0.5863186334349799, 0.5843186899991457, 0.6846403428596428, 1.2127820511280083, -0.08548287221031964, -0.5695515343280443, -0.3469158028424612, -0.8122621706422598, -0.8358426761105727, -0.17023596869941446, -0.4492505396016624, 0.4552451598423419, -0.6877005332323408, -0.2570490096989234, -0.5765941513063042, 0.7492655540074181, 0.7343739552738522, 0.48313631869979595, -0.6503790773785254, -0.5346343196306651, 0.3591890990565718, 0.40794014368953174, -0.6770079954191726, 0.9395593862032344, 0.8183634934342859, 0.5945690303223955, 0.7858249007434767, -0.45076113164721765, -0.6806691288557425, -0.07274357280036983, -0.5513861956387116, -0.4844698505193074, -0.6824142181096619, -0.3256621024610409, 0.11708230249407393, 0.6920774940845356, 0.840360931314643, 0.3868669065866791, -0.46576908655458243, -0.0279792569794477, -0.6250453977477035, 0.7374705926264757, -0.3871475820434832, 0.6299119792190975, 0.8221167037084008, 0.21580921739157724},
    {0.590256504502734, -0.9583465943926345, -0.5917436434321597, -0.23607551177996133, -0.6163033361631036, -0.6475421122779814, 0.004585101436302518, 0.41963325338873353, -0.584762320732146, 0.5853446451568295, -0.6156588648311202, -0.7087548742179689, 0.07709155089522635, 0.6984745614558044, 0.41004209292117916, 0.36510350663407165, -0.7483868972625689, 0.2773050964650714, 0.548488704191144, 0.6933414974511602, 0.650970096556816, 0.8195928397143464, -0.1764185713190357, -0.5641035303950893, -0.6653471773922155, -0.9423060526825666, -0.6826392429530911, -0.22826312710205499, -0.5775374548548037, 0.8811850295836552, -0.8419595785511607, -0.5247150011536769, -0.959090812546019, 0.957015585762209, 0.7674706061929096, 0.7474383211761585, -0.841542892054279, -0.7599637319330222, 0.20463823662326677, 0.7187764502993179, -0.7112603647849434, 0.819775501410599, 0.6754556034984122, 0.5375794256944851, 0.24659922226756967, -0.5145788859311106, -0.7366129751345751, 0.03614698176959945, -0.6531931216149217, -0.4673302395721169, -0.6427484064519073, -0.48940747728417844, 0.06954457771437614, 0.8023413066900923, 0.7832677727000023, 0.5859984676134589, -0.28620715224131316, -0.0718468364360739, -0.6993320076132417, 0.5174069727568787, -0.8747882322286735, 0.8222529628989981, 0.6858691183705744, 0.20576207147601958},
    {0.39907499004598496, -0.9932344190256914, -0.49255021451784126, -0.3702340214239626, -1.084689005490391, -0.5950675735238131, -0.038544111343689215, 0.5195243032567484, -0.670367010059007, 0.6396873091752855, -0.6184973811536367, -0.44987793182109675, 0.167145471927111, 0.5792457080027736, 0.1623095934078978, 0.511083277610444, -0.5314652128129568, 0.5218780153778901, 0.5937909905844474, 0.7818126225785893, 0.7233020417714969, 0.6841474491479987, -0.30611552078579035, -0.2678478695435464, -0.7362310103816714, -0.8590078947962152, -0.7007360392766844, -0.3150739789959943, -0.6068169310560849, 0.8145006374560236, -0.8333879391894773, -0.580201908402758, -0.8097186468277625, 0.8420490030841044, 0.5258648551565562, 0.3011840719327173, -0.5806065923676379, -0.8788767758958035, 0.334329955003361, 0.696522680581444, -0.967910316737021, 0.8958440716593422, 0.7588470722049254, 0.742271752369725, 0.5208095902957374, -0.311240122515093, -0.6279593049584551, -0.19457659566146143, -0.6802155656049402, -0.6620136050625414, -0.4852789741218945, -0.43828753722567204, 0.38437388082647617, 0.4337124448795099, 0.5706576994204479, 0.7056757722681931, -0.6238818189455909, 0.31129880586763775, -0.6206812236279144, 0.7117353444749004, -0.6664060175964518, 0.6334478640611079, 0.7214087226480372, -0.11147987908099785},
    {0.5300347912475633, -0.7166326333484134, -0.4691765709256508, 0.09067755504218697, -1.069327166785362, -0.555366064301136, 0.2575337592809066, 0.3383077451251268, -0.8868595984159034, 0.5353261174469345, -0.8582139533533505, -0.833518178639738, 0.338495144971181, 0.680274975260183, 0.2272457857766065, 0.7749722484560716, -0.5618231572961787, 0.6429422886535863, 0.6236873793648429, 0.8304403231343939, 0.8930986398545022, 0.6847285328551707, -0.0755196341581755, -0.2884010347877928, -0.3981395374240782, -0.9138238523225416, -0.9023467067817788, -0.24098849831037414, -0.6266112762898829, 0.9926669689346077, -0.8283002369539189, -0.43471232618965283, -0.924044039684967, 0.8384239149257868, 0.4995763213500153, 0.5999959207861434, -0.7487237043767071, -0.7101992079168795, 0.7033158812200712, 0.6445961566486185, -0.9028626021495278, 1.0516175878441387, 0.4140452749679355, 0.8190467659873298, 0.5426265937766256, -0.35685343763605354, -0.5077267216657162, 0.1043942018055664, -0.6816103065129065, -0.380756177140195, -0.7135841776335695, -0.5352693797295578, 0.2740831743534308, 0.5310108732186338, 0.6710308724311691, 0.2036975097188904, -0.45635409251583053, 0.06088878677072121, -0.7785735309941305, 0.7333788711284681, -0.6518063902739797, 0.624628055195433, 0.402848988766143, 0.10789785509101965},
    {0.2023284625342546, -0.10495404590822954, -0.07787485983418013, -0.05714339355925116, -0.08054654835007805, -0.1551083183506184, -0.5673536345806772, -0.24969060696571907, -0.1396579963250056, -0.7962055153631395, 0.15192052112839363, -0.2417812616391425, -0.3767866058739097, -0.4399857139350847, -0.5595439345825327, -0.16153535454069703, -0.27134266048209543, -0.4969334920069228, -0.5367242506051466, -0.5975448963322554, -0.3091795080371343, 0.0603437410602974, -0.1773306559755181, 0.017812699232311942, -0.10120198891651874, 0.028273065018123465, -0.3449470060214832, -0.17605099950734676, -0.48027287673139046, -0.3076614964411294, 0.1291656659652631, -0.0656104533970446, -0.20771124563752882, -0.2500520491265901, -0.16101924213844537, -0.0006408525558478155, 0.01277335362552435, -0.5773105864143419, -0.36468693974772987, -0.29957661738042535, 0.015235852563887774, -0.15216426445453288, -0.3469121339028302, 0.2788872589293163, -0.10320076205392766, -0.029582623684280034, -0.3516897209056947, -0.6698560741100794, 0.030575472668925765, -0.22989763075295325, -0.3106166819821485, -0.12128947703734572, -0.753781068968762, -0.4007315045210431, -0.42892850692140266, -0.47162034241242984, -0.052000153257166455, -0.39140193058470374, -0.18165346869440782, 0.04459858942893932, -0.13611795939744734, -0.7425886836929607, -0.295264247516825, -0.11469230406630226},
    {-0.14667689580211446, -0.7075755990687229, 0.0822969180079787, 0.2744903816393108, -0.905275436313097, -0.5974003983081285, 0.17412450000087182, 0.10545770859377324, -0.6283757398446206, 0.0474353411172628, -0.37942255578060863, -0.32588875078527224, 0.09722582703568287, 0.27638045207753037, 0.004397767968046062, 0.13145512369964218, -0.014055440517064687, -0.13094291830701074, 0.40340115453282743, 0.5100644705598913, 0.5149995760682619, 0.21109651447206645, -0.020708366168492025, -0.15878634269560915, -0.47236962311780356, -0.5449812797137666, -0.5242686617826934, -0.3425316537276894, -0.40483964006136325, 0.02063757465699479, -0.8909260096513109, -0.2816626015772926, -0.6125986136962921, 0.4852271200862289, 0.20051801303270858, 0.14242262213383175, -0.46813198787533195, -0.11914574721284305, -0.18827011300564006, 0.0666649242488144, -0.6199440826575363, 0.3178929590693013, 0.3822861405383429, 0.5440881290932934, -0.16240101201145873, -0.595509146086871, -0.2281435867548759, -0.4505417439855906, -0.40850292231267354, -0.3449432882091113, -0.4490223921291096, -0.3098491274860847, 0.14748012402732716, 0.3412509705776231, -0.08921241502821373, -0.013990960859516401, -0.2724509749677394, -0.21751880821173922, -0.35875861888122473, 0.0198872585521367, -0.7540423596540485, 0.23406721514986814, 0.48603597645607166, -0.320855508463155},
    {-0.3607477189861339, -0.026825706424465825, -0.47609137207666274, 0.30965177771420666, -0.15981418177445209, -0.31453834854501406, -0.061971689665215456, 0.012531908675556362, -0.40368347322542647, -0.4773186081769888, -0.5864894784580496, -0.2880323478440746, -0.7535460287166486, 0.07612290066703585, -0.3335119244190308, -0.6025713625587149, -0.1579621268180213, -0.7018918394629013, 0.19746561311699112, -0.14602960865446887, 0.08354764564637827, -0.3781860845086498, -0.4262879874918211, -0.4367899094067263, -0.4917885462505103, -0.0044377632717605845, -0.3584549289829994, -0.32020566683227186, -0.5443349933766306, -0.7719582402465655, -0.15644682974492383, -0.21655076308293117, -0.485184122493389, -0.0536030617162881, -0.044888937262805004, 0.023102337671027696, -0.4725465302979477, -0.5953725205119749, -0.6606100183988876, 0.004146591298560721, -0.009371775663286333, -0.37912024285298807, -0.24168290309737966, 0.2190763881262738, -0.13935352738300713, -0.5546870105782991, -0.5128956022166045, -0.7528204083373953, -0.29686459801124926, -0.3656850420569211, -0.22777890284050104, -0.5606733210923216, -0.37659888802035835, -0.21388845068789625, -0.6136315520445316, -0.5973718303824134, -0.1736044437193575, -0.6549675028084216, -0.24669862324932565, -0.26434782710902655, -0.2136418055284397, -0.25095406668316245, -0.4064941462999433, 0.17870795149908522},
    {-0.660635322906314, -0.03011262113640419, -0.3015296404289909, 0.029242645239368016, -0.34389242091167344, -0.09384975291474665, -0.18042527331845915, -0.14608542373429587, -0.39438695276408553, -0.3122706113872977, -0.19553113489073704, -0.03247488061140012, -0.5599361440879499, -0.01582691741223966, -0.42302744751805105, -0.5868753818576475, -0.13110628622688292, -0.18620954574354057, -0.03127158119709535, -0.07128645506637285, 0.020076084585597193, -0.44891359221298593, -0.5328501989601958, -0.5911228909916676, -0.6503913173573485, -0.20906482139662674, -0.008475388510708042, -0.6990218800433327, -0.43755407045461564, -0.49101809764260645, -0.2804564405620766, -0.14748802091578578, -0.09475723627922991, -0.2745172112414334, -0.14725742396149233, -0.12479360052371877, -0.30895555692496757, -0.14269619281720275, -0.5506608721806322, -0.4388069584282041, -0.31551391034543463, -0.22664641268464802, -0.1836110510337083, -0.27559297559542156, -0.30879777870579844, -0.4927531324267317, -0.23775482951351068, -0.5617152708159401, -0.4039297144757596, -0.37627423363036405, -0.4384118016699187, -0.15055642335392025, -0.2452369068703987, -0.02711130582896339, -0.8920694017892313, -0.5244207788032419, -0.5714238079726435, -0.3345619190103275, -0.4696162655975565, -0.3430563100661413, -0.29777798320571125, -0.10460627570073508, -0.5634445233860393, -0.29488344653701926},
    {-0.2391573026405385, -0.6084183173120102, -0.4644830949222556, -0.14895768721683894, -0.3129305843177209, -0.5108391537658415, -0.22459717145005814, 0.14469637489787052, -0.5152492996155014, -0.40887769091416837, -0.7787163248827584, -0.15492187981975503, -0.5087195441298175, 0.03324467456396961, -0.3213269453976495, -0.4001926772731989, -0.5907667243269291, -0.46735511010912795, 0.3943227463706665, -0.1254669691233411, 0.10135629038818193, -0.08476907425567287, -0.42817971101827634, -0.4634298998632287, -0.47862626048956325, -0.694443411630672, -0.8032145708440065, -0.5999737588186108, -0.4486279003892636, -0.30859685667271186, -0.13004408384724347, -0.3091080260190551, -0.7620033029694153, -0.09001543634517356, 0.08245648585822217, -0.020617975639726987, -0.5841575290518394, -0.39486920768668693, -0.4362912074797242, -0.32277964347430266, -0.620848907025751, -0.1623821467639196, 0.06165349299561073, 0.26032283061116335, -0.37094722084134096, -0.5585175803580477, -0.44547964858043587, -0.4410142251178583, -0.4999994139632778, -0.38251116159071086, -0.8202872828678908, -0.5531300828260007, -0.4673032241841782, -0.024195145779558405, -0.5036191659964028, -0.45026500718595364, -0.29087061304080003, -0.5211241174944341, -0.6129611945535743, -0.3372171798920546, -0.5941431472761094, -0.18200206861718013, -0.23606746572226744, -0.10780997899400477},
    {-0.2419959956457306, -0.38065604983287976, -0.11620856086706595, 0.26438840845974504, -0.261493879271247, -0.14956512701410907, -0.37901936863367536, -0.04362781138874171, -0.6519721267630533, -0.4659193465898769, -0.564222655112113, -0.15708675777619827, -0.5703540979092803, 0.350484607410008, -0.3061661351924813, -0.3345370136922017, -0.26294357594958134, -0.521202542422693, 0.23183834635183148, -0.31549562520420954, 0.030126511993936764, -0.2416103518249109, -0.39155425690338375, -0.6227815198214248, -0.39113076712784256, -0.42466574620099995, -0.48363961012343043, -0.43748719930694946, -0.6063159470552504, -0.17767450245996352, -0.048853556105096396, -0.42157293373587024, -0.5473018486408316, 0.2849198826842452, 0.1756812454653078, -0.08000623183771483, -0.42798675436096945, -0.457978352774665, -0.6164563071170265, -0.021733181218547414, -0.539880894635828, -0.2056362109708889, -0.0912990025459119, 0.6743753738496508, -0.42626248094066405, -0.8160032973002743, -0.8065894695861932, -0.4308837902341914, -0.38546054975544936, -0.392917629872575, -0.5193617611855276, -0.7028204444896747, -0.3457192113774738, -0.07984815617027875, -0.49215223856955986, -0.3138508037061917, -0.5858582976980323, -0.4273530606038976, -0.4610724040206948, 0.019109338882581903, -0.3767147663278245, -0.12763446631203895, -0.3705916882674064, 0.2521999732515541},
    {-0.48046625809870086, -0.19791795254544248, -0.18829322188542907, -0.001396743950676585, -0.4857863924930719, -0.5510915619731884, -0.3941535588871617, 0.025954669291185804, -0.5809781190650393, -0.6336837162591848, -0.5366371011933846, -0.39463157067038673, -0.7130313083976095, 0.37308761813344543, -0.5522185169339591, -0.5788614137191923, -0.6356492145302644, -0.5008043507401997, -0.05982911228259886, -0.30161433257848447, 0.0013662487976601695, -0.1509961202624141, -0.2151048623607344, -0.672726897441259, -0.7578468286912131, -0.7280952123914539, -0.6621203095310659, -0.3172340674425868, -0.5099403259722766, -0.4133908324704629, -0.3793844260474105, -0.41291122150603476, -0.6328038769144182, 0.01980323964250465, 0.14009164772954277, -0.18409059164502722, -0.09440300956001416, -0.6466514417225309, -0.8738377374746521, -0.17467489634939942, -0.5301221019555107, -0.3261083024708076, -0.11937614193409644, -0.1474900720582742, -0.2510223672267311, -0.5677919499165764, -0.7006131676377352, -0.5710744205212331, -0.13749588821814193, -0.5960171607686803, -0.4480240033567105, -0.4018068049810385, -0.3186189376596465, -0.2945168446043419, -0.3186284073679898, -0.6377483950665732, -0.5577271944241381, -0.44022329199421806, -0.8077137923817771, -0.1319585267710592, -0.5809486345225904, -0.45484389390050295, -0.5014157710582043, -0.1642615898627238},
    {-0.10350876884155243, -0.5103963700618774, -0.35341329934566557, 0.44369743292208796, -0.7095339332302149, -0.2960013654276572, -0.05697997750114963, -0.19963604789004885, -0.4759266640397799, -0.39444121183123587, -0.7795776304693677, -0.11086833673734506, -0.6498506986750455, 0.2798151501020541, -0.6754028922373572, -0.2926319902655932, -0.49065285634484046, -0.44771005844526424, 0.13877238506547426, 0.204245437894566, 0.27935087304022665, 0.09169607820519846, -0.4959271020970239, -0.46545153595643973, -0.5481085516046759, -0.5294644067041648, -0.28004463889857584, -0.3534196645999652, -0.3343737925484575, -0.25352983612661123, -0.1412048579357434, -0.2566251931976639, -0.37160512893523845, -0.07057244851416868, 0.5326325406224621, -0.23245866972737553, -0.21399013095973562, -0.6999416965677187, -0.8413510897798595, 0.2788300145451211, -0.476220967101388, -0.357101003627746, -0.10598874517365114, 0.22046719956142044, -0.061848441193732215, -0.5833932296872283, -0.6417703444695312, -0.6467721352446286, -0.48541682462793934, -0.27525087027947087, -0.6361475458908125, -0.746973863238917, -0.22079910133510008, -0.05907458695994703, -0.5025953858357397, -0.6820633227416267, -0.41537572401114425, -0.9325421170551035, -0.42446863975476806, -0.1501078495383136, -0.49422797435817084, -0.4072199225885843, -0.2142625226680762, 0.14547982975289137},
    {-0.21848877317969762, -0.4160339277927164, -0.3058858017365181, -0.021869382976318266, -0.7333517712079407, -0.5086106434120492, -0.0535179068582886, -0.15042876174874076, -0.4641079657637972, -0.4640662709327517, -0.6481199783369893, -0.23468041759714464, -0.6738553882351497, -0.06915615250440837, -0.6966685523900437, -0.3571677420705287, -0.18365211914679094, -0.3411892059265524, 0.26948124711238164, 0.006119394992618181, 0.16655976057897523, 0.04290685575810761, -0.09764379831522894, -0.40255061601788567, -0.6436880030109201, -0.3022529731207576, -0.33315431267561635, -0.4779165766231518, -0.5752533368983389, -0.1857653372609046, -0.17939211608875832, -0.16007549103175972, -0.5334454984736168, -0.01517587243245209, 0.05795671932986887, -0.140161817759198, -0.843955861980685, -0.5256952582729688, -0.6520754322776707, 0.20427685680354127, -0.5488831114525613, -0.3805956495990476, -0.2725655157434923, -0.056138818708017825, -0.3097983714033503, -0.569774057980768, -0.5744255414476064, -0.6487555619989538, -0.7077437576481546, -0.6983427975487663, -0.9622933409322999, -0.5931921018272884, 0.051272694961792126, -0.15987577972651112, -0.3202946888615111, -0.3795523565399389, -0.5907941322903444, -0.770891535068269, -0.7408723999153919, -0.36513321778424324, -0.6442929603861742, -0.3050689400640062, -0.030237598694395334, -0.012981958066098878},
    {-0.1436173460768156, -0.2527013000627948, -0.3649901543922358, 0.3791649549869967, -0.3559370355477943, -0.4484356441693015, -0.31727341298043443, -0.10703500891814093, -0.8818127983121605, -0.45290531062218214, -0.5439126491199875, -0.37803012499097727, -0.6549780606734757, 0.3212823303720422, -0.5381122264611558, -0.4378157005432801, -0.8190305009546376, -0.5761607262972497, 0.006668603993277849, -0.008771656427216128, 0.17523600557921412, 0.15746819883479418, -0.29533138763113714, -0.4916338774679103, -0.8263200853576061, -0.5041261285150778, -0.6763787373024749, -0.5736502980800152, -0.9065683883326201, -0.5946584501512352, -0.363377081800287, -0.03816649388147874, -0.5864582901829964, 0.1987521393720125, 0.4141372685018911, -0.17707386836776914, -0.4520103385967717, -0.6791515703393329, -0.8551247871512493, 0.07352855157600849, -0.3908408114425798, -0.18999007184616212, 0.08392367309652286, 0.44925357636449526, -0.4352619544844617, -0.7657248416335138, -0.5905912795507829, -0.7434675828913462, -0.5369448061212355, -0.4707044486584279, -0.6934275468782888, -0.4863120654446835, -0.4723501342437778, 0.038196721348302605, -0.6553161149295366, -0.754812586799594, -0.4912709861762831, -0.793208468623391, -0.7894352120186225, -0.168940462041953, -0.7297400638343178, -0.43296520578949166, -0.5387274714686165, 0.15605860567089597},
    {-0.11016925348401818, -0.30548863073718585, -0.10407068258859799, 0.16485836507850074, -0.31244037597321306, -0.4520938567064737, -0.6129565553647756, -0.19711168490955755, -0.6591860700056511, -0.5691910780364962, -0.3632654587583664, -0.2696267392602478, -0.9490331947886237, 0.26547864390968284, -0.7296929313191742, -0.416186703425264, -0.6229266422965615, -0.5716438590077733, -0.2142548294982861, -0.18345234023858553, -0.15640204060498317, -0.45253042816849787, -0.479911618519027, -0.49759657961301507, -0.5436912088329021, -0.5619600707234849, -0.5672414215626149, -0.49070132814242307, -0.6447393824292985, -0.5676228803412997, -0.18988712080312475, -0.3367951084475503, -0.840395099919489, 0.04006433438114835, 0.07002626183639374, -0.4947609528485793, -0.6063679187593182, -0.5491601482344755, -0.6118061788022452, -0.18871156570996878, -0.5144796027894468, -0.25225703619885587, -0.4189007530955051, 0.02155554099496925, -0.526811476505616, -0.8176208521623326, -0.4078989540364948, -0.68491736568145, -0.8051222620827905, -0.43744483581848187, -0.9086043659198743, -0.4127465327813851, -0.47925078508699603, -0.09838420074747957, -0.70098790307642, -0.6917444799684033, -0.3338039563927816, -0.6028302904211429, -0.6374217562580379, -0.39987187393424206, -0.4594885006621653, -0.5255411614062674, -0.40986109061885445, 0.006323926275320354},
    {-0.20846786299850115, -0.26909255615509414, -0.30469608479446586, 0.20614684820536852, -0.4754445588202425, -0.37544255305681906, -0.15448939533398656, -0.4380005385252977, -0.4651136735814609, -0.3005223763114005, -0.7495710621818773, -0.4317585424769396, -0.6296996766487115, 0.01615611648351561, -0.4212257259136312, -0.4069363966188403, -0.6358331852126459, -0.7230636282668854, -0.1002365920885105, -0.27835172194737035, -0.1525226738869036, -0.3214122818525721, -0.304638349371528, -0.4796930694842402, -0.7690484395181978, -0.5686970342367148, -0.5400407271544814, -0.48034467720965696, -0.7217197577585859, -0.48088836895217824, -0.009648144081997158, -0.3548566356080343, -0.6818654218694892, 0.28278735989735626, 0.5455787356155983, -0.04070974432911715, -0.5046902777415262, -0.633626833356839, -0.6095164835061904, -0.22476776325772715, -0.676780425813228, -0.13834897965612786, -0.0049071632713250804, -0.19102748420471505, -0.790223655364968, -0.5999057690401781, -0.7767532991580008, -0.7114243321588433, -0.7818283091098995, -0.5054012067561748, -0.5006030603774893, -0.5710813925895715, -0.21413420482865517, -0.06485174237795091, -0.724995271239636, -0.5333490810699579, -0.5077364985466098, -0.7926503479306695, -0.6555420825251134, -0.15976162445966896, -0.5090172449145952, -0.5386767826518926, -0.34476215899487284, 0.03719899019915727},
    {-0.19248130806872643, -0.677391407439354, -0.6561084401845292, 0.44479777835849715, -0.6460552759163783, -0.591223295010656, -0.20154071026364295, -0.5548232566547718, -0.6857897820196698, -0.6481240222143544, -0.6653537135136455, -0.37534060499179944, -0.5454284889034846, 0.0033838402214099975, -0.6030289766310526, -0.5432272846625716, -0.573096099679401, -0.3895193428195331, 0.1076597284696324, -0.326618109808339, 0.0025001810522800785, -0.5363894732164961, -0.5060337360129098, -0.5559205454883872, -0.6821695989349739, -0.9459855297860308, -0.2773807577514147, -0.47430815668083315, -0.8193311480702414, -0.48297871536648196, -0.7641525109265053, -0.29752257088779, -0.6151989313906012, 0.017755806078691212, 0.19086748682149135, -0.041159830695615754, -0.44655423551406287, -0.7586055314329205, -0.7149586145852994, -0.24677718832104556, -0.5790782879106983, -0.032399715383010154, -0.12207310367036664, -0.04363254627996528, -0.3498132517203606, -0.9811626762195037, -0.39832896217720487, -0.6362081737826444, -0.6573790639724265, -0.6207631192369218, -0.745761486985472, -0.43567016365283984, -0.14053756656633826, -0.040079195976858106, -0.5893942251045993, -0.44104414847384227, -0.6870531359332811, -0.6822006049027065, -0.8434942532839314, -0.2886729433414708, -0.6275655191763528, -0.22838406281002, -0.4477526675845317, 0.47797099105437874},
    {-0.4644284026955551, -0.5003137388810108, -0.3557593133804542, -0.10285812101868555, -0.6021824239983035, -0.6280512076123886, -0.03478855500400291, -0.18941917382562004, -0.7953746526036682, -0.6925126531255172, -0.5078451286436508, -0.4332366168961386, -0.8534725740820023, -0.02025633450678656, -0.4231902508438391, -0.5688393381700498, -0.3429513703695684, -0.7183504711762383, -0.025073474644808844, -0.23698061778559612, -0.001084004806554255, -0.5009380141363806, -0.791095275675473, -0.6310752405427571, -0.5478263701459354, -0.5311333249770169, -0.5657152550762219, -0.5029328957426046, -0.6840438149669761, -0.6479464822303509, -0.3904915749995344, -0.3988180729859607, -0.4731187718774598, -0.04967740230662055, 0.13973222780839023, -0.09576158474923549, -0.6383950039577265, -0.6490818839060168, -0.6026123469089679, -0.203587244656853, -0.48795822458243543, -0.4610457126609395, -0.22865263048700338, 0.20988605579203545, -0.7549638460489806, -0.4967878159176554, -0.8194520968625293, -0.6398426327097618, -0.547478049901261, -0.6067749217080833, -0.8171887834616246, -0.6958296882691026, -0.2903700786707803, -0.1458992550377895, -0.7371510922740775, -0.7729305297962376, -0.4814677091458615, -0.8561174883128472, -0.6829864366960239, -0.2557773912458566, -0.8759168109362246, -0.1980967779682487, -0.20798316054567167, -0.06268986207857699},
    {-0.2000580017165612, -0.17054069480393466, -0.499298456210463, 0.42211899400579483, -0.5956860052342204, -0.5469217798154269, -0.3596957102014593, -0.2816157777424351, -0.7186571110507116, -0.6879394396928459, -0.6282430206996004, -0.49180648294968765, -1.0150089906302342, 0.23470562344081733, -0.612702686756851, -0.46426705681158603, -0.4942975620740103, -0.5363865521561998, -0.0479395720535845, -0.31176167366192103, -0.032314762149149086, -0.38932016867646035, -0.5294086538197965, -0.43747556159642026, -0.637701649228392, -0.41901943588362245, -0.6507565473399528, -0.4404794646894573, -0.7647156587584008, -0.5132661431287597, -0.25573325712410844, -0.08935163223501798, -0.6968857800756452, 0.3207057040789083, -0.10553611028789621, 0.18893498599953426, -0.6982455421235527, -0.7223318005789535, -0.609698405250132, -0.14828621361244398, -0.6008906127132936, -0.3547524228187331, -0.1842987031008819, 0.13236509857694886, -0.5576928433355166, -0.6837234463339928, -0.6161884935210011, -0.8880398868080442, -0.451160375595483, -0.689590349135348, -0.5612223596409793, -0.7508371715840444, -0.17513688396418164, 0.005280572459666688, -0.5052566683641541, -0.4768596688924588, -0.21424409995626517, -0.7638985193970712, -0.7736875914661685, -0.12408660709640949, -0.5909536846873177, -0.371947715133417, -0.4005598377601059, 0.25660649409452124},
    {-0.031008501929892917, -0.3034512266749972, -0.5248557117639561, 0.3924657777382481, -0.5942602328014799, -0.4390141880813625, -0.18497774656082067, -0.24792009149316607, -0.5584041085982934, -0.745324150369885, -0.5499602505503993, -0.6616264340944423, -0.5864281843654197, 0.17650383446891116, -0.6675469499822219, -0.7886554089547093, -0.46645844554227667, -1.022204734749042, 0.3447481007560147, -0.41289661550786705, -0.15848165314232404, -0.16793631996496916, -0.400676211248147, -0.5155364988888907, -0.7947041197654139, -0.31398107076756154, -0.3879887058982335, -0.7341460025772574, -0.726372253648032, -0.7437447731751448, 0.03979268277800075, 0.1231288403199562, -0.23276711343457307, 0.14224878802494326, -0.1695176302494702, -0.018517952208529333, -0.31924681666736987, -0.727263720460006, -0.5986725790831009, 0.07345508533165296, -0.35500052408097976, -0.5525559816225186, 0.14024229580055605, -0.22002331277535367, -0.554617259741383, -0.6509390523053574, -0.725414417149692, -0.8888296938997933, -0.642142505635393, -0.38041643826640315, -0.526525841273171, -0.6208916988018002, -0.6092023442589497, -0.21804114845977582, -0.3923701571777523, -0.7166119247906505, -0.5344161025364165, -0.7017909726332011, -0.6214951365324021, -0.2690108247305496, -0.5376362086308425, -0.30472596160168935, -0.12789527029540676, -0.22024656889144387},
    {-0.11051760237316079, -0.5077907421147354, 0.12986393447594877, 0.1349716583705371, -0.31656583971430524, -0.30160788112058845, -0.11868242647520215, -0.48037790474526154, -0.5066696680104651, -0.2804358843496394, -0.6227296131053188, -0.3807133689182121, -0.6677480476129958, 0.29354207939195637, -0.38463871806535155, -0.5774734609803068, -0.49769530610779383, -0.9337369521759297, 0.40582643375022315, 0.026827151978092267, -0.13982016879299528, -0.3135838953876103, -0.45518225966816855, -0.47681110644313296, -0.4835262976430719, -0.46727312205073496, -0.4010874523622286, -0.508945818680534, -0.27208443490964945, -0.6011327757394339, -0.24175529758502184, -0.040252444207955256, -0.37895158639757376, 0.34786818778219564, 0.08618206291132523, -0.11580896686855885, -0.5159846099835734, -0.4249715168163467, -0.639234854517331, 0.2560718064986496, -0.33108641590972043, -0.2991909887232909, -0.31632567580090193, -0.15057644350656935, -0.17256752685422294, -0.5103497728823644, -0.5408075353572738, -0.6981506371586647, -0.6469181092402267, -0.5561716169608286, -0.5209772944883829, -0.26656968176468476, -0.6407618267028717, -0.24759702659997895, -0.40501418171539416, -0.44762955985298924, -0.5090737659107345, -0.619924999362104, -0.6708566209071051, -0.18410157090234067, -0.4503415305559214, -0.11398170872616277, -0.24974296967742557, 0.4236006751514067},
    {0.275187490430428, -0.11302365288597371, -0.2546133026056584, 0.5090614103276678, -0.32647616369668453, -0.046995415292112916, -0.2635609706952561, -0.016709768821797765, -0.33808968066157513, -0.08520979520631906, -0.3644618125580594, -0.30657292861603624, -0.3900238440636911, 0.33526744024616106, -0.37829906672331026, -0.20197140316729367, -0.13790408290110293, -0.36244894058440114, 0.4334739291704471, 0.10622484198498237, 0.27513759254315145, 0.23665228120689627, -0.27469296210276883, -0.45396861010111444, -0.07750868796543803, -0.29141590299978537, -0.005238955962516124, -0.5093854808850811, -0.36688269395807743, -0.3149070279671128, -0.20226733019006868, 0.1139144430112289, -0.07740973040529163, 0.508927022446041, 0.36346338705280407, 0.10658192967809538, -0.5593190885981303, -0.5821978433720907, -0.4056294441434656, 0.5696465454579839, 0.22134152245070426, -0.0898175737191649, 0.29380394498613654, 0.09191754919535303, -0.014736128514012011, -0.4588887658429691, -0.5127690632336378, -0.5111946958313976, -0.4336536831537386, -0.4219716464166849, -0.16625365976895978, -0.28512776070316437, -0.08907454029021211, -0.06867835336295386, 0.20048423754812497, -0.23720858764502406, -0.3480063737828165, -0.40115662193952023, -0.4127442827486215, 0.03699058651450011, -0.07095690515199189, -0.1384401463628116, -0.05357824335434527, 0.3654392490293266},
    {-0.08439419069702672, -0.0047793568547245665, -0.3750322276055735, 0.1506800875598169, -0.08956945705173153, -0.30265868957834685, -0.17802910334216018, -0.33813572744903886, -0.2232281874125016, -0.4219063715400881, -0.29895540106094975, -0.10749983042800365, -0.4637624999094001, 0.05815884878670075, -0.6660357093351326, -0.6832120127626974, -0.40640866763500433, -0.7058014524055743, 0.07607232470212352, -0.20503449324544945, -0.2574635397497452, -0.4726556242347941, -0.455744509648879, -0.49727004863687224, -0.5249886859414284, -0.2638505104627831, -0.16677692085999954, -0.7213352492113115, -0.6354414071357568, -0.5411042049952204, -0.28673563311038053, -0.08412927179355649, -0.28754015123155996, 0.09834990838166588, -0.13809440264586828, 0.22370236193033696, -0.5791329275560353, -0.5021917088461918, -0.6296004474277753, -0.02443210859245674, -0.40133655627304426, -0.13604569396118874, -0.14887355045569176, -0.21140502706687542, -0.578102080149858, -0.6029416543660138, -0.7866549044159187, -0.7547906523702308, -0.7177857174572312, -0.19886994097776634, -0.4983181057521446, -0.4557937568036086, -0.5105753519065923, -0.2233528042333277, -0.5734011300724691, -0.6811901482658034, -0.376592095186581, -0.9519106380229411, -0.5125170885433075, -0.5220891087576108, -0.4911442128625164, -0.25420861751429985, -0.5125607277261194, 0.2502154218104197},
    {-0.07999255692569561, -0.14201359355873655, -0.3939997582852514, 0.1745004591119499, -0.46661384382914056, -0.2389493843126938, -0.4308552143759884, 0.04412834160998765, -0.8644994924105128, -0.8132520998214902, -0.7901607890989633, -0.3363410873035529, -0.6588738890382041, -0.1640324826507853, -0.6609272616249499, -0.7657669531348782, -0.6930825256114743, -0.7999720043721912, 0.3407901700747795, -0.5798607809293655, 0.0005397257932663595, -0.6123168191800297, -0.726773417239492, -0.5974792739138706, -0.8379137722753975, -0.6429576765488376, -0.3411175529893712, -0.502102765470346, -0.844998499487452, -0.579861428735962, -0.3499224331307168, -0.27668322807961526, -0.46902155242647686, -0.1477614084575629, 0.17302474721683436, -0.008283399831266702, -0.8579033052990739, -0.7257829274381346, -0.6378056960502723, -0.17350791443573327, -0.5339560932820574, -0.5096142379893038, -0.4227609140303036, -0.08825475930494048, -0.4324201683027719, -0.8357361238566949, -0.6997336073915502, -0.6895506863598274, -0.6955177788989874, -0.495730980159037, -0.7747649269732703, -0.6582592718789807, -0.4334848381830627, -0.17625592534887402, -0.8313563692719008, -0.9933928509813803, -0.43353896075592463, -0.7066031721247624, -0.7696321102479585, -0.2955221230241653, -0.36433429487555113, -0.8235210776233166, -0.5140621327754882, 0.14447873939880343},
    {-0.4397705538185402, -0.3982972998343845, -0.6592244565611548, 0.09284781484452585, -0.5475918530340994, -0.552578053413644, -0.696511811754402, -0.22855975876875834, -0.9434179986837973, -0.6449422203805093, -0.490304748223641, -0.9104194187186508, -0.8308669754720933, -0.2880281280613665, -0.8167328440662625, -0.4723211117165775, -0.5114291268138957, -0.5464985849341841, 0.21480672205647833, -0.21927875570802413, -0.19751492759164405, -0.493796538746757, -0.6742123540097413, -0.7361725310731911, -0.8210217635076705, -0.7306751519291552, -0.7562546087184978, -0.6098873623316056, -0.6606578516772514, -0.6073408667815804, -0.6411484250724901, -0.06393145082398692, -0.6128936633467116, -0.022243533052708295, 0.1437980603413517, 0.29434925857713695, -0.34709665862127026, -0.9040642048103423, -0.5011248620685267, -0.20560335274381006, -0.46326105357808695, -0.0375453258444061, -0.25428881104067325, 0.11385945883150755, -0.4030337887548309, -0.8124112280648091, -0.8503213631093, -0.953984921242184, -0.48478503622202285, -0.6777285133162517, -0.5836354212437028, -0.6546575622682431, -0.721040432176248, -0.3587726242588356, -0.7826121569196977, -0.6033960772344054, -0.6624572797625199, -0.7441438915913796, -0.9187172392135802, -0.2994368573548842, -0.5939051821099052, -0.18925118703448157, -0.05258217559132372, -0.00639640521638457},
    {0.29777673173732505, 0.02881906071897208, -0.5265136526531238, 0.7860626357775952, -0.2716154051206739, -0.3395850148657358, -0.10629931870372233, 0.3868161926378527, -0.7531165197615937, 0.08877443875652252, -0.5111358041427615, -0.42580546234070926, -0.5179757097612355, 0.6501773902235899, -0.6419474405010209, -0.35919846270416755, -0.22096288428607405, -0.7523581593779919, 0.6623862999566787, 0.21946182604495254, 0.05053767610947303, -0.05003641693096968, -0.39170681211984715, -0.44454066106256246, -0.4670000689740165, -0.1980179219838053, -0.5622986859821977, -0.6728553238573303, -0.6002027223798965, -0.4006958178614326, -0.367742658819548, -0.00038605503515447314, -0.5203209661613147, 0.3660363133507356, 0.4597770241336508, 0.678077122717545, -0.39502073034460783, -0.7110446038960044, -0.6719673180282758, 0.30598552845332777, -0.25818329620113023, -0.06437027557884767, 0.6473019804740645, 0.5244232235711991, -0.16993004581015644, -0.9012701725370688, -0.5293557366930052, -0.7953817343136406, -0.20516314089965726, -0.3577383263473915, -0.1550163453035178, -1.0053889983096342, -0.2396131227197684, 0.34768251344968554, 0.1585843962860934, -0.5957791980661292, -0.15060620394606658, -0.6492966891478833, -0.4443355645574182, -0.1737064962081067, -0.3555484298162716, 0.27095645810799346, 0.11647827328589407, 0.7327972947360987},
    {0.6315453838351645, 0.20581990192686633, 0.02256875749017113, 0.6281884100828413, 0.021494242007364557, -0.11201648854586387, 0.07595824963888223, 0.5989288585928285, -0.3926246861218693, -0.11525320301898648, -0.3309971047979474, -0.06870863564316955, -0.6720647513331577, 0.6654950316092306, -0.4946722213845991, -0.8023119255128006, -0.29475182692340446, -0.8710616965588508, 0.8306209406134674, -0.20679817477348736, -0.14138864240275734, -0.16711951324272684, 0.13469909782836503, -0.426284303427116, -0.022139345359750266, 0.36218019714227967, 0.22330155998802503, -0.5193590328551431, -0.7248963582374868, -0.6686611238205724, 0.25012848098994717, 0.2707745755736032, 0.0943280265432438, 0.5261238105933647, 0.33302974769081745, 0.5890357488696766, -0.22704059473471835, -0.23631586003867228, -1.005823871044242, 0.3068627287745124, 0.27876800222407433, -0.09162686950899379, 0.4049279983496001, 0.718383963519943, -0.23314975870871454, -0.7306490753056165, -0.4195277702599186, -0.9791949021208602, -0.28346538962461126, -0.21918218435549178, -0.13011752974947807, -0.5821310181736679, -0.39881530607725146, 0.28985833326853483, -0.3256699130505183, -0.3432586373188902, -0.31764445763792737, -0.5893844880255473, -0.22901102981369875, -0.12048492517827696, -0.29088568167484086, 0.14996429476234335, -0.023023664916805707, 0.45719502875003004},
    {0.1944432939457267, 0.09809052995883549, -0.32301346459862007, 0.6560571128742331, 0.11620799130150716, -0.24077379185461598, -0.27156897218763043, 0.3378032884320993, -1.046189041916374, -0.46637278895923934, -0.47158487185384845, -0.43500387956887115, -0.8520667899107016, 0.2322258275250236, -0.745844145951393, -0.8131491662994554, -0.4861254349138338, -1.0807429298669446, 0.15314166277505775, -0.05920691343850909, -0.38763138745591386, -0.36458804375869786, -0.46447736849373716, -0.4768784092553874, -0.6372252330758984, -0.08261902130632942, -0.11379208011015088, -0.48412766948314967, -0.7268820759802921, -0.7779528885277756, 0.1828223253300662, -0.22226275251374245, -0.26009724942949913, 0.16370855613391974, 0.40643815032341407, 0.4922744985381328, -0.08562504545270849, -0.6046060647488471, -0.8048358624662588, -0.010599248637818729, 0.3045067426614241, -0.30831740163481963, 0.09392892386407839, -0.050870029387028046, -0.47853275172042425, -0.6965747751116095, -0.6365017751631113, -0.7631971103462614, -0.6884764688046692, -0.5178699420128406, -0.43232026805031426, -0.7131566602666725, -0.5027854721225357, -0.17347092268378173, -0.5276276940443216, -0.8254620494978872, -0.5601818798795968, -0.5724758890846839, -0.2788759040328591, -0.32900332829643186, -0.23298706007009826, -0.42902668886181017, -0.35598969805851793, 0.4981239733566734},
    {-0.30095722407110054, -0.44608713990694715, -0.565834225352103, 0.30922397437233934, -0.3506182217153937, -0.47984102884331165, -0.210309102777823, -0.2484504186183167, -0.8570125524587964, -0.5377456163518486, -0.26896269816065865, -0.5363022373498498, -0.7849300371320806, 0.0790286247524983, -0.5765036770653821, -0.6291412888345129, -0.4913267439832196, -0.6130298204644026, -0.211352147934291, -0.2892487313700057, -0.3611366326207398, -0.6356536202183107, -0.5896283570389974, -0.8233940129166585, -0.6650576242691659, -0.684282237188892, -0.591204187620702, -0.7016608452904509, -0.65972922111632, -0.5737119851814759, -0.35186418827562316, -0.3204168081275405, -0.5064921594382447, 0.12298716872369564, 0.20168078917702503, -0.16133635583375375, -0.5500432760582489, -0.7614642580166977, -0.892442701090892, -0.04923877876775581, -0.24391724988171598, -0.13591941022782442, 0.045736753686369286, -0.04559132890224516, -0.6308270491375563, -0.5305124040946737, -0.6859442711259834, -0.6740826394991335, -0.6731678919951688, -0.5954122565381496, -0.5719991918350581, -0.4289465559773335, -0.5233839434031733, -0.08096864919300877, -0.8042598164647143, -0.971803389048844, -0.6357017400799164, -0.7169114208097707, -0.49039952634611805, -0.32150526509507277, -0.7543621171977821, -0.45842964212425724, -0.17756207446281635, -0.202830059981222},
    {0.21153648337241937, 0.015365108172810709, -0.33744097781935595, 0.6818359638124338, 0.252000984917657, -0.11995123777346635, -0.28606055640891137, 0.10180039400103348, -0.8057783090428754, -0.11398622554775932, -0.3335889416256127, -0.2676738551851665, -1.0122182445880274, 0.2793526241847747, -0.5451958157668216, -0.8035380123276616, -0.28859163251602443, -0.8963553028851997, 0.22030695840824344, -0.2722074162068548, -0.32568980777821566, -0.2576033884415464, -0.35749737736432247, -0.48895373483300514, -0.6243184842478885, -0.17219737031502064, 0.1923842959119838, -0.49955268095641875, -0.7508112938769372, -0.6511602230432222, 0.162372248113956, 0.13383595524631584, -0.23882646110267514, 0.30684314542122915, 0.250380658838298, 0.5060348115916352, -0.05546090088002569, -0.24435335220871243, -0.8371442114585418, 0.22671212768328328, 0.0564378114528505, -0.4959852003650274, -0.21079654373216908, 0.3324500413361488, -0.6282223331997057, -0.7628394497162696, -0.5173784194740654, -0.8301446616427763, 0.027188257334002944, -0.3501750263158954, -0.29117750099399053, -0.40831166268203584, -0.5849012975590402, -0.06179444586485633, -0.7115672272940708, -1.0364004920521102, -0.4609038924055847, -0.5113204503309285, -0.3593017540412697, -0.5544122628009627, 0.0658170569180978, -0.10198505532345778, -0.330276541208365, 0.3746091681579448},
    {0.3628215022465059, 0.16985241601727288, -0.3212821455206782, 0.6672841252013177, -0.13881735147890822, -0.632972719021225, -0.21495117345288167, 0.278901539701844, -0.7069742605203849, -0.29311814256901647, -0.36931487680469177, -0.30086951177136373, -0.8102725423280644, 0.38844188108147004, -0.7846695128324089, -0.8632563479843883, -0.49058146727311597, -0.9782288478411331, 0.2440285782957272, -0.2718526489656866, -0.5119667308393158, -0.2344032488800368, -0.46053663819920254, -0.49219593903781195, -0.8355514618742255, -0.3226049952354979, -0.16777276641185618, -0.4889896966400985, -0.6706602106067076, -0.6079201514549706, 0.044803426323679, -0.20515160874860175, -0.4106695773782825, 0.47787254294462017, 0.053259125018981245, 0.3663278716321651, -0.2983428110294167, -0.674904189800626, -0.8862565690804051, 0.2568737675272609, 0.1351779225186845, -0.3203798867673771, -0.0408214715306916, 0.006265429193579453, -0.3181472439846111, -0.7706004791712208, -0.7079493037839528, -0.9793647903847353, -0.5444816228184385, -0.5499925706354146, -0.8103813085992638, -0.7550346608136002, -0.6322077268435841, -0.22951158170837974, -0.43525433568649263, -0.5030475689816513, -0.25762443517725164, -0.6732817908778427, -0.667617888704456, -0.20342455089907896, -0.3792701061873021, -0.2968356186876391, -0.6126976415153081, 0.5764499181927014},
    {0.3061340011120044, 0.09675301083297079, -0.40245150307381405, 0.6015752441889008, -0.3780518404280889, -0.3299862754958816, -0.3144299443499916, 0.05868735172783645, -0.859636054879916, -0.21699619662582764, -0.48714007759761446, -0.3947361511451691, -1.1198117452564025, 0.3022262117586217, -0.7813866954213081, -0.7959809391230529, -0.6004591721087326, -0.8863806891160352, 0.2675483788346295, -0.2644198771338467, -0.40307966218619184, -0.15158420484604346, -0.5924228308879919, -0.6422671386215324, -0.603996875367805, -0.5110416564853878, -0.08168752519117946, -0.7705240331650927, -0.6477861174436063, -0.7346286535686293, -0.09644593624419455, -0.012563625972858521, -0.4503814550961311, 0.4144696661947549, 0.33874061081295437, 0.4022588645933923, 0.008208540553392216, -0.7439205891930225, -0.8691693857962226, -0.027330734371679242, -0.17421879939176851, 0.0068625980784672285, 0.16665911014966858, -0.03655199915985391, -0.37344772321427966, -0.79656479333594, -0.8643016384340684, -0.6052845793943957, -0.5309317992300263, -0.5082945058635232, -0.4806803730181572, -0.47918877348287964, -0.7383344612934809, 0.23663118330664165, -0.7905350778583783, -0.9651392594926377, -0.5132858373722874, -0.6847182676346338, -0.6100039947960406, -0.3735035331012785, -0.42953998022956735, -0.4175055206691441, -0.05327247856150603, 0.3018317861405895},
    {0.23857382032514943, 0.20375879309042777, -0.25167166025894266, 0.637138100229063, -0.007039397231554996, -0.29771467330836937, -0.3524107655155875, 0.1754824798624727, -0.9486422487122557, -0.36262234735098403, -0.27401512035105346, -0.41591733404738, -0.6861367134529138, 0.4247380340453982, -0.7102048753011133, -0.7147378875423245, -0.6136640320844184, -0.7195525743705008, 0.42627483471309885, -0.2506181123521178, -0.26874885264424275, -0.3962764322801349, -0.317313851249101, -0.2530519133937426, -0.7633583156089399, 0.05349157093210282, 0.06003818320062083, -0.639006767883746, -0.7856495794351217, -0.8399154545956334, -0.19665478579236073, 0.5927978867618194, -0.06970727478481765, 0.3230079093036226, 0.27636049484933217, 0.6099362228131029, -0.15844613340927824, -0.5744900523210811, -0.7113928986006606, 0.129617009594912, 0.1869403258443531, -0.26406201921764144, 0.15548933765999218, -0.008383078325323104, -0.4837434575273332, -0.7178991518056934, -0.8122362463137068, -0.6197989151727796, -0.38749634394559307, -0.6272834143359579, -0.3594645249858552, -0.6573042884350629, -0.5009083041246297, 0.03187822832579462, -0.6234610385816852, -0.8271745927686629, -0.33806919690000986, -0.945767259902349, -0.7310960902901348, -0.4099036388119027, -0.2564109748348285, -0.09677340300169417, -0.6188862965977914, 0.26215990282757096},
    {0.11688779301445215, 0.34639066633247817, -0.44976980483106016, 0.6890979006083716, -0.4085716124542075, -0.3264653428191282, -0.2205837463031023, 0.2485187496057156, -0.5417029414970796, -0.24781914782912454, -0.6750636454777711, -0.3486404150858067, -0.9908097780263033, 0.3643236757500491, -0.5888599275763696, -0.7091197874767607, -0.5369431744018127, -0.7637275003888108, 0.36362763080607413, -0.07246784057951601, 0.06284913968491267, -0.42992928372468836, -0.2110648498803459, -0.32205138422312235, -0.41766781708364953, 0.03064602199153786, -0.11926724404514116, -0.6500260623343725, -0.5360498258950361, -0.4210338776012151, -0.13262973171821282, 0.2207813144999889, -0.0801237140481113, 0.5198917615481945, 0.5345368834699907, 0.6387780245089502, -0.0715377782211949, -0.41436499838850627, -0.8841724210645017, 0.41234813409095084, 0.23368596468821126, -0.2642663850094251, -0.038219088290076954, 0.3783773124848113, -0.6795423923268349, -0.5736679546680997, -0.7903257040595241, -0.5743630315198427, -0.4273648375939758, -0.522310177033571, -0.45822815751259, -0.6125463752110002, -0.6167091151084847, 0.20792520267392123, -0.0013095922327456089, -0.7243918359985845, -0.49171385985608984, -0.9885479750103537, -0.21733047148564377, -0.526535397633516, -0.22155212107458905, 0.08476910440041828, -0.25920910949427073, 0.4842550083938167},
    {0.7240445552083628, 0.2290164434788408, 0.45401111440432834, 0.18388310718328638, -0.027682916342746944, 0.21461579953039253, -0.7251141432412017, 0.40688536922501517, -0.2020981545767074, -0.6999090338952989, 0.39470144288597675, -0.4741437102811757, 0.24119036531275045, -0.2776001502310297, -0.3614637650530873, -0.19353947820299255, 0.40538425233703146, 0.15445901890065958, -0.6313844493248039, -0.6322465648220367, -0.4034303702267353, -0.06980273311364228, 0.4149274451636892, 0.6248696590413708, 0.20422684826231824, 0.1607235167729021, 0.02288330675144819, -0.4915631666793593, -0.4546703218052733, -0.09247399078368483, 0.3620443233445453, 0.34064395138968306, 0.31206998512275635, 0.1335247300102475, 0.8345844853048807, 0.24033082555091234, 0.19373963125848984, 0.27860464327391693, -0.068705191588019, -0.4556853597651539, -0.048684857948946315, -0.3675732247301931, -0.5415394740789616, -0.6145537266313019, -0.5827381025330153, -0.09825835467510323, -0.3533337628713856, -0.43466056062536657, -0.27606640961476614, -0.6130934626672107, 0.09842497969663945, 0.2945003382618336, -0.8001556332312073, -0.424297907340365, 0.29121873413391497, -0.05220652901913398, -0.3921483655848814, -0.11655262456795987, -0.06814673425527422, 0.3720066430152069, 0.4046603119482519, 0.5266413141878613, -0.3473239250371509, -0.690391930751625},
    {0.47265685337564706, -0.03239268616488985, 0.7121078390966372, 0.10061003817923551, -0.042321623382309284, 0.16973932764366045, -0.6824209971894694, 0.7557986227368165, 0.401326958729224, 0.019377513103745643, 0.5100156285169388, 0.18179958933990595, 0.4644232152115154, -0.43104567303148905, 0.14960873046728582, -0.11563990062962665, 0.7660973672645778, -0.04747941099253821, -0.29340729745713884, -0.10880894670624723, -0.2822036155862209, 0.06459071061692263, 0.663794427567562, 0.4624489053564785, 0.39194191977155174, 0.2563484250803209, 0.24175206258684148, -0.24005721222367077, -0.3333148708006567, -0.09909625339096487, 0.22466472572663274, 0.7416834985346286, 0.3442990786381961, -0.009576960738427632, 0.5350234598237487, 0.4053573830989377, 0.14597094742810682, 0.1460978824603169, -0.1077611583675524, -0.31605294094798214, 0.08046762617791957, -0.4522567797844285, -0.8459650935681019, -0.42074526187199374, -0.8338789715346179, 0.20574248409784465, -0.3733880426688476, -0.39809107609171285, -0.1735423417190728, -0.640060517473841, 0.5626851210230547, 0.21010151484104406, -0.6324253884294908, -0.6554217238731646, 0.31765529219106103, 0.03450938168009208, -0.1377572773510504, -0.004243828898311812, 0.11182339745309061, 0.16847351201454921, 0.6486332063394582, 0.7729628869203927, -0.49668763987741216, -0.5261903462299281},
    {0.657423437980851, -0.018713087164092677, 0.3179064892543852, -0.1424275910953068, 0.37713242957041504, 0.39813280858288547, -0.8526638937069302, 0.29839165695147835, 0.2716580324758739, -0.3615310780761921, 0.36219888226647184, -0.05289268251256166, 0.057469311882058505, -0.5352382023796928, -0.008688089877132401, 0.07940594094174334, 0.44384518353971303, 0.31001066422287765, -0.7375808372445942, -0.5406890605177979, -0.6404005850042183, -0.1264720607815129, 0.5518944006718948, 0.733942655268419, 0.3540346856888213, 0.27938472251558777, 0.4092386220810665, -0.1879947615713817, -0.48905378296821456, -0.015358623649073316, 0.18596191360341546, 0.6620873891992034, 0.5224551333250975, -0.08401435970416432, 0.22627225411077304, 0.8810023631135712, 0.5258679059992784, 0.1980353043525921, -0.14562152566715567, -0.5573283574214931, 0.4194688282310764, -0.4061785264440439, -0.3735538458717903, -0.6362926137937359, -0.47573798308139037, 0.19073144540783066, -0.34785589542810597, -0.4509036382245036, -0.31669647481793567, -0.7293591986585334, 0.5573118816345785, 0.2185264498168828, -0.6859691226007141, -0.5491147248160476, 0.41349653650348367, -0.5269981845590844, -0.2559105793030061, -0.04640403497843615, 0.27266790484535847, -0.00737288552234155, 0.16929208387650557, 0.5635079041388985, -0.8251455346554952, -0.3885357617677201},
    {0.5761488833658475, 0.1939263501237915, 0.40324528554510364, -0.26124147169460504, 0.26594640764700794, 0.3861873806756397, -0.4774857756778301, 0.42519467052664467, 0.5637668957946776, -0.09203289042659873, 0.7352527426258018, -0.5203712493530536, 0.2952150065283001, -0.6183632799139197, -0.08097384978314637, 0.06952049853640693, 0.6770110359102303, 0.41140155676342205, -0.24355905337441452, -0.6106347782020405, -0.2679094447825413, 0.18367425881806257, 0.6055043223661226, 0.6033169163876568, 0.4437428568531991, 0.3720945535688203, 0.32183956625527366, -0.42620410203835396, -0.38036202687711634, -0.08997694515097668, 0.30530708708799026, 0.8190397944829991, 0.10588060247162248, -0.04600486233180855, 0.5147019228262464, 0.7478100699153164, 0.5968152384836275, 0.37136311102702696, 0.3570390615387, -0.2155639850076552, 0.3512507375636452, -0.44373911438889313, 0.017811942022795985, -0.598753482494213, -0.5060428006388639, 0.4755795593610888, -0.5369775240205787, -0.16060507900448584, -0.17046247107548546, -0.6079766835679383, 0.7799079403450796, 0.035517837302094776, -0.6004700727587438, -0.6262676903270709, 0.892903430413971, -0.14258339917571503, -0.5708993071552223, -0.057911170656954246, -0.043218525792566576, 0.235387037236024, 0.31427511720898627, 0.8291688818412503, -0.20291375002010634, -0.537349887717271},
    {0.5931725509692303, -0.19375139281568562, 0.3287559323952093, -0.4850573766426957, -0.12546309279231482, 0.3706041078814556, -0.7085920088292794, 0.6625431111893558, 0.18869249643904565, -0.31246537113582146, 0.7281106207237298, -0.30359935205759925, -0.13593082417242733, -0.6243967526035458, 0.15794554946139808, 0.33835518853314883, 0.34996586321756146, 0.07853752935451541, -0.4850597419955998, -0.4405697282176471, -0.09791575028950668, 0.18422132181933004, 0.9336856348873328, 0.4736595835025214, 0.48008674854486366, 0.47164190371600456, 0.26459964962021615, -0.6280823888855329, -0.30914371248042144, -0.07554544275432483, 0.2621026652446334, 0.6301772414400525, 0.2288028147832646, -0.3604238950655432, 0.4437412017560719, 0.6927181314695315, 0.38922754833847134, 0.40506788520368636, 0.24977406912157452, 0.2600336515016338, 0.17013918101058054, -0.35457979211282137, -0.005287335869814385, -0.5892013997445018, -0.5378597757022368, 0.11914371785567111, -0.2437737812286059, -0.08560397025296851, -0.03287045278318009, -0.44057333257670644, 0.7098262662266082, 0.10325893371573344, -0.47043588896099703, -0.3044356469391599, 0.560521330087878, -0.3712092957092061, -0.8153385562079898, -0.2602316300576024, -0.4791079587338465, 0.4173123360386662, 0.4069744355335236, 0.6415954510165247, -0.3288659515837712, -0.4500555246790177},
    {0.7631364188671291, 0.2357803810128457, 0.4694939172099828, -0.5612619773991204, -0.21798077588443351, 0.4163940688175568, -0.6550299475801742, 0.42163561826664064, 0.40449495140806674, -0.20147326049866296, 0.4665304020791426, -0.5281393580151478, 0.34488547985602286, -0.10971626642824443, -0.0707546611355671, 0.3464336000921838, 0.2965125005498965, 0.10542397401104996, -0.6641486219268755, -0.43197749965372445, -0.3181161220296141, 0.08680574938871792, 0.7531654380024756, 0.1350663195248131, 0.4211988664061994, 0.41368385665218377, 0.4370240737413704, -0.3711908160934619, -0.311338367277099, 0.012611220953018407, -0.07145772239167651, 0.29550851338402756, 0.28530523859767837, -0.15369116857491086, 0.13698974929070598, 0.6764529675081831, 0.4195310463299945, -0.17920291124059134, -0.30419311847440433, 0.12107665111568948, 0.4980210127103396, -0.549395592868108, -0.6202996739081216, -0.5993886814480074, -0.6517169745675327, 0.22404294897611995, -0.6788435074089431, -0.2402381207484573, 0.05256004806283848, -0.6564757591897954, 0.4142227016099364, 0.2772433655014469, -0.5596280844176293, -0.8236584731774892, 0.1703608081550755, -0.18083907908100869, -0.6463266567660184, -0.30234108107695873, 0.10667427860515674, 0.06338387752392133, 0.5602234515666186, 0.5881618460742678, -0.5704397316834585, -0.8001341312462562},
    {0.7224500810054587, 0.25871665082483747, 0.4836923815611212, -0.5414113393714507, -0.5817127021593943, 0.405248176441222, -0.781037865631825, 0.41657170727611903, 0.42914174684274253, -0.11623100483889144, 0.5906199748636606, -0.543764390372052, 0.04320900361330784, -0.5624171395071081, -0.010679078758502, 0.2531351286161146, 0.48271844359619287, 0.32135151987505955, -0.6527126286410065, -0.18747989842217339, -0.07207378221072397, 0.20888637394813217, 0.8619778297282069, 0.4616062493780355, 0.5422188289237317, 0.5235588250238667, 0.37464978650134323, -0.40957790505817343, -0.4877831709103018, -0.374575895598825, 0.06300120661964112, 0.6460310635392568, 0.5494237464646551, -0.22559243736510448, 0.5800063258584854, 0.6490098633756118, 0.5462017739964332, -0.12477523766849832, -0.04529758211447761, -0.13332635935353615, 0.21889535426591666, -0.43924846820530994, -0.4197157481689803, -0.5018270717914884, -0.7548083276154851, 0.17407730975085658, -0.3180973398665225, -0.06766706632733308, -0.05330169693210576, -0.5059275517790651, -0.027602183447594266, 0.2927760931845151, -0.3851744240623439, -0.6520204900383183, 0.5498734456659524, -0.4756772861470487, -0.6144326720811405, -0.14201424364824067, -0.29065552189275673, 0.13074148258253224, 0.6390879810648473, 0.45370150184347224, -0.7573125935551991, -0.7445068799902532},
    {0.8156320313849015, 0.3777904663805881, 0.5853945332378244, -0.3524467916694388, -0.1588349312077926, 0.26931925513266364, -0.8391565603039102, 0.8810113775096966, 0.1976867044220203, -0.12434340680844368, 0.8311788328255275, -0.6730795083638124, 0.28590166774160436, -0.5386800153486996, -0.0718250721929783, 0.32321894763301445, 0.4754327245183453, 0.4775620820881962, -0.6059979731383832, -0.5236106267785398, -0.33070083681712537, 0.0841850382844186, 0.9392941320119866, 0.455471257626702, 0.17647900891358945, 0.3894733423738361, 0.5502499796662077, -0.3959807572295675, -0.502466073621215, -0.028280982234848536, 0.24042084779379871, 0.8561112928188512, 0.5500120948465396, -0.288638585494746, 0.36183104784437903, 0.44955728437011416, 0.7193252359474474, -0.04580125942584557, -0.07546188500939519, -0.12283613425332626, 0.23417390454294115, -0.7179428425705459, -0.5597237779796023, -0.37106513566570337, -0.6583062823650662, 0.12015955230123707, -0.6908338239142143, 0.04700696088095719, -0.2764589301542172, -0.6777440390817396, 0.3796572899206027, 0.37826244366907696, -0.18087001992350446, -0.6869181871868313, 0.37080554940377874, -0.2855265729206444, -0.38271025293807903, 0.17895541892595607, -0.06938383563269518, 0.17841085851644906, 0.6767211001166743, 0.6458003775477907, -0.3042452111919095, -0.7273369103932648},
    {0.7992730402421224, 0.37881061139664796, 0.5995321292724247, -0.08175411802893433, 0.20334811464555536, 0.4790823361172726, -0.9048524765953733, 0.4938330366945574, 0.19516419284013756, -0.3376550146741789, 0.5618221789349702, -0.7506503042407094, 0.27308751918490815, -0.4895065215109652, -0.3928092875982522, -0.09079327008812255, 0.388234182521531, 0.32288680981844237, -0.34667630356847373, -0.36821477864273144, -0.3271181607897077, 0.22219963639789078, 0.4531241536657099, 0.6120912488923189, 0.631400471478075, 0.6447489733366352, 0.10101399266789501, -0.556787871171862, -0.28889967045549836, -0.13148756314174134, 0.25758139959266363, 0.457055966492239, 0.4008212137698108, -0.4315849810867654, 0.7067460452768902, 0.600495834041733, 0.6385569092130038, -0.21496271338303272, 0.22133363161550135, -0.38051512946773347, 0.632538439177021, -0.7059525526214762, -0.6612594618412847, -0.5180295619443032, -0.5873847979790259, 0.2174427162704387, -0.6058939546684653, -0.1287306091480974, -0.3238467394752304, -0.3728912759265921, 0.16761936151710408, 0.6410450552410722, -0.23609964212616258, -0.5231768354210836, 0.28887187793329533, -0.2824614786855217, -0.15256280947320958, -0.15065308081083445, 0.07722456419603974, 0.22026645973958195, 0.7063467821766726, 0.49796658393546284, -0.4911148663147548, -0.48905097893426275},
    {0.8242873270044629, 0.30608796786573916, 0.5322380581085697, 0.13949696348813767, -0.1295351341767635, 0.47902750510080205, -0.6988163405983865, 0.7325552173341067, 0.34233254280212777, -0.5003495811818788, 0.6727466682013846, -0.5968706371498037, 0.05360679985464038, -0.1453651335727157, -0.22130635493880696, -0.0165021880346304, 0.4196147714806785, 0.31616022727525145, -0.7578058960641356, -0.5245939127581675, -0.3488344704702449, -0.0893154536453743, 0.5435904144411571, 0.6051109092473307, 0.5310164000810085, 0.2533629182695628, 0.036065357135456326, -0.2406994696823751, -0.561797953867665, -0.2594477926836825, 0.6758336709425609, 0.6249095339229607, 0.18439821736020118, -0.07758583735906861, 0.9086055480858366, 0.5000506995197668, 0.5955096766624616, -0.1091422670566918, 0.0916661009411905, -0.48437792368092675, 0.359059076988647, -0.2653593380893662, -0.10157498585326791, -0.5589206170391784, -0.405079719645236, 0.27464983769046614, -0.5576793457199488, -0.5367805733228285, -0.2582822065520826, -0.836568156719305, 0.18621398876409684, 0.2448029123530665, -0.5195180240487658, -0.676051407188404, 0.6240700694783153, 0.04331282538778113, -0.3409596790218778, -0.04791960497511939, 0.19719328732420455, 0.02855151255986129, 0.5547272239409307, 0.7823139644940371, -0.4460056541983108, -0.6499962436205126},
    {0.9239665393995024, 0.20630295832352588, 0.35035491004291813, -0.0728169652701002, 0.060373768477995145, 0.183335442356565, -0.6482080167505663, 0.939332038992913, 0.0046992971664369275, -0.13716692717234075, 0.32915017020499376, -0.8472054487295275, 0.22232497722454664, -0.5179545279099944, -0.3912886079752546, -0.04244647440149455, 0.2823274370291801, 0.05444883527822289, -0.4084347564203758, -0.7630464265324384, -0.1554445250611264, -0.19703561043472448, 0.49097293256337254, 0.4454124613399666, 0.39293094886889934, 0.40622034240472676, -0.26380330970343013, -0.41197359724153504, -0.5385156504320158, -0.21833504356673947, 0.39991668892141996, 0.5923316617722308, -0.14180509106235167, -0.09175365419018981, 0.512903926264503, 0.6357192361627951, 0.44320966268992873, -0.14194594283824313, 0.23343381208808497, -0.16401919107387827, 0.30499419948219236, -0.40358120517929746, -0.5519686337034349, -0.6038968830117968, -0.6769609551387615, -0.11013539313427999, -0.5727627979563277, -0.3485401365237714, -0.48793880049739313, -0.5852468001609925, 0.406669274934905, 0.1664032690055694, -0.5812074973406904, -0.7131135852334922, 0.5113642426013648, 0.05696923104078251, -0.24182458713173902, 0.035072829050034525, 0.16408119236584764, 0.37100776835861793, 0.5502478045362975, 0.8447291977565615, -0.2606959949494714, -0.4914324593055743},
    {0.8074583114293177, 0.08124957012213749, 0.6003927027104808, -0.37017095357953983, 0.27129143661941807, 0.6092583002247072, -0.9545009537774458, 0.6345006030767125, 0.32132395820821924, -0.0785002853884568, 0.5477673494123095, -0.6369687595141933, 0.42944931628886107, -0.2872842441839496, 0.04451183169073202, 0.11024928990216329, 0.49037108915189725, 0.348172879012952, -0.618638624585582, -0.7372312466316795, -0.329745833886212, -0.008709799744684252, 0.5477590222718908, 0.8643527322668711, 0.4999864694115212, 0.3738563643525479, 0.05380490112422919, -0.5360087141222472, -0.4747013944574224, -0.4449940384632294, 0.5932593350317049, 0.8444836492020411, 0.3786739262475036, -0.2970812343344584, 0.5221461047017302, 0.7273253554198462, 0.558502807752438, -0.16351219139145745, 0.034839534286297234, -0.38870840452233596, 0.8738390763313414, -0.842102762085373, -0.6366728153281472, -0.8666294921714631, -0.7076201183584562, 0.07832904020989566, -0.7765298379674214, -0.394204099500614, -0.3408330027683994, -0.37999339834918666, 0.5935351100329811, 0.2592422765993604, -0.5421703364683906, -0.4756896554846282, 0.35516968993403564, -0.2270389791859876, -0.3706160795573822, -0.107028463052805, 0.4282123345292275, 0.3199042565026487, 0.7606055512191645, 0.7842429034608481, -0.24129660618642235, -0.3428735247551873},
    {0.7085548269050402, -0.02938817202416211, 0.610700231716628, -0.08749644925995059, -0.08777064758588883, 0.47723763276851, -0.9072402008101393, 0.5427737079261844, -0.0015756129553687686, -0.08337786625265219, 0.41796234747155914, -0.8134672602075212, 0.465177551074751, -0.37514455266966396, -0.02166757126906356, 0.03210029987589221, 0.5346232545580757, 0.254266708556669, -0.5441308028878905, -0.6050531843931959, -0.3476005739524265, 0.22943158702694144, 0.6947541450700303, 0.7838752703434367, 0.13707535798516715, 0.3451773078096363, 0.09361411935655113, -0.6144282500213865, -0.3937902675610216, -0.269295806375469, 0.2848271936600293, 0.8297151341542875, 0.45823161211640395, -0.3022159255161108, 0.722209308620285, 0.5708369020487813, 0.3276893029049178, -0.09282976385391631, -0.0013594441788937765, -0.42293636865131495, 0.2625356540544, -0.6282508858531787, -0.606404906102367, -0.7692660469257839, -0.45269265624836696, -0.03251736894102932, -0.35460013958470554, -0.541120685948824, -0.01429504103955584, -0.4628102233323429, 0.6784827557059664, 0.025638429248729038, -0.4988667091342596, -0.7490479368288896, 0.20274752418646957, -0.21175032489744058, -0.27057609218364237, -0.28667061869929583, 0.10489883990281634, 0.31183289177741264, 0.6298005918450068, 0.46504579342183144, -0.7547436848012927, -0.45712205694033775},
    {0.8188326305447949, 0.3845074650722829, 0.5584588364730007, -0.1146681726608161, -0.21116955893092762, 0.6453476914147718, -0.6782357904029814, 0.5282057051781491, 0.17940577362081028, -0.4068228565688587, 0.4317613391792886, -0.6533149551825764, 0.593915662155324, -0.5839441930716103, -0.32608036170331917, -0.08813169736538158, 0.256580180222954, 0.3525868603521494, -0.22631399211995368, -0.5473803280374315, -0.46522279030059344, -0.020491855252839364, 1.0171330966723466, 0.7246878881643228, 0.6525148222701341, 0.47320282188954105, 0.2462465449639153, -0.34614330759246575, -0.33847885241950065, -0.10802926307140374, 0.282886565234068, 0.30099709626100285, 0.5194154117250844, 0.24355759818495507, 0.5463454133532604, 0.4155764078941609, 0.35523637080703846, -0.17045026327913315, 0.13269094705734036, -0.4531819006132475, 0.5295198325924476, -0.8397891338079471, -0.6277498879076554, -0.7624767557603797, -0.729425913237964, -0.036853138335750955, -0.6795319757169314, -0.5781806747573707, -0.25780313581091086, -0.5412211129497921, 0.4674226223588683, 0.2175607240468047, -0.7262092659319401, -0.8033738039047787, 0.46017512572837493, 0.11022097897426877, -0.5112197438222832, -0.4200906427266202, -0.01753885585933996, 0.388823021143328, 0.7171050601792158, 0.6822435389513173, -0.6631444751149133, -0.7770851114757051},
    {0.7706386043930448, 0.34622807377212406, 0.7391285446928391, -0.060171511968236176, 0.03654326282458471, 0.44967552575001285, -0.5968594481049387, 0.6815280742034274, 0.19219173666918643, -0.4904452286792937, 0.4037451371385252, -0.6501605594813503, 0.2679174493882174, -0.5289820022561988, -0.23258350691149607, 0.04323196486842558, 0.5098619480278395, -0.005340622181399138, -0.13198281891291186, -0.7010535802747974, -0.7025851149165379, -0.23543374043220616, 0.6688270572664979, 0.7765978826275023, 0.7116656059867329, 0.5503512112928233, 0.7120615046505141, -0.6283617825432083, -0.48668030088908487, 0.16205099014559618, 0.3025135980855641, 0.6748219193909697, 0.383642248573442, -0.10905910744780681, 0.36880255473692214, 0.6774342500117013, 0.5650157748861099, -0.20594622694856968, -0.05124748096554876, -0.5686414166612456, 0.733293725464026, -0.6667642906911855, -0.3360490634439851, -0.7040262549294912, -0.4962753071930183, 0.06727252378368982, -0.622820467362961, -0.42029389353692037, -0.23584543760554136, -0.715408400649641, 0.4412746329064711, -0.04584757296404988, -0.5124503899661362, -0.4829739674481247, 0.41662158785641223, 0.0339878471019397, -0.4856890799718453, -0.23532051283344982, 0.01599190933558954, 0.12099960641603744, 0.5202717563622754, 0.7591535997956886, -0.7509742715573708, -0.8009411670014421},
    {0.7286785588496296, -0.045150921666948826, 0.11054989874824991, -0.33286070661811634, -0.2415288482039012, 0.45527686757150265, -0.6460807693499271, 0.766824422278827, -0.014425833241210858, 0.051434027091588765, 0.5489203901563372, -0.6062671544176484, 0.43478699025075973, -0.4411393916485016, 0.035381197905479736, 0.286391412669488, 0.5175817760421789, 0.16081839738014253, -0.3192542664111939, -0.6657837228279267, -0.2272085305657018, -0.09521095362947146, 0.36584724157665904, 0.7997894453259732, 0.22731075408243873, 0.21718671001388984, 0.41758887437559894, -0.6541913825455817, -0.38485009327332576, -0.2971547414303465, 0.3210797822665068, 0.8558134941837878, 0.5167083068179992, -0.2556643776911213, 0.5147362173220911, 0.5814841202534022, 0.4529543831501991, -0.2467691688048343, -0.14041914999952188, -0.49095388393003564, 0.5299798900375374, -0.6674838611598534, -0.34084224429893695, -0.6060971872465266, -0.8777941337479784, -0.21264393767615056, -0.6660814217135412, -0.370232907046101, -0.12135958923706952, -0.6831326569252137, 0.19257717683456974, -0.007087609136458436, -0.5412984600354444, -0.5760020679479677, 0.3590735332585726, -0.3567225767087609, -0.2892589468401619, 0.05294899703421648, 0.08524860318042676, 0.46609614248858616, 0.5308471496077517, 0.6070293835438083, -0.40365540031114056, -0.914310253398623},
    {0.8050705636323984, 0.45279431154779126, 0.5933252848692044, -0.2149993899160819, -0.11653204494249167, 0.48086786949553934, -0.6881971613265123, 0.7528416626024661, 0.30343683678765293, -0.32806532318605586, 0.6444484352384924, -0.6827798343660983, 0.4528293544335173, -0.31938015497521455, 0.16493691971357596, -0.09199318810806935, 0.6896886944535372, 0.2753294463675989, -0.48405879567844184, -0.7035303915782689, -0.3850954753482421, -0.043894726281474464, 0.6821315620177246, 0.604197888956315, 0.30541552143409595, 0.14384925668207993, 0.17762688583863728, -0.483976742789697, -0.26723025917665283, -0.04420717768385683, 0.6021078498484189, 0.6960373543045612, 0.30037463738981984, -0.4174684507067446, 0.5586213404264054, 0.6861470773631518, 0.48781215786876503, -0.19203509240604505, -0.12069850726489749, -0.6775541845694173, 0.46780493018670954, -0.651204799387235, -0.24631365540491365, -0.4424179366039831, -0.6715351525853259, -0.07093775091888764, -0.24283031029887056, -0.4919097022942006, -0.6283654041711462, -0.7274728223506074, -0.19611672022295862, 0.24702970281353004, -0.24516902815018973, -0.4740691614421807, 0.48679315273692436, -0.2659725990546144, -0.29943272943965277, 0.04734338958239587, 0.07621086446877692, 0.1925713184111781, 0.5992222262025652, 0.5821637560300688, -0.7155476363368019, -0.6686262757853451},
    {0.6526610572099091, 0.4282839960986529, 0.7333101564688093, -0.13272596309456827, 0.13691756029715885, 0.4611042922843398, -0.8139460908664785, 0.3697403897471889, 0.2487747238717519, -0.12122988428534007, 0.47765897189570095, -0.7015143966163915, 0.26856288037444226, -0.5260299808643267, -0.5656807168617043, -0.1067535159270547, 0.702206426830835, 0.5037739001528427, -0.6992649639894397, -0.8639818654900643, -0.4546001011608275, -0.20630923411550786, 0.6662239621774736, 0.5632902542533683, 0.31914159972198675, 0.3874119141768898, 0.15330681259176757, -0.43101533737354525, -0.6178043859726203, -0.17448125983930163, 0.3436366080497287, 0.5992165746264576, 0.4705168594587043, -0.20265720423983374, 0.733822284880584, 0.7434800232819304, 0.2695418687270577, -0.23728268634351174, -0.42481226034636604, -0.4457251601030625, 0.4878050851192142, -0.5783704339351252, -0.5018131040071392, -0.94503478376459, -0.7587106815704869, 0.13066913129001878, -0.6395824192015803, -0.34841536554139463, -0.46315651311021283, -0.5585204543550781, 0.10941290211878256, 0.3644094128464434, -0.6375030832277111, -0.6713435676876145, 0.742333104813716, -0.22123804834170568, -0.38919258234278387, -0.12447238029803745, 0.03594842801548715, 0.3821576800393078, 0.7170363333239596, 0.5743898453615376, -0.3403538688828861, -0.6208266378785643},
    {0.9128227640643466, 0.4572417996303115, 0.3227144164786637, -0.1493769708338942, -0.218920651470981, 0.43012856719991405, -0.829420690289004, 0.6858557015326298, 0.5528191215615528, -0.15896810870712968, 0.5993498844220312, -0.5930529378639618, 0.1116144245827514, -0.4672678800476275, -0.4754586326346933, 0.044487345221295334, 0.138774690788568, 0.49083728865103643, -0.7663428399265783, -0.5587641774068022, -0.5329794727795651, -0.3733096311574166, 0.5917815032245197, 0.6480242453128834, 0.23608146880932226, 0.5325130930942197, 0.31359070434134556, -0.2403851060193108, -0.6469384635079061, -0.12179790747748939, 0.37305969685264534, 0.6144292760687619, 0.5286561298115492, -0.16860861798838347, 0.661934276433999, 0.6070302848740039, 0.2033390982216436, -0.33490466945912395, 0.06388002904813891, -0.6266548652088321, 0.49185751990503496, -0.6380745995125067, -0.5944275210428491, -0.5717062659527303, -0.7441295983544383, 0.29864333621759864, -0.6719335268120461, -0.6005167983638394, -0.49992494012728494, -0.5720580633772657, 0.3883817888532163, -0.10019184580129666, -0.8575289219193981, -0.9961769942066988, 0.5173241009720192, -0.31587451063512806, -0.4033744220785147, -0.1359727853017943, 0.0005318112954706264, 0.3562648788891274, 0.717302965128209, 0.45129473216210864, -0.6171770253671303, -0.7090068491379081},
    {0.7750990367573636, 0.44417262152487275, 0.5003075470678346, 0.3638157432267285, -0.1633575059607144, 0.307341135923568, -0.7461893837654691, 0.8385263551663595, 0.2579042857901231, -0.21461011886255582, 0.5753453058278593, -0.5639595136354534, 0.23646475929890423, -0.42352453404215096, -0.2729143554373323, 0.19818199823706192, 0.5489699017986044, 0.46658554467957886, -0.399350973208418, -0.28228318682528974, -0.32493427147164156, -0.15516885718479048, 0.8602741193722002, 0.6554187979338907, 0.5429010891267342, 0.6508471025386032, 0.47734510191876095, -0.36917457801937203, -0.6552771906953412, 0.17185300414976096, 0.6332766143100713, 0.6821463451961496, 0.6309853033034836, 0.1327975525223075, 0.5232822879559984, 0.8185650982914667, 0.4643067810746917, -0.2148246523324596, 0.2055212648996151, -0.6603010287307357, 0.6089125511603825, -0.8087193031114238, -0.3201311684188934, -0.46616029929745834, -0.8277851676900733, 0.23015349631437254, -0.11751050750438057, -0.5202454210005882, -0.7751937162199106, -0.7804238102667099, 0.16258484587680638, 0.3364176073971482, -0.6889227376012822, -0.7507298826359752, 0.7325003065377167, -0.058416306780195375, -0.4400309317038624, 0.2893188902998416, 0.13527596277911386, 0.19262471769895406, 0.5676790403258205, 0.6454570416022375, -0.42442962563395653, -0.5230497263130633},
    {0.8181724746298381, 0.4319131990677276, 0.7429456629623657, -0.22653178289411105, -0.17796037524186065, 0.5070797449695122, -0.7068194771246256, 0.8663921954202543, 0.3478823639564251, -0.1763304627837436, 0.5368970138076352, -0.9649176893481057, 0.1279325600945938, -0.4697216201201884, -0.18980885819875506, 0.11128582585620163, 0.49138621096358814, 0.6613746781821825, -0.3561328919447164, -0.5515587313041134, -0.5195898676586549, -0.06352013726881477, 0.7254359163456314, 0.6565879131902115, 0.6107837804514504, 0.5944202745712377, 0.5606593472570821, -0.30989535336181834, -0.5066694328554198, 0.3466880743520807, 0.13811558294008797, 0.7702919333557332, 0.691064622160231, -0.5434321825831002, 0.5094046398164203, 0.625925545324138, 0.4816735877192078, -0.14976208683739, 0.1943194551854721, -0.6516748360288396, 0.4410859762095347, -0.364404177777555, -0.5646710766634493, -0.7501884464139368, -0.5904840095034708, 0.009419619118942743, -0.40555132540785166, -0.283938983555997, -0.3753409926051614, -0.8610774613409615, 0.08639750398985196, 0.4701357607588777, -0.8868798018650089, -0.5764178638357956, 0.5142823872420348, -0.3033985398046222, -0.40135033111547297, 0.18693700701634686, 0.21715949498336806, 0.3403234901419422, 0.7735569093065378, 0.48007909637731266, -0.7402790589405441, -0.8953736703607554},
    {0.5485009652163975, 0.21601393439824565, 0.8598120567670627, 0.32153958549715284, -0.25908377847114483, 0.38030114113986224, -0.7735020397342225, 0.6908173321994812, 0.48088180054650465, -0.510076269295073, 0.784162365599545, -0.7313442771745952, 0.2576803991576356, -0.46002477297969835, 0.07340647734871424, 0.1945982965936073, 0.5425696059403059, 0.5355993352870222, -0.4658054985453124, -0.8937572053463841, -0.5193681979526292, -0.25777319621684686, 0.6811892966387443, 0.6877626126936941, 0.37445198875753044, 0.7562128999963917, 0.40140980766648804, -0.1301328600841626, -0.36820597253203624, 0.08382791500625834, 0.6358823234548671, 0.6694521168383224, 0.47925873408224007, -0.22073504509801833, 0.6958091989267601, 0.6064064066214307, 0.2889901468680812, 0.010540145808142323, 0.09550254077396811, -0.5345248050248603, 0.3649382319293186, -0.6926432604785768, -0.4433183717016105, -0.5948522991674556, -0.8194103524755776, -0.30071336422178513, -0.37767786930226227, -0.39962103240827174, -0.05548356018212919, -0.7650530326315235, 0.31008544374119507, 0.06517808848841097, -0.37914868674550234, -0.6822192375069693, 0.611596652518078, -0.01160824082068314, -0.2798689565060435, 0.18976607543624782, 0.2371331542307081, 0.538071101907259, 1.037558241768989, 0.6311833671285861, -0.4374242210085595, -0.562915184782},
    {0.8816121175157073, 0.5071188812462595, 0.4838406080897151, 0.32658390043872265, -0.06132901379450256, 0.461977336135317, -0.7405636518930585, 0.6211945494988091, 0.37103844091304555, -0.5671304391776792, 0.34823614550559845, -0.8121276427802989, 0.49128052324556576, -0.369312848440315, -0.6074130247799833, 0.2722031183848335, 0.6062027799889935, 0.7807050038253028, -0.5010069991216707, -0.8667605176021724, -0.6252580211289648, -0.5182132602746272, 0.6900752602271356, 0.8140864376180534, 0.47787223040570037, 0.6563777534770391, 0.12987605533560043, -0.6668835446686748, -0.4916164962849736, 0.16705748044095098, 0.4300828847275579, 0.9976892854025847, 0.7796901843285946, -0.30435127763366004, 0.7618333098271829, 0.47440738855629616, 0.854490926329326, -0.20870056083828106, 0.011026503468232807, -0.7385635825233866, 0.5156952223234325, -0.7507428560890409, -0.5347582111796201, -0.7108205407400282, -0.6331804030940383, 0.2281860915655633, -0.8690401274059754, -0.4403237303232225, -0.4631015965845651, -0.8118453350170899, 0.3185832980132115, 0.3680662602468433, -0.7862563649185409, -0.9320294911514354, 0.6788109944978176, 0.012216913880742643, -0.3330366769589962, 0.08290907158601633, -0.032067120191555123, 0.34211391310263883, 0.7213293635435575, 0.48228684094609375, -0.7062504304784951, -0.789916214812622},
    {0.7476758784064094, 0.3235780656985611, 0.9354045919925789, -0.016193854632661854, 0.40549094648423956, 0.5104613972171512, -0.7509521317999371, 0.6820749838589708, 0.4906625514333806, -0.5397044928064273, 0.7980719467719969, -0.6710120361020291, 0.21544994726905858, -0.15091406466431675, -0.5266002733886305, -0.10749855258446829, 0.7320511774648635, 0.6202484731958169, -0.23976117297831062, -0.6995453242075093, -0.8061402841157126, -0.5608315859563558, 0.7874723513342954, 0.5337291294330904, 0.7435102846054638, 0.5233463193113218, 0.29705650208476586, -0.6084163901304174, -0.8232860977828124, 0.08310843542301458, 0.5625780019844208, 0.5983702901516392, 0.45382244815926726, -0.2903898743085113, 0.596223756475748, 0.7262299097835205, 0.6416772161078258, 0.11132289127603517, 0.13658865442729282, -0.8574587637126588, 0.22976649435102958, -0.6492791654807872, -0.5797431061482831, -0.5895108435776332, -0.6848790575070911, -0.028045568499570878, -0.842324813174787, -0.5338827902221975, -0.6986431806052301, -0.8389170065280256, 0.44127937774472975, 0.398362169380109, -0.7978814269904418, -0.6046609264488008, 0.3829034242697069, -0.08161958741472643, -0.4708191601032532, 0.07679861858802078, -0.004111232203431503, 0.42888280792861355, 0.7489465426707248, 0.7768744668429509, -0.5049036904751102, -0.664054910695283},
    {0.5726375755739115, 0.41368684746272877, 0.7971812200617874, -0.24097225343163697, -0.028614367748798393, 0.5794567877975405, -0.8853236941193545, 0.7279830217722832, 0.7253454455285518, -0.36765536386220904, 0.5259366900827361, -0.6824407413250644, 0.40505785195343474, -0.38297198415400746, 0.09322986511472295, 0.24327841944805806, 0.5567471647875586, 0.27923281867959177, -0.4119667456717849, -0.5921054690412402, -0.5413890358532338, -0.21235875298244347, 0.8913621424948514, 0.4833097418826224, 0.45601369914942114, 0.6969810161153592, 0.3688953819766938, -0.5209761315963393, -0.6641275427470616, -0.07507226625657856, 0.5595565261729842, 0.7057103497325218, 0.5058913960622773, -0.29392427345737343, 0.9513691096970472, 0.48782183927815115, 0.36167096995744, -0.2433870860701897, 0.22167343989737662, -0.742826001649963, 0.41438207825722595, -0.5264753236374832, -0.5330920853630894, -0.42543342484309116, -0.7191353903978345, 0.2318142730168473, -0.4434436064833018, -0.47033977101297364, -0.7413530791261023, -0.8907790255632422, 0.3317503576617006, 0.292057716860989, -0.6892079636479903, -0.6900171479338156, 0.5802782775894028, -0.1433171272920374, -0.6249766563736167, 0.023412773433445246, 0.063980893103919, 0.6085290781106895, 0.5525298379684653, 0.6419936098365301, -0.5690518985901537, -0.7079300025483345},
    {0.4910998450767709, 0.4201482580350202, 0.7482211223275086, -0.29317149319292785, 0.09812443797441532, 0.29743661100982965, -0.6221140293328821, 0.864048575129024, 0.16262202551759672, -0.5790358442414475, 0.6250694255047284, -0.543858561757526, 0.4314085665317102, -0.5078844443368571, -0.4172482842872085, -0.1563517261565512, 0.5401659355624507, 0.5344043704538578, -0.7263696075473056, -0.8157551006051175, -0.5827862148021042, -0.8844443252944465, 1.0540167871122743, 0.8272799709042388, 0.5108265125940964, 0.6367126169569117, 0.28656201103896606, -0.7974897607269175, -0.6778564496012293, -0.20687183077245686, 0.5289194050903554, 0.3665135724435657, 0.3478036775112749, -0.25922348400600304, 0.6939772484331025, 0.5484845205300927, 0.7458408724189404, -0.163321456339941, -0.10122338058499185, -0.8741833728949723, 0.5526582568355143, -0.8425642889432804, -0.5751563993034224, -0.5401382029433108, -0.9272401598704473, -0.006428437077947937, -0.6136054284722783, -0.46046082115385595, -0.4751291575946964, -0.6020689835310421, 0.35405114008298316, 0.24712355271988143, -0.8969079833179815, -0.4895473037581622, 0.3855366241028026, -0.4075434607277283, -0.6263972974139996, -0.24616159723851366, 0.06318516896186134, 0.39639407525601356, 0.6277420253176236, 0.7041215856795325, -0.598763519102518, -0.7172124627201254},
    {0.7503939112320731, 0.15865553245823732, 0.9038443633394462, -0.22547064032609698, -0.03736028877455353, 0.37684793283696416, -0.9413204093562022, 1.0149339729264584, 0.49942875392074687, -0.6059069887242614, 0.5315079325742695, -0.3767166411054368, 0.0915909632387123, -0.45137542415166465, -0.18611916246715238, 0.018174561665462323, 0.27045415161492153, 0.34656266985236206, -0.48976363947862894, -0.8605234241910343, -0.5007106525274553, -0.33686917797222643, 0.8414295938606793, 0.7400551570917474, 0.6513336780038957, 0.45603193276833415, 0.5394939847678029, -0.7963816529458798, -0.470971384453788, -0.17668511144544058, 0.6881338401335729, 0.6818089293632699, 0.561976937769176, -0.08358521505630397, 0.7663198671302262, 0.5840098186325827, 0.697665770101889, -0.05430063025300039, 0.412471906323624, -0.5198626555699347, 0.6104931333880662, -0.8061567238802873, -0.45458775726088063, -0.7450137138893734, -0.7408741570566527, 0.4063757303206632, -0.4795165864336578, -0.5880153629269828, -0.49533212496261514, -0.8472100283101712, 0.444214429621447, 0.1321618311203595, -0.6352586241514825, -0.8385722105193979, 0.5937513543532861, -0.1226653445694256, -0.5669185449150275, 0.0042174541638487625, 0.015179376030895132, 0.30022728171256596, 0.9370701438442509, 0.5131850269872839, -0.7031996459474634, -0.8697756024901083},
    {0.8851509152120353, 0.19183786219031077, 0.6660589623140956, 0.13785891141503231, 0.06054049886864404, 0.5279123791174583, -0.8224985784841906, 0.8123557983537756, 0.1708189419350708, -0.37166449113606503, 0.6659707228558881, -0.5563084991407001, 0.1988128439280675, -0.5075400679925187, -0.41874828251233404, 0.04844630209608811, 0.6881410919097214, 0.6991593556593385, -0.7658087643612026, -0.6516881914365691, -0.6062812386909224, -0.09829806016516905, 0.832288881239678, 0.9063700501499355, 0.4157556599022842, 0.5983211708041383, 0.19914632486745423, -0.5037431016774153, -0.45122217788771274, -0.010628694914245573, 0.48419652217944353, 0.9801118926018585, 0.6323862282134098, -0.12576405003737337, 0.480525801742633, 0.5699465288120309, 0.293816915506042, -0.040010262742636624, 0.24232371448583057, -0.5874139126136279, 0.5471319008981673, -0.8247621325028388, -0.40029137354834593, -0.6563585642596901, -0.6989262245788922, -0.13161677456692328, -0.5626878065452731, -0.6944076992804078, -0.6964221293138301, -0.8008865260232677, 0.3172327263454055, 0.015432870406206214, -0.47557775109216405, -0.6704050648560579, 0.6698234717359351, -0.23087105417288709, -0.38589184050468134, 0.26506990869561925, -0.036730155331156034, 0.3302218529637703, 0.5941146281183287, 0.4864021604827604, -0.41506820838157266, -0.9021132722219565},
    {0.778009603202125, 0.13251770440214408, 0.7804637454075636, 0.2372866037500919, -0.1805448632298843, 0.45472840929147995, -0.5760020589502861, 0.9435478828697843, 0.1722645428331088, -0.31086530571047366, 0.7505868643142134, -0.8310683977238166, 0.3167360316107343, -0.36313546140698055, -0.38157766106788155, -0.05897291261691016, 0.7832662036990092, 0.483739723252313, -0.6144761542051663, -0.7374557907979237, -0.7452688201682279, -0.4180651000134868, 0.7095798445072313, 0.8942165393759076, 0.5212478086104547, 0.5642996304242861, 0.011582933692142994, -0.5177510356621797, -0.527920952894146, -0.09571061788078912, 0.5129980927488934, 0.6545682396470796, 0.6249511683063146, -0.16312796314908104, 0.8895582026744678, 0.6549850898471821, 0.30671349674915754, -0.019409572385156146, -0.06277627590030768, -0.7840366329676391, 0.5785317374719593, -0.8493494998882812, -0.38350334268999253, -0.7343523643598107, -0.7327349481196359, -0.13814767618829552, -0.4449322867613578, -0.26687289476826787, -0.6674323082166204, -0.5098447269350508, 0.5560236141882376, 0.19465074618397246, -0.8114241977612827, -0.6571684348645868, 0.3797081785966837, -0.23723163926470603, -0.44271549342323163, -0.2948517358302695, 0.10447807712595951, 0.468017294148884, 0.8303281963739375, 0.7066066959265869, -0.8191619610951331, -0.6299351503060512},
    {0.8782722232071163, 0.26398593573077456, 0.7577074556994596, 0.08396591563300797, 0.1324090311654848, 0.6953403123153188, -0.770437782035427, 0.769247634539569, 0.2585765828650249, -0.6430598773995888, 0.5310601413946804, -0.5570761059056679, 0.49730381592193773, -0.4146078078642079, -0.3067061723607055, 0.20857168371883983, 0.4807075816087107, 0.4891581927316938, -0.6723855598359266, -0.8964105111201073, -0.5661369003536009, -0.358873464198294, 0.8424625047702471, 0.9620534403970643, 0.6218128277217747, 0.6059968818457248, 0.405537319464341, -0.6668734611767978, -0.6706220832938432, -0.09566579800610499, 0.49471733795013245, 0.7487590606853262, 0.41182928892244963, -0.32020395892618014, 0.7662510784801171, 0.6364336036002505, 0.5976549767477484, -0.015688297851484716, 0.10511836848088013, -0.4766173253784841, 0.2263299427721633, -0.616578244583732, -0.4107344590145911, -0.32836661218472557, -0.9480325658809802, 0.0996791774275611, -0.7070339114716369, -0.3249351517223143, -0.5655353504653415, -0.6034978815120284, 0.39058783756397314, 0.4276211814653283, -0.9734776584702409, -0.616167273391348, 0.6644506058179761, -0.14912851679018796, -0.5947434977641736, -0.05749116417482263, 0.12595344484654578, 0.19900436722310316, 0.6382108435075335, 0.6717238440716983, -0.43143638558405, -0.6797253065130502},
    {-0.14891353663792783, 0.36965347531063597, -0.38985050468932353, 0.21065900191760634, -0.15715224154180174, 0.14110356772023747, -0.05899830293426089, -0.5430581624460639, -0.31894890483544286, -0.5011917764325928, 0.119089198716074, 0.024878664035383847, -0.5578995044261966, -0.5020337844218888, -0.6770810933894815, -0.3432088188743813, -0.20198719821971617, -0.4572357113177661, -0.416914404155961, -0.6067344796700007, -0.7798079745740568, -0.3491969556976981, -0.02357221293351385, 0.13639313451527774, -0.14868817526297526, 0.2601915299939862, -0.1586868110602107, -0.5438116953935959, -0.5633412017914654, -0.6018911166418622, 0.17577572574667116, 0.08416449389650241, 0.2190546655125157, -0.6063741268449833, -0.19336718931101785, 0.019648061554046033, 0.37284957347718467, -0.4294968402154425, -0.45603533076756964, -0.264294793404526, 0.3307961652049183, -0.6291462787776118, -0.5112823641771929, -0.2851029800426999, -0.4489353542360627, -0.434642552329438, -0.3428081500692613, -0.5996535202515054, -0.14037162757993293, -0.23952779495368415, 0.3099641926588732, -0.5166317673268327, -0.960437682255525, -0.5698279665443896, -0.6670328648499879, -0.8594048226183317, 0.05952347068516151, -0.6600119649102181, 0.03663845493601724, -0.2147228141089765, -0.029858296638002216, -0.5452897863749013, -0.42813184120230924, -0.08608678592480118},
    {-0.04786859941452864, 0.10838170661054834, 0.1761531309739304, 0.2174012333585971, 0.38872133213983057, 0.3073684928129468, 0.3165633389283474, -0.011250451965514895, -0.06046129756163961, 0.06001041423451596, -0.04771707675024159, 0.3094499042331466, -0.2240984650650407, 0.29330874562280623, 0.027763420458872246, -0.10593566938747073, 0.24769445333922305, -0.18993172193810712, 0.28829695821172585, 0.10747516616743731, 0.29553653687111703, -0.05481588017337841, -0.07929315246156751, 0.3059516069801407, 0.29054315517532675, 0.5428709892512563, 0.30400998485815994, -0.21996171953199228, 0.16850799839529798, -0.2591446082070922, 0.3525523695619138, 0.24178953249479665, 0.3971519742151075, 0.03595586938689458, 0.018121202220154366, -0.16285384663251684, -0.04892030421049554, 0.29841400856772876, -0.13368997209413208, -0.28906899471107916, -0.0012373482394885445, 0.2539586375909175, 0.3143945510971377, 0.04617916101994652, 0.053655125325636426, -0.10964724432136846, 0.2934370933695984, -0.1181736535732746, -0.24055332475079352, -0.33054212081386014, 0.07504453038486471, -0.1476276797220163, -0.1483448314309131, -0.08311200613714868, -0.14100996258148915, -0.2536132347253102, 0.1673029052223229, -0.21952650681321004, 0.23057732396588806, -0.06327717878838651, -0.2527252491550707, 0.2593534697870482, 0.10011518095369565, -0.03376195289882989},
    {-0.17107977111540182, 0.18458892424917106, -0.4680856652566268, 0.3829265684798435, -0.1187543183075497, -0.31688089768185573, 0.26261300932916604, -0.4245901373072945, -0.4743934269480836, -0.49543084639752843, -0.3479842113017986, -0.4500543468961231, -0.7636243824339027, 0.47073392059414504, -0.6888290909519023, -0.6535809383984601, -0.2639232895496068, -0.5116335530614602, 0.16413042559769636, -0.4892170355654026, -0.3091490225021134, -0.4966597076443375, -0.4999945892891752, -0.6738450951047452, -0.3222477689950806, -0.18002672783730453, -0.32373324455379526, -0.45179373956454993, -0.5549332712446332, -0.6768310184806673, 0.14782314324494616, -0.6732251047346954, -0.15135412946323962, -0.08548675427161087, 0.15544781441415462, -0.023492440025762885, -0.3953864211804496, -0.8203632474971211, -0.6257288614200985, -0.4088463033947147, -0.210271005475545, -0.352515556050671, -0.05359349237669087, 0.2076258574019718, -0.028266256741109854, -0.42820117669564445, -0.5403325740163888, -0.5189010862896822, -0.48211835093683403, -0.21620441950436806, -0.27801318701018585, -0.5748058938551639, -0.4298522826892579, -0.09776941296827169, -0.8272477312190153, -0.7269549790127371, -0.44447732432885095, -0.6064536859386105, -0.38725490390021217, -0.3738998831813601, -0.5303810485171723, -0.4553017426306559, -0.3533888141219936, 0.15580336811352902},
    {-0.5466308478218018, 0.23563805832469745, -0.26092049460900557, 0.3034328882676341, -0.13536737764848544, -0.3018065582972968, 0.20819820466580125, -0.2847099771684083, -0.49999858764883354, -0.06417303605910418, -0.1374734597306484, -0.22009529580530574, -0.5755218800159931, -0.04167518599627083, -0.5709978238068432, -0.540358615701763, -0.2279355215391903, -0.5787492788657164, 0.36951537026807724, 0.009034408226022415, -0.20259827737985897, -0.6351209660581237, -0.3550461540646578, -0.4549114567454381, -0.548441610409725, -0.028201250740323088, -0.11092662339556907, -0.3096978948863284, -0.44268008457798436, -0.5992866732273286, -0.1059929033748217, -0.17078503657026659, 0.12141366446755372, -0.32287778745270496, -0.16323050315849394, -0.11933381385441187, -0.2260134168430803, 0.16810120984075436, -0.665946868667135, 0.24702972511259433, 0.014566304195672692, -0.454610098531603, -0.4508354215979715, -0.03056129010656341, -0.41154804367803394, -0.8606207078024007, -0.2863322803633356, -0.4618857894833203, -0.5777905703750599, -0.4539476539689369, -0.5996359281275039, -0.37765641372867625, -0.4852430086264783, 0.12041829127411986, -0.7645189236730544, -0.5874127688652747, -0.618222078019917, -0.623131501490389, -0.2880567144368196, -0.5966116531230781, -0.46332870421285727, -0.3513979544289694, -0.43965558508286834, -0.26527071644276096},
    {-0.37776991311689834, -0.3862848004604231, -0.42608509989692533, 0.29291005581126334, 0.14901563332059942, -0.23952022060392056, 0.2575030083367136, 0.45454306884840456, -0.7328092676430212, -0.18122940513445954, -0.1283935787342092, -0.1459459627278565, -0.6131093525068088, 0.17897804552349694, -0.5631700589887425, -0.5960646031789629, -0.2869913619864484, -0.7007697278772806, 0.4674348692273795, -0.08089709071627402, -0.12119292368435079, -0.03983047114758416, -0.2533562063752669, -0.8578943343330634, -0.326888070049131, -0.5733314585552449, -0.26601265551896847, -0.1709533371658324, -0.6218783432226958, -0.28035007336006484, -0.006334920224068532, -0.042046032218091715, -0.007446834841599543, -0.12582280335836787, 0.19015865674320176, -0.056575042957968474, -0.19216978333588258, -0.5835691123474812, -0.46644559850827944, 0.11798764726716264, -0.37132318677595116, -0.19678369859977884, -0.06132692190597436, 0.3161632088905527, -0.44430183543249335, -1.000397510393464, -0.6627223726728984, -0.20804090069264944, -0.2151073748102502, -0.678135431887199, -0.23387366177656077, -0.6456456372876884, -0.15994821443105442, 0.2140436110508336, -0.2458305326999821, -0.6758976033307419, -0.3421388898281522, -0.3182297648480953, -0.35227760979472, -0.3885366380825631, -0.3264607692610583, -0.07141328051365976, 0.021343768204438014, -0.07877079570389073},
    {-0.2626310266173693, -0.23956771549505299, -0.40053278543671045, 0.20613373379449587, -0.19428282160909288, -0.39393417969429867, -0.523953579260232, -0.05659443593070757, -0.3644503081726241, -0.3079515818201665, -0.4883818794695824, -0.28639159662843583, -0.5019953511429258, 0.030453440869651884, -0.3451450245320217, -0.3219078485660416, -0.42328323364795856, -0.33340241972965073, 0.28943866064002743, -0.046000670689968715, 0.01051314500893605, -0.11829445390138653, -0.1578435273801069, -0.32658650072696566, -0.33142397460906625, -0.01637217455342504, -0.09428744961929024, -0.2865985935108182, -0.3212559204204126, -0.17893014828566411, -0.10030929957919765, -0.3837440962992557, -0.2579341753925263, 0.5102505264454444, 0.23139192182188806, -0.3409661315240435, -0.22611992175251786, -0.5306215413771549, -0.5435762448195862, -0.386001159614112, 0.013462614512577043, 0.05220115821713836, -0.005832730491169489, 0.35778154697882913, -0.5513794203787538, -0.5365149509719764, -0.5609266552779368, -0.1700128421334137, -0.18461741958848304, -0.7098638773901141, -0.36771138335107156, -0.6910794211294385, -0.36980764604148064, -0.05736773758900141, -0.5909109721690614, -0.39832158199327317, -0.5933162979111627, -0.2804319691119823, -0.7756071873152771, -0.04251507727936237, -0.11738726002828066, -0.08807458146910983, -0.265582586211443, 0.21006016147580542},
    {-0.33700356958102523, -0.2521672416378797, -0.05668647980972927, 0.458730068788827, -0.340777377762336, -0.24445354110995515, -0.3273899923761657, -0.011630806710428754, -0.08346380899316687, -0.4271080383143656, -0.6062804775967517, -0.6169105365481005, -0.69062983446147, -0.03624195094683241, -0.6204352025973456, -0.47792507601752776, -0.6639582792912798, -0.43129187239602196, -0.2888451700745351, 0.1417936525662497, -0.009752872172228543, -0.0018073240859112476, -0.4299896684295386, -0.5137508064417454, -0.4155751690741439, -0.4207686293970419, -0.3090425313649633, -0.3375893068542025, -0.33194299803680044, -0.31305445921463354, -0.31491241048540186, -0.49935012820919567, -0.6617827493727738, 0.24442015336436032, 0.23496085140822778, -0.40841120946491605, -0.045821706748789895, -0.4737171294023079, -0.535146460311883, -0.041672085440975545, -0.5480477444853608, -0.24095920587256744, -0.16589292088507646, -0.0027940359387280947, -0.3257757730826569, -0.37133459239254696, -0.3797013014130261, -0.20895160710928218, -0.16179004546890552, -0.2997646252952572, -0.6234193685927115, -0.3781338463987279, -0.6550018014835367, -0.02755480818437159, -0.3835668390385794, -0.603027237682204, -0.15140539963284547, -0.27440288992656287, -0.4945721052097521, 0.022928595487339845, -0.2706107220105654, -0.32463141152735175, -0.21435338859029598, 0.1869858400505309},
    {0.10936566211076587, -0.21791266932233155, -0.15880133502750018, 0.2303942951730391, -0.4348264403169171, -0.27271216680234334, 0.058100265450516414, 0.052604534984911897, -0.19531489296390087, -0.07042233020911395, -0.34080231379272397, -0.2466064503201028, -0.3725467971684662, 0.2607800143060873, -0.404944921825457, -0.41087726513582673, -0.41237318597165395, -0.3348102089502629, 0.412750529010542, 0.08132279683935781, 0.24474970877874866, 0.008718547380348293, -0.18751500294630782, -0.358078526950747, -0.40319255226755046, -0.002719558463161306, -0.6066209716144487, -0.475500034804618, -0.2456242346382354, -0.42898199984270563, 0.031644122302273515, -0.39724105176394636, -0.04404755648531382, 0.406766101754769, 0.5413619650963525, -0.16051781872805604, -0.5101582974658783, -0.20638006127976435, -0.46465700789305875, 0.5015280369585927, -0.25310013478700205, -0.06293414870218403, 0.042853477313820734, -0.04214921327538886, -0.011171669301003188, -0.4082924579215497, -0.3080710061261788, -0.6245123645667667, -0.5932625941415831, -0.37480597453011616, -0.3495454198446131, -0.4337537905071986, 0.0951658636066315, 0.07619941192872304, -0.37014651255566816, -0.5089946040657145, -0.540592666661622, -0.5769180706373734, -0.37243132444872346, 0.08512898746324875, -0.3060373877213893, -0.12171503258607935, -0.13456933287164177, 0.09986745641007741},
    {-0.11728696566174361, -0.28188020328427155, 0.12810930628166817, 0.13361094530861115, -0.4620308249139658, -0.3046030297401029, -0.17993764133410003, 0.037141772245875164, -0.46566484096323624, -0.5438957107253056, -0.7287778880795842, -0.16215400305358607, -0.26007773413648533, 0.12779957264640307, -0.632503011538106, -0.37335931753105606, -0.45114780359646994, -0.33660687233102166, 0.2957543935199249, 0.05607260479628466, -0.015787962391478953, -0.0925482149913674, -0.20415715902053197, -0.43375522613456374, -0.5811819652220227, -0.3288681873275006, -0.2589963935128862, -0.43226335692929885, -0.44597114748739336, -0.21727793279046437, -0.2945030738972158, -0.238118637683994, -0.21083350649324634, 0.13340896197622115, 0.4717916786633761, -0.2499081860470603, -0.596750644484578, -0.37471784738822345, -0.9572164903135417, -0.07717308882709475, -0.43636402268078545, -0.3204926501613379, 0.05030479480152251, 0.009885852104567078, -0.029824627761872956, -0.4212688540497946, -0.4367547828724045, -0.6657297481113498, -0.3472980315441713, -0.28196399055830246, -0.5158504034059147, -0.5408530997894893, 0.1787082619612624, -0.1685934912910907, -0.32570786118768613, -0.5701022640013788, -0.43849593389941843, -0.5334470378612124, -0.3412703027469511, -0.046020709211647255, -0.581549713216041, -0.3543102124105686, -0.28647138099655167, -0.1331202746462922},
    {-0.2158763278858625, 0.10922970927033837, 0.05982625179346742, 0.6468487063424088, -0.14408490603257573, -0.2527672382294313, -0.4315477450090957, -0.27330611476463446, -0.6359139711447807, -0.1643121980919953, -0.5835014976064252, -0.06854033955761872, -0.7670920118146575, 0.5931755301688975, -0.5329766090904708, -0.47284530132309377, -0.6405821278829181, -0.5386001965920789, 0.3009669693506361, -0.13054641382395674, -0.033788102721464326, -0.09640898365373347, -0.3815586992047998, -0.20295865192707988, -0.4135186781804082, -0.49560392655551605, -0.2932855478312132, -0.24313355303154388, -0.7273492562723946, -0.7993937959632214, -0.03079914497413273, 0.29746013099657803, -0.2546360136682637, 0.5967628731832513, 0.24596515138871072, 0.18015314987660697, -0.6100946758925767, -0.40077740018737945, -0.6798738473587637, 0.0723020201441987, -0.3363762090323251, 0.049156602328061606, -0.16270781383618044, 0.528751194249573, -0.22873251230337424, -0.5588336930068587, -0.5210972277973972, -0.6875832931355524, -0.08768702689150011, -0.34925375678885845, -0.6015615027571712, -0.6261609502008055, -0.5455076190091045, 0.025416417130784602, -0.6427734722924177, -0.4463688741231523, -0.4278420934092138, -0.6972377822778519, -0.6459808351440889, -0.29612462757356606, -0.6530636439273887, -0.5992782261333673, -0.47822357640581326, 0.4238852043767095},
    {-0.04070838916137008, 0.048189525506509935, 0.11341386105599938, 0.45231247097127897, 0.023865449715139226, -0.20579537649171584, -0.435320765970718, -0.3663395524128212, -0.5296675737947586, -0.3803170596244332, -0.2191083207884493, 0.2291189382697651, -0.5739257477819626, 0.0835221861820317, -0.47984368402557537, -0.4115048910282948, -0.6219794694323245, -0.647040367808842, -0.020396146263839187, -0.33986280481834025, -0.044179055932229594, -0.44888629907395505, -0.6809950707725105, -0.4933986972031301, -0.4995587214123474, -0.2893409820961144, -0.3354765647808423, -0.19498691519276387, -0.685985389951771, -0.5586804743896225, 0.0527656316634094, -0.04856313509465804, -0.3434682025458714, -0.14236381780957444, 0.5284516855686914, -0.2672650300015683, -0.44747525104798397, -0.13909850333222898, -0.659415336252378, -0.2783184839670637, -0.3093039798651621, -0.15161621803205114, -0.13138744567867955, 0.07743635352092648, -0.23231156341605566, -0.11102457646603776, -0.42298899482644226, -0.5232459498977495, -0.5445319044328835, -0.08447562265452443, -0.7215014875144828, -0.29862795200472136, -0.19794967164857902, -0.13521325348927424, -0.7923973971907713, -0.4468741836541598, -0.48309117877360586, -0.6649725397359258, -0.40038589049782686, -0.2453066446692685, -0.43351539729912775, -0.7309037492239808, -0.29348823547189185, 0.4322907049812955},
    {-0.10486890821447425, -0.038314881284190604, -0.243187895121946, 0.30029264720958904, 0.09765040434068667, -0.23665720257609524, 0.0666579862657873, -0.04144260600477299, -0.395081417363947, -0.38659805695917554, -0.4829395796481224, -0.17854164339454834, -0.9591441114339433, 0.07674845956227316, -0.1822315745505056, -0.5735156645224462, -0.3738664450839213, -0.5602699697319804, 0.12361084760671234, -0.033734980594604294, -0.20528778235435988, -0.39414597082630975, -0.14153721328222793, -0.2502339962289024, -0.8247519270879645, -0.23647279072172542, -0.3307435019534439, -0.31607615441028464, -0.6637562089639282, -0.6384035690797887, -0.03851499817650105, 0.06311970257841519, -0.3117453054517654, 0.020839650092926477, 0.3817944554277829, 0.29017419766510516, -0.5713934033696415, -0.5381116466182655, -0.8101214710138586, -0.3477873907196915, -0.41824089739753867, -0.12388978774351257, -0.18064474578901896, 0.020645703164305834, -0.32400801624072595, -0.37615281515077786, -0.4766987411260827, -0.4746940878312879, -0.556013068304479, -0.3624010519539433, -0.7162350340649697, -0.6740579280489393, -0.21359482759628481, -0.08813599335112801, -0.7708767413945021, -0.5361660417402673, -0.2749477894267436, -0.5126219945609802, -0.6588986850921171, -0.18378947400104167, -0.47012181969440764, -0.3304190088367854, -0.2927804639329165, 0.18692189544056673},
    {-0.1483372210109624, 0.0560993751623439, -0.39958507938185034, 0.380240438405028, -0.38134391078501306, -0.39353594348555265, -0.14627986005178312, -0.3121908953573676, -0.5581593550705283, -0.7289242144907161, -0.35185728329896304, -0.3801522000682214, -0.7846010065734661, -0.051634574683640654, -0.5753937594609599, -0.46055535522548735, -0.5274441111917079, -0.8124887445867218, 0.3048991266150509, -0.4303062512334329, -0.14457400839036968, -0.7007143321322634, -0.1631060745460902, -0.3724405423629536, -0.5891697812843664, -0.4778864582732687, -0.04116691588966622, -0.6053561726364272, -0.5165353083638599, -0.4913310227880026, 0.1922922936909869, -0.25630857551301683, -0.3960872230393311, -0.2162236831229187, 0.4443954247662061, 0.21789221700710784, -0.20028245999437558, -0.2974267177155097, -0.6486472829977468, -0.37526400619435946, -0.3433340228008368, -0.08324402727682619, -0.010932359470904268, 0.049865711363951376, -0.26740948010764504, -0.4311840751193917, -0.46610372605897, -0.22045854547104554, -0.4596188293898512, -0.28662441711182435, -0.5493340397613251, -0.4802215414926166, -0.1291866939008399, -0.0764274922105841, -0.6751856094637937, -0.579847757710146, -0.03199903342147242, -0.7481853637367377, -0.6997186921003912, -0.05379255967242863, -0.3646484110492966, -0.031155837946009624, -0.19662791732792273, 0.36186079139080485},
    {0.05763405954305954, -0.017131591262391804, -0.13670144180271301, 0.4617611974629481, -0.3096939699376157, 0.13349172238921922, -0.0238220789744582, -0.10793529272467302, -0.23365452812978912, -0.5616402196076026, -0.4855055084257404, -0.4011485344639602, -0.6093575475438948, -0.1661464676067731, -0.6547182517897442, -0.475820203367589, -0.5030648273669279, -0.6145436841449211, -0.1758174102171761, -0.28679785871960795, -0.33056639075808836, -0.36633623685166605, -0.4372525407577314, -0.24613107148685717, -0.35017863348851624, -0.20072678445497114, 0.01567014522992808, -0.6089919232343419, -0.6724776142620136, -0.8334708052518337, 0.178739734414114, -0.11990605385269931, -0.0023820773998712874, -0.2313313039294338, 0.4586711824837264, -0.1349099660207764, -0.5439602703749586, -0.47584746663627764, -0.7084969923139838, 0.030962308609801065, -0.0936419171091739, -0.20030665588001345, 0.08350129881530068, 0.19558708086371146, -0.3019053303672, -0.6607913117429238, -0.278461801688952, -0.7122582022754594, -0.454912684923006, -0.24550919650572356, -0.09016882395801228, -0.2666412096452008, -0.22618250951147834, -0.1012815408839619, -0.4727403514817762, -0.6782626611904267, -0.02252054459128008, -0.5710025619754305, -0.6343826285386718, -0.25534015727173087, -0.6144210057619414, -0.3335829972162139, -0.20082088168455986, 0.08669161390777108},
    {0.15498560790659752, 0.09430490621470956, -0.38477172631802387, 0.9276719564761954, 0.11492392104799788, -0.12486821588137006, 0.0034374628729676397, -0.13158035914009358, -0.516867719298851, -0.14187495912266176, -0.5093712599480179, -0.144810715940706, -0.6217726012109289, 0.3953119865141304, -0.722317288519324, -0.7252062805822279, -0.05265359197606116, -0.4782492892834778, 0.0879230093412451, -0.05427138165953971, -0.09812573541241652, 0.044166949919115905, -0.15798865990354044, -0.4837423089165423, -0.5310343960968089, -0.16689629990242122, -0.4862040077590116, -0.3007166782333365, -0.2635969802479917, -0.4512483243484384, 0.04830900230057671, 0.17353609357303532, -0.23726475969905314, 0.4136649765925772, 0.34878850392285116, 0.3585849593025234, -0.32489371149030444, -0.47826115623034343, -0.6214847731409734, -0.03765448399207808, -0.07265515459157826, -0.31393754969746, -0.17454527253088958, 0.12784887262939268, -0.4696532537789204, -0.7925977699285592, -0.23551782157463633, -0.6654070805311493, -0.017750489754465817, -0.5490109533128369, -0.16373410935885202, -0.5940491013690418, -0.20471483632097873, -0.01667874985761123, -0.030490301721591534, -0.45097205063991674, 0.04159541270362863, -0.731812348863437, -0.5620888698773915, -0.5138287755548041, -0.47324740444218527, -0.2633329724861712, -0.38218675869526136, 0.4364646321011353},
    {0.30123862824425857, 0.3538365703633808, -0.3263171995241258, 0.6208508050775248, -0.25715706305287006, -0.11426518667312259, -0.1991504880821682, -0.04549428013962623, -0.26561169161203985, -0.41960250406806426, -0.19033801070127584, -0.1624392277306231, -0.5900178067103412, 0.37403851062808674, -0.4279636429043382, -0.5374313768928047, -0.1507857745990704, -0.7977377982477827, 0.05268155323544614, -0.020382403976248895, 0.24297213491262057, -0.36555287285808435, -0.503088132014019, 0.03541481523369756, -0.25027288914868, -0.21079867734738875, -0.05959997405659524, -0.8612695274284234, -0.4464680811933166, -0.383624784326759, -0.009679133541074584, 0.037887179330021545, 0.011673385507160973, 0.04857172689428672, 0.02151791829163407, 0.2778750514809294, -0.2898946690144445, -0.2068456801761047, -0.470735255286931, 0.02244638098860626, -0.0772865228279961, -0.363815322579652, -0.033726409629289376, 0.14786722372741387, -0.3308475049125397, -0.6116916398346767, -0.5145747967034816, -0.7198724877113555, -0.430854377794405, -0.509811891546824, 0.07707532662287085, -0.30035952294929946, -0.4154149847543909, -0.09602592356399271, -0.49438404509853, -0.6239243363841809, -0.5728954277092237, -0.5100190052760988, -0.18773295875933668, -0.2746703929427122, -0.14049976004025166, -0.12129550156334755, -0.5699592377835919, -0.10421181535617581},
    {0.011760137669665818, 0.27339046161206004, -0.11764957712155644, 0.4519029549864332, 0.24811733196229174, -0.18790346515439899, -0.25643002830921297, -0.38637069371871086, -0.4675830539751477, -0.22762134531924075, -0.12679747363818772, -0.08799890393392418, -0.7472550742821907, 0.11667488941782943, -0.39232955473273357, -0.66199616369259, -0.1853776423060951, -0.6975052966949904, 0.4923482365551629, -0.4867494920383451, -0.2001146382244687, -0.5084612755546071, -0.33089883941775106, -0.5134432175023129, -0.3599394231474745, -0.2594320543383145, -0.3684726945764479, -0.721169423148395, -0.51357586528689, -0.6658148855957866, 0.13921804780455369, -0.12040340620026926, 0.03133711440564202, -0.20051980194072302, 0.02871051112690296, 0.14990121759433042, -0.2108588006267625, -0.25382155482139535, -0.7777989147816221, -0.2060518292836015, 0.3039026929506164, -0.3447540613919862, 0.09260243408759145, -0.1048412567487046, -0.4583299484135876, -0.4786126613368835, -0.34585004165832695, -0.7689957116324432, -0.6312138091588121, -0.5998109617473041, -0.1551766142764331, -0.4446101168530614, -0.5075254903463189, 0.2151664229056517, -0.5369931918007717, -0.5341879606918094, -0.2538679262753961, -0.8553692386842793, -0.46073519209617847, -0.1892483150257447, -0.22384134865086866, -0.359950175797337, -0.608089578065857, 0.40200074133035524},
    {0.2412325707065146, 0.28817708339331094, -0.1481971866730707, 0.6682956899988888, 0.2509212792237473, -0.11946557746874793, -0.3308399066047219, 0.1238547833071648, -0.3967600329951885, -0.34728226106071863, -0.1472789996239171, 0.09532691363870756, -0.5342774152181273, 0.338622462344478, -0.3951873933384951, -0.7356099710843038, -0.09464422311165832, -0.8914026903725296, 0.49017395881968673, -0.11132582115746653, -0.28668867899777134, -0.19330569760822286, -0.14187028092886386, -0.48656515787333443, -0.21263967234869605, 0.17781841546822866, 0.5327509888914771, -0.6798292135471532, -0.6290705234976084, -0.7510764611323356, 0.40643649405916504, 0.23939540144452093, 0.2808758824738986, 0.2519537927442631, 0.4113916375446413, 0.5085207383229251, 0.034659704994381764, -0.08142355491693987, -0.7958844901560838, 0.2959853938685412, 0.21682456534281302, -0.03524509175519758, 0.15835050631065625, 0.2160585961774869, -0.06094053664105838, -0.3152143090186892, -0.48081512875136195, -0.5359922376602511, -0.26403396323429157, -0.3422040313768733, -0.41171642799608976, -0.3764175339732176, -0.28451750604120374, 0.3229276595182752, -0.19598622136506494, -0.6566570647525278, 0.18506662953248787, -0.47149424992745004, -0.11908698686636389, -0.1971920959800162, 0.2373728756447513, 0.06830190197305745, -0.5272881852901545, 0.16742965856160344},
    {0.08346803988710214, 0.6006381778246195, -0.11807215762342071, 0.44019647178493204, 0.5501425006836174, -0.19385169171211103, -0.035688342003870145, -0.2399734671725916, -0.19800597301721157, -0.3318149816422041, -0.09553086958790469, 0.2146446248391625, -0.9326457646104294, 0.32469055279530123, -0.6401591248631262, -0.7030069185695743, -0.31361229778366445, -0.8800349122998509, 0.27533684621621424, -0.445050340987423, -0.5568143113503402, -0.5055429420352293, -0.08377793460624418, -0.23633014352303786, -0.43859305263515047, 0.020494616186068258, 0.29793230248403996, -0.3537297912965042, -0.5795512603775874, -0.6922342408003692, 0.3332181424937151, -0.15946855706050356, 0.46568953588994694, 0.26561850968573514, 0.2945349232146475, 0.48646584150214184, 0.04607841110223221, -0.28190728727212305, -0.839814671180609, 0.15814633329421446, 0.39977693730362157, -0.3673737837282708, 0.029734691784015246, 0.005407900039882253, -0.2108463344510173, -0.5757176731496909, -0.20162213365015075, -0.6122580302436174, -0.5860581691706521, -0.17052891657627264, -0.42446007166540384, -0.3341716405953866, -0.08755027840984762, 0.1960992796692712, -0.6739372017634877, -0.97253442089953, 0.04571387491275049, -0.7771921275167233, -0.26103019899665136, -0.1143871015643462, 0.03278365755831125, -0.10359199415280158, -0.4224974173316089, 0.14879286035237643},
    {-0.07341316363675263, 0.3452769116207515, 0.14542846572443577, 0.5156798651273087, 0.018720708457946277, -0.0635502605623028, -0.12931338795537312, 0.12536208951974942, -0.4874273546315355, -0.6901513566240689, -0.2868202624706924, -0.44339891117935976, -0.45484729973942006, 0.10630477186552081, -0.7666758553575854, -0.5780903591909667, -0.38835046682626817, -0.6041081198112577, 0.25887989030063124, -0.3721518528025784, -0.3310476632147817, -0.409761816139344, -0.6195196560137328, -0.6072091721305091, -0.4921656805029531, -0.28383253747618253, -0.13343121200313335, -0.5755979927683474, -0.5938423739192972, -0.366634280800829, 0.09452964064628608, 0.12671734735524784, -0.17857895810654031, -0.12377760199210956, 0.4549797746661119, 0.10639211281329074, -0.4362230526267892, -0.4391870021070582, -0.6837220857660312, 0.030299590046562914, -0.040857771620337324, -0.6741518426818517, -0.24793792514458732, 0.09412347762550466, -0.16228607594248387, -0.5656433600006574, -0.649539198833241, -0.633464493276407, -0.6325438308664934, -0.3258810263768168, -0.48282952347883407, -0.5481015447778351, -0.33210571693354524, 0.0435169375509851, -0.24697502870975466, -0.744765521915255, -0.32100225206584493, -0.6166647823610668, -0.7189567524325919, -0.35674832401730155, -0.13177830388134293, -0.44191382764005044, -0.5634986211943523, 0.25252502897476065},
    {-0.08004099062806251, 0.14070590773803435, -0.2800801205097496, 0.6549789807611387, 0.0007407281976675273, 0.0007401033328933961, -0.17884680666151698, 0.1251253074489779, -0.6530874590267908, -0.24722597812861846, -0.2063165576771385, -0.22577636045451618, -0.6527622690972119, 0.09770760628500931, -0.6764782467766867, -0.5528599362270507, -0.4342036069787461, -0.8352483545458544, 0.265760458042417, -0.43383988682244207, -0.05486446409262974, -0.6531908322836434, -0.626362663586725, -0.2491867619080074, -0.5713131770888284, 0.31667609221193105, -0.017031171666582086, -0.5980972297095932, -0.5950846170189162, -0.6620498016678962, 0.03729346488836216, -0.006382466010457175, 0.33811751536878915, -0.18878991305922116, 0.1581171347642224, 0.5669892117812797, 0.1469241511503439, -0.37561837886607463, -0.4699723541958889, -0.13466165168668465, 0.5375577801405039, -0.6897759622674889, 0.1001221836126885, 0.005343181132562361, -0.4324940839081165, -0.6571055548795346, -0.9616436679605384, -0.9473601343299985, -0.3326274988530963, -0.4782447646168948, -0.350541341550055, -0.5364642990002583, -0.31144668385255375, 0.20237854861457505, -0.3015160055420973, -0.7388004224687583, -0.36232899247871836, -0.740045165290387, -0.013866912116495345, -0.08634669717924495, -0.36056856887826194, -0.39755260300212164, -0.505139163869866, 0.2569647441882978},
    {0.36678222143240585, 0.5501187798699153, -0.44143593277876453, 0.9009814832257049, 0.30037484133859327, -0.03527877847857986, 0.2587911750225276, 0.5348199187599069, -0.5386901053201182, 0.21872061017807218, 0.21263692089612768, 0.16927455204651926, -0.6297844082598753, 0.4218006239032413, -0.898277415036295, -0.78741197788238, -0.1110771023647402, -0.79704479219384, 0.679926448705816, -0.3232428687092757, -0.31480653376070095, -0.2358172768491175, -0.10222717668345964, -0.5189894748254298, -0.16373106127899942, 0.6317471380973919, 0.6440517300012112, -0.8057624845976169, -0.6633553339641517, -1.1870549425981658, 0.48829256747496314, 0.49018998097341127, 0.2675005611337901, 0.3561565927096889, 0.3118100201359439, 0.5153985388021985, 0.28315942751222783, -0.5293152373051411, -0.5950043672018028, -0.03264573580583872, 0.6519544694576843, -0.4822394883765346, 0.10448371562313209, 0.8887881298812169, -0.18917912869230452, -0.7362630665225132, -0.5298774572293999, -0.6477130782222141, -0.02714566904837096, -0.41909987800805915, 0.23997580560156784, -0.8746523036655948, -0.4230822811600616, 0.08674858972425435, -0.3365018575145901, -1.0997836324276002, -0.35294187486364476, -0.8529458247895245, 0.06836957561890027, -0.3469813000427421, -0.11030500483712802, 0.14414820531053832, -0.377947948731173, 0.5807699090620418},
    {0.7053243701210208, 1.005942683143798, 0.09811521477721008, 0.9825120368204391, 0.6242779687979955, 0.2538192746351276, 0.1578436688190229, 0.7033674936451679, -0.587105457129214, 0.14536359295394596, 0.2056865932892383, 0.017065506006804818, -0.7724225888141433, 0.5721069060136879, -0.8668232846761031, -0.9915289864714081, 0.11029919969409951, -0.7090384067672991, 0.47325401011803886, -0.3373466659280124, -0.43351480523067565, -0.22121603813772173, -0.1215401223285351, 0.028996306708329183, -0.16666158989877275, 0.6374920087529317, 0.73082326038024, -0.38604341433326966, -0.321329085158063, -0.768353890277485, 0.7063366684699967, 0.2706577732592087, 0.6159655972511392, -0.007724528968713605, 0.49636511466731537, 0.7299165487807329, 0.3653395708094754, 0.11143424773142326, -1.1262766369081998, 0.14318643203467465, 0.7556162078617455, -0.5312667063192652, 0.13462568357939766, 0.30686619009237864, -0.37711936448379657, -0.944162040439481, -0.1373784245336893, -0.6799956033133352, -0.003250135017238075, -0.31355396738754976, 0.2542700426570967, -0.874290322029137, -0.4657222486046473, 0.1899893142537728, -0.1725244034342665, -0.7091193133057695, 0.1607506362542428, -0.5796680109327579, 0.33321859240285956, -0.3915379935344, 0.22545233908071086, 0.11670426711139331, -0.34190409988018056, 0.7455875002931436},
    {0.2881215552981002, 0.6648621820461925, -0.22934088538681172, 0.8580653621104939, 0.6561664384836396, -0.09986977416011092, -0.2615250348213572, 0.028249828124902683, -0.5618202472652696, -0.3105580008614943, -0.005457685335847521, 0.17847682503891224, -1.0624007694267628, 0.5061383405340958, -0.9909063346746232, -0.7039811052028936, -0.2694727466222613, -0.884938811474482, 0.26620860315538325, -0.26548666005378185, -0.3205902683644563, -0.8533228783557418, -0.3871688828334502, -0.2505794284313581, -0.10258597321783006, 0.2893058475685787, 0.29360832224218286, -0.3059538002498099, -0.3962640192672328, -0.6253649219390893, 0.39492427282935344, 0.32576707728725607, 0.44290621107839523, 0.21475352447185217, 0.5938081150506859, 0.41974534517466777, 0.1610762845677643, -0.7103563022664138, -0.7746548515015339, -0.010646226414307269, 0.543617434305963, -0.30372779535170474, 0.022430674805832954, 0.058123336949376755, -0.4902192115092111, -0.7632663285968803, -0.8076225124767612, -0.5213011580784721, -0.052439505418722755, -0.6949100569788448, 0.09277994560284193, -0.7671711589821681, -0.3473811523895828, -0.09693497958109303, -0.5373354397367816, -0.987234458105221, 0.022276416280795408, -0.8097838350237234, 0.1300227315322339, -0.3824098177340865, -0.10985911759169818, 0.00729973776110268, -0.705216694211438, 0.5343771087405744},
    {-0.0012487009687443382, 0.44703468191733914, -0.34453345308010425, 1.0149672592112657, 0.2438613871179824, -0.20723176843125815, -0.2836431443595227, -0.16093747367948627, -0.7271992004053955, -0.11514693175763359, -0.3874492610758125, 0.017249965261830914, -0.895014709241256, 0.19002879986406332, -0.6971169951280066, -0.7002003974618873, -0.43818176569376643, -0.8843906283857453, 0.28894026901536707, -0.453931317088459, 0.05290789039661944, -0.6541420021784851, -0.5452833012151066, -0.3736780567876314, -0.6431067005086654, 0.03312758752139165, -0.03639813102930395, -0.599636864153579, -0.7782934734257669, -0.8621182770302681, 0.06401855873421601, -0.2213984661171601, -0.15601425177584866, 0.035486831051248585, 0.46044877939418344, 0.3651458487819306, -0.21207073513976268, -0.9126673783279661, -0.6976256889338663, 0.031191946304004205, 0.3449825534485138, -0.3486741329251211, -0.09046408476400615, 0.182812635436782, -0.46021865637226933, -0.6361526261243878, -0.841088443285914, -0.7593431737175875, -0.48642498475074925, -0.5118503644064565, -0.022739430774848458, -0.8220806411718775, -0.5843607980409987, 0.10059827525057041, -0.6396115175202968, -0.6913273116327989, -0.4206104133443053, -0.7041289349892202, -0.19254566724317415, -0.6119572654399656, -0.28082330216749685, -0.22979637656213028, -0.5742901598949679, -0.15405049874141086},
    {0.359605223091795, 0.6304120352609323, -0.06433195686651477, 0.8046243854732825, 0.4790875284011222, -0.01773395564361461, 0.2292333102214206, -0.015913262557298427, -0.21062777239431107, -0.1142515372297755, -0.05499529963235258, -0.16198361843163472, -0.8269296138666677, 0.4022234249387931, -1.010383504777971, -0.7902810194643173, -0.026266674055521348, -0.6849236835311708, 0.3179178627841469, -0.47372548954347443, -0.5913573791724762, -0.5196783072776973, -0.324397729593724, -0.3596976742957358, -0.1990382770058904, 0.3119742039003917, 0.7340753548960319, -0.5176556405674783, -0.6169280843610027, -0.7162212827219666, 0.5320000669625422, 0.43545171770429525, 0.27752238466753093, 0.13572989392145185, 0.29990300378246293, 0.34417025624161435, 0.5526694133062634, -0.1450864457302954, -0.7629130015589471, -0.13226635812358953, 0.42143627591683025, -0.6364703406675976, -0.1644027723643299, 0.11188230564889788, -0.24014076808104184, -0.6916824177370287, -0.32725121181773253, -0.7352088033094722, 0.09379416292562016, -0.6396094990770735, 0.18043200371814327, -0.5501231968761275, -0.2613790276322602, -0.09716710338788587, -0.5917810381453907, -0.9558653449633313, -0.10598236460056192, -0.6308222305746481, -0.19204036940829342, -0.5034629660775594, 0.15253411361963534, -0.06869627901476799, -0.5654153010427543, 0.2825986663872403},
    {0.318998947679605, 0.958067201008274, -0.3697662969861413, 0.7570138743462826, 0.5369881532360469, -0.14322964567872126, 0.007387380084394097, 0.15092127462003854, -0.5230023476383697, -0.24718813553409633, -0.14216378680316566, 0.13025564995713415, -0.9603906002267264, 0.44410708834133483, -0.6997547114830464, -1.216260661322974, -0.1356581260963081, -0.8741446586297694, 0.5284100126951697, -0.4596699710567429, -0.49283383448522844, -0.48568137405616535, -0.38735790022577227, 0.028780309957910206, -0.4261439383913248, 0.4887220015817751, 0.33233845509859306, -0.4839749558330694, -0.6595032008524809, -1.0248335268674276, 0.19767411856011474, 0.16816039754032816, 0.18505363894083376, 0.08869910718271773, 0.473292283209606, 0.6315233710894815, 0.3352719869651042, -0.45559245421799144, -0.9402863938962922, 0.13217163753795041, 0.36336425243523757, -0.6658975263712393, -0.06971848967954411, 0.3186425833027391, -0.4535504071445255, -1.023367950689078, -0.5573234547024457, -0.6255883724455317, -0.03966106574126742, -0.5608904709806865, -0.049595743165761694, -0.6124703723507844, -0.7571801319928413, 0.2700719864494211, -0.3933499754491627, -0.9799225367466077, -0.011854400072799368, -0.940120106626128, 0.11091849206333183, -0.6445428081738604, 0.32522328254731997, -0.08966661559677933, -0.5117670817930945, 0.6005813446814772},
    {0.184679173852875, 0.7632537212003127, 0.054489218851414466, 1.0014104135020103, 0.38498302251215843, 0.33486151131289954, -0.05818410681666844, 0.3078500826478046, -0.44061649624542853, -0.21736530856284667, -0.5016012750055708, 0.0965762919429876, -1.0128569165734296, 0.39399643200576745, -0.5240878921074058, -0.7922566109070048, 0.05350676490156114, -0.6932672914333208, 0.14325834199832155, -0.46713115644667497, -0.48412534771706706, -0.2991047834214011, -0.6274167132237652, -0.1311966768567135, -0.37912177058255603, 0.2950974741245727, 0.35524700464631154, -0.5279868329978421, -0.6319983058522435, -0.7784292084541655, 0.21224163508887237, 0.30767174534093245, 0.21318706655012765, 0.22403529639577813, 0.4147644196803502, 0.7233397247635553, 0.14006948853651524, -0.5963953334237468, -0.7021332590455689, 0.29923669855280804, 0.4615203908023944, -0.3100173373641895, -0.013768227309289649, 0.20435881967498196, -0.07080526875249872, -0.998727646309853, -0.4469251591377989, -0.861771683831746, 0.05723147519633878, -0.329897250667433, -0.005732562916304416, -0.6036488125027445, -0.5346134350111984, 0.07677067016037536, -0.5168663957740813, -0.9690941459907165, -0.21242302379901812, -1.0696845954024012, -0.08597997907578812, -0.3520952310370919, 0.047582309537771546, -0.4240770709442274, -0.38643125523467936, 0.2849145780922896},
    {0.3485176589063186, 0.742448495278113, 0.08114979871860935, 0.8095492969900084, 0.46680889892813054, 0.005815456653195309, 0.02989934455748221, 0.3228185382127816, -0.41288461693863304, -0.13816120037413065, -0.011866030358454559, 0.028805674686875248, -0.9570561693516918, 0.440498474504268, -0.7217994627443386, -0.6557134325269913, -0.18189117923483902, -0.9239092614902742, 0.35043570920648465, -0.39265094419833646, -0.4284904650946875, -0.17596480767181438, -0.3175861093407142, -0.10629115943461719, -0.48706077941033443, 0.5983858770460158, 0.4640674321740072, -0.4311146072016016, -0.335401272859664, -0.7879323727416662, 0.36275880528296806, 0.3903465036422513, 0.3067801111701077, 0.13394580756057514, 0.41926105674546615, 0.4406072552315267, 0.6820501177667976, -0.16939590160895782, -0.6775955665189974, 0.03965439031397673, 0.7711960550357982, -0.4898626921311279, -0.0284187192294983, 0.09294702292894075, -0.1214183116481429, -0.5899209927343444, -0.48580028213304616, -0.7128251022820156, 0.39000686783239186, -0.40643700528126764, -0.10975901443501274, -0.5267609308760192, -0.39558691810879626, -0.24549323423265978, -0.3310834943156276, -0.7375156250572182, -0.03491056354390894, -0.9156145816327343, 0.06282510369190898, -0.3784042105952205, -0.16297440279515082, -0.016808246928971565, -0.5815698612703963, 0.2810519701259688},
    {0.7611268074111273, 0.967462309423393, -0.11759115604104795, 0.7329033342107111, 0.5281063911959613, -0.04455641004454009, -0.3250164483963375, 0.15162936632315924, -0.3641310901531611, -0.17362764832806335, 0.14913772033995054, 0.11860111861097833, -0.8147851954461275, 0.3783873830920606, -0.7376738132825528, -0.951257429767547, -0.04909141770230581, -0.8581845564434144, 0.1843225652169767, -0.44657330806188417, -0.38295810469872926, -0.31714687879738424, 0.14982890221471057, -0.1799373878121231, -0.013577124946129322, 1.0279556488105135, 0.5062101744797659, -0.555891989248906, -0.5321279877968123, -0.6963902712732463, 0.37731841302866886, 0.5136932471546864, 0.5780612006324336, 0.22881551476413772, 0.39116734858729785, 0.9213698161206704, 0.511176242354571, -0.04359821822053171, -0.9457550804818184, 0.03227610423614241, 0.5645841971457481, -0.39150000347134667, -0.1679474016412979, 0.6048311626170934, -0.27162315385656144, -0.8333893399393875, -0.4034616428827234, -0.8312503049177481, -0.12013476465776837, -0.5161375462513895, 0.4601148088558836, -0.6952568653481088, -0.6945426093070399, 0.26159704048742727, -0.23794421613741937, -1.0229747989961384, -0.08096688391370799, -0.9134649053629035, 0.2981219252206587, -0.49094306250997, -0.04113437825838572, -0.12234593724521194, -0.37464128686840265, 0.45402145574582414}
};

static const float b1[64] = {1.0006501949813207, 0.8907901531472635, 0.9299605374405711, 0.9396874293318674, 0.9403490331700131, 0.6104043180662424, 0.9621336552588581, 0.9726960939631142, 0.9405394286040483, 0.8289419125343233, 0.8985607482760962, 0.975852283524494, 0.907940208010312, 0.9542436953214618, 0.841647793889723, 0.8365951599921725, 0.9062692575274474, 0.9642792407987072, 0.9517125286873686, 0.9116404928912554, 0.8645148343841313, 0.9620930490075991, 0.9068943070023462, 0.9616502532946658, 0.8914679144957188, 0.9048244833866247, 0.925503891883384, 0.8040487685630429, 0.9545723444968078, 0.9034554222441709, 0.6576512516627526, 0.8675671909884491, 0.9186326228010191, 0.9202788760756945, 1.0469349102744854, 0.95411161262301, 0.9366245177838128, 0.9233040112619866, 0.9380483995571409, 0.7738877811702016, 0.9337937977943681, 0.9378686268307325, 0.8668559954554949, 0.9478818297831826, 0.9051342707025516, 0.9183862074241118, 0.9505204337297612, 0.9357502868195733, 0.9314987719230431, 0.9443685552630999, 0.9377004397259493, 0.918679703771158, 0.9347627522345754, 0.8006504054212585, 0.8979163262564317, 0.9428791837278288, 0.7083218023867602, 0.9294658349522559, 0.8453394889180624, 0.4882088085301628, 0.8790993103309751, 0.9559651755325734, 0.8815458510830397, 1.0046156984557346};

static const float w2[64][32] = {
    {0.8834843048448331, 0.80771610070125, 0.6872749158420947, 0.9416844233681779, 0.7625653501663738, 0.6921062043098594, 0.8145400067363561, 0.7159373460907541, -0.1584656753151017, 0.7020140697254951, 0.9721083847618472, 1.0521388515694883, 0.7180183776552864, 0.45565610609917306, -0.21838107481169883, -0.5764673746632448, 0.1678375323244625, 0.26044795855553243, 0.8949646872196363, 0.48762326433771164, 0.5508003492424324, 0.7710091997245272, 0.718033464698486, 0.8934916344083912, 0.5470344904968487, 0.6261669749430938, 0.8937802232700542, 0.6513363056330006, 0.9835343631076969, 0.6722255465676709, 0.6007363653045007, 0.6858102256889521},
    {0.785771405515204, 0.8128771075631958, 0.7080406996695812, 1.1876832970981366, 0.8456774860932645, 0.652103606396203, 0.9925554354241815, 0.8845313963263811, -0.33284833904709277, 0.628667119528873, 0.8199955167830137, 0.7113629709395697, 0.804704632231026, 0.4262375331395579, 0.20200514700072786, -0.3330251118733351, -0.08816154127125615, -0.1532747775587899, 0.736592169400097, 0.3816196317144125, 0.7172624599505655, 0.7260346752657065, 0.7855136406662168, 1.1492042905923001, 0.4966480549142894, 0.6747254497523362, 0.8109764856074345, 0.7282890605708542, 0.8607820333600406, 0.7820789143356498, 0.8697582672620005, 0.7944408644194387},
    {0.6560156003811012, 0.7806933065879292, 0.6933089555486112, 0.8883484118214883, 0.5883318294104344, 0.9881075190075627, 1.0127522960771607, 0.7090522368084999, 0.16561870988629143, 0.8676307169610952, 0.6829581795993513, 1.166858999400233, 1.1624578560240328, 0.393890582533162, 0.08547712620101926, -0.03642514108809734, 0.1397589760731668, -0.2900216782175921, 0.632814675760033, 0.251925111345759, 0.8737886940727639, 1.042390798962876, 0.8675322001426402, 1.017582456715711, 0.1887654745754288, 0.9200057883913849, 1.0567474142083235, 0.5429328650377117, 1.001746437672336, 0.876473231091108, 0.5468810043424993, 1.0137939970026284},
    {1.130892982619567, 0.7136870013407723, 0.9663655424883654, 0.7084659373418193, 0.7078212594585515, 0.729053761032018, 0.715373599072615, 0.6418995529252549, 0.05405160631394024, 0.4366421315553316, 0.6769487259669271, 0.5759453887832038, 0.9428188792829504, 0.3521389803255987, -0.03230250812810322, -0.15577845356702485, -0.20492878065846312, -0.38120694978085307, 0.5724452233020323, 1.0959638137077408, 0.9255615509029086, 0.8649050330199498, 0.7030901862089916, 1.0955525517077958, 0.7393405404732004, 0.7539038100862783, 1.11518372127534, 0.3472456389124185, 0.9351002695721699, 1.0843184856112542, 1.0437225900776328, 0.7675594250343637},
    {0.9703589972049779, 1.0549645238361374, 0.919634134061617, 0.7773316011096051, 0.6831101399695837, 0.4501318104735241, 0.9008773307369379, 0.7478280347130914, -0.1263603298916186, 0.6768042436026019, 1.0040939191285851, 1.0992956938899887, 1.0565801908351302, 0.34244986251693543, -0.329283140799576, -0.1523039438807097, 0.0935715070211957, 0.18186015452814758, 0.608439486441869, 0.6367897833453199, 0.7238637507736055, 1.018682416335248, 1.043913628832343, 0.8021489501871264, 0.09495674508150581, 0.6475877368950921, 0.955010405446221, 0.9636524203504535, 0.6946318808728699, 0.7406325786986202, 0.42460483655692166, 0.6685510282331221},
    {0.6698296248281073, 0.8429759659612167, 0.429803126000041, 0.6826750733106978, 0.9030701736482103, 0.6275614205411357, 0.8070084201098908, 0.6842974801448494, 0.0811773463126559, 0.6504015758860521, 0.5283390411675687, 0.5939033566876457, 0.7869149521890044, 0.448953030255216, 0.13538414032422885, 0.04684392609616267, -0.2810898035620373, -0.06904800833310708, 0.8298089408350486, 0.3200302601470863, 1.062529651649624, 0.715476543833668, 0.9168293426837055, 0.811031314485704, 0.05452811595406905, 0.35268289319814067, 0.8422408626535359, 0.5540814150686886, 0.6036045469158516, 0.8531893738526809, 0.44804117997561066, 1.1955829964934193},
    {1.0642686813799187, 1.0367191700892275, 0.6763938121203428, 0.8224357212359364, 0.520773447094922, 0.36566450188918387, 0.7277358247077182, 0.984216197079667, 0.09353600628438292, 0.7533315722093934, 0.9864118627146925, 0.8785237849359943, 0.6746658777584906, 0.155293262876945, 0.016383114613167885, -0.42465525109386804, 0.08045893310257135, -0.10569536850827155, 1.039102101825815, 0.7768240478766605, 1.058379104911307, 0.5905807803811739, 0.3601081000632478, 0.3552746729134755, 0.3168020133430832, 0.7679335700964172, 0.8824132906261143, 0.5367175468254733, 0.9826085230097892, 0.8565067617291893, 0.6933119530148636, 0.8607653595231615},
    {0.9298992110384047, 0.7205492078430729, 0.802940221912778, 0.8759643895610012, 0.6185297953200273, 0.8628570681178919, 0.8730240737913533, 0.911643259081079, -0.04898597907647138, 0.5612304679978757, 1.1360309464463842, 1.3177368489284946, 1.1629017641896542, 0.6991186110127378, 0.054261439285981095, 0.13270847393498766, -0.04332329067592915, -0.20593762070468066, 1.0089769699087798, 0.6492202002979813, 0.6109653870927256, 0.8308526642408876, 0.9561865806398326, 0.6929164601499272, -0.01900647772065168, 0.6221899032028463, 0.7198368476997727, 0.6863273604386887, 1.0023290015577206, 0.8449003404494093, 0.7245656148361149, 1.135276712214521},
    {1.137867717280808, 0.7153610666986757, 0.8089319727525212, 0.7929763035891918, 0.5675898992644904, 0.54857714892222, 0.5282002348411076, 0.6225789488329355, -0.06003843896846181, 0.4190236495179333, 1.021943676325653, 0.6094510578620944, 0.7720918104427402, 0.37831390989005137, 0.07973343293426668, -0.4237464899432683, 0.11616399733861198, -0.01697851086223778, 0.4296418412287439, 0.40633300345224743, 0.7818979735474691, 0.9902219638780226, 0.49748873545215133, 0.8371204410937836, 0.34352188449559073, 0.3320210893908604, 0.883534894192404, 0.40420877132685035, 0.9611810433709269, 0.8898355901069733, 0.984312061961964, 0.9832399071929934},
    {0.7814502840479938, 0.5547511163208902, 0.8618747891472401, 0.7978984333686445, 1.0446192585287726, 0.575636851796521, 0.47611236530372547, 1.0570324506494932, -0.04690823658460076, 0.4203138341454233, 0.7785824112622205, 0.7803630549048379, 0.6597142668913595, 0.47845807396623213, -0.08010703098018375, -0.01628958415027927, -0.0539949326880049, -0.04649933345515297, 0.8470030343215803, 0.23077550071948758, 0.8369978983866189, 1.0841499634140541, 1.146652005863511, 0.7506293299801378, 0.15738025320877627, 0.6459793117629117, 1.0398230228048717, 0.9045073100609379, 0.9717541254913511, 0.7003486738029859, 0.8337474072684401, 0.871665728344655},
    {0.9662053894405457, 0.9180874645134771, 0.6697062662607581, 1.1358848188107384, 0.4828904388628131, 0.46155145291359073, 0.7556137112563441, 0.6084262310464961, 0.1138183939335046, 0.622997928760765, 0.963848169645828, 0.8909112475042129, 1.0229048827907068, 0.489843545203648, 0.2353219363882127, -0.11777895862156902, 0.02024737931755905, -0.16144603077680708, 0.9051516819198953, 0.31173354293073413, 0.6751162783544411, 0.94986644091908, 0.7288182911135938, 1.2026311649984842, 0.4993329270892191, 0.8969287438129282, 0.7677164477577166, 0.38093308234257844, 0.6070999557737596, 0.7570601954790553, 0.45961860949884104, 0.9014687145417832},
    {0.8823938481118427, 0.8048703034430761, 0.8571245781505528, 1.031948996661026, 0.6313426256708802, 0.41635754184456997, 0.9360728615074273, 0.6233339308540403, -0.19146857834160266, 0.6103039041382485, 0.8760690643005895, 0.8448547363567642, 0.7585483635309999, 0.4475165182593236, 0.014602269104397003, 0.12162664978734446, 0.0035746542022305227, 0.039051965545044746, 1.0559518094752174, 0.43172321738377833, 0.6409778020050958, 0.8094471141379711, 0.9928841950625874, 0.9692403263785725, 0.13635168518719865, 0.6334129116599916, 1.0830996978718925, 0.6900102048557373, 0.9651452181970244, 0.7706741174378735, 0.7618398014375856, 0.8278651375368058},
    {1.283654854350398, 0.9576792204848775, 0.6548578936708725, 0.8663525987997244, 1.1113072785995015, 0.7372256317112124, 0.4749318010973385, 0.6615277372783829, -0.16734560165513912, 0.4974912829176138, 1.0881796473605068, 0.8084792435524102, 0.7432702556154394, 0.39361347492672694, -0.1669443972315789, 0.0676671970745785, -0.1423384751496371, -0.19440941450466354, 0.5131102441298457, 0.5381951545792859, 0.7599082874797574, 0.8230941806136783, 0.8109261168604841, 0.7907819377585162, 0.4400815247067274, 0.6441858432740715, 0.8673548561238507, 0.3790669951677441, 0.7115030300009694, 0.8869798565704577, 0.37585089343731537, 0.7768327495485663},
    {0.7885841095289893, 0.7810582339910829, 1.1076028309927937, 0.7962719617791737, 0.8431198800258666, 0.7074643564697937, 0.8474409411546219, 0.6253716685393352, 0.020297144957816576, 0.9931639481039221, 0.5648185852178581, 0.9555850961134543, 0.883210416727215, 0.29560739219166726, -0.3735594506876594, 0.1113539900609766, 0.13927865369849277, -0.2097712063019411, 0.5581084473673762, 0.3650598583706829, 0.7287395062461741, 0.6628190919318003, 0.7738217471807758, 0.8793025470873337, 0.5514310830177058, 0.8253085675044964, 0.8430930949429553, 0.9131670583617716, 1.0773986447093604, 1.1264664579903754, 0.7674357252854758, 1.1083732998119715},
    {0.6071770771019759, 0.6449010828854926, 0.5773452522409428, 0.7208144664645249, 0.28638347232075734, 0.5899131299042525, 0.873686240199788, 0.9627676476946424, -0.1289125870858828, 0.7222485790641827, 0.8666330495982117, 1.0847061243540186, 0.7073541712022788, 0.5785929051257176, -0.2127375273212423, -0.08195892900022125, 0.08611854928951371, -0.09552186455995322, 0.7564946602717528, 0.2702008318688163, 0.963637830113734, 1.0840357380268488, 0.8884062501933174, 1.0006436867389363, 0.4674499369175549, 0.5537902775148519, 0.9903220428560898, 0.6207209365997314, 0.8022936493639096, 0.7961307326776567, 0.5138346860530033, 0.9652481858350106},
    {0.8279445440400813, 1.0339168698510184, 0.6997995641500807, 0.481947254542107, 0.7336740519406784, 0.6447937099703229, 0.7484347639426254, 0.952070260390988, 0.20902981548141666, 0.705934892053194, 0.8821410324196027, 1.1143513739939601, 1.0617138571429632, 0.46792411270799816, -0.1295426987115645, -0.00026219698910569624, 0.24307062191651974, -0.008077489089658753, 1.0483232801158215, 0.06546443236186203, 0.4937858582777922, 0.7620744206493012, 0.9881408140957386, 0.8964577424503636, 0.2647556643470693, 0.5911919528549501, 0.7512714503965843, 0.7099164695002349, 0.8075473435179393, 0.9076792231093789, 0.5660466596951143, 1.0514367942776266},
    {0.7290648821775507, 0.9455173697642155, 0.4996202391477485, 0.7205978280998903, 0.8636974911002738, 0.6351744435314105, 0.7921253871443585, 0.9975191145238319, -0.13147667234611876, 0.15665314049901113, 0.7527160791257688, 1.017170002179832, 0.8764874978098319, 0.31691978850378005, 0.22827342614649154, 0.004500034495647101, 0.10784156398827359, -0.02114095058248565, 0.6327960665270687, 0.5835187608590543, 0.6296738915385207, 0.8229662659011469, 0.6974159143735458, 0.6456636409373195, 0.1974007505393424, 0.6013310723649552, 0.9677690850815686, 0.5372878679645636, 0.8484109987072721, 0.8796660211897143, 0.7879155278796133, 0.7312307019227476},
    {0.744804981727575, 0.9405202895017103, 0.6597921854532696, 0.8318866425469666, 1.0718370029597506, 0.4631078975016733, 0.847261246810344, 0.5655672436354154, -0.42133686648985363, 0.5385039573324285, 0.7509907661617224, 1.002674241155803, 0.8728576366972998, 0.5987178113990477, 0.14849489184390813, -0.1101934778679849, -0.10646590490418616, 0.08043603170102799, 0.42680486756201924, 0.4583809255398099, 0.5578216167110193, 0.6993227986969506, 0.5871580268479324, 0.6754389642524904, 0.35445957743738854, 0.6493804937233957, 1.0159446585447005, 0.5158333267844875, 0.9424540859455873, 1.0232680021548513, 0.5325875126489591, 0.5937880800734955},
    {0.9547103189152266, 0.6824554398357635, 0.6701367356291212, 1.116291763387584, 0.6883933046949765, 0.7030586874672266, 0.6647759507399287, 0.5943172203668083, -0.09835349068901976, 0.7332033917904354, 0.6300284475059578, 1.09681788409479, 0.9516881989156363, 0.7168592297460304, -0.08967594387570986, 0.23674880578060467, -0.08368522735298359, 0.07455475899485668, 0.5390577361453485, 0.6870238480651016, 0.9773135114632139, 0.8245598980998464, 1.0162199818037625, 0.9491649803748873, 0.5680991404834175, 0.648827447910445, 1.0472306751330263, 1.0485809632686034, 0.582824894539432, 0.8079607018896723, 0.7688914853110168, 0.7878192562363985},
    {1.1911801982129593, 1.1303830136281734, 0.7368436486141343, 0.8326936351845793, 0.8834643897068417, 0.3621977736075652, 0.4563894900763038, 0.9823987935463351, 0.040265146456984924, 0.7575810237007204, 0.7776867224225288, 0.6286442845160897, 1.1294989878939699, 0.4850575979552785, -0.0063821640950239315, -0.20341906196131276, -0.0355055910795028, 0.3271983814232511, 0.8858470734163452, 0.4260206094489339, 0.9310259802831515, 0.7650270681557237, 0.6762388996072367, 0.7997313477755303, 0.5360764463980743, 0.661955052231372, 0.9481534772597725, 0.580991117722479, 1.0833605446943857, 0.6269594553459732, 0.3670950188169063, 0.7237667832851064},
    {0.7943197698571556, 0.5939503845109951, 0.3912072257408255, 0.877241919170017, 0.78812005102287, 0.35188660343157224, 0.3449371013664718, 0.5337577059783296, 0.11722822906228035, 0.5928107824658926, 1.021624596266435, 0.7816706263840986, 0.6963569051928004, 0.6503439649045112, -0.10535857180196927, -0.2437154569917006, -0.10890898874458173, 0.07894581577947853, 0.5511200263369694, 0.4829814391371661, 0.9668339019280217, 1.0305356311007146, 0.5901243899238147, 0.724796985461224, 0.614399060398545, 0.5451241149597238, 1.0109946948542694, 1.1491703583909472, 0.5368475784496496, 0.9024195607250757, 0.4727852230707327, 0.6378585677515487},
    {1.0290576579214625, 0.5803074842294269, 0.8145510057251545, 1.1034733256702367, 0.7001331026483988, 0.8108680483873462, 0.5773115058503332, 0.7684731595683887, 0.07609950917855264, 0.5621460998446417, 0.7522116290543392, 1.175746601824766, 0.9614943874725408, 0.38508780973357604, 0.2596655430607832, -0.11837486166075407, 0.03524939086477055, -0.3759997408266775, 0.6030409772724251, 0.36150132653830447, 0.6398735898843715, 0.8196602745419493, 0.6618358156238198, 0.9407179807239754, 0.24595618698309216, 0.8201897451627393, 0.8786241625996363, 0.9264034905354953, 1.1606084796656848, 0.8017568324825705, 0.6729950403772691, 0.799806997776947},
    {0.7224424544292589, 0.8730715905691709, 0.3014274708703373, 0.9500747768961987, 0.5216138877897551, 0.46362098793714385, 0.6973626200864798, 0.9552740739197498, -0.2028124482914839, 0.7213205818019613, 0.6161817518070679, 1.0836308246324264, 1.2416389483708858, 0.6535792599060702, -0.012969332086110473, -0.09187697612713376, -0.00817323581345877, -0.01401947417009024, 0.8096879053462159, 0.5433547377485595, 0.6180221573498403, 0.8576389907513702, 0.9182940498233734, 0.7696455093732896, 0.1849309087837498, 0.6192833308600226, 0.984825454838465, 0.7910201511624232, 0.9092413290134906, 0.7417139307455647, 0.9409717517386486, 0.6386800704306425},
    {0.9966843022205643, 0.9796185394482575, 0.8236576753663591, 0.8867451577670954, 0.596983056926655, 0.6841610535116547, 0.7121697092750862, 0.7847662186073714, 0.09995959181987797, 0.5874482271568203, 0.7521766368281761, 0.8634848737367508, 1.1779598673359506, 0.5154921268533017, -0.31161741237270607, -0.049119739770622846, -0.1174929649576854, -0.0152541945688931, 1.0529316133999818, 0.16788030572743448, 0.4536198824379057, 1.0126739454220761, 0.4912848529145019, 1.1316320487421934, -0.09100156651357115, 0.5978896106326784, 0.6691504012087842, 0.39333901871053745, 1.0387718936784431, 0.7413368636868176, 0.2746423016883096, 0.6560986574677141},
    {1.1510672627979408, 0.9063788210930529, 0.5153813496337654, 0.719311572568246, 1.0501652956506906, 0.24029527049660493, 0.6469289601584335, 0.8324655102729338, 0.17182596861770041, 0.4358581132851731, 0.7109262914228791, 0.9646364217189537, 0.7070992063295087, 0.4197387494845634, 0.10879712976751707, -0.3662490100775906, 0.09075456948813425, 0.10359096124764644, 0.6732847632062776, 0.42613705261908125, 0.759777626216852, 0.7272251822995459, 0.9214993529099897, 1.0644827637810113, 0.3145320939587963, 0.26688220137165397, 0.7928826335323892, 0.767242483707945, 0.8589367344290675, 0.4891613023388228, 0.9654742092682226, 0.8157063319976484},
    {0.6907179527034395, 1.0684279130253111, 0.9123710674342189, 0.7937905203035833, 0.7423697761765062, 0.7032923275824383, 0.9676829592847067, 0.47543159975369037, 0.062316797834377824, 0.5599272427716688, 0.8974485725909435, 0.8537216595063101, 0.949087071256827, 0.7776581404685999, -0.13268380553987547, -0.07431952277226989, -0.3415442624251318, -0.16085495423179808, 0.7242550083577944, 0.4256301113134533, 1.011490752776244, 0.8925563072525415, 0.8991260561691881, 0.998386007554324, 0.1798878105753043, 0.7355316985211163, 0.798225094041691, 0.7197880498151968, 0.8988211710939056, 0.6889047305719276, 0.5651809217067264, 0.9152417109659067},
    {0.9937890151586966, 1.0806070608829894, 0.9905883214156505, 0.8660352349616165, 0.9711460942917842, 0.45486390300585705, 0.7940133756443175, 0.4524173558376993, -0.08505039544022484, 0.7065542402387851, 0.7320881401150777, 1.0356610996636044, 0.9262863712439173, 0.5823553018739394, -0.0955020730850259, 0.10883510403949817, -0.04919545207262481, 0.06357301653351648, 0.7997767142351868, 0.4713962654438596, 0.954065574415791, 0.8014436693487402, 0.8121007338002023, 0.6786152234393023, 0.34977630379522096, 1.0187535680862305, 0.550790787229644, 0.4250499003354342, 0.8146625546967071, 1.0148044366384275, 0.4842223512823016, 1.0454566180167866},
    {1.0006833464325458, 0.9634723134028518, 0.2961420408831551, 0.7479152168739559, 0.602431291098265, 0.6062701502669727, 0.6636572205854442, 0.845940942797295, -0.18351071051390908, 0.8884025444987617, 0.7334685834500687, 0.6411981932482486, 0.7812735413315689, -0.02439113477839744, 0.3767212610163237, -0.09174365317835535, 0.278049400187656, -0.04621176542109252, 0.8497538071966309, 0.38691536960641393, 0.9732023927198753, 0.9329996101062333, 0.9092666848118809, 0.6031677663310099, 0.08137754221999634, 0.571336054162572, 1.035849609045122, 0.45918125481905014, 0.6730795585354206, 0.7770047635659321, 0.7294506932238224, 0.519066111534845},
    {0.8421768097719639, 0.899912362733884, 0.6650918806818976, 0.9180959075292134, 0.6256386109008043, 0.8009186399544751, 0.5165652015680506, 0.48638295012465155, -0.14807149417638366, 0.8227435712892985, 0.9320272863067828, 0.7354776988961405, 0.9255320734773922, 0.3531882924947365, -0.011422666244046574, 0.08577414849982802, 0.007467858545375305, -0.05361726129350258, 0.8044685302258907, 0.45559387257094497, 0.9310064546351363, 0.8714839694849035, 0.726693355703176, 0.8254120013010287, 0.4724669956197339, 0.6064278031241134, 1.094174113014919, 0.5390850898573274, 1.0984240849260865, 1.0005693044550588, 0.5838673957105166, 0.8276009382475958},
    {0.9329987466044225, 0.5830358560744751, 0.556206841761679, 0.9260852694659717, 0.7600383108651987, 0.472798842289609, 0.9678918178722131, 0.5332620105027647, -0.06563256062041369, 0.9808772289373515, 0.8729519678699654, 0.8017615650703939, 0.8223338103343599, 0.818373095067514, -0.09790579615204538, 0.0945868826929388, 0.03877734204862437, -0.2172902809132228, 0.6895261421747776, 0.5843956187691072, 0.7530027818731654, 0.6457764431293539, 0.5401879279180417, 0.9427685047140582, 0.5036582999628769, 0.6504742918997112, 0.7918256367254984, 0.5134592454069069, 0.953479236613449, 1.0808435178375773, 0.8595329655301088, 0.87401354659094},
    {0.7118595481392513, 0.7401608449954566, 1.0887549932178242, 0.6511523947173626, 0.6285570836624391, 0.5400675036976291, 0.44750778131846713, 0.7850906338513366, -0.3036337156699375, 0.725961518617811, 1.089182336274697, 0.5139636397406787, 0.8712464011696323, 0.4403187252885529, 0.019117809927754525, 0.07854937135063635, -0.09735773454409341, 0.01616162380920947, 0.98170235401083, 0.6781631604661374, 0.8276484030939119, 0.8917286092656906, 0.9493923411844314, 0.7475082258707507, 0.4273674014179934, 0.519836066108443, 0.9293807852952446, 0.701368589701138, 0.6130837153994564, 0.9697955145729605, 0.8770195346985141, 0.852119638630416},
    {0.8284536750080205, 1.0046761213404085, 0.8335130456228319, 0.697912338923162, 0.8275522412489736, 0.8165198764707586, 0.9369351656051069, 0.7176503284731953, -0.19079581969544507, 0.6200668225467478, 1.0614054975550065, 0.9199121763403542, 0.7400165428012527, 0.45894246297728297, 0.027026005022554055, 0.34255650066313276, 0.17179947799360096, -0.1519982977559344, 0.5938328687282252, 0.6194176836685669, 0.7037964663021095, 0.6024180822616721, 0.9654270839231331, 1.0298572636000427, 0.39978806062162525, 0.5872532861188658, 0.7435624673320295, 0.5120612626523124, 0.8251117475607913, 0.6891762794983046, 0.996389536695836, 0.35423564237221566},
    {0.9167510599271962, 0.8523699877077335, 0.5932797962362376, 0.9281402770032924, 0.676692388335158, 0.7355132124153037, 0.6637294522090118, 0.8399060275363799, -0.008638247965944737, 0.6522160272080931, 0.8365510843479326, 0.8952475935389782, 0.833003018514855, 0.6673610593161979, -0.32782691022550786, 0.0055308411834471445, -0.1397983744070887, 0.05950189277044738, 0.8779787509690875, 0.6178556152065159, 0.8596359090899738, 0.8481396078113004, 0.6467418453348542, 0.9484801369030001, 0.3612957927023865, 0.8130844011113495, 0.815375084259042, 0.42863297087210434, 0.7250727661630608, 0.8436072946267342, 0.5129783578640167, 0.821922980435308},
    {0.7403729488824553, 0.5334510846404963, 0.9121515784984986, 1.0811896026030552, 0.6786142729542699, 0.5620826109699685, 0.659477730918855, 0.7740631336719954, -0.350914540457327, 0.9520470450744161, 1.0890419225965957, 1.0860231030434904, 0.8582307504498546, 0.7060124152697586, -0.07545386271115209, 0.08990248989079298, 0.03297242636406584, 0.2159228483455075, 0.4937913914258037, 0.699015435953015, 0.555732978644044, 1.065586334910183, 0.8432110217204054, 0.905433644474115, 0.528593057196146, 0.6404532128647302, 0.5249599470669823, 0.941927209516428, 0.8577542205002204, 0.6268914626307923, 0.8538056872150983, 0.6985661615389586},
    {1.3587398874703223, 0.7017840198720721, 0.7313943757165384, 1.013476945379334, 1.055916623538998, 0.7826490825447633, 1.1612198083315695, 0.8871909470378817, -0.07950980618245107, 0.26096094842198553, 0.894162249787284, 0.9937153793030187, 0.8020666082728802, 1.0191170145423818, -0.21389215941252468, -0.18830099444431536, -0.16129861269713677, -0.0447522638812377, 0.7731086127580913, 0.2871726377847967, 1.1031922904443199, 0.7018728693035938, 0.7759797660681977, 0.8645841659799921, 0.2254556050407072, 0.8100361489424611, 0.9419491631046535, 0.714355997052768, 0.9600241444872312, 0.9515529410169805, 1.1205878890502898, 0.6174246026883808},
    {0.9347546484379176, 0.9347718951397996, 0.8823377313270168, 1.0103824192631672, 0.9061438883802172, 0.7016073006321162, 0.7904337290377547, 0.8391637848918208, 0.047611157907511255, 0.6896742165337826, 1.0708027045667445, 0.7555976908988837, 1.0461948276574398, 0.4337133426463626, -0.18748524119813612, -0.09163916996827287, -0.11470796247993237, -0.053840280274949144, 0.6539790621010539, 0.4828653903712278, 0.6458965363154995, 0.7981614101969451, 0.9614335443518861, 1.0437535521345551, 0.19394158782896662, 0.7186095030407635, 0.7531493359370764, 0.6565870392855291, 0.8677312468072711, 1.0654350978289682, 0.77749413315033, 0.7842400197386739},
    {0.6858606890357862, 0.9657559933938709, 0.9915442204475123, 0.7185649222523129, 0.7839278322407358, 0.7976420922415552, 1.030214809637712, 1.0948628961398397, -0.10781239146194303, 0.5132079398510091, 1.033850044442277, 0.8963595076626538, 1.1152437487525548, 0.7766726130313836, -0.19749898005088817, -0.09059010512221537, -0.18285330601714045, 0.07672850725134028, 0.6351729890506481, 0.7361784079790363, 0.827597800074903, 0.6573658745461236, 0.8687548951129939, 0.505402113124214, 0.140651749620912, 1.0827296880955153, 0.9993353075310102, 0.4498713593401972, 1.032478382298508, 0.5725991209277279, 0.5510873889592143, 0.8735425425301586},
    {0.8859733886307635, 0.9374477619947132, 0.7691637517237024, 0.8891023751055447, 0.5915509920596203, 0.7830212154645149, 0.958702721024338, 0.9524912054096106, 0.11365144956928509, 0.7338014033834331, 0.7485718904601555, 1.0887557607566218, 0.6679409792849164, 0.4374079585685509, -0.10926537313443382, 0.15104406832143216, -0.08029713885256709, -0.1303481395929403, 0.6460588492176782, 0.39159114678714085, 1.2167327284182676, 0.7530740891092602, 0.9010048810589267, 0.7706958848080679, 0.24172254734821755, 0.5081239582108974, 1.1017118176838927, 1.006756921889073, 0.8055914765790759, 0.7449757108873055, 0.6174995073862433, 0.6656591345271087},
    {0.8615833584430731, 0.665521729749694, 0.9558238747439358, 0.9095150332599796, 0.5872302255428633, 0.602749434421219, 0.9331384273437977, 0.6969453665173725, -0.15701134841068215, 0.5084020820547892, 1.1100319993365058, 0.6043949048354174, 0.7530232351762582, 0.5224641149606272, -0.11474245432028175, -0.08284876251290464, 0.11678797612647605, -0.2619438424777882, 0.6171170179308293, 0.5888783689853884, 1.0065883342504, 0.5769017771473091, 0.599777004677968, 0.665946516496895, 0.2907430967896969, 0.5372732481953809, 1.0898965855191154, 0.7403245873162542, 0.9558504806575844, 0.9410890379190322, 0.24592122230227215, 0.7818905980121119},
    {0.7391901400652802, 1.1092545493316066, 0.8641856511097546, 0.503857110865742, 0.6554970560235367, 0.6604673976769061, 0.7783989955248838, 1.072706410285772, -0.5539017628587527, 0.6736002164288154, 0.6569671532188984, 0.8293869765710726, 0.6502755303925156, 0.260968134819929, -0.21053071448111482, 0.17462681981189423, -0.10876487934516998, -0.1050719506114248, 1.055834361894627, 0.7794646040649275, 0.717295567207793, 0.7362750405010524, 0.7496331206163095, 1.0098975309229876, 0.5438495587419884, 0.6345027520929658, 0.8695636114315104, 0.7434950172837925, 0.9457141707886069, 0.6857073353538663, 0.5709175161118945, 0.6052357575984647},
    {0.7279086306627945, 0.6941535382959979, 0.7281493546081074, 0.7069757121847191, 0.681836260009005, 0.7247818935047997, 0.9759750672100981, 0.8727153405685328, -0.2592923086261786, 0.7446796941990586, 1.0654935119960482, 1.0970243319178814, 0.9689069271556511, 0.7165474333279989, -0.11291419329328832, 0.04908009371498701, -0.3564624109417787, 0.13066579915437387, 0.9832526672668948, 0.4120625833479402, 0.9230453405684994, 0.586506424588866, 0.9214461669284548, 0.5343723131920991, 0.46992209107024624, 0.5445302781722349, 1.0740449767937708, 0.6180118881003289, 0.8506747091712378, 0.8678596398272006, 0.7027820847193486, 0.6515474243053633},
    {0.7846793902801268, 0.736778023899455, 0.42221123595750093, 0.8229831242880358, 0.4540698211120407, 0.4780257994968786, 0.7025079507627423, 0.9082793326960101, -0.3218715515699227, 0.7092349383650086, 1.1583110272877866, 0.9982300425003454, 1.1551093731166502, 0.46459667858994275, -0.1858163525355955, 0.10807229671399463, -0.18060852027663163, -0.17575793852231586, 0.6522094915497473, 0.11820145988684928, 0.9933595167768132, 0.6737879883975711, 0.3854568877183887, 0.5937086914468133, 0.6397300114258427, 0.8765181674346557, 1.050673739850488, 0.8463958891052558, 0.936572711698763, 0.7330697333572944, 1.0192757241503054, 0.9182731503574552},
    {1.0633269170975301, 0.7834049310256505, 0.8025938067339321, 1.105056703282939, 0.795731472719704, 0.4274156415646658, 0.8111014469375336, 0.7303856798444541, 0.027350247932014522, 0.9157889816972605, 0.9219233418948367, 0.8586939847472485, 0.7297656961360263, 0.6132492150172542, 0.09214785883906976, 0.010281338369244193, 0.07294612702697048, -0.3279525535620267, 1.0107012933724926, 0.28360265842236826, 0.5204932578242, 0.8642008963297552, 0.6427640115677976, 1.0189651788933685, 0.5586035960262686, 0.8630467142426319, 0.44644353410748117, 0.604034358026165, 0.552366965769694, 0.7664830238853239, 0.3570705894702697, 0.8082430124741209},
    {0.9152901619844805, 0.6480343551510359, 0.5668870348692957, 0.887236295234412, 1.097983330463654, 0.61846970615133, 0.9158983867647131, 0.9972983958995816, 0.07430673213829757, 0.859462793869691, 1.0672517332410052, 0.8577483703735518, 0.7316401694898996, 0.8096413151800852, 0.20026795584268095, -0.25393353396372303, -0.04020604434056831, 0.06841535453804153, 0.9775227323700731, 0.2360210577111721, 0.8585577912761093, 0.914547280492468, 0.6347333612786249, 1.2809076524203122, 0.4974809799784242, 0.5259896460899145, 0.4310649292992929, 0.6211765939662287, 1.0857624661360654, 0.683297820981167, 0.7231857509504356, 0.712340070235038},
    {0.8585147044641429, 0.7263628254447951, 0.6916875168525521, 0.4877766933521211, 0.6024111814776032, 0.8145891267456767, 0.6414440730523915, 0.921545652946711, -0.030147651877168596, 0.8496418745682554, 0.9383668410897754, 0.6956643707510302, 0.7973904860065489, 0.6393295656393172, -0.1996286388418569, 0.14889855072255245, -0.010687323211328682, 0.035483602699887914, 0.8637440345900087, 0.5292956537495893, 0.8765700274434134, 0.5167990585144911, 0.8296903197988289, 0.8372304169700627, 0.4447708888091745, 0.6100046611546539, 0.7001332621369061, 0.8266153693566152, 1.3369971967270502, 1.0442139251892342, 0.2949622303757355, 0.43840947327520946},
    {0.8563717457983892, 0.510017978297819, 0.9657222851972641, 1.1162583826045036, 0.972306890133423, 0.8558106152991923, 0.7798626692700589, 0.5593358338504305, 0.17876532266878448, 0.6470295019156844, 0.7491129310867508, 1.0211097871910542, 1.0843848935145652, 0.4778772952952066, -0.07761259294614668, 0.03754038898173984, -0.3505242387415611, -0.20235045891649248, 0.6677526038282274, 0.6240422469724609, 0.6729829706095392, 0.8360549299925801, 0.4240242603304854, 0.7681599837251646, 0.15374190017199965, 0.6340612417729181, 0.7015475448746125, 0.6379382839342619, 0.6702402856275307, 0.8811124462503137, 0.8980049659247797, 0.8358242844143969},
    {0.7533409886349027, 0.705894647859028, 0.6120726471560134, 0.911723019696534, 0.9345289773816812, 0.387991898322746, 0.6553594802265124, 0.8173942728118844, -0.04133274934230513, 0.5378689484883739, 0.8370049551369265, 0.9795083888121696, 0.7154810881066138, 0.39205611110819916, -0.3641192087041962, -0.5110214226061036, -0.1360032322260189, 0.04323099317126618, 0.719047174510629, 0.5370843880597153, 1.0545556965386362, 0.8465463323473844, 0.8331910267197091, 0.9505855435150582, 0.2551637007519607, 0.41765415984566867, 1.1636734259095423, 0.4863457501924304, 0.7114002911871662, 0.7890399283566837, 0.38354018444002785, 0.7565620842128775},
    {1.0772800413092527, 0.9284417128046608, 1.1237705156518967, 0.9120009500124692, 0.33023997561040047, 0.7008978925308879, 0.8773838178251656, 0.500269335024646, -0.03493702024883267, 0.7263223324875441, 0.6324458880859264, 0.9995521794213909, 0.7551525614216261, 0.3958376807325798, -0.1347419681713228, -0.1560382445373483, -0.02062070802640026, 0.27372582660032746, 0.7095826796726495, 0.8690729992658752, 1.135929877605648, 1.018933111416259, 0.586079206767414, 1.0647381682943533, 0.6760420901981247, 0.44306513088803556, 1.2262989206766133, 0.5592431859267578, 0.7985889679442909, 0.9467781931726246, 0.698106770243201, 0.779889546591474},
    {1.103628599955095, 0.856530619902024, 0.9577689842681629, 0.8269105882194487, 0.8435338644780274, 0.6106562717069841, 0.9991191043790653, 0.6015888419694041, 0.1048055086584512, 0.525892907389603, 1.110608945017665, 1.202720739019005, 0.5495057055067919, 0.5680865404899466, -0.11639021835480114, -0.12390465704362302, -0.23942340723335187, -0.15885324007473345, 0.6531491207232386, 0.3768850209104843, 1.067107016613972, 0.9616184446941625, 0.6819250437619315, 0.9237697798487059, 0.3512390246121519, 0.5446485848526406, 0.5960969247322774, 0.4372851812418551, 0.966104639702798, 0.6756878936224598, 1.0320892401947301, 0.6195695749445593},
    {1.1287046312788875, 0.8890750273257539, 0.9963056635996479, 1.118072674076344, 0.7169244701989173, 0.6315079714147758, 0.7215632236083659, 0.9254441814541934, 0.012642419702164363, 0.5547965788326344, 0.5979997695288263, 1.0926335120526267, 0.8089949152239931, 0.4401532176333206, -0.06166751288151748, 0.17464383215204562, -0.2919356060689218, -0.1733946439481831, 0.5583255810210841, 0.500620764210385, 0.8671733472139458, 0.7444011139923681, 0.7933980918877972, 0.8419380544016031, 0.5819025048846874, 0.5542764126606282, 0.6796852686652606, 0.4869914688597273, 1.0043506365615804, 1.0545626293966126, 0.7871995151747547, 0.9184831075784232},
    {0.8688771318337329, 1.123733920582118, 0.7633504947118053, 1.0320692600539119, 0.8543448419242083, 0.48277211792621455, 0.8310730379254402, 0.6218706940318394, -0.16784838641945765, 0.8531580227247849, 1.1222623957102735, 0.8469755598605938, 0.6682315762582437, 0.4167224324183994, 0.1015736282654712, -0.25511078935070375, -0.18884663357147957, -0.4416070624634368, 0.7763090895112692, 0.17988712579194613, 1.114618299993296, 0.4471471672393516, 0.8172767056374798, 0.8604971053072658, -0.01600991123232731, 0.7141175789425911, 0.7430993073336076, 0.7551541937097717, 0.9102757485352597, 0.9100044188820993, 0.4580629800520127, 0.7624576764696446},
    {0.8540907642838254, 0.8666375913634027, 0.6052775336114307, 0.8634552987763209, 0.9768412304970016, 0.6712651548659475, 0.9916246349409006, 0.6617173298911955, 0.00987622432914284, 0.8043813673958319, 0.3870915465746794, 0.9493068689991989, 0.8587875474840116, 0.778668323284453, 0.01734875668854777, 0.18675887956125664, -0.01522233636870509, -0.019708577843196552, 0.6053999058381853, 0.09754855517935461, 0.9122294043318401, 0.9567139165442624, 0.8638726076455918, 0.9340346195314096, 0.1129515832299836, 0.48668801672391104, 1.1515932254733514, 0.6695341746679949, 1.0721794144207426, 0.7318482793036946, 0.7185201283695333, 1.037471504131402},
    {0.6694512631624892, 0.8140716600657527, 0.9213461669675105, 0.8394653016462462, 0.758839891573492, 0.43015509116463574, 0.7549828066624441, 0.9078225825363463, -0.1255620025687408, 0.8580999214660052, 1.2361845146865638, 0.8986925829010461, 1.064904018911741, 0.2562760412499337, 0.04514121988201715, 0.30923353809162174, 0.0038439455618296974, -0.1431210115387838, 0.7235836358769704, 0.572523225995341, 0.8811673763918626, 1.0314252530925494, 0.43648527369702433, 0.6835926035482469, 0.6004895412190749, 0.6359181564396658, 1.2086095107197776, 0.8279393739476296, 0.9489524888041525, 0.5436655819004703, 0.5334459358994432, 0.6738640481450214},
    {0.724459542252929, 1.2399320817221229, 0.8008522104378736, 0.6312781654517388, 0.7898267924319167, 0.5447304866795903, 0.6259877901987432, 0.8214720511609401, -0.07543067248277877, 0.6418506655898062, 0.6201624705821218, 1.004765765520251, 0.9347526557171205, 0.3563385276247251, 0.08563624598981179, 0.0747039565219567, 0.09445001957329748, -0.2896722267417774, 0.6786300497392417, 0.30343376389400506, 0.9418125797830637, 0.8874242072471693, 0.8453352988306063, 0.9707312280474967, 0.33280608343094714, 0.7099208006945994, 0.5915867022153839, 0.8778685038757522, 0.8428085322854666, 0.7174875533873704, 0.700591528125659, 1.0019480352584882},
    {0.9896598576092764, 1.0893726008752227, 0.6631433663778553, 1.036793360452785, 0.6205514303507451, 0.8114908488365562, 0.4790969590702395, 1.192634247545711, -0.1438387061477776, 0.5980481487787234, 0.8451599499937963, 1.1541005803405253, 0.9002470865782207, 0.5990661828973279, -0.11937510268385824, -0.18565920251180068, -0.24667870367884473, -0.1329364532314811, 0.8168911254220979, 0.41410075441171335, 0.7518223769624406, 0.7422682147473426, 0.9564542846074044, 1.0292538190922287, 0.4234867389888571, 0.45963245255659557, 0.990031925913884, 0.7549477550571201, 1.158609256534646, 1.1358269243160495, 1.0830545472558049, 0.7656491068239877},
    {0.9312465399669069, 1.1276957309899824, 0.6064147710528868, 0.8482313451420376, 0.6139704999328592, 0.5089852941958034, 0.922349333861532, 0.7136435512733316, 0.04605798658731108, 0.6489134361928872, 0.7842314618256895, 1.0228814539293527, 0.9888685329815855, 0.3022708798811179, 0.03422512701610326, 0.09029651935478783, -0.2435615981392587, -0.06926354534887248, 0.7044535406484704, 0.21324561414440862, 0.6637882286032278, 0.6289273300708244, 0.9050880873845856, 1.0333361406580956, 0.40207259981100374, 0.4877801848459346, 0.8008420401941171, 0.4668117258923436, 0.9828754640418712, 0.8886496777182277, 0.20385765539928197, 0.5238960445732064},
    {0.7135977206250167, 0.9492115963999452, 0.9988998256677057, 0.7634869955051371, 0.9762232007173695, 0.482096330650759, 0.9972818466856113, 0.7029011803156734, 0.06195372670817876, 0.7290910670862563, 0.7870789409732475, 0.5171581601433404, 0.6117327497576831, 0.7862036056603523, 0.029904491752964654, 0.058450845240185796, -0.1826877525111136, -0.1782419391475806, 1.107861762458908, 0.3243112042710108, 0.7810401026330854, 1.1423662577324536, 0.6343168107557517, 0.7275375814562429, 0.4385703005967456, 0.6575536711103177, 0.6720651471132019, 0.8497662655465421, 1.0030093618904874, 0.9876320605429452, 0.8921629665295343, 0.6327894442441611},
    {0.8769896189511143, 1.0618164712041436, 0.357069086048118, 0.7826359613934702, 0.7309085223809348, 0.7682663974237274, 0.6892638064981645, 0.8301759001677782, -0.13295549688020578, 0.6571770856111159, 0.4869266249832547, 1.028594324034473, 0.9382296730279723, 0.4940636877152222, 0.06473462125655217, -0.2365901040328534, 0.14190275124556478, -0.10233182055957606, 0.7716208177633618, 0.36025388955227955, 0.5670412235538425, 1.2397061486797774, 0.5654248570645476, 0.648440401673803, 0.4118063142027044, 0.5398605466888052, 0.8978846295444389, 0.3252196909101809, 0.9107416401105017, 0.8531446528840971, 0.4924779911612934, 0.6416369439696586},
    {0.809895274218699, 1.0931402015119767, 0.4330586138179724, 0.6835963961466125, 0.6291103323680203, 0.2661230466763129, 0.7937384512973445, 0.9055893636892046, -0.1821141907469832, 0.6123450604207906, 0.8739559104139423, 0.7633476935589073, 0.9498004238474194, 0.5719444819910309, 0.17658254859182096, -0.07525729925561644, 0.14124893798155058, 0.21545062058682923, 0.8801613115774654, 0.3724508270211672, 1.0393916207412146, 0.8493286493655248, 0.8048801501215334, 0.8571594901175057, 0.2785986150196473, 0.43559462911890373, 1.0589916984001821, 0.6692417015906442, 0.7600347417681533, 0.9426320875270862, 1.0340980155936101, 0.8991913242869778},
    {0.7641529084793602, 0.6487159897160704, 0.6771242115896041, 0.875312076734714, 0.5673541429593913, 0.6180017293170559, 0.4533509162893749, 0.766837896332401, -0.14114672750558252, 0.6826982833413598, 0.7563505950846643, 0.5683096323684843, 0.7775700961346064, 0.7966515267689709, 0.3261320036661772, -0.09904195898084957, 0.038884801193533595, 0.26549714571571126, 0.7160111108263274, 0.7472667068861764, 0.776297593965702, 0.8039995840680152, 0.5627046218865621, 0.8676829791913611, 0.5796450757518757, 0.8244590092716741, 0.3942620811388834, 0.4021720915425928, 0.7795575442078524, 0.46093542848469665, 0.5109804331286475, 0.6373700032983218},
    {1.0801587964739823, 0.949444419012304, 0.6743916413192712, 1.0465121148130359, 0.9810517325987992, 0.26263013113874184, 0.6996609695799679, 0.8540256067149606, -0.0577116411485479, 0.6195305864889847, 1.0432736837912016, 1.1408155284249006, 0.9953601414991144, 0.4010168616357488, -0.2281510714649196, -0.10095532165071112, -0.2303952134329476, -0.01547109200108412, 1.1314653432904673, 0.4558683412410707, 0.7720154543146868, 0.8329847927653755, 0.9468951472628089, 0.7781006438101934, 0.09474320747034021, 0.6949158587676564, 1.1506098811933263, 0.5996668261733322, 0.882744527015623, 0.5944099751419591, 0.5128006881201058, 0.9743202227227703},
    {0.9462132061143393, 0.7836956292048869, 0.8742068727062233, 0.9006655017498109, 1.12565041020882, 0.9755606116853921, 0.6998472701303641, 1.1415450325926213, 0.07120104296020088, 0.7951772999520116, 0.8708391393039142, 0.8290858088404883, 1.087547376633486, 0.635777019205845, -0.02802583948634551, -0.12667421549808158, -0.06907438122098097, 0.0676331882298479, 0.5330497717868767, 0.24623605372554422, 0.5830461664732338, 0.5449121295823943, 0.756192469105651, 1.030052790637259, 0.5689936231064621, 0.6072754568106069, 0.7601703782173125, 0.4603912298978832, 0.9905100346815398, 1.285162091029681, 0.5491696928541975, 0.9624172302743942},
    {0.9306608893829311, 0.9045382678294513, 0.6793370744540057, 0.7574787039719965, 0.868633075875643, 0.8073189826416544, 0.6455896046632711, 0.8897434962092858, -0.03342456071373778, 0.6894385956125916, 0.7685212013653236, 0.6952491679947774, 0.7867081691554553, 0.3605563264784881, -0.25449285698085866, -0.2369098448914266, 0.09514162563485003, 0.018249262663796628, 0.47444289979993726, 0.3122728842729532, 0.8765243326059288, 0.756188386165369, 0.5091865451569761, 1.088819570985172, 0.28453309573736946, -0.018129306967831042, 1.126762044068629, 0.6797203325498299, 0.736599021030253, 0.9895200929245862, 0.6069749325018186, 1.1072944673675216},
    {0.7219625781831586, 0.777363065039837, 0.9683082086684912, 1.1176922778046616, 0.8097337781943521, 0.6052073597987, 0.9187765161801827, 0.7148742717332631, 0.04408273125594705, 0.594117431878049, 1.0955208968744559, 1.0419537954851503, 1.0007591718344062, 0.7474661017722606, -0.507677208794588, -0.2728066468591686, -0.041400494223570235, -0.10438582187230737, 0.7292108304181695, 0.5833284262721521, 0.7820881006861149, 0.6689936532420985, 0.9345317006529069, 1.1113639042192636, 0.6076277611451277, 0.6403515246082562, 0.8147801520995397, 0.8412622251531382, 0.8463951147256126, 0.44127969141641327, 0.7549414173500778, 0.7739918741253925}
};

static const float b2[32] = {0.7779944066841185, 0.7889812479532983, 0.7804862847132834, 0.8601019270371466, 0.8323859993534297, 0.6622546468309856, 0.7597426161543948, 0.7708299395340036, -0.09271221383130664, 0.6444447966333531, 0.8144504773648787, 0.8209189000346319, 0.8606427889929565, 0.6337146264652282, -0.05810912449448073, -0.0010023391569792396, -0.06577703826184014, -0.061280268777012745, 0.7814452996805403, 0.5452235945959225, 0.8504194920129499, 0.7714049271274721, 0.7300656243784291, 0.8334382702729295, 0.5325463983434073, 0.7414663314063348, 0.8509154175743991, 0.7397955895847089, 0.8187779066990951, 0.8517105793479001, 0.6963209802695037, 0.7954623718033823};

static const float w3[32][16] = {
    {0.9392658350568768, -0.15486731013387456, 0.8826006473924234, 0.05512712063052191, 1.182800734176081, 0.1745386382279036, -0.24707202088559815, -0.24050345361272102, 1.1398021588865987, 1.161746914851492, 0.18409435064886495, -0.1674929141441902, 1.5021209583759063, 0.0053912045583573735, 1.2209376487939607, 0.9371518584993453},
    {0.8431755705483919, -0.2156071838081722, 0.4789557739076887, 0.15514917544900428, 1.2357236190398837, 0.28044376443722496, 0.33374075019931937, 0.10445365982005109, 1.1360278608057155, 0.9743362055139564, -0.08703669282748329, 0.05241768137952207, 0.7599491423160116, -0.08519912406618822, 1.1991332372995487, 0.9896978273063837},
    {1.2486609232147736, 0.06948852285142941, 1.0151008047670376, 0.2805381792120146, 0.44878940300835324, -0.17227340588534032, 0.2316657901139772, 0.11505223143952689, 0.8845982431272548, 0.6606586454020963, 0.14376532873406253, -0.24411472944832482, 0.8706350193558307, 0.1740397374655129, 0.7885591304959776, 1.053274721218617},
    {1.0550696616364592, -0.49138371932369856, 0.9915224396943505, -0.500298264980761, 1.1303932283830491, -0.2571830651085112, -0.33463599997374993, -0.03637057418016208, 1.1140420197277994, 0.9337831641804538, -0.3446084162746521, 0.25492810946125893, 0.6809004449990455, 0.2727210634707778, 0.8788219503558095, 1.518435958265067},
    {0.7499286485465885, -0.12504053134550372, 1.0696301613355415, 0.19882253148509524, 0.9048145145811705, 0.012579292684364288, -0.14080033579795076, -0.6874556692799838, 0.4085836465947839, 1.088561460000472, -0.09124632001973769, -0.16776281749390265, 0.7612334638816652, 0.10864143211672873, 1.2615906415683817, 0.959342334983158},
    {1.012638441183499, -0.4887951698858983, 0.8636066997195662, -0.10107860387619924, 0.3593414731104915, 0.0390490474532886, 0.2587090824873004, -0.06923987342848548, 0.7006063481045979, 1.3656656348754386, 0.017713290643456427, -0.010388358901863185, 1.2297297293231266, -0.046131415490440385, 0.2785145983703081, 0.8714198159831885},
    {0.8444262000774463, -0.1904828000649404, 0.9462748772104702, 0.011348952493575728, 1.2295242955552714, -0.37092952469433316, 0.31514392098588284, -0.30188543425572745, 0.2220565729114265, 0.9609097254229398, 0.10637968077758096, 0.39180175522826627, 1.2067877424536677, -0.0955083323516871, 1.0337471260781375, 1.1489527353931204},
    {0.799165260081972, -0.35695487588849245, 0.8724815448392975, -0.010220204017091734, 1.0814997027902846, 0.2746046588440583, -0.015072023990909145, 0.11040157378636596, 0.6508590452412717, 1.0321607748341712, 0.2922187535619187, -0.28360154840674917, 1.0915422105425028, 0.10856411306536418, 0.9646448334465004, 1.1347180856259285},
    {0.1976129452413637, 0.07923910852991262, -0.2920957050047911, 0.18682500876163688, -0.005778992237629224, -0.18313523764572417, -0.3392909773601049, 0.29711470590861877, -0.06952620314582718, -0.28095261526614096, -0.24220836506729723, 0.10455229922165743, -0.16704860016389028, 0.1801643970158394, -0.10849065720563532, -0.20245040558594235},
    {0.8794595188559798, 0.3980779265280946, 0.2702207553692703, 0.15742175634446468, 1.1870200920034981, -0.08624952118666679, -0.4560045416964229, 0.22316204678061566, 0.8500880462897373, 1.1359276809810737, -0.7921803713329639, -0.5251883903348018, 0.8337518586867246, 0.07806977106799157, 0.45699636241851616, 0.49615248335619266},
    {1.0328682269014478, 0.006157440606932977, 0.7061551542282491, 0.1785552798281292, 0.9364599539727921, 0.2693052212102151, 0.12859326484097255, -0.4731774497077826, 0.6182290904625846, 1.2218009795420213, -0.36978241842905496, 0.1882973712814533, 0.9933021869676824, -0.03917078364856958, 1.3378041082575203, 0.6812513903521565},
    {1.375412481435688, 0.33207881523187494, 0.7549908368151934, -0.7264275386911215, 0.8409665463019919, -0.14187689496131461, -0.1080786279995656, -0.2635313850293832, 0.8326021125055076, 1.107322718153551, 0.0565092769143234, -0.16652753476709148, 0.8439276322244532, 0.36893200803409887, 1.04477749786753, 0.9691917798033598},
    {0.9149435465374517, 0.14217652582299192, 0.9484505661557172, 0.12629163747441927, 0.7228082846649565, -0.11892184321434378, 0.17502637111681635, 0.30746955421170724, 0.8112217726473817, 1.0557479914338452, -0.08286748460198104, -0.6217752198008373, 0.7503062557201423, -0.314947195195343, 1.0305802002539226, 0.8098094259518215},
    {0.6411935750969934, 0.21454369152716687, 0.6047356176739858, -0.07090410616425594, 0.8405432933563155, 0.05135403831769967, -0.3641043761923017, 0.08013393498652047, 0.9588456077390103, 0.7889779654066087, 0.09976340966391437, 0.3290598192944162, 0.6356970752212827, 0.023704757285571015, 0.39604391955202867, 0.953238589329228},
    {-0.181226521914687, 0.03303345169578107, 0.3170907042630916, 0.30250682515766686, -0.5309549257367009, -0.0546070222337509, 0.034091159700295394, 0.2910828668170885, -0.12053960176739409, -0.16255411686641377, 0.41525878433959057, -0.22096045740883474, -0.2706673249559436, -0.15826516348936015, -0.32649584934319, 0.14898718346923231},
    {0.15273205883413993, -0.04686228601826629, 0.16131657206312994, 0.019631020460258008, -0.10437073319085229, -0.31467908299886044, 0.06504177913434468, -0.20484255085009462, -0.5626166254565319, -0.18971522910185556, -0.011164555951623903, -0.12980530929365042, 0.10167820703328585, -0.23883211162293133, 0.13027764201277534, -0.05204651986195064},
    {-0.5173055944361622, -0.21412885454732308, 0.05405206765689959, -0.20636913439423177, -0.4786513274278588, -0.3276499305311704, 0.16832029347119024, -0.1751349150173815, -0.16836011587105507, -0.29731977920274716, -0.38492900087533755, 0.288140868611786, 0.21119881309137362, -0.18533406177344225, -0.16541633262584549, 0.006365848727197975},
    {-0.14201376405189065, 0.029255485477093376, -0.12906962455910662, 0.01251311346363284, 0.036328029919475945, -0.11777157108688194, 0.31259830628451835, -0.07825921048771409, 0.06154751074703232, -0.08736871236043874, -0.15258297601878654, -0.4525583802070974, 0.02224811573290596, 0.42053961182385957, -0.056957382160653554, 0.1865206960694446},
    {0.597126094903724, 0.5160841572536458, 0.9620557415271997, 0.09633585387805228, 0.7407690720302046, -0.036718573864096014, -0.3203408720673635, -0.15565939114655683, 0.518185034513014, 0.596804346505242, 0.14881610566653836, 0.02942898024089394, 1.200543799855023, 0.09839057656254963, 1.422584124871087, 0.8162034862631793},
    {0.3941181997051547, -0.15932051939785027, 0.6957667425702758, 0.14355647537058785, 0.39592488544746307, 0.15830815669985007, 0.4081393720402713, -0.4092237396478399, 0.909749203592611, 0.5618029390078838, 0.040589792392817875, -0.000964641029019246, 0.42131365253166453, -0.007112964349985828, 0.9356602657745714, 0.760175829112029},
    {0.4810138719322565, -0.1725204183245376, 0.9981530992449097, 0.3918508062051186, 0.9414080902307114, -0.2306777194696167, -0.28487241159304466, 0.18339174007488918, 0.6232298000453289, 0.9774458985162113, -0.4116868195586222, -0.15236609619068725, 1.2416763616765847, -0.08879122094305347, 1.1429126627171444, 1.008369528800818},
    {1.2337591486632622, -0.05410144781587979, 0.5309375627202265, 0.3932750702911974, 0.8591098463356044, -0.06462509629152877, 0.15834013545812511, 0.033684956176628984, 1.0719255701307633, 0.9081954028363969, -0.05057197753940169, -0.11114352661296971, 1.0053645731473555, -0.09680283898665303, 0.8265695472295768, 1.048715132163634},
    {1.3724881592565372, -0.30887235873255126, 0.8242258269256193, 0.05214768391986174, 0.8689526820899767, 0.5107911079095737, 0.1333880561549364, 0.29382352387380234, 1.170709031306152, 1.2204767897257036, 0.2019141718004831, -0.25753069372735726, 1.0499783650822268, -0.016283731660548396, 0.6244615559424987, 0.7421353931448273},
    {1.108257357373067, -0.2047322425886917, 0.6042589726868116, 0.46665324152995175, 0.7870061494700576, -0.08438488799686565, -0.17230813288573074, -0.16808377844901662, 0.8668531768407863, 0.7579272428960041, -0.1662290374660339, -0.17430087438937214, 0.7266493391500558, -0.4196774282140815, 0.8668018832792506, 0.9399491288160615},
    {0.2095136875264192, 0.3894407298199309, 0.4305140514764926, -0.004995745628605272, 0.3140429529506348, -0.11734994858151036, 0.10293204075422627, -0.1067916708919192, 0.5446758190164884, 1.0476759049023334, -0.07774690018515863, 0.47014688839939583, 0.7983460254253172, 0.3080659486010529, 0.4779508897966729, 0.725041611593089},
    {0.9093709734932629, 0.22573986303627425, 1.0217843180218482, -0.20023254829803522, 0.8087560035268159, 0.1815418698373885, -0.1010088855538125, 0.12237006129666692, 1.1217429935986556, 0.33536673555232255, 0.5927469241205127, -0.3234391924092471, 0.7714581339558924, 0.1288625102310665, 0.8908092798649753, 0.5550946061526869},
    {0.6575949435352743, -0.029744496062931104, 0.8370752287755739, -0.5220947535548, 0.9946899304043593, -0.16581547688113588, -0.5524547428075908, 0.23403375820748948, 0.7459544146456754, 1.0739214740760616, -0.484197086187467, -0.03610039125175777, 1.012024989974058, -0.27241894097480973, 1.2091716316405878, 0.8396204919266231},
    {1.005979502716336, 0.036059613899173865, 0.7790694777051662, 0.19784311798024282, 0.7812647447049279, 0.1992175772144434, 0.06592937157742276, 0.4650143224834323, 0.9019033613599051, 0.4508805802733864, -0.4003892658051946, -0.2238952647964045, 0.6225179295833948, 0.06868674551202585, 0.9078252011388627, 1.162844113807945},
    {1.123481753012376, -0.21369356826549157, 1.0602829978024126, -0.5453049084986336, 1.2893519858530982, -0.13906269737040286, -0.1436940638030893, -0.30448878059903123, 0.9643710122367734, 0.6872730025598583, 0.06462740696358278, 0.005054822617246311, 1.0040006618955273, -0.5137089660763444, 0.9641395672636628, 1.1736594048695599},
    {1.4569907537426539, 0.20661825251900295, 1.361037582186301, -0.1258544411501003, 0.5147784198171944, -0.6437429452900055, -0.06714046091663546, -0.21159686335508043, 0.5439927905572344, 1.1799989608364212, 0.11350911484419775, 0.39453189886510276, 0.3607956724263249, 0.07169356968331832, 0.8291251275421828, 1.079670132484702},
    {0.4729008246906592, 0.16914030434973562, 0.6763083822218214, 0.14962282881662775, 0.8999104088253136, 0.10789494385403439, -0.1800221564606031, 0.5506337847349397, 0.9616446202010307, 0.4242440623848927, 0.03606886411603647, -0.3743458545589965, 0.9963340595389941, 0.10636553610601295, 1.0658410934457707, 0.845597943231028},
    {0.7556936476398107, -0.4433162804403896, 0.8619768277109496, -0.20106753950409684, 0.6103817686313199, -0.261223074466834, -0.3185240383101668, 0.3247773149452378, 0.730419628115101, 1.2402174354384252, -0.0672374103598555, 0.392511488071117, 0.7510012014191245, -0.43785993937598944, 0.9283553221511905, 1.114830437352822}
};

static const float b3[16] = {0.5738830341862734, -0.052822832149827754, 0.6670604694242768, -0.013268131834266601, 0.6879416861056942, -0.05725054246500267, -0.030870685215051475, -0.011531708436736303, 0.5178175428865737, 0.6617653763582224, -0.016198063797993375, -0.06272554596021761, 0.6775552178023887, -0.03127288674629583, 0.550579408909669, 0.6325987781074072};

static const float w4[16][12] = {
    {-1.1834185662525556, -0.6194624809285567, -0.5516325794685971, -0.37534714628407073, -1.167886403835603, -0.7463098222580817, -0.7940740111445806, -1.0322451509335882, -0.8638183652088164, -0.7226323009389325, -0.5571429894356053, -0.36138166808178257},
    {-0.215579945865895, -0.47027812319041395, 0.2206207029464504, -0.34496402077844457, 0.3476833360526264, 0.2312570403574203, -0.2904377057140337, -0.22628011222284952, 0.2834329766216251, 0.039395102548074885, 0.69749191318434, 0.2736512845010826},
    {-0.8888948194362134, -0.8371072151573467, -0.30273734401626534, -1.8151038828972825, -0.558488077928401, -0.8096619866789132, -0.7717051939681057, 0.015297138941916737, -0.9852370736142329, -0.12157220043553219, -1.047309002524584, -1.318869792905228},
    {0.23697408941050038, 0.02595432182175016, 0.07611413788333236, 0.11477862092546567, -0.27617555306430763, 0.4792046989163239, -0.6025811646968202, -0.26871322512292556, -0.3936679080665628, 0.16915042924113793, 0.37689650837563754, -0.0038519649136468663},
    {-0.8162207080403452, -0.9138526693750435, -0.832289095588831, -1.0772615509514327, -1.0797336777349211, -1.1554265582993188, -0.8735511963331397, -0.5754129670517444, -0.37268620976715755, -0.7626721713938356, -0.4589975123964011, -0.5043921860973771},
    {0.08359633491523429, 0.16479745317740022, -0.3290482412910331, -0.24214445905721707, -0.033022802745362644, 0.5849044426887373, -0.20153142844742886, 0.57634832772292, 0.3968764895136087, -0.14835122364124514, 0.6167114243250096, -0.10451223730425432},
    {0.5280569862286663, -0.33705699790423965, 1.1090826364714734, -0.13484765461874043, 0.28551860771524906, 0.17586521449428374, 0.07180115100727472, -0.10618293788279436, -0.43041165284491667, -0.4293266607643398, 0.1737032403730654, -0.3691815971069487},
    {-0.25665372130369446, 0.552287009048263, -0.09695287798891025, 0.16425361533101732, -0.22002635892247738, 0.8490208038198712, -0.2111377575641035, -0.030584612482495513, -0.27071784173465174, 0.6545319951034094, 0.35110759438317224, -0.278148782340808},
    {-0.7730449899960659, -0.28336083541573415, -0.8461247270261798, -0.608774111370008, 0.23744967629602495, -0.6055106238761901, -1.2368212879943972, -0.8609431655366936, -0.47985089798345804, -1.532501376237612, -1.3919199044988626, -0.7336642872882395},
    {-0.5578537323167685, -0.8219328324815682, -1.066490130135449, -0.6643203011781029, -0.588408448712406, -1.2220480069990052, -0.42848030304129064, -0.5420608668088991, -0.4216132507581876, -1.1177996606253426, -1.2190890707630542, -0.6596005725531983},
    {0.2340262052911663, -0.36637562468221657, 0.18711175855549156, -0.32336216116244587, 0.22193321316710493, 0.7051279466690649, -0.27240688720142897, -0.34419212907763524, 0.14089901027948903, -0.11808249963378152, -0.263422412441149, 0.28113226257176566},
    {0.2020516539681213, -0.17757018353398965, -0.17420561132151124, 0.0932701914368251, 0.30239021255054577, 0.2667984886136063, 0.04001081022549144, -0.18414129313852529, -0.34193423487579555, 0.18615506314518793, -0.005244211528152676, 0.6226377919796751},
    {-0.8460366040011704, -0.8454144524901412, -1.2633837817100468, -0.5329337687003346, -0.8521406967426336, -0.39704753749163135, -0.6350094690941854, -0.990343336205802, -0.8125164112457021, -1.103025702225294, -0.682989406286745, -0.5587488951398827},
    {0.3681395059453542, 0.34038955902306917, -0.3051015814147319, 0.0010558718043638304, -0.29886453709683736, -0.2890029630784359, -0.08499848509589523, 0.5943412628257947, -0.05846767410456241, -0.2845736653536099, 0.4409261491854848, 0.5754347403896745},
    {-0.819483957344647, -1.1730072626882349, -0.420079030253851, -0.7549821773836427, -1.0502465740821942, -0.8511054497167957, -0.6796861845586116, -1.0359196745877035, -0.7476411901863069, -0.06894371892144582, -0.5400149787474375, -1.482471609083134},
    {-0.3859336739090798, -0.6584835002264205, -0.8984242545254617, -0.6225414978396266, -1.147795319800684, -0.3122155780477932, -0.9287776914044447, -1.1159227687887843, -1.452247216928075, -1.0237984792560932, -0.4358090853812877, -0.5922144870154784}
};

static const float b4[12] = {-0.29477163951710705, -0.28702449282375175, -0.12923395596800816, -0.21162830946563607, -0.3195177826940577, -0.20176469545322503, -0.28703540632924124, -0.3632347665817378, -0.24615513452726648, -0.18052450951179327, -0.24139980311340115, -0.2501356922009617};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
