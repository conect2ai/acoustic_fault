#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.18880810608611112, -0.31216278634230504, -0.369095182240563, -0.4376840345811785, -0.3255128522863208, -0.09404922447548777, 0.6173560275785183, -0.17651915087116954, -0.3003440329371675, 0.8185569658551184, 0.497693214839514, 0.4131570896503301, 0.5556352702452358, -0.1837093981600305, -0.54127928295177, -0.20802470407286838, -0.3643910448335859, -0.460428290059116, -0.3466485380575071, 0.29672820383809656, 0.36355573827573756, 0.8695831447950977, 0.0479784152320324, -0.3235699775974353, -0.11568401283826579, 0.8805252547982316, -0.3794838541773898, -0.06271636956076243, -0.19309380874535972, -0.43723924329388936, -0.5064995366634334, -0.21273504843696156, -0.13114655112659018, 0.4700996657589963, -0.32130623872135605, 0.157740568106233, 0.18379139496535823, 0.05391093118750225, -0.6421781431075119, 0.13092187200131544, -0.43483184385891205, 0.45795799521653485, -0.3461420687995666, -0.2245141511670406, -0.28603280985396334, -0.41425599376294137, -0.4789759387522418, 0.09621666321197757, -0.27428036765854585, 0.1200101303511834, -0.1666508199826278, 0.3474248102359748, -0.2380175194184986, 0.016144237325845925, -0.4843250428831138, -0.36182498867593427, -0.32753553972058436, -0.3740250012419054, 0.5919236128723161, -0.39992516128162603, -0.1894004084657657, 0.6131757555980984, -0.3353701860563304, -0.30592838918166493},
    {0.06545931678211535, -0.24742134051109935, -0.327271095184948, -0.5538580675951004, -0.7714957221068122, -0.3593173708731367, -0.05207511517794812, -0.21532514700901884, -0.06875644012370749, 0.44774829789310583, 0.7782580421598922, 0.5052848102246417, 0.4401380116234243, -0.5400777780098794, -0.5498336279708188, -0.9809468476996694, -0.6015345251123154, -0.2686009567403458, -0.3807265809427453, -0.0995004812071174, 0.4515948842427443, 0.6085118415936968, -0.35530170926762433, -0.6445932637150167, -0.36319311171003016, 0.5291175271244212, -0.48837867221129805, -0.7321993656643069, -0.5339211517567812, -0.801442623717478, -0.5854175703765419, -0.3079344966177171, -0.2963715388973552, 0.6851906608369395, -0.14994802414687913, 0.1187420080666463, 0.3614981453114283, -0.19402772117316847, -0.5944620059346495, 0.5940410264605542, -0.45428031093258386, 0.6987663176442509, -0.7750067888115163, -0.5606900907101857, -0.32668446310271665, -0.5747209803005406, -0.6642287730356828, -0.5581065578351125, -0.17280332734749926, 0.11257514545710247, -0.0422118645922408, 0.08257708910904883, -0.05571184039989871, -0.20843687542864386, -0.4578875412446019, -0.5073169841305595, -0.681348255751089, -0.6835928415622486, 0.7395510019739837, -0.28127029356468497, -0.22680867418239048, -0.1474187264318676, -0.2789127124556372, -0.46963448481750103},
    {-0.27321028089111254, -0.5261542834990006, -0.5966219982948643, -0.9471916757347927, -0.5588028753864551, -0.7555599380271474, -0.14056196568723203, -0.22290129833082847, -0.37225496024382776, 0.8866728927508947, 0.68685676825084, 0.5936070156473701, 0.24529699576913772, -0.42517781732900317, -0.7553071035412988, -0.6224356139938549, -0.4770876559550487, -0.5382154586013997, -0.7733295386603036, -0.07053879183835902, 0.16789915272665387, 0.5247576171815512, -0.22208600574513446, -0.9987581021605895, -0.5050289675504922, 0.46712165362061775, -0.7652855425292666, -0.792117909409417, -0.8942364233305604, -0.8953481112691619, -0.5023368092302076, -0.34270621451672983, -0.45712110099669445, 0.584300761374868, -0.427703659677051, -0.15765808019032393, -0.06338672513244119, -0.3750835706032341, -0.6513988622772973, 0.35029849275586417, -0.3407734982104149, 0.8587911333094512, -0.8814078972880425, -0.6809867536472394, -0.5050323106315798, -0.8378491021880942, -0.9630157078577402, -0.6537810298854893, -0.4470691617040714, -0.14605618807867654, -0.48213758973765425, 0.315269326811737, -0.40478732447493987, -0.34029154588350075, -0.5704386289970182, -0.5131126972757947, -0.5944741406116087, -0.6127263719519666, 0.7939708109714714, -0.5942565074993336, -0.5134156139739255, -0.1556618436541268, -0.6473405368298529, -0.5868255821747013},
    {-0.16891569351816751, -0.7111791533145523, -0.811068995263407, -0.7614818487174312, -0.8770222621277568, -0.5186175797826308, -0.6927966049174087, -0.3724882219839898, -0.49399690835302795, 0.8804141974382942, 0.4750219070757004, 0.5655495689979381, 0.30374760017322266, -0.6959288897511146, -0.8355242479689807, -0.7063829517462941, -0.6833345358710152, -0.37194487483285077, -0.5047047889047006, -0.16779235955471877, 0.004358587011209886, 0.5232755345716932, -0.4608183751983414, -0.9589207691656554, -0.7123115554452186, 0.5041965432938728, -0.7094507140416618, -0.7199464907259336, -0.5952775070299384, -0.8149686655943433, -0.7050804704937413, -0.4959290703580845, -0.5132706544023584, 0.7367819084059724, 0.01653939269276755, -0.09722420418330625, -0.14455550443180612, -0.5871847136865675, -0.7002461540557164, 0.23712626336955034, -0.5644404093880374, 0.591866834136068, -0.7983113488560397, -0.6585386555050183, -0.759192225668027, -0.8907578302567825, -0.5625868587874999, -0.4628474353309898, -0.5495238446938078, -0.590777952090778, -0.7412579557508404, 0.2848430093456537, -0.5271318745050011, -0.5442255859373374, -0.6389336120280583, -0.505854104400716, -0.5944741678481832, -0.36345641384567157, 0.4362587179031531, -0.5047745998337911, -0.3863433168849953, -0.08418029401391945, -0.5623306763966123, -0.5901918606502041},
    {-0.435354133525956, -0.8418863735305887, -0.8586486267319097, -0.7997334112108743, -0.3200151523527254, -0.7280714053454326, -0.758293968008784, -0.8126955009688938, -0.716350610119576, 0.7646870921399955, 0.2712626383914942, 0.5243345796821406, -0.16394784991128727, -0.9255364927665688, -0.9456529449230553, -0.6313272990361463, -0.597841728224853, -0.6791535311475495, -0.6748805011728515, -0.7308401450504112, -0.42721939473840376, -0.024088793375101204, -0.8230958589143224, -0.8330163678337007, -0.6791953203340954, 0.6108107719655218, -0.6523145929310258, -0.7281745332379443, -0.6371411384280228, -1.0151126686588539, -0.6469646853862101, -0.5948707208717532, -0.614619695008664, 0.3234970938956121, -0.41705940939282626, -0.5327124292155727, -0.45982987248005625, -0.6466741090440504, -0.8569200587592484, -0.07507441143316797, -0.7136386600751146, 0.5714597773544396, -0.5746791117360288, -0.6986411272756158, -0.8292815394750257, -0.8622607181626125, -1.0896090337760054, -0.6867114320756197, -0.7642578323897451, -0.7074244450572559, -1.0319386660258492, 0.31759232124795067, -0.5854246886138006, -0.6246638119760879, -0.6181031597899385, -0.8439536673801573, -0.882634124287984, -0.742232347024221, 0.10175951025133506, -0.8199410847954133, -0.5083003085129246, 0.10135616818057538, -0.5586166222812164, -0.557439768156092},
    {-0.419021378988335, -0.6685051118043905, -0.8705449954749426, -0.7303298309340187, -0.5270924580647408, -0.734282944611966, -0.5832159580917233, -0.9925790355477355, -0.3060016624574047, 0.5460148247191252, 0.040525190027623545, 0.2105594470347987, -0.41061896095634537, -0.968232790796507, -0.8254480587325357, -0.8628691710117213, -0.5395465021436344, -0.8586948997792989, -1.0393006391233688, -0.6759676502023708, -0.4077498277519161, -0.29626238406682703, -0.7312454097997205, -0.9221858472795779, -0.9831462810621577, 0.08902075267477391, -0.7392401847692142, -0.7620739375257586, -1.0449723032490918, -0.567524991790859, -0.9830425347001623, -0.7077386365101964, -0.4991694947465884, 0.17178758602089353, -0.614272116021303, -0.676298970557468, -0.6202828439900087, -0.8017921144868738, -0.9043619214719637, -0.28380944241880113, -0.7596322314878688, 0.7347478658088604, -0.7893797953066378, -0.8708062228030136, -1.1124430863069903, -0.8882478625701506, -0.8142710415235704, -0.9331044259620099, -0.8416635499133395, -0.9853595967566591, -0.603701574778402, 0.16432855023530152, -0.6948079022731226, -1.070826193572308, -0.7664970213328112, -0.9529428787315852, -0.8683521678254608, -0.6695825676875541, -0.12150898933743351, -0.8076250392962683, -0.5530549942053139, 0.15917230990126574, -0.7381345266310295, -0.6622425556450937},
    {-0.5021968726898921, -0.8954275670741856, -0.6132315942643499, -0.9910438561897346, -0.38517253310380845, -0.7704863002724565, -0.620483431937216, -1.065791560755186, -0.7322448530043622, 0.7317987539517091, 0.39704520192439874, 0.4598917498710693, -0.41755905964363227, -0.9307292484871461, -0.9128551400334883, -0.8737117076516021, -0.4496952437828104, -0.9490898963330171, -0.8716150839724481, -0.7327661005613387, -0.3592152031527408, 0.06239722349408891, -0.6198288597631234, -0.9546814422192631, -0.9146295967518333, -0.22835202813728375, -0.8777603635470829, -1.1369170785625864, -0.9587345479859796, -0.8997118758426047, -0.6978328761976773, -0.9517986622543751, -0.4280358774314396, 0.0225574237381709, -0.5391294874764305, -0.46033357124364815, -0.433791621062993, -0.8040742326304555, -0.9404400261888333, -0.26542963101453054, -0.775490464552454, 0.6870807760906015, -0.8009522237197211, -0.9246072235335957, -0.8525108078152417, -0.6418763216136327, -0.5707568157223476, -0.6506928390707262, -0.5988406050993116, -0.7601366941518671, -0.9170002350777893, 0.27723629477330003, -0.7333182191220359, -0.8478970105134594, -0.45621336108576777, -0.6064444220058192, -0.8468407586334329, -0.7763845800852599, -0.2963877469028885, -0.7094655159783838, -0.5818908828504866, -0.02603104388019461, -0.737232788546565, -0.6805105193490386},
    {-0.23291266726334486, -1.2775114770988825, -0.8642579133806693, -0.8642322864814154, -0.5337805750756934, -0.7256655282582408, -0.5842573140040239, -0.8025758867957888, -0.7681905866421068, 0.647328572812041, 0.5685701867510456, 0.7663208336521415, -0.09002154852795871, -0.9257524988154702, -1.1873214334452051, -0.7046923608128183, -0.7383173996431542, -0.4787998591743007, -0.8805730330335155, -0.6592360397426957, -0.27480563718127, 0.11378135158678158, -0.5752144094632086, -0.9334737714780685, -0.7352937035530632, -0.038822555407919, -0.7892331185158089, -0.6451896622214661, -0.7450927651905654, -0.7677099067375159, -0.9381198822474855, -0.9221668753176269, -0.751953530420995, -0.08697484866928762, -0.4439771187060497, -0.5078447952983215, -0.632579440918089, -0.8615627510644273, -0.7856222862781832, -0.26894773955101153, -0.6454442801529485, 0.710434747070634, -0.5569139535299594, -0.8968285418426248, -0.8032735866412213, -0.7768570929421814, -0.7950761535996602, -0.5827216151167958, -0.6445446632675793, -1.0411259455067425, -0.8562242504382855, 0.09033950433191706, -0.6073842004016533, -0.9215701208730284, -0.758723413318301, -0.8612468659424852, -0.7681299257659483, -0.7401430813758633, 0.03744857016370732, -0.8466968813032497, -0.7672865716568636, 0.23206771008509755, -0.5147706560065175, -0.6390142930907347},
    {-0.3782618227800506, -0.6941200479838142, -0.8529894193706149, -0.8556242596700631, -0.8256229422965199, -0.46888647148033785, -0.44899422101304387, -0.6882461338304351, -0.41851836901854267, 0.5783667054957754, 0.6327857384655603, 0.9455050569574512, 0.291864408914817, -0.9822346508245925, -0.7408545386634946, -0.6986290006197059, -0.9313507787767505, -0.7630150494175442, -1.1627372999005239, -0.910200229516957, 0.015089901872059223, 0.34802557317668725, -0.5611077742032418, -0.8731620860922963, -0.7695119645689062, 0.2985951656764379, -0.881184073527319, -0.5436162583564569, -0.8900459690007679, -0.9149263894495936, -0.9431797203913788, -0.8509194349772963, -0.5832725251371134, 0.30249556376546494, -0.42082520834338494, -0.5706883146519933, -0.40628148390347546, -0.7114548027794754, -0.7986379093257099, -0.30556140937087417, -0.6579195908074007, 0.6135765377078775, -0.602727638998776, -1.0769074916722594, -0.7443936319026457, -0.8666879093457991, -0.8642186728170478, -0.7692431177294348, -0.6351065153640263, -0.4298961939690613, -0.6611032932581618, 0.38634491740214677, -0.6385211601066659, -0.7598639064846857, -0.5155770668491837, -1.0103748770164132, -0.5560822744527792, -0.5994344220632253, 0.5095499892071963, -0.65706533201448, -0.7274021199053716, 0.18858384228679217, -0.90165586127985, -0.812850718239653},
    {-0.25357572380890064, -0.7332756246795108, -0.8484714432843572, -0.9307297516580961, -0.6125360339964996, -0.6369305429118511, -0.24403211631460106, -0.5375474582273184, -0.4763184210399267, 0.564820727658582, 0.7866509746933363, 0.5530451684132717, 0.15127170345928787, -0.6726971327164455, -1.0559429703609167, -0.6039660832671839, -0.9677720841809445, -0.6313704196161692, -0.7032994380933643, -0.519480232110811, -0.2770556999073347, 0.5754078460961959, -0.4339266510326053, -0.48284273051787185, -0.6611007148599191, 0.3358600276253733, -0.6146997241407005, -0.6799885092378042, -0.8378372257678522, -0.7501176981848386, -0.9749393509779739, -0.664500746896674, -0.6053846437758386, 0.2213127985496762, -0.13817471288882557, -0.520759874970811, -0.29040153247973777, -0.9083960031947762, -0.7639199393606183, -0.10608074623848764, -0.8499684342140497, 0.8713843142429378, -0.7990814896240944, -0.7824174465996429, -0.7176636987591356, -0.7908164326593731, -0.909737580181587, -0.791839380118966, -0.6825243125271132, -0.5044205716341028, -0.6399003686563263, 0.24049018408296324, -0.41538498838977816, -0.5701508127037803, -0.6571157904186429, -0.6487715732585022, -0.6651770376498696, -0.7813146647648308, 0.3743162191389055, -0.8627584165381346, -0.5270606337580195, 0.4275510406151457, -0.6323521327100753, -0.781812817317696},
    {-0.510728419904207, -0.6787528213274091, -0.5877134220123158, -0.45035752438961213, -0.6687639474856529, -0.5913498988750484, -0.403266594317491, -0.39769812556782486, -0.6704616073949214, 0.6948311735594325, 0.431773811967351, 0.4760065316708873, 0.03800906367797916, -0.7124926243755264, -0.9338503188403682, -0.7834799496219508, -0.6464272977665115, -0.7675673603628378, -0.8521547986665876, -0.32018836503697323, -0.4644991118754787, 0.577867571567531, -0.7990184199042576, -0.6888944509734196, -0.5819226816661368, 0.08459217611679169, -0.857086549831852, -0.8294304566809132, -0.6354647210341287, -0.7448365697781207, -0.8765365634721726, -0.5898982520073627, -0.46874353083167297, 0.105365502429719, -0.24162469158984612, -0.42977053201814536, -0.18930852296803927, -0.5530214505346944, -0.45039492022631517, 0.04669475328705906, -0.5728839326395894, 0.2889003456223262, -0.56290175726169, -0.7343485134376632, -0.7033669605841647, -0.627319921792241, -1.0291591324179252, -0.5493682561569374, -0.7911369813058329, -0.5373487345145253, -0.7273751254481707, 0.27194932642285174, -0.10197304223057914, -0.5597219822528611, -0.7303417523721831, -0.4014855954433711, -0.9456433730910715, -0.4752390551254759, 0.5545525886661595, -0.877927644902501, -0.5406285386584596, -0.0029723787634601912, -0.660717965934867, -0.5788405797718439},
    {-0.26810613991754056, -0.551792863840472, -0.5288838656866134, -0.5641993065425722, -0.932812649761299, -0.6794218962306694, -0.4311217527859658, -0.7125365292804781, -0.4611017168234248, 0.8197414171916779, 0.6157421063419205, 0.615839284577808, 0.3678050475901824, -0.7485851303755937, -1.0653596541810886, -0.5180678727213566, -0.5517885750908497, -0.8145574162983642, -0.6080082637219123, -0.3458158297035206, -0.2383640488763841, 0.4783540902410078, -0.5864632612001472, -0.6666035551780901, -0.48077156104590485, 0.5909760606581902, -0.880838297095934, -0.7089795194966643, -0.9127874770323113, -0.755925500284618, -0.5567091896088976, -0.377672267787056, -0.47114584626569095, 0.3366144786766366, -0.20737011404022238, -0.36838198856212323, -0.23761797083868094, -0.6267068371917408, -0.5759967343640651, 0.21228795456177835, -0.5771643487138756, 0.8712077346799529, -0.9472063180105752, -1.0867209627526973, -0.6772395775966885, -0.8684195884302849, -0.8653818576316297, -0.7608024220168834, -0.8354559230715021, -0.5722273771390783, -0.6810561470005695, 0.42606413438591983, -0.176697057319669, -0.6488316674747568, -0.5583815700021749, -0.5470341654537099, -1.0160897609566464, -0.6568814665436999, 0.45531964008028836, -0.5850407747772322, -0.59409655953189, 0.26094756552602955, -0.6653289447899675, -0.6871163150166861},
    {-0.15103934377813288, -0.780934318730916, -0.4954880388871382, -0.491338520189108, -0.7954868642561633, -0.5004343674331052, -0.3294417710938439, -0.7659894748661938, -0.42669370242540194, 0.5157330953817789, 0.8311909289315296, 0.6580660334349526, 0.4340680728030657, -0.8285427881709604, -0.6394314895945168, -0.8385960041467705, -0.38681042204233523, -0.8258104752462497, -0.8853957409381231, -0.6242903728701495, -0.12607601147471081, 0.3379355785463819, -0.5391867719675362, -0.7664856158273615, -0.600012963393838, 0.33320089137978454, -0.5782465785750293, -0.5859426123595065, -1.2217176950371837, -0.7108779517627466, -0.6102278577194814, -0.4078761430216206, -0.3175913330821326, 0.7585320314860047, -0.25201783888489493, -0.42935526251520895, -0.49066576518773103, -0.7566356057946063, -0.6282438730258898, 0.004551121337803241, -0.7321333020283904, 0.5625708160058882, -0.8444817862749812, -0.5123135390304225, -0.5048912875284655, -0.8426056845607532, -0.81548972300872, -0.5990521501390511, -0.7655278013336531, -0.46940427667703905, -0.5356249326977054, 0.48332287668212076, -0.5381657997413916, -0.581169984603801, -0.5955003889504962, -0.5754338304246632, -0.6703512857303076, -0.3628081462803458, 0.5430469160344019, -0.43759574841500176, -0.33836352562660454, 0.13186327093205588, -0.9944856723941621, -0.545982081496868},
    {-0.3461675603447127, -0.8532334789097502, -0.61913431263165, -0.7951794292194103, -0.352736336606364, -1.0707182289274872, -0.25330345362195444, -0.44294506730142086, -0.2003712887362223, 0.503674404590994, 0.6706599403619805, 0.6142263552779476, 0.14291210439130603, -0.7536662878910549, -1.2050974899013018, -0.8880647035138911, -0.6932090425811216, -0.709465099457312, -0.6594456003544935, -0.41760120435972004, -0.31530953779517695, 0.44931602283365657, -0.379657859448943, -0.5472524478430763, -0.6775011928513787, 0.5467362350174753, -1.1086075150079222, -0.5216923577545838, -0.6401452353156722, -0.8167580676400434, -0.6023713399778404, -0.34859564165173906, -0.3450883633590504, 0.42384302241911653, -0.28184628278318574, -0.06589606814324446, -0.24587854118457864, -0.7077924890977838, -0.6718547341923841, -0.07869717547604733, -0.46934706420352346, 0.759012305563891, -1.0268127151592783, -0.3533993857499053, -0.5051921880160201, -0.7803860711311262, -0.6803845209889496, -0.6520871884345356, -0.8430624167577107, -0.3831906041534617, -0.6347482744436433, 0.40205938657932583, -0.29578322683846114, -0.4598386073267017, -0.5397548505194805, -0.14975964429504457, -0.6239848769983409, -0.6025031347205527, 0.14087027315595416, -0.6749118293133279, -0.37911614986647985, 0.14608184709760264, -0.8657612708336605, -0.701335157760302},
    {-0.20043337348120596, -0.6992796644597667, -0.8306278976771021, -0.873937885349238, -0.6617054241855844, -0.804669034351354, -0.38445041706260413, -0.32527489341685173, -0.4901285203021935, 0.6110219699186032, 0.5945129638396404, 0.7783731146416699, 0.6380581764585169, -0.805084844704945, -0.8814212494064766, -0.6511208651312552, -0.6070940979166447, -0.5973788081653142, -0.4826421171937243, -0.28940029171659615, -0.18183257287197563, 0.5265395182792719, -0.33482346821326464, -0.7226756152163009, -0.6634382167139662, 0.19419408665336957, -0.9965800843782006, -0.6984593212344301, -0.7441586212807454, -0.7158858233114287, -0.8067963514968207, -0.5494999970891663, -0.6133777710769588, 0.6163126984282369, -0.41174192754859973, -0.4281701152600605, -0.011925311601372222, -0.7032159916787781, -0.7516497312673808, -0.04738319167172823, -0.8545063020003953, 0.6792338715233367, -1.0271125487659265, -0.5352067621732901, -0.6745149761485959, -0.8432689476070209, -0.6255003610665046, -0.741294514057012, -0.5683366297504867, -0.4074692287207504, -0.6622155635958544, 0.44690910204472495, -0.2900538188440433, -0.610580126120406, -0.26513249779960135, -0.7422583800043164, -0.8146107276756432, -0.5501702079795227, 0.37447965599622096, -0.48575704233963807, -0.5006132693272297, 0.2696315996828189, -0.8372715532257996, -0.6330255940208953},
    {0.04339850238496873, -0.7430562728480999, -0.8361462551323996, -0.7733289531927812, -0.6703463727763656, -0.35458757780799877, -0.3861562021442072, -0.6691636878388221, -0.592974620467812, 0.46395988440434466, 0.9141699122760844, 0.7191481280606133, 0.402705891592833, -0.8781322742614353, -0.8682965156601756, -0.9466367761122593, -0.8623435433014629, -0.6673267534761637, -0.931669119416912, -0.5588319215912315, -0.024220432106352503, 0.6780135863662061, -0.4837669314219008, -1.0304622487995507, -0.7298704779764028, 0.2968971103228102, -0.8955537163402623, -0.9248511345456417, -0.9208252861754654, -0.831130273741386, -0.7377069982311641, -0.6258667492362633, -0.7274256768954285, 0.25890617957810935, -0.2734719797502743, -0.3470058291350009, 0.02574111448736096, -0.5147680342218595, -0.8863390464734172, 0.07041781793702687, -0.5173281185295747, 1.0836033243681853, -0.7594737249923345, -0.8111283892417118, -0.6633815750362398, -0.6255284262497038, -0.7015598608103792, -0.6518579988440281, -0.7268780548503734, -0.5531970822614348, -0.8553488878279507, 0.5937433853844933, -0.4998657829246219, -0.5877274104780723, -0.7122257016092636, -0.5654447297155661, -0.49229823149571944, -0.2998611577542699, 0.3085454422830499, -0.6528456616371336, -0.30334850578300254, 0.29144449558529845, -0.785667198825369, -0.7627243910354549},
    {0.03949670194863227, -0.6145040875055864, -0.4705434539058963, -0.6653066523893648, -0.6809534232986729, -0.5115395330497294, -0.39687714103528415, -0.6469281666662517, -0.40498098231910823, 0.6027817508044495, 0.634590821175802, 0.9222128770685195, 0.5817661741998108, -0.9704842570378586, -0.8713190394683133, -0.7914771184654622, -0.6661429562843946, -0.6485922581291387, -0.8401029120716802, -0.3538591160943842, -0.04274938438837607, 0.5163278255665807, -0.5374867428293874, -0.5795685174271621, -0.46392836390982806, 0.8414884746330756, -0.8420876790381935, -0.3638632259466956, -0.8208054589144822, -0.7571201824955953, -0.641435412567488, -0.429125291851173, -0.3458158346482808, 0.7375383890481103, -0.3395211180067274, -0.40218312733423034, -0.2597417622906811, -0.4336485675566285, -0.9048587166893312, 0.1606770937126908, -0.5206586596251718, 1.1260755999154297, -0.6664219860429949, -0.4791469329437756, -0.7475021069493077, -0.8242235499217672, -0.7023662110089625, -0.6690105999963014, -0.7711509832430856, -0.3859743353076329, -0.7432757342625345, 0.7554990816444558, -0.47028203135540414, -0.530643010612294, -0.581332391058528, -0.5844376464190764, -1.0470759486877372, -0.5437329331328857, 0.6422010718433897, -0.6612406883317091, -0.5005016839019518, 0.3447430329035342, -0.6335143069842396, -0.5846643675512131},
    {0.1884844011758067, -0.6129737363933385, -0.30995321215018723, -0.7041642911567653, -0.8761789420775081, -0.5780520457210366, -0.25590622047341244, -0.20391207790263943, -0.3889976065405531, 0.6527247637693553, 0.8116014321179007, 0.6943620441413804, 0.7089265063647593, -0.7486534964373759, -0.6745768004536954, -0.6342271642363914, -0.6811594792851466, -0.5974391377539499, -0.6809683935075764, -0.052670715894680815, 0.18591728717386202, 0.6945668799072492, -0.4025573166351278, -0.6176331438634516, -0.36568019102262994, 1.0066758634362043, -0.8412110379722398, -0.7529814428943481, -0.7381595628397822, -0.6239200099200743, -0.6303684245586105, -0.2550316941712949, -0.3917484821499901, 0.6946240434164875, -0.18166335678997797, -0.28749736286873845, 0.10919193356104381, -0.15912312213382554, -0.7542628819597581, 0.1736716451453894, -0.6569814956576069, 0.9832584533048566, -0.5908407299871222, -0.3447312910958787, -0.43592897985162443, -0.5733078921711687, -0.8070973006596843, -0.1357405412536107, -0.32321309864807457, -0.004271194640140572, -0.817245802338065, 0.7255325546586041, -0.5401488770043887, -0.26660534503753763, -0.3702006956169717, -0.3641244509568377, -0.4511679581949231, -0.40250832004545195, 0.7469237369975964, -0.5580890492174483, -0.09365132180068891, 0.3425974823654399, -0.5795374785215052, -0.7162064216771004},
    {-0.09150367079170667, -0.639558728690677, -0.6940943360805784, -0.7755433653490705, -0.5296291140867374, -0.6575027855747935, -0.5307243994094525, -0.3150794806357089, -0.5093280933918239, 0.5288770276103295, 0.8212435744750075, 0.6310423480434392, 0.3875454319260006, -0.4594870517563412, -0.9431782017197602, -0.6753453292289003, -0.6443297684894879, -0.6512528304142374, -0.787860680960844, -0.3917104829688125, 0.014444364486806142, 0.7046547669140001, -0.28442390508297066, -0.4229158436280046, -0.6452128251867403, 0.6842041862204887, -0.8572172622059403, -0.7444199664133856, -0.8944226442436979, -0.7680336443492775, -0.6108256795963671, -0.6709494077343185, -0.3626280489843925, 0.6254696162595563, -0.18070584955221375, -0.12115480178640402, 0.18179968778379715, -0.5662934430948958, -0.7020776363630951, 0.18300509594497957, -0.4306035374509308, 0.8746099079490365, -0.6982146408468387, -0.5997133650121488, -0.7079187092928471, -0.6816898405281709, -0.7806821906573154, -0.4107401617534541, -0.34025915386232414, -0.4203708621649329, -0.501688823572127, 0.9482214410728144, -0.34331517999263617, -0.2797650708925093, -0.46094122533217785, -0.5586849232309041, -0.7178633852308747, -0.6506465854843397, 0.4547626145424596, -0.45447318062505665, -0.47191198349365643, 0.27764760211152495, -0.6947626477701513, -0.6507218841031712},
    {-0.21653478755035083, -0.6989158544409269, -0.5093302270516509, -0.9952478947910903, -0.6428247796434444, -0.36461639464970064, -0.2880867129657205, -0.3490803224004886, -0.40633149340038194, 0.7884488410914592, 0.6190929026926726, 0.8025836982283222, 0.11173136110244695, -0.7945690920967237, -0.773780609937772, -0.6512470758494239, -0.6856683100388088, -0.5384348923526964, -0.7122050327311255, -0.3684834345709369, 0.14971496479978422, 0.42394735454516, -0.5704486524271618, -0.8227958780324564, -0.39957460127525574, 0.7208166251742568, -0.8881068750789575, -0.7342129389075666, -0.7928559068336172, -1.0204030232349892, -0.7126154355608544, -0.5200926565195155, -0.36710948611105043, 0.5744743998925826, -0.16417301868602416, -0.3985119233981162, -0.1593465425005473, -0.4878489814305216, -0.7500782456130328, -0.18821565974330318, -0.6579133218223814, 0.7990139223008169, -0.5822517503405875, -0.807782811906817, -0.6332200831355924, -0.701991860209854, -0.7183632618565671, -0.5974110187217179, -0.6319491177750566, -0.43770931794815093, -0.6287601735342039, 0.6230814433743913, -0.18091849938200974, -0.7693490284875671, -0.8199002052258845, -0.5101127210339512, -0.7368976680440191, -0.5172010660334754, 0.343479738685819, -0.5826736730880504, -0.5155749906553866, 0.15437096705487363, -0.6600711484565388, -0.8154184871140838},
    {0.2645423730899709, -0.43295377611999475, -0.7170924312541853, -0.7587671275736579, -0.44369949473535447, -0.5456803418547171, -0.27946541960553467, -0.4327868357102419, -0.444942547940183, 0.8009282302402563, 1.0452588461343366, 0.5627171448068459, 0.336880180570603, -0.8058727563774585, -0.9050526315970213, -0.7200509985807722, -0.7167788660048858, -0.5375268667812149, -0.4145342548633, -0.20971328238873665, 0.3646371979138162, 0.743924966162396, -0.6367424143200198, -0.6672299401773941, -0.6145736853419376, 0.629164017873107, -1.019972825892598, -0.4659244471964488, -0.6893410872875824, -0.8628993796976869, -0.855753790474039, -0.3364286662150503, 0.07787689151550105, 0.7973198194013812, -0.14053464399740037, -0.13327843440721499, -0.14991850748011631, -0.37527613376104835, -0.6461999799949827, 0.254347551220583, -0.5220341051748801, 0.8051913935404622, -0.8029634383424074, -0.7434913576999712, -0.44254937649106624, -0.692412768526465, -0.675812772107679, -0.42551916236467435, -0.34334352838725085, -0.16234559692570097, -0.7533869721298943, 0.41191039758955655, -0.48388895811523314, -0.4361996069747501, -0.7150964481455159, -0.5161498625890114, -0.691385405471769, -0.6682734062853235, 0.5937518627509797, -0.26328365116418445, -0.22600353355884986, 0.23208654009668464, -0.8143022363029567, -0.8161307974272699},
    {0.19597317634914746, -0.6439554032757732, -0.5090426589409254, -0.6491840581399125, -0.6040472998565016, -0.4051868233768694, 0.016875316036524344, -0.1921894562470341, -0.13772855935142234, 0.7371404530954845, 1.1062149042557294, 1.1124568700341688, 0.7115466371440542, -0.6635901006447925, -0.6318360317721088, -0.507078680722342, -0.6299383862311255, -0.4157279684720584, -0.5924851481587379, 0.03840672550713739, 0.26313923655591764, 0.9213242270784174, -0.44725319157161497, -0.4617863951339799, -0.17744620362235689, 0.7493581840493583, -0.7232475931717703, -0.26037155239325294, -0.6034857655145086, -0.7319518575446023, -0.8171783977587723, -0.33607016791243094, -0.31176383392317325, 0.7226578478386099, -0.2393022619382504, 0.060197434670791784, 0.09469645363365571, -0.24546546395313087, -0.7849419354935924, 0.21453839141613137, -0.5356682899363817, 0.8399549283222255, -0.581040747747542, -0.6975998412119194, -0.3942847418930531, -0.7467186949178984, -0.5879265009934792, -0.590924005472306, -0.4540476966530457, -0.07933319539599433, -0.35092652207242714, 0.5901084755458909, -0.37013400903414295, -0.3684461486787868, -0.5392398696819869, -0.5070297182005449, -0.6783067451421274, -0.5886463523357996, 0.8431141738672064, -0.4972630496558113, 0.09722540805661915, 0.28095841398904725, -0.5954617140538371, -0.5891729162755125},
    {0.04438461416330778, -0.7039818626149068, -0.2175912298294792, -0.4816637867536135, -0.6519846810466179, -0.49917979808086665, -0.032305544755706406, -0.41640140983313007, -0.3535299012975891, 0.8435141383058478, 0.9692061717913658, 0.7581079413322417, 0.7776307821717098, -0.4523985522176255, -0.5580221981889754, -0.5323818166245086, -0.5269445724505658, -0.4525214369190516, -0.6888516892544891, 0.007502804577232325, 0.21550916809103876, 0.8108985569498651, -0.2658158176685515, -0.48720660587032616, -0.2936712554091096, 0.7814011825152283, -0.43914522937094097, -0.15883790581413654, -0.37263153621155143, -0.918667351925746, -0.4836565374250464, 0.033777313492345785, -0.07256961612000974, 0.7431947674652661, -0.3118381433134469, 0.12506670954876095, 0.12409476513759127, -0.28264902570208983, -0.5541165796794414, 0.2895978595081295, -0.2743379147278802, 0.7140750098203031, -0.7568134401018444, -0.5044611883284408, -0.2245850644554253, -0.8768511601491663, -0.632984423660399, -0.4982571836593185, -0.0991068276718172, 0.29111123976068737, -0.6408532183147905, 0.6720296092323998, -0.41800799892642254, -0.21436834923672687, -0.49941903187391545, -0.29935815333942495, -0.7667333945866037, -0.6430192510311405, 0.7138091031651725, -0.5727677759365937, -0.14216886518056696, 0.37492117515629014, -0.5372509433159829, -0.40315689213540795},
    {-0.13948902952485046, -0.3244822201202508, -0.4356602849274881, -0.8315956545245051, -0.5796258048419475, -0.5620316865634787, 0.04056770564209956, -0.1406875419284471, -0.539543504361945, 0.9608647377810676, 0.9135306261868311, 0.8214759586146112, 0.67479613869289, -0.41522860499633707, -0.9791615255750808, -0.6281387540624014, -0.5819429312353068, -0.45590461216759465, -0.5932485120727768, 0.13034050007532008, 0.22770564051374695, 0.8077891884221342, -0.475030761527286, -0.6883385292228756, -0.3408368469441968, 1.031438256257967, -1.085414962120079, -0.5227280316658307, -0.4621658725196881, -0.7253522232591614, -0.4332005922840692, -0.1301259786006361, -0.2163251828171297, 0.8494990604643116, -0.18383359593252047, -0.17986437625906035, 0.1650595812008293, -0.3912936143351645, -0.6195479708883754, 0.495783409764411, -0.5383899736061826, 0.8213436397215236, -0.8865215066358693, -0.6803869245303767, -0.36320181001862356, -0.6768248819040201, -0.8161168112419149, -0.35412740726081615, -0.34958363321406377, 0.02218291704579735, -0.39121249751568377, 0.6641406365763276, -0.6447516768861534, -0.2634982375908036, -0.5333190664638422, -0.5963324685043524, -0.6553183771787366, -0.5119730311452921, 0.9245758408405804, -0.36334649695477966, -0.33853619298545595, 0.41483391011749027, -0.46169322017653486, -0.5466786471157525},
    {0.3149087293560685, -0.7439420909064962, -0.5365498154615813, -0.8188203595973098, -0.6686665214932206, -0.43565359349377386, -0.09570487506175973, -0.5329757262638355, -0.23735229908893032, 0.790252159033928, 0.5233490105541962, 0.8812714058493871, 0.4359217990895375, -0.7256516874301144, -0.8518949612691924, -0.6410891181998931, -0.7346807148437041, -0.38630569794388575, -0.5339075374010246, -0.08091818773444727, 0.3337114896869669, 0.5458267464683498, -0.6000712135453287, -0.4846852786255632, -0.4735886281609573, 0.7466317842807608, -0.6941535523721263, -0.6341788359911664, -0.4908776473828541, -0.9266943807427154, -0.8670389646435109, -0.24435515563659535, -0.37069844675888014, 0.9018269276043548, -0.11723329729225035, -0.04248413758403893, 0.08278841822772229, -0.5135870028455847, -0.6544705876696778, 0.32263251939280363, -0.566648128919739, 0.6234509017654623, -0.9406096682324501, -0.7895189172264405, -0.22892766336381526, -0.6028722054629917, -0.8516487860015365, -0.40308662462690864, -0.44525527381094904, -0.06398986017738327, -0.5132453275544495, 0.517482163190419, -0.4942852496212532, -0.6446215916481296, -0.5296308853027542, -0.6055799937652102, -0.6715686526232737, -0.5117581461582967, 0.6304751953994744, -0.5407274108039539, -0.29048644517817107, -0.023941208937046776, -0.5617384215639154, -0.43107888020277035},
    {0.15055788973861664, -0.5205273349177785, -0.05577813075428447, -0.4387549973205143, -0.44707339047851563, -0.11950002163798344, -0.26236189682954963, -0.317856631179047, -0.22190056954035928, 0.9850730122569905, 0.9758663931216028, 0.9076372378114747, 0.43774287643470383, -0.7109986461782365, -0.8065339405932811, -0.6007131489677282, -0.43514765106581493, -0.5547008770796378, -0.5769932572691852, -0.04521428337358232, 0.17093314918735822, 1.076007499242925, -0.3343539902337683, -0.4331842088990396, -0.4575130543399896, 0.6626066900279881, -0.598636015228797, -0.45629335624689993, -0.6636834664564177, -0.816078228712427, -0.6885663288049891, -0.34649477976399495, -0.2089004229176299, 0.7433715126128215, -0.4110913490077894, -0.09395277009196114, -0.014966473480082891, -0.2661101129737713, -0.39011338637698995, 0.23556803746689572, -0.3285923449522809, 0.9683262136277929, -0.6715828039843027, -0.7430629175983797, -0.47031521505803464, -0.6080698330558871, -0.5129960327112794, -0.5173968508572556, -0.4426471636735694, -0.03593031332407282, -0.5648338241420415, 0.7037843540556125, -0.2276085388772201, -0.24364727211186354, -0.5422493535806381, -0.5145311642404895, -0.5748122119589645, -0.6986668741296426, 0.5676532543851902, -0.5009343558996041, -0.22177358628936256, 0.21412256840716717, -0.4158865878997003, -0.5157711403526167},
    {0.2029021934466406, -0.5630793857876778, -0.4251134862335426, -0.8227747016799453, -0.7419944768359388, -0.3878206963351282, -0.2168866422707593, -0.3821855827102823, -0.5008419028048879, 0.7719587898072482, 1.3432942102424348, 0.6399499217106436, 0.39788727830592874, -0.5580557796429796, -0.7916140703374165, -0.7908188277176662, -0.6820708686841587, -0.5238804988795196, -0.5284401481746028, -0.3505653711450365, 0.13888517727377397, 0.5586108717195799, -0.4530458013277048, -0.6810277882850471, -0.33890384193567635, 0.7061769471732743, -0.6625509489748372, -0.32770949777914216, -0.5075894213460178, -0.9088447893537842, -0.6088111064827203, -0.31082316234307433, -0.18404832165092105, 0.5991314942914415, -0.29996286959473123, -0.2484373265667144, 0.2286202865339851, -0.38908782806219316, -0.7511229456689381, 0.38831192795012, -0.6775852191956881, 0.9960129484914335, -0.6209827684970253, -0.6221658624811727, -0.4859951810308878, -0.6736881812901201, -0.8173802679984262, -0.31994074753241236, -0.4371893195927617, -0.13564830296846409, -0.6760899139407248, 0.6090173185591357, -0.2267858814730242, -0.46249919634595243, -0.42003053631254533, -0.5702167772999451, -0.8608628772510928, -0.751475268575885, 0.7680898235226118, -0.3873359317958882, -0.28627892399680027, 0.062015718831565037, -0.7879497595785065, -0.6163487009300956},
    {0.13342249461877692, -0.49835788005540665, -0.2346552767893817, -0.8913964959939632, -0.6647497490964116, -0.6021637605874404, -0.1491217262300807, -0.5294027346361659, -0.4238155054283551, 0.5967024323134288, 0.7786752006242778, 0.8845909375885018, 0.47638362359054454, -0.5981617390552616, -0.779372396658376, -0.8184396320386255, -0.6203511627488849, -0.6093375698763136, -0.6465047366803232, -0.15994886809138703, 0.07844006118359681, 0.6598764207550774, -0.43885676344570534, -0.5316262040772178, -0.607001119340218, 0.8528993091684759, -0.839153854779156, -0.38647709846332906, -0.7087871043792817, -0.9701928817882844, -0.6898436894490689, -0.41597269403196435, -0.10268435285822673, 0.4468845713341133, -0.058706103812726694, -0.21428634923047774, 0.12490129076705614, -0.37929570114312006, -0.8191066329189713, 0.14721953813946193, -0.3790470745888574, 1.0506767872425853, -0.7352193525405398, -0.810176771217893, -0.6338378940206839, -0.7582856229045101, -0.9445731336356589, -0.45834138616481473, -0.4981888162779291, -0.2002589409896341, -0.4041074594921038, 0.6184613111328965, -0.4030456817752356, -0.3813613095871411, -0.5990359347027566, -0.5594876922491798, -0.7204902089406504, -0.4343050550206943, 0.6753674850376823, -0.4377063461658322, -0.3564064951988977, -0.05077856047946937, -0.5643131971038625, -0.794640546872202},
    {-0.024744191830394904, -0.6414807546056411, -0.425782115145723, -0.8011506780880696, -0.4696076885434792, -0.4436677998350223, -0.27147795626617666, -0.4762482734793261, -0.5536419193887923, 0.8474108497791702, 0.7310354561872062, 1.0933083245251058, 0.7737192564885939, -0.618808822834619, -0.8171149886921255, -0.6336770669579753, -0.6440026945005848, -0.4824888985980781, -0.8690425622866226, 0.04487506591507546, 0.23046987049295717, 0.8142595608525682, -0.6617729457776679, -0.4656026733962881, -0.37825192133659735, 0.8097130060698002, -0.7593471901066254, -0.6164581439483777, -0.49965976417352703, -0.8712187970251352, -0.49212951383093545, -0.25309554483252744, -0.38051678366502584, 0.8610474064656649, -0.1983086512473592, -0.28152854799213967, 0.02262533324841053, -0.22979188942396275, -0.6227280778379505, 0.31964375750899665, -0.7246455940378983, 0.7801445873204599, -0.7902345126428656, -0.6954260218112526, -0.6310755993986918, -0.7312847990654963, -0.7184885602598563, -0.2903757669728203, -0.7104927296741066, -0.22006345514142375, -0.5857899532096483, 0.5326147163970782, -0.35282736349398125, -0.4774782448939187, -0.8416708730559759, -0.5446870774323695, -0.8488273849781224, -0.4352367824317043, 0.6949197403624375, -0.30647971240936966, -0.21503982087798462, 0.0837748359592471, -0.6670047199155247, -0.3491498724283096},
    {0.37002537302737715, -0.6735660084059854, -0.1716228438418415, -0.6336394407180506, -0.7094857070416085, -0.37736670349919615, -0.00883146727874018, -0.2465582765858476, -0.010248024333975706, 0.7710221239172046, 0.8052799236933289, 0.568459257646036, 0.8358697126234668, -0.5055966078999202, -0.6741218102464298, -0.8403375722807671, -0.6965876006190922, -0.5671586808026259, -0.6379803857931589, -0.12661448279510917, 0.1169403407564757, 1.137120197148537, -0.4214508496204234, -0.4651128114800359, -0.32750240194268687, 0.723976487956822, -0.6105667700336984, -0.5679011436368894, -0.5275904885616759, -1.015277089132254, -0.6868569473724957, -0.2067180363622955, 0.12846439795267167, 0.6052922376819574, 0.04990407791035753, 0.07000058001557967, 0.153451261725813, -0.3437045857913554, -0.8340927151451376, 0.4260773601304399, -0.7780772588015364, 0.6808592007397951, -0.7322810352579048, -0.41703202519667804, -0.20950713767661444, -0.6900935475523181, -0.7252730706145551, -0.011362375123079542, -0.3751809386249744, -0.08169897323114525, -0.33250400618997056, 0.6021196961161904, -0.3970625735478048, -0.07170522847567432, -0.5970290305248452, -0.29661579727453324, -0.5461386394264478, -0.43691814288063685, 0.6848544127450445, -0.3939203664290016, -0.14959986102084843, 0.13184741388378873, -0.6269846513755241, -0.3458571792758765},
    {-0.01466794260950065, 0.5715341506534486, 0.48159499395699046, 0.10458759800333485, 0.2723982292520333, -0.004677125126185185, 0.31094209711625936, -0.09975156218682651, 0.2486837814481838, 0.3081369216337554, 0.6318640970649112, -0.01262164107779146, -0.3220290409817749, 0.28689652205232574, 0.6524901874686838, 0.05586598084215234, 0.2441263406998945, 0.3444814815497421, 0.35204820228018163, 0.508395633478682, -0.04467794552030448, -0.6378146944733829, 0.20131210350937553, 0.24699597345449503, 0.17516705737652027, -0.27291516711002106, 0.22110361103277898, -0.06887441078057496, 0.3111991420466995, 0.30646789301924865, 0.3021793487377378, 0.6834365633313237, -0.09436058186666506, -0.4350401509755058, -0.1495388864153495, -0.10748797369703167, -0.34993308429599823, -0.26968972803760494, 0.490124813739589, -0.4557135245005543, 0.17005034002814992, 0.48911929614422495, 0.282352004879202, 0.03728296907584777, 0.3526399771759963, 0.3501262463261864, 0.2062087046507689, 0.14906080803903218, -0.02640054714963995, -0.16628457042924258, 0.13605018242169908, 0.09322716453229733, 0.6117679534656478, -0.08418891482000937, 0.440837444631472, 0.47476655168794735, 0.6604163110041457, 0.4403206420557934, -0.23634758891876137, 0.62513090972249, -0.3932768913201065, 0.3238798227651437, 0.3668262135556188, 0.14949187070237213},
    {-0.19189702808129075, -0.6420766528443774, -0.8192569724539779, -0.641787590363712, -0.4661102637306313, -0.34390132889534647, -0.3656511215194826, -0.4372626041699005, -0.5957051565803222, 0.2625880004826521, -0.1421636269681601, 0.23655051683328804, 0.005741470659525077, -0.49074108864476346, -0.49557849885988164, -0.5029379564004907, -0.4435977715424045, -0.4781085419800739, -0.5979559492631445, -0.02852639440967853, -0.07866480760672097, 0.3621408380515862, -0.32432085224749196, -0.16540003092563604, -0.35403832120964807, 0.23841564244748079, -0.42631986103557223, -0.09018866695281946, -0.6189925976092402, -0.732426863497108, -0.704305171334884, -0.25261597501294275, -0.4269264479649411, -0.023754940358279738, -0.4451962816622638, -0.4877798708103891, -0.18538840167720708, -0.2876616950520196, -0.8278523415575014, -0.24402569616635802, -0.5529273651603911, 0.2895001313848249, -0.6617201627674292, -0.3324106075706265, -0.47458441376515004, -0.5947395039506096, -0.7362969256537629, -0.06785931198046671, -0.4332243386577703, -0.1951385335267206, -0.3574339888149826, 0.33041676141159004, -0.6249750678632311, -0.49413779295016885, -1.0318119797680745, -0.5447645454143578, -0.7996952230807994, -0.3410654796662343, 0.37593590955844197, -0.3345640682017949, -0.39520840582692696, 0.3332433357722194, -0.20483802581777497, -0.2474844621470993},
    {-0.5248925692136646, -0.4785929991203277, -0.4571200837219557, -0.17161841592009525, 0.41448074580314076, -0.44411711829759765, -0.36297782904136244, -0.3635140557316971, -0.43023406726545804, -0.23721434420949233, -0.1354317618931269, 0.17667026195070795, -0.4510908845400345, -0.42400023385144403, -0.05449731823024301, 0.19783645804627661, -0.21583484974080527, -0.27706742366358017, -0.13771770963269542, -0.3088884159332469, -0.49057352043243657, -0.14239715806433303, -0.18854871702052645, -0.06967780049650173, -0.5900039888071876, 0.028970823958704175, -0.5860197866825746, -0.34238909852744004, -0.15417011812912895, -0.022744141901788136, -0.5156709716968955, -0.569727100496034, -0.7309264155764693, -0.05326156861378028, -0.5689631901105217, -0.926787217567157, -0.39735681583163845, -0.47011551863690687, -0.35950639559952163, -0.7788618644163352, -0.5195994969768233, -0.07432829945828252, -0.6685947966169602, -0.2588598152016147, -0.557242112691432, -0.027711202844644088, 0.09634027234257049, -0.3861259143159375, -0.7444984227383057, -0.3926038786416192, -0.3148775885770925, 0.4649934561061732, -0.45634584034726244, -0.7309045230658191, -0.36146993189954246, -0.04841892962015456, -0.07402659966319128, -0.03531278140544053, -0.3337717623972205, -0.3363220103357147, -0.7193251760382737, 0.33203666003790255, -0.3779612485139541, -0.6241792077503132},
    {-0.46031044083088085, -0.6712285147321913, -0.5748077434720317, -0.07979153847155257, -0.27532208004707787, -0.2935494572858949, 0.03391540586139794, -0.11964471972815802, -0.5060254405930058, 0.060038561104293106, -0.146991845106751, 0.1942069936062291, -0.038807526215429204, -0.2905964864826714, -0.5232242077973177, 0.0894812974588438, -0.3253025155242889, -0.2354127976277386, -0.004746413832868228, -0.022958669773384188, -0.68192229455876, 0.11660762764241353, -0.20163430159171972, 0.057121604678731015, -0.6238269508661818, 0.17588721806388866, -0.32678618275099913, -0.17633503068020662, 0.04175575943961963, -0.18568692358557531, -0.30697409905301093, -0.24407332264235973, -0.1709520742179639, -0.24431302657467027, -0.3461890179151865, -0.7616724129095682, -0.1841830950784756, -0.27908248429349825, -0.5575733845069736, -0.46837362591616283, -0.5303695551421966, 0.040271566227601294, -0.34049632724440987, -0.1865416402004493, -0.25944722758084793, -0.3165801961328114, 0.06146888160656429, -0.04804539942144484, -0.43762861391950497, -0.12503954469397488, 0.07531247692790273, 0.4762769975730076, -0.3980597620930727, -0.2504738231397903, -0.5265286838021557, 0.16366902573090042, -0.09012291377404268, -0.3131081598221831, -0.20506929845969857, -0.42879225430244766, -0.399652495698199, 0.2641718420460898, -0.3058033880905214, -0.5841120393657165},
    {-0.6312930038535658, -0.7756123368590877, -0.6608801672960116, -0.44156618205974457, -0.35294872471774946, -0.7482279953609693, -0.3920043538799004, -0.7498869334989977, -0.5271182985410858, 0.21889542575438098, -0.41404875895126814, 0.14152511760880823, -0.6550889325781566, -0.8968804740493094, -0.5711074249031035, -0.2204512684047219, -0.571849286911341, -0.6624098196702717, -0.6536669551557401, -0.5384498092064419, -0.48757210626971775, -0.3256345255716679, -0.6543503733819714, -0.29746890613299615, -0.46775283244693483, -0.22782324766037373, -0.5355867991033014, -0.5474690292957838, -0.7913233440540285, -0.6023141672853806, -0.6489986280067613, -0.3130542296579802, -0.6055954791316107, -0.047607316705143635, -0.4095322592179613, -0.5579905829375056, -0.26155094841307724, -0.31545917317272865, -0.8623505107821599, -0.39574816025851534, -0.7349224989903177, 0.06919176488599464, -0.6153443041745358, -0.6688860175257656, -0.8565638348872411, -0.48250756769765607, -0.2778398693260846, -0.25004144373216003, -0.4785531827421132, -0.43455270397100465, -0.11469693591656684, 0.16981590224158377, -0.11642606016764939, -0.9351861034819777, -0.6407071684618001, -0.4644010789801523, -0.5443383913381771, -0.49966760884846295, -0.17096626050209274, -0.7209093749934908, -0.4767252214596426, 0.05484560063564811, -0.5101576449001731, -0.5818525689124907},
    {-0.4752813278683947, -0.7920923714552361, -0.3450701713799139, -0.5570386001387809, -0.26188972134686267, -0.5207381715814213, 0.034849401310646136, -0.520924757452753, -0.6941932306502753, -0.04338104487173258, -0.3455374007887989, 0.3370197749020125, -0.6137530261964623, -0.556361809859273, -0.4420930295174022, -0.12779179747434813, -0.7164761753054003, -0.4849462957994668, -0.6210387588715156, -0.5208002100438681, -0.5761643588481837, -0.08205502499481179, -0.4746218995030565, -0.6837605915855469, -0.4243509326403556, 0.14754742694386339, -0.7822089829002727, -0.30174809981116135, -0.5958321567094933, -0.2576081719615117, -0.5731193613967747, -0.5149567114493849, -0.5359138652404153, -0.1235559719931234, -0.7354158238729924, -0.5894762116293443, -0.3450822063092833, -0.6206054091107481, -0.5859948078450604, -0.5395660804889445, -0.8489995874166772, -0.0503970215529063, -0.3072348614424536, -0.6914039901200405, -0.5794686734858994, -0.46774474116844494, -0.1973090365623684, -0.35617976680831115, -0.7118175661132866, -0.4688678281086569, -0.44802033893810106, 0.21846195049112352, -0.02823941728640134, -0.749168849339819, -0.4652278147165047, -0.40944856315718653, -0.32938223274243494, -0.2636816235579536, -0.32320055312120033, -0.9171879375746841, -0.31286900532103473, 0.10110519222634892, -0.6123799293827743, -0.7924289444097607},
    {-0.7036767015842541, -0.7250929730321922, -0.5510505896308043, -0.39498685355013236, -0.14914859514521164, -0.5930316213889152, -0.38890531633149567, -0.5742190335148323, -0.793027497081748, 0.31248603231451927, -0.02619531158300514, 0.28060460070055077, -0.3182636237852262, -0.6584754186409937, -0.5544362126399068, -0.1910057692056274, -0.22072268717109356, -0.32161996415151795, -0.23577057244969846, -0.47385224242958923, -0.49892806807709983, 0.03283096629489411, -0.1592250411163449, -0.49277614832450534, -0.5450720414534164, -0.30659363618320007, -0.3309853814703236, -0.5660251995526593, -0.47926592089677195, -0.3064121415594674, -0.7535529101860637, -0.6429968609235321, -0.4774177368108147, -0.0952870740808582, -0.745334219561151, -0.6508410574773295, -0.3441869651027896, -0.6890714102737924, -0.641866313630052, -0.5438965737399163, -0.4962997166184018, 0.1413792788541515, -0.7056213542293182, -0.49681585958067553, -0.8176297580583683, -0.21748134355914986, -0.12057795021241462, -0.20578333658310602, -0.4240779927379403, -0.7087635818824821, -0.2594918469204815, 0.2986204620346764, -0.13008325954756025, -0.7097917127770319, -0.5641968928103023, -0.04627885331236448, -0.4175188815504681, -0.22711757430241727, -0.34949911536730904, -0.567294761029183, -0.43291917573860755, 0.6099844186925432, -0.4501650248974606, -0.43271411688647693},
    {-0.6848505489446098, -0.6694156215018978, -0.37849275091021345, -0.4476003763075446, -0.21509528840552877, -0.5904566365340537, -0.08495667363655582, -0.3818818746305199, -0.6100222952176173, 0.31714705054145204, 0.04909651357725722, 0.04121378757929704, -0.09553050987535087, -0.5957875006021641, -0.7694584734685775, -0.2878254522232478, -0.5377906899710899, -0.8493751870296463, -0.24259299380755148, -0.5897737293196555, -0.2997883511070684, -0.005071815447119059, -0.8121061297382617, -0.42920172350280694, -0.5285659854486614, -0.08656314676417029, -0.6048445581630794, -0.7643715519520997, -0.33860266161920044, -0.26255888740798955, -0.5869449998595385, -0.7764467922589267, -0.6247375523618018, -0.09418714001343739, -0.5106733847518219, -0.6608711559211523, -0.5002069412098912, -0.16870653685380382, -0.6451658934248354, -0.3931770799614045, -0.6582320335486966, 0.14432149288962226, -0.4703334486448113, -0.24697229083091324, -0.5979921909805173, -0.3448067222521252, -0.30206623399007854, -0.6430751500247636, -0.5632761387051249, -0.7311462737771871, -0.31993292178130733, 0.03782300321443064, -0.6770313887364902, -0.469704639936039, -0.5380926292713201, -0.19938953923195787, -0.3873588884857755, -0.006805990559402245, 0.02275988015458952, -0.33521465828437574, -0.33896932841089117, 0.4355985240058721, -0.5754524649971118, -0.5962794635661679},
    {-0.31495271686748094, -0.7314073909445282, -0.7883055922128467, -0.23246985683933188, -0.15947527381459847, -0.4120132057939301, -0.09038984685195571, -0.5310880556796984, -0.5452650130227781, 0.2554158949419535, -0.20390366155753764, 0.16003590126443343, -0.1577562564994046, -0.7111566300378148, -0.8482241208040365, -0.16795825426342564, -0.36366695193094, -0.864643591329121, -0.5877299872557378, -0.6628697157425764, -0.19736707609515933, 0.0638531704238252, -0.5394344532148131, -0.2982702564251435, -0.45483832584213707, -0.1998937144018074, -0.5963514759973156, -0.39685064977397955, -0.6404370247560484, -0.7550782342647595, -0.4235700481389339, -0.5542488955738492, -0.7107942680078653, -0.22507305746409395, -0.7162403041997635, -0.5727269775470287, -0.5309564099881154, -0.4305856189059239, -0.5123619697689653, -0.17288409085752626, -0.47427812512692546, -0.045943794778633584, -0.49754797426948855, -0.7598793981507244, -0.4744694481833988, -0.5371906805427588, -0.3401338901966032, -0.42275217457574626, -0.8047955257941556, -0.5754585531822536, -0.45617790310235534, 0.4276230557382522, -0.2970396051375229, -0.5969171997778204, -0.4795291325994429, -0.1597137538878655, -0.3582836398411656, -0.309542181090579, -0.10478630302619257, -0.46508393691541144, -0.27141054969190487, 0.5240332972027986, -0.5503852182151324, -0.7459196520139099},
    {-0.4549906610246664, -0.6437974475504008, -0.39299269498093187, -0.29367023593943564, -0.14171874478934304, -0.5570066306971823, -0.20179282418400005, -0.604749976888287, -0.1554419017362856, 0.3841283482683842, 0.28903412134618045, 0.37327248402093277, -0.30717105440924775, -0.4820470492142879, -0.6144529903187229, -0.14466556623929255, -0.3742735036432295, -0.571406145091003, -0.4580048204448141, -0.36796197948633996, -0.024314764656121892, 0.027149203405952997, -0.6636959914128922, -0.4529892797694842, -0.5018173162479416, -0.13807763733745457, -0.3492349756200759, -0.6660246831988589, -0.8256676551723234, -0.6642639663655281, -0.6825688157757089, -0.308424116518703, -0.27584234481011743, -0.34330404628281985, -0.31823765328394993, -0.5777816007359373, -0.4348093045874502, -0.42389387919601407, -0.3557464421398934, -0.501164633591933, -0.6166180407012585, 0.19054376763616485, -0.4045277048896267, -0.29408251808250413, -0.5238978776607994, -0.6791250752044149, -0.2966339497967748, -0.676227843701265, -0.7493303115881603, -0.5842229389584374, -0.5384688104400033, 0.39390225742421586, -0.011945249064597927, -0.8473329077432176, -0.42640389726996586, -0.18859767457418838, -0.1220396040071598, -0.2644040475536419, -0.34486978006867847, -0.3943295564483946, -0.4460703779057806, 0.2137281529135364, -0.5029922495930887, -0.41412044902276923},
    {-0.8511033704319725, -0.676079292934379, -0.7311369719197528, -0.21722252134681086, -0.46082221327572903, -0.740248631479428, 0.013546904441064708, -0.76356320221592, -0.43851559413465946, 0.15999946227677708, -0.12397897215576949, -0.19988201082380105, -0.8129140099850228, -0.6540069546391772, -0.5779820396782854, -0.1916849506448933, -0.6173701105697071, -0.5566589968085932, -0.4820985656225441, -0.7087742978284495, -0.3828577195815351, -0.29609655043424665, -0.6762281252312395, -0.5407713850456697, -0.45672263087140325, -0.5561156594983498, -0.5543229516683388, -0.7617560298647912, -0.4544208778972101, -0.28073144494457664, -0.26034758627364, -0.692081276299782, -0.6644223839635032, -0.5298190450362412, -0.6801888754221651, -0.7369306951034476, -0.6557144098170498, -0.5690943091020929, -0.4885861184851963, -0.4199154923439761, -0.8786833582487702, -0.17010360883929587, -0.6128383267683339, -0.4772008168646551, -0.8742258381677063, -0.5837273272330613, -0.33031013584433006, -0.2672507708188767, -0.5829045752931493, -0.5630779449660319, 0.03600531628973, 0.24104024113787637, -0.33987020913916893, -0.5203334739273253, -0.5674303387518111, -0.09711031891994652, -0.4526083359951317, -0.2799361800948894, -0.3686185690273467, -0.31136235841483634, -0.5129870881181804, -0.006750147739536754, -0.35109699680805295, -0.8674409188813913},
    {-0.6666252743299776, -0.7882219707782685, -0.658444257515436, -0.4287851145465876, -0.1936300656784231, -0.4231577366055143, -0.3572733903027962, -0.7249051572621029, -0.8446598819764557, 0.3357110112431025, -0.08858482138047892, 0.046425483265870655, -0.39017024299001957, -0.7160637756451947, -0.6517934468967982, -0.07577873938673074, -0.6056903620122562, -0.3565399023488625, -0.6627457819256337, -0.5947817540877762, -0.2565109168036048, -0.0511306796660138, -0.5217860936239989, -0.408152708782622, -0.3229178463253369, -0.08145650111607192, -0.44942700499331906, -0.3576921750164618, -0.7045789974031259, -0.2898328305211086, -0.599455859793658, -0.4318465793998784, -0.4634500433706805, -0.0943008728794924, -0.6469650272028498, -0.9026716797543598, -0.5436421818624065, -0.40737353176722396, -0.4223416029777589, -0.4991804479825161, -0.5239267801500465, 0.12139785472421552, -0.2658075578925252, -0.474531816341117, -0.5795464904846858, -0.4586405688861449, -0.39510646827054796, -0.4048085579531731, -0.7520467616787486, -0.2986901700883382, -0.1098561167385252, 0.31042023890044507, -0.1526864688581322, -0.7849467172693158, -0.6785989785814954, -0.2459421588103037, -0.20864086285552635, -0.20103836171721443, -0.2074092689623465, -0.55173893625958, -0.5188409683521268, 0.3262941394529059, -0.2857959867372375, -0.8729443697516304},
    {-0.3408363858563046, -0.8071700499112026, -0.593534551116857, -0.41766135400202875, -0.4071404749774725, -0.30342939070956393, -0.3258863501194547, -0.8984151337032196, -0.795680165251941, 0.21886416856812085, 0.03924334972859633, 0.22921462922037827, -0.48944387628349384, -0.6019085622230068, -0.6554899433150949, -0.30865521758101044, -0.5618583001354004, -0.7432270498760274, -0.5723505301159579, -0.6511365751748811, -0.4897174206468449, -0.22830058899060654, -0.4334508116181771, -0.5258100623290366, -0.6199483696691227, -0.1955952831834447, -0.8075382502082991, -0.557351650120179, -0.540290575829014, -0.49449815111497497, -0.9777340658686052, -0.7576372147227677, -0.4085809185919213, -0.15680803005251162, -0.820272186291957, -0.6409112110114021, -0.7102875791796215, -0.8232845936790152, -0.7656510064098513, -0.7493714918774581, -0.7563079189651145, -0.04485886590108012, -0.5505873664309114, -0.3869637230602832, -0.7516214166927649, -0.3349256832490515, -0.4920421956748777, -0.453517552325914, -0.7125373520055487, -0.4055179123359212, -0.06395668562241319, 0.08783890248861294, -0.17885736995424412, -0.7269117290717938, -0.4100182399658306, -0.46428197033372104, -0.21382379741375934, -0.1575042495188454, -0.25902578401488824, -0.6121887271731539, -0.8515568205431617, 0.15093501881716662, -0.7188518471369684, -0.6921065298783418},
    {-0.4400110613375772, -0.6125549381223134, -0.5044875831158463, -0.5102106786446312, -0.3786702042946332, -0.7522152312089382, -0.39540325507578056, -0.45173771833864373, -0.5348708117484043, 0.18177546246452736, 0.16970087413551121, 0.16318861339534466, -0.3021557241475461, -0.66610536000024, -0.7095871266362489, -0.2421902928882465, -0.7461873140289702, -0.6658224459291937, -0.7059557998406802, -0.638611332606477, -0.4164505836730482, -0.20422782014447594, -0.797260336825307, -0.7939758136702586, -0.8320435382253598, -0.23691056475226407, -0.8865112949953967, -0.6561126235359844, -0.7828247047432517, -0.624840739972478, -0.7089955814940929, -0.6526361161758542, -0.41119983388917875, -0.043083374677422764, -0.6373563559373505, -0.8068651748103134, -0.4297413984881082, -0.502027325281027, -0.6957750897237952, -0.5711381328156618, -0.5382498818628183, -0.04586898997120027, -0.6375568370173228, -0.4503967298441322, -0.6208051818091007, -0.6605875583094821, -0.5309131462384714, -0.5175129818028077, -0.6353086814159455, -0.8139546666899257, -0.6841294295851822, 0.0842969811592513, -0.46930466308227836, -0.9202302348915291, -0.6417934310162638, -0.42654032681478776, -0.5943454588562237, -0.14418051044195732, -0.3023537327247523, -0.4456545986828, -0.6557706569403825, 0.15756773528451523, -0.6715831884644111, -0.7360876591280062},
    {-0.5876895792124519, -0.8694720470551717, -0.7486867640051793, -0.39565000751897345, -0.12006491154349466, -0.6209384488156341, -0.3377217927004141, -0.7709565744890856, -0.3486311384009838, 0.1306338587378043, -0.14642526402696496, 0.15452282648785154, -0.45528788201471393, -0.5137303407236998, -0.7999185610498774, -0.23048952658589986, -0.7908570085874007, -0.631536524552383, -0.5827872717854117, -0.5946121773003059, -0.4707320139580915, -0.3330424333179724, -0.6923326359080669, -0.5465267997276543, -0.8347407538877767, -0.15174649189942147, -0.577903689613723, -0.5841522023880121, -0.7690065679462237, -0.3541203422154016, -0.4746539664998561, -0.567942730298754, -0.6638844228415048, -0.4313474662352007, -0.5997925839885905, -0.7487631710731983, -0.52444618269427, -0.3977496530474947, -0.5522952972058209, -0.7291145148013441, -0.6130554209523387, 0.34939609176250247, -0.4253819870358836, -0.7318144612761894, -0.5732965951895375, -0.5344623069311519, -0.41343719032631643, -0.5030627798868454, -0.8157122603963157, -0.5436394497999325, -0.8736180838874555, 0.22152931372407006, -0.45953319874963594, -0.6966467410628577, -0.7708779147614226, -0.7346346188969748, -0.2959849360466265, -0.016522242917318092, -0.5143750707733767, -0.7192558355579747, -0.6930578650966825, 0.28385115953561757, -0.5973663708604664, -0.8620799190576734},
    {-0.7103176333849119, -0.7486103385676395, -0.8114678497313237, -0.7114827778263478, 0.06420434532397981, -0.505129029491865, -0.3230806916776415, -0.5134784264687867, -0.8570570032895698, -0.06426603693941874, -0.023555429749039836, -0.0898767137239716, -0.33646701315730393, -0.5751873390356022, -0.7768970656761146, -0.16558029187899745, -0.2629693253276251, -0.4824167852857916, -0.5602166742111169, -0.6125460304391396, -0.4727876562863797, -0.39312504285721184, -0.6531042158688748, -0.32269253737422504, -0.4451339595625558, -0.12140777035867817, -0.5256204580680919, -0.4231012734873524, -0.5098857816739587, -0.46652209093072233, -0.4650750935757574, -0.6520598979171747, -0.5985984046253882, -0.5221921119049029, -0.7672854828763788, -0.7632831857020853, -0.6002926863312685, -0.6491177776504505, -0.5577862933841609, -0.8062541081524817, -0.826340478528957, -0.11513849249927063, -0.4698140537995513, -0.43968993253784705, -0.6299348347412126, -0.3501741493631381, -0.3008792408821547, -0.18359525446192337, -0.40510773393976107, -0.5448300968746703, -0.5217616017279335, 0.6060865473186166, -0.47612262368600117, -0.31150441397393713, -0.6849265671452037, -0.6137470795902129, -0.12360518048357413, -0.24465867643619096, -0.41975544766661926, -0.4878703753812483, -0.807251020820888, 0.33495823462756197, -0.5654941385570403, -0.7043142825948456},
    {-0.5641012805301876, -0.6436124400614102, -0.8620805821201989, -0.4194210015566787, -0.27671353584516284, -0.4069841933585615, -0.7152078946692201, -0.5809627086345212, -0.6805844140569558, 0.19029053952851357, -0.11057908463659706, 0.106028581713643, -0.2194991744153158, -0.6117926191324348, -0.5067173010967982, -0.11907167260794768, -0.6673619546300192, -0.6022525112441321, -0.8667262985830497, -0.5229810768268512, -0.3023962162175514, 0.00996740276753682, -0.4483335099832426, -0.5355933482676141, -0.2600883197853184, 0.07765259999305417, -0.5877658139457883, -0.4166457098150104, -0.744297705105536, -0.3353833260721548, -0.43801390452583433, -0.5839458896883697, -0.5569894646443068, -0.5648942940553942, -0.44374752577620696, -0.6231304777669444, -0.3870337792957882, -0.2718675884100325, -0.6069565905852121, -0.601181042565634, -0.47913261818747743, 0.0684027170674853, -0.16838131587814487, -0.41275415524129205, -0.598173193315862, -0.2714289270766733, -0.44110630012023333, -0.43076023038370725, -0.5542570250611051, -0.15107525615403697, -0.3962279437041642, -0.05187671529503258, -0.6737051929290879, -0.627498832573437, -0.5130732771050673, -0.5258799787700885, -0.39918655336660497, -0.12155996016900665, -0.17918679163889287, -0.6422416211912432, -0.8022032032195541, 0.4745517609459435, -0.3167020137386677, -0.6083489098587295},
    {-0.7400535287023632, -0.8162881600819076, -0.45783499336952393, -0.36558721765330626, -0.2175036622566457, -0.5237771900872195, -0.18355646070125484, -0.15612016896814612, -0.5606400396047108, 0.18539967285924044, 0.17288981850505386, 0.11587901187496263, 0.12743339216040514, -0.5814440143013698, -0.44486857273882074, -0.24362659306008602, -0.3342181739988561, -0.27170818261565294, -0.7340980598133512, -0.2509188430465989, -0.2822686293271329, 0.07473572041812301, -0.4502654558587724, -0.5452951579401571, -0.3443634797088487, 0.19440944247662054, -0.6745088516630996, -0.3773999636819094, -0.5738144836947044, -0.39120598670876755, -0.5130593009788166, -0.4539208223755007, -0.42387726112208346, -0.09453198525664194, -0.7611491455905619, -0.2169423130254183, -0.3201598147492996, 0.008471318668281085, -0.4818304778049465, -0.732855218693673, -0.8177751736588547, 0.144512204894157, -0.7935151306638383, -0.3979387644410866, -0.5998300141526304, -0.26350897594532, -0.41872603745494263, -0.2924108059728741, -0.21504219760720109, -0.18673786204665577, -0.10406503834388633, 0.653651044175254, -0.41957908619386186, -0.408697152001443, -0.9640097180073651, -0.3688966699798806, -0.2764913439685047, -0.10262216037157748, -0.38186483000507143, -0.4484137865006569, -0.5789910028042878, 0.34548191173789994, -0.6204718535873598, -0.5996868471078621},
    {-1.1106848754984175, -0.653158996148219, -0.6132187319695237, -0.3496817124602164, 0.07137049434350216, -0.7573291651676306, -0.29964377744391113, -0.7294586597820715, -0.8092712660781964, -0.12131629779006065, 0.08817233617847821, -0.19170529628345892, -0.5568870158668993, -0.4778339698017569, -0.43415833095133666, 0.04166842870479515, -0.14724342472522278, -0.3979407015832851, -0.3643872041606253, -0.4045706509255861, -0.6081695683898419, 0.19226267930998886, -0.5815593386199521, -0.08345253236832519, -0.46408946062605105, 0.15499146256643315, -0.6454405876152397, -0.30975395446217513, -0.2181925250412036, -0.23969821364363889, -0.8380847729031781, -0.3559386380596021, -0.6168508215289322, -0.31518525625483806, -0.9094841893011305, -0.8544640873509327, -0.5009041675471216, -0.32384660968029977, -0.41545791612879024, -0.5763036466758386, -0.5093528870088232, 0.0073296984611828705, -0.7364819173654331, -0.2234903575201759, -0.8670589566280963, -0.3061857828511378, -0.19681283587565154, -0.19248494378105976, -0.25314666650447154, -0.5020089707713615, -0.20802746820190954, 0.10688046980830726, -0.37489380284603324, -0.7030481968051708, -0.40894342817284224, -0.5480751479480419, -0.2593796861124475, -0.03577527421952311, -0.5449736477345913, -0.7020358360961838, -0.6598400066047351, 0.2618654352133462, -0.36391308136154327, -0.5280627257298578},
    {-0.5957158707841657, -0.5718177317788585, -0.8517762134777069, -0.36837087095800203, 0.13365693870924356, -0.687035135246742, -0.3151718226416991, -0.7861879420788317, -0.7731619673666419, 0.07415939806980258, -0.2242222915623139, 0.00908692952231391, -0.5407221487947212, -0.677994641882508, -0.5601059658981408, -0.23387019382847826, -0.6369345421219089, -0.35044234558874676, -0.3526728066515264, -0.4855528819590456, -0.7027100469367454, -0.35834491677581726, -0.8056850366080582, -0.38817788096906075, -0.15286225728496294, -0.2971284697209767, -0.8047409918712704, -0.6788116114249937, -0.6226355850804334, -0.17811125793777507, -0.5370996690862206, -0.8156881965770518, -0.7717057115014128, -0.1708156412873155, -0.7537311816367802, -0.79605599952101, -0.6573620619567763, -0.31010007043116683, -0.6708178641760735, -0.48861620663586663, -0.5473002088809209, 0.35608976073026966, -0.4750633877164971, -0.6385560385558868, -0.9998763707235834, -0.3543108348680421, -0.3098596432520468, -0.28090607755100283, -0.40255096521555883, -0.5388005861812967, -0.11896533063369807, 0.19831902032298215, -0.21245852740132704, -0.8682525167710022, -0.6149548148730274, -0.45324921015797837, -0.4581972286406443, -0.15126809995037932, -0.45274129533768287, -0.5028904965094066, -0.6783068148105692, 0.40514363628617095, -0.5591775349384902, -1.0801410114534113},
    {-0.38996132427943486, -0.7906013359731664, -0.6918224421536738, -0.4150544703469645, -0.17737219941888072, -0.4581491539204769, -0.26580896680818283, -0.7044501489481552, -0.6910924842398167, 0.15979473896441806, 0.040479980676658894, -0.08956366604792321, -0.19809186892759448, -0.7089871892656299, -0.5767067632067396, -0.032961903381682735, -0.4651982101952819, -0.567548229591426, -0.8047867382481166, -0.339098094027161, -0.8008898830154494, -0.1067221389359225, -0.5112229259302511, -0.5872196988801914, -0.6189945345765259, -0.3494635260853448, -0.5120845837762052, -0.7641491162827111, -0.7139265880456801, -0.5365265049851093, -0.7232285482678038, -0.5778669948853536, -0.7161354047621641, -0.13016434521610284, -0.7018591319927595, -0.6503886478695073, -0.7312774811365343, -0.7756030723875962, -0.6116672857097878, -0.4098916329009266, -0.4383323623133882, 0.0843883554705597, -0.5796500504438276, -0.7429664660446829, -0.7392523118017237, -0.5207214482469543, -0.2950176785515062, -0.5173523125057548, -0.471540644935846, -0.3541032064239698, -0.2764851117199563, 0.4135021993823583, -0.2056763128979693, -0.9971631655106977, -0.5042799036983947, -0.506126677579074, -0.578086513281952, -0.1721439706590328, -0.3709675218990557, -0.5757449016878712, -0.7807118671521311, 0.07320040124716218, -0.37244685528464005, -0.8368308746379001},
    {-0.7484507590861396, -0.7022164512089153, -0.7103859156405958, -0.5411075368291708, -0.12334532380426175, -0.9087725586476627, -0.10625323643570611, -0.7459143283847223, -0.4095179307806637, 0.28689752225736087, -0.05668643737053094, 0.16989175293333736, -0.18600412396171598, -0.319526999288958, -0.5145766957683982, -0.4140466667372842, -0.5402480266047541, -0.5370789037487506, -0.5045715456115685, -0.35361694924580833, -0.46058223437302276, -0.07468273166877541, -0.4317876358138428, -0.5658376354229355, -0.6148375528219351, 0.4491326443127772, -0.6450180621587264, -0.6486167759610191, -0.7274647084211593, -0.4182394861010292, -0.7429898008527822, -0.513568872052085, -0.6401096084849773, 0.11258009331717544, -0.6857272057646312, -0.4346759250604968, -0.5523676292525117, -0.8182384474937796, -0.576058334816542, -0.39970259996568047, -0.5960363451359981, 0.46564652894349273, -0.5514902482123281, -0.5537221813492331, -0.5479396876161522, -0.6270950662139065, -0.6298048592904056, -0.6897715143550375, -0.3166656759931772, -0.6319424300573465, -0.3267707888991303, 0.2614457497140923, -0.2122932245557382, -0.6815745004229795, -0.5340727840479845, -0.5204032375311438, -0.38260284577970605, -0.01506929476376286, -0.2961624848928462, -0.43987032563266815, -0.5510667726488033, 0.27464601451955445, -0.4811217744251975, -0.7686613432626481},
    {-0.7470898828902853, -0.4295658332016342, -0.4467197126660501, -0.24440488746314085, 0.38093124589255467, -0.2273967801117129, 0.16985038821882587, -0.7228939781704864, -0.5321938602102165, 0.039228048348377384, -0.21394350940280896, -0.12225778071199606, -0.29083955289610625, -0.3847223633639515, -0.022029512767408364, 0.26811990455561674, -0.11654634793834541, -0.5732119012698942, -0.4606549918973836, -0.05033302476205119, -0.09821696227909021, -0.24928344581184073, -0.3041556158228597, -0.13185969875603076, -0.5597662488809076, 0.10639290676599714, 0.052790386871249734, -0.31597847290937303, -0.5054754833314462, 0.04725909125786827, -0.343962029937549, -0.84860656161252, -0.8128709515486535, -0.5585468839332858, -0.6951454174104332, -0.5948940206792863, -0.631246999763548, -0.343824776588846, -0.27376046473397786, -0.7114079253358495, -0.4844898585725706, 0.2663060989236947, -0.18584243330772243, -0.06960864933441556, -0.7003163771367246, -0.29541881145101373, -0.09496085612979076, -0.1508409508049664, -0.18432212339313936, -0.4090204236908006, 0.09492011363264927, 0.1887938680197532, -0.03315704803427403, -0.5639169066145253, -0.5955622834582381, -0.2744941781235944, 0.22531761706123368, 0.07306213133920138, -0.5972629479285033, -0.4926967035193263, -0.6506436465298407, 0.6797988805527272, -0.2974572436587726, -0.6561778949618607},
    {-0.7918793792716564, -0.4397577883810051, -0.5126288939889343, -0.05065033120106837, 0.39099125708292043, -0.5333702540839141, -0.19872799255211665, -0.8007579051836493, -0.32201879353370755, -0.12306627759560616, -0.4891144446232577, -0.4987171819989295, -0.520000328091389, -0.7705652135766419, -0.5640729086788873, 0.09167138332114212, -0.5640059605202554, -0.7752889340742278, -0.7708874039787925, -0.3831567998138114, -0.5256704482798773, -0.3969512478019186, -0.4159251475099162, -0.413825712539017, -0.6785776181008121, -0.3320086609873123, -0.305828187928522, -0.6469898672025193, -0.5938899528765695, -0.0033813336337288405, -0.33234228266308335, -0.7309992423008939, -0.6876653268952, -0.6727592731581338, -1.1056966139357574, -0.876671549639922, -0.6773939708522166, -0.4461842394657758, -0.33198110868522457, -0.8258771350857511, -0.49537118579510614, -0.046118429420871854, -0.6295264285470134, -0.6332955048627256, -0.5723454767403011, -0.47341833724663634, -0.20065968698821848, -0.34354275595739137, -0.6311907824764589, -0.7230574185988485, -0.0026620489320824, 0.08569667823993887, 0.017539820139780435, -0.3792320678031298, -0.6390732339386098, -0.6346489744945064, 0.1987881994504696, -0.00609373480397142, -0.36958308862600886, -0.8064711471207089, -0.759577661030422, 0.3440422969844859, -0.5188527846923543, -0.7963577534045683},
    {-0.7972575331151306, -0.6320661045278956, -0.41634193536849917, -0.7133977064867367, -0.07030615994796652, -0.6782416981331889, -0.14688135374406594, -0.6387200494790275, -0.9525867035443125, 0.27766654387929046, -0.1612301481579196, -0.1715405725768585, -0.43269776136047633, -0.8756040261159183, -0.23472750615254898, -0.36853262848449825, -0.5158053025980845, -0.5610606049869895, -0.9015112428419076, -0.2835081576169483, -0.7011920598994315, -0.33736141823393206, -0.44867959627984155, -0.457038429238542, -0.5908113777963838, -0.3810819640694677, -0.29834764320769225, -0.4996582219065474, -0.7209414844275612, -0.3838702734088157, -0.6744663471695432, -0.7545685669276444, -0.6986228384202393, -0.4739045323640405, -0.695764657033525, -0.715972379324484, -0.5748978970425715, -0.498174738124796, -0.6731837939774745, -0.6119291575153399, -0.805458145409628, -0.15125002390557832, -0.6602452048462657, -0.5355309523270568, -0.9756957967911005, -0.5127869929607823, -0.41711120763991955, -0.34293403741656475, -0.27523776574924547, -0.7770740448342057, -0.12498858377596377, 0.10056646762802746, -0.19045583612826225, -0.8422453139635729, -0.6924729374863331, -0.6039133381720235, -0.053811936341828945, -0.4140875190233754, -0.662140231130703, -0.5619220013162038, -0.6062649700750903, 0.34490454485581046, -0.660648440789456, -0.8066310730391462},
    {-0.6600032417793797, -0.49035132631162864, -0.55503726705628, -0.09776728069995934, 0.38322585842959045, -0.41816475593699143, 0.2582080423485257, -0.6119146622790687, -0.5329349943895593, -0.021922833514345784, 0.021335650076890082, -0.14451316561632047, -0.6755846842571651, -0.5030056719027597, -0.10159906747377122, -0.2514319995107718, -0.11300276674670609, -0.5215778392603472, -0.13316911764583228, -0.10681049799431551, -0.8049680007292737, -0.4041183843639393, -0.42315512862146587, -0.34912763404807257, -0.6160653796396942, -0.1684775919583269, -0.21488251158369215, -0.544686950236365, -0.42443337879051973, -0.07319050098252061, -0.3033246194147765, -0.5934593719423834, -0.5840321563991681, -0.5748479519904157, -0.8707059724421, -0.8454499895015997, -0.523677614664211, -0.5172006011787119, -0.3721911978323361, -0.8520208146348017, -0.7200753659280709, -0.07067487518553466, -0.29256046775506317, -0.3231213784666363, -0.9714395057156613, -0.12516849175879402, 0.07014612322891534, -0.060971687029014364, 0.06226994871786411, -0.43279532112773, -0.08707072719591272, 0.3060761578403893, -0.10690471507337791, -0.599467440353063, -0.6423654441860135, -0.24026779499080533, 0.011629100106392648, 0.3143971637273229, -0.5501367916835543, -0.5052986558402727, -0.9132766816914897, 0.5204129690370141, -0.45093236958037847, -0.7224498951298226},
    {-0.9357510213680228, -0.7488524198851718, -0.5789752658612486, -0.14722768789711704, 0.23330948911131213, -0.3113018639167513, 0.02295636412541122, -0.7641422504051276, -0.6394143921944071, 0.3653627961636567, 0.009329481939128845, -0.3917926028340698, -0.6621702206727811, -0.6220578411717358, -0.27765236420635847, 0.10602912953841129, -0.304672364395674, -0.3367636181015889, -0.5869324736054717, -0.3567004156207579, -0.3659526346317385, -0.34062669535655515, -0.547365862777035, -0.372796307693857, -0.22878350509262674, 0.08807073944743961, -0.44517577726083807, -0.4956311838816988, -0.485757007435188, -0.10489109554401072, -0.44981143669884205, -0.6426938405299745, -0.7402984561831962, -0.7470858938499569, -0.9096989353501355, -0.7967594020375012, -0.5654615723281489, -0.7804018445240216, -0.5091394006163655, -0.6411082035165601, -0.5328270083156887, 0.3035490088358658, -0.38350533354001515, -0.08538530485719037, -0.8505080724788229, -0.35345389658864745, -0.3380151467831948, -0.4353752696892424, -0.0035394051437720605, -0.45986023712714474, -0.15740930645029652, 0.42451742276661897, -0.2209861562820682, -0.49593897571532203, -0.5825105024405427, -0.42166476091607397, 0.043560213877840225, -0.13458998045398504, -0.5633480682720698, -0.3940165475537906, -0.893955133048853, 0.15938891763820562, -0.1818026859182724, -0.6508379443376847},
    {-0.5379937106403099, -0.6587262571335906, -0.5219923195052237, -0.5855315064244776, 0.05580317597932397, -0.5610256633573221, -0.08425530016237327, -0.616676315400324, -0.5900344538628887, 0.24304485943184032, 0.31627908790229464, -0.026993225044801738, -0.5071909944533876, -0.5954965037914498, -0.3413063951429314, -0.3079981155948027, -0.5733680104760692, -0.6079460178799597, -0.25504180281583017, -0.3220987355364421, -0.789629343749326, -0.05408204438979653, -0.600807444766662, -0.6377343660490515, -0.8095246437567488, -0.06371986206546854, -0.5332579053480179, -0.43168231238616805, -0.5178195823214702, -0.5566659626305486, -0.5660206625416525, -0.4678202517681263, -0.4823529092729032, -0.2786614302126658, -0.6956138191688858, -0.9030133844117482, -0.46582033812893897, -0.6143476987302889, -0.4292086841366911, -0.6981254772092235, -0.8050447613726455, 0.14146646219928788, -0.5609373142378442, -0.4531102004109551, -0.891686290847758, -0.5928612580578604, -0.3154614059207399, -0.21595353128725442, -0.345238170728163, -0.5634697182066918, -0.11946331806803796, 0.32903880390537876, -0.16516304463694734, -0.4886314418463074, -0.6283907915856211, -0.5249283339344327, -0.1330478547722531, -0.1589825344845911, -0.6524768336054458, -0.49694765213285547, -0.8650938436062796, 0.22438331543859286, -0.8284627270423321, -0.849903796571454},
    {-0.8619572351638388, -0.6215171617099825, -0.8529704864674388, -0.3612796930351991, 0.4029718473686981, -0.6340952320473435, -0.048877594343890086, -0.6545434051595603, -0.6358284454577002, 0.06303752215016864, -0.14561599733709177, -0.03264213755579683, -0.4515328985592057, -0.6159978614100357, -0.20028914449623622, -0.04595065181002054, -0.3397067865080745, -0.6664390409425025, -0.5697528644960712, -0.21675907387830554, -0.49548887002554476, -0.4871330221191402, -0.319693969603141, -0.5822757548196064, -0.782167505723732, -0.030573869505078975, -0.3659698893776614, -0.4816306129516724, -0.5439221674926134, -0.13154324114752922, -0.5981964878704635, -0.7069787279646392, -0.5812323391703305, -0.6808341881450906, -1.025708736450592, -0.7420262423115608, -0.7849791101142062, -0.5842798947375814, -0.5188669560657057, -0.7210523789087755, -0.6804374469013764, 0.0602541056647628, -0.7063601927767685, -0.25416275975933306, -0.6951303631177754, -0.5391054881709887, -0.25479421754635334, -0.11486022489526702, -0.45816465903482906, -0.502506922137043, -0.20470920701191306, 0.3864325174579253, -0.2783640604668808, -0.6411184074829551, -0.9879116907364169, -0.11060096138391108, -0.14428402144884425, -0.10075054140346607, -0.6968671583776372, -0.4667573369161299, -0.9715636048016668, 0.3605650128225701, -0.7522981389234006, -0.8607627034530012},
    {-0.8951243657378216, -0.2522278475585998, -0.3329713480179819, -0.21555188018603938, 0.10505738942588586, -0.3256875100576415, 0.07656650292002622, -0.453217046868304, -0.3185479912926777, 0.36925704018826006, 0.052313406340166305, 0.2191669457251736, -0.13690477700657033, -0.23313118586358858, -0.01872764481134954, 0.05643292758303847, -0.11952488469316656, -0.3086177183306475, -0.3726481809072647, -0.11577878399198686, -0.5212182653500982, 0.3001529306187987, -0.3447974236029383, -0.41102490846062073, -0.2903040759097107, 0.13692121491059328, -0.239404896815109, -0.4963122502596007, -0.30302712489627825, -0.027897082794673633, -0.49825525085032196, -0.4738321974144514, -0.7142380146901225, -0.5022789060620902, -0.7545908134598904, -0.7876917643080086, -0.5989963696707823, -0.24022955473093463, -0.7051664381084618, -0.6183524882149702, -0.7664963807273262, 0.36436707850311895, -0.6925541505564052, -0.19811285127025022, -0.40117959510794193, -0.20831636310127297, -0.14457346937897103, -0.07869832335389125, -0.18277980811570554, -0.4186231563894351, -0.4770607507175191, 0.2988420163692225, -0.12742576119951957, -0.2208966775581175, -0.525149735646297, -0.36321040098141955, 0.12598330996811982, 0.20455877156139432, -0.7954256450849083, -0.4085319474826826, -0.6607126850619791, 0.3961267964019596, -0.5595391001110677, -0.6076804994753333},
    {-0.05665871315808273, -0.29514973064107786, -0.232674515116216, -0.060009328572853605, -0.23050860744151977, 0.5395852038833162, 0.4045629745460748, -0.29920750646388966, -0.3255654201811115, -0.3395069768632136, -0.07705279476873081, -0.2712023187985565, 0.4098499653437196, 0.04896936261625895, 0.027803063954329726, 0.02295902047830754, 0.47640079196043134, -0.0324044289148846, 0.38804000576482045, 0.48120334068732956, -0.6235359802062812, 0.31738817335419783, 0.019769324460476828, 0.06903358075458627, 0.33968694089612506, 0.2809962026561949, 0.18943039271105092, 0.5047633733628787, 0.42226134468821364, 0.03432838955200482, -0.1996916713530626, 0.025957375325635298, 0.5128383571902494, -0.4333275141550797, -0.5758967701093833, 0.3139287234601807, -0.5514875043978481, 0.4977721504142319, 0.3045672979697055, -0.40904525020160526, 0.08391011856029575, 0.42575580483400155, -0.24978316980761678, 0.08453459214244852, 0.07919641850211433, 0.22911280291772843, 0.10298153559305526, -0.34877356612357857, 0.001494834736472976, 0.018596837085388635, 0.48740679121019964, 0.1744001790817257, 0.37838072256972616, -0.14269953501225682, -0.24840683032270852, -0.3331255720330942, 0.09342405332454556, -0.5704974401964562, 0.30579440869586305, -0.25346418761145645, -0.3325264602752428, 0.06836119442340285, -0.07711862202587051, -0.06808529611804534},
    {-0.41764544603789217, 0.31895877415787594, 0.08362449598521028, -0.04200678019117211, -0.14205009765457755, 0.550189196519211, 0.4855276940235649, -0.3384115224334797, -0.4267551836801385, -0.18926259754796454, -0.7587422633774501, -0.302337231040195, 0.5813708136307607, 0.6191444273412173, 0.1906708997376946, 0.1840139405490692, 0.46491427342372676, 0.4410774211492099, -0.009988120355235984, 0.5870904120546171, 0.14319107696660083, 0.4262796610156282, 0.3607205104448186, 0.22620021102351906, 0.41273663953744605, 0.4187411338690783, -0.006130657913610729, 0.33376918162949537, 0.37232706573996455, 0.2687454813695314, -0.13949267546995456, 0.05914990072021491, 0.38250914482956566, -0.40650090502075964, -0.5907642099741143, 0.2153710924535345, -0.5501971321761907, 0.27042705165038544, 0.05415670309160594, 0.048591774649722336, 0.03331373937084067, 0.5494154910638356, -0.07180747298972957, 0.28732552758166074, 0.3001798380663718, 0.15020321745009663, -0.032939073003591945, -0.6981952197967249, 0.22950319394030744, 0.14055694911614774, 0.4099158083815898, 0.6653039198877316, 0.8112328858021364, -0.17459211856310528, 0.014289406277304906, -0.7911180026703798, 0.029218129906614588, -0.7420420791438289, 0.195394735132936, -0.5697004418877303, -0.35962758451332844, 0.39343916493158504, 0.1739822477679447, 0.18692486420455623},
    {-0.6801348022763432, 0.35042200059148537, -0.26172546907130795, 0.06990294962498958, 0.13839158989901415, 0.325299273189424, 0.5924004250932645, -0.3174026659229215, -0.5578239520908452, -0.15054268463658266, -0.3914644659206981, -0.43511004791905467, 0.7857918996252146, 0.30417430614796254, 0.041678935276961634, 0.4590868078115086, 0.42455480511935456, 0.521590265344043, 0.21661969756074428, 0.5395158610770692, -0.5857411700730482, 0.3891845100609274, 0.7563140748783449, 0.10791879875289828, 0.5281507479231969, 0.4084691490262838, 0.1336270037033646, 0.5040424825551412, 0.5849056463375634, 0.3603585712406262, 0.5131333504131761, -0.33933370052726186, 0.36896755443640483, -0.5509669839014263, -0.5458236104391475, 0.23823740391893639, -0.7702201852460895, 0.10492074535833303, -0.09855675578021628, -0.38825263849826325, 0.4365867727534817, 0.5999062951581478, 0.23023236368404545, 0.6505606884694002, -0.17642400485496584, 0.025589591636299987, 0.11431397801250787, -0.8442769296866897, 0.8098330675670323, 0.34734440114967513, 0.4909734892793224, 0.8983534582085115, 0.5287635236789096, 0.09232323687226313, -0.4212145225926584, -0.8214365510454182, -0.5083401233818952, -0.643799114736624, 0.5912210526544004, -0.5100295629802811, -0.43866897320382464, 0.25909965604094104, 0.24797028958198802, 0.03329421455597393},
    {-0.39532381729895194, 0.15374555760688402, -0.3886577588357429, -0.0725275904921478, 0.15452360359169742, 0.48901035706284773, 0.6901966280300994, -0.06330995914137522, -0.31333306206258443, 0.0794031062032001, -0.6160689416291245, -0.3247971218868724, 0.42205830891488844, 0.5219096971511101, 0.26326415557648064, 0.28304611506830185, 0.5375282713834002, 0.5656340108760692, 0.19932463756356877, 0.4321058471852289, -0.7838694424001643, 0.5095631835056712, 0.3193557821106523, 0.20919997615842195, 0.5618765495738146, 0.6066978985030448, 0.21247822839761274, 0.4783819635260689, 0.4934176886586037, 0.4920596382430213, 0.15587639127386282, 0.22063531956586233, 0.5951966865884, -0.6709060225158698, -0.3548385994890327, 0.15418991028030676, -0.7144963311127588, 0.017048710215251044, 0.16362622328551424, -0.6280474530580981, -0.007213213716459261, 0.5649843148000281, 0.3665361236708826, 0.4764562469861798, 0.049367450794810884, 0.32127843620839197, -0.2579939146009431, -0.7456744726730535, 0.3076524346835883, 0.599589236659359, 0.20550137835055352, 0.6245690244157475, 0.8316964467365668, 0.33392388611221474, -0.26070934528575296, -0.8075026234847462, -0.2778329580739161, -0.7358161308813251, 0.1998831098696711, -0.4946687463319766, -0.2673562803277042, 0.6200626068046333, 0.2396298663906819, -0.18065116340263473},
    {-0.6146502603227894, 0.42825058171667163, -0.12986393811437005, -0.37118989399509383, -0.024617771014459455, 0.2206890570658552, 0.47143161697053587, -0.24431756844952895, -0.536527589239942, 0.20168246019205874, -0.1289269196563197, -0.5331155338217388, 0.441185903060301, 0.017561322198616548, 0.02452956777581736, 0.10873002152023922, 0.4610085881846565, 0.7395136356688194, 0.3487110641660183, 0.6725585913128589, -0.6060835458837243, 0.7868803157722317, 0.5143177695264796, -0.06746745333342502, 0.5221701160767417, 0.22248376004576656, 0.21474230189747168, 0.5330609682408216, 0.5053904279812791, 0.18065129542801953, 0.14417488760296643, 0.019196668561935977, 0.23126916096482614, -0.17249516919778185, -0.40321011197097567, 0.5792408564197558, -0.5969620826301782, -0.2794756310178003, 0.08445960877863543, -0.04046236907988959, 0.5722531652969848, 0.5723626703769102, 0.297980428912946, 0.5705804518544597, 0.22490829644705995, 0.039256526037167436, -0.5444951972905598, -0.4636322203484109, 0.5052395504348234, 0.3760444806492471, 0.021664481767451775, 0.6081516149825911, 0.7043715212814651, 0.2917784196443522, -0.48803455588277495, -0.741188126008416, -0.19607852224891645, -0.5306870339024173, 0.28868987999852747, -0.5002531450859332, -0.31031857566336984, 0.3607709141069639, 0.6764359532493782, 0.13609920070294948},
    {-0.48561060150389973, 0.24721775513171837, -0.2744486787651948, 0.036913480030440184, 0.18344917320925916, 0.4353968190139324, 0.5392968166748047, -0.30804347535274534, -0.6503621414572008, 0.20093882684835754, 0.056075615694550406, -0.40128107903344573, 0.6495392472918726, 0.31055847049757446, 0.05644579609424767, 0.05527979853789636, 0.6143871078413957, 0.5092653760240753, 0.25370805616302333, 0.4889129174181058, -0.7448161293056736, 0.7387953849653787, 0.5324945395878126, 0.20694718993240505, 0.6179155482168224, 0.38105706455949334, 0.25146363047211284, 0.7703441678610277, 0.3583818534907479, 0.3892783135008024, 0.19832046286363084, -0.4684371222609715, 0.4012638437287414, -0.673730073895491, -0.6269249774450496, 0.1955759225495099, -0.6036876147811943, 0.04035019124790918, 0.12871142441623695, -0.09033696761677848, 0.6954862806493923, 0.5763200012293123, 0.504290917257245, 0.5152613677524949, -0.16619828525049002, 0.3895253380240084, -0.34669093460701916, -0.6045086197689277, 0.44264332170733434, 0.5824418717914539, 0.5105619260084739, 0.7020207776569996, 0.862339070655762, 0.1766667460383318, -0.11896693940953246, -0.9694733659534271, 0.006279051808211572, -0.512630525565387, 0.19899185990121754, -0.7704509619704849, -0.27607149948148646, 0.6417761114869869, 0.3647142872734032, 0.07666224194693733},
    {-0.7140092967455907, 0.088620592690416, -0.3012646717050016, -0.20168308080848857, 0.000922511377480978, 0.0280466245852817, 0.5423481356674269, -0.6474683551531278, -0.6563019573804454, 0.00860724156542724, -0.5619668068942179, -0.5241136181352719, 0.420905460145469, 0.04609530609024016, 0.26921097191394516, 0.021796103276281526, 0.698749812522487, 0.5640114947962045, 0.306077827562404, 0.2227565826180112, -0.6183935948392734, 0.6342145882376733, 0.17421300180332785, 0.2872444233282473, 0.7767955423535597, 0.4632366720174301, 0.01720732117702499, 0.6021224313621579, 0.4885745175537016, -0.01601086138171273, -0.25230059046844655, -0.38720068549137854, 0.33133926898046256, -1.002541931423877, -0.3793117385876382, 0.308976831261148, -0.6640645292357302, -0.1967891486959995, -0.049935321560593396, -0.32598347548282697, 0.3248380379257801, 0.44066855724978476, 0.5255986429557461, 0.2694782327479971, -0.09244895502018466, -0.1571608212208241, -0.16990026469791975, -0.5706741968871013, 0.1602923326349907, 0.334326464719852, 0.3536249655117471, 0.4492933854167631, 0.7437305857780605, 0.020054556962299047, -0.3008716960575836, -0.5442992653768381, -0.07739867372937119, -0.4232282342260246, 0.010503546720796455, -0.8662874800861575, -0.500597793652767, 0.4670710187464704, 0.19228044936567384, -0.17372457212370962},
    {-0.41008760286412915, 0.2663051419401576, -0.006529256451562558, -0.0900561893341791, -0.3297113159734811, 0.45231763612050224, 0.713658311609996, -0.4245299309895129, -0.6783274562460178, -0.3095784455753093, -0.6359497937680718, -0.5152529658843238, 0.2824641033573032, 0.3274746320207713, 0.22839722224945158, 0.1847019929908247, 0.4589866809716486, 0.49306106863648624, 0.16819971620606294, 0.28357549272543064, -0.8800146739481544, 0.48922510669123936, 0.43970487601125186, 0.2902870729622846, 0.5652662089536608, 0.3182250615000468, 0.3304576440792201, 0.4608796711498722, 0.6356891199545757, 0.07601695478623474, 0.3793033283509365, -0.43370457060825923, 0.5725883496423063, -0.928226022496517, -0.7255937019820714, 0.6293880758874233, -0.6822117805631445, -0.10974565407997332, 0.365241659097155, -0.31374734040887586, 0.44030160452224437, 0.7106192712404258, 0.17433353750037825, 0.431064217196941, -0.41740771885157524, 0.21583001677783653, -0.11265011658209534, -0.3508460182579917, 0.5413387008107934, 0.49498893956497186, 0.5912669832171127, 0.6774955113806505, 0.4302467834382008, 0.6441414658927308, -0.6430734114140818, -0.5008414193521801, 0.17045130592399355, -0.4717409115749848, 0.39631512585853124, -0.6078121326845458, -0.40356107513762784, 0.42543098325529144, 0.4761151269625823, -0.4578247520237772},
    {-0.8801877443279801, 0.2801691412082631, -0.10792982207112296, -0.15802737163750832, -0.08904795121411743, 0.4512894834615661, 0.7469194584493603, -0.5035088743890551, -0.9000834177529008, -0.16829072307399337, -0.30745768109588917, -0.5546544931136413, 0.5606235814483462, 0.13746150543371208, 0.19136211385823026, 0.1252458173355798, 0.4741320693816296, 0.42551092479609337, 0.3146753010456698, 0.6050483488608863, -0.630693038117236, 0.1712367113614001, 0.6085766699309941, 0.5953541691884814, 0.5741571595637722, 0.4540656605279652, 0.4144701392228907, 0.5631239886836178, 0.6577167057003344, 0.1529054959613302, 0.17349293868369547, -0.5911353919722165, 0.6036390158855329, -0.7259095500034962, -0.5496463493570107, 0.16670414177849882, -0.5568557479997234, 0.526433467868273, 0.13178983171023606, -0.41793041470542447, 0.6043473030106752, 0.3829423238066692, 0.2941242053185521, 0.3839087499506993, -0.24428373371792195, 0.14872160740500026, -0.18396185389681624, -0.8218476201371671, 0.5402519052393531, 0.35009084690246195, 0.5674752862885317, 0.2835464662609962, 0.6033656093910014, 0.3750070844193058, -0.5190146677065701, -0.7280913062063264, 0.2998397828159667, -0.7228154474210204, 0.33236325933592026, -0.6196819245249457, -0.6848050456351162, 0.5052421768204695, 0.4164664888290513, -0.2818516743223079},
    {-0.5870006038320211, 0.41921959432662714, -0.37266078491371896, -0.02078992234547634, 0.18314672569959026, 0.12361013361752009, 0.5515874165577537, -0.5739792535937138, -0.7131841217980833, -0.08034075229124195, -0.29389272937123334, -0.4936622253736494, 0.4747713899005122, 0.1276010673085418, 0.06425840500621688, 0.1623193826741916, 0.6438331105290653, 0.6051692460581348, 0.2971560874572386, 0.8404952712476406, -0.5811515693480991, 0.4752408354935445, 0.6635302116196394, 0.5126085640940354, 0.5933198478989684, 0.412483822322429, 0.2493040813149318, 0.46421691724565, 0.5590093822541811, 0.42152413036574643, 0.224614219514145, -0.4463178105914734, 0.5400719795240154, -0.6624755136019852, -0.2826663851930271, 0.22071918367313778, -0.5789661229081515, 0.1506067914323816, 0.37186839644800207, -0.2703969942858639, 0.3891887732414532, 0.536957114400472, 0.3726579280034963, 0.37221974068371627, -0.07196319280775754, 0.4571607797632871, -0.18672625816510097, -0.5506298230878716, 0.7813259851261691, 0.17649302380714188, 0.610078525100957, 0.9018008460539879, 0.6546746309962929, 0.12469036026923129, -0.7183992742770239, -0.8489241568470889, 0.11538072347319885, -0.6005865694867972, 0.3151263396145345, -0.8355103310090489, -0.48627086595583335, 0.6878134216980246, 0.6951305236019787, -0.25827337144331103},
    {-0.7616729935051377, 0.005167655214005964, -0.2223036950726134, -0.13314728737128648, 0.3179661982715435, 0.44407400829018656, 0.47049295131652946, -0.44566406231046063, -0.33909178742411494, -0.14204173597893638, -0.5180237418115591, -0.5408063024377133, 0.7724322161044772, 0.3132132977255024, 0.000521636943508218, 0.3844798057972087, 0.5143558297148224, 0.5557341042901125, 0.2024435972455446, 0.6694320735714361, -0.8494176737456846, 0.5689661897906355, 0.8966139673633631, 0.3305239963937406, 0.46223673905959817, 0.3447884248422444, 0.4093641465512177, 0.5172006760953515, 0.654373432735783, -0.004946293251311231, 0.267516512274725, -0.602043596360596, 0.3791950481034435, -0.31043830768912567, -0.09998784377199926, 0.007688999378511997, -0.6176200609258702, 0.07857186970442837, 0.1211026170228959, -0.3225064500173212, 0.687979860251293, 0.5739737154124183, 0.03612788173537933, 0.4175869590639787, -0.13091840286527223, 0.2551654332271059, -0.24007974917284125, -0.519537098936061, 0.31154757405754907, 0.03403108364783324, 0.15234464054151386, 0.801749953696776, 0.6609033971442605, 0.01748273317653724, -0.48367603946702564, -0.5802521879808367, -0.19736767857940554, -1.1514711512056521, 0.4095445045743484, -0.2824871266872492, -0.457530483071343, 0.6162225916240825, 0.6948490451755006, -0.11918414107540859},
    {-0.7033462533276947, 0.01821500104574787, -0.4327773447237606, 0.15165895725148074, 0.0663510894131005, 0.719695869086331, 0.726373044288254, -0.5942746876358329, -0.74839593358123, -0.5436846858012819, -0.6619646752893531, -0.5844858776256143, 0.6296226311946921, 0.24646128126406708, 0.4334430292141606, 0.1770065208412587, 0.7965173250730173, 0.6152609003438045, 0.38727728416474194, 0.8108301610857854, -0.6752148929457779, 0.48034292209057206, 0.6499793676487096, 0.24255788826635208, 0.45447470285801805, 0.67324603568174, 0.42686544954065614, 0.5416436679961772, 0.3893210856450798, 0.27220445696057544, 0.272620801098354, -0.25211671166549937, 0.33041470573282816, -0.7391622713416842, -0.09607123578689711, 0.3267873157541517, -0.7515917763719361, -0.32142235012987547, -0.003354433870684011, -0.24400888467549192, 0.802600779641692, 0.35069521098676065, 0.46649549723618794, 0.4768549048772801, -0.020271330127346717, 0.6460518126855501, -0.2563238764887667, -0.8266989423054558, 0.5163692963430739, 0.18765606328763387, 0.9177011180947081, 0.6521001536832066, 0.5799664942247773, 0.10983061910315793, -0.7178954090345815, -0.7464812110874808, -0.10406654924649773, -0.7565996184291107, 0.3427027695078747, -0.721694205585942, -0.7092918112222787, 0.5213990104156799, 0.32668834893550786, -0.2329852344904184},
    {-0.8211579490730201, -0.2793063184091824, -0.13958652198305002, 0.009101435992970754, 0.05487578941481454, 0.6631131734062319, 0.9236534480205976, -0.34956971850546226, -0.6517661457233307, -0.09443495596317734, -0.4460478087799235, -0.4046122453554963, 0.5959754215122165, 0.3460747494619681, 0.07004571193926909, 0.3064238036322013, 0.5111918385923828, 0.2626366435598226, 0.5192713295518261, 0.6109533121403588, -0.8594362516544576, 0.7199153180692528, 0.6641968486776147, 0.7650133917335977, 0.6129689975405443, 0.7346942992427328, 0.41018371144318905, 0.7674187391478123, 0.47973546980216986, 0.4600774165077603, 0.30991239609532195, -0.24933683360679623, 0.34050458607287043, -0.5710027099306776, -0.3154786558338935, 0.567190295963494, -0.6617611020806969, 0.144089221425651, 0.395732778818525, 0.04296036365667575, 0.7283481878337874, 0.48436788738382686, 0.34199388879308373, 0.5954935974694499, 0.00141187375267155, 0.39743050248117184, -0.07948450236755543, -1.0124907011454183, 0.7467792885204838, 0.1793619414959794, 0.6750789715359783, 0.28734292020854, 0.5076595543035491, 0.21498376624042845, -0.5533994818217789, -0.8025761633513232, 0.06687326435295317, -0.5053151074853843, 0.4140753556823579, -0.624944101268038, -0.6866543062498491, 0.7321851010732792, 0.5392736543656231, -0.3359741560053306},
    {-0.743402377645588, -0.15889855612711623, 0.009040873007363818, 0.15139402233897273, 0.14229209049403743, 0.38049411857058096, 0.6922235996502929, -0.42808108068839396, -0.6708418470923225, -0.15465976109309817, -0.5926787857024074, -0.5945104357618043, 0.2729802086071324, 0.3549599302356334, 0.16982394593519518, 0.31283941314487973, 0.6419702732262526, 0.5311847473435279, 0.2854384758383629, 0.722677680826278, -0.5168115130775262, 0.6861850360360239, 0.61925575831149, 0.6085316369516329, 0.6562013244492105, 0.6833041253232314, 0.44791570306149137, 0.25739993872308514, 0.3902197335848991, 0.3185062862107662, 0.17899729016711766, -0.19892011567624676, 0.6112463347061469, -0.5706017685553016, -0.4523070487490947, -0.05101357265588267, -0.35660083534131776, 0.15129471360710717, 0.5031251467062645, -0.4575847466739128, 0.5085500145328702, 0.8105211620185861, 0.5984582330632057, 0.6108290523893372, 0.06480602896414384, 0.21613986434523447, -0.15670760325433145, -0.7137406554217788, 0.7956248472520457, 0.40567006587558485, 0.6065789115601675, 0.41217959868128434, 0.5040805986878703, 0.27749360031545467, -0.3030335676247378, -0.8886019882047046, -0.18136321111234593, -0.7118607398953424, 0.47297613185434656, -0.6322378366261766, -0.8152651329966243, 0.16737031312324058, 0.6591025219141186, -0.3820109432957394},
    {-0.6356954240715066, 0.16833079944399396, -0.3592623271836297, -0.0937808527871994, 0.09881646671630352, 0.5023410557252546, 0.5243550201618342, -0.3198486812895862, -0.6621307801572094, -0.003149537994791477, -0.7718950588379702, -0.4407595697889383, 0.197509464750445, 0.6350002743843115, 0.27216874517744977, 0.519691718434923, 0.4917051920237152, 0.4090885438521755, 0.33805107884662017, 0.6619815530827401, -0.833345778170333, 0.6404553883643685, 0.7257726591099051, -0.035314960737176944, 0.43313109755098805, 0.5388859095501074, 0.06418108267510123, 0.6255538093648265, 0.5591062111636168, 0.028966607013292237, 0.10007314367695719, -0.23257010341873152, 0.4665103601640794, -0.47583518862089486, -0.9959942158500078, 0.10137991836144136, -0.7000933376658157, 0.037804244055373346, 0.22622238958680993, 0.017726926227866573, 0.3462429035277764, 0.4558360003003834, 0.5395411054363396, 0.40024424337622133, -0.19748254287071687, 0.29431526258043395, 0.31778912449592606, -0.6684292886706068, 0.7055455130901868, 0.6438320190095614, 0.5725667262592, 0.5458745022777826, 0.5361363432701661, 0.22756937763742324, -0.609681945399184, -0.6015068879848059, -0.1222902538055294, -0.6491543609503025, 0.20017424457369964, -0.4337847989745405, -0.12518736348758414, 0.20205516734756873, 0.3599345542667874, -0.23294954754925157},
    {-0.7023190540875247, -0.10956231076341372, -0.28279620153635404, -0.0831946666906951, -0.01738785085926153, 0.46972381060988827, 0.6419159743818825, -0.46634990317505187, -0.5091988697756374, -0.20455662155039792, -0.44370580716180663, -0.5340063540253641, 0.4981507435838096, 0.37546385532311033, 0.1799699206811827, 0.3462502925686238, 0.48076601468452673, 0.37306115925892613, 0.10693394417489932, 0.586457804623805, -0.8257493965577632, 0.43358512306103125, 0.5377510537773879, -0.055071372861327884, 0.6616815086387327, 0.564945946503598, -0.29663906133142454, 0.5575738690677468, 0.35355927474506166, 0.11262025302319557, 0.1980879162330695, -0.22690500326993918, 0.2713862384360133, -0.6618890962696333, -0.9211659967239055, 0.24195186276711808, -0.2843901088635006, 0.16027321031952504, 0.17569183021320223, -0.07472744971156638, 0.5069853906943851, 0.5388121494550495, 0.46080304744488004, 0.6005027522753105, -0.24080469054727632, 0.014442936386634863, 0.17201208399326087, -0.7134100661021434, 0.4729767568966973, 0.44521920628657213, 0.4879413021795903, 0.4876566654712719, 0.42810181749541687, -0.03425022633743736, -0.821935579505745, -0.5358263632331967, -0.45424338627564564, -0.8583934176303545, -0.058569474967950765, -0.48124135112261324, -0.5072207229188357, 0.2931191042543255, 0.472339486460812, -0.4338696153248844},
    {-0.8018324757691592, 0.1150006926774666, -0.7703194256110976, 0.23662185609051772, -0.2773050644691422, 0.5533924516088651, 0.7786765771995958, -0.505881700301242, -0.5093735007756941, -0.5420558434335634, -0.7049319463488513, -0.38604585024051585, 0.8501819094341532, 0.2685752467586913, 0.3604418350926168, 0.21841626467142805, 0.38827339168382624, 0.6484387842291218, 0.1845963790934099, 0.7349917553959431, -0.7693790708949204, 0.6745716692988115, 0.657502538765735, 0.038555861970517954, 0.6138151845254771, 0.6050517259405619, -0.2703719896307482, 0.9083001753356917, 0.734340395718399, 0.39274838400392476, 0.31790948505680894, -0.4437141665838277, 0.49052626751536654, -0.7497731112796021, -0.5598731392844943, 0.4331358481335275, -0.6001587566409163, 0.22078073327251288, 0.5422126797308392, -0.032331927314668225, 0.6640672214297336, 0.5471995559411901, 0.26929840967931323, 0.5663312832567873, -0.4099859116898683, -0.022769762204120657, -0.17026319551925848, -0.5018969501610874, 0.4227492720758889, 0.6573223625954069, 0.33311357579619916, 0.7478337768468559, 0.6478961000355644, 0.1946538559522194, -0.6007898903628826, -0.6089518199462274, -0.1811232487131341, -0.24016074273330168, 0.6188845507042257, -0.26034992592871187, -0.5819065386087992, 0.4425165797236489, 0.4647535106876183, -0.27043304857938666},
    {-0.5233127901428314, 0.22055842751887186, -0.36309671312187203, 0.15771035136172776, -0.13655030524452552, 0.25281289502376253, 0.6992237838254031, -0.46391359753957556, -0.6189302682490518, -0.14528815065162118, -0.6079565924885991, -0.6250456206263819, 0.4592974901782492, 0.30829735610586523, 0.30246654354843, 0.2333952054232088, 0.41945957259505584, 0.8410834609366188, 0.2480657072826419, 0.7509189596265503, -0.8317122085801254, 0.5381572310315081, 0.5061166413701179, 0.0391238043578638, 0.5887593718809474, 0.3610645301928821, 0.03907869887486426, 0.41181679459235915, 0.7226376556969503, 0.2724806237851999, -0.24285219512321746, -0.2798208907366005, 0.0997419941021149, -0.5888905696771392, -0.3810524809529295, 0.7643875768562931, -0.7512155416397033, 0.22938933869415717, 0.11085721557038865, -0.08327439842289586, 0.4421586031487648, 0.26485386021553764, 0.8226770286190455, 0.5095329344430366, -0.2915367767718407, 0.17556140990079397, -0.24818166256399088, -0.6285634914693109, 0.678875632561229, 0.7698289394406462, 0.7114032675823547, 0.21143440772534028, 0.642294489053361, 0.2763952931791145, -0.8356213890656666, -0.6091538498242274, -0.431914730692189, -0.5040317328850371, 0.20992490149476783, -0.695258645486501, -0.46043161494271256, 0.6042034540122614, 0.8961973885043972, -0.17844931681316792},
    {-0.6625630420715607, -0.007062936424611732, -0.41183555544593237, -0.07286258534462008, -0.16025549420345722, 0.5899094030903689, 0.6494847406515795, -0.6173819482754567, -0.6778039281904923, -0.384907756648279, -0.7208196941450501, -0.7236859111770613, 0.544480566898382, 0.3250692030768412, 0.3546925180304487, 0.5550379362218152, 0.5224518763701514, 0.5613260801536668, 0.5645456665476293, 0.5925277840175613, -0.6676569674388397, 0.4943206252775225, 0.8623072579260196, 0.33045064800974067, 0.6326768741909637, 0.5794499966625275, 0.392357202261611, 0.35669934854567614, 0.5310475822354138, 0.011644242575437289, 0.1812602444366278, -0.35098475095943193, 0.4101198241678622, -0.5131791569415708, -0.5879447615040625, -0.07738690268681622, -0.4649196240126901, 0.5422457208822309, 0.26327255159999213, -0.07858699801529324, 0.3343076050056287, 0.33614531860062, 0.4255269023993566, 0.3457057061045616, -0.2028042848243678, 0.22089402498812372, 0.3198562860996157, -0.8133889404070529, 0.7348913695519106, 0.315966244217286, 0.566609805477902, 1.0671327881675101, 0.5759942685055497, 0.08693910590067704, -0.543970860897006, -0.6631747803625265, -0.0329717120726929, -0.271322745699054, 0.14715404699745016, -0.4518139241392252, -0.5112625309021058, 0.3352483723617195, 0.4280996466201566, -0.11770697869159492},
    {-0.45294079307694035, 0.18147362671500447, -0.41334253862633796, 0.3819598952034933, -0.10347339459048766, 0.7927701042403973, 0.9790760880316476, -0.49749622370333363, -0.791393336846622, -0.36785694406036756, -0.7230394423875347, -0.7028758267872589, 0.5409515720501135, 0.7049626456968722, 0.2927710404519619, 0.24112021487360752, 0.5559970190918065, 0.43772473562756126, 0.481589629979914, 0.8252440565511867, -0.8802968876814744, 0.8021283722995189, 0.6044176181234493, 0.5885219475935248, 0.4097672443718775, 0.6983956247384356, 0.37784970195845535, 0.5303466254275255, 0.8865056463912176, 0.2129304744848098, 0.1712579080255714, -0.16389452926959466, 0.6826488579468405, -0.9012186381344933, -0.8205892417434492, 0.8028175504364519, -0.42721081363338836, 0.5682740036646052, 0.5382055234542247, -0.22624220260691305, 0.5733878607011366, 0.42307830127886537, 0.532863034949573, 0.5919521995209671, -0.15638468685199272, 0.37295383737471505, 0.29411916776069785, -0.9771650225000161, 0.24863248231763688, 0.5917296626489263, 0.7376601703906529, 0.5309265293683602, 0.6390456929476844, 0.6834259807182789, -0.5712307291021008, -0.508321830731777, -0.08728685887108804, -0.6600038550029326, 0.5320134676265813, -0.71544503152786, -0.29055416567099246, 0.34238907023529874, 0.8046113559350192, -0.30335876116242805},
    {-0.6362024867387869, 0.08897121177595226, -0.6198680327314589, 0.15452056701758243, -0.23605096236795287, 0.44170623358066835, 0.8216971969581571, -0.4143019486983083, -0.6888131942584103, -0.2134017979738806, -0.46168999245561304, -0.6072982296953152, 0.6526943410686756, 0.14826067590766642, 0.2502831809641571, 0.4506091964014935, 0.5084125765495615, 0.8367812465384628, 0.6510847332115755, 1.0401450888201929, -0.6689723743154998, 0.32372340067906735, 0.47433586096799807, 0.16641084952730578, 0.6353771663314417, 0.7962913813177881, 0.15143392378690246, 0.5543606818652306, 0.6041055232588952, 0.1228956298446684, 0.16706764557624293, -0.021816801859386444, 0.40348999931053464, -0.849432397028256, -0.815587556564331, 0.5900458256164056, -0.5281217962513857, 0.4275229742288376, 0.24076962871246002, 0.029141760338694332, 0.6215547752660393, 0.18718195154155776, 0.16578938930821738, 0.5094629550184434, -0.1055199749268002, 0.4936051258643649, 0.2770260168791612, -0.6641706508908337, 0.49840439265426717, 0.5155718224790113, 0.7291443414683623, 0.7322294655980814, 0.3523614743322385, 0.5460728637410045, -0.42748608211388095, -0.696337796466138, -0.0995175266359284, -0.6639527370917048, 0.3459384287007645, -0.5919556517548881, -0.558640292302365, 0.4993910797631997, 0.36199801209994065, -0.35376528498600884},
    {-0.5551077197607025, 0.1507289597218066, -0.5599537345874417, -0.2785286252038961, -0.10981689351602855, 0.4456774381046184, 0.9637782378183404, -0.4870918963350459, -0.7590288894477499, -0.31242860192855126, -0.48494726773648855, -0.7023757176145266, 0.6155562394699114, -0.02702142432214495, 0.06316544630943603, 0.3208055116285777, 0.6932371562396473, 0.6307841945603062, 0.2572232582553843, 0.8217969769105801, -0.8654394181753722, 0.5642217315415219, 0.5423740987886237, 0.000995072678953892, 0.6536894315525105, 0.863645373209213, 0.106172766924166, 0.7288439556677515, 0.39964647074335946, 0.25603364530012074, 0.31517123488708476, -0.015027985743002322, 0.30928470514409934, -0.8190212991693827, -0.3836580005912058, 0.5458999741326008, -0.4030443952256182, 0.11303716172296886, -0.010534880602750938, -0.1202790043228258, 0.4050894876505554, 0.8193668459151947, 0.43738262544963535, 0.40861878261705614, -0.22008584452617733, 0.5257021421523854, 0.09128529422965467, -0.5616071890655027, 0.3138862935485409, 0.47356683417063694, 0.6908611997263382, 0.7010810703825228, 0.6749365989626159, 0.4317012687552952, -0.7580408697121823, -0.5992170849733884, -0.20661115578862949, -0.7592601355929515, 0.38737934471199825, -0.4586163358952249, -0.3876403441412873, 0.40480851745976637, 0.23509626870190725, -0.36369682450626195},
    {-0.8158602845184371, 0.31556044584449827, -0.7888950730295411, -0.02694483992882954, -0.05568949802632551, 0.4584167587061455, 0.9020585604412009, -0.39019324702146074, -1.0540439738101013, -0.4261689465166477, -0.6775651763250172, -0.6394010011326122, 0.3836185225621961, 0.3638747321101476, 0.4388186462314177, 0.4913063269241754, 0.6097649377002354, 0.3590570962955617, 0.5033955058453826, 0.7460554658054434, -0.8360488428053011, 0.42910173278082137, 0.6000129577941509, 0.3006728590045562, 0.7122969200822975, 0.8999323525459313, -0.05049251279208773, 0.6172665381217854, 0.5833473291854374, 0.22171535622245606, 0.26250251933795227, -0.1417123595097498, 0.42552679575229296, -0.9034382105542669, -0.6591365373413983, 0.14034981854591178, -0.5750198174702286, 0.46268620011436645, 0.49570489535870366, -0.22985349204936162, 0.4084154253690241, 0.43548558432997153, 0.5950069804956506, 0.6380916381811067, -0.39942140638700857, 0.28483257198503764, 0.13480627622833247, -0.4225046790727867, 0.3994384088590156, 0.4415879479940237, 0.8324859038288819, 0.6060738906659298, 0.727075330912613, 0.32520717039259794, -0.7000045470576186, -0.24900227077665227, -0.3875838920421895, -0.4694114913989007, 0.248306494186695, -0.5718774348594374, -0.20997789861382327, 0.2320628695219426, 0.5586442368619505, -0.3086403814301813},
    {-0.42092226636669233, 0.18670783878582783, -0.26107845679626407, 0.08427425780244106, -0.19490943447734124, 0.5497186322787383, 0.6992350745710375, -0.4505106825534643, -0.6955817516406337, -0.27281087421789274, -0.877799494544219, -0.6648516398914988, 0.4020729802420541, 0.5443569101800774, 0.3214237797691666, 0.5020403989094928, 0.5977226570394678, 0.48697565475553206, 0.26805953133247107, 0.7463550983253564, -0.7305842457727838, 0.1380237930660333, 0.5215917004051314, 0.3134228144721207, 0.5472620461336076, 0.8070288495938619, -0.0018821017463060874, 0.3156544179398203, 0.4272211997071472, -0.016627264620709254, 0.30827948930217136, -0.5666769615808442, 0.5242264284513951, -0.8475230496714466, -0.5925280644795515, -0.020595745311055704, -0.7300626244765481, 0.266492143872411, 0.31363371899988435, -0.3598028438772275, 0.5160933119969026, 0.472399896571068, 0.2802281525272643, 0.24770500658719027, -0.30162736848613264, 0.34541183327464714, 0.202385587559794, -0.5279485035290132, 0.5450125844115579, 0.498707159509108, 0.560297894489425, 0.4247618928826279, 0.710531619249761, 0.24901522814791213, -0.5585784468976065, -0.4065370726103855, -0.3819996988126333, -0.658631642537923, 0.4011928639823137, -0.7318676623542526, -0.5645810532304482, 0.46279409297112906, 0.5904032600419408, -0.23421787973567876},
    {-0.8775526354725844, 0.1326451275991866, -0.5652092294473635, 0.008212636876003912, -0.19486239169714387, 0.6876220791787016, 0.5808734769147692, -0.4858959665959321, -0.7015252902843768, -0.1714064059589081, -0.42237616719734344, -0.5729456910468423, 0.576088018546917, 0.5000259268753322, 0.08789541523622271, 0.46803114477860447, 0.6679268514849962, 0.5067087886028387, 0.2495032659310484, 0.7054222665859109, -0.8113757650212241, 0.388629179392008, 0.5578746842009157, 0.33296994219780196, 0.6789615240664039, 0.784311112784174, 0.3064622476266104, 0.4229974781899816, 0.6450829277315686, 0.16037834354595307, 0.4602005949614182, -0.22510982024064655, 0.522168767995074, -0.6724711439369819, -0.6962439221090171, -0.08590594684096127, -0.7806502422251658, 0.460831791408112, 0.12442128453865679, -0.027216469963895353, 0.5176328445130469, 0.3315396223385825, 0.3773004574118355, 0.5216519158379896, -0.2931682412805857, 0.42555379484941536, 0.17431929899679946, -0.8607440337323812, 0.24793496153588643, 0.3978453423127613, 0.5811237490526501, 0.5299710483172156, 0.5801091598305539, 0.4611835088050404, -0.6025735396396604, -0.691889828963511, -0.3033715991361902, -0.7208696866702903, 0.2830756436906277, -0.6288607686399659, -0.4790408425468464, 0.5875130378660288, 0.46818649669190776, -0.38488049658725},
    {-0.9479870478924891, 0.1118289805747232, -0.8091121707693159, 0.057107915806624665, -0.18093089358966072, 0.2954101737635465, 0.6845596993626107, -0.7119043961650942, -0.829373940949615, -0.08298163152116467, -0.559072944807338, -0.693531105775832, 0.5947727693351075, 0.3240016500361418, 0.22685320197315162, 0.23548144802304619, 0.8577310744459714, 0.5856931054838195, 0.16304673146525536, 0.6911135412392992, -0.7383498393518826, 0.7440472248391401, 0.41369971304667524, 0.5246730115618455, 0.74009483617674, 0.957394271425345, 0.09548277585354216, 0.84110532688029, 0.5000558737535293, 0.09737360429693662, -0.2925610370436196, -0.3625473381417419, 0.7505295438226252, -0.7459072419850834, -0.6094996525597544, 0.33478523195559334, -0.8875980578473266, 0.6001099951929044, 0.2650394400887467, -0.5447226463034364, 0.4803336885557668, 0.5796085425096914, 0.5266171866965834, 0.7384677596216943, -0.27324024258739954, 0.22169150270641313, 0.07971814967135941, -0.6226340387777344, 0.6662697618118998, 0.5227825200819227, 0.8695684866226445, 0.9250687147840041, 0.7757185407858364, 0.3532457595008618, -0.41174358328738253, -0.6293183766253702, -0.45378406762748447, -0.6152794315971477, 0.13865872884849745, -0.5672236345404298, -0.49222204478851384, 0.538111720580291, 0.6590590802197437, -0.5289604122765967},
    {-0.6600183889645246, 0.034921046018907595, -0.5181558792500315, 0.06749591424496194, 0.000793480089431207, 0.6775415668455322, 0.8050097463737533, -0.3065933338767879, -0.6180157503197178, -0.4190836434126829, -0.5117542188930491, -0.8968961450172337, 0.3889751292670046, 0.4057726860368694, 0.1888196721787064, 0.4488071417700344, 0.6564359393804472, 0.4445860027422423, 0.4833623007557698, 0.7047462442252459, -0.7138241196656673, 0.4234980623522832, 0.6308995863420007, 0.33853856031991947, 0.6275940503951761, 0.9330435315862227, -0.06441944731439174, 0.6631749373274786, 0.5022278978648783, 0.023791803937467635, -0.04883825463117234, -0.4526042779436692, 0.45406099481995765, -0.7937861238340906, -0.8531196742074338, 0.08007912709211784, -0.7877072387707013, 0.269752673153381, 0.2334800927908813, -0.5742207558448892, 0.5414885146814795, 0.5683009701226122, 0.5199588393266461, 0.318602632848509, -0.22715263918162332, 0.32884703156017925, 0.20929295691409322, -0.6830491029739224, 0.31025272666694315, 0.375308970785673, 0.5698086269823818, 0.6534288528965695, 0.5633587218848999, 0.24145502714221273, -0.5847073516707487, -0.7346368009328451, -0.3903263400439629, -0.7549991783483987, 0.017614213170723984, -0.5439353610247908, -0.5360989671213798, 0.5111786248546626, 0.5606027246333636, -0.4105667478400498},
    {-0.6852450966750869, -0.12811876339956707, -0.4963323564155951, -0.02028144525499191, 0.03206785305827051, 0.6236216649098429, 0.7679359097981335, -0.2937790931312189, -0.6072055846570985, -0.3530172989708603, -0.5485822160655229, -0.4845699092128898, 0.28513393858197666, 0.5522777827525265, 0.25942365605463563, 0.39531221950138645, 0.5984648978402946, 0.5441466164103432, 0.006414922130486446, 0.5553683975722411, -0.6325852179693588, 0.43265779565064655, 0.6126840369128207, 0.265805221311157, 0.7977111379746586, 0.6617692307462669, -0.16872251077282308, 0.5762084426494403, 0.4846052466776942, -0.05186784563837558, 0.1714442496834446, -0.32059778071156664, 0.5772083344563954, -0.8502526081091578, -0.606375057292315, 0.006881870185033242, -0.7123505067018723, 0.32419802324954244, 0.1571271126256248, -0.311507430902593, 0.3746744400963709, 0.7621099662882023, 0.4310016112794915, 0.6566551212935099, -0.24220723879001907, -0.060839353756782795, -0.03264780786039551, -0.7363183285021261, 0.3977862308591889, 0.36643014123866957, 0.8716282902522319, 0.5569128685251246, 0.4440061877869921, 0.17298709587813732, -0.43518560789781974, -0.7563862471823134, -0.17684729231155674, -0.6424219769246788, 0.16627623745436795, -0.4779272024287206, -0.40893528540412716, 0.4910758575772255, 0.6094195925102536, -0.3558156593995244},
    {-0.8149583016185622, 0.05156236679530669, -0.24306539466715185, 0.03651750564768728, -0.21946643979504227, 0.4408466052822227, 0.5612217556284294, -0.3624884853487404, -0.7211118907143399, -0.20376471729621198, -0.6317731601052914, -0.6561918435931344, 0.35524458080764804, 0.3003633426960074, 0.11484659824475017, 0.4056718769025413, 0.5843979883422117, 0.6104667079031537, 0.26186108139211006, 0.5098998468687865, -0.8803332891250312, 0.563140503382795, 0.9784377725074603, 0.2541146551694403, 0.7276032582583318, 0.6083446549331794, -0.23106322431512974, 0.2908995830147479, 0.3338556817012124, 0.024567978788021617, 0.03775314616352959, -0.25906878251368526, 0.3318825828316128, -0.871814048691782, -0.6565922878268255, -0.1997559213863487, -0.7908730361883127, 0.8044193441861521, 0.11627104001304345, -0.09684132034257895, 0.6179980314733555, 0.5999229621804213, 0.2195596238755711, 0.46051098521879896, -0.3298314938723247, 0.1535483925635444, 0.15755639436798288, -0.6978160390564428, 0.34050974637266584, 0.31228355768527055, 0.7334605639217615, 0.5894104257210693, 0.5143641071291514, 0.1821355412259641, -0.441854142894634, -0.8140071420240902, -0.312712802326881, -0.6908901466963776, 0.20268600032868056, -0.4456637619273226, -0.48162935314288147, 0.6474380512811426, 0.6224943454969656, -0.29527602640704853},
    {-0.8531796937343524, 0.3870312141879629, -0.40027092431488676, 0.17828365409562666, 0.06337446800649678, 0.4689783594135357, 0.8362392980907997, -0.4913660011796254, -0.7470268610893716, -0.3082260860588622, -0.6884933003963234, -0.7429852100938654, 0.7951082208377558, 0.353669167148543, 0.29251260652702743, 0.30511766205566404, 0.6601876950629525, 0.5780094765465965, 0.2653060649452588, 0.6755041174218605, -0.7957183140777003, 0.5039232263823937, 0.6678863548305708, 0.27127593932103405, 0.7948681610994309, 0.7587259533639307, 0.12800280217717896, 0.6720624641610117, 0.4951958717355253, 0.454005109793643, -0.06235451225624233, -0.42757165284129195, 0.5384676615418874, -0.88230300120951, -0.5549666939737099, 0.36230531213185924, -0.7435815247555203, 0.3239782347017651, 0.37006482876001384, -0.2059919863634214, 0.5050246488927174, 0.3611936151318922, 0.29587921008388623, 0.5401187765426544, -0.09106144092614137, 0.40857561474679444, 0.2459912994445127, -0.6638854238487699, 0.7418813765494009, 0.6384383558280532, 0.609822214108701, 0.3624263485216879, 0.5702226606299269, 0.3216775838978956, -0.5131419141613214, -0.6573302361396764, -0.2732895870540487, -0.3969135398617524, 0.41694558792701253, -0.6449164160510227, -0.504989324466517, 0.362030023409384, 0.3946399881534757, -0.3667211626054762},
    {-0.07053015543630897, 0.4527307125031712, 0.36224944087990607, 0.4068986750701179, 0.5427608777390095, 0.22434027796030717, 0.1208503083313261, 0.22476061192998378, 0.36335616777527957, -0.29521241798741, 0.49230310864624127, -0.15970944117259647, -0.427155083224482, 0.24525314312682786, 0.46188816877468325, 0.3952548121164116, 0.08254061015970504, 0.5381920905942564, 0.16889735676810586, 0.08860001489918612, 0.15025890578029816, -0.7903350515359241, 0.3655946416424796, 0.4638832683521139, 0.15918900086792467, -0.33117825830226294, 0.2721467506996027, 0.1799623479684453, 0.3159143016250408, 0.48868488105663216, 0.4858260863727363, 0.08210173134474018, -0.04999507340270123, -0.6404701859527897, -0.27993349631795433, -0.3063617717819623, -0.05667551276051533, 0.004808672448125528, 0.7761855743551774, -0.4320660599506515, 0.13750166752323628, 0.13233530011915812, 0.5933281354994724, 0.5038479639340798, -0.026951770925689542, 0.44390489869882627, 0.594114106590589, 0.22296342211102857, 0.25692449421727276, -0.3675434865381847, 0.37290866703941183, 0.5686917229311927, 0.3724866433758039, 0.27223913722615, 0.16279610329554503, 0.7344064543760792, 0.40349934095323736, 0.3796550691393602, -0.6756641510528708, 0.11261336201670796, -0.48811092827486474, 0.2938037354573974, 0.30168116432826514, 0.323167424556516},
    {-0.49537108754625864, -0.3034696414861492, -0.13558606675042167, -0.16231347488287054, 0.2839465181672267, -0.37332112749284024, -0.228361240338375, -0.32266767733612106, -0.6525545185331908, -0.11697250180668309, -0.1309647141229623, -0.6372654088486269, 0.04575865749885506, -0.27567844663620217, -0.038491065022425934, 0.21060752468593064, 0.19648043350335576, 0.04130788565596192, 0.10656548898837484, -0.13174786971435712, -0.3906608172873345, -0.4781080967817711, -0.004826465857966933, -0.04964900021161651, -0.23877545185492913, -0.3490060073538379, -0.1760068697458149, 0.1717895867485959, 0.033884174676118414, 0.09696090939999101, -0.05696720925134482, -0.20255724019412216, -0.78579632014054, -0.6108664436400083, -0.6451912692590066, -0.698209676550675, -0.5088091207253764, -0.15873330033589378, -0.28679157419512197, -0.41035766091953607, -0.1322436967677771, -0.011766231346260838, -0.4218375358712746, 0.09362508157588784, -0.31532475102466256, -0.19207551957894936, -0.02377814790592829, -0.3987122088341858, -0.2484066971621224, -0.10622420155534672, -0.2865587910677357, 0.34662967165361913, -0.22517477318913973, -0.3723891128617195, -0.4612467859090247, -0.2529641840779058, -0.22532659894659604, -0.11214018461651509, -0.3367960282940665, -0.4525295715170414, -0.19575626531958903, 0.2860124475906049, -0.25849233237272695, -0.31843025646343776},
    {-0.24453248085881493, -0.33448220419237373, -0.2385434981443144, -0.23530613471710216, 0.42205713657424854, -0.35573968734632305, -0.23042150402671688, -0.3375900830836183, -0.3278905194629803, 0.003684430008964644, 0.02173634684762808, 0.14228228140295054, -0.24514616764301464, -0.3246802877956289, -0.02332166073782733, -0.00021541947715419943, 0.11836360279079573, -0.3937162816567385, -0.05611124441667185, -0.22538913193572313, -0.4073268177647189, -0.21056871243636396, -0.35007038376351846, -0.2105553245658414, -0.15667350102708208, -0.10943039324707689, -0.18989065230267238, -0.41310077918507576, -0.4696289492576528, -0.14386843878841457, -0.2062469984368001, -0.12446989948414164, -0.3293963888986307, 0.0780821357955215, -0.13339557543959654, -0.5487806770125943, -0.1514556398364459, -0.2866674023313608, -0.21423071152644838, -0.6569233591253476, -0.38924070181719916, 0.042104852042225145, -0.05831795294604256, -0.5531119043005679, -0.5984387201903791, 0.09241101372171617, 0.21635166744860795, -0.05034847637023243, -0.33786171227550665, -0.11811707221756047, -0.02720101721590851, 0.6285916076887209, -0.1643524833478524, -0.5378467388234108, 0.00411347940784378, 0.11740939155064313, 0.02644781976212171, 0.3808987165963975, -0.5826394360571332, -0.06209396801169525, -0.48393239640129276, 0.38719941624132004, -0.3190046831681544, -0.45577342664276776},
    {-0.2974095218847561, -0.5998356791576782, -0.38660264822690465, 0.1263869052953257, 0.16722816704514948, -0.33908392405999627, 0.2279412325821574, -0.3073109143825428, -0.4638265308278326, -0.09782372663317014, -0.4426515710778099, 0.3648299191306632, -0.2587179033507857, 0.038862908506257426, -0.11366061964401243, 0.22891597070964573, -0.1564267342659847, 0.11939217651863433, 0.0007276422630180824, 0.030199281492814173, -0.47378450764564567, -0.047859155870175266, -0.022085767795437014, -0.08693558878755615, -0.732301630080212, 0.31131388870566956, 0.2515112320795588, 0.08351530227021552, 0.06706718225622091, -0.12771325856647686, -0.08528717355857963, -0.1656363527073955, 0.02002365649811016, 0.0945280148163026, -0.1826591309894822, -0.4792506682277283, -0.4165436252083801, -0.24919953912982407, -0.14954399112122996, -0.5300566794337251, -0.20280962033563812, 0.11405906255888283, 0.17129038171941802, -0.14037419964334136, -0.17058394807105204, 0.08744091878495451, 0.21730177012193552, 0.07932201739098914, -0.26791029673702765, -0.05472294392282831, 0.16915841594786754, 0.28983093305667196, 0.02775696596668057, 0.0763738558718171, -0.30357940478814915, 0.14818272224238993, -0.1303711117663547, 0.15019762116170085, -0.27339697377517674, -0.13406418929760758, -0.6452246922802979, 0.34943943567037344, -0.24389401042184336, -0.5436435163762662},
    {-0.5310971365590988, -0.6961614889770638, -0.7126267599758488, -0.498298825220443, -0.0834453073510393, -0.3780005911264204, -0.023221991547758065, -0.3654355102494227, -0.4569288932200876, 0.044463920090316786, -0.5388108644103794, -0.16230452007501284, -0.37476196575032167, -0.5771292118796953, -0.29391875932290584, 0.1658365880954882, -0.4025416290448106, -0.2560386919487359, -0.4543097948244205, -0.23640846646925848, -0.4504989961094772, -0.24409647041571494, -0.16878561917606544, 0.02794624315492249, -0.64833999007924, -0.03221178810335119, -0.28689029591282356, -0.41928579943086686, -0.39929993282271176, -0.22225165536252237, -0.6994788677239527, -0.4608778987404632, -0.7552705004099247, -0.024371028987244563, -0.5270544435319396, -0.5097455869358001, -0.04078132582104781, -0.33006226838995123, -0.5487633695772003, -0.20825317925222914, -0.36847081100212586, 0.0018944143553685042, -0.4170896512313656, -0.5415755803468708, -0.569504627182226, -0.3771089114245697, -0.31947055666036595, -0.2192293144364134, -0.2247015891895727, -0.3942454993918675, -0.19283130649623303, 0.3494036751249882, -0.23856355951530483, -0.6564506964264886, -0.6934756076578017, -0.29549115842281704, -0.4647203550358661, -0.2032635639351816, 0.031529728211048866, -0.5431884600273728, -0.7762446696884965, 0.5511548430029295, -0.4544837673264023, -0.43200560678623917},
    {-0.3656749898214927, -0.8831149088789386, -0.19811574563323361, -0.4066564956649293, -0.1477437785783026, -0.4595713277831895, -0.005266051759347293, -0.28886487655785326, -0.5184471657848871, 0.09818388709426903, -0.42015216851791093, 0.16775673741308852, -0.05008398610484455, -0.5289199875399395, -0.06040790871976625, 0.019282966816794735, -0.2243097881435076, -0.21506364634358055, -0.5205987661230714, -0.40203574514558316, -0.1867427329024993, 0.06543880413656994, -0.3053917329428214, -0.07335326626543767, -0.2415415914124038, 0.1825675259320053, -0.5173582543604089, -0.2391742897197619, -0.4214969330578075, -0.1850461888568814, -0.35184944812798286, -0.4551627019229431, -0.7531604187918334, 0.08721395969292392, -0.3290334972224664, -0.30169898121106786, -0.1688046136266908, -0.56117331972083, -0.20462231803008243, -0.1124913705325008, -0.15404371210347984, 0.27683700349097035, -0.42722887992437814, -0.33694596133624855, -0.23971723467217296, -0.135783575042932, -0.1407623419540928, -0.01443760314756765, -0.40203555391395385, -0.4541485539114565, -0.11769238349349058, 0.2631495883679006, -0.2961836108062745, -0.5654895466375287, -0.6116783768605958, -0.21830183729011188, -0.40070758901787684, -0.27757271412221174, 0.2578892635812113, -0.49303061417428473, -0.5446377979080868, 0.2220589400282695, -0.1409453432960937, -0.6728791561497982},
    {-0.5011605257978962, -0.39301190506980394, -0.2911374870873407, -0.134832229789755, 0.06547816466711645, -0.6418900002861238, -0.16509555422984304, -0.46194568770236694, -0.38603567879144196, 0.33606788496837947, -0.2811344858836973, -0.16069724875794594, -0.33558175631309156, -0.24599352706072466, -0.4463620782279449, 0.14736157532303562, -0.2575854177212411, -0.153165177316496, -0.0016025051328594953, -0.36691818389895875, -0.07380258647337613, -0.08703639726833483, 0.08878251186888246, -0.12681497194219238, -0.32702443199158926, -0.30726622960985944, -0.42933833982466263, -0.42847568506154265, -0.3856785908101997, 0.040074282237661775, -0.3976256128974303, -0.24867545439053038, -0.3498868777199812, -0.1869019333575061, -0.29124443222079194, -0.726561172699833, -0.23262430004612591, -0.334876771582301, -0.5847791385578898, -0.7671840104748765, -0.39727773351644574, 0.24656641543374375, -0.3310071266057861, -0.4050578113890017, -0.1526137081684169, -0.013952912399818343, -0.03754564849241272, -0.1849672386006918, -0.20552983046376036, -0.532468060586725, 0.23182690724375646, 0.1798280964515432, -0.18081494723356475, -0.5858039588464304, -0.3289434539353606, -0.1098326746857077, -0.24627085305134483, -0.05815381214309756, -0.19761554797114592, -0.42251628564968174, -0.7003924242145965, 0.11762581406411572, -0.2847021331550833, -0.4883961541473493},
    {-0.2897090066656473, -0.4088173273338068, -0.3761384526542592, -0.10800318139134493, -0.0232496784142494, -0.4238690719284072, 0.36022088108127326, -0.15531682126781207, -0.3426566429761682, 0.12877886120528176, -0.26555588703742183, 0.19358223536874977, 0.05418250271796698, -0.12555506845919492, -0.2816968210289277, 0.01238089099094344, -0.06849161825256309, -0.2048982551995237, -0.01905438066900384, -0.5794350192533102, -0.35654281581333847, -0.029759003289932032, -0.0471048493431487, -0.2777263008723446, -0.22308085162713215, -0.43373966236592876, -0.10924356567905324, -0.07421899792378739, -0.363924405265075, 0.10056042053428982, -0.2190021865664671, -0.5255952382952247, -0.1604791674335633, 0.07710915794729117, -0.40888577289831674, -0.4221506768975915, -0.45423705906172623, -0.10672860712990423, -0.24556858918760596, -0.26673577493461287, -0.5362860094081126, 0.29097367834292914, -0.32362741490995806, -0.3123064240500495, -0.4958032978199493, -0.14921272909753736, -0.367408563419838, -0.0051647910429448215, -0.2651111365825063, -0.5231593295088668, -0.5599058346957279, 0.15396709746617757, -0.48271190276251114, -0.4213811435405358, -0.33528634396485774, -0.01669669248472439, -0.3499143422173093, 0.19103829682014453, 0.040617488580114096, -0.43961402824730944, -0.14505017013455374, 0.1630080275722425, -0.6994542589450498, -0.2552661848952238},
    {-0.5804271796056089, -0.5133602935287891, -0.3587264182539766, -0.008314070900952113, -0.36628950067925065, -0.717111726551983, -0.1820989765012264, -0.21271329968513034, -0.4818345950712912, -0.014145743897792105, -0.1781922975107217, 0.111286862776398, -0.3120376182786529, -0.12691939017532264, -0.40646994638639006, -0.1894116456849982, -0.21829152966382132, -0.5696428669324854, -0.2471957304701366, -0.37603840851184045, -0.17463176376608935, 0.10683522879825104, -0.6777366067189738, -0.06871011681036786, -0.3645545292417491, -0.12587260709376244, -0.21560824416276142, -0.0805211216856785, -0.43380350750435204, -0.4340143350742524, -0.3176645890324174, -0.3560729712993717, -0.6858974044110431, -0.05959084923712958, -0.6215941047273013, -0.2379895567794209, -0.08411274621001431, -0.2817110091588094, -0.36633860697154197, -0.40750131641944454, -0.2613249983346696, 0.1287419495977197, -0.2556881588061684, -0.5359838387505804, -0.7196811042067616, -0.2629997468678417, -0.39749071205992403, -0.5759934773127143, -0.6262082283014426, -0.7051990408575797, -0.15219726170562553, 0.32556588123871044, 0.017868233597667194, -0.6859447742968799, -0.5779926266846167, -0.10521699192421975, -0.2700933078395361, -0.21616541994618832, -0.21065654758134997, -0.3669349408343816, -0.4723002263105783, 0.43092479632869674, -0.13421448482856307, -0.528866692763224},
    {-0.17503981508365948, -0.5181708604511254, -0.016568087084809283, 0.032319465931599456, -0.33665512314423734, -0.3967836693616579, -0.25479995380070447, -0.2543934642515526, -0.022669175854911138, 0.30348846480022096, 0.2606959048267151, 0.3364373654488558, -0.3413751033649061, -0.1497129452670062, -0.6871099730794273, 0.3920588253254506, -0.21392869648274743, -0.21735318203821263, -0.16986390953334068, -0.25769462089970785, 0.058830840720537105, 0.04374518411212622, -0.4271548857488893, -0.5699140611934252, -0.16573538272613825, -0.052784372108522645, -0.19079053221779832, -0.33946948598921334, -0.269830382414523, -0.4354088699204279, -0.1376632981168568, -0.43563340200272427, -0.23941983680506093, -0.3577495266168448, -0.2455107734459997, -0.38155514969823784, -0.46066561806179235, -0.49358163049007436, -0.466733856191263, -0.6702792384189894, -0.3845115092966021, 0.16055897734377805, -0.2108062327239345, -0.3443523844484804, -0.4938530204060827, -0.5578628855173935, -0.30838757555263674, -0.23769913055362443, -0.28600349090344684, -0.45337243585226444, 0.01892808351343532, 0.5879621244722845, 0.28004921433834334, -0.39060291036263173, -0.4855088558539962, -0.21458629755640982, -0.06460591421467568, -0.04851369263707791, -0.1765333906923829, -0.05122228273651364, -0.8312960729598692, 0.13668658093101504, -0.1871557827904046, -0.13594675690533814},
    {-0.7486855354476722, -0.40337774982958724, -0.34506991164875456, -0.10878497850976732, 0.07537778960744754, -0.45487670931764324, 0.01688689537428207, -0.656506689506873, -0.41358424002632016, -0.10702929242356995, 0.11163984865148054, -0.34392231625677805, -0.6640066497390653, -0.44156130399778637, -0.28402844937899235, -0.048503506872542415, -0.04790851198432232, -0.2379049074638878, -0.038990122734964994, -0.3760548419846305, -0.4145632589350324, -0.4061432883128236, -0.1307356422487171, -0.20586501582430897, -0.632203233395705, -0.38764110758787346, -0.0678242088664624, -0.7070609470221475, -0.0576751670395426, -0.35187483884922705, -0.21548915361588278, -0.29254284405674746, -0.7557133886778464, -0.2810448606465314, -0.41280430414155495, -0.49691764913760816, -0.7112235017088075, -0.5040334879807424, -0.15780502425169393, -0.5981263456446584, -0.08513821402228393, -0.22553028848386744, -0.3466833752607613, -0.20914061854631733, -0.534575239220307, -0.16523063780778363, -0.020165916458068627, -0.22539927439132823, -0.25506304816585806, -0.5347677864918944, 0.33316622979993316, 0.14241692151078325, -0.28635183252876717, -0.5318219262963444, -0.36188364034498, 0.20893425106145358, 0.21300848322678895, -0.05915515446461102, -0.2665385129175011, 0.24386813528851178, -0.7817243039530005, 0.2778774953400821, -0.07524329437182696, -0.47176445796378913},
    {-0.47587145772726414, -0.4760936987763724, -0.36722672687205327, -0.1981159421409943, -0.11141723019967699, -0.49230981256899997, 0.15330830043535998, -0.5225992678076105, -0.27795243916282375, 0.21613980664847418, 0.11711997956805122, -0.35695255210047566, -0.47078647153320713, -0.3737292902454112, -0.21633491562690463, 0.16868111187232462, -0.3300966882135506, -0.21737172430988483, 0.045828218465524095, -0.2480843069310338, -0.13496862100882803, -0.13790161512819996, -0.3038342329761167, -0.07022520025623193, -0.15645318564672592, -0.1880067591268205, 0.010774454982690961, -0.49466626389442697, -0.3204479374465471, 0.07289083015298031, -0.2401278527637698, -0.4060280549266432, -0.26242138023596123, -0.15642920943631736, -0.3204332036723788, -0.46075436389730423, -0.6796311506760717, -0.26324403734915935, -0.2574742496681425, -0.6495745916500366, -0.16684424590632296, -0.03264284593610094, -0.052663578333187674, -0.14379460185560336, -0.48897641118567126, 0.047606931943548494, 0.11362073216222635, 0.02616624196738532, -0.2921218020202149, -0.43106230034309895, 0.09203467720134788, 0.49548598896250545, -0.34825546255366, -0.35514314820672777, -0.22797737086687683, -0.14593055994154594, -0.24574466091383992, 0.27404466797147436, -0.30345476655137177, -0.16954011611427294, -0.7031366870171891, 0.4243390887019746, -0.13542448163663498, -0.39298836681103305},
    {-0.5459491213016492, -0.4476420533571988, -0.18232614755580076, -0.47485039173887145, 0.014977059662799113, -0.2347306562213429, -0.24252406779969973, -0.4936015486769557, -0.6853571258981184, 0.25369115553197247, 0.29798196598801296, 0.2141541505714372, -0.6862710787383793, -0.062151577785976526, -0.1820670312161168, 0.2561301911446687, -0.40402631476998485, -0.2269585868016345, -0.38207208010091287, -0.15171689678767292, -0.07202514960547342, -0.29453640715884055, -0.5019453848600234, -0.2518392704656579, -0.5547407136615781, 0.16586184677901672, -0.3517200304193634, -0.45556561329439355, -0.31173831115169415, -0.3190088815812814, -0.2617175188694643, -0.2683039402820054, -0.24335124281187487, -0.3803473378231735, -0.32007039266905507, -0.5210096737051477, -0.5187246347222014, -0.29870236962311136, -0.18345502052755377, -0.49044960947187866, -0.4716879288680925, -0.27500666312977823, 0.20979117108432632, -0.18523751274263156, -0.49261914266265694, -0.18966341455163943, 0.3098037205288168, -0.14123552268929934, -0.2488461309026891, -0.3735073231267405, 0.3371599782054468, 0.2440413151207955, -0.011094693659317303, -0.3510529492538749, 0.0004137048869663836, -0.1722329329610277, 0.17889125411650508, 0.1567348555943743, -0.456326646686255, -0.4892255021201308, -0.21125787188823966, 0.21743050287523802, -0.043385667131163354, -0.5093734473454036},
    {-0.5308821981286789, -0.43930884438314166, -0.28634498863568036, -0.23502534225752317, 0.11934784005344183, -0.38880931448498507, -0.34348556934427804, -0.54006997584815, -0.4653125431451501, 0.19363370485417988, -0.085633932954595, 0.026764089203585667, -0.3195356073665705, -0.36559165057598386, -0.41072862483530453, -0.23671784121639866, -0.4146782663617109, -0.24229016903048015, -0.4724421539283864, -0.14137049836893753, -0.45724180443768175, -0.6743260501090094, -0.49752187886829247, -0.33595147761860333, -0.3113973961261427, -0.172041040331489, -0.38332554178790956, -0.4095030870576173, -0.2898822523179371, -0.23333934980539156, -0.31535336236592526, -0.47442139198426747, -0.24183218135303977, -0.19925885479225083, -0.3366694206294824, -0.49971639518134625, -0.3608853041090466, -0.3385469660206402, -0.27724581008605587, -0.3803624134819781, -0.3584965484284074, -0.09406129000674407, -0.4631906635412062, -0.14960662915441483, -0.5157072092786693, -0.3738717891964837, 0.2901495709353978, -0.09722658134530265, -0.4925666668063053, -0.5170761180736085, -0.45638555999702834, 0.2823767388176457, 0.044536417215669526, -0.5783867827744719, -0.3929600539235864, -0.3514248561741461, 0.16238893396432083, 0.23689870055155585, -0.34019670231244414, -0.22760912196746996, -0.5434211117332108, 0.09490382469884957, 0.01574791552768846, -0.6314692987874228},
    {-0.38183670162492883, -0.34139646865542456, -0.36176703763783064, -0.07591961258554239, 0.3715197733867174, -0.5666283337452753, 0.18163082891178012, -0.4159615792294739, -0.5735463100181428, -0.03654411778657901, 0.17320200601745042, -0.0251554601612856, -0.32618324618937766, -0.2335558781842443, -0.6157781975497839, 0.30803568921902685, -0.23974847293332377, -0.3945101188362272, -0.2950800729371548, -0.741390670082625, 0.005488054473156166, -0.31273429830183913, -0.68257995846818, -0.34305979623598154, -0.5303123400592086, -0.043949331476618454, -0.3205178589338684, -0.3057200243461444, -0.39371688954042017, -0.1848134776312175, -0.17091406434711934, -0.4776593116466182, -0.3605755109088893, -0.4455568055037608, -0.5255660957450651, -0.48822294454526455, -0.4062078387747634, -0.08452977801997348, -0.26614777483927426, -0.8449418706080162, -0.5694997427328028, -0.04493839668904689, -0.18540960794324293, -0.11459070899140185, -0.7664019262325292, -0.05942398273043899, 0.10043859191075144, -0.31998363101927846, -0.3032351135960296, -0.20486032267720286, -0.5587854773138972, 0.34105966374994906, -0.05882921066765631, -0.6620992738374207, -0.4500054560353123, -0.24598911851044503, 0.04796673804679221, 0.4399241064226233, -0.4870062091025645, -0.5149003154469924, -0.769897388994494, 0.3160143987701704, -0.4775351333033738, -0.4148143691152194},
    {-0.6774727300796209, -0.2980838484386497, -0.3163464995388091, -0.011899099349510807, 0.2966350161900097, -0.24503107344579803, 0.0147895117627346, -0.2446518979981662, -0.3722473893789906, 0.3476897066724719, -0.0877878192710089, -0.09053146936266018, -0.5059076449375387, -0.38225723138724677, -0.04499596287345633, 0.01238725398406517, -0.21748578614482358, -0.25490479999819293, -0.3064647753892695, -0.5407985713393774, -0.4177352440171318, -0.26369918966937766, -0.5426451270725746, -0.17139304828009871, -0.14877805650590756, 0.35369203453761494, -0.17235971591884164, -0.4551590150121515, -0.18316537416509623, -0.1180075359459815, 0.06698599431425803, -0.6595560047766312, -0.11986866254410222, -0.46836543669740793, -0.7787133256480578, -0.3773628925123511, -0.41164936176699346, -0.3898776219056091, -0.3672670403062774, -0.5273101850495701, -0.41889756586976556, -0.05451265650490653, -0.14424440636578503, -0.3186261153181986, -0.42762387103243904, -0.2662431492825812, 0.04796478921044908, -0.08339508146299068, -0.25838904098268506, -0.31671085500791046, 0.06376734255311256, 0.2966386557067268, -0.17358913953826188, -0.36151826798005954, -0.2914558300128759, -0.26764968331385214, 0.20929057246118246, -0.08540299395770601, -0.5855001039069306, -0.09903373641283879, -0.5505947197878791, 0.7463700059658208, -0.18132516799074783, -0.5817712551780644},
    {-0.7135406355969901, -0.23440627499223246, -0.2700393949789594, -0.20275224459638322, 0.2121309897485352, -0.12366529176014993, -0.13590809766549905, -0.28534921080859016, -0.5661950510803231, -0.17042612256166237, -0.39514263978793346, -0.06454138275781886, -0.5148941781792756, -0.24065948150828906, -0.1072781756392085, -0.04668133962803159, 0.017695079546596732, -0.15522454296736163, -0.43433057327066665, -0.3791077224003856, -0.5449315399404362, -0.024392767034258953, -0.23682130020356007, -0.11123958565401489, -0.21441459275930175, 0.4025964085181362, -0.22608506966795036, -0.2540452108279667, -0.33909841025814863, 0.3149277514941029, -0.15826990098402982, -0.6841523862059877, -0.3594706921245143, -0.06042277758459469, -0.27253871695400217, -0.49668270436354467, -0.15322946750417818, 0.00506327395239711, -0.2559061640489523, -0.20660424961782223, -0.3335814402832415, 0.10083956031551874, -0.2954654132505505, -0.16113845600993318, -0.5189696737997824, 0.0021328368104353594, -0.2567532715734827, -0.37676031907233754, 0.13818884468883258, 0.1641820453839743, 0.17754208326971274, 0.17570463824801746, -0.3223516904884636, -0.14771705332445878, -0.3199360147617856, -0.18333835897191036, 0.22311242818844312, 0.2108182291933453, -0.27877836338210504, -0.22451403326366562, -0.5792142068587124, 0.37476948879928773, -0.08920009081156446, -0.5555981700668245},
    {-0.44374233485674563, -0.5992397778285378, -0.314658709223911, -0.03092998896524619, 0.1813084137218265, -0.38758439929338806, -0.37212264446935855, -0.38927343771583056, -0.3277829331718975, -0.2749542274297333, -0.0804835825277218, -0.015899274583823345, -0.3857132449085602, -0.08976710231780347, 0.1200676262003154, 0.3468711120477404, -0.1526697204265342, -0.19565362990749807, -0.09678031644443326, -0.1898119784224634, -0.36736086243799926, -0.05227622080600806, -0.0587293173286649, -0.16615373127586983, -0.08196883011452674, 0.29304162142411705, -0.24017283373783704, -0.22763593072877364, -0.20787096448026496, -0.09533710450400731, -0.1251578330523443, -0.5428240880966644, -0.3160280083473057, -0.1971017626980874, -0.494750018992356, -0.7334723122994742, -0.6572933429529262, -0.26484011983636774, -0.6031818500805386, -0.66359322369814, -0.18065728451085666, 0.011559175055447, -0.22268142021597648, -0.09183393929978771, -0.4498817360615078, -0.14913197766009367, 0.06769162886007687, -0.0686444231556471, -0.009287336390229401, -0.23110964913230828, 0.0629342648633825, 0.6511623759240877, -0.09743093498080689, -0.16003934770950587, -0.4863646758811041, -0.234611913127127, 0.16907272748158925, 0.023769689299200373, -0.5485001370023846, -0.5100722289542371, -0.6710929978625934, 0.6215191187996203, -0.3267393821093217, -0.6233257517872675},
    {-0.3560962130433381, -0.20238966149424134, -0.4448935080878445, -0.16008299759738687, 0.5270102136282525, -0.20013729178134645, 0.1301349840799409, -0.25049894916071874, -0.5202774231443854, -0.06275895687061231, -0.09074917391634946, -0.18384753717533442, -0.39856133658242343, -0.4870630300243753, 0.14577730151262638, 0.4491084793059595, -0.14283694319503804, -0.33660312008953835, -0.2753613178814768, -0.11292947430043922, -0.5203701658156945, -0.40640209142965533, -0.3036878856052455, 0.0017655891792247446, -0.3528883808287736, 0.007480816586104633, -0.32116334858250206, -0.20981946213706093, -0.2675708984031047, 0.12368791730646694, -0.2833684380939399, -0.7170629822801171, -0.4596577776444921, -0.26810325657205386, -0.4555347560561386, -0.5345211575173833, -0.5459172296992363, -0.018033467531117033, -0.24971587677500504, -0.638030581362016, -0.33354543890576416, 0.2317739833896017, -0.19669862606240374, -0.11208106985587997, -0.5163924433765583, 0.270881905854876, 0.07777664437192941, -0.11348609770327513, 0.08541633808997243, -0.35867884981949544, 0.07177645303198164, 0.15722261674303656, 0.003498087832253798, -0.4218899591848194, -0.6460354841664586, -0.17619746606636733, 0.23661026277580252, 0.06360558428577762, -0.5187426600975992, -0.3506606122396019, -0.6094082222389049, 0.4999166393233785, -0.24328713664112894, -0.4434422468456723},
    {-0.658436499532621, -0.2570747478536769, -0.613241757465731, -0.20172453455623113, 0.507046365053942, -0.6266679569017801, 0.034396185600335416, -0.6960194561379022, -0.6622352025625791, -0.24507806725517822, -0.2824777734186135, -0.05855161113340822, -0.5420274318100805, -0.4027774127188462, -0.046755507302302754, 0.1501873900744854, -0.15971855739412721, -0.5054076154266817, -0.15436093899866749, -0.3924668703150062, -0.40371971926983613, -0.18090663737914559, -0.4022377933831497, 0.07819952419166021, -0.4405835983917148, 0.035347448333880385, -0.38148873299447794, -0.3825086569851513, -0.2677701191516005, 0.05727670750971829, -0.3015002338037374, -0.9091527292866017, -0.2582837914299104, -0.32647978883930606, -0.540841397603556, -0.8345612576659195, -0.36570182341386087, -0.08920032932650676, -0.38426033330202836, -0.6122260981852489, -0.29895052027703284, 0.08810333857445071, -0.27241945537479656, -0.3863812793231772, -0.7381704102864995, -0.1008937685420152, 0.1839000125104129, -0.1825756214986828, -0.4487204382132085, -0.5793233420260332, 0.07230126831045129, 0.07884832390481751, 0.18615658997391485, -0.6177569304399435, -0.6528485199221408, 0.06304867352499247, -0.037354750272505746, -0.11984431124656977, -0.508406235997679, -0.41530584318283575, -0.6941292392806965, 0.3007571267311369, -0.16346682524361952, -0.8229760984124155},
    {-0.6402770569448466, -0.06894282235704247, -0.6942710220218558, -0.15650202523826195, 0.18251177953104616, -0.4855607671529483, -0.35425306694838965, -0.5149773535419588, -0.5055862959728489, 0.07188205438858485, -0.34628083277881083, -0.15635338663103024, -0.525427166856359, -0.399746603225068, -0.22168707989489045, 0.4875713451436953, -0.15973285992780822, -0.5990764369765942, -0.34977644447042305, -0.33341450218911395, -0.5405959678593687, -0.29090370910004865, -0.22795677089162325, -0.1269572423269262, -0.7200500924882743, -0.23905558691132656, -0.05653705340070997, -0.41739192271559916, -0.40613108784074137, -0.06679027144386843, -0.25014340289742987, -0.8327991757695469, -0.6768703759848083, -0.4781233287761887, -0.5673923810920728, -0.7739580275164223, -0.384282281742003, -0.8200663839179958, -0.5397001209808432, -0.485922823063348, -0.31580047521902893, 0.0584984057389716, -0.03733499466037999, -0.21603123740201066, -0.6380108871399496, -0.06409474063902217, 0.44156966275615817, -0.6551728362203677, -0.14208199690491494, -0.35206586086259983, -0.14421476756740914, 0.41094131037312187, -0.23788496806974851, -0.5157304830098017, -0.4499738217362997, -0.3304952738169425, 0.35609720472596246, -0.031475301267494454, -0.6929418745115522, -0.5840074381277963, -0.6679695542309205, 0.24941022244950764, -0.46619584719126933, -0.6015844526354543},
    {-0.8501434467160952, -0.2014645996575245, -0.4527783159546128, 0.14101063144002646, 0.6077188991592282, -0.5218327859568855, 0.07903691785527983, -0.40781117523172394, -0.4503363560229972, 0.044088344649310336, -0.5419945075402542, -0.14142136913912265, -0.3095731020113437, -0.464860751578344, 0.2580648919704239, 0.5000730664385576, -0.10282057113455746, -0.44207907543985264, -0.05008937934955122, -0.12042068454734882, -0.41275781709865955, -0.34265086955673363, -0.09539827887289525, -0.2484527746138961, -0.4049037406644903, 0.2629226086832807, 0.06422013254682193, -0.18585784563813, -0.15581439664179125, 0.2156728542309214, -0.19074461310629978, -0.769533539192051, -0.7572170547612055, -0.39089816240040803, -0.7293314520500194, -0.8576720089148454, -0.7230884490322966, -0.7478613058959235, -0.49831724038177966, -0.6080303753484984, -0.22298625786259257, 0.32958237024540704, 0.05701093170138746, -0.05990489625076801, -0.6664701699038647, 0.19419362808751095, 0.265181581814017, -0.39195979860003727, 0.13650147450976124, -0.5796380792943411, -0.01825814140156493, 0.32981356293960906, 0.018694666528160438, -0.4051268686317865, -0.17132558263171804, -0.35554485352625487, 0.4804443025118641, 0.45123437045881165, -0.6680730595119068, -0.3519270236558331, -0.46576564715753466, 0.135538878205352, -0.19453141293449697, -0.5842407269619408},
    {-0.7344982544179143, 0.2799192085862538, -0.05062840515451513, 0.48503148202305296, 0.7440153731667672, -0.14810355726907184, 0.35978421869725236, -0.30244171582571505, -0.3265330755352747, -0.37197231581044404, -0.5843015346651822, -0.32859121453347373, -0.26495153683809525, 0.0011201842797893408, 0.47682755102105884, 0.8366242348398405, 0.15259186842081865, -0.22024758806898537, 0.15571955089071007, -0.10773297302925314, -0.310161033539025, -0.5295647510526206, 0.2504144391441156, 0.21157939012922208, -0.34662486525030983, 0.13274560835799842, 0.3459775494726576, -0.1984792246760948, -0.008479028160111118, 0.7152393667976061, -0.145293396605782, -0.7608798588008261, -0.5563984237018333, -0.526210838507897, -0.8955127127114249, -0.8098433662936807, -0.5583652337945444, -0.14294448371724172, 0.16936480554023803, -0.9263989131497108, -0.07869115889141551, -0.19963053875020334, 0.24070929374919267, -0.17117304067712483, -0.6362694765073791, 0.38386330052547757, 0.6012820192455334, -0.011644688966898605, 0.12668592945416607, -0.4382538968125706, 0.08252409350233798, 0.20737534212336595, 0.45615119600982146, -0.43906693561516186, -0.10054994364592247, 0.10308332315901333, 0.6435053205577467, 0.3734335593373062, -0.8040618559653034, 0.060411611508264455, -0.6010248766982352, 0.6102739334303525, 0.09412188994935416, -0.5874675523710408},
    {-0.5861462312379125, -0.0955634635394364, -0.529640147624832, 0.4687331065737717, 0.49920377975633135, -0.33372455257987205, -0.0867214669219311, -0.7292802283010449, -0.4232332069184195, -0.12933494469111753, -0.5515735341275445, -0.4643206742896986, -0.5081865185327912, -0.24796670402672993, 0.365515362313656, 0.479807531770955, 0.024395047694530273, -0.48576751457094514, -0.002795920194244697, 0.0005644979348120262, -0.11466028348349167, -0.5262006160851193, 0.047692483890545784, 0.08572430240691072, -0.227649693578659, -0.017487050087681998, 0.08941273457123977, -0.2762296383916774, -0.20890909100331717, 0.22713698536809676, -0.19314793808462719, -0.623612049962513, -0.653084171087269, -0.7094413969384503, -0.7913156817260406, -0.5193078620278437, -0.5661315853504646, -0.2918860022006005, 0.12721189193649296, -1.1025528014196688, -0.2804545030820608, 0.13220412641418872, -0.1048623131582133, -0.19439467707511435, -0.667961654553406, 0.1500931771416204, 0.4761363457386496, 0.10326072787947167, -0.2823636174418742, -0.5737978675093863, -0.09123046379429216, 0.31150942419615674, 0.23688833928559053, -0.25788271014373443, -0.28968689563137406, 0.061399172000377734, 0.5282918841220412, 0.29946824454216625, -0.6481355442104246, -0.582694478993482, -0.6665403793051434, 0.4129470110393083, -0.22764608240648398, -0.6070244746312901},
    {-0.689062785760354, -0.5104286651539308, -0.4506535953175477, -0.2719720506058252, 0.502090346643066, -0.6105579033492905, -0.016909997408216165, -0.7329912597028403, -0.4734758774611986, -0.07071911766777354, -0.42570452144457555, -0.1885781899926344, -0.6275036727335768, -0.21415134069295172, -0.02078884270360967, 0.3444886658020276, -0.3415125460851676, -0.46864545507698085, -0.20703403824019018, -0.14164008718897816, -0.65279545089739, -0.47949184732928835, -0.32439640337599607, -0.18834342399344792, -0.5859910165717461, -0.5123092336397276, -0.19156613091654906, -0.20606008221281574, -0.27933764850147236, 0.370745153283161, -0.5632513340848682, -0.5517773609708373, -0.4864311573846974, -0.49295757092549614, -0.8395677387968916, -0.6026287343712156, -0.6593972870794046, -0.24269817328192256, -0.5262317624810616, -0.6374386961627906, -0.4459495621940899, 0.1677437675662516, -0.3025526009536246, -0.13266590244935803, -0.6237427717698262, 0.02577797165805378, 0.07200368111021939, -0.7483312376334581, -0.2717169968868678, -0.8170421914429613, 0.10569829127921396, 0.2852975357069065, 0.2379033861989254, -0.7126482334379706, -0.15915392860880087, -0.5382108046816607, 0.14057770973302117, -0.22753224452894688, -0.5728649411643121, -0.7139458704643054, -0.8382092320778687, 0.3979645827537704, -0.48760116622264316, -0.480459379907723},
    {-0.653257625401533, 0.044423810380080704, -0.37238051054766663, 0.44182662417898444, 0.4838367966905215, 0.12156776358727109, 0.19165118634986855, -0.44087137791020087, -0.56247419944495, -0.23970945272940636, -0.38665212714193586, -0.19009802715444196, -0.7445570769225717, -0.12040906867600747, 0.5814146603479327, 0.14895810212258168, -0.02089281294152514, -0.319874288042335, -0.01603590067504746, -0.06388418956751642, -0.6110483995794184, -0.4979622618501739, 0.018313048268504835, 0.08358686953550087, -0.3698078306823634, -0.07587589368584433, 0.137650426875373, -0.3210067434603859, 0.06710008286547406, 0.36270673001262854, 0.021437243749426804, -0.9288431743136322, -0.5564243866902684, -0.5682859872739481, -0.4965929049807348, -0.791059857373893, -0.5940109648859591, -0.011115092312598808, -0.12049807235909468, -0.7414047388623856, -0.34199549183284705, -0.12931155239018557, 0.1798539746073605, 0.11915538775307258, -0.6364371720760382, 0.22783025852525984, 0.12187992628837038, 0.001395844893317716, 0.2140854133227023, -0.5396038672274249, 0.005421980787322094, 0.3793932299389166, 0.29955244853976953, -0.5584401936432306, -0.1078106582695247, 0.043954416834183545, 0.5856736525809432, 0.32529808244070013, -0.5792765713534347, -0.4709007784493432, -0.7382914860086123, 0.3737738500766723, 0.029665912679220505, -0.581145793672469},
    {-0.5704550742120666, 0.06276282258376147, -0.06095614303366136, 0.35665494004008086, 0.30037536074471605, -0.20862865754076645, -0.07647008325569986, -0.5176823473899813, -0.42401387731284146, -0.06699363970234257, -0.08911059126679362, -0.35208850152326066, -0.5565268207148218, -0.2566035534887973, 0.5470442299729158, 0.50698740181668, -0.1821060494015301, -0.09373640147122292, -0.11109292920059657, -0.2712725993412454, -0.6498752897490431, -0.5914485736744001, 0.10478435503918473, 0.07266435218445366, -0.2194242001767198, -0.18451101897578812, 0.1754720919496871, -0.23658470590069103, -0.060801755156969894, 0.28277761055283657, 0.2237333646706193, -0.5929373249041724, -0.5108868997451923, -0.5920403278985336, -0.5521039475487348, -0.6989620047458617, -0.5791219551472768, -0.49460231436421914, 0.08554466324668698, -0.8481179757474601, -0.21973529919111673, 0.0016666113912849364, 0.06387986377322967, 0.22417919103698083, -0.7409573970948731, 0.14601330009172245, 0.4217229900365055, -0.23233848946450897, 0.1322093563171724, -0.3173301292637404, 0.11973814083859467, 0.540901616145504, -0.09457696654718427, -0.3161159957780463, -0.2541017684830433, 0.18292520168644574, 0.32168714022840045, 0.19409660608188412, -0.8451305911950825, -0.20025590726457074, -0.705327410544819, -0.023168189514860594, -0.30311464793589415, -0.5178215017413573},
    {-0.38370607689547565, -0.23738557109833286, -0.6233657528325561, 0.24027159340904128, 0.673214544604507, -0.4370641085609489, 0.06379776577375149, -0.8618977887646486, -0.4062055518440754, -0.178156659218755, -0.029642618932865288, -0.4811028426491279, -0.5512712992610399, -0.31625178723567016, 0.21093196396615738, 0.4449904527447844, 0.006251557196703615, -0.2783718835679201, -0.07309724100305226, -0.08936997352239527, -0.35847346834611227, -0.4831617839736317, -0.1170112676624597, 0.018825918897823746, -0.5889938287540272, -0.14429194679813534, 0.20763606516751648, -0.3459500950576126, -0.07511657417120506, 0.2152509136687409, 0.02783168296137968, -0.5729254796717861, -0.69011706476331, -0.5770597216012883, -0.4833138234135214, -0.7923118787328314, -0.6420866314264475, -0.31912914630954714, -0.012035777137923396, -0.9920591478259444, -0.1686642882290083, -0.08298329361322293, 0.031089770593162654, 0.005587109253632509, -0.8246942669223263, 0.18619504088786124, 0.3780049607328953, -0.3316349448403244, 0.20073304710207518, -0.5004708888555759, -0.05374336430931053, 0.5075873159570717, 0.07547214761959216, -0.14800071034626097, -0.07748432263979071, -0.14331595710145542, 0.7546563681768865, 0.18958050295122256, -0.804484359473236, -0.5171744586931486, -0.7311468872931763, 0.4829126560316504, -0.07648005730458217, -0.5907834513157143},
    {-0.7891281153413959, -0.33332421175092647, -0.2538619464150048, 0.13817200272475272, 0.9016874951534014, -0.26123159371474924, 0.24861680505696193, -0.4869335866427085, -0.5737063002471261, -0.5250887890112069, -0.388598034571244, -0.28452627777524464, -0.7589989773257669, -0.20196533637257433, 0.370332087899069, 0.42291973242403685, -0.12075457323545141, -0.49918973451969684, -0.16605233335997258, -0.1953428855572409, -0.14246078842511303, -0.6253776607008613, 0.2615441221482917, 0.19293428385025282, -0.6075015195909599, -0.09913389291611296, 0.08689727027655585, -0.0693578082112378, -0.14968612015745159, 0.48161026432524173, -0.02628838431857227, -0.8816124413941352, -0.5418563741610699, -0.6121175796913118, -0.8331141854307877, -0.9250946488671487, -0.8521223800578392, -0.4875879811776744, -0.1514048803321506, -0.9219668382073467, -0.4853062783244551, -0.15130299039393436, 0.041492136786417624, 0.0072402763463080885, -0.7840373445696789, 0.19074895408526935, 0.34725604675377153, -0.14675795528876268, -0.043520574541777025, -0.640075093222498, 0.10588302563978254, 0.4047218418040723, 0.06857517162026841, -0.6342533005850154, -0.1047383572835705, -0.116607090688945, 1.0965994678656743, 0.41304876500224613, -1.078444387367152, -0.29783591300304724, -0.8429106768327379, 0.6346705545906901, -0.43617993377959996, -0.5941993769959},
    {-0.6900898243100649, -0.1539223372084856, -0.19723659552052086, 0.45529232426684413, 0.7777380550982325, -0.1417086105851926, 0.384575359573606, -0.48393923993401766, -0.46630174253937445, -0.055151990476800264, -0.12987238100749363, -0.32705999998008406, -0.5760208273857144, -0.016379200785545094, 0.5460581910367431, 0.7109832868486681, 0.11838936945625048, -0.12348474247367622, -0.03211978577560596, -0.11854701768503256, -0.11279758068035392, -0.6068890087171644, 0.3693753173314311, 0.18462592330111985, -0.6822109542854852, 0.15194401520779094, 0.22834881039016508, 0.042098506612880525, -0.11233051192537863, 0.4743191204669278, 0.22490332500959034, -0.6242153659265299, -0.49801068274656124, -0.4827732814749263, -0.48017400796802545, -0.4274490038630158, -0.702033631006706, -0.3470251030178245, 0.44669737630146344, -1.0812830263015412, 0.07141261274520348, -0.040876754586770626, 0.06704966999583627, 0.2171771859343447, -0.4162005425964768, 0.47706151023319443, 0.4572909428756348, -0.21802279700082658, 0.28768924905480475, -0.4428388004478842, 0.23770623732238264, 0.21414631668610606, -0.1223720569068583, -0.02641089311618267, 0.023125439507429436, 0.10595406459216797, 0.9333721869088845, 0.4487424798504291, -0.8900762591792021, 0.007243370314889864, -0.7064928593229519, 0.4276766620649794, -0.005220378379076733, -0.45872046366188374}
};

static const float b1[64] = {1.0898442360804805, 0.99855593266407, 0.9863806639444208, 0.877510616480062, 0.8033156487100312, 0.9541290857470461, 1.0136405374532937, 0.9897401960275536, 1.0487515498723357, 0.791528630777469, 1.1013174613532177, 0.9574841391055464, 0.9732513603893199, 0.9501395963620723, 1.0019125139665406, 0.8471188328502366, 0.8919237487620036, 0.9287155621540721, 0.954701392498664, 0.9861096479559528, 1.0806032428773402, 1.066638197084168, 0.9893233529565323, 0.9406429323915753, 0.99717090866045, 1.0863926967601345, 0.9721747841899594, 0.9228831670359811, 0.9964841720021699, 0.9780897711453065, 0.9252469001291573, 0.9798501912687797, 0.9375846573664303, 1.1041973832287977, 1.0278357464731054, 1.000897362960842, 1.0685684758382588, 0.9516647579595009, 0.9564829509334588, 1.0011232704081907, 0.9859002417628517, 1.107585196411508, 0.9718653739535722, 0.8844419779083534, 1.0308352572635264, 0.9028286066159439, 0.8878519574835804, 1.0141218182037028, 0.9919144217842069, 1.0330495228754368, 0.9834416978009678, 1.1026293051059095, 0.8982300355122445, 0.9703581174403386, 0.9618005878840931, 1.027006340056275, 1.026971160811842, 1.0204571381707779, 1.0024655988081521, 0.9839343760922036, 1.0400439622018058, 0.7991012424256506, 0.8931972425085675, 1.046952123011252};

static const float w2[64][32] = {
    {1.0407134751302949, 0.6470579017565556, 0.5814896312768775, 0.998053193098496, 0.31398501456424055, 0.7174591334970021, 0.9419475634081668, 0.8173690782389167, 1.0804949095572798, 0.827310061011388, 1.0627315905805643, 1.1290296668627935, 0.8596883161804888, 1.016565467577153, 0.9633916730423744, -0.03560584598346719, 0.9111399208374316, -0.12261929091625118, 0.06404012187227541, 1.0848438426622953, 0.5858175939530715, 1.217555265166799, 0.9858724969347795, 0.525250249613775, 1.1910268495669132, 0.9424509167987195, 0.783084872256367, 0.9577878396093582, 0.8068786145109403, 0.9471949792048527, 0.6843131658908609, 0.8783166723525831},
    {0.7680574786083666, 0.6629551115853065, 0.7674653084183946, 1.064411414431604, 0.20280570882534882, 0.8036994585710275, 0.9235485016011847, 0.6604408524284476, 0.8818099339065782, 0.9469384658977166, 0.6566624543804499, 1.2073658302756902, 0.7177141189848616, 0.9868578453322289, 0.6155497348079157, -0.2827245357436678, 0.812303641121817, -0.4260343513084679, -0.03315530583362375, 0.6131159803013095, 0.7982757655230435, 0.9054592776126841, 0.637559451201902, 0.6758807425978108, 1.2223637396885003, 0.6895720869992557, 0.6943451296554202, 0.8792782978071529, 0.7826799399086918, 0.5348866268382308, 0.5562056608492988, 0.8216097492879901},
    {1.0163279728960575, 0.6788052891481456, 0.5130242661362269, 0.9544835373295268, 0.2644395896686336, 0.6878029248061855, 0.7689586701213488, 0.8655152579517706, 1.172930853604289, 1.0927506263055864, 0.8060437998439601, 0.8463176289675094, 0.76821486640237, 0.7066553818352034, 0.3504462067342739, 0.09044734052152212, 0.841249683802026, -0.16592468480791486, 0.07684643817086702, 0.7385568216382723, 0.6798743834854004, 0.8375194324521101, 0.8816306933655338, 0.634320110501517, 0.9806911982117021, 0.8250155476953664, 0.4807858269933133, 0.7682029964462105, 0.6463063893804801, 0.8550061621756323, 0.30146453350082536, 1.0949859073604757},
    {0.5767568443819316, 0.6238827307629883, 0.8818518326625602, 0.8636591037726995, -0.08472038083310948, 0.6262990892920802, 0.6489558969468714, 0.9267273494983633, 0.8211914680303669, 0.7604304094469064, 0.48940197367729255, 0.3577758268138709, 0.7139942486085578, 0.7875155085702419, 0.791637537711275, 0.013966015571068795, 0.8061784961492869, -0.2686401520288025, 0.1695503443748498, 0.7976784620501147, 0.5362342152014352, 0.8329350160145756, 0.848081150700234, 0.6423621269377584, 0.5967980261146214, 1.091846060348979, 0.5206337057697517, 1.0212119917377835, 0.5047255276936704, 0.9193255798257272, 0.8058335512978655, 1.0612433136299262},
    {0.9732772844646832, 0.7905646873115955, 0.7479455956190375, 0.5780350290035531, -0.11684437591288002, 0.7289909242990396, 1.010509056101098, 0.955797205149508, 1.0007246970336034, 0.6648271418721506, 0.679828547107519, 0.6332932857286188, 0.9112863425927447, 0.9228432703309826, 1.1464329487646734, -0.10933416183084317, 0.9469791289004774, -0.07812094957842068, -0.08734853575800451, 0.8311273001676103, 0.657120649718888, 0.5698248586560033, 0.6987424181881375, 0.8419223197487848, 0.8663268316577052, 0.9883317157810932, 0.7655456253791507, 1.050591112707475, 0.9687948669798202, 0.9726699122648429, 0.7531192249109985, 0.9090125637122382},
    {0.7869880484169804, 0.6684531982527521, 0.9469716014837903, 0.8786769131212065, -0.05263525934435037, 1.0212636822240577, 0.8233788239408105, 0.6176444816836795, 0.6210419922882281, 0.7169828324992991, 1.0725377873509576, 0.9716315169731253, 0.6943475225196988, 0.8249426339788565, 0.8886000153984935, -0.34458418505413707, 0.776394963795732, 0.01572988135235129, -0.39874983846237705, 0.9564593004915661, 0.6971531456213832, 0.7413568402757215, 0.7871637935154162, 0.360263392933859, 0.9349299235802759, 0.7901753105587453, 0.5111244051083983, 0.9713616402788408, 0.8204177208119627, 0.973205632557696, 0.7455768014058785, 1.3218671644759779},
    {0.6127839247782383, 1.0413652269588185, 0.6992268336732786, 0.9715022787119301, -0.17816118145709606, 0.9010524409055216, 0.8909543295316202, 0.9474198606670499, 0.8748857246903231, 0.9577358199910033, 1.361024312634477, 1.0542509926029915, 0.8224772342756572, 0.9476577706180732, 0.6185925524155933, -0.018933038060139396, 0.6607307029207112, -0.16862509655994565, 0.0671306178513714, 1.1324580219835332, 1.0767577950133052, 1.1045402101190855, 0.21296908227146294, 0.505990658804764, 0.9891892151871949, 0.7581251305000106, 0.8969035013907481, 0.6205904265548482, 0.7568537922710541, 1.195408609520346, 0.6596468894727723, 0.7036409828570545},
    {1.0976114016586753, 0.8746920678274301, 0.7170197298404957, 0.9063586973054123, 0.006476788892310917, 1.0062103038912504, 1.0126120069619593, 0.9387984341555891, 0.8565859721071793, 0.5821065584157173, 1.1305507614277581, 0.7922179920651095, 0.7169704016966452, 0.36097007860817415, 0.6654127308371385, -0.3573841682172655, 0.9744979044949632, 0.045809835820968994, 0.0039621966273515165, 0.9053921749414435, 0.37457284852339306, 0.7730650964018326, 1.0360319736978918, 0.5426174584535486, 0.5565811132993514, 0.651594791972811, 0.6854877936713454, 0.8417754576052229, 0.5019656295976107, 0.7932831967580682, 0.8292207391145594, 0.6234330090668518},
    {0.6104798017373961, 0.8277350935382827, 0.8407025081342929, 0.9256950252193075, -0.06514015135351908, 1.1403262040417836, 1.0089274032014848, 0.6764402716305158, 0.9968575165229835, 0.6961923557188229, 0.9974319120473212, 1.054839414574396, 0.8800489646527051, 0.7430334684975969, 0.9718523035030339, -0.20815846654623646, 0.7440642946857112, 0.08725282453853847, -0.521967562163405, 0.9130691343563744, 0.5640541673776889, 0.8811080300577887, 1.0301471567372513, 0.6549379468336342, 0.7534681698194009, 0.7639680226566609, 0.6576977958234386, 1.1497742306970398, 0.8795460631448286, 0.6435131226545504, 0.8219417080025194, 1.017708764066967},
    {0.549714086190357, 0.8564697243893521, 0.7883284601352989, 0.9001592877085504, 0.1190441212314505, 0.8170923075077918, 0.9576522385067984, 0.5280986125671746, 0.9275356599448864, 1.0325921364048052, 0.733616124780238, 0.4625227749136106, 1.2757413204126378, 0.8202635081863114, 1.1114702013063162, -0.39008480068857376, 0.697458599841728, -0.04205764882202677, 0.11090535100229092, 0.7576170177101829, 0.6576973239420567, 0.6843497654390176, 0.7561048871883251, 0.5537584050845605, 0.9634377870924095, 0.15565520429078022, 0.5369880171297272, 0.7064326143412697, 0.6261845815693398, 0.9102542133391466, 0.9816318562320285, 0.774207301840357},
    {1.1357285727219173, 0.9357362896265247, 0.8813323061946479, 0.9452325217509612, -0.3436824572362312, 0.7952622257995328, 0.8587824253317873, 1.0371824581743303, 1.0241269373975048, 0.9997068367518834, 1.3531640949601336, 0.8902528977548169, 1.2544241167664698, 1.086218298678174, 0.77746564188166, -0.250188283814716, 0.8403097615479054, 0.12518895774138059, 0.06970787046614675, 1.0421757833036864, 0.49070451066319026, 1.2876077118661986, 1.1206338793614878, 0.59009772977516, 0.9440137157298129, 0.8874101434195015, 0.867741159709836, 0.7486911804411005, 0.9374022526465172, 1.1629954632554116, 1.0815074681316525, 1.3978835610089162},
    {1.0271876060570244, 0.8611672493644094, 0.890618489304819, 0.8765792716047761, -0.1612057773966723, 0.9245957206392559, 0.608467864184036, 0.8663392392970628, 0.7794087066707928, 0.923832793760202, 1.0603101799081411, 0.7755762819552237, 1.0436360729318055, 0.9396764012750343, 0.871420296373506, -0.11341180086469248, 0.8650743792692714, -0.10545422125626813, -0.39564238808419233, 0.797789996983673, 0.8439532406258, 1.1770484113496262, 0.6816089811633284, 0.5387962909976446, 1.055087341527377, 0.9010120101296276, 1.0414461857298858, 1.047409029300788, 0.8126128112770278, 1.1143136821592043, 0.7300990723994477, 0.5641889308565629},
    {1.1639938263950125, 1.2613561842874585, 1.0552157933980266, 0.9104872953263696, 0.059495433041454784, 1.1812833936233893, 0.9889596959086661, 1.0963134526947544, 1.2139407032033827, 0.9773415445135046, 1.031124228997563, 1.2277790972630558, 0.8456895053683355, 0.795185503119218, 0.9654142504651481, 0.07689002081607302, 0.8866423672100181, 0.1964362741390366, 0.3568961854613521, 1.0250500019490056, 0.8121452261321194, 0.9954259274808596, 0.8087071552550028, 0.9893402403203494, 0.9437173299648208, 0.8583104202418835, 0.7847436342478059, 0.7492689575977691, 0.8830592777847736, 0.8264222558050658, 1.102326159195059, 0.6426413415058878},
    {0.7035563707200213, 0.865818068089352, 0.7331376164065782, 0.7591525840631237, 0.045400439195609515, 0.7006198600031759, 1.119663542549459, 0.7806578246252892, 0.833282309543889, 0.75069971215641, 0.7182631570286735, 0.6939096533168432, 0.8044541734096706, 0.8610173947205595, 0.624413255221243, 0.04396968221692787, 0.4621351138217166, -0.2242774500770436, 0.2597901559145029, 0.6321378224462776, 0.6450043337335051, 0.7842807092998177, 0.7298675281588297, 0.6652175666330571, 0.7999641870674569, 0.7022296304068453, 0.644442768738626, 0.8309876328920129, 0.5370370648747338, 0.424112695941469, 0.6590551574982759, 1.0372009101793742},
    {1.0979345576207766, 0.9385407774632473, 0.6741699792434626, 1.0074402746982127, -0.07959345149084615, 0.6988490839228394, 0.655966873033623, 0.7280144782393038, 0.857914474397515, 0.8773755049369273, 0.5360180241092033, 1.016785876216649, 1.1081592673263216, 0.7018567715769898, 0.3096396253258437, -0.38616379593442113, 0.5930905292237918, 0.07262976394844088, -0.04400347323853593, 0.7473976946628996, 0.5864056008559352, 0.9280613890448314, 0.6759615272131457, 0.33598056549059935, 0.723541427424481, 1.0254508346751534, 0.6246199922466523, 0.9308265884905496, 0.7297928889354797, 0.9295288802548879, 0.8188209310290991, 0.7911352660197554},
    {0.9476407448758427, 0.9868311982925411, 0.9047675074858965, 1.0309286197333425, -0.1907580328574625, 1.0611759962840384, 0.9142911192419001, 0.8889008098005333, 1.02254764710933, 0.6956580194615728, 0.5720962532947417, 0.6445114610887323, 0.7964567314585794, 0.95771680086069, 0.738781244532116, 0.29408400553750813, 0.7775302194502421, -0.1209706437397996, 0.09632273499206964, 0.43734029886925835, 0.8708299214186176, 0.7063651985222028, 0.6899316813283233, 0.20973984132355822, 0.83340371329051, 0.7933951991913331, 0.6398038759316557, 0.8822786400209043, 0.6945965925355152, 0.8950109896322266, 0.7744730465350494, 0.6720998747186078},
    {1.1211057754893552, 0.6839063341649024, 0.6965071884067934, 0.7879921963007506, 0.0708938888934473, 0.9439268575030862, 0.6220268520760421, 0.8917520563513823, 1.1810468186013012, 0.5929779275381218, 0.6278999231188116, 0.8706013350684577, 1.0800502139762183, 1.1905337948498107, 0.7821395338790883, 0.10897905771550956, 0.5535544871214283, 0.12062328923872809, -0.2970759361654936, 0.9727510767974893, 0.6817606943534841, 0.26630543692364067, 1.0171180100705257, 0.8347837660057158, 1.0001652223859063, 0.7239266928046129, 0.8812140394208253, 0.9617373069234747, 0.7310661004043675, 0.7699813635754189, 0.670643086062066, 0.7442214780802288},
    {0.9625568506433013, 1.0059235519066068, 0.5355032566509054, 0.7581833536930445, 0.08608164813592988, 0.8467365285422244, 0.9529418954495965, 1.1346630492394851, 1.014216935616545, 0.9414348866974798, 0.7758023832441967, 0.7037583948824402, 0.684680277924407, 0.6775242760924327, 0.5732770307429231, 0.23615845606530134, 0.403825696617357, 0.23184759222977477, -0.11323748523442197, 1.1177998518275922, 0.36249601389920394, 0.6819298297142601, 0.966750408905599, 0.30805124752803953, 0.7310786330669659, 0.9064478235920655, 0.8966177244147313, 0.8355641765129387, 0.8560684998459079, 1.163483367950694, 0.6913401605220497, 1.1444003643719065},
    {0.9782979882979691, 0.7459326291163468, 0.8613401259872634, 0.584881938372644, -0.2875771828048852, 0.5746739494087987, 1.0472691992275434, 0.6823286492261993, 0.7264445669228532, 1.106837475493476, 1.2196982841927664, 0.784595236356262, 1.012810378950329, 0.7441718424878898, 0.8664041933410599, 0.11229838588959473, 0.4868701492191094, -0.20825167605491257, -5.576642851108494e-05, 0.6000359430382494, 0.5094676533785867, 1.0003386453865446, 0.8270270752668357, 0.9347730332530796, 1.0904065063496562, 1.0844386631210599, 0.9028790733243489, 0.7915350225222553, 0.5415317546912951, 0.6661831274336162, 0.7450590165234856, 0.9571950968278727},
    {0.8117872388369509, 0.9935296386645427, 0.927423099523851, 0.7149329204364999, 0.03224388369056698, 0.9931935767130846, 0.9255483704095835, 0.5355271965941348, 1.0806865742572291, 0.7545534010475027, 0.6685354121402229, 0.9380100490206027, 0.8398045535812872, 0.8985431191051585, 0.5649768402885448, -0.13275026181620606, 0.5399375254124553, -0.159333939175824, 0.03308254905402659, 0.8578298761745814, 0.7101113345133422, 1.0016757185374368, 1.124675559001042, 0.37653169656012747, 0.9811252893196055, 0.5044072952443301, 0.5655033041857446, 0.6693853009609567, 0.7802761840578458, 0.685226718226163, 0.5216274696636417, 0.7079650904380874},
    {0.909251121581579, 0.8354812534768365, 0.8667417930676488, 1.057848799923508, 0.06605786595170432, 0.7624983350773645, 1.372854772704114, 1.1818193826817258, 1.17504152825334, 1.123519296441433, 1.14232868775664, 1.1453215027942447, 0.6667971937751223, 1.1608761465930517, 0.8467361857143674, -0.3892007747044857, 0.9827318328101762, -0.1852656613560412, 0.05106678686528197, 1.1310816068055236, 0.5706038514657826, 0.8530564388847591, 0.7960710844557953, 0.785994538382198, 0.8085009634475573, 0.9020291639102519, 0.8478139707031547, 1.1051524493333922, 0.9617192248210724, 1.2796237396654584, 1.1993106624033874, 1.1008877991565813},
    {0.8393267080832396, 0.9333662532512167, 1.0876605102897667, 1.1715596941251352, 0.05778994923072983, 0.8691093195211518, 0.7968289613477445, 0.8383804241719623, 1.2135101041153973, 0.8629327691951809, 1.071031120010391, 1.0815980711003588, 0.6422133410418555, 0.6771881529145433, 0.9040661052208536, 0.1473292179846645, 0.9179360326737478, -0.013176847697465474, 0.14578075042077251, 0.9332918610331059, 0.24793267166167676, 1.036405534050887, 0.9061574756264741, 0.5817795396541686, 1.2342163210309254, 1.1688950261110918, 1.2293019670319068, 0.6407641947654993, 0.8071618922952245, 0.9099595209177432, 0.8693860993509965, 1.2726502605978944},
    {0.6190835910886063, 0.6947450410764815, 0.3020370210981282, 1.2407746492910148, -0.19212872491344593, 0.8874273358909446, 0.9400331943351035, 1.0853923600430848, 0.9216912574754692, 0.8183533461552032, 0.77502595317799, 0.7494665710543019, 0.7202858051213827, 0.5242819773406814, 0.7395250401649589, 0.13464177623824772, 0.6182472245460513, 0.21793341491330587, -0.04228845756141178, 1.111093536675656, 0.7053834506230884, 0.9687146876822852, 0.9019201937895671, 0.5731829968261797, 1.0008916421330936, 1.078424158021375, 0.7449049318107953, 0.8779231169522563, 0.6492218725245932, 1.213292931772079, 0.5505661519169741, 0.6323163166086455},
    {0.6281036432425289, 0.8257285852509779, 0.6170665652971582, 0.6683956654716711, 0.3509087624986489, 0.8221997400865574, 0.8001166589957515, 0.9174885397315723, 0.8235367126543273, 0.9585003020357201, 1.0722037816031913, 0.6560599007776039, 1.2041532331612488, 0.8563720912110404, 0.6773235758583194, -0.056823299206348286, 0.9374656920358475, 0.5329402765972069, 0.05397179597681761, 0.8515001398420542, 0.677369913071198, 1.1302929260391363, 0.6221710844743229, 0.6164822461984065, 0.8989807240220481, 0.7291628929428665, 0.4423751848577086, 1.1692612142387488, 0.9450724544602671, 0.7725315708306013, 0.6395127374855124, 0.9348511471981398},
    {0.47139713746516865, 0.6294429601887351, 0.6693828045695914, 0.7908409924006046, -0.04506747643365561, 0.9940399553429242, 0.6766180164405897, 0.8030697817739393, 0.5983095353375782, 0.5168098157458353, 0.7790598715228724, 0.9823115452517289, 1.1758662009864336, 0.8191338636502397, 0.6246591185422374, -0.21709724249743434, 0.6218367558496631, -0.0243519815628357, -0.16538766138136785, 0.6202267489850967, 0.7151834887193749, 0.9593026630423256, 0.7821284696043255, 0.7409741575614868, 0.6972857771178658, 0.6672084574300617, 0.7591061848651166, 1.0373305751953334, 0.46449893914233914, 0.8392444996550557, 0.62646710803271, 1.0416758575828513},
    {0.7661326302617674, 0.6293592963471966, 0.8379232382852145, 0.9358334681019844, -0.06524127530779023, 1.0771079670954136, 0.9113534972173672, 0.6279950740846069, 1.0248294769662023, 0.838835718237994, 0.9867631785194744, 0.8191144650343977, 1.2585786933773822, 0.7645036454641911, 1.0504776758075058, -0.1514401511298124, 1.0225197306251723, 0.026015021684983968, -0.33298434568895013, 1.0836222495753713, 0.9873737469250972, 1.3153455600251196, 1.0549279992347613, 1.0795796928894943, 1.0090839995877652, 1.1463311113528938, 0.83438131793835, 0.8735027730253456, 0.6028779833911193, 1.2548440884808365, 1.0291512968036782, 0.9648048674088527},
    {0.909596800198343, 0.8767376320800858, 0.8178287056739103, 0.8071982127113979, -0.18850443563275648, 0.9146689315632532, 0.6123133801191488, 0.8986264328691327, 0.974814036146818, 0.6683636066580357, 0.735152264017851, 1.2512736505350979, 0.8723084118606731, 0.8868288039727215, 0.8906161288306722, -0.22225639569523864, 0.7471136431067236, -0.06120939467575059, 0.08894327191733985, 0.8675429425890642, 0.5054777933623699, 0.714139141976964, 0.8343959742618433, 0.594673947892475, 0.9992867047990044, 0.8838075060410358, 0.5684154453757033, 0.8777178105390644, 0.7176975720925207, 0.9567455072848569, 0.7428394091253534, 0.9122890532831645},
    {0.8357690801191805, 0.8205171559713312, 0.2623647597695549, 0.818358140789065, -0.11274096351018206, 1.0612202406528395, 0.698437569141919, 0.8247397614850802, 0.44228757262097057, 0.832005034632661, 0.6468351601679051, 0.7550452089104046, 0.842411366248941, 0.5325506783252087, 0.6235799818280231, 0.0705326918938534, 0.6705840794533452, 0.21738831877709625, -0.09484416330855967, 0.6324075748216441, 0.8151033489510484, 0.7142144193686132, 1.1314543209609944, 0.6213884106250461, 0.9815433146404582, 0.6801509956326035, 0.3901685170040349, 0.7157285064418721, 0.527940513629633, 0.6885196463633236, 1.0276830331156435, 1.1483127641936246},
    {0.5026169626349755, 1.020925192627663, 0.733629286843076, 1.2700973149009416, -0.015852368242818608, 0.7182731974423029, 1.112814788582, 0.9463295947141991, 0.8002748215555813, 1.124350342460737, 0.8370906643259008, 0.7539598280913569, 0.9061514504715569, 0.8428715675867898, 0.40913645944646393, -0.06166733885950695, 0.6869890196043301, -0.1634127014061022, 0.1826947432103067, 0.40714924449682843, 0.43334638107988166, 0.43201339371054026, 1.0252688187693542, 0.6500451931188574, 0.9053365563327556, 0.7631406502258884, 0.6215463975281155, 0.6299823197829626, 0.497923082968191, 0.7147543758939072, 0.6374931360328538, 0.6909347462645037},
    {0.8423180060685179, 0.747183130637791, 0.4354525185382434, 0.5175476570917088, 0.10796543544960349, 0.7408791272857796, 0.5768372529004061, 0.976406578530218, 1.2180770876265152, 0.8511446490054753, 0.504681329691173, 1.047951564594879, 0.9917489316771771, 0.8761304130502869, 0.47366159548705206, -0.22517066846848258, 0.5264863242276463, 0.02229543410823187, 0.12253745519149807, 0.642049938193473, 0.3677757077860536, 0.8097515379144342, 0.8916430341445325, 0.6840789496545864, 0.5859154437929947, 1.0859404432483648, 0.8228376079006986, 1.096212392690531, 0.46826047433878587, 1.1728390761876217, 0.7065663155514892, 0.86975371560237},
    {1.020155248325091, 0.9299932241265338, 0.8050311788704155, 0.9404984476951647, -0.09705635036684825, 0.6430588724023585, 0.8362770032180618, 1.0848182685358871, 0.8129439793001849, 0.9100710524328393, 1.124488932907328, 0.9153657747686116, 0.8854718273000693, 0.8549901809869754, 0.58219164782366, 0.13199518214712277, 0.7096972806045537, -0.08055801067145768, -0.049639154277192274, 1.0596879879582881, 0.7302500818200426, 0.6773194444173588, 1.1915542528545269, 0.7623275689688187, 0.9646194467493261, 1.151094896414243, 0.5201456179297592, 0.7021131451739424, 0.5376136943359677, 0.9281808455734509, 0.6844750887916549, 0.7733521748116983},
    {0.9676652662956816, 0.8401970361267691, 0.4433306400488895, 0.7020675130895038, -0.21695897745757456, 1.1412768649204863, 0.8218429332147393, 0.739228763715145, 0.76738547288426, 0.9024697497723821, 0.7774909211661493, 1.1416810796253634, 0.7622610408541916, 1.1286331248604997, 0.5722926081263938, -0.14386519371157722, 0.853257146164542, -0.08347290062225385, 0.06621903671528138, 0.9093911114606339, 0.6691996365766977, 0.8511601571097066, 0.9786847217838984, 0.6443198344383327, 0.7766060562029516, 0.752692151507858, 0.5557988371446222, 0.7807906619884964, 1.0280432670998898, 1.0930047484056966, 0.7058800793667093, 0.7652427443329334},
    {0.6987270568244152, 1.0581941533594605, 0.6631697494748787, 0.6450429024352733, -0.11674019078860735, 0.6606221003764017, 1.0308412652029448, 0.753372378061645, 0.9693854986862421, 0.9227772402863131, 0.9432113008826198, 0.5133239716166365, 0.8677489615757946, 0.6199335834200738, 0.6074182757523413, 0.22373219282654466, 0.6820895338839941, -0.17459452940558234, 0.12685421188935203, 0.8960345354771092, 0.6190096252492863, 0.7021380836365674, 0.9624452771276693, 0.7467686432232675, 0.9650035751378953, 0.7790840682638999, 0.7375664649491267, 1.1090888400051495, 0.7314054105042435, 1.0780186931957707, 0.6946916098571209, 0.9043056615007318},
    {1.0714275414459584, 1.0885047195213438, 0.9931161097935342, 1.1821439382000056, -0.2282293569089484, 0.865523784703653, 0.7599766881259258, 0.872218911537874, 0.8278636759533248, 1.0441504324138147, 1.367093550946212, 0.8744077710020561, 1.5137785995165078, 0.8907729374466401, 0.7415632749541567, 0.039715247815552066, 0.7080938781313272, 0.04008378296051756, -0.03570396467704648, 1.0077548175746558, 0.7870688234296088, 1.0943777553300882, 1.1760154138327, 0.5141133381289004, 0.9133215239049086, 1.0103181899018774, 0.7588678573888722, 0.904879172316269, 0.7359866769855677, 0.9071177245057638, 1.0100757485554812, 1.0392009660732742},
    {1.1537704685080317, 0.9091188582166769, 0.7438487113708713, 0.9450019170181455, 0.04060817416896377, 1.2452989474272769, 1.0563790803976056, 0.636559768422208, 0.792788466646136, 1.0006591253191064, 0.8410283937232457, 1.0402534698035142, 1.1961819238490572, 0.7771935358443707, 1.23036756191963, -0.035516096232452915, 0.7626542202105717, 0.11240043116668838, -0.08031043729958107, 0.7918572266627637, 0.45600930854630506, 1.2510906273300175, 0.664622563542917, 0.667063593609115, 1.2670557602088206, 1.1622591695285835, 0.7324450870745207, 0.8518092485793413, 0.5889770527462992, 0.7754076430461246, 0.7955155423741707, 0.7205019204801878},
    {1.0629034887956608, 0.8409630524830252, 0.45552924506125464, 1.2435470151125134, 0.028444058583317444, 0.7212233175079065, 0.8341067385554821, 0.7271188577523722, 0.9013788832887829, 0.9440520311825402, 0.8451409339318331, 0.9041769246882175, 0.9014588507530087, 0.8996987974971341, 0.8833723943897995, 0.03623474042060362, 0.8812727142583386, -0.15711668030793824, -0.23268514073138874, 0.8525617735768973, 0.802856991816899, 1.0655721285343396, 0.6931285663815934, 0.9162071628485424, 0.7115041081690681, 1.2368441047956107, 0.6013194138182671, 0.7845351925365951, 0.546509870303884, 0.9413478473095823, 0.7501502148368642, 1.0102969605433088},
    {0.7818545476301635, 1.0859528572141548, 0.7761142793256992, 0.9036124760173442, -0.19293445082224317, 0.9786196830057895, 1.0426948642378033, 0.9303895457162846, 1.2329911856651663, 0.8797399002897379, 1.225413113475782, 1.274364206815757, 0.540617080185817, 0.8226131853256013, 0.8565893891317841, 0.17277749285338073, 0.9101911366468571, -0.38235614628464126, 0.0723322627528728, 1.1325633023882535, 0.29008359072793777, 1.405195016857263, 0.9694367472361897, 0.9284999992650537, 0.6948669030147367, 1.1798925002866953, 0.7886538136921921, 0.7702780942541925, 0.8882919411760881, 1.152408693829904, 0.8547145867384524, 1.0181550166849043},
    {0.8118752621383477, 0.8066066766624235, 0.9074007966430322, 0.8221691537743506, -0.06579699927046591, 0.6307583270026973, 0.8378345367958577, 0.7624209788460006, 1.1781753852613106, 0.5317181318020331, 0.6255809432629088, 0.9325928401077668, 0.2625939036244301, 1.0071835629475538, 1.0053074307360046, 0.11829511103099911, 0.5339243309688594, -0.10409246571179437, 0.08479693430883313, 0.40521932500836, 0.7857034520243084, 0.9323142863539702, 0.9474787576803233, 0.7295193791822328, 0.7657364507168105, 0.8750496303338644, 0.9857308523378677, 0.8696400022830799, 0.5402484865183754, 1.0749767154338874, 0.953766221299713, 1.0320579759972708},
    {0.5852311921058753, 1.0837111689939651, 0.7016870595117095, 0.9991267219468747, -0.25353505565558154, 0.8921356268693905, 0.8454149777133712, 0.7796973548915136, 0.9759239728838064, 1.0510774530040903, 0.9345571689819548, 0.7065085987206154, 0.7942339801992555, 0.8602646395958502, 0.5532146168956673, 0.19161223481105227, 0.39891901027138654, 0.17492071211054508, -0.14860296767534237, 0.7749684204347519, 0.08083734118134298, 0.7584115832325822, 0.9630127071681261, 0.6076905418936359, 0.8819409197052728, 0.895578120481607, 1.0533053782262807, 0.8845536248967528, 0.4314961798712023, 0.7848685435098881, 0.738911092241352, 0.9085850120760737},
    {1.2163677495515028, 0.918041425029193, 0.9679254663089361, 0.8075039783738046, -0.18408227376752287, 0.9494531216823138, 0.9542030876605052, 0.7985941649235835, 0.9662019951152189, 1.2609914421992066, 1.137650321875135, 1.207987114666159, 0.8401044146989406, 1.00067978448923, 1.3128151473068723, 0.06759270724160764, 0.9150035272296573, 0.03170178485176694, -0.2238082731320002, 0.7571421461886012, 0.6363892988832682, 1.1144474413331058, 1.02201998160915, 1.034924149240743, 0.5020966692809352, 0.7609525503924811, 0.6959534742433219, 1.0740374680670781, 0.7943990012335305, 1.0512572315392847, 0.7744911980796176, 0.6068152769912711},
    {0.9072952785130213, 0.8652433505782974, 0.7477257244828741, 1.023470936232875, 0.10035313129316181, 0.8234985936498666, 0.6502892491976323, 1.272520678329008, 0.7404065317966588, 0.7953863746381599, 1.024037756159106, 0.7301293610175309, 0.8785228446415004, 0.88327115500637, 0.645778542740531, 0.15747910868541004, 0.40840124581651627, 0.012148083186061767, -0.07657491118527678, 0.9433134955449611, 0.6719796822534556, 0.6890121179007339, 0.8664250903828328, 0.27438650440997964, 0.9521335392932246, 0.7822315434816866, 0.7406186610662658, 0.6982552446514231, 0.9216214703400175, 0.953115749077186, 0.9861182165395832, 0.8016080144939487},
    {1.0119580669471622, 0.619757020825987, 0.9126009432213666, 0.8730719337093629, -0.1508464641550943, 0.7435245358938426, 1.1604185868130479, 0.8898857546836709, 0.8225521399029113, 1.015146985854691, 0.9210343345732839, 1.057898407820418, 1.0572114393309509, 0.8057295026895126, 0.9901073992616435, -0.3238263483897043, 0.9695741801427225, -0.28020707318795374, -0.07098103503282847, 0.9718267546547397, 0.8279240859134631, 0.9073022418730403, 1.1245856576487285, 0.7606930730847821, 1.1730776219751555, 0.8168033059469547, 0.8169714705035405, 0.9811732349171058, 0.9301374575454189, 0.8595742770924012, 0.5478318294501067, 0.9718634581573573},
    {0.85138504671572, 0.8114630169328251, 0.5609451393921018, 1.081105436394665, -0.09245437483537966, 0.730983851625383, 0.6248088853157086, 0.6527280929755327, 0.6459869299872711, 0.6984788077987125, 1.1628460961864846, 0.8635536091175176, 0.6355342292274331, 0.5869817433535338, 0.5345803768973747, 0.05900382012620547, 0.5386405939519526, -0.3265489524439144, -0.23832775122517405, 0.7968210399967773, 0.691347837999501, 0.5325306585656837, 0.8971084449434319, 0.6565498002749729, 0.716832030944411, 0.7498970400711631, 0.5512159975046755, 0.7307671929614442, 0.5245631969128727, 0.8323805103365668, 1.0439691197956489, 1.0433224969427308},
    {0.756942126754556, 0.6531339909789513, 0.6402029012188708, 0.8508528283489534, 0.2125187095913069, 1.0496213517615443, 0.7946390455955369, 0.8863782166535259, 1.1808115879209795, 1.0037008495227784, 0.5619249798352456, 0.5216914174550615, 0.8968975833185927, 0.8549536751972391, 0.6572292277440279, -0.18370906317268473, 0.8032417566215757, 0.0009372738300727697, -0.3164080309032897, 0.6760327302762184, 0.44713527654878127, 0.6852325693468859, 1.021617934876218, 0.3905919579546916, 0.6036074239700991, 1.058074976679032, 1.115003519867808, 1.013837902567981, 0.6535994007440938, 1.093422455429471, 0.8408234371880032, 0.7315553703293676},
    {0.9620119301162073, 0.6722484772400125, 0.128752623562579, 0.9922241675058766, 0.28194291809299193, 0.8745465648426305, 0.7500715728088679, 0.743472750639555, 0.9343105690215059, 0.6666466931601784, 0.9736663948905194, 0.7713543667547115, 0.9517590947166742, 0.7393395250036734, 0.5787282811997345, -0.05709033966304537, 0.5138578669903663, 0.10714576583329045, 0.004610852144458378, 0.6839400716497748, 0.7356459135301308, 0.7371513328187718, 1.1944581547466524, 0.6500990543917694, 0.8977101439873325, 0.9612242227288372, 0.6629443487882455, 0.9838835927376531, 0.8300839079894905, 0.7559624906487176, 0.9433226976363773, 0.9768742910013728},
    {0.9199566167000974, 0.7326061970474566, 0.6658906916405626, 0.8502898644873936, -0.2779955398224835, 0.8141279235620558, 0.7336428215572226, 1.238655728516239, 0.8119336614376428, 0.9683566918400883, 0.6765764057616023, 0.9349028903432671, 0.7747081951882936, 0.848119436203336, 0.6294457978628284, 0.09905124410118943, 0.6730393437491138, 0.05988495759979762, 0.4062768442287006, 0.8617066599301308, 0.4785591415434895, 0.7677227966979034, 0.6802811395174062, 0.38522490347701954, 0.8946383623893184, 1.0218734816991712, 0.859424811066987, 0.8114272728362231, 0.5675744067960216, 0.5013566558747946, 0.5311145271628459, 0.8929279510567435},
    {0.6848139265929937, 0.8604905675706686, 0.7373349175937237, 0.7569912754165546, 0.1722521895019522, 0.7378104872310506, 1.067948296783482, 0.8888174121367413, 1.0710976276676423, 0.668716177567061, 0.6916847401565751, 0.8529824604660357, 0.8858441401763139, 0.6007497689923441, 0.7393345049705227, 0.022719777845569222, 0.6812781640848005, 0.1891520587759622, -0.20031068536809776, 0.8003611667691071, 0.5956446613485054, 0.930607755914419, 0.5496303693841803, 0.5552696770630162, 0.8271278347293677, 0.8010811001959387, 0.7477707984957865, 0.8561119149280972, 0.5801713998115801, 0.9280437004914567, 0.7261676891069545, 0.896692816681455},
    {1.0687302753170709, 0.7567190582882695, 0.9209871286819391, 0.9710946773683959, 0.0501383926364489, 0.9385359679840851, 0.8792263650819461, 0.8477332065892472, 0.8135854067544868, 0.9371349636253357, 0.8911572481562114, 0.9791355190327832, 0.9788134263840199, 0.739828614491868, 0.9782363790666219, 0.2149180959351437, 0.5231971391598743, 0.09148410053464523, -0.019826643197802602, 0.9801007599412067, 0.7564177952007367, 1.0251204368021605, 0.6814097054892543, 0.6230622733953478, 0.8170099386010069, 0.6632233797811558, 0.8514817385696577, 0.981990581828741, 0.7046594792823438, 1.1711654945004226, 0.7420867523177647, 1.0933962894166198},
    {0.9002491168978543, 0.6433600038013472, 0.7908244623888935, 0.7782537205914773, -0.21484936787297315, 0.7926249726602648, 0.9055752047117136, 0.9559781418526118, 1.3331399883745352, 0.7945769422920576, 1.0296034583932792, 0.9630625171726864, 0.7874315893829407, 1.1113312235426378, 0.7847220102769547, -0.015613606921233907, 0.5837619259710073, -0.029101722045252056, -0.16499221171332418, 1.0018397928860874, 0.593215237190966, 0.7867598418643693, 1.2582825167967981, 0.9786263842280651, 0.9903916133938279, 0.5495335446440961, 0.6283562944596965, 0.3849359560750114, 0.693097991077758, 0.8130479540795024, 0.9681360840375389, 0.612431054323968},
    {1.1589667601131557, 1.171271787812148, 0.5058060054059421, 1.0303697851729792, -0.07968026789869184, 0.7208708158865328, 0.931912207645758, 0.8999044494463344, 0.9920162790606464, 1.0509779182085817, 0.9072117874371439, 0.772571086215708, 1.0728342893622478, 0.5516231892496736, 0.7465641902156018, 0.0015814334251942098, 0.598336965883663, -0.09922388118546088, -0.07330350385266625, 0.4590908766617725, 0.6231925986822122, 0.7638222369450449, 1.103688087205034, 0.4924016731460823, 0.9848318201019126, 1.1180484502947818, 0.6820784700517771, 0.9440660095154689, 0.5461112271521912, 0.8190145306163821, 0.9825639332356201, 0.8800364528429161},
    {0.9895158444212283, 0.5657812041672411, 0.9709015558834517, 0.8906982322979393, -0.06324849029953407, 0.7358198317678154, 0.8859404207449633, 0.9108185125025537, 0.5189205379004942, 0.636078918738217, 0.8154647173908501, 0.8631718500618398, 1.1449083117844787, 0.8264101882684165, 0.5835533666853701, -0.09012327390597834, 0.5967833082848536, -0.19408170069944847, -0.17361218800593625, 0.7056921679971521, 0.5247127318923805, 0.8952189562067353, 0.6677153681617221, 0.6356802834741736, 0.8328370463421128, 0.738482757968829, 0.7213195350197988, 0.5841989919057532, 0.49748820869896265, 0.946752917338462, 0.7430721748516579, 0.9412939458968336},
    {0.7357303765747663, 0.8196551311468658, 0.7580367016345497, 0.9500287953757219, 0.06106986868381367, 0.7438652232118533, 0.9338989912622565, 0.7563697799929678, 0.9817297693062759, 0.56968794450122, 1.2628435101909674, 1.0942195290823098, 0.7277794536231644, 1.1213843833098847, 0.6447467426552724, -0.26122078862931075, 0.5903927845921303, -0.11624712640935424, -0.05437580755322681, 0.744378000526027, 0.5040359824284973, 0.7004866634744423, 0.8586484077288324, 0.694509198180479, 0.8414601939803324, 0.93064041068129, 0.6234139581304322, 1.1462880199423344, 0.9217810821186122, 0.8965626988226024, 0.7441406550973536, 0.7072447132911739},
    {0.7237483484022952, 0.757101497154071, 1.1636956544330659, 0.7196066038113366, 0.11276312492247913, 0.7268293997488638, 0.8773124233043872, 0.7331058472344876, 0.8493283545231016, 0.9835009716547319, 1.0474936429816994, 1.1680035117937477, 0.9998305826486418, 0.9068606109147865, 0.8704678242087196, 0.2795401999531144, 0.5197629662930465, 0.04196417421749762, -0.054527250861564944, 0.75014890939157, 0.8166098003635477, 0.9107582353815545, 0.48422616329966917, 0.6960160681740911, 0.7776648476937649, 0.9193317247810162, 0.7646422459701298, 0.5961877649109671, 0.6713693478583164, 0.8127541239643844, 0.5686675587710575, 0.957672638125178},
    {0.9713154293060163, 0.9930304295561441, 0.5932957406521937, 0.5786335047561969, -0.42385197475334724, 0.9022145106599848, 1.0962840632146755, 0.7023546830584869, 0.6455270785540456, 0.8371566759579432, 1.0784030114366276, 1.0453401210667421, 1.0169610112634058, 0.6508312916872705, 0.43949416240806427, 0.21282878814011663, 0.6621553036680425, -0.25162404833305246, 0.25015714698927494, 0.8384202835115567, 0.5345361590210713, 0.9021906010428024, 1.0703654793580266, 0.6837710512193728, 0.7636495467927186, 0.9686912019697049, 1.1202271342828283, 0.710740485969377, 0.7510221102415514, 0.6817546179092473, 0.9057684885791722, 0.8368398544277197},
    {0.8469328943497019, 0.7551693265950596, 0.5914505949064319, 0.7345477827280493, 0.06620580170122663, 0.7153191063643523, 0.7041424134110064, 1.102408239044636, 0.9033278612144167, 0.7572091235485084, 1.021055031806952, 0.7102458263313558, 0.7850986263669062, 0.9141744601133843, 0.7176446112166285, 0.13182407889664743, 0.796613684950575, -0.19956066825906194, -0.09586663909019388, 0.7130563987831737, 0.7141364815773834, 0.977791694480364, 1.0290979777941158, 0.6580561637975353, 0.9220983656222731, 1.0256616338252336, 0.6520086551389093, 0.8858831518540699, 0.8827596474661703, 0.6871470043333417, 0.7486958012253738, 0.7720304749718462},
    {0.6660797656894186, 1.091512148442062, 0.596345427877667, 1.0025972189824939, 0.15016395555650355, 0.8642396536927658, 0.7384482463397053, 0.9730377967708462, 1.0927628655857646, 0.6435270437484885, 0.9384314017404676, 0.8360401249794883, 0.8807041407349246, 0.5918879706537106, 0.6295867048424346, -0.1260433141934572, 0.6740850427282468, -0.0021370458026024634, 0.22847873124505083, 1.0216692502618396, 0.4912377511990952, 0.9931613296694487, 0.6384628073356343, 0.7430872326550834, 0.8365198288273815, 0.8705104034499256, 0.5881413788884586, 0.960922912052852, 1.0087217876753136, 0.8053139905561332, 0.9741504515618189, 1.071901190464963},
    {0.9789418971615159, 0.8900952335109279, 0.5820542088124641, 0.760433459851994, -0.2913731799251844, 0.8905459056610007, 0.9302561108846009, 0.9695741744049442, 0.7995794617314149, 0.6620591741727798, 0.7473956866759328, 0.9242140342113336, 1.060137655112233, 0.7044391076007798, 0.5886510494533967, -0.16260104418552787, 0.7651407552052616, 0.020443227417118823, -0.04268127940469079, 1.0514079347752452, 0.6512186083975565, 0.7019151100706597, 0.7810725140939959, 0.7534549707588277, 1.3912199241507675, 0.9181956785848795, 0.8546535568101893, 0.8558008209464747, 0.546526716867305, 0.9212456710268849, 0.8779872586810852, 0.920733626887974},
    {0.8501624881029654, 0.8831951669952763, 0.7545494220927325, 1.0100141003721534, -0.050801690760505204, 0.9223166517325614, 0.8009144281897174, 1.0223597993409095, 1.1109677751389337, 0.40723704427022767, 1.1517284991163568, 1.0549419139798564, 0.8002841920814678, 1.0646718985455117, 0.6249834011154989, -0.3435478120763342, 1.3633011596391438, -0.04579139679482837, -0.2597679053135081, 0.6584104447523227, 0.8067534619864798, 1.0695972212375473, 0.871321363694549, 0.4586419441843928, 0.8532857155697731, 0.8539018907590282, 0.8074043861139422, 0.9408093976053321, 1.1088370317014917, 0.6862741293745627, 0.675704485745491, 0.4763500891442705},
    {1.2381457345529157, 0.8423005835995239, 1.077091607402259, 1.0400358599899737, -0.030910561020334463, 0.9988942565761969, 1.0829677205768686, 0.776952746730447, 0.6925103743054758, 1.1963118623568196, 1.1986447070268171, 0.9466178418363183, 0.9851152384887185, 1.2414675687715706, 0.8190759552247528, -0.12826419778210946, 0.7111228093764528, 0.10451032725489177, -0.3055916698531543, 0.8766056755354621, 0.37651952592882615, 1.0036542038282188, 0.9598487147394207, 0.7743069966884223, 0.9601573887599735, 1.0345986556329922, 0.9034759563280589, 0.8248923646424191, 0.9650265196976423, 0.7816666646853392, 1.0326808807664676, 0.8688246072543455},
    {1.0644726312260775, 0.8764473175696658, 0.5414475886220416, 0.9619609602755733, -0.022614040577563294, 0.8801234504464345, 0.8524801376651474, 0.7364739870235739, 0.8590699982020753, 0.9430174120168531, 1.029804031303334, 0.7544134734517294, 0.8196665409974248, 0.989378339469093, 1.1647000409648622, 0.20991837788326345, 0.46274195483453306, 0.12461313229266179, 0.01044774792697851, 0.8775107221479373, 0.9629925506043362, 0.820524148095035, 0.9310343023522728, 0.46327889135408057, 1.2508323657681635, 0.9013457644415984, 0.8479953989860963, 1.1707990997150042, 0.8597129508961812, 0.7183410698069901, 0.838754977940778, 1.0657122836429542},
    {1.3487603955362797, 1.0361696674272893, 0.44806505436781074, 1.0466661164924325, -0.09075709072949059, 0.7388394314899727, 0.794388046491678, 0.8338778071638436, 0.9425496514872272, 1.0168899173986532, 1.094976477642716, 0.83864228809945, 0.8474186244907128, 0.915684067432104, 0.7974666136656818, -0.08589049811214843, 0.3552930402963502, -0.3133899688048455, -0.3279150885338045, 0.9346547757053112, 0.6752473891473836, 0.7683449895392416, 0.7413448429142168, 0.603924637099502, 1.2241296915842228, 0.9323333470103099, 0.6867643756332948, 0.6404700319376109, 0.9729694237856461, 0.744622970350057, 0.8371850832937324, 0.8329755578252901},
    {1.0492502740315353, 0.7928302377793724, 0.7594381569265318, 0.8140370878524777, -0.09977408919531035, 0.42324969719776584, 1.2003070531242073, 1.0353389287330874, 1.140979121217637, 0.8434266396920616, 0.7684061633227087, 0.7368857666880958, 0.7936532036113163, 0.9613999942394928, 0.5804911275691199, -0.005208563450856682, 0.9209323571147391, -0.2921170307108833, 0.018014586222013924, 1.0097755263122377, 0.7495091979624586, 0.5257918048213956, 0.5327870932166314, 0.5871472854513579, 0.7940530283905812, 0.7158202107130386, 0.9518598588529368, 0.7091919772484534, 0.8613399293511224, 0.46884471682129586, 0.6280334241673821, 0.9805631125969676},
    {0.8127655560219609, 0.8059102629963376, 0.7412095012457746, 0.43985835321540084, -0.011968760913871404, 0.5568687050305222, 0.6726858600748421, 0.8517246121784608, 1.0864089951021323, 0.7352990343915535, 0.9256018076787895, 0.8083355210749369, 0.7933088007549951, 1.001135081564797, 0.6011315435743324, -0.45217348861485546, 0.8554050489377286, -0.1204185436925019, -0.5213529925682231, 0.7764476361087105, 0.46380308986115326, 0.7582332033482205, 1.117640646253343, 0.43433791250331655, 0.6817688491656668, 0.8542570645263995, 0.7124013087097445, 0.7629902975750997, 0.6560622979946878, 0.6988288471537155, 0.6882417142433519, 0.9946852762313988},
    {0.8873292210449824, 0.8902620279724021, 0.7347296453448476, 0.8841173734539622, -0.30443868389631906, 0.732921225388671, 0.9446938128793523, 0.8416940593154204, 0.9288364384585931, 0.8134094215957823, 0.6148906475007923, 0.9077508815891793, 0.8618491986575288, 1.0547579809128877, 0.6788769926520407, -0.25388019543982177, 0.732023359830013, -0.1251121552319624, 0.04977757917984906, 0.7563948612193356, 0.4823528064737582, 0.8251144639826031, 0.5871024463495579, 0.3428564243807647, 0.743920409739122, 0.8523627927562791, 0.604874034222534, 1.0883314701722877, 0.5618114674414116, 0.906460788263126, 0.4983122146222247, 0.7472160582419775}
};

static const float b2[32] = {0.8416089872444321, 0.868792918132393, 0.8341244282209418, 0.867529173687466, -0.05227074246368862, 0.8929821641814709, 0.9000000649744558, 0.8945934355131261, 0.9106392774230663, 0.80999345048998, 0.8931444042414458, 0.889914137871676, 0.9028468921676595, 0.8736388412237764, 0.8111421673634371, -0.049033326450468095, 0.7453056526070369, -0.08437933557668557, -0.05583900566936567, 0.7972446025361085, 0.6916381446265988, 0.887559624439398, 0.825250892411258, 0.7176353995024265, 0.9125769923910758, 0.8345388051681476, 0.7442886811071792, 0.9112707923493081, 0.8371189401216127, 0.9119950079393254, 0.806137876006513, 0.9142780094137574};

static const float w3[32][16] = {
    {-0.02852506110301831, 0.2146656517154406, 0.7355341078538787, 1.1675949356833533, 0.3297869042208619, 0.5416912083584143, -0.05211089166955932, -0.2129507482644415, -0.001965292166710375, 0.8289507461784923, 0.7445324998880618, 0.5624679927197026, 0.7479955612889579, 0.9212847366177612, 1.1487186462134429, 0.15256752261589138},
    {-0.07342450560373222, 0.6947157833292945, 0.7100187916901051, 1.1535645224697315, -0.09615629615753146, 0.8114517385279774, -0.48662009679463564, -0.014645158324016914, 0.04101276482512435, 0.6929161705089402, 0.834183328601683, 0.9724359127224346, 0.5785963024253411, 0.6152546815318805, 1.009056741956765, -0.09934109405818593},
    {-0.14482310541016746, 0.3691627795314337, 0.8799338123005073, 1.1629347827952157, 0.19243711412667933, 1.4093296779734055, -0.17024806438876292, 0.3988237485585913, 0.025600692515524298, 0.9170678977156317, 1.1452539724061253, 1.372140226565621, 0.8858666223710456, 0.9737283648393487, 0.9382893100887342, 0.3233584594052095},
    {0.02909015529513053, -0.3796017599294022, 0.784796651748019, 1.2002013193386494, -0.09799845092721346, 0.6630462932040033, -0.0005820289823871111, -0.027244790003474996, -0.14393727064921555, 1.2974038481495673, 0.3689442066645846, 1.0900851149868975, 0.9104730576070481, 0.5038024598021374, 0.5157608896793824, 0.3517004784180147},
    {-0.1371684110517711, -0.04959906472026611, 0.29562952364690503, -0.09100469456892461, 0.32859610379371595, -0.31417564933434966, -0.4473596974358591, -0.07656527631769935, -0.33622467796674693, -0.43936777281727485, 0.16455640227056037, 0.02260652903230754, -0.20254277914574015, -0.18016750653989252, -0.1956601131580157, 0.012834397435717633},
    {-0.06621996413897636, 0.192213357492177, 0.589558761344742, 1.1077225957886772, 0.4256719250810414, 0.9195285704087656, 0.10676214622720005, 0.05888748207493256, -0.12820619133623729, 1.1208285572059913, 1.1210294236688205, 0.43969229708102914, 0.8124335511430265, 0.3883047671485675, 0.8008299643025493, 0.30445172732826464},
    {-0.22638842443776505, 0.10176855200171098, 0.836813935094313, 1.1530974880003197, 0.08094060357541949, 1.2121341853414338, 0.3292592436153437, -0.09572125849760896, -0.3863507577367187, 1.050548429783894, 0.6733960870094163, 0.6737522878714068, 0.8094899618671028, 1.412035964694229, 1.1345257849414394, -0.2654998626349833},
    {-0.21096532043937105, -0.053105224416211, 0.7443690935170569, 1.536720737958789, -0.1425126885349024, 1.4361173926506525, 0.10207217992903767, 0.026476198759794154, 0.007678591424090802, 0.7155179103199841, 1.1048919887702158, 0.5618786469395581, 0.4751588590672304, 0.5866644173543514, 1.2011879940864365, -0.13779258398107233},
    {-0.013985280015056159, 0.47415285844487026, 0.8891936553882909, 1.1718585823532803, -0.19027678329898476, 0.9268524310896833, 0.08501113439996379, 0.07866079583848282, -0.026204415750855314, 0.9356675285301648, 0.7014809778414282, 0.8492358291277702, 0.4475892748409507, 0.5487542988412321, 0.9458647089889582, -0.18388961510962656},
    {-0.5051646755624078, 0.18233295858849666, 0.5355610922838361, 0.6807729222446551, 0.46960190546707564, 0.5998863607323751, 0.1488741059844392, -0.4688898110233432, 0.08157155518265721, 1.1644436531787132, 0.7871080426989009, 0.9830741337339495, 0.9893129232136438, 0.5570068560857991, 0.952313975409918, 0.15590557248458398},
    {-0.2126443567364907, 0.2515581038238588, 0.5097326615807432, 1.3199074919157623, 0.21619192556925598, 0.6227276035909695, 0.3426208163510136, 0.06194303592464887, -0.10844772253548142, 0.9073113140359714, 0.7451176464920011, 1.1317844759924207, 0.7676723062427651, 0.4660298717950884, 1.3372757223124436, 0.002600892901461547},
    {-0.25589092118544765, 0.3810374799427555, 1.181246367936605, 0.7347811545805599, 0.15216211381673433, 0.8551911707540996, -0.056938142861380006, -0.19801387555212965, 0.006958002462801251, 1.2359958281426155, 0.911301501763179, 1.0908442363675812, 1.1254623140111166, 0.43118247868766296, 0.5512383255152842, -0.34773450554444163},
    {-0.18950501410611284, 0.24721660731896955, 0.918096698533839, 0.35972567739266886, -0.17288016132231512, 0.7780778078295782, -0.4855885118832825, -0.3013320920934362, 0.04466732118338162, 1.3681599605434405, 0.7345084629977364, 0.9066295553098279, 1.1703919661332736, 0.348205529798068, 0.9827118023040018, -0.11597885578227782},
    {0.3973597077931655, 0.3177827888335355, 1.1061239632143005, 0.9940832983782094, 0.07057505382905582, 0.9428969987580229, 0.12944657774375767, 0.1368504819408811, -0.13446044536664667, 1.2284879091755985, 0.8382173972630016, 1.1130615899989489, 0.9027369294539139, 0.7065756827577329, 1.0301257335456175, 0.21208452552459986},
    {0.13643646254800662, 0.8047571061255806, 0.9248269567413258, 0.639122581317274, -0.3783968458032883, 0.8561217795655558, -0.503540109481357, -0.42021723364553565, 0.01833622279482672, 1.1428694401455426, 1.150014289050312, 1.091776438211024, 1.265021937784234, 0.8014254525104203, 0.7601711561848459, -0.1120057845790158},
    {0.08636919634132409, 0.18320569907054812, 0.18250144445432492, -0.26510382176002995, 0.04601876828243776, 0.1714407226317861, -0.08161650927772837, 0.12611122209878733, 0.36190519475620075, -0.19012553215861677, -0.2347043076884651, 0.3079377773326821, -0.08726885438314241, -0.0010857510511176906, -0.14517205487216056, -0.12193316030342626},
    {0.4889598432662818, 0.9121914170073405, 1.0675841101972456, 1.1223180031527313, -0.32009815935564845, 1.1924484314000605, 0.1278391120161006, -0.27654553599860193, -0.19311848896621422, 0.6656162029071758, 1.088246152021534, 0.14346159683202644, 0.887414583553396, 0.7774662552813093, 1.0214905430771102, 0.32076799350391244},
    {-0.07361655794426329, 0.1414432487929362, -0.023815260049461592, -0.5184607927210153, 0.4566230555248233, -0.2650888297869136, -0.18386999126137454, -0.11037605897564444, -0.1618583106190645, 0.3551515177538637, -0.15912140219055299, -0.221284357046374, -0.17483482275811002, 0.3112326016002477, -0.08883834681587419, 0.11358793705060428},
    {-0.3751849048505632, -0.19686276233103167, -0.09020444795686104, -0.09982240520426827, 0.06927444391316069, -0.6809134041780514, -0.4012478963053218, -0.4550449772200845, -0.10542661042512441, 0.12354653874878764, -0.4785628348298021, -0.10308000521866163, -0.15524926560259403, -0.5220606084435906, -0.035961782230677405, -0.10997275495007075},
    {-0.2321742526360612, 0.3555908127249287, 1.4812093173985883, 1.0135922153148633, -0.5517513808773693, 0.9738254979012662, -0.07324108529340416, 0.0012073285619648593, 0.3950915322881739, 0.9372818523583452, 0.9775671365598663, 1.367206216672393, 1.0309467036227125, 0.9825934604620461, 0.8450013479432938, -0.33015486831156937},
    {0.01202646197906456, 0.6469627851815195, 1.463824546820101, 0.798593575386981, 0.2883451966279297, 1.0342715601899504, 0.08624662500022717, -0.4447990088158111, 0.15743640544133267, 0.7673491026021246, 0.5497853337935192, 0.4688474436279203, 0.8013472791537779, 0.4599412831980755, 0.7248856620537336, -0.08056857044854536},
    {0.5000422626955542, 0.3605679799301128, 0.7149836653806831, 1.2447896312728093, -0.12568983235638537, 1.0077738190075405, -0.21942984210076552, -0.06104326848639735, -0.013096142552819028, 1.1972599824950998, 1.1902586381884388, 0.7683198919589751, 0.974624819951228, 0.5793698677667694, 1.4419282204859771, -0.39890826293439935},
    {0.04378461279121262, 0.7074482112038236, 1.1339554059513315, 1.125180903564595, 0.29258056193217796, 0.4997544035973084, 0.008055069955379811, -0.03665637529404565, 0.09439287454344972, 1.1771892070341352, 0.8745468918241923, 0.9748360262029752, 1.0031194102224275, 0.5770518759686647, 1.5092854512932947, -0.10778425974534052},
    {-0.09567462362177862, 0.3361188749071118, 1.3493116161220067, 1.473699413011307, 0.3271261760182875, 1.1915299324006383, 0.12438926179085506, -0.08578457100770537, -0.36756998151925596, 0.4299596364735209, 0.5384457271031885, 1.0716160678607045, 0.7925490170669764, 0.6712809903896076, 0.6233554447783789, 0.13805860411849924},
    {0.09366819008596187, 0.24121523573875675, 1.0071760215829355, 0.990359458846633, -0.11108842444845078, 1.1531402778624058, 0.042310978069933704, 0.017235812271538056, -0.5101130651606139, 1.0804231740093881, 0.9471995692048568, 0.9016882105610482, 1.0145400084773226, 0.16573784628218205, 0.93492159282524, 0.10648689380021699},
    {-0.023555216350882403, -0.010025717731168117, 0.7145589188472812, 1.1197489400430347, -0.2682347722160709, 1.1909397955153065, 0.3028262876180269, 0.0707042018573099, -0.026271923232002156, 1.0275938329612297, 0.9383874509263095, 0.5567871125763098, 0.9863805442831401, 0.5141461697622477, 0.893707404887632, 0.4172747730903884},
    {-0.11972620245126359, 0.3406518143190314, 1.2594419844118738, 0.9006440329890187, 0.15906739509140008, 0.8878786211219776, 0.06416287618476625, 0.19454994754935295, 0.7257961278506692, 0.6764521091240271, 1.0902784925106044, 0.7410471670538556, 0.7094167906173167, 0.30740150482058654, 1.0643874885456568, -0.47771672382630503},
    {0.03722150391876446, 0.5561770745308902, 0.6111407810078695, 1.4126131946427558, -0.48110168279919874, 0.6912210463458219, -0.3049612433205496, -0.2933448379181129, 0.1674663348405204, 1.0352439995366374, 1.2796767359162284, 0.20702409035491628, 1.13496071198087, 0.13562511819823006, 0.8258754605600395, -0.1610570404277026},
    {-0.065540390022292, 0.48708426583209247, 1.0376405369356874, 0.5398849453612182, 0.03065874494516741, 1.0430839998955437, -0.27280381975680623, -0.06788865738692137, 0.03231901419889344, 1.1402584408740437, 0.6399370293222307, 0.4926585761302624, 1.0861653458566873, 0.6974440899093897, 0.7688038078119295, 0.012600683661237958},
    {0.09326335550768224, 0.4552699572429412, 1.1733738124383366, 1.1389934936863781, -0.10265606446352499, 1.0894856481348074, -0.6256561508992057, -0.0758446650981511, -0.3536215087877572, 1.2230319611700875, 1.2051698144404104, 0.634652451889818, 1.015035542373224, 0.7967274577388743, 0.6947088491442192, 0.15921705820063373},
    {-0.02206731186964837, 0.380285647727199, 1.2666356434792203, 1.1740256393186406, -0.1620397378827391, 0.815104936580709, -0.19770494276194342, -0.23756504738386552, -0.1537576762404156, 0.5951011421488163, 1.3599403448497855, 0.24134042882202544, 0.7414518418965825, 0.5470398797653869, 1.3833933952263857, 0.16556651252852037},
    {-0.38853713838368753, 0.4290832875155087, 0.66420676313741, 0.7524709926193843, -0.3363136198758388, 0.8113819584965934, -0.18674681486976527, 0.3891898797314761, -0.1624831048100999, 1.12332054471689, 0.4291792593517046, 1.0317052742423052, 0.8793638358348077, 0.7107055194443458, 1.2231633500518593, -0.17106969814797157}
};

static const float b3[16] = {-0.034536403492260385, 0.17030135303506344, 0.5582013897376823, 0.6061483549469873, -0.009358816449605926, 0.7144342310310227, -0.04402303646230975, 0.010119830457693933, -0.027799721740644788, 0.5378101975996741, 0.6849246937871194, 0.6739899687212899, 0.6003162323663854, 0.36854308146872533, 0.6110885914373099, -0.053804663549322486};

static const float w4[16][12] = {
    {-0.39841158222161344, -0.04616069522804168, -0.04580963338159287, 0.1983598962615998, 0.394680558563314, 0.08073097702857174, 0.3257611601444772, -0.3335535079572799, 0.1758509737087209, 0.09228669081310814, -0.04155703226012849, 0.01631253411020987},
    {-0.6287781967394089, 0.03166624440250269, -0.23132907918484052, -1.08600978089577, -0.3999091657005487, -0.9842940529156983, -0.4653356145143706, -0.6984851585277461, 0.007288006409384202, -0.31007615383499193, -0.17560515750936256, -0.2722201199939296},
    {-1.0834940860421134, -0.7017000247645367, -0.6595444598983882, -0.269917476455886, -0.8281134969303531, -0.6141653052996195, -0.06012527931798692, -0.8656333630320919, -0.3226552168919802, -0.8548640730888295, -1.0286236976449883, -0.9587402525974903},
    {-0.8368065403541861, -0.3316628742744042, -0.6715551016262441, -0.41227168709471146, -0.6618140838780658, -1.2786602251728907, -0.7243337537838624, -1.1967321761297933, -0.567307669983066, -1.6910431541797766, -0.8236605719651295, -0.8989739835047491},
    {-0.05998161228345076, 0.218956621576552, 0.40389536835705336, -0.5786792090985943, -0.6118410183373378, -0.4719092874732306, 0.015530872729318523, -0.23730834923592603, -0.0409090468792984, 0.21530693054849764, -0.28155096364621063, -0.022578823997702908},
    {-0.8556781787516268, -1.1919902544602137, -0.929067802911695, -0.850879380089914, -0.1945424586443328, -0.4073545820381044, -0.7045901710396313, -1.012656227352686, -0.6587571855517451, -0.7233796832351079, -0.43980686914339634, -0.7977912473497382},
    {-0.6261371272202213, -0.1577899469458103, 0.1038726838672525, 0.20468137948180928, -0.08320295167642687, 0.39937366550016834, -0.08114918515119117, 0.3394361425814152, -0.07854763530097779, 0.41330387597182017, -0.09255989048123801, 0.34191862960106045},
    {0.17495810750822308, -0.7266358774258842, -0.28255134245832136, 0.020001916736310504, -0.743957015387978, 0.346819659288916, 0.13667536488333945, -0.4638454822577489, 0.06791417426244552, 0.6879942218733621, 0.6450859153551433, -0.43848468421907627},
    {-0.07672616840028146, 0.6887094730501967, 0.2521033680783145, 0.25505477984994573, -0.20075424278197854, 0.005027481711759763, 0.52943584998241, 0.31918447375256714, -0.03423718537625102, 0.6556952768935197, 0.05788323169861428, 0.07699899511729441},
    {-0.469161331714817, -0.9154589975515401, -0.6044605989314087, -1.190419716842146, -1.016010847802651, -0.6638717478752909, -0.9362939125654574, -0.9002127997714008, -0.971981511723412, -0.35022910721632833, -1.1051946589072323, -0.7681802633374338},
    {-0.6708055285642214, -0.8765799971131232, -0.7366010411560504, -0.36353450115533437, -0.9347235740260333, -0.5233357319377262, -1.5156036938828683, -0.665953479314651, -0.9048167930908586, 0.15635278098800628, -0.5047178755381365, -0.5634949283835653},
    {-1.2124643663789494, -1.1638927099090184, -0.8056458932889389, -0.32465726301957254, -0.7642824931914194, -0.7642977865211369, -0.6188947762905006, -0.7222539634062929, -0.9586242385522252, -0.7382391834175926, -0.6806715583055142, -0.4445092853349078},
    {-0.4601289170088714, 0.23977826316582915, -0.9859436896411957, -0.6078609586585828, -0.9361753563036479, -0.7611676961215902, -0.8557504011539206, -0.06077269605911935, -0.5428352588736379, -1.044019099673161, -0.92251986654622, -0.6905557180290277},
    {-0.2983545669822809, -0.6864266211817598, -0.5146458533130065, -1.3346700452094957, -0.8180452269701585, -0.3082402802018188, -0.7690948634779142, -0.44873871512814384, -0.6966166329209443, -0.5029233974055444, -0.3090692440386867, -0.17854323145335618},
    {-0.3868882430472861, -1.0268167879098076, -0.5630272973201393, -0.996002789627297, -0.3458856972760764, -0.7026650180897265, -0.22991336329347078, -0.2956322947741683, -0.9859921818548749, -0.5284971126015839, -0.5515188438675264, -0.9221651102497763},
    {-0.062168570399259576, -0.26214372155817317, 0.24640117882740875, 0.5596391724051198, -0.4843861712187187, 0.2734982615328327, -1.0617279173731349, -0.12462133683216832, 0.07126700323713432, 0.4884629679646458, 0.11100096487854318, 0.08597458021639191}
};

static const float b4[12] = {-0.2695718989429686, -0.14340226058617345, -0.18337623250006316, -0.328523841569952, -0.21826952748179343, -0.17282546731402432, -0.2144511790167716, -0.26716648794976217, -0.26374725958498363, -0.0959125993540651, -0.20090512011415448, -0.3203257675837675};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
