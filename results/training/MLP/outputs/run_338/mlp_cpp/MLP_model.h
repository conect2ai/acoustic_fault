#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.5392648567004833, 0.2340743395318449, 0.7891112146824478, 0.5709378959405251, 0.08588630060374089, -0.26098986868387647, -1.4668119062010454, -0.12450896037596278, -0.44690123469818244, 0.6504754924213697, -0.26014104157700857, 0.28894286053421375, 0.9441829401341327, 0.20986926097402658, -0.5821436262392082, 0.4810011835883327, 0.34263302538445256, -0.4687503320615736, 0.941667021931926, -1.107817214678527, -0.5055559238186734, -0.49364950398589896, -1.5771669740947716, -0.6647291945260073, 0.7744609983240924, -1.2340500308584148, 1.197304428739796, -0.15448905716691977, 0.004155121339035421, -1.1160478559816143, -1.3880000360888907, 1.2423512705835078, 0.7664918996899153, 1.2539099137150254, 0.28652832448851423, 0.08903027841738184, 0.8851943889889438, 1.306766865398621, 1.2154037872364536, -0.4956552607392565, 0.6416699664602453, 0.9615338660702383, 0.11377749693860782, -0.07265219582853646, 0.23205136862654596, -0.6809937940078213, 1.0140083044014283, 0.2864265358305931, -0.03388448902866622, 0.4426763919372896, -0.8840015678933575, 0.2798982735503853, 0.05253316779433209, -0.27791490924246687, 0.47776122192700904, -0.6333950286878768, 0.7052615851168654, 0.01092346575698159, 0.4705847366421242, 0.2874724662663825, 0.9170613953640147, -0.613333681951399, -0.8554161944933779, -0.46027850294612194},
    {0.8189610920161549, 0.7161375774479669, 0.821993609594208, 0.5069810372958443, -0.8409546444255732, -0.5751668249180011, -0.6589037091161056, -0.2106375190047387, 0.7840498891222526, -0.2144723704389474, -1.266339167958075, 0.29883260633553477, 1.2418601321772686, -0.832877696709161, -0.19468314624888713, -0.11400618242521372, -0.45078715157867155, 0.18725425756451577, 1.2711346551931648, -0.48030453356440894, -0.7817736102310067, -1.8510690630821678, -0.8454879833059765, 0.37896035356676844, 0.8384705278517456, -0.45408238688198904, 1.3151475566424355, 0.4262659244901966, 0.3578708464414377, -0.06475360346550259, -1.92779667716342, -0.05164522392160506, -1.3592502655501866, 0.25397383992955336, -0.29625396499027434, 0.09344119131495376, -0.4789078337206801, 1.4066109929003374, 1.0219283758045161, 0.5707966610781643, -0.25811247812577304, -0.07217153025931633, -0.3651230938131872, -0.6634891815740764, 0.23292533249580988, -0.3216403081176343, 0.4996042617443066, -0.5339212582313296, -0.17790437517897773, 0.6163535240467386, -0.6873741122694282, 0.3151113000892463, 1.2873920685272688, 0.5503691517688458, -0.09194833082055057, 0.5469454237193713, 0.8014142807605207, -0.27315853163922293, 0.8677864408209726, 0.2195223611351843, -0.11029497068443328, -1.5403035943924155, -0.8399679305428679, 0.124988858411084},
    {0.20469022073465132, 2.216650379612901, -0.28148041633594084, 0.24674928370945426, -0.8751419864889093, 0.2607375715310264, -1.6620633435096943, -0.7045613832431381, -0.883989742773501, -1.165987793268796, -1.7660700813225245, 1.1467117806116252, -0.7764246542835513, 0.3195393370063523, 1.3945968446679196, 1.5113969297140888, 0.8662368346789295, -0.28790571178451946, 0.3236367868118092, -0.5888115211417355, -0.85050689092351, 0.09586841352852848, -1.7684653374818482, 0.025008813435991633, -0.4874214306297489, -0.08601710648771312, 1.239875937289792, 0.6874991086183607, -0.7971948787897202, -1.5487964810371984, -1.3619615888424745, 1.4806369037516842, -0.9128956698663304, 1.2527187847712666, 0.033742158696131834, -0.6530305857246091, -1.2591823354102152, 0.1260205745303207, 0.46513187914978055, -0.7396916328161511, 0.09008015465280074, 1.2597684435097576, 0.46837466424492313, -1.0267962242708297, 0.9182812021675174, -0.43853498987326306, 0.8446149096652201, -0.8489060738014205, -0.224196746614398, 0.6753395559589561, -1.1025083220688572, -1.6206456605144293, 1.7311818811042217, 0.7692930234894698, -1.6582694397151647, 0.6613599231853305, 0.07851292453790218, -0.34429204853314027, 0.9675241345688528, 0.8114645557199693, -0.030241371228577694, -1.4548156664031582, -1.0543016323893364, -0.6069521122875513},
    {-0.8649517371761313, 1.831628519968762, -0.42178070968191916, 0.9741173847662882, 0.028802707907210127, -1.0122628630603807, -1.821619899288372, -0.8155465411125896, 0.4349574327505502, -0.14898930636939295, -1.4865324152363741, 0.5748928132450286, -1.0528671363036162, -1.5317728083228297, 1.1305978271314885, 1.427644131311894, 0.2061302551039831, -0.12190617280124436, 0.2969128191807612, -1.927022585591629, 0.5759385180067506, -1.333318666815191, -0.8286901032541878, 0.9487616647559752, 0.18830789066189238, -0.3052589271565032, 0.17277369876016496, 1.3624010567124354, -1.500701643116355, -1.5845314857356732, -0.10570614197679822, 1.6843114498065563, -1.1339520884746406, 1.3763892375058844, 0.2144767860919571, -0.9935697093784495, -0.9654773315531644, 1.9706060036168618, -0.42675323609377025, -0.46723891592699485, -1.97915829247184, 1.0082501869146099, 0.8561072639546781, -1.43541085912752, 0.1694707850933836, -0.3860966986395257, 0.06946501055722981, -0.44252296151960774, -0.657560589005413, 1.1398236341998311, 0.6099854832232249, -2.2145738637519896, 0.6724496225575095, -0.8144672914518123, -1.3785362197178117, -1.6851266989237454, -0.4218956710873077, -0.08207784663216842, 1.0294207785281424, -0.2947732668383804, 0.5522405190514115, -1.9816580403555508, -0.8679669900274302, -1.3061518545068147},
    {-1.193946538875282, 1.0037615715997508, 0.08530552904513936, -1.0690466853873803, -1.4259337046978646, -0.948402043244317, -2.0822897085197565, -0.969949477061642, 0.516945038189785, -2.0664804733908455, -1.407403057783843, 0.27307582382728224, -1.346428777449114, -0.6465704943733422, 0.8342534200108997, 0.9112352557062946, 0.35459353281955514, -1.0572101751986498, -0.6016086230596923, -1.5643752333893441, 0.669291454493454, -1.705599521206124, -1.1366401523534893, 0.12564807465362307, 0.5807526174484292, -0.9058977726849504, -1.2307636747557256, -0.3082511564541606, -0.7636108358239073, -2.228563040390027, -1.6682564580170685, 1.6656832844862026, -2.1562271793254544, 0.27015740590372367, 1.397695368137227, 0.1677972376385934, -0.6330950955209683, 1.5585157007782873, 1.0011251350883543, -1.133529492565852, -2.0145051616829326, 0.9251811082535931, -0.8067385201081892, -0.14994340277508672, 1.568340761297654, -0.19543426869715547, -0.48467275297125073, -1.670115355640585, -1.4338091263700836, 1.1938097206029836, 1.0583731844254758, -0.7986787790779017, 1.3445825707157975, -1.1969065352527908, -0.22415154777615512, -0.03592169717428617, 0.6063575396246723, -0.08838133005103418, 0.644448127043465, 1.3869750932994018, 0.5214588191681241, -1.704168710081223, -0.566248813176942, -0.29749827146005897},
    {-0.04235086872236183, 1.5219431222794166, -1.0088582914675677, -0.3651634669980971, -0.7943811363869184, -0.7946048469692303, -0.5422928126336815, -1.3158753876464087, -1.250848427416436, -1.6333008197182497, -2.183623497357263, 1.2237275943399737, 0.07703636441218989, -0.2367109459904084, 0.15391251531517064, 0.7039633107522422, -0.03775406889534257, -1.2410838599630023, 0.34644204973478543, -0.9338319072220588, -1.0297766609922878, -2.0595836128789236, -1.3871744509536061, -0.3061875238568667, -0.13699698355986742, -0.9356158372456507, 0.062613501037949, -0.0177896446810583, -0.5915074549481005, -2.1206336328850774, -0.5054431317120209, 1.1791574970568772, -1.775705848852096, 0.32100760514723453, 0.4178254108357148, -1.167908665943097, -0.26591563985930217, 0.14151782257577106, 0.4011240891178482, 0.41170199499365245, -0.45025382276173315, 0.7069452191037143, -0.720314895553126, -0.06706911162601321, 1.1591150422371654, 0.23653816538821182, 0.7863084248185379, -1.9909771506400789, -0.7359740030299955, 0.5481620158062662, 0.9966570070984464, -2.287144710423406, 0.8995013793442344, 0.5460603147617265, -1.3878051564750393, -0.38269260119294, 0.39027974565427814, -0.5729362323159286, 1.0304813177187144, 1.450329770348614, -1.2549600240035212, -0.9414221108623, -2.0829358222255663, -0.47982659571273095},
    {-0.7182569628846471, 0.9772532021763138, -0.6908052018662753, -0.8218860249079439, 0.013440774684972527, -1.1141733914258358, -0.5546120309420711, -0.29642102122936337, -0.29333014889120923, -0.8495016856101055, -1.5975837163498696, 0.3771551632956574, -0.5953240679195371, -1.765998295536735, 0.34896454302319174, 0.8215668585733036, 0.4436918962162546, -0.26903892078878167, -0.157554318570677, -0.4979267647380825, 0.5000277361969081, -1.461355932454643, -0.001838293142629285, -0.18844594326178066, -0.5114172205245132, -1.8855336361663702, -1.1914665553525394, 1.4870428835971314, -1.8978459977538673, -1.256491222207083, -0.7511040902850808, 1.201363722517141, -2.000010882181033, -0.317472406721753, 0.9484115748857104, 0.2774543642645579, -0.6157599102956135, 1.5832317711846224, 0.6234996656025587, 0.18116678938903177, -1.0935909782835735, 0.21427406556885092, 0.6089791168605773, 0.008707218361802369, -0.36125206808117405, 1.1276741232228191, -0.39414890265585656, -1.1539885313780127, -0.1103135735551293, 0.861492116473631, 0.22642515978999878, -1.5499921026379777, -0.36341132025329925, 0.02004156977781542, -0.7452787749278537, -0.5289485624742915, -0.06843503237302959, -0.32701032326681484, 1.2632400371099968, 0.43651507405006734, -0.04892562579837586, -0.37406448468409326, -1.6448334161456557, -0.272791371446584},
    {-1.3124527587607788, 1.394406957013788, -1.4205515540158122, 0.4523321053552887, -1.288086008410571, -0.25574230261139835, -1.5723019725263316, -1.337398591075475, 0.04405833654448996, -1.8229731927244879, -1.119746712631954, -0.06728714908880745, -1.0301397151158507, -1.8284639648107135, 0.333240760788294, 1.4552537413633229, 0.10380722349517621, 0.07670756710092617, 0.7094394825724933, -0.6350231291537114, -0.18272420602321934, -1.8291924950298533, -1.268332532411264, -0.7908784145710239, 0.5295235762220215, -0.9559465746670078, -0.8367283092974325, 0.2716519907162555, -1.48191061647318, -1.326916478405268, -1.1449256419936993, 0.005470851060459833, -0.7151027380224547, 0.8895938397742017, 0.35161292430878455, 0.41982550949339004, -0.5640226359771057, 1.02181005447405, 1.1811308059024117, 0.42769862560456884, -0.5691805411586235, 0.730301780302417, 0.12563439045112024, -1.3785071837787604, 0.06681511739457993, 1.1450310246314148, 0.830788469399976, -0.135774545735272, -0.6348157660966531, -0.010742204004816614, -0.10723066015186813, -1.5276471358548795, -0.4793854271745793, -1.2499705976246847, -2.121643902159243, -0.7804312578464881, 0.019281035338614205, 0.20676912856724017, 1.422808252224969, 1.3894767170387001, -0.9368841782214427, -1.0767928365979893, -1.7403676053992365, -0.6762342273902037},
    {-1.5066682749025238, 0.4008938884680208, -1.206845478834131, 0.04406410287636754, -1.4855567685450903, -0.3419486648683662, -1.0149879478364223, -0.4304099342863533, 0.07909255254939324, -0.45170962915172247, -2.272783747671859, -0.05163824153448522, -0.8866450410275754, -0.5729382854166798, 1.1160365917863257, 0.1784017853067433, -0.9305413151293594, -1.3047180909699865, 0.39620973869157483, -0.8722616768551666, 0.5130373242295052, -0.8655396505835892, -1.6782183688509618, 0.160877741423177, -0.5938468794904056, -0.6535442411335585, -0.5866586278712057, 0.49195608493726223, -1.1903880349967026, -0.3748308358458905, -1.544168151650919, 1.0009959379936195, -1.682917239045367, 1.461331437988299, -0.31932389093362484, -0.1286655449092716, -1.1717300273931144, 0.909573135288641, 0.43280882220783196, -1.0052653863685546, -1.2984758393863656, -0.06812601754195972, -0.11159531258248712, -0.4076448620355481, 0.48531035968188774, 0.08645812166903634, -0.48390625814414173, -1.9300157899150456, -1.225073663479523, 0.5496015661234526, 0.24146896307108537, -1.5198774197153235, 0.4593032066716018, -0.7875187320257169, -0.9462344030064982, -0.4857837125304838, -0.4575426278334873, 0.3502544548917944, 1.6541458747083444, 1.1538566115767765, 0.20213305385556363, -1.7253983321154664, -0.7621342494963583, -0.17390188392057504},
    {-1.2811020102047401, 0.1498723789465649, -0.477976932182772, -0.491624215941276, -1.4389657872446437, -0.7802260137726256, -0.8549606720418723, -1.1938863282843375, -0.07518503789744074, -1.8839026950109778, -1.5953987140384054, 1.774392338648233, -1.2047382846405223, -1.4783213515320954, 0.4285504385456884, -0.10952971808246928, -1.0792729748130212, 0.16983393753339981, 0.06319212010938069, -1.0143438025800962, -0.3058920276395715, -1.4290771567661262, -0.3056354739797904, -0.5317637226140284, -0.4390221269867694, -1.951580760377908, 0.8849486631198805, 1.5635260086932137, -1.5693445215882118, -0.6855930123908338, -1.7347999744383087, 0.3450160530858915, -1.406077822410487, 1.6370870665967951, 0.3609982239287086, -0.6185016345636059, -0.9153612362784901, 0.8805323874958816, 0.07418092807171124, 0.033325567316093464, -0.5473564968211274, 0.8263398193231934, -0.946804301167846, -1.1549394542621858, 0.7574636451443316, -0.3904397921609654, 0.05745852545992029, -0.09792125692892659, -1.2422119803322949, -0.4217764634397835, -0.12726838065729926, -1.8656051121116628, 1.7399054280122372, 0.41654268941723704, -2.0832308061089844, -1.3005526324704844, 0.5614880344108789, -0.5497419156562813, 1.413554228715263, 1.0073792289846006, -0.2843066203830857, -1.4413037892219185, -1.074079018329793, -0.21575304838426193},
    {0.1520508618088681, 1.666899201668957, -1.3718340659863357, 0.44271077982208956, -0.918917068758183, -0.46827415450717924, -1.8894817362102756, -0.9475838342884028, -0.6637164402122, -1.9582684092431382, -0.676793753401186, 0.17223861255157122, 0.21660386491527897, -1.8779456095902525, 1.039646831093687, -0.0926295470080435, -1.371996469970411, 0.5260918959349958, 0.8044269887062089, -0.06282804630415319, -0.2550594518278851, -0.32777158552411445, -0.654623372309964, 0.6739491436036874, 0.5639999142284753, -1.1823269967598127, -0.6324374149340449, 0.6135579210336566, -0.09712737713528732, -0.4634698726497019, -1.591738575301992, 0.832832289417095, -0.5903818035192727, -0.11340137191298466, 1.4131931560964173, -0.9816347816973595, -0.17873937886044158, 0.9932150259953454, 0.295395961768419, 0.16569774944199414, -0.4952387734951673, -0.2006373794759241, -1.2303882432364432, -1.8100675796391337, 1.295317387398643, -0.459802615601049, 0.6541279430837862, -0.21800586878198652, -0.30853499474978663, 0.6687712302675707, 0.2204022692892606, -1.5280403033390053, 0.30003355508943275, 0.22428890276616317, -1.8259326605960788, 0.027450696204534112, -0.16796834836818628, 1.2669568014735775, 0.44565457522105556, 0.3206532558817792, -0.2747055201760388, -1.4806843842116846, -1.4192297190352579, 0.13376266503896428},
    {-0.21070474859522723, -0.35683441956911305, -0.6915823125571805, 0.7644549750115169, 0.17337619976586194, -0.6130591808775306, -1.4919102007505072, -1.4772358659369267, -0.4310264817201637, -1.1395914480516176, -0.9881171644801061, -0.06791006603204626, 0.38010740911585095, -1.3574256064474708, 1.5302678277512303, 0.7532650764397998, 0.5282120208858018, 0.722946679678334, 0.5552759861239943, -1.5758423863306452, 0.013906835517488988, -0.6372120665763495, -1.628856481206486, 0.24054181755898038, 1.0251579171267715, -1.9587103831130122, -0.8705718802840947, 1.6115308637535086, -1.51540638259258, -0.6245544979213573, -0.536205993988984, -0.42221473339649024, -0.969636190124245, 1.2718894972721975, 0.2577248101451244, 0.050778006899432786, -1.1880079323017876, 0.7516150498943687, 0.4174029691043522, -0.20589650074862156, -1.6343239367384474, -0.28947110584102226, 0.4602052544201162, -1.5121415993243976, 0.9773347440286219, -0.12282531845874232, -0.9928777424941532, -0.3406872025106708, -1.179191357887865, -0.2929066429575344, 0.6758579121355935, -0.3779895099900338, -0.3398461678495906, -0.9362236809193663, -0.7321600168945198, -1.3135673599764026, 0.22704993897980652, 0.05491142410871978, 0.6033963176335275, 1.3541706262361484, -0.584148490385628, -1.572207934852607, -1.7279815222576647, -1.441681497112071},
    {-0.9467202954574074, 0.9783502062285944, -0.9098654856121537, 0.89899166787206, -0.6177384975558586, -0.9942470718418696, -1.2937892396704493, -0.4877472957421264, -0.04630416413507051, -0.39487102645138994, -0.5061959341998118, 0.09206725190772595, -0.2981277700076461, 0.022570159348855704, 0.461408555243046, 0.011137813053333702, -0.9484076137954018, 0.4812599401587322, 0.9052010724763198, -1.8163897232155295, 0.7282898273813382, -1.9400393692191436, -1.6647573165177547, -0.7354680558163018, 1.0572059358590702, -0.953557717875861, 0.4969511272078852, 1.4799847325392144, -0.2025398845119018, -1.709678651977209, -0.7446420772923188, 0.06419486189828852, -2.048030304102683, 0.2752590563106756, 1.1576878701363034, 0.5165972848533408, -0.6908970010011977, 0.1591805429701545, 0.42624750232631936, -1.1011269889678879, -0.3911409954613318, 0.7788457510494878, 0.27162112350284373, 0.06185623801119718, 1.2804824750376114, 0.8372245433251981, 0.5003239943251594, -0.13246052201853908, -1.234908456149964, 0.9230157905632431, 1.222955146023697, -1.6251545006068773, -0.430138491349933, -0.8957952748697027, -1.4077226388526471, -1.9066742519878497, -0.3073109348039353, 1.2794850871158547, 1.5082274554459898, -0.4908018664636309, 0.4096291170329367, -1.7731638418654936, -0.8460937093933323, 0.014879802176948448},
    {-1.537759349057484, 0.5333030118958337, -0.006749988539596917, -0.26739391164697446, -1.223627628501484, 0.35199792202849206, -1.6005299222252518, -1.7590742577830951, -0.44059870765351655, -0.2457393942265753, -1.7299421183876993, 0.3814166291310793, -0.44443542635562433, -1.2566624510952262, 1.512181309041847, 1.1597590101014834, -1.4167528633253716, -0.051325882579966196, 0.7543489058714815, -1.372249103532393, 0.22649496574273603, -1.3920650046950551, -1.9446478508332676, -0.7002895101897653, -0.7123815356688048, -1.491767049977035, 0.22049850265546492, 0.3119117013961815, -0.5552106574449206, -1.2756200856768594, -0.6721173120990246, 0.708922885690269, -1.6791067145023504, 0.6007520628947991, 0.8831887025105757, -1.0068376977453306, -2.0107850058130303, 0.9571234937386377, 0.750994027012744, 0.40472630382353253, -0.9584481020187962, 1.4070160482625726, -0.3029724784645689, -0.35067191533172526, 1.2064767897370376, -0.2853200729641276, -0.05166374108657009, -1.3177366997403774, -1.7024519875735784, 0.6157095743202964, 0.8648854847841502, -2.186568526461792, 0.898019290982423, -1.2550374645621103, -1.8951350606382007, -0.7464253583899856, -0.8742052514035278, -0.4384165122030264, 0.34091130721947027, 0.7683728288548987, 0.11158736326932996, -1.8353570162702408, -1.5442710049556787, 0.19100049755934334},
    {0.36935736906406824, 1.3276336836608535, -0.025377464841828536, -1.029819572946532, -1.0439340727376467, -0.26141070432762276, -0.9451499284233115, -0.8846251976100296, 0.609400687244425, -1.3890809250810368, -2.1814736226692526, 0.9594831269960683, -0.4883492713584832, -1.3641587003856899, 0.7390300788568873, 1.3942470002614638, -1.3753453486896712, 0.0793649002197869, 0.30838036748075703, -1.943645139193192, 0.4790230571017926, -1.4182624418409762, -0.6515475318500276, 0.2149770907222096, -0.09961243259755194, -1.2577030952720105, -0.8944470731865384, 0.5799523521051964, -1.5246968924474837, -1.0067857563076588, -1.3694797231507907, 1.0551430327174742, -1.0110844616710546, 0.48678278430886596, 1.5487540948394574, 0.6950231670134286, -1.3270273281626783, 1.0675430673597373, 0.7095021035535857, -0.5719580760943027, -1.1475060820792566, -0.3779284837702758, -0.49886193707577636, -0.4875159159393989, 0.42029129900342654, -0.33753991159109814, -0.24444453793076965, -1.0765271767998963, -0.04517787791064482, 0.12681796954248709, 0.49742242779550633, -0.3408620705889549, 1.104934317252397, -0.7894085997836991, -1.4038814397152657, -1.8252618556326814, -0.4437958355629713, 0.20160005719481705, 1.4442748636858533, 1.4002541428349047, -1.1160842049196684, -1.2083557410083754, -1.301639613393252, -0.638750836499827},
    {-0.2152697820322504, 1.8906917692286804, -0.6879796227697056, -0.723519936469641, -1.8433275106521632, -1.2106667586891204, -1.1992492467874036, -1.659591508151332, 0.5922233178812766, -0.5383027463204665, -1.990084413045215, 0.5420482637983881, 0.2905212039378611, -0.7800798202600218, 0.5534396966166304, 0.7237079838372704, 0.7712626427928142, 0.691195402645094, 0.7391183663512673, -1.0065766095117081, 0.20039110096583254, -0.7777446334881323, -0.3337026441233587, -0.2811801020122388, 1.1929992824639681, -1.679541329030982, -0.02801033394462756, 1.2749572994761071, -0.4564088244735319, -1.2887662701524856, -0.6234218398983657, 0.42545513632088655, -0.7164527098444965, 0.5263847109106471, 1.6355023290905064, -0.04760570887825992, -1.0886102686771975, 0.8485679110857184, 0.131907354102039, -0.6770995731176633, -1.3286359443152165, -0.07035873524885256, 0.5925895538347241, -0.23079550585370895, 0.9886515405400679, 1.2141605977656849, 0.8710361392626951, -1.856303459531011, -1.6826104464684215, 0.7305559135413986, 0.6365429064083571, -1.5863755420697465, 1.6862821215105677, -0.27906162561095416, -0.7401240338793745, -1.8169106760181846, 0.31857968508705103, -0.3720737812669367, 1.7144165150606259, 0.5020756062357324, 0.16138178816063062, -0.4290270062219351, -1.9320114627810316, -1.3389115168789039},
    {0.21334269024454489, 1.6804663352026847, -0.11169332183005501, -0.347944461556365, -1.8231285812597482, 0.4030271561664003, -0.06317276560663163, -1.647579121740354, 0.5417875137294272, -0.3973302566043451, -1.74571094889026, 1.8123059938655912, 0.36910728065485776, -0.9702425138202915, 0.39788718993239985, -0.21852257050989848, -0.26845852460019765, 0.5829920029223038, 0.8554566545048897, -0.45295947249872476, 0.5943710954095177, -1.58147699801856, -0.5717037858206367, 0.5362574574815401, 1.0465211153896574, -1.176424519032838, -0.5958692789957714, 0.8632630256349227, 0.0006753387481854158, -1.5221443293113393, -0.22679294493732446, 1.6899005406809404, -2.013389904519028, 1.7434062478399395, 1.5201064660415036, 0.3743012440026088, -1.0918555367268294, 1.5452627877204137, 0.5111470022966178, -1.0623162890455538, -1.3799049864713018, 1.2359837655029637, 0.11739206455986813, -0.5308257469374689, 0.8889147644180243, 0.7210151513089613, -0.12850778789440553, -0.675158350131659, -1.90276496257184, 0.08823864411097261, -0.41878436649378936, -0.84464262438308, -0.12721030997006946, 0.6288441274497667, -0.7279446880759785, -0.7559704853781772, 0.280647811326458, 0.9411781961852249, 1.9904467756399429, 0.6616586769383332, 0.03455123486966439, -1.3793252587008433, -1.141074943409743, -0.05674913353124615},
    {-0.4612060459452557, 1.5587179332349737, -1.4763415167662803, -0.2619910748868985, -0.16631175938302264, -0.49390873960003795, -0.7267825145270198, 0.2002262051829139, 0.16822389989977624, -1.3447346853835225, -0.6337821950894253, 0.7921028814726008, -0.4078896545501159, -0.3037191193776285, 0.6392603892277615, 0.349267216650002, -1.1451314849193601, -0.7061606870043432, 0.06611562960182328, -1.0251694268097349, -0.5355027417507288, -0.03361232793522933, -1.097748858064149, 1.1302709370563053, 0.10292876953527687, -2.0512666655648197, 0.7078050522461505, 1.1163479687376634, -1.5685081195852189, -1.7344348455812537, -1.2894705759034253, 1.3269507896414943, -1.6015547882183392, 0.28114153399383635, 1.581832461638811, -0.8851927976970547, -0.23745822183410348, 0.9504327478719512, -0.0901188580881557, 0.45103681559984227, -0.7020243596175051, 1.4965113905245775, 0.29093864843368694, -0.9091733297340312, 1.6966260864877185, 1.152253995364847, 0.8528755331043368, -0.14555074602169357, -0.3790271235411861, 1.386489621959432, -0.24698965883187166, -1.0005057663072139, 1.8095981504312733, -0.5586639679944786, -0.36343465066749914, -1.2666909055344995, 0.8796397803436908, -0.2526637876076742, 0.9739859337969621, 1.090511369544253, -1.2621061298717386, -0.9173290438407944, -1.2912414870590754, -0.8045167120619591},
    {0.05297518525814718, 1.2596852002894439, -0.10062433758695745, -0.1076330232613951, 0.06641216808845443, 0.1039059385513391, -0.5865792349825313, -1.5865213260805575, -0.8978709858975148, -1.350624511245574, -0.17171093325950923, 0.3248446350596686, -1.2858865647810178, -0.9361115176225279, 1.0899448249375108, 1.1220689551157024, -0.3502329930924663, -1.3319838527003671, -0.2643818133148416, -1.928336841201596, -0.24869922210678724, -0.10157571577422352, -1.989732192965944, -0.0900565477456719, 0.5239613456502932, -1.4608598914131299, 0.5390112184409678, 1.5906027122201578, -1.65242179794279, -0.7027642590490532, -0.7665068474765167, 1.465370229061083, -1.006739417574782, 1.1886705990136293, -0.19750569223401032, -0.3717212900086488, -1.2554878008703234, 0.2604379208457124, -0.7790926215571699, 0.22826620995798397, -0.7123567722850241, 1.089772669538791, -0.8344866493730032, -1.6147930260055672, 0.784285106023395, -0.031004570950104022, -0.5946148054829995, -1.462731896500646, -1.416087284291482, 0.9766280511614996, -0.1484945771269423, -1.5454643899843368, 0.4725949481910392, 0.13024552050659605, -0.2671671548798918, -1.6269656958149157, 0.44024668696721503, 1.1785177062775725, 1.366585267086222, 0.8185179668185526, -0.3322953369315644, -1.2162286113145966, -0.2670007162303684, -0.5157296976701788},
    {0.09138842202811391, 1.711202445153703, -0.5497062492722039, -1.0365161877498388, -0.6879249636982838, 0.07809152924183464, -1.8803499987097188, -0.5497783748737964, 0.8049348403441918, -1.113749821826353, -0.7617437900771638, 1.329069897735232, 0.10581662098662346, -0.7404245763191919, 0.49734236487454336, 0.8752002899249857, 0.6531714214120493, -1.0911255239065427, 0.7706145949286757, -1.4868577287127651, -1.0425492710922324, -1.155557024449034, -0.7027784190378235, 0.5261173841468236, 0.5131367870254268, -1.3888721519546443, 0.8170708114591746, 0.6482757775706112, -0.10543300528727936, -1.4007791955531648, -0.29787795848117726, -0.03230911709956994, -0.9310343027738857, 0.21835570334996793, -0.23012227871922475, 0.557583317612763, -1.4243653541374068, 0.9954203517901118, 0.7458799401633429, 0.030727554869399213, -1.2028250341195, 0.49197383868593136, -1.2135640864095332, -0.4166318881331738, 1.7119833328391008, -0.21817133957798132, -0.5769763791603614, -0.6067988318439662, -1.6981834737952022, 0.6335515486050534, 0.6689924141671871, -1.299298796478441, 1.2797890346726128, -0.6184888569450406, -1.2844342265124207, -0.9638102911809528, -0.13933246714572114, 0.6756081513555164, 1.468395269842468, 1.5384053730592873, 0.12810453052046816, -0.3919203070696912, -0.7840201767617189, -1.1995776918689456},
    {-1.4841364002359203, 1.176748694926791, 0.08114689096174463, -0.8409603401201388, -1.6621626607319293, -0.6746085799771855, -1.4962753739651138, -0.643789865387715, -0.6941149063359466, -0.3827258943192229, -0.9067617414696223, 0.9301302555165234, 0.18995286028442113, -1.6397697681645615, 1.301987190704104, 0.09235802624174737, -0.2981755317869943, -0.4409984491594721, -0.8869023002145141, -1.4179863105126989, -1.0870582591527604, -0.9240388254604973, -2.167439510653375, 0.6348523409777822, 0.405099498773419, -0.46069200869737775, 0.7424965996161632, 1.8398080242300376, -0.26082924990773865, -1.804350474958191, -1.003310965146941, 1.3851362867797707, -1.5813406535798935, 1.6116500309989499, 0.3813840750034973, -0.09221552859838542, -0.07065621159095468, 1.4871627029172416, 0.9073144511030407, -0.4126075461381079, -1.6612760485810785, 0.7751395560256342, 0.884354737823656, -0.4519522653186885, 0.42826901782348575, 0.023590746333144674, 0.9730054620646823, -1.4000499501526462, -1.9547138779160889, -0.31442952493814963, 0.17677660563395065, -1.114006715219874, 0.38274412053101603, 0.3338231827854377, -1.569251447789454, -1.6185493175095742, -0.5035324790240543, 1.1829921116014548, 0.7051542229134942, 0.7961407443866029, -1.0684946159206032, -0.9169103622692244, -1.838151560858357, -1.2353225650813109},
    {-0.032726991765042686, 0.7836920901414242, -0.5005951500095464, 1.0827858387297224, -0.37547485388527774, 0.1253917573900837, -1.6728945172743692, -1.273435502344729, 0.7430123351233303, -0.6428200875265322, -1.1376456339598673, 1.9689146596161464, -0.8933121129477658, -0.45168298860981687, 0.6955194723735418, 1.5668582790958399, 0.7855918255244456, 0.07412511070565524, 0.2907348698213471, -0.9337453337604644, -1.0012563627831235, -0.566802920316603, -1.7015251948931813, 0.9900864734512781, -0.4851511443315444, -1.8915903453499827, 1.1367008876266058, 1.107041396493976, -0.5578471730175457, -2.0422001884396357, -1.2265280046899993, 0.485292533769042, -0.43367372648621766, 1.137074263646095, 0.23916492435527695, -0.7125073387603302, -0.7863430586927841, 1.7174697574427409, 0.6092952743153652, -0.48038725662038007, -0.5373756396437942, 1.1246309679720827, -0.5612088343670676, -1.7617939242268406, 1.9340013811536612, 0.7078469628466589, 0.5930183578897765, 0.24068693356102852, -0.47104091532931974, 1.429240025502687, 0.9660365582749204, -1.1009217896413483, 1.739834284171355, 0.19323766935773157, -1.0000562674277627, -0.8220799624291105, -0.2615826090045979, 1.6591886175863615, 1.1826287496840076, 0.5608767611209068, -1.0763535040625214, -1.5595638835485206, 0.07597362733484596, -1.1174034213473198},
    {0.7705936514722291, 1.36120810248669, -1.0171473907618849, 0.6376536936984966, -1.193360686389165, -0.810366812631869, -0.8546956836830646, -0.2741231614609675, 0.6799120653322467, -1.609111510551562, -1.0255721692899133, 0.6106630941802998, -0.6106744026256158, -0.7393343321701853, -0.11197868738516252, 0.3629254559284784, -0.5479593891845506, -0.732116040539982, -0.004889535347391465, -0.4422031462061506, -0.6275329098936175, -1.2670236559063424, -0.48701122662145113, 0.4179506409180282, 1.2491057800855925, -1.2999248502520142, 0.28898698540191115, 0.8831868266670126, -0.2812672122363875, -0.8405855780241029, -1.4631255377522652, 0.7913039694493098, 0.2715646708140477, 1.5362449086848176, 0.4729128978315695, 0.920084034443156, 0.0924886305119027, 0.21538701350294237, 1.4717758690798424, -0.2840565211278578, -1.8655005118113621, 0.08184880455067364, 0.03641509443426279, -0.8958116720803773, 1.5244780835145624, -0.5306128618859294, 0.006649706271305255, -1.1134181597162427, -1.8075388538844155, 1.5937628581814522, 0.3282744766794864, -0.22854571357427786, 0.7701614396960204, -0.04911022094333522, -1.7623620237599573, -0.5161547201736726, -0.14314941301498302, 1.4600446154831808, 0.6905177706441163, 0.3456505087606724, -0.34029244850399026, -1.4529708928949367, -1.0419644876976304, -0.049330372741231185},
    {-0.7212935510181036, 1.353257881282791, -1.3738222249160046, -0.04929465958361973, 0.14852054455748184, -0.5731767550370833, -1.6409218409230373, -1.330161979218984, 0.3195561606209322, -0.6280890219160056, -0.5953175642596893, 1.2116152267975404, -0.4720706001199998, -0.1938662889685917, -0.051447776694047334, 1.0341205313024537, -0.02496094579120612, -1.2291204428204205, -0.9841350278347756, -1.1193264894070922, -0.0013411672821331802, -0.32840354750931916, -1.8987536656834163, 0.024181085240551903, -0.6269524277077203, -1.9477204192846589, 0.45310274799641354, 1.3541949177398394, -1.577921546966774, -1.7161100974421803, -0.2162065655733953, 1.7846871472854844, -0.6923062122354754, 1.0940588329311915, 0.21391215532284266, 0.8488156463812724, -1.6997791577110655, 1.959472672150789, 0.9148941522311951, -0.4992631006047868, -0.2782424488796365, 1.9268667021976582, 0.4684335632725314, -1.2276493237178732, 1.3779119261890247, -0.30497533537945654, 0.42408437885340194, -0.7945300462484141, -1.302514588884087, 0.3991369791855782, 0.994037420342554, -0.6580017648308374, 0.5126392468662396, 0.7938259542332351, -2.0199241473240805, -0.019588871810368197, -0.8161606449973968, 1.5340292436660756, 0.14835569130732593, 0.730254408855168, -1.234562460054183, -1.6013713071329867, -0.4522103507654904, -0.6940567507091903},
    {-1.2326762115414704, 1.2173488146774587, -0.7760143871463682, -0.5533504367781503, 0.17429490455944902, 0.37228646744871163, -1.3861045111166008, -1.3879861477324889, 0.8355777177551487, -1.3855886284567613, -0.6477228987440222, 0.6684046260388875, -0.17729646917655167, -0.8906969019114976, 0.9523005344477573, 0.9088895454748799, 0.2838417682999162, -1.1041576737813188, -0.7672460620617979, -1.1343209387541757, -1.1324019518790023, -1.4669100245913531, -0.5695812750688445, 0.8291687416594177, -0.2064703051468992, -0.4693599562487463, -0.31908037837556236, 0.3510939295011851, -0.6335775052719281, -0.7658219372248883, -0.48549599796527193, 0.814762424201253, -0.9733688275070268, 0.6473132820042456, 0.5812431922862109, 0.1995064876981525, -1.7278106708143843, 0.4905838852531129, -0.6375655436200561, -0.09061183873127053, -0.3472475842395295, 1.8964910323422897, 0.9719435031134686, 0.055021064992062496, 1.9552832621674034, -0.5685701888704094, 1.0092207361537544, -0.6021779802497067, -0.4750373891226446, -0.169417374729005, 0.06778456701386215, -1.343851406223126, 0.9436210414288887, 0.494482279118402, -1.9090003914711324, -0.10053121215347342, 1.0995134168506477, 0.41229440038410864, 0.729052956047361, 1.2935907815011842, -0.9607458789605451, -0.5397238565061627, -0.7852741471693193, -0.43139452385300975},
    {0.6259081585457387, 1.227399982532629, 0.1977190520658224, -0.1441008363688426, -0.5803960384867953, 0.020286114981184038, -0.42082277966018167, -0.7794370299512953, -0.8452579625274926, -1.6095419981856824, -0.34590467168398153, 1.0242572557601162, -1.0188700574898166, -1.2458461879807652, 1.4093375660697787, 0.7885992733581166, 0.045338735071347946, -1.0667422664846105, -0.4284795511380443, -1.529928648558826, -0.7182079619044557, -0.4362159427743676, -1.8668304950778702, 0.9699247578530034, -0.8172508955320751, -1.6738535780330923, 0.0003370869384774877, 1.9432645884555944, -1.5942298222424292, -1.250564854076281, -0.8021538312594496, 0.34447866656594817, -0.21434195870031558, 1.7439627853395216, 1.6073367056276275, 1.006105528189484, 0.09666999385526213, 0.09780143184000764, 0.08841765490781242, -1.325490070723513, -0.42943793652874707, 0.7173298157959817, 0.09135357203651412, -1.7079564098365771, 1.020989861980825, -0.09376483995169915, -0.14217977416038607, -0.42619972125493916, -0.9884581303437802, 0.7320488486468937, 0.25071479581637535, -1.6121092125986067, 1.6448243954320072, -0.9555043140094073, -1.967559425065293, -0.7891049526485333, -0.8656321244579724, 1.4224306214028413, 0.8099378630955636, 0.3803214733702508, -1.078573296429204, -1.1214754128485893, -0.1256097752177391, -0.2441988428217496},
    {0.08120061779042134, 2.0216492306719447, 0.556137004946193, 0.8085343966747349, 0.16962331103080114, 0.35138523329604515, -1.4610111951112732, -1.2500002640267605, 0.13953850720614164, -0.20110198489519468, -1.4686053596939994, 1.1492618487323065, -1.25674046515313, -0.1438175445278279, 0.31281968140679667, -0.07169526800408234, 0.7021587656016168, -0.028783544432743415, 0.3694862700047752, -0.9342819746128656, 0.42052990560536824, -1.9992808617159001, -0.25737054842089363, 0.703737061040801, -0.7177541510576877, -0.3119252721743759, 0.21318118023724117, 1.5308385000332263, -1.136458129115457, -1.1121995490937624, -1.3791721686606742, 1.0990114856389706, -0.6068446273657475, 0.27011931097053155, 0.3140318765871623, -0.8606449214967956, -0.006377066178471162, 1.055004242463553, 0.262183897598171, -0.6847165289181493, -1.2975541307377216, 1.6515617132757436, 0.6550896862751501, -1.857895671401894, 0.7319913644843634, 0.09636992111489362, -0.834091506121405, -1.6599446742536086, -0.049679665792688864, -0.3175455597590656, 0.8626934192788039, -1.9233681794234494, 1.488507482589238, 0.5454073600172683, -1.583176886760979, -1.2741563817687052, 0.5770532003212155, 0.8554119070906753, 1.318402645957493, 1.5189203556649982, -0.9216007157050918, -1.7820016293807572, -0.7051199297051939, 0.49352969879864866},
    {-0.47470745758557015, 0.5185612753368039, -0.9995151441593341, 0.6838085180511332, -1.351992232669875, 0.040235876831813754, -0.8560391684765237, 0.05758981494816645, -0.493973356843454, -0.5406064623311874, -1.4368731761276676, 0.2061768552576023, -1.43890523311116, 0.09356657622740876, -0.14065071256339146, 1.6418679118338695, -0.5831716114942159, -0.6335055851081981, -0.7634974026223005, -0.06084836523063591, -0.2611738216742387, -1.2173941640627486, -1.7167626121417088, 0.5433608158216723, -0.7339779750828499, -1.224275701669131, 0.35752770368813214, 1.4691468074555625, -0.8005513283009731, -1.4703991290990404, -0.3308593437941193, 0.8061278097016933, -1.843995815365689, 1.0409083908036387, 0.05838628362483291, 0.6086878814019571, -0.23762771740864982, 0.8555966756481113, 0.13895963282211088, -1.284149229127339, -0.6960766398570405, 0.39673903739232597, 0.15445601241511814, -1.8235973891610462, 0.7110121146653445, 0.02028446772486163, -0.35196511782445605, -0.8914922108995303, -1.5305449952148804, 0.4893130386094915, 1.07945896123099, -0.3437325057480975, 1.9841075485343347, -0.7406664255690496, -0.2041317227468298, 0.2701510558359025, -0.17673477241829028, 1.322513431012499, 1.951946528952014, 0.7124395570931591, -0.5841224824791201, -1.1978490674218472, -1.5284745757527691, -0.12392463716065781},
    {0.5811431316226098, 0.27785598732481664, 0.08467689174807792, -0.37813004750137874, -0.7497366066076003, -0.6099926083342421, -1.27001609918007, -0.9672039875951822, -0.6687764200520095, -0.32166308977759245, -1.8838783992422563, 0.7311480166833659, 0.5044496879319695, -0.6216127201345372, 1.2384856635336297, -0.06590317297796079, -0.08387143215621043, -0.21988059156721368, 0.9194398337833133, -1.4360941168167767, -0.8636288290185571, -2.0144919895951294, -0.3500674832142469, -0.188272959063818, 0.20860464904113582, -1.4385936924040463, 0.17348081381641103, 1.5336074459692743, -1.421377044251525, -1.2895505114914503, -1.6564859326449504, 1.7965015805548432, -0.4979098701505431, 1.4312753003343477, 1.7897743574051497, 0.8180641969323869, -1.6789760228218158, 0.5277789190370894, 0.5597738349765489, 0.10890941650898317, -1.7130555259952813, 1.6513592480632477, -0.328555322407567, -1.8449118305143817, 1.4089254436663303, 0.7311576761495029, 0.8969187260427711, -1.682529225453497, -1.866921446566486, -0.2652363200479006, -0.6955380140393497, -1.5832948853326432, 1.993882139418039, -0.3806958644013782, -1.871712948105548, -0.8095751844237559, 0.9900526586155406, 1.3809008886586704, 2.051652437483376, 1.18146464527411, -1.1800105215938692, -0.8593483080779676, -0.35330305755562164, 0.12390018996918321},
    {-0.5079905227331986, 0.7110453597621799, 0.20712208853785116, 0.629530247381927, 0.39456522371251573, -0.8768815870838877, -1.1870954834658047, -0.1304302587422744, 0.42656016724916257, -0.6392244243335912, -1.8252974310291417, 0.6729927952058254, -0.5666332076804359, -1.0992198737638819, 0.40151279995163386, 1.500444322120865, -1.0835784108897475, 0.6083485369143593, 0.0582343571392981, -0.5615461315031443, 0.10717454468340673, -1.7620211256333023, -1.6031153842467714, -0.041071083562199594, 0.18213695567446686, -1.700993729183956, 0.57643038617772, 0.9569671220862019, -1.1867253715726425, -1.71923348912157, -1.0460333992825954, 0.5391857316126099, -1.0417994097101593, 0.7532708500127618, 0.575645356688105, -0.8117223007739335, -0.10606325308141204, 2.0325125883747046, -0.27293190948848284, -0.6208087256738339, -1.8940442983494068, 1.5693019733153555, 1.1016849458114994, -0.7439081826997191, 1.072447392434127, -0.5988870451604633, -0.1315210282673586, -0.5127712158399195, -1.91318018509156, 1.0181182757655478, 0.23803799328121808, -1.8854976886761294, 0.15532137431523435, 0.5944886830712515, -0.21058446708819348, -0.7882159952506481, 1.049419624939807, 0.7791675898147915, 1.1435255366351362, 1.331333383564159, -0.5275608702956444, -0.7208444760789633, -0.10937102825523913, -0.07933564605431136},
    {0.9175427111676979, -1.0898819929191381, 1.0693688961923222, -1.429194529824873, 0.9500822276926296, -0.9155552043801921, 0.06374780143369883, 0.35596800544963353, -0.8680431997627, 1.1410184007078674, 0.6142416501881204, -0.057170056887643074, -0.4300054506820452, 1.3922891214003317, 0.48954690142008184, 1.0558630475972375, -0.5693346895937486, -0.35891791480663104, 0.6710127921431948, 0.07549635503252712, -0.8471644429911805, -0.6570702942794799, 1.3576588114775674, -0.7456650703483969, -0.13436670525765534, -0.294473787304723, 0.8110428275395737, -1.1146819934022099, -0.6527555351497178, 1.198624040309213, -0.08675097951177377, -1.1832972934623796, -0.9321743334607371, 0.04531192841262989, -0.56412780881658, 0.1962238503966731, 0.8858804522078374, 0.7515746447829846, -0.6971847372825375, 0.983747922384348, 0.24319312761218898, -0.24568179367112855, -1.1010311709763687, 0.36658780946428887, -0.6684017515705031, 0.1419007909913564, -0.2649925564457719, 0.4505856048809368, 0.9718245186784442, -1.085466596929587, 0.34022047294753577, 1.1168154971584017, -0.8344623388677355, 0.4429351006488325, -0.34142496982301257, -0.5242352873960486, 0.04575700090611419, 0.6826680805399031, 0.06696141845420431, 0.3556583515275102, -0.7554036178226853, 1.091985444509969, -0.5006462133797113, -0.013068941732130345},
    {0.28652509849802715, 0.23743793540044433, 0.12414709021625189, 1.4854044233474302, -1.4845560487145253, -0.8386167229743232, -0.41994689056450984, 0.40281396195777913, -0.6242767535999586, -0.36461162706801264, -0.1051482339509186, 0.6411852047210711, -0.2501466284554163, 0.09290442640402388, -0.3071347119294291, 0.5607879140606655, -0.10895108942452246, -0.5755364114689706, 0.01968491743182841, 0.7538350292014228, -1.344633010955628, -1.2409250704821821, -1.4928229169815117, -1.0570042140633418, 0.49629919327468247, -1.0461266774622608, 0.9628979957688999, -0.3826621569916085, -0.17763285727540973, 0.4295431738074767, 0.22519276312750666, 0.13098347866097307, -0.5958975714455889, -0.08243421787117565, 0.5907540610067076, -0.9855444034034998, -0.6228638178054943, -0.7660661398258003, 0.337929561221113, -0.9542584793104323, -0.07784916997702328, -0.15509528601102346, 0.7706648394633074, -0.5505603426650507, 0.833447416095446, 0.03828755448291406, 0.5674770239284938, -0.45516852089658016, -0.8489465617167294, -0.31462291571288203, -1.314449869259966, -0.5931617443083241, 1.3234230902380342, 1.0471304003066333, -1.1420165595685143, 1.0328972716576195, -1.1644484627426797, -0.994697998749957, -0.0690864258867382, -0.4405552569703293, 0.9743229918165728, -0.9517476196673126, 0.43385616148012335, -0.40308747412256823},
    {0.25479318252495103, -0.9334460688111004, -0.21535642466425226, -0.21155217509551535, -0.05076393263902395, -1.623050056655887, -0.6496359251605285, -1.1407674792524276, -1.3196393135419973, 0.2657573363823649, -0.6344718437297328, -0.37593105580225245, -0.8284824475291761, 0.5070011973033091, 0.3610669425915679, -0.906559159763941, 0.17120910116038382, 0.06372744197748977, 0.12015941154654088, -0.8040457935969937, -1.6753595228596452, 0.533903370988462, -0.15106632603849446, -1.5550937989747922, -1.4813836281824713, -0.24867879338143092, -1.0132587818150336, 0.5071071020877901, -1.0199376800169893, 0.5603273105683362, 1.0685673348697167, 0.4000276734247669, -0.7481631766961359, 0.11951023338234473, 0.30895185108535744, -0.7602845247164498, -0.9379272606985466, -0.015656496311000415, -0.9525228519644958, -1.7007363179979884, 0.7557211884655657, 0.3068594229753027, -0.9285863654730955, 0.5192584858082249, 0.023920695372233715, -1.3963695742099418, 0.08500817666563237, -1.2603867979761156, 0.3989359136772191, -0.8901445608224502, -1.1973670445503188, -1.4802722980245908, -0.21946952238861026, -1.4689854873090131, -1.2247765981844208, -1.0505937855410565, -0.6868834427776459, 0.336164294026101, 0.5629058589100974, -0.5246979958573101, 0.2927425337665053, -0.5879994320016027, -1.328731812483285, -0.9417367458837465},
    {-1.6390184338974063, 0.03753238836196063, -0.6860501376650394, 0.34913736091188696, -1.367370030077303, 0.09993589909654577, 0.4965751877684473, -0.1652420465102128, -1.0563474123413596, -0.8567202123225459, -0.09414692383053129, -0.9603336116210875, -0.5414484221769945, -1.321082417289573, 0.5544254701341661, -0.8414070237134283, -0.31441730725213984, -0.33697150963263645, -1.0501899987978167, -0.6126502446432789, -0.37583228172951205, -1.1744734606246712, -0.001636204891367267, -1.3721040494249026, 0.3112474853297417, -0.19622889422773163, -0.9927294839784346, -0.6799166124737233, 0.24424108845763, -1.1797865831721217, 0.6033999596455051, 0.7071752895104416, -0.1512333155033583, -0.4240229207204268, -0.8959126581243433, -0.9976055190886277, -1.1753962274028051, -0.20588292483510673, 0.022994179865474775, -1.2076374114046768, -0.11289854691706343, -0.5378236160880883, -0.5729028130098843, -0.503870253143055, -0.9904660111378171, -0.41119132193307756, -0.9767951864814706, -0.3889278029969006, -1.3830679331613533, -0.28712395062424223, 0.10976195913482135, -0.3926982515382161, 0.538330944354549, -0.07133014045214867, 0.08295612518496125, -1.1209533002165937, -0.7629272573042896, -1.566294713039106, 0.5069327149238441, -0.7337709175866978, -1.4918744555833932, -0.057926148916553157, -1.1449080297808159, -0.14492164733299753},
    {-1.4869947535147154, 0.36511082375504655, 0.2955271026108416, -0.4376287390666796, -1.1070612390175467, -0.2986611587274797, 0.40752151700605027, -1.2169687206417956, -0.5873674354022212, -1.8287594031506302, 0.13749718305851913, -0.46189255026472226, -0.9673845761858895, -0.8608541137017225, 0.1016409028502906, -1.2366209203679759, -1.3976076593856823, -1.2585149276768695, -0.42469727588843464, -0.076236428642717, -1.042157119797815, -1.5346447099731657, -0.8108879088276105, -0.718532026537511, -1.443115514307478, -0.6003762359827135, -0.9626154877358927, 0.11725055208815957, -0.1770941514634797, -0.39861271568625756, 0.2876023615120806, 0.6814492175873202, -1.1957969499143963, -0.8832710429282151, 0.5864838069119122, 0.3010310115651619, -0.2968881697517077, 0.24846468108094877, -1.0446686799651366, 0.14879599713615627, -0.5777626304988143, -0.4517003186775764, -1.10976359259037, -1.1668859249991783, -0.8214421186488059, -0.6462523504575823, -0.3581857772431686, 0.2899502456477926, 0.07955629032736673, 0.3716249533911508, 0.2892701247549947, -0.9816201732280674, 0.7498427667847228, 0.510705316640178, -1.1748485728814477, 0.24887598457423635, -1.60327799069103, -0.23640767829952286, -1.2283194899159164, 0.5725308343636647, -1.2182902510506208, -1.3054507918190532, -1.6104961455383258, -0.743491085629556},
    {0.016277742002832347, 0.3292627295617628, -1.2415492508097152, 0.8070074180425578, -1.6337732695209868, 0.4322360193120893, -0.3879642294777684, -0.8181725018716118, -0.4338789499966848, -0.45328329483902224, -0.8769287275275413, -0.3702190211899077, -0.6480750674969086, 0.43991113132859916, 0.8913328407792969, -1.207979549301649, 0.13779166187261027, -0.4336322382266116, -0.48472507398778797, -0.5414987282380865, -0.5270651870389768, 0.344171963215853, -1.5622220996325153, -0.28613211598127886, -0.12614247252614952, 0.4925974757729439, 0.6087072777630462, -0.5728566936576901, -0.7644761861615508, -0.35393469265800326, -1.2271019747446084, 0.044309877972176524, -0.6939451836618791, -1.6255608889819726, -0.9059115494544739, -0.232232285423601, -0.47727513412189293, 0.6881384290111013, -0.6176645543114744, -1.38241798597949, 0.3365498187168035, 0.1953552723714162, -0.6211020707538777, 0.3462989595585226, -1.0049033907715434, 0.37477942833262573, 0.33044845491849467, -0.2273551997931693, 0.2570064538150423, -1.146255799879758, -0.3392766545510174, -1.25561184352582, 0.32468938859377855, 0.23148027365564214, 0.43572327497334357, -1.6102997012603786, -0.028448617080737572, 0.3327960254400803, 0.6966918087617445, 0.5627030990001763, -0.0710434391676231, -0.9013580800831509, -1.264585226736328, -1.069557303828682},
    {0.006059430717360857, -0.15806747468556984, -1.4130647945683301, -0.314717112369454, -1.205994791176409, -1.0242151944078368, 0.39077543187544567, -0.9500284726487082, -1.4212243684185548, 0.2868820303924704, -1.0056900017146544, 1.0296668736146313, 0.07500549758258572, -0.658249306299934, 0.04384170299605755, -0.9162744816752496, -1.2291517820338442, 0.12739974903192416, -0.6254781075714876, -0.40246780485472866, -1.3419316624513848, 0.792660048686644, -0.014697128601544375, -0.8939858355881635, -0.2867681983296215, -1.2067670389520087, -0.26368415169396164, -0.2189691398359297, -0.6387008601854113, -0.45627628987482266, 0.5884734613936878, -0.6752108902719987, -1.5664975127887637, 0.01098297751027641, -0.7439754812207819, -1.452598213992244, -1.3097105223003414, -1.2958280691627704, 0.24249017454888422, -0.19426328676716875, 0.5388805593710748, 0.26641325791773746, -0.8774227698613909, 0.30481683441256474, -0.3550552484854097, 0.011846925427681622, -0.5210622683292078, -0.040054167028676146, -0.154287071944047, 0.03165915560066407, -0.20879013967039195, 0.11347742717955385, 0.5917997834002856, 0.2532031007459089, 0.2003638950291989, 0.007222834778430669, -1.2661484882104028, -0.787135112706338, 0.7132904551118567, -0.10034906682253186, -0.20082881408040576, 0.16696550944812752, -0.17946917673396295, -0.4902636929080886},
    {-0.892208414697737, -1.0982074563806161, -0.3030426983699369, 0.3514457207084829, -1.5262307693001926, 0.3687712366310897, -0.037592882032043196, 0.045372320395099135, -1.71080498945833, -0.39630631640635505, 0.05858106371517716, 0.12719551208696925, -1.579310491210646, -0.04497903707089288, 0.1269085253190381, -0.03283777139637736, 0.15735030188661575, -1.4158353527703593, -0.5696561726518106, -0.255968346444416, -0.956567702424189, 0.7609558487253888, -0.7832041420508803, -0.4842384118099394, 0.04697304642206888, -0.2562690407444712, -0.02806452396144324, -0.4480277490942671, -1.2936940537435306, -0.781880490849107, -0.42248437961757246, 0.06675127564121211, -1.4009777472147338, -1.475570648769318, 0.019176182626826188, 0.12547724977615074, -0.6927323784776722, -0.7304636904227272, 0.10385559377018891, -1.375091277276411, -0.4728835559721398, -1.0367091011348353, -1.7660084126992566, -1.0387613377051286, 0.16889562043807843, -0.9832688771111912, -0.921350558866283, -0.04257239174944863, -0.8238706120870247, 0.11072272553086597, -0.5316249864864794, 0.15665693308502587, 0.16268467018504576, -0.921037484705257, -1.0460887782327812, -0.8875238557536042, -0.22413596195807628, -1.217225034519941, 0.6818150021151125, -0.22643544322586637, -0.25906598467807634, -1.5597663212949684, -1.2083691988561716, -1.3060770844911778},
    {-0.9564544954233273, -0.6474984879047708, -0.01383105673980252, 0.5731197697283182, 0.1464892936330193, -1.419436794286428, -0.11155379919821674, -1.2420386046933627, -1.6875102421216084, -0.043449139531823645, -0.9809102140302228, -0.23311783586362703, -1.808354174008011, -0.40206805115844424, 0.8149576442841004, -0.4853960850130377, -0.609948338545582, -1.0510297132504078, -0.7440027872230425, -1.2020879937261213, -0.35190442750196116, 0.3252511879462521, -1.4570486490027834, -0.6404225404130447, 0.37447102138004884, -1.619614329874442, -1.140262244958385, 0.14964618034042593, -0.41321115807430575, 0.01512535330047422, -1.2054916430987446, 1.071641284757633, -0.8274878050557416, 0.03629294954321113, -0.5144418632506735, -0.8482109177839783, -0.5287936775701311, -1.1573437517303973, 0.34525368669238377, -1.074397150942882, -0.7501262991775438, 0.2393195401641875, -0.8693672330859474, -1.6797660024237298, 0.27507257388798056, -0.6694113214200301, -0.04691922804255242, 0.21570676858322166, -1.5782844280666575, 0.5645106447232142, -1.06901252219308, -0.057248651800480756, -0.20726547030664141, -0.9675876670276395, 0.19789308258456126, -1.385188358730912, -0.6137701393850634, 0.08104238055564078, -0.7490828339272625, -1.0084385232905428, -1.0051955907145338, -1.4466450051620379, -1.1788454003135946, -0.4491625701774047},
    {-0.11391857485354846, -0.6681169728831093, -1.496736935599384, 0.18094738135570443, 0.35796902919036167, -1.0613572382253926, -0.0434028176915829, -0.5682826202620931, -1.630564102096229, -1.3975780360207395, -1.5510976323760057, 0.9820581088336728, -1.721871896993686, -1.3272561140990486, -0.3214053243735595, -0.7648242294635296, -0.8220292162343733, -0.9809979945079544, -0.9575023538560278, -0.6396908234165425, 0.36169397691627286, -1.284912935975637, -0.6744871283981163, 0.3741639754759745, 0.21430511589786155, -0.028243836769284804, 0.10831060102706232, 0.10434033268341485, -1.8269101031872765, -0.5484403011669243, -1.0294994382812594, 0.19588623811488676, -0.47689149716107, 0.2207449613808688, -1.0824802982240942, 0.36544798171447546, -0.7653172053490975, -1.0544561711599787, -0.8108459994439696, -0.07383642405771482, -0.9137455588047423, -0.5440969202627833, -1.63780247334001, 0.11112983222519339, 0.7799181691658994, -1.1546181996475577, -0.10371848592334519, -0.5776859267378801, -1.5454153668258825, 0.1595412689292674, -0.7651410964429076, -0.6160987916601764, 0.3228656764369945, -0.1580647719707572, -0.22434728413911664, -1.4477758577351478, -0.7412856743788694, -1.4200499875436456, 0.013922074235750063, -1.284216798857182, -1.29965239569479, -0.4321223185939487, -0.9399563293349111, 0.3219362704785197},
    {-0.6704196912355831, -1.0339787573436383, 0.2557005588653511, 0.433739965251902, -1.482495170271197, -0.9462465851526698, 0.26356168033117017, -0.6365799193179221, -1.5886798720500415, -0.28312077787287876, 0.0661491519647975, 0.6570741797178312, -0.8762897997486224, -0.24279514153096496, -0.13777032311859685, -1.1364838061374336, -0.8484594908642149, -0.9829361001242701, -0.8421035348137519, -0.5565350602909026, -0.13450569473153695, -1.2261403850929284, 0.6129383403008339, -0.012764570982043602, -0.19593812932622476, 0.24573562953514244, -0.7191554169473542, -0.3849346245377892, -1.201056897537126, -0.5564029432896772, 0.3412703430604166, 0.08243468080518111, -1.0614332847206767, 0.3101270594992237, -0.10942399878922117, -1.0093563966976227, -1.235136964668537, -0.5271842701291389, -0.20594726467721783, -0.2473811621884348, 0.25945599110563156, -0.5157531283610404, -0.4734476518318624, -0.293549509874595, -1.1199491154887147, -0.5855530728365534, -0.47207661695227304, -0.06882195405840988, -0.03197017584470033, 0.7215814380482256, -1.451065953639519, -1.2781567588035598, 0.47820889501577685, 0.1134064331900517, 0.23233693051561277, 0.14703379258511567, -1.3193452178463192, -1.1448851013441115, -0.6553258048702317, -1.2968515530365723, 0.165814421816828, -1.542223352202242, -0.7030401091186916, -1.2146417776806242},
    {-1.757760397306346, -0.06296442891914196, 0.28822246304438615, -0.5813093570601305, -0.8912811240316082, -0.8722055472623711, -0.5898198203958104, 0.06915525567778541, -0.6491769874622606, -0.9970653900498592, -0.20280646617093873, -0.40060436108797864, -0.8272833450558218, -0.3674810475583825, 0.1550558236295012, 0.46106323875162364, -1.2844324437823988, -0.09458281372914237, -1.3792066297141963, -0.9661631045029526, -0.2753332888556539, -0.9508049622654934, -0.8525801950866798, -1.1023162748379105, -0.5043304419177893, 0.4953236223177944, -0.9387504070934471, -0.2061592349267404, -0.5696793597563902, -0.14468983135668542, -1.3643300374550242, 1.125996613347172, -1.816987145173032, -1.3092962868412918, -0.3047966099950726, 0.11991505811076955, 0.412250400914861, -0.06816086513785599, -0.6696381894956503, -1.9363412428279057, -0.5333582470271442, -1.1882805025173704, -0.7842962568031886, -1.6409231463857277, -0.9622173626365154, -1.6046098610084785, -1.310187352522737, -1.570051538122278, -0.5870507602286685, -0.3431816924593074, 0.010715048711294911, -1.37751584609374, 0.6546166535379723, -1.1265746510187074, -1.2335807263996732, 0.3534347247172254, -1.5722680274871879, -1.3840337405868917, -0.3751380667998826, -0.16856222435475532, -0.707260472524877, -0.6183023973259121, -0.7230549054469463, -1.6196221988266815},
    {-1.4270547210777782, -0.4522958326495815, -0.6174699585697924, 0.1446517256662567, -1.2499846337673195, -0.517983987829726, -0.2078225204090427, -0.23093586698350285, -0.22396612966400195, 0.16965309811280332, -1.8357343048913342, 0.7304977277729353, -0.3245171915789464, 0.21994117702156984, 0.07484055777925339, 0.7774284888502898, 0.2848491238731548, -1.4586979516374374, -1.2594934126603132, -0.42709437260270916, 0.055907704288969816, -1.2385871731809035, -1.5554453955777472, -0.7113427366074441, -0.25748559558615003, -0.5679240547421676, -0.08942478460516183, 1.005019573113258, -0.2715442088316159, -1.5728948433355223, -1.4168364583220883, 1.2026849383298381, -1.9056614028008372, -0.7277273064076494, -1.128521108389134, -0.02566782586532605, -0.32697134729365246, -1.0223226474454354, -0.709719626812906, -1.5468692171134246, -1.3589883232068964, 0.8056369099853993, -1.0023645783668944, -0.7198940398478857, -0.29689277129443703, -0.7157209286801219, -0.7434836761024471, -1.50365159019026, -0.9581975976191903, -0.4842150644771102, 0.16984138333541787, -1.4534896405514581, -1.3004260428823196, -1.0908767229096494, -1.5803096313907585, 0.19823573010986376, -0.33028804168988607, -1.0309131979446275, -0.205496215875304, -1.2937624917449186, 0.01708137666246801, -1.1413253932249199, -0.7022411045229073, -1.8160053035632766},
    {-0.3954944556437771, -0.11286071398132051, -0.23448597778469105, -0.686525094238382, -0.1975506687153404, -1.7434222305842457, -1.8275483277044013, 0.4272128070160697, -0.36936795571103714, -0.8739885409415533, -1.5476993242877628, 0.35879954210761017, -1.5994316369796426, -0.6463623726252429, 0.04096497563725112, 0.20141644349823387, -0.06889729914182277, -1.5580027136096644, -0.20290676310592032, -0.004372257851481582, -0.2370433853489462, -0.19277996546018003, -0.4788052849583181, -1.0143826428955414, -0.8870023750701331, -1.1118721487019976, -0.982341277692085, 0.9663207514444818, -0.7562992767666148, -1.034576885145737, -1.5598172484941606, -0.36675875527490803, -0.11240038397767678, 0.18912771278428614, -1.274913676049035, -0.676511422399965, -0.43575095103425654, -0.3205135315857997, -0.9795581173570761, -0.9328573784431097, 0.1552817409196843, 0.5457662468171731, -1.7859146022328267, 0.273725691361551, -1.2002717250785562, -0.6825718639065875, -1.020440321903338, 0.030475060322729317, -0.6837530934242512, -1.1747699398563352, -1.7551223802961187, -0.5657741746308653, 0.4966818935025888, -0.9510271740319789, -0.19460993915941152, -1.5060769711995312, -2.006710599776951, -1.0682229568779171, -1.112339560247155, -0.933591290946875, 0.04233452522429638, 0.2775246960588687, -0.6834406712208266, -1.7725825092688465},
    {-0.5035158299189697, 0.47762091221012604, -0.4906859350302949, 0.5447638987822135, 0.10928862685323171, -0.625509240313078, -0.5230951942615264, -0.6138350381992413, -1.8599083545718766, -0.34902080641006894, -1.5360205412518275, -0.03873126386593458, -0.8746486005835948, 0.29308505235492954, -0.3612736542927654, -0.03342712586489657, -1.315990963631405, -1.5695969569028094, -1.0488291830834435, -0.7323486919253326, -1.2227972627349095, 0.2861591457641876, -0.7973285624584769, -1.194464298433251, -0.6422946481784906, 0.24058001553905273, -1.582778178032717, 0.6141972330860208, -0.0457538668430021, -0.7760782773072319, -0.7047903005509965, -0.07460654163895125, -1.8540393835224818, -1.3094467906885383, -1.20516528117464, -0.9782089493759935, 0.23086602639211612, -0.10032496378215235, 0.1773588402255539, -1.7610814205635732, -1.4871923216622176, -1.3130817145107971, -1.5213954353044084, -0.451287451626885, -0.27742750043511033, -1.0498542773862534, 0.08835893517234504, -0.6952806284798335, -0.3162401937276778, 0.14297081693393718, -1.2197484176255808, -1.3427240029760579, -1.3582511979626588, -0.6121242635061318, -1.2428864481070567, -1.215845089799139, -0.6062548550768475, -1.1041290172764875, 0.7075752966971033, 0.3652118646954113, 0.33244787331253906, -1.6179492521198358, -1.8177872055747075, -1.4059697122106911},
    {-0.9099794998397729, 0.566531077896237, -1.1277484608059434, 0.5265790366771126, -0.2241806255654532, -0.6260533345022729, -0.449249578100918, 0.33608100992933443, -0.12935659593392745, -0.8405531613045484, -0.911136486601851, -0.6868009351690909, -1.3774409650969297, -1.1912237251073625, -0.05213188981254089, 0.04701796422812565, -1.8004320898845378, -1.4989792221922364, 0.173911105213653, -0.9965686454634557, -1.5941147377681903, 0.4309417685175341, -1.0762124029244324, 0.07493935605313815, -0.36645484061174605, 0.1676475413368023, 0.274756590893709, 0.20254670554080306, -1.7411110361598205, -1.5466643533379587, -1.4769771261621516, -0.6101018904501622, 0.06172820832626753, -1.166534691206389, -0.06956354091239228, -0.5630590964182801, 0.04130319139863606, -0.8589528150813346, -0.14857489545310879, -1.959567432519712, -1.454237075744827, 0.2631573617517651, -1.951765899657155, -1.1520142942119551, -1.6004124111760365, -0.46349297616838137, -0.873996006688646, -1.6218297849066619, 0.1277260838260112, -0.5024194185081844, -0.34351931206915515, -1.6005223565412465, 0.17613103055377946, -1.554134455126886, -1.4829921072090528, -0.26297500068253765, -1.483666570986395, -1.6140353928990028, -1.1128349288098895, 0.10748175755450262, -1.5682079179276553, -0.45022672136800623, -1.6305481093018621, -1.451565815927174},
    {-1.4690282009826259, 0.7013124577852228, -0.5988396382870991, 1.0096359142452498, -1.0871281237119395, -1.429696581709844, -1.2940082082266684, -1.0497372110301528, -1.7194100994423005, -0.09187523805744496, 0.11755019635271356, -0.602988730306222, -1.5538479331720105, -0.5853457504741997, -1.2611861795898236, 0.5387760950626023, -0.6885051158420286, -0.5291984167820944, -1.1649133193061727, -0.8773460963934999, -1.0686226023840173, -0.42269459238157914, -0.9098029733662468, 0.19044928044988882, -1.3629966440631587, 0.5273788105412792, 0.05258721992250308, -0.21526020802933601, -0.5191469665043158, 0.3541074661305811, -0.7326074719369015, -0.4379107553759389, -0.148211071540315, 0.3905423649521164, -1.2559385750870484, -1.4149051801062111, -0.5059361694360266, 0.07807747321850764, -0.9934684267850682, -1.8295774740429136, -1.5109981040948142, -1.0851640818990875, -1.3151643465581013, -0.633309114046875, -0.2042638236805173, -0.8234758102625667, -1.6247866982271255, -1.259042483355644, -1.4725293360800757, -0.4829532814803184, -0.07683482459808498, -1.5320773048683511, -0.3803220431506657, -0.9461505662018522, -1.3257764238078262, -0.5360448443976799, -1.0163258707750462, -0.2153162907729479, -0.7822172477798222, -1.469393268379002, -1.3868794049109663, -0.6574244220829646, -0.7391069102449493, -1.7026459730916306},
    {-0.7877413135822908, -0.021683735142736207, -0.6090986705652768, 0.2002742938548171, -1.6314506347497482, -0.7197863310264941, -1.1551279518075441, -0.8159346035668441, 0.18102759402018326, -1.1910462303230176, -0.054122477277617424, 0.04611707559716319, -0.005015192046314037, -1.1923946087590787, -0.48193802963975024, -0.9221866131224703, -1.3061114385202155, -0.28919326126211353, -1.0595335438451967, -1.488890247768057, -0.9427852073822766, 0.0068008945813078595, -1.2151932296581647, -0.28602776386688494, -0.05232724660160365, -1.4108189061572836, -0.8094226264331122, -0.17208904426156174, -1.7637558486032998, -0.013697232411687422, 0.4652086833714623, 0.9692277159530256, -0.4582328327714397, 0.3391708261523407, -1.091627215504793, 0.2616050769621169, -0.8582789323004528, 0.18987868009480374, -0.318044175651307, -1.513855250196248, 0.22970178681718006, -1.077493753514953, -1.6999981870998044, 0.030884277238289317, -0.5394350379696367, -1.0993264994919458, -1.5675097342185296, -0.7168677546999721, -1.1905018937043328, -0.4697189136267291, -1.5634537801243495, -0.11163099400002924, -0.10688390770431007, 0.28585173220656207, -0.6657560818136001, -1.4243063525408144, -1.7215269389586623, -0.03259149036475821, 0.042734934088944215, 0.16131026686022143, -0.23054101275081615, 0.19514538237611012, -1.518738979352, -1.1187557688069285},
    {-1.0969565590339037, -1.3991983810643376, -1.2860503251861077, -1.288079182888164, -0.8277038747584555, -1.39411450079376, -0.3586187910766565, -0.19474488582959967, -1.62900305826418, 0.27844179532621277, -0.1342948498696867, 0.729734954270144, -1.8962604655646884, 0.058330916040807916, 0.12565144886609056, -0.644409518046971, -1.4168503131641437, -1.7941906422578424, -0.5882045940862916, -1.0831176487612475, -0.7232813899998329, -0.4264565842889169, 0.3034029252975247, -1.4259349439022486, -0.17525411050513226, -0.060774488074818105, -0.5856301611943958, -0.726073353529644, -1.6949892083735283, -0.4860631369548741, -1.3852994585466658, -0.45248268031025873, -1.0276155903400916, -1.6984319624824478, 0.009113540621080794, 0.05524341132088201, -1.3537182697856784, -0.5538774183716313, -1.444630246530938, 0.12128599698853058, -0.6931983724182333, 0.30906536944377294, -0.3651764829373593, -0.7823712509206772, 0.07393338434940797, -1.618601932271389, -1.5634444420134612, -1.1000088668321237, -0.3297411751530597, 0.5789283701507705, -0.9736843022975495, -1.6224829596678305, -1.6880605968018894, -0.7904828396416603, -1.2688274172239562, -1.3748870258953656, -0.3126816735810405, -1.3498129434708832, 0.014377866699325316, -0.8243507072643139, -0.5895008506544235, -0.21190052058223277, -0.030435282658748626, -0.41496850860997064},
    {-1.2491438583973962, -0.197015986110898, -1.8697980080195156, 0.39152132601835105, -0.34093234281117424, -0.3865359106931658, 0.023948746590804187, -0.12035811693456153, -0.9459516536333078, -1.2237542953214213, -0.3733978728082252, 0.008293135531045525, -0.22738635595838746, 0.21632755213754717, -0.5606214991419418, -0.09700334232229886, -0.445800020574684, -1.0845289788995645, -0.6277340155312822, -0.588964725276621, -0.45628438235336516, -1.3116991069565336, -1.0672134975502114, -1.7255720871789066, -1.6299101602521426, 0.06406879844846708, -1.2114851756212779, 0.5758268390191656, -1.9107124295194553, -0.8965431663860765, -1.1564848759262, 0.573919682140003, -0.9790537802961806, -0.7169611918034111, -0.2435379464669793, -1.7806224411092455, -1.367950313580684, 0.352036338788353, -0.31256390098683173, -0.947306031124284, -1.4869175364754383, -0.19045833956007527, -0.0315118773487813, -1.2933156167500222, -0.3410977031379564, -0.8132484561732695, -1.4163598932245778, -0.6720363632458566, 0.12808201336829078, -0.756369790468247, -1.645307536490165, -0.6567809072651181, -0.1472840459794024, -1.5610923644148975, -1.0589010061300637, -1.674521458784322, -0.1689593705508464, 0.06276800600410365, 0.031000638944272813, -1.6599213455267372, -1.6538580035932429, -1.8293623740628764, -1.4339948560992297, -1.7184586429329218},
    {-0.9292199443439503, -0.9589886475910266, -0.01376280476011445, -0.0636535722626738, -1.4147860187952266, -1.6089446819323627, -1.3298676380830028, -1.4283016009702996, -1.4003404252021823, -1.3898025925695556, -1.738835460864667, 0.9851783850962624, -1.412599297260635, -0.15729524202491088, -0.6366594725005124, -0.15080042077657096, -1.045425924567608, -0.0190084786872111, -1.4328091644787562, -1.4346098031240857, -1.7376347870434374, -0.5231884848783044, -0.2979973245178268, -1.1731279180561833, -1.7052941333527751, -0.7355519520850753, -1.1484792279891702, -1.093730079611883, -0.3675153734534592, -1.581497370193999, 0.1697508062285478, -0.12185245443893908, -1.2433440648439948, -0.1860398818958597, -0.03538645629926482, -0.645596616036219, -1.2006945085103649, 0.7151756533080064, -1.1888313013256837, -0.8138398709101101, 0.02171028902537814, -0.3070210678085606, -1.070481702629112, -1.16065117247222, -1.475800667273056, -0.041340185367620796, -1.6747177846842654, -0.48021417144738426, -0.128831347189517, 0.03501629170428658, -1.007375184836914, -0.50105586266798, -0.802495502240036, -1.0295084994969448, 0.06558055606473882, -0.9154371051615051, -0.9041039516431727, -1.6064270983203675, 0.2639760378878665, -0.7934844656927176, -1.2163333741266977, -1.6409472516683978, -1.6560635363146963, -1.8383445947997255},
    {0.8004221395565219, 0.22898205428480076, -0.5902395105784547, 0.6746257528323392, -1.383280542386057, -0.941744257520435, -1.2865616463854772, 0.23167296360243034, -1.7462025831343524, -1.0157865111723605, -0.6694899173439672, 0.5900753976707609, -1.2816800731715337, -0.6248454253488253, -0.015809921565518976, 1.163573022252757, -1.0828106316097537, 0.011646347764210488, -1.1282377070694007, -0.9638214536535843, -0.8477096136443941, -1.470660309879177, 0.02802649015381887, 0.33781592786014947, -1.5798991755594023, -0.24900133671753588, 0.7855471797446549, -0.032010845433742025, 0.23725655064897966, -0.49131509831300063, 0.17313496335505102, -0.3792383706808528, -0.5332964219805223, -0.43217568992879146, -0.05133434804448265, -0.6645527249335472, -0.0519149564832987, 0.13080671346393485, -0.6594763104255793, -1.201646404079083, 0.5146788243156563, -0.08337426408448213, 0.09383167269194236, -1.6250607486286603, -0.26509742092865624, -0.2316532049490801, -0.5721677811430773, -1.2946118741577763, 0.2531774760202181, 1.0518731238521184, -0.7744890740461028, -1.655837936498482, 0.06819742652761838, -1.1685779734903703, -1.1282199228632475, 0.09745442740585923, -1.612174634622709, -0.006345210474251754, -0.5120590477353198, -0.05603512636616101, -0.8640277878007177, -1.7413458337928396, -0.3430524285132105, 0.18478404453285238},
    {0.7047316835715789, -0.3795190055104562, -0.597615894673709, 0.6172733526943879, -1.6024314166746763, -0.9970655268898124, 0.07701734631361104, -1.1873674857229435, -1.9752040626713627, 0.4884342416434751, -0.5000233654794259, -1.0477642987222868, -0.15784214147438433, 0.04716410809119584, 1.0167484586532198, -0.26221131515100443, 0.15770134571764988, -0.18406114258425044, 0.5066455862460703, 0.830486057318285, -1.6923935734924402, -0.13560951426685586, -0.2774297484922859, -1.3966452151531787, -1.9025119358162015, 0.586534382698284, -0.40681933192648045, -1.1221798232061013, 0.10876675384477637, -0.9606771007946057, -0.9502945473868072, 0.0380497515481193, -1.1738067363395068, -0.5283553228588989, -0.4698684432112258, -1.4626922559161326, -0.1925043292097725, 0.3122161543055675, 0.7091794284949984, -1.9708927583293605, -0.828644350353021, -0.06420515127030581, -1.7106546719688924, -0.13822985088309728, 0.24081450492231635, -0.9339963481030393, -0.19333197346208564, -1.6501096059040619, 0.2083928599081878, 1.2154745621275524, -1.1324650726428485, -1.015110345484421, -1.4281085379085907, -0.37929117923596156, -0.47054458968797747, 0.1251398933294924, -1.6241941882708437, -1.4674419931815106, -0.6769138426936571, -1.167414469656704, -1.3852364556311834, -1.3045306856526953, -0.6051165356825114, 0.09785836146124695},
    {0.18877528271600427, -0.7478160344608968, -1.6431889933321788, 0.6877332062790096, -1.2779502401152543, -1.1253739400509328, -1.2173188952250538, -1.183344087390759, -1.8984639649456994, -0.5953368153793885, -1.0321243674320664, -1.2079511210010956, -0.9955917096430992, 0.9937171100911723, 0.21488240526031585, -0.14164473502540478, -0.3336555538241202, -1.5237325574888707, -0.38325729777095663, 0.09259429021691326, -0.867273807952792, 0.8111551987277219, 0.5048611409379001, -0.34742124796880064, -1.6902793206498954, -0.060453604797805184, -0.5672574601647253, -0.5793442697389788, -0.916530245732947, -1.3824983069856678, -1.1768344195005063, -0.8621365190314011, -1.451217752127789, -1.6552215445097171, -0.5725732442901473, -0.3822340293854829, 0.14817143639252844, -1.6029253870320463, 0.5675105384908655, -1.452920947581706, -0.6626050526468019, 0.2718499879752467, -0.14235491583068116, -1.5058339188766758, 0.007507544628426924, -1.439154544925165, -1.4703592016988634, -1.7420899671625996, -1.3148032488882297, 0.10520881446988299, -1.0035347119415414, -0.30813430621423804, -0.9099788488984992, -0.8364799622797539, -0.23126692085106115, -1.8203939667624132, -0.7365971447352581, -0.4647071455840574, 0.21793625201330624, -1.4291577774868487, 0.24754706892100922, -1.2196708902053486, -1.0332018546848714, -0.09624196863235832},
    {-1.166869357249347, -1.2626441259341714, -0.3777218920686245, -1.2861568195600253, -0.4850093988861515, -1.4447209544920876, -0.9489819903377795, 0.17788112343325918, -2.0379942847834362, -1.691530020676826, -1.3734502325247788, -0.05839153982078879, -1.1334483575006482, -0.8878355371277803, -0.7215153003617439, -1.1805790055317975, -0.837285213779404, -0.2692281923503321, -0.29268407625762705, -1.1903182000232482, -1.5298375071025863, -0.9210164715800095, -0.3728584748602183, -0.29885090920405794, -1.6700652733847414, -1.3662952758005515, -1.4827066856365896, 0.2771900895606872, -1.988869320052541, -1.2288788877724903, -0.8421036315125561, -0.3469430451391385, -1.77833361067854, -1.0150838058965772, 0.4755858149232528, -1.1363733029165006, -0.5633824442779846, 0.3845090532333334, -0.4166853294687733, -1.3301143353135818, 0.04512984544429079, -0.21753965824341434, -0.540626015597812, -1.1482744832267207, -0.3648357091784881, -1.595357137198685, -1.5040503125363052, -0.990698696049744, 0.3985189430826062, -0.7798025416506574, -0.7047732815482385, -1.2662636698079706, 0.34242168339594353, -1.244157300753914, -0.8306528366148098, -0.3802543080814096, -1.1923480116693028, -1.6465941983145396, -1.0680382731098017, -0.5809835013790717, -0.7654992628272786, -0.5262026001745227, -1.2907588073299079, 0.00038371514209097323},
    {-0.4031589389291506, 0.4525492656884066, -1.6467298361315577, -0.5964587867220067, -0.7278428617953783, 0.21329027764676473, -1.3404729495510574, 0.1426438824678255, -1.8554029598797195, 0.17758967229327344, -0.15148079749077678, -0.24917530739096305, -1.141855817452938, -0.5025665592695117, 0.7497501412647188, 0.7709874585782852, -0.8667149482792815, -1.3505265138918385, 0.18432178341024774, -0.5218549181498117, -0.46713314476878764, -0.041792183943412144, -0.2018467599798741, -1.1158054067576813, -0.7880077555188442, 0.22558590813686044, 0.1760653654100371, 0.22563853357958746, -1.4619133903213355, 0.4048327400729716, -0.14645843019043595, -1.093782331965115, -1.1448716928462592, -0.36381036768705, 0.12487972638286268, -0.8858685076987979, -0.8042482088373714, -0.11890799295484623, -1.1192448243376454, -1.8960867814828073, -0.163334271874088, 0.61538300393666, -0.39892797048505013, -0.19994367260249407, -1.787880424604674, -1.3814504758200583, -0.610225768567823, -0.6078592238703456, -1.0223333517921356, 0.8883115173377035, 0.07830700968813463, -0.573351508783808, -1.5282806009844225, -1.3787766784799562, 0.5583202672982341, -1.070559960771702, -0.7946849177378701, -0.8824159588105981, -1.0333695747305878, -1.826404654802715, -1.424392536050468, -0.3530824184238477, -0.43064207594501974, -1.6880982209436755},
    {0.2753463001918551, 0.8592660876574739, -0.92444586042336, -0.3696421974097557, -1.0590496617174727, -0.16514934987536398, 0.08833537558925614, 0.6017063649009701, -0.8777130487021387, -0.17875667864411496, -1.6991722573046832, 0.7213795781241017, -0.30154185214074475, -0.9186013267342311, 0.7747722847061859, 0.9190510794093836, -0.47426029175218193, 0.27374761296207684, -0.6158182417869316, 0.6129978857082413, -1.266061697173237, -0.7986271734482904, 0.582333694646664, -1.4140912015421443, -1.0126221032882137, -0.7127490528859093, 0.07898177730821593, 0.7066973936728882, 0.059318468689918885, -0.9932365343836455, -1.34628191526196, -0.3601265086584957, -0.5086259662490183, -0.706121633518617, 0.45740621272454385, -1.34258471731178, 0.7738667479089779, 0.7643586407097341, -0.7699123284047013, -2.040138935682094, -0.08597635151187644, -0.2497086889532973, -0.2570732573606544, 0.22879476895957188, -1.5103233000264356, -0.8216165524176655, -1.818813719709829, -1.084493162806236, -0.14858208158000252, 0.9695529143231166, -1.4515278656331638, -1.1912011069371862, -0.4010919945330302, -0.7463947154767944, -0.48540357461777034, -1.352354557102684, -1.1690971792823235, -1.7101442935053555, -0.9386352674472153, -1.6442480068115355, -1.611637330916605, -0.08257436670310533, -1.4099331767863736, -1.1487985168578783},
    {-1.28965999435465, 0.7544105687804554, -1.7097055758400053, -0.8270734463515986, -0.6027221738682583, -0.9376906890293232, -1.3460792276415203, -1.1287172278834896, -0.3795194702802907, -0.8876445623143607, -1.7270620047442984, -1.0349024164425444, -0.3950354864448965, 0.724544152094259, -0.6182259808003264, -0.6522315608094026, -0.6461112365472731, -0.8621078537338934, -1.139655780445104, -0.891772159199516, -1.1649228721781888, -1.1340417937372311, -0.7444899217680753, -1.7920444294217281, -1.042894020710894, -0.853695933638967, -0.9360229938383529, 0.7637527444671447, -1.9649764430557934, 0.008326139965789613, -1.1681096247611327, -0.05961731596569365, -1.6104511399122485, -1.6199828122366788, -0.6166577566019914, 0.05574538171194087, -0.6943091079807836, 0.6388513435258859, 0.22957779377124765, -1.7532722720479177, 0.4053214862498428, -0.17373336586471963, -1.3061927212664064, -1.3307966637764863, -1.8176522834231248, -0.3852968462188066, -1.4711894125057272, -0.5929756693332637, -0.9353643159430571, 0.4430687046526185, -0.7440670953640511, -1.7891533254798855, -1.0728642919282216, -1.369965261164975, -1.0189510418924959, -0.08067769602194745, -0.7638830745335141, -1.406946737306459, -0.7536528437998743, -1.5395999394052988, -1.266120054246105, -0.7599314082189238, -1.043369880137655, -0.6973645183012858},
    {0.5441797627356663, -0.9942502621180889, -2.0228363187732095, -0.3659765048940902, -0.8803199375847205, -0.3770204045292187, -0.7543610269750514, -0.2823708456417138, -2.0225905520274026, -0.10550921729263447, -1.4052793096699547, -1.2873039387930127, -1.2681132579814207, 0.46000730050988775, 0.6010185504769383, 0.3285240892766754, -1.7119120871616198, 0.016209397068357723, -0.06933857788091748, -0.519050039391842, -0.07344703254744199, 0.8056141647962025, -1.252342370520854, -1.6507290977158695, -0.9195524275076465, -0.9109298626930117, -0.3167745930702075, 0.005475244489437054, -1.5120705686712346, 0.3322765839370332, -0.5741480109689905, 0.7365211212098081, -1.4299349363003326, 0.08310841894055158, -0.7273488594021906, -1.1172268521458437, -0.18166374188156045, 0.2774783672954601, -0.6952488663639801, -0.8279531852399585, 0.186852622370499, -0.26508542765757503, -1.6382829318947116, -0.5391465665701395, -1.5884684733503076, -0.6458620057219865, -0.015191816775182358, 0.09997171457687311, -1.382360252230774, 0.001519899865222576, -0.9203331871024435, -1.5473123275737797, -0.9638293697621436, 0.037343113892169946, 0.06409488711110436, -0.5313720324840173, -0.11186879268196023, -0.17593516177532612, -0.4363959023336303, -0.7383229026778176, -0.9681987989799612, -0.1971155037734385, -1.225390152141844, -1.8672187153249205},
    {0.5999311360220061, 0.5031364445513999, -1.0821151449033843, 0.2295596859561868, -1.6983391043902503, -0.06464508302712206, -0.5381000688068258, -0.8817587526653148, -0.2253776826621779, 0.7501025502615438, -1.2361605631379864, -1.2054375546996576, -1.229241644357899, -0.019985804613823172, 1.110535368490403, 0.018796191573886695, -0.7478374815135236, -0.5848055419187141, -0.48245113872685885, -0.04901710662926471, -1.7101535008463449, -0.2979270273836459, -0.6968209921896303, -0.749798410820212, -2.078293920542357, -1.260437533273875, -0.7895679564270023, 0.8311320184769245, -1.6294079857554726, -1.3605999695050812, -1.1923270416850902, -0.3424838024502061, 0.33610289120773923, 0.015284804670825944, -1.4729106036786828, -1.3616208818244304, -0.19002025677606377, 0.6591746754915087, 0.011021259550854744, -1.3444032467858724, 0.8591495261282502, -1.2062727695356943, -0.7317129283548346, -0.6665656648973802, -1.0874698235378788, -1.6912360933063382, -1.198814267084521, -0.06072604718982337, -0.0508588620078082, 0.710063678242369, -1.7494537073313388, 0.26044016733059927, -1.5572992700968584, -1.8028581480742318, 0.9667904099459529, -0.12198820728393671, -0.4384389269763763, -0.8693498038923366, -0.09941992009039645, -1.2243006113301598, -0.5541068661533438, -0.9526561914568552, 0.7022189988446998, -1.8734412240745764},
    {-1.3080865794181933, -0.5945024937876615, -0.46109548997234284, -1.2776719059983825, 0.37668906036408084, 0.1695991581391473, 0.13864113747645912, -1.033412579239274, 0.5680607368976137, 0.7503268734438399, 0.3014891009795916, -0.7997818175994945, 1.1020035283625504, -0.7657362004669119, 0.11018645220821774, -0.7046162883877675, 0.5747906907576832, -1.6905827853857496, 0.20025551423258753, -1.056197561419188, -1.009083676949477, 0.7938851055787707, -0.3446712583051123, 0.5921929656461219, 0.8804087992486527, 0.8796861546956393, 1.1595757465214054, 0.7267416956305781, 0.5691900277912753, 1.0207509887129451, -0.9167604680520942, 1.0575113310139344, -0.37315810759583484, 0.5369692323886536, 0.1752422355339031, 0.12346850183189309, -1.2203585298928565, -1.123905345218803, 0.8024372810231591, 1.195086085820814, -0.1297691344649923, 0.6447858603722787, 0.309514005886605, -0.3331240121745511, 0.0641474301695304, -0.5338563925174024, 0.7477296757424594, 0.1645671665268509, 0.2588407566546745, -0.8623254811259298, -1.3983338489843549, -0.94551168117338, -0.3491074833337489, -0.7465662793699775, -1.226271556913042, -0.6239734126025389, 0.39719699310746004, 0.15310860439900256, -0.946631512044243, 0.08914234138211416, 0.00021967184561465326, -0.01953921357557455, -0.26597290975489923, 0.1612432566955224},
    {-1.2258974923550794, 1.1952212947540204, 0.1600736140702197, -0.04186285754726484, 0.8525874051669641, -0.7509717241684071, -0.10781671716212966, -1.481995961229105, 1.0896819403291695, -0.19079217802000945, -1.0642603147858165, 1.042501936606552, -0.07086413071920745, -0.2811773585942017, 0.5934637024027831, 0.9285134017982992, 0.7123813553695018, -1.1057273897313, 1.4614746413657926, 0.27401988163347074, -0.2199088290717804, -0.5943881875417139, -0.20480003169910516, -0.5257724867269238, 0.7350761917734034, 1.4431955001719554, -0.26607836452608696, 1.0070637766012873, -0.8914338916501815, 0.5804955456601604, 1.1348153595117754, -0.36749502952017443, 0.7566966269270458, -0.6135390918763067, 0.7912245133074813, 0.4553047616175137, -0.4557571399669565, 0.8259928805833214, 0.9918653692092543, -0.1999479152014104, -0.9392770305346752, -0.2843664312484177, 0.2586015448312893, 1.2935701677382743, 0.1312341623012429, 0.45264283123736815, -1.25194659026864, -1.3223656710282674, 0.5206750405528321, -0.13574454045312678, -1.0715921473072272, -0.24197682298091844, -0.8154729193061008, 0.3192053351437967, -1.2187024274062395, 1.2471811377517716, 0.7374347349894218, -0.5910027547494509, -0.9829422803060698, -0.09448748781010333, -0.7120211729910184, -0.460002859900254, 0.00516563204988269, 0.5951149153095074},
    {0.22423469798684986, -0.5866381717796368, -0.8433759058535385, -1.573289476708482, 0.12905252782862092, 0.8980332698576111, -0.8283966905854026, -0.3524388770404286, -0.2437925242518567, -0.1385606753676507, 0.10246518164051245, -0.8472053470893581, -0.4310830653434928, 0.5535982197493383, -0.2803921610055241, -0.6582802368000565, 1.2875983122531993, 0.21504096526997807, 1.699268712327547, 0.21982645897128456, 0.3125080375241506, 0.968549849929675, 0.7995935453182779, 0.4951981085341962, 0.09139726085884411, -0.10450128520071605, 1.4807103555815, 0.31820661078652546, -1.4648124318889386, 0.600589738556612, -0.5007900750357758, -0.4435841273377483, 0.900248708477302, -0.007133126014367754, 0.737077391042237, 1.2945424623610222, 0.4057692722185749, 0.6223087824187057, 1.3156785924530179, 1.4351180120327205, -0.6550306397122073, -0.4260410264634844, -0.02097183202049526, 0.2530534663188366, -1.0298954928746384, -0.90950469414421, -0.9561023756030369, -1.0442786330779643, 0.5927299904589942, -0.08859385120731328, -1.2306261342975133, 0.5956022759424272, -0.7534490273273639, 0.3587070415077196, -0.09003364929760026, 0.2908033164725296, 0.3494532979378954, 0.5091362854329932, -0.8697973565390023, 0.7610107938265482, -1.7962417679434577, 0.5504757911728544, 0.4902354450825934, 0.6105175277196558},
    {-1.3129152769357408, 0.26604663612468105, -0.8837046756016794, -0.28312603531422814, 1.006061392795337, 0.14580642298209637, 0.3963468810009675, 0.07035274380793441, 0.6497279320230397, 0.0440423175987354, -0.07338687403369822, -1.1349844831215725, 0.931021422280989, 0.861264190787135, 0.2483453209609573, 0.999029040851636, 1.3416699299865116, -1.5656359160045357, 0.6333683048141941, 1.4146390070854802, 0.2987866491078777, 0.1313153865792938, 0.934082169003473, -0.17409153950058562, -0.9077058081453041, 0.296428425094137, 1.4899421163536908, -0.20600619614969612, -1.70475657283128, 1.22775324429426, 0.1718718515736702, -0.13688102167851615, 0.7482449435685108, 0.16877633382937354, 0.3221387375405699, 0.04143858739297671, -0.9223767790557835, 0.47025581383045684, 1.5904044972960225, -0.0671775463048144, -0.22275326669130224, -0.6199588392877368, -0.36453382100691506, 1.1685557497703347, 0.9752864931151872, -0.8670713247046138, -0.5336684511534131, -1.4242118034947506, -0.7203411007443676, 0.4237510285567909, -1.429031352809121, 0.16148956291349048, -0.16171103235280965, -0.35898924098828033, -0.3451139828641437, 0.8819690431988578, -0.13146601320338183, 0.010504098183868462, -0.7049058767836738, -0.5453455935193704, -1.52362654283662, -0.6700502948296533, -0.64596076044864, -1.029324996236249},
    {-0.5266573793073713, 0.32340783583738036, -1.5243051098050653, -0.8789264105130019, 1.2280342567950564, 1.2136603226599014, -0.25782378984812815, -1.1341657899078674, 1.5293092650288012, -0.8021520425380724, -0.598341279295127, -0.6062669281852463, 0.026813423031622395, -0.2456002739995507, 0.6542511445036, -0.30892006844201036, 1.2403108970969647, -0.5441713469846369, 1.0840778052139397, 1.218254227753657, 0.7022823380661122, 0.5527346069340846, -0.3718379802739793, 0.13871464476054593, 0.29744408529378735, 1.3967864740803655, 0.4602489855977601, -0.20694785286201325, -0.732694831891572, 1.3246221003216694, 0.8091294901504013, 0.7032679936356091, 1.2511505633986142, -0.9455838338305332, 1.3997287504798517, 1.1075942003375576, 0.5537301046438212, -1.217036518892615, 0.6417029426660706, -0.1656127489858538, -1.273253876487184, 0.8681544770682398, 0.5423035959628041, 0.7338500158764504, 1.2451530822227896, -1.1457044693210114, -1.030381540466787, -0.9998554060769606, 0.6631288718176818, 0.3895776675643677, -0.8574249369453624, 0.8348257336576731, -0.0904243818970896, -0.8763535860510507, 0.17625803205086238, 1.138180675792279, 0.6272655316392778, 0.5696640267135573, -0.06498780817862546, -1.1248475063064436, -0.662113003170249, -1.3500037378112413, 0.23238318696060525, 0.28186282755836295},
    {-0.16762933556617907, -0.3406658568987128, -1.265558166380731, -0.1504104306912005, 0.6465257013942063, -0.310077189552612, -1.2085582833905444, -1.4785513912074, -0.165155533305257, -1.0070448717725218, -0.30516306083627237, -1.0641080505240141, -0.10323238918566692, 1.2470299796758093, 0.5903123970978333, -0.7121605288107848, 0.05869778136229815, -1.5117694365254126, 1.6569313525500522, -0.6633124955159365, -0.710509774180599, -0.21931556579179232, 0.07025438009329582, 1.1241777062903322, 1.1057418948270679, 1.602534633714089, 1.826181124076769, 0.11148427778509835, -1.362303468192843, 0.9964268651348038, 0.5254975807411201, 0.933692148471011, 1.1764239058901043, -1.1565959754622102, -0.3106341782874403, 0.5732526613769392, -0.9601551434452276, -0.9685097641917068, 0.14787480198073066, 0.9682459649272188, -0.6195403707991147, 0.1747302172529518, -0.8927571747550609, 0.4127658602456621, -0.20789865755195777, -1.1060728559843938, 0.49137839843973186, -0.07474353770412256, 0.009519411769842384, 1.2774491072414558, -1.0205069169220053, -0.5260243633011202, -0.7198707373327421, -0.5712691921823945, -0.5480880794938233, 0.5485476133487688, 0.8269848922640443, 0.1442932574795768, -0.8958599259526034, 0.21225522577035807, 0.43188503346139084, -1.5119841277492476, -0.17747342907629413, 0.4491309486732727},
    {-0.9031815229299534, 0.34936554712462803, -0.4538359235049652, -1.2200642601938627, 0.24743924343338844, 1.0522950124405275, -0.999926214886562, -1.463398731268393, -0.4197316597914055, -0.03574996117674026, -0.5080147648123939, -1.4013115011419606, 0.6075012034373871, 0.27319347243244524, 1.5162810795685302, 0.2993336019938205, 0.9140066067461466, -1.0871174977446605, 1.1450714511179196, 0.5568662519202604, -1.3908978436041957, 1.1037131180863207, -0.9045347089946646, 0.4930105881142038, -0.9673382581013603, 0.2206916655135146, -0.14908900496240457, -0.21446173277499994, -0.4531719186266733, -0.05886743575017697, 0.10177867234917237, 1.231142755000517, 1.1524925797291552, -0.5770857036743429, -0.36761784365598466, 1.4046700001563555, -0.9833710116630707, -1.2630079301232093, 0.7326435624790926, -0.6445591838138931, 0.2546001422261042, -0.6994746072094927, 0.02966270682175519, 1.4657866124646985, 0.36478966424529496, -1.3410784948547734, -0.812763559814253, -1.0716633764536574, -0.04746834668864517, 0.08859791000894775, -1.8124562430334474, -0.17222929543287335, -1.029984855500924, -0.5479965627136558, -0.09519408617811935, -0.0875567333679428, 0.045878362113822777, 1.206728351152561, 0.7279264452473128, 0.0653013241500272, -1.4805632191325964, -1.072747801048571, 0.9565367867258842, -0.3738732234709591},
    {-0.22870679000992922, -0.035667409774872594, 0.5910253511632274, -0.3457038397115705, -0.07150772040011703, -0.5029810073219415, -0.36332167957392025, -1.1337016619960238, 0.0199227469542881, -0.20137686898933013, 0.041510260006671074, -0.6304732580360155, 1.1010323486331577, 0.6845616074682154, 1.2410518066659186, -0.2967010376498285, 0.8400996459784382, -1.4928836809485926, 0.6690768424356335, 0.9259562345415903, -1.2690761289043835, 0.993908315411815, 0.7534620366157013, 1.015182480254715, -0.18403511162824165, 0.7751070313701103, 1.6324067575793988, -0.16373181450470242, -0.5987750212036501, 0.11874006755694456, 0.2541502660825751, 0.3592797127770012, -0.23120728165813337, -0.7015903898668594, 0.8389222444711045, 1.7530165143370415, -1.2824866935494432, -1.2021461972233454, 0.6595062720901185, 0.22105961944468744, -1.0947524174722785, 0.10663255260756004, -0.5659489557639993, 0.03398365763979354, 0.38177565639448874, -1.2178244223287995, 0.8303984294861416, -0.6551783698990776, -0.10021575223433482, -0.062267820926093224, -1.7048699869361736, -0.4453554259191443, -0.5424732200634923, -0.9238515640673447, 0.5265355227063011, -0.22907410534570447, 1.3260135935444113, 1.1598448028351631, -0.6966857743114755, -0.037943286265641966, 0.3641505613803822, -1.3150208701703576, -0.10712068590357018, -1.2532334436322812},
    {-0.22575380416411164, 0.47218402751678, -1.3681441600223192, -0.7012656767699711, 1.2116906467373048, -0.10993101975837302, -0.09406801102647087, -0.5556138087080873, 1.3989364156817556, -0.5983836170598499, -1.0742391925662131, 0.04716113905454231, 1.320032054368181, 0.06640572156902867, 1.4309943709615056, 0.9976169396009538, 0.5442954926548687, -0.37278220718764005, 0.3073490107527508, -0.0809344145126937, -1.3991986103003802, -0.1878269557834467, 0.4926836094878899, 0.732476754164632, 0.9335787678762372, 0.4566755930069689, 0.3934347284281524, -0.09871912056908856, -1.2815210016925311, -0.10843889456833959, 0.8612010861136158, -0.5522695623212781, -0.0886416822982971, -0.19788307759577164, 0.17845459859536145, 1.3152771770550338, -0.29324092221485215, -0.5706395185428129, 0.5404686502255529, 1.3859707660921978, -0.7154086042816664, -0.0037143890766063174, 0.40634686886499594, -0.7370404148073104, -0.613250137607177, 0.7362099626465737, 0.17382249832759555, -0.3949416111768675, -0.7574377413683546, -0.6943334047558963, -0.6807921728792609, -0.009104394517004412, -0.9302767110682202, 0.25509976300926046, 0.8926622361259348, 1.452511690213979, 1.9000710009955468, 0.44760124573407745, -0.6169006623060975, 1.1121152663021332, -0.6000725138367435, -1.293832839487976, 0.3093613563853149, -0.8689281724810145},
    {-0.5326936144719994, 0.2555459704006203, -1.2124204418717692, -0.022091019804725907, 0.6832356094039094, 0.7180895789155036, -0.889623977790399, -0.4302770069779531, -0.25297875070906295, -0.4789048285093383, -0.20249694680466382, -0.28464728472233497, 0.967655459540281, 1.3966877951593923, 1.276774042179617, 0.17997914877385562, 0.47242710321274556, -0.7010939637581619, 1.6278154324388494, 0.6582833382504297, -0.7688872212077817, -0.15915920591472701, 1.1530868098101594, 0.6579467235177315, 0.37363575483672457, 1.109982952215234, 0.9381952440562455, 0.22192120702754092, -0.7962866438994493, 0.3002627320330758, 0.7167585836523194, 0.1560196767805273, -0.20256089680346387, -0.3417224630152229, 0.5672382995687464, 0.5475494145840001, -1.6368773672272112, -0.14057768421352176, 1.2302981319833417, 1.2776884845717804, -0.8627430080131054, -0.7874484586113294, 0.11457144556513314, 0.07404696211672024, 0.9647740387982742, 0.5143072159018793, 0.5083759097225197, -1.4341167170241047, 1.1040465292065724, 1.5177711842823525, 0.007666349454472676, -0.3728164674411252, -0.21477336424196736, 0.2026784941656234, 1.1280542191825484, 1.3583323772699314, 1.0519290820987666, 1.3801812576654735, 0.21913294465722513, 0.8370204916384992, 0.0009339355015089826, -0.2341812073177604, -0.3056072940272856, -0.6485783652311872},
    {-0.31777441791737276, -0.05928280455197827, 0.7027705172288512, -1.171997418209297, 0.2462332196528894, 0.8915851911187062, -0.2809413104968327, 0.3083852584265048, 0.7839013506576601, 0.3843888322677585, -0.08888570193311032, 0.16905234881137893, 1.2743101829720966, 0.14394627223456724, 1.0137378990299828, 0.11069700118469654, 1.1547837036034319, 0.2798597651453259, 0.42859834653971496, 0.1680976765083725, 0.5647939538374909, 1.1893182492514232, -0.08267709187963465, 1.4810393712190792, -0.22700787366984415, 1.0573176885625395, 1.566647876972148, 1.4846045497662257, -0.8462789996178891, -0.11998476685283145, 0.4755178352758955, -0.4670724348561153, 1.0649864094248174, -0.6004382540843226, 0.3498454515494504, -0.4251605477100438, -0.7598010536566728, 0.16907889509516796, 0.3475814422659845, 0.9541546437398429, -1.4752493642028932, 1.0341945706731595, -0.7521628859562789, 1.6289716565182955, -0.29818535760517195, -1.0141386283135954, -1.0536853735522527, -0.5127359379562781, 0.7723409305388004, 1.5478138478013086, -0.15543344293103278, -0.5960241378932776, 0.7241695594625793, -0.13175215210912597, 1.0795835957179045, 1.1194798010475047, 0.3660041103201858, -0.04053768372661095, 0.42737679743180584, -0.1543472197292693, 0.3278991646152669, -1.0429210667893045, 0.5544134775351095, -1.0031563901070748},
    {0.16273587260396624, 0.6611111309278938, -0.29294655325960395, -1.319724982136538, 1.1795973960820432, 0.6596879505389861, -1.185972031383081, -0.5038908572518849, 1.0963019577336182, 0.08695984911117707, 0.9447063895169636, 1.1491935122881112, 0.5401788576667842, 1.0989053413273944, 1.0354378273601992, -0.054697431622101264, 1.6674756527724217, -1.2593459792764552, 1.167686579222664, -0.41899445962217124, -1.1789201883519855, -0.8318247822375315, -0.6378122171981754, -0.5149727239097898, -0.7700983354331649, 1.2822138213152816, 1.4757487160064182, 0.4788857361000142, 0.5936891411795192, 0.0876461396415191, -0.1458294715364004, 1.0793198696083461, 1.0488281739697096, 0.9882986965758639, 0.751257640747114, -0.48002609731183066, -0.4845953502199668, -0.5301570365669954, 1.0493308136741613, 1.2517576003276747, -0.7700328170260837, 0.014353186237491758, -0.5833127589701558, 0.6610002996179761, 0.4376000477933003, 0.9080108671149651, -0.20503590681219316, -1.496860708856738, -0.26043857401548404, -0.3924247332677341, 0.3231591574042265, -0.3046871634266725, 0.042774803401255876, 0.5186462590164312, -0.16894724292267083, -0.4490480261372756, 1.1204521324041914, 1.1167932759544161, 0.6182288221629523, 0.45655084629406417, -0.7279871882538692, 0.0020208933670848687, -0.26508689046818196, -0.8450720540371955},
    {-1.117391384199127, 0.8458942336732895, -0.5263268708382265, -1.0029618103917153, -0.5584466367976358, -0.38319440691575923, 0.6857045295946997, -0.5068402374029768, 1.0523149618795304, -0.5271375910455846, -0.8104942193389828, 0.5873093026595995, -0.5230599312888878, 0.49001213104009506, 1.0246813291966135, 0.2627636656091134, 0.07432937114645566, -1.1743331563537567, 1.1991745694722278, 0.5523099494059187, -1.3349857923986106, 0.5274021685479322, -0.7376311787393158, 0.24849320249128962, 0.07056691655855406, 0.9133383480239811, 0.21070220224389616, -0.7402939783317839, -0.18085478798152782, 0.3083029447096571, -0.22343244236396556, -0.32145057133632304, -0.2737106217068791, -0.031751531598640574, 1.0350150420384943, 0.057660263779661776, -1.1137637709185177, -0.0004256237682134391, -0.3714149423229455, 0.5399500960335426, -0.03411578317155181, 0.537874331391003, 0.5732059111642959, 1.2614128951687966, 0.1304368754030671, 0.0939539985434222, -0.8038721548443338, -0.8606882912112342, 0.6405542403799291, -0.02877714230304154, -0.903761512018175, -0.09771213042028365, -0.9317614077680114, -0.2691915881174419, -0.4366592019330979, -0.591617627502408, 1.5135121072860822, 0.7995977188148966, 0.7553518030005979, 0.7856595893666104, 0.17547692891235872, -1.1579897529642245, 0.5944926756052252, 0.11448467243611372},
    {0.49283386252268835, 0.436148673580245, -1.1255424576386224, -0.3330376290896612, 0.3509438608368303, 1.192475277792492, -0.951715438709557, -1.564710971588818, 0.6344690772323389, 1.2038301445521542, -1.0291531254743975, -0.37954445036552764, -0.19968803381093803, 1.2103925786022969, 1.432353612688572, 0.5973788800126991, 0.6308721831885097, -0.3893701901440763, -0.016603188313573183, 0.6526763102373571, -1.3459182129840623, 0.10877670520350234, -0.823904343692243, 0.9769189972430227, -0.14631844897468732, 0.4158350806777818, 1.666914774470348, -0.8981141691037592, 0.037511244531801935, 1.2364456488528743, 0.9725225991813936, 0.7465104626491703, -0.00529130229959233, -0.18847945159609805, 0.7069020699203108, 0.2652198344508669, -1.3545047501086984, -0.06636197613869163, -0.5594719657984716, 0.2618904742976949, 0.010991901016746825, 0.7986627387672369, 0.5132564518715893, -0.22667750467608785, -0.20370541554408692, -0.5881045815180646, -0.8275745460221096, -1.7859602379889896, 0.7556839533160125, 1.3635192972711474, -1.0763152878828834, -0.6652098440866887, 0.05234683468971762, 0.47683398267288657, 0.6908045251668027, -0.4648899537698642, 0.8801558047401726, -0.15773781207766732, -1.000522130212156, -1.136092002035114, -1.2556421730495428, 0.30339115338747574, 0.09005166824682416, -0.26442461803757017},
    {-1.1734464134528337, 0.30343234233163807, 0.272769381826348, -0.6837498724701095, 1.4331247470654194, 1.614051210215366, -0.9086062391736981, -1.0089501951199382, 0.19885598276057867, 0.5949831209549056, 0.22345208615114173, 0.01413308034078324, -0.6230318578705536, 1.2103967387325285, 0.1574006650281467, 1.3407443543831923, 1.6816684006757343, 0.027316516620522292, 1.1052127484787924, 1.2644775538734028, 0.3710950886230339, 0.8061522862750218, 1.165131307193262, 0.8737225664380623, 0.8179930085416857, 1.0919092079077883, 1.4152007836931693, 0.4124210531420199, -0.40533122348200457, -0.3089972853576042, 1.2915871991173506, 0.5208661235885961, 0.7877500315739692, -0.39918448421046293, -0.6918096715439476, 0.29344730829437854, -0.9779281795942983, -1.5818300158208842, 1.0815991547521808, 0.11886669838331111, -1.1259839480818121, 0.26877766451032903, 0.901733790352925, 1.7017810955359123, -0.6837050688702426, 0.12564779287131378, 0.29578141012583675, -1.0661439369458015, 1.409655109341309, 1.417070536955023, -1.1860629051078113, -0.3630848436021631, -0.7431361640982505, 0.6376225513586917, 1.2051504685513237, 0.9466441328560731, -0.23142097494450117, 0.7709442727958126, -0.056224800368301346, -0.2531221633803336, 0.3377012799192122, 0.21542644020243293, -0.7865064309256274, -0.40681086700521596},
    {-0.5246995799756115, 0.9572148593510577, 0.44897654321333413, -1.6157064252173288, 0.4434058169027824, 1.3030724741906827, -1.171601177552247, -0.20202622720177957, 1.0744957520009881, -0.6364136596007713, -1.071277256337996, -0.360326111705919, 0.13972153347902325, -0.053453231327847364, 0.6238098379055543, 1.591454705627965, 1.5141223992158324, -0.39728209637748507, 0.8876815658218524, -0.5852974082931817, 0.4389797900088936, 1.0431359916124001, -0.41042737789791506, 0.6816698368281036, 1.0240782355704763, 1.2550708514020197, 1.1083275998941033, -0.33430552858081075, -1.0118802791344363, 0.00843312056493352, 0.005570001499783791, 0.2295418308698574, -0.05014011171929637, -0.9894119570952762, 1.3025901042483015, 1.1979123405430143, -1.235042110146117, -0.9259716188759403, 0.7570465598542846, 0.9476531452829354, -1.2072776447630076, 0.8389963631315726, -0.280897735497026, 1.7066638247159163, -0.9255964899976966, 0.7321021133987042, 0.12431396267938012, -1.233489337599896, 0.734221505462704, 0.5224054190999572, -0.1306903844484885, -0.7426500635733501, -0.9172897144359733, -0.41208707624540974, -0.21693682188377236, 0.21240770013251917, -0.5424785233358169, 0.31050602337469013, -0.5595866304329896, -1.1971930911632775, 0.6261611869400691, -0.6454346692753924, -0.891805513812099, 0.23851048798692037},
    {-0.8194885947221865, 0.4102141886289514, 0.6210268026927769, -1.7230546460370846, -0.024304020247140862, 0.11163646189915222, -0.6136003487827896, -0.6419033809697476, 0.6568345972033571, 0.8205945088433871, -0.27934761644845585, -0.2092095085531189, -0.497934302850647, -0.6378079826719596, 0.048101510466716076, 1.4020957862282706, 1.0152447698309655, -1.5682531744903787, 0.15945924362363237, -0.09949857852195956, 0.5283796986002693, -0.3251788616178725, -0.767535902989005, -0.4931151436903817, 1.2111301023455812, 0.37906313438765793, 0.378566161125563, -0.2882380043488753, -0.5246757911342226, 0.9257979644868914, -0.21867056597839027, 1.165632581289069, 1.284123417481337, -1.2571458241587086, 0.17643635119397025, 0.5177874771670733, -1.1591871265749438, -1.4087819278852196, 0.7773670899840011, 0.784685761162827, -1.29919555256271, 1.0968471018592865, 0.12217245454624237, 0.6047005356448505, -1.0144080377114797, -0.46039091245171887, -1.1270322337970287, -1.1324878157935856, -0.09129763090173743, 1.1066721645217827, -1.3806257319082327, -0.10926954633058218, 0.19977615482543368, 1.1575768566394018, 1.1003978729738837, -0.8610243517874235, 1.2608954241616614, 1.2275392724634224, 0.8990163201703948, -0.47180143563960547, -1.3477077571023792, -1.4821212673280861, -0.13254644226905474, -1.0628531288011824},
    {-1.310491292480404, -0.7548564269456643, 0.17139510208385125, -0.19057110460127752, -0.15459947102400304, 0.6751865608734263, -0.049784537672726226, -0.005212506278686928, -0.11339463840139971, 0.9530948072140417, -0.9445666630930312, 0.5735409679296327, -0.9947365301216898, -0.07888332328412942, -0.3101997548545037, 1.54162509189677, 1.0082606674604047, -0.5249767359976562, 1.4442265877834575, 0.6901201919871359, -0.5847865310658008, 0.8804329934092541, -0.08977088203338028, 0.8089485387943165, 0.5337640554038201, 0.3365308027106007, 0.9432350605629497, 0.2554779103567105, -1.4671507180442809, -0.41755777964673185, 0.04853752745777829, -0.04537471778385695, 0.6132031108694915, -0.14875297800815712, 1.1481993312748406, 0.6334076566944393, -1.7466293165300348, -0.6330147442034444, 1.440824111810511, 1.4194061766909152, -0.6736551657380527, 0.5825026620967152, 0.7662459624987997, 0.3047921619590134, -0.23361914597469943, -0.49777529875257387, -1.5961397314428336, -1.7946830356456829, 0.9543894129109256, 0.7983591590429353, -1.0223220717521853, -0.7978620163896448, 0.4756269210037088, 0.8306373663414645, 0.17396115482891142, -0.7980388276365622, 0.8094340411795162, 1.1515014148530514, -0.002856498761879011, 0.9691159355898683, 0.3528064399825673, -0.12400667089862419, 0.4045161491477382, 0.5331329454330989},
    {0.5183819154114944, -0.34211259488198636, -1.4562524784802298, -0.9064989840130603, 0.6596424671374953, 1.3846240360031656, -0.9603485853317295, -1.361025097910711, -0.193299794043725, 0.9873661037357434, -0.3796032334966539, 0.388434926781663, 0.5021510873696006, 0.21332712812827218, -0.44249960754572953, 0.7875896919884572, 1.8187773262749556, -1.394147696492084, 1.767590691423225, 1.4018385598655478, -0.4391594886125326, 0.5975785490322102, 0.6009772111752861, 0.3358155804942247, -0.3153245695698889, 0.13194085855871707, -0.031566894751227356, 0.5817717944355871, -1.2173122470411797, 1.3253572652928203, 1.1397036862114949, 0.619386260027845, -0.049491862390428555, -0.16351501744692795, -0.17469204180014572, 1.5525322607809084, -0.680964452284517, -0.3567180053356627, 1.5776025112878127, 0.44138140838374346, -1.2873094392013662, -1.0295753540249721, 0.41074852728451133, 1.0500326585899105, -1.026556839233287, 0.8953920429561664, -0.7875327004763477, -0.26729670580534753, 1.0291158715095627, -0.20818894118948408, -1.3573124453491756, -0.4747843682547579, 0.228695717091763, 1.0321204904985273, -0.3140539692681788, -0.09350485296246942, -0.36369642845778677, -0.07361654814592801, -0.9294308303524134, 1.0269477502606137, -1.0094151503520699, -0.27986851709832394, -1.0319323317755196, -0.30882019704998964},
    {-0.6941286997137539, -0.7226535408842324, -0.5699232359864506, -1.0922209973184438, 0.17103916987196713, 0.9095897908741324, 0.6949952759167847, -0.7860017278679695, 0.045865273079574845, -0.13380569230198414, 0.4486053697648884, -0.6733804001409445, -0.6860867018076269, 1.4447539658350514, 0.9306174984113987, -0.2708714633173572, 1.7847601666539632, -0.07834862228419162, 0.3958556439454056, 1.6034181509495173, -0.5538189675421495, 0.34331405657388964, 1.057471404683052, -0.6592765158016942, -0.12609202868897001, 1.5724708753750638, 1.8133871805070871, 1.1378132452645195, -0.8492558692217482, 0.8246324107066618, -0.1890956423024473, -0.43688189460615745, 0.23858976302744778, -0.8526364492898272, 1.335138823089832, 0.3711688835828696, -0.9009214666449586, 0.07993870022957526, 0.840524278829607, 1.0976728473022561, -0.7730333639801684, 0.8501514731319207, 1.1782501662232527, 0.662403824738581, 1.0694105941734482, 0.27949844752115055, 0.8850813689020832, -0.6399246774253017, 0.021775975233043827, 0.08217524132515146, -0.9110318861741483, -0.651389964107009, -1.0195509084441443, 0.7782594569113956, -0.41833795063938906, -0.7922280299111335, 1.647375931564221, 0.5973922230628136, -1.0831800815080206, -0.2145259703547506, -1.171606619475748, -0.920748056529931, 0.7431142407454683, 0.48108291681659265},
    {0.694484464799811, 1.2778292060665424, -0.44741551265167157, -1.0080057205426676, -0.023137414230179548, 0.06544174614601356, -0.34085731554414045, -1.7019859733607359, 1.47726159430725, -0.7719293323749579, 0.7418936494502103, -0.7049425752909254, -0.6620430760790866, 1.5760589467415178, 0.3911032407175957, 1.132250732098134, 0.1421357786731467, -1.14842725849099, -0.2763733737172992, 1.373205093311583, -0.056351841386236744, -0.48512717350210355, -0.1599592242900219, 0.9848088172214088, -0.19920862486828544, 0.2811483206053257, 1.7643821700304332, 1.6833978019050213, -0.9687298100205318, 0.14642140771211978, 0.14502407078952145, 0.8358001680103557, 0.11034165904977723, 1.144728026228739, 0.28249786276717315, 0.354175542349997, 0.18065559577885304, -0.7002435740208489, -0.1695433809955452, -0.10308961047171791, -0.6321759067932522, -0.355476768369304, 1.477682121057631, 1.4704740949188215, 0.37468016830152684, -0.7815902984490248, 0.5533346518922994, -0.7596894875867215, 0.76986311148712, 1.4913981607195066, -1.4977522472434117, 0.8131715029338231, -0.876943115413538, -0.25835124857731995, -0.7128318081119528, 0.48384348727484444, 1.4258630662377283, 0.5199419042361659, 0.06822204070017582, 0.05699835390441266, -1.3436504590186837, -0.7883910554246972, 0.2780539786012646, -0.7179185005657666},
    {0.4484932556776372, -0.3056309604827337, -0.9243455452454442, -0.6641589838112397, -0.1294519416303774, -0.2574609560971071, 0.653867055468132, -0.7987942070095636, 0.8470430258854108, -0.8861007670297663, -0.8822791535187662, -1.0914496896691086, 1.0204046889248464, 1.3898108368145887, -0.6352490458886054, 1.6562670472632615, 1.8276495222795646, 0.006780968273638374, 0.6509689146779362, 0.5299885611033249, -0.35734313045751176, -0.9062526545631769, -0.7075779220341413, 1.050260980882193, -0.03364793555179939, -0.23996417260244776, 1.263616337291611, 1.089689592243221, -1.7068727460445012, 0.7045847517883425, 0.6231618393801078, 1.3523323266937635, -0.06335619418931655, 1.1136295246146748, -0.5195696124578366, 0.7498921314691511, -1.4262131899698423, -0.02333185736914106, 0.017477492855714254, 1.688646584630798, -0.9816078910825343, 0.04355089436655066, 0.5685217161407304, 1.757740590036786, -0.21754369191501324, 0.743842604638998, -1.4300574749582726, -0.2746999719467732, 0.4317509735580941, 1.1161692309379962, -1.3263359206206606, -0.009870709260753006, -0.3269880713814756, 1.0534881679240309, 1.0539441395552327, 0.7329433889416934, 0.12758157321650615, -0.044041115862085325, 0.745025547892405, 0.3622854168372449, -1.4823755418846245, -1.0910120672191534, 0.10488524001352778, -0.30268819281562115},
    {-0.21708537047535278, -0.791947033200384, -1.7041907927481688, -0.35690113887926017, 0.18942670840353878, 0.8638045782777525, 0.034759232376180615, -1.1544175495619602, 1.2223547125017535, -1.0520958782822396, -0.8186903289011813, 0.2552827458133239, 0.7745201137966781, 1.36571152282755, -0.6125767207366478, 0.8052095176270694, 0.5658785960974633, -0.022628205353478238, 1.2744912995730981, 0.4284344421190612, -1.1917404759679986, -0.7494825115761563, 0.41393974627152924, 0.8560831037959992, 0.13415118470034035, 0.9891213926521204, 0.6932342900788977, 1.6311288097924208, -1.275165351178227, 1.0251594058409508, -0.3890153534289235, 0.3849380057611636, 0.3621579759940565, -0.7565569907928305, 0.36378531093578254, 0.6976801203240588, -0.8522111359158797, -1.2600696393202715, 0.541327843968232, 0.3435810941971468, 0.17446692683419324, -0.6995740902266936, 0.09636362263990637, 0.026639194997702887, 0.22719368536786813, -0.15837860982977517, -0.09900751483145438, -0.3159321377369355, 0.4908496000097594, -0.1981469442517924, -0.800532083560988, 0.7906055141848598, -0.2986303321933114, 0.3632939919537722, 1.2553743082264692, 0.9549615979833644, -0.27495400120724883, 1.42419313774831, -1.188958526134164, -0.13509681044212374, -1.0696518603877219, 0.8092314766762182, 0.1383664681481928, 0.05259866395313622},
    {0.3798917993221017, 0.7088770781266298, -1.6711584199309155, -0.8444719995529139, -0.39563750333919057, 0.9329085425188876, 0.47313862898677667, -0.5006986076361368, 0.305493047309331, 0.6431255478128108, -0.6258650450812753, -0.23117261866101194, -0.2463962204891413, 0.42408501574643187, -0.4802678966031289, 1.260956577490555, 0.9574718994683412, -1.1342373556181178, 0.07737495588051273, 0.27694192919647515, -1.3191861369848108, 0.2658892076710802, 0.5101193613730626, 1.3092867759468212, 0.8566968002722462, 0.3114962196104468, 0.5568859414217032, 1.5588688956121937, 0.07740711477419285, 1.462254874268332, -0.08223690209859894, 0.9557508316697189, 0.42273796464740154, -0.7947305738029496, 1.0969550626848967, 1.495894952414945, -0.6446559456652687, -0.027836439882093326, 0.6849665847739197, 1.8085317534127368, -0.7685332575205602, -0.8914966365402508, 0.21610662953621637, 1.2890544717998746, 0.025117405867836135, 0.9747920425664576, -1.0226481293208431, -0.4968070132120621, 0.40996544133337603, 1.0297499167499007, -0.9700910686697528, -1.0144643859328253, -1.2922879450039593, 0.4682427351234233, 0.7489202174824381, -0.952368002572586, 0.5373311464211822, 0.7455492962559439, -0.1739096998060071, 0.3411104204832321, -0.8279542627600162, 0.1053786789349119, 0.7961538758412893, -0.4697209604150142},
    {-0.3982653468010606, 0.7336366677631114, -0.4218209042481722, -1.3285863420357047, -0.20103331778809194, 0.8299610762878987, -1.0800806318335483, -1.0627630166164408, 0.20630495018236805, 0.4019962666956123, -0.42270855604953794, -0.3662644349414979, 0.7870243684468848, 0.434515182876757, -0.4701940629373303, 1.1842117730989004, 1.8396169105761428, -1.542904222778072, 0.46245938389055496, 0.7211217711291952, -1.3768709734420477, 0.49507015462932585, -0.5341528984554506, -0.5786028632735916, 0.17801616848501087, 0.649089846032729, 0.7952310890239854, 0.9940162814781245, -0.9718018783824708, 0.405821758383019, -0.2984815420221538, 0.4465995416950602, 0.43802645787167577, 0.3489926192689793, 0.6598264747133021, 0.27703520225885137, -0.7239535525369207, 0.24091363620223027, 1.4417692527421573, 0.7928481656313628, -0.6862470303968126, -0.45377801868193685, 0.7488813519070856, 0.19006482205434896, -0.13316064043395617, 0.7467907107568823, -0.9437850327264762, -1.5065541246176724, 0.5925240462180715, 0.9945625342155365, -1.573561857402353, -0.12406870240395046, -1.0439976358707788, 0.7051189278222323, 0.1203360082842713, -0.017865591853678642, 1.8052478798181837, 0.4034682214823446, -0.5748014911016341, -0.6774123800790115, 0.1590799101410304, -1.2327118401034474, 0.20409407634089283, 0.5935286938189044},
    {0.29878176362928127, 0.8282725410514664, -0.8268671676283431, -0.25023260818492066, -0.8651910888044938, -0.01726592201857896, 0.537068324988449, -1.782151959102575, 1.4409431330663902, -0.05725305636634667, -0.34775050146439, -0.07632408747543992, -0.9340173907694352, 0.9622475050826, 0.5739709882707819, 0.12343494140080453, 0.8032771652246182, -1.2411217423600567, 1.2673381255302476, 1.0553227612441871, -1.134608937314388, -0.4859238525837941, -1.0370641259250604, 0.7900387534980081, -0.3020122139165534, 0.07065556865964348, 1.486636825956685, 0.9610926674319136, -1.786523898272519, 1.4178894341690693, -0.7637249780268752, 0.6210874391916208, -0.018576920261702205, -0.2618756187288545, 0.8575832799787293, 1.2874372607888225, -1.2080148676678109, -1.1201332925132501, 1.8730932368037814, -0.00011087473349604669, 0.03335644968966185, -0.34522598207010846, 1.3255566607416027, 0.7064041393611713, 0.32566490112730906, -0.05886785081364518, -1.4629831957691946, -0.3421425631229433, -0.502580850468966, 1.4285727486352002, -0.864785647256348, -0.908014809949159, -0.2683378440452374, 0.694513587637307, -0.14793755116093557, -0.7197620926766317, 0.6065577151239715, -0.5837703221395882, -0.26069906745130406, -1.0094343109215504, 0.4036838378983231, -0.7281563517644796, -0.17296953983738883, -0.9809229481493372},
    {-0.8760403727508598, 1.3132250593315336, -1.5660836982756519, -0.16516120021898695, -0.9827368220654913, 0.9460162105714599, 0.7322193276928779, -1.5865891014472613, 0.8272534069779494, 0.9910859272850043, -0.9105025142665223, 0.014443198929453985, -0.14550038191670583, 0.6369945016757429, -0.35974870116734803, 1.7035548977939006, 1.7962413322232729, -1.722686991089256, 0.3393588303039444, 1.12683535700025, 0.23508976506062237, 0.20837860836828506, 0.16054442541999897, 0.35987236559771896, -0.9389275002085404, 0.9291979038891197, 1.829526806328682, 0.8671377796063366, -0.6367720029402394, -0.2535213713761852, 0.3154958344109554, 0.48395683371586307, 0.03612214430714597, 0.9653701903650748, 0.6803416625326097, 0.3738161778313925, -1.0741828318866211, 0.39041500095517917, 1.3971679999012119, 0.60874996349804, -0.6580738208285304, -0.35377839231230157, 0.9530671153063176, 1.0491327891729596, -0.9857306416702889, 0.6659963552383749, -0.913830331603937, 0.15448988642095224, 0.4665244169717006, 1.3391722869209681, -0.17183181364659075, -0.5558636493874729, -0.9258054314493751, 0.22259611793293965, 0.6851340821736791, 0.8630265409880118, 1.599955268192097, 0.7795540832457997, -0.41581638489263884, -0.8837794156044854, -1.3014611834394136, -0.7212883678306166, -0.003125247805945183, -1.119166845036522},
    {-0.36057408625123, 0.26883459566753953, -0.990457665145878, -0.711993840347971, -0.9351532547914018, -0.4879776205153896, -0.32681347949837236, -0.4009024172833654, -0.5094046707282442, -0.9238837433901684, -0.5654453740869463, 0.8624764005273436, -0.8677392380643528, 1.304539034986537, 0.4746580845456322, 1.3821550973638963, 1.0620524161921494, -1.5583867690077315, 0.9628919658641905, 0.23390939541905564, -0.971519144869454, -0.08834427828168531, 1.0157280632262857, 0.14210343402620093, -1.1704172079256536, 1.6448051030191475, 1.0793526751611453, 0.8316271425425521, -1.6907863815905497, 0.39694921318903775, 1.0713427117491883, 0.8070650289052687, 0.36052733906572376, 0.04529679139896568, 0.6662727956482241, 1.807414518787697, 0.4339339338404267, -0.5834517115998752, 1.5209888794189226, 0.24122354871775611, -0.36237307258792584, -1.04341963479015, 1.395548650617221, 1.4654057945516703, 0.562944790570595, -0.5175380804788294, -1.1931070109713267, 0.12763630043474578, 0.0585193459748599, 1.0487806346006907, -1.2007665676284847, 0.4505251214026226, -0.6027150591717773, 1.2446586180259025, 0.4592147981495902, 0.7945746152224369, 0.06900300395177587, 0.5069422945875949, 0.5828814162759295, -1.155843641237463, -0.6951769427278249, -0.6467477952662019, -0.26581003835471656, 0.5864285931883203},
    {0.8775711177696879, -0.055089334995679896, -1.1397922642978435, -1.385491463379549, 0.5075844426970904, 0.9854106321053918, 0.46865498378239673, -0.5881305127974442, 0.6882042680102, 0.6744308593355929, -0.31944716446412263, 0.5705570536709529, 0.4403448811249681, 0.8660864400891801, 0.8290573194770873, 1.6729356600470706, 1.274721895339249, -1.3518252301749056, 1.367681854290756, 1.1301600371164824, -1.6008037335328467, 0.007827410623416702, 1.0144124554304956, -0.7708743316613321, -1.1393198405793838, 0.36462160646786357, 1.7117557837113757, 1.2759147707061769, -0.5849185012558115, 0.7618305444564903, 0.5273131199585271, 1.0220517499235777, -0.7405396440244174, 0.8181885235511146, -0.17244967001018402, 1.7988947500856363, 0.4306217838848731, -0.177244560394342, 1.3617961144227861, 1.0428393771546243, -1.41280428068776, 0.15461486313092931, 0.9686836462369854, -0.3121080173044442, 0.4680432971408441, -0.0854973230627029, 0.17954488978523195, -1.0357476968438801, 0.8891155624247916, 1.7666416411238246, -1.078610075241333, -1.2097653103785018, -0.8092637644003718, -0.03123538870432443, -0.11260216156098136, -0.5043952145022893, 0.31670820861213156, -0.6851500296975113, -1.0808028941223098, 0.06271498080822895, -1.172284426327782, 0.2926241245148708, -0.8702693181730345, 0.18354706558617398},
    {0.02143781086411526, 0.9691425646121435, -1.5283035606393822, -0.24158791769165305, 0.9375654298151406, 0.9972724248419446, -0.7772981728150956, -0.014243052833908146, 1.2178646097399246, 0.06062173966205593, 0.4290945118925615, -0.3311604967178883, 0.18834840221362864, -0.12192451457184726, -0.7017021117084107, -0.031799545588812955, 1.8919316095941545, -0.5328052099357768, 0.9189233925973114, -0.09314523228313609, -0.9048114953449985, -0.5219141453200751, 1.2351898538061044, -0.1156995814007771, -0.698609015239516, -0.294886605159266, 0.4005650734337326, 1.1640253593405472, -1.704516428242876, 1.0269802075170382, -0.9855205566676957, 0.7067731639001125, 0.5961527566466335, -0.9433905011690075, 1.2716095638336122, 0.6599056927201649, -1.4802752618188593, -1.1202270821047986, 0.2417584785663766, 0.5873771671883641, -1.2834028029470612, 1.1046841734834572, 0.45257796099528896, -0.32642542255252976, 0.7902854024319184, 0.14338959206645943, -1.1714874315084527, -1.5482070829946561, 0.567040311459838, -0.21485156764201288, -0.8405826020502848, -1.2993723468974072, 0.06555174479423742, -0.20206727026526647, 0.9190167873525389, 0.8692473085704637, 0.21117514208998098, 1.2572862491817436, 0.9235960343340607, -0.6228473454576418, -1.655189289641445, 0.7590475001066639, 0.2861055648082102, 0.3602584017651759},
    {-0.7198788170136506, -1.7099006345686762, 1.0327575618533589, -0.3313981731344147, -0.18964966123449697, -0.985259541170002, 0.013446013203910924, -0.9428137911067067, -1.5435943175191076, -0.4348177978110811, -0.77173463989858, 0.5669245149304005, -1.2711712105913993, 1.3115262350181902, 0.4863082289807568, -0.010754947450281382, 0.9124300951301064, 0.5427525267813972, -0.8805188690229657, 1.0746797369822458, -0.7251828755490177, 1.1496994092434338, 0.9054727102779959, -0.8208664125849303, -1.6494688628640728, 1.2823597318244468, 0.21136586496081647, -1.1361054916006705, 0.8933444212019512, 1.0734198886779385, 0.549412239790137, -1.1679916885507342, 0.5936788081625731, -1.7467599803604743, -1.1946076728320472, -0.3524213405276886, 0.639764147278748, -0.5411900527827231, -1.317751519594757, -0.08321129042248875, 1.2809778632735258, -1.1192858635929022, -1.6969696202662596, -0.527210405756359, -0.5545181986751434, -0.6507302986317272, -0.8894478060355471, -1.0844830865992605, 0.31477153267803043, -0.6357573728945858, 0.8885102137951584, 1.3668463763376222, -1.339444454574553, -0.419479864179299, 0.216462137073946, -0.9682762994954398, 0.67509853015848, 0.08202541980245365, 0.43552084962011056, -1.345984186764086, -0.13937582843018362, 1.2174022420706063, 0.8841435969406417, 0.19572372617670206},
    {-0.1575582787486575, 0.4347728901236341, -1.4775297461355699, 0.8261404907264686, -0.6662388687194545, 0.5930571570675385, 1.1834063529925405, -1.1421946392293907, 0.3609516020750821, 0.9054030658847146, -0.44811228909284245, 0.8923871747480931, 0.1469335264107063, -1.0429091673839046, -1.0742481742303198, 0.5545366041275493, -0.7380453556543954, -0.9723285662405546, 0.2609130601358319, 0.3854530662453463, -0.7031185087075978, -0.204199605644728, -0.1795541755154823, 0.6339886306595777, 0.24833542778491235, -0.979308952111402, -0.02651470270234939, -0.5915779732162768, -0.2517706922195792, 0.7812810900537983, -0.04689190402213281, -0.5223475178892077, 0.32953256928124736, -0.11543018143002724, 0.6817456277320628, -0.28482178020606913, 0.5021073209237461, -0.8443338035156497, 0.4449837374475282, 0.19413433955585166, 0.6887258519023214, -1.2288690082087466, 0.5086853679317264, 1.0331036347725464, 0.5247785682243072, 0.6759722785186245, 1.099488048140901, -0.8639776614774882, 0.5658258245843116, -0.31757274459896845, -0.9477924641668474, -0.7954135877067005, 0.3643345325913017, -0.47674442816226764, -0.9464397077443211, -0.3941371736864525, -0.6814932739937535, -0.8300887547772243, 0.9437912593896209, 0.30205669641759797, 1.1011447007802444, -1.2324413605384816, 0.888311009161746, -0.7042089051606581},
    {0.6232465208217267, -0.12950937807020793, -0.3343723080993727, 0.1378265708815564, -0.8208174007703407, -1.7087662274451403, -0.9023032144581862, -1.2950426108375581, -0.7044594177296959, -0.8344410279923726, -0.4554156156230139, -0.33816629966857814, 0.07259403096561237, 0.9310759731412053, 1.140912220181726, -0.8387608492873758, 0.3382200290642948, -0.8062783755522539, 0.7250169915115406, 0.7275544722720658, -0.9323019657271773, -0.6918976371816487, 0.3888699272121878, -0.15662965581478247, -0.8761751113368266, 0.5815123647979115, -0.8526023657355078, 0.5225564367123868, -1.1781883921316307, 0.09663176053276225, 0.9892246576989481, -0.3329360692245727, -0.6545368802202249, -1.1092972154029437, -0.7445877435011636, -1.0759765543092488, 0.24546443175419266, -0.44353482071320144, -0.6052440838210295, -1.211465784227922, -0.49188317950662663, -1.2030982165148127, -0.13181794761241092, 0.1316174536356736, -0.9447129035808003, -0.2366018252147625, 0.07148490765344427, 0.06244058338354259, 0.35245058379502636, -1.1697155904831154, -0.6944579226694311, -0.09823481570704064, 0.008180967299577662, 0.2401268672127023, 0.5277172371630432, 0.4115484378584053, -1.1313124671748949, -0.2788649802776177, -1.1414672244745578, -0.08100363119975715, 0.5521342271743975, -0.42151864752657636, -0.11710088351394866, 0.38433070777859557},
    {-1.417093252921258, 0.03106529701566476, -0.1836980795936828, 1.066073411283331, -0.6566826269159066, -1.3699500246767862, -0.2767675328581393, 0.2993169481780317, -1.3851916828382531, -1.453771859585906, -0.08658986567044558, -0.9899916097575796, -0.6169767848410527, 0.2353165037929522, 0.8893598459956139, -1.3862771396474844, -1.0966997255647806, -0.6764031008084921, -0.6572798971656328, -0.8438007505877847, -0.7560688177508148, 0.9442146046251017, 0.16639511991511563, 0.16613516349886326, -1.3847984596935226, -0.3794663317396192, -0.8491868216858314, 0.4135675304433322, -1.1775128297549489, -1.0230363698255835, 0.4840585056142692, -0.16566976095656347, 0.4396753758084302, -1.4773890762183322, -1.155134479311847, 0.2814151395410988, 0.6428969877370455, -0.6419534698567996, 0.8058827426883307, -0.2814236007937235, 0.2786813121502721, 0.6353630846310444, -1.38496327125841, -1.3398704673706983, -1.6056082863276, -0.8002308083540609, 0.26650662860819363, -0.652275995480335, -0.6305830682969343, -0.13033815302663562, 0.2235808385491213, 0.3117195469507722, -1.214236474530965, -1.3820945407746301, 0.9326696941793492, -0.5948503413400872, -0.9910349678972437, -0.9171858207511779, -0.06347163304990401, 0.3501216222058801, -0.940496462806277, 0.3888803169637363, -0.979814679703101, -0.13330366032354563},
    {-0.5927726016267552, 0.5146132846741915, -0.32382458289476995, 0.9212431784399838, -1.6942456549732234, 0.618609464740793, 0.6128227228583439, 0.5466577638488321, -1.5803223072781434, -1.0227123156123574, -0.9886885844108436, 0.25994261040410865, -0.4806240594471252, -0.9276417563994762, -0.19611395261318224, 0.03370743740159327, 0.28001369736684306, -0.2180574352223796, -0.2763059365742879, -0.8271711986673663, 0.2834411022598158, 0.31034709151758266, -0.5342506065418028, -1.2485522252810517, -0.15701259852026214, -0.38734371932017775, -0.8011346224742585, 0.5896743209056993, -1.6532438262147966, -0.8238944431668312, -0.32113736334688797, -1.0035534965955888, 0.18029686373644455, 0.005629192746132445, -0.7660651311936498, -0.40414614437340746, 0.09700479435465018, -0.5475361015233324, 1.033267443463437, -1.5969162567308668, -0.6066839442689494, -0.9420263758625732, -0.7886229733781938, 0.4229813769455862, -0.2753194020245881, -0.9021193878772452, 0.7453472926358252, -1.3524320173306101, -0.2903112233152892, 0.1835652044082771, -1.194674065267015, -0.8921309995820066, -0.3647011273419707, -0.5481714904576385, 0.4368534934832601, 0.2873713114515635, -1.1777171655304564, -0.8856671769086588, -0.7582726119941091, 0.80172904639165, 0.025228203365892907, 0.44023445856081744, -0.8457737784229014, -0.9489946046216748},
    {-0.5640859064450667, 0.009265785906530799, 0.026890163054800666, 0.8195752345894727, -0.12551126343493357, 0.5406309567317095, -1.3806791836430223, -0.17635230508174246, -0.21274167763909302, -1.2100063029759205, -1.3844510105649195, 0.9936849444710784, -1.087639308623739, -1.0362574265273792, 0.6705319773506274, -0.17732037780156973, -1.0097427225680786, -0.10266597213498592, 0.7829771034286686, -1.2198312423475175, -0.620793091551239, 0.4133782876766372, -1.440935804231016, -0.025935273085752518, -0.8937898010087393, -0.04868522628938348, 0.6880368583103935, 0.9174659431282717, -0.715344934792273, -1.3144297209865965, -0.9844932523584453, -0.6404652088429373, -1.3857069093607688, -0.6444406534566655, -0.8954015403302727, -1.572223404362768, -1.3253995728428971, 0.8321714223967246, -0.5096324168588416, -0.018598810043789247, -0.43832850532233064, -0.9292482121047567, -0.5526205167405279, -0.6531371700021734, 0.3848189914579001, -0.7396792104427371, -1.0160577757145914, -1.141361083737874, 0.2141837050966156, -0.8152527178676298, -0.12790677920833496, 0.45194556504352557, -0.8021284712074795, -0.004743126094572783, 0.42709833930893965, -1.1054982718676087, -1.0515053495021698, -0.3627528301566308, -0.7831578394553798, 0.08948040104599599, -0.6261885470983304, -1.2883583997105552, -0.9686709473848557, -1.2503986596103673},
    {-1.25941752689929, -1.2580388245385805, -0.6514811996910841, 0.9094047114759328, -0.6184185939245399, -0.44262775382464054, 0.7059469625791728, 0.7858244575805002, -1.480908095462877, 0.31088574175150957, -0.7181352518804894, 0.050707313930004036, -1.50084483174065, -0.8048675052011622, -0.04238571413641948, -0.17412925897447343, -1.0809323412841707, 0.604282740002634, 0.6007772122289499, 0.32121494444597914, -1.247583308453187, 0.6962706507304107, 0.5095884883175369, 0.4718654614035413, -0.9832517526566702, -0.697681719976193, 1.0362365508402254, 0.3446960513047591, -0.3277727288295567, -0.17705068208249455, -0.9305699986867373, 0.39778627416777046, 0.28033013175303795, -0.6941194251161034, -1.1719306136138499, -1.0992128203580276, -1.3274992821320306, -0.0014288228204818586, 0.5042771969655253, 0.24655269448630623, -0.06250421123939319, 0.16695673916102488, -1.2513128130501396, -0.7178215436809187, -0.40242021387372423, 0.6539090351560294, -0.9180548450277033, -0.2566776247589133, 0.3966206622103942, 0.6961121806850835, 0.3310472630116541, -1.1242679330988754, -0.8550985421918441, 0.4957712771298369, -0.8052784214131101, -1.1201598227476155, -1.5595016077014447, 0.5414577598506481, -0.3521033482362496, -0.317321745124793, -0.09222321579837404, -1.309864436877285, 0.6491961476806952, 0.7088758539017368},
    {-1.3993120035618825, -1.2096394256285854, -1.4315061565304028, 0.5425086308440142, 0.7638976569530004, 0.012628555663641768, -0.9227662110462915, -1.2675974346324717, -0.1929079190069766, 0.05101219547898412, -0.8903516885179339, 0.5773586422635313, -1.6088308511022664, -1.2158168776138334, 0.10531293148653063, -1.3835204017918417, -0.7789711930341676, -1.4871811645485258, -0.8030115736069038, 0.7285346890181518, -0.6734962900088173, 0.6504470680410906, -0.604739672377155, -1.495709298963568, -0.8872276688682001, -0.8301043284552566, -0.2736757933132311, -0.6970234652583147, -0.9653891114540932, -0.7865280014863176, -0.14233474982327976, 0.6381108354033912, -1.406637792926184, -0.41822996216564734, -0.3888898510652747, 0.3395687563693472, -0.417974004226264, -1.2602028149836897, -0.1803345205399157, -0.9876912057419156, -0.3074243286879108, -0.7667538615861466, 0.09003239562127466, -0.7335436607621931, -0.7807178652570309, -0.41835572932550624, -0.783824517534216, -0.9336623083056684, 0.354282325866395, 1.0004283294399865, -1.1827439734707235, 0.006854958678280267, -0.03114463374264232, -0.3734887415889205, 0.48729399024571823, -0.9252993315041683, -0.3527123710985996, -0.04802716493871187, -0.9528356619261723, -0.43883536450425714, 0.2693480375663002, -1.324940286434288, -0.4573602023076495, -0.5580540815058173},
    {-1.2249952573829423, 0.11588390030472692, -1.5873852395107235, 0.4604406620703863, 0.5510243347587653, -1.3393146741253796, -0.41986958984534006, -1.5112735226591354, -0.023819795297174262, -1.5917785712909611, -1.1569660729060733, -0.6179729649101847, -1.2827632230302435, -1.425642324640096, 1.1483462316287638, -1.0214173390570127, -0.09420216813220761, -1.0346449251548093, -0.6769324135818598, 0.3816538122552122, -1.1870407193318782, 0.7095022772254531, -1.1173158767142444, -1.6267820241352176, 0.7353816541859026, -1.6854823481671855, -1.2284613976479315, -0.8406169862211159, -0.5848160294098013, -1.2123012542859481, 0.5605653662800685, -0.6483149441742628, -0.016888834502588185, -1.2656821921066386, 0.8921197684999798, -0.8883483541689803, -1.4536041761136589, 0.35633109387715245, -0.1444043636800136, 0.4495001992510062, -0.18002866172477794, -0.4769239642608273, -1.5366104187713452, -1.7534864813650546, -0.06959664033722492, -0.1370227553476525, -0.3013457182377654, -0.5641094995760404, -0.7199706632156136, 0.41455053182384144, -1.5284424059692152, -1.4806571595116316, 0.16808776691369243, -0.13394328012559534, 0.2978322300132831, -0.17958619746080517, -1.0804974905833231, -1.3872566583673236, -0.0943937145445757, -1.2271692332998652, -1.0306988529087224, -0.6439121174877922, -0.5234770790257808, -0.7679426670608376},
    {-0.8953921224855147, 0.7147889040462239, -0.210594064433714, 0.5448769327168119, 0.01131286553857203, -1.3701742369676504, 0.05122867695448432, -1.2992245638340574, -0.8619582326358259, -0.05739296298967374, -1.2467755099598197, 0.28764256457602366, -0.9701462484531864, 0.34421170274440793, 0.9843538807599164, 0.8087256881922034, -0.11906717967319802, -1.3116401986411115, -1.268874964246978, -1.2062140242381219, -1.5077524788813144, 0.10265265549260673, -0.6172273822574407, -0.23609498222835087, -0.5179827947327111, -0.9709841947256032, -0.7029964346970531, -0.9665345198747983, -1.548186015351154, -1.2944859752133948, 0.6105691451130733, -0.6070963317014493, -0.2641140038143158, -0.8588779115015784, 0.33421059011314064, -0.8566418100185462, -1.2078917416541912, -1.1885174316848537, -0.10578937188617289, -0.10513499532797424, 0.5767060944628848, 0.09270191950409878, 0.0877685300264173, -0.7074867141050991, 0.5859265425116047, -0.22239001541890077, -0.9207244839901766, 0.31988737178994076, -0.8972310569515616, 0.40605151726330524, 0.3451447505625843, 0.11879909361653487, -0.4970382494556295, -0.5176948089245997, -1.1212161695485656, -0.11410952748200918, -1.331665695675318, -1.5674826287661625, 0.7581861685773121, 0.398940022156273, -1.3299443967343842, -0.6535083555122019, -0.6922515439133136, 0.14471753029472106},
    {0.6789811744957605, -0.3436100569419112, 0.2298169028228282, 0.9068422581705076, -0.5004429227793844, 0.560523467442106, -0.43956565840551776, 0.9817820464337524, -1.53733175664062, 1.1175060069574783, -1.0437587286470842, 0.8664936283445418, -0.3981248215144764, -0.09756281986605854, -1.0282845967841439, -1.4511121477870037, -1.1122105878807869, -0.33646752076188063, -1.2500179854121738, 0.05844735901076174, 0.16398302350436889, -0.29083124393320464, 0.5474603313623746, -0.149457300279655, -1.2458576886207715, -0.5409477615039764, -0.7532669106971857, -0.28617496128007625, -1.369875651909709, 0.6924253865768524, 0.806506192168545, 0.30627042734356025, -0.9798913916712877, -0.9970261113379685, -1.1641367149839303, -1.557552699636177, 0.371751602316597, 0.15919545113931433, 0.37564925967307755, -0.019586947288538315, 0.376187439921079, 0.28716940345542463, -1.4670180459183662, -0.707047938773763, -0.24761422648699752, 0.2941572866648162, -1.358646036446836, -0.6719971368231796, -0.22825645642453904, 0.8944562109375453, -0.21394447860276877, -0.20539412213112626, -0.3827551550094005, -0.5844236398440844, 0.9170522361230057, 0.4513899470174355, -1.4775935706999908, -0.46326421226338993, -1.3018667994769393, -0.8310080204573634, 0.13918383602498943, 0.6609255621299485, -0.6339316670119228, -1.1803826664383514},
    {-1.503198721439314, -0.7390206685107492, -0.2147259147170242, -0.5665912692936609, 0.40795599775881575, -0.7639801492053518, -0.6026644930052507, 0.06319594739751239, -0.4566573393433039, -0.3046980542065313, 0.1999649592828772, -0.9163458404539576, -0.29401067413147697, 0.9650797016259207, -0.1513251940038992, -0.5577067768924969, -1.4390635461437753, -0.08728948182535841, -0.15311736992015748, 0.0012569173398714625, -1.5800726266911902, 0.9776311266781469, -0.6539549020507066, -0.3067855353540116, -1.1984374913569384, -0.9968315065981477, -1.1313604283228582, 0.6677236126472041, -0.9114264879874971, -0.3595886494972319, 0.09024125634391753, 0.7640080836559584, -1.5233436735533559, -0.9944286878758289, -0.22457864132201108, 0.580924597234446, 0.08416245536212653, -0.09625405279534983, -0.37303763483642577, -1.0975323880789813, 1.0046904628858568, -0.8873296695150696, -0.6871901536978957, -0.8792665198571812, -0.9437085997927672, -0.6858010754301351, -0.3923804552139107, -1.013438522828668, 0.8999226393317099, -1.0509619953701899, -0.1927415126310104, 0.5812478455360062, 0.7560613064955987, -0.6619263374296258, 0.5399338558475733, 0.20283923596296363, -1.3393038168498945, -0.604390107911556, 0.4300922132997994, -1.2448482490069799, -1.590868574070683, -0.7516737668423411, -0.7605960191092658, -1.5456675249617244},
    {-0.22721415667159334, 0.8490905619018553, 0.6141564658110813, 0.3243596743551152, -0.469171824055966, -0.17129846034895294, 0.46313946840208586, -0.6479328377700166, -0.6042475539127041, -0.13408078511797306, -1.4393011500146395, 0.8113488939318305, -0.17115640368140858, 0.9375087023221748, -0.6263017888856265, -0.3089853775976273, 0.49674048665910425, 0.47336316737300693, -0.4777958569289167, -1.3223363100353276, -1.3650517074944735, 0.2532358846621357, -0.1715573658824299, -0.39265345458719725, -1.588939060596966, 0.7763979530646181, -1.217458415092746, -0.4985896829468435, -1.1409464345510854, -0.5649403199866564, 0.22248798495851133, 0.5986716292104673, 0.15812667763335475, 0.09787965436007354, -1.1269860586713907, 0.8502975704108698, -0.6907206669555807, 0.8607272179826809, -1.0930732618279884, -1.0361526347789676, 0.635907803015905, -0.6679706448566028, -0.17830837332182806, 0.07564060773026614, -1.2437969734065115, -0.9584867388281568, -1.4499687293069703, 0.5076085658757453, 0.25903755707477216, 0.43101598301595645, -0.5638348002669303, -0.3435327171612182, -1.3569286912827583, -0.6519340853918252, 0.15216003293591676, 0.16075013180145648, -0.7308810188444049, -1.0378239750621088, -0.6880365562935007, -0.7212534229668479, -0.6861797874464828, -0.9356525001824763, 0.5771907934224733, -0.6436952057237565},
    {-0.1651790730121847, -1.4088790015716484, -1.4667361631973634, 0.6723643248253208, 0.35321129433229004, -1.0446735100204996, -1.5151644999262266, 0.21438075943703644, 0.048610942329397215, 0.4357634549650665, -0.4588987767756676, 0.3792183282470861, -0.34163854829863083, 0.6603628831466517, 0.32030176286828543, -0.5352067767689597, -0.7797024221901149, -1.2487458505973894, 0.5872986737634163, -0.5588576692197162, -1.5556088811910922, 0.9296418481404651, -0.5118480968958025, -1.3780576932120978, -1.4023751056303424, -0.5067911163663098, -0.16432834653614806, 0.7632439329251123, -1.01505115401288, -1.139508945696231, 0.3955645489891613, -0.5876225710707421, -0.1143956111802617, -1.1474847257391254, -0.3862213611216441, -1.4661657215632917, 0.46695171244650235, 0.9150902242408381, 0.4792206869890723, -0.20452385527156858, -0.4888241842732793, -0.9555427253348813, 0.23918734913345144, -0.007745498162024152, -1.096372204914115, -1.4418751503330491, -1.0338621373686911, -1.3035131628593546, 0.23596686386467297, -0.31882301451335177, 0.2557546454198635, -0.15392856420480786, -0.9223838663112325, -0.7307272658255944, -1.0074999920067182, -1.575949665055645, -1.5622374270993513, -1.1573164376845986, -0.5029600311666321, -1.6684744888409833, 0.5073053788565721, 0.41513840313781614, -0.6559449764576768, -1.5783900852355033},
    {-1.1277068559402372, 0.34020184295601286, -0.04788911738695874, 0.2524748592634447, 0.027432528884963118, -1.4931655338991014, -1.0845518850456162, 0.012401352702842747, -0.1649203602047717, 0.11170071557312165, -1.3937590083398372, 0.5162443648061888, -0.7271611029042987, 0.8867153952357111, 0.607291993117035, -1.3143389207844975, -0.6630968191341157, -0.2334165123644516, -0.01566083368169225, -0.9241602733105369, -0.1115248082581576, 0.8209140505072783, -0.5117788349622727, -0.7191847077480048, -1.3506493944900098, 0.6413382556740935, -0.9705471812774722, -1.0045483993584257, -1.3416409484404987, -1.2452405822224932, 0.6951528674737671, 0.8311690168188272, -1.191325522558634, -1.4630409156447368, -0.6944854571967173, -0.3535506307962392, 0.006918485286237085, 0.1938585968328954, -0.8720734037327766, -0.39874645096233224, 0.43474331211220313, -0.7207555034453867, -1.8380983273606608, 0.1348809789950079, -1.3008894971760918, -1.3383217643919674, -1.1913759687612018, 0.007977726243412748, 0.6063279285418615, -0.6368947310663986, -0.0626068824166409, -0.7739141728592409, -0.5607697656082363, -1.3919278991748567, -0.38466217001712677, -1.7734643264003513, -1.1607223752250775, -0.17437038160284699, -0.37792099855580136, 0.4108759326141627, -1.2195994573028726, -0.030110883736890453, -0.2351233176087998, -1.2993141230028986},
    {-0.08955117693071547, 0.7388925950147059, -0.22244654870717465, 0.02371255318042273, -0.9837949761327248, -0.14117905711505582, -1.4855089989883823, -0.9582534190617855, -0.8063729752346345, -1.3273326878052234, -1.3176791554334544, -0.7233880146797895, -1.2728887968662927, -0.8214294817794655, -0.745713939583986, -0.9927131107784111, -1.3143974495545376, 0.566727772266872, 0.15844380507768727, 0.1595690974904846, -0.4611275825774619, -0.7060543236821448, -1.0295636201046208, -0.9776534227149876, -1.7460817614284816, 0.7858216302190272, -0.22457217162427998, -0.02014648056972202, 0.08706327674408154, -0.46975430051064093, -0.4302607916702944, -0.17571170958939827, -0.2635725919604813, -1.1854131219599813, -1.2133991096276453, -0.8476966002374787, -0.24509778359193415, -1.2680526058928658, -0.8639128231335282, -1.3393716701246885, 0.3730327120957132, 0.6463750320469778, -0.11222864878282171, 0.4021957217605077, 0.25069120661026445, -1.5533814138600397, 0.3940750056294575, -1.5919665925715332, -0.7554938727915186, -0.9936569965733563, 0.4431590096954259, 0.13277927062337178, 0.01698363124178129, -1.1793617018349163, -1.3070873442756488, -0.9036103262346262, -0.11997628753372098, -0.4012450456196498, -0.4473361415128914, 0.2708729490316052, -0.5778124048147095, -0.7210128964497791, -0.4206106712676237, -0.0019593942387411},
    {-0.3535783750913145, -0.9407841939672564, -0.14231608549622224, -0.07700168096970539, -0.29992625045645815, -1.2938310044933583, -1.342738082701794, -0.29827921578451166, -1.2688914381335534, 0.28313306138043326, -0.7623120866856099, -0.5380812735602232, 0.18642300742243134, -0.02207351675795434, -1.1017206278803298, 0.6973649299058177, -0.3008284960087586, -0.7609842120559726, -0.5039574856753944, -1.4160835320456444, 0.04085606147393692, 0.732365997670134, 0.7580689524954493, -0.17566528563479455, -0.18906087511470107, 0.7914943446484465, -0.6832089762233621, 0.6728225471651089, 0.4498036874368923, -0.08104992787911813, -0.4368846508099021, -0.8463189564706319, -0.3441793263203115, -0.19086054009370135, -0.14024868723853862, -0.9772591931439203, -0.6274373672762908, 0.6555343950965442, -1.2880765373447056, -0.5833144929070436, -0.030848416082348906, -1.3034117345491234, -0.975415302843076, 0.18274256854431975, -1.4473784553322242, -0.45619669401981217, -0.08150948053575427, -0.7149262050773041, 0.30124939522674776, -0.7096042648629174, 0.5010055745205086, -1.332984885845109, -0.46800030384139724, -1.5745027985101314, 0.4409189160499903, -0.7109566363451724, -0.9351226671507352, -0.21460710897420945, 0.5797250227942332, -0.13538426010226198, 0.13025198187407194, -0.36719639519026764, -0.39280886584210223, -1.120800924521402},
    {0.19612773862957147, -1.159979260677454, -1.3125559472168873, 0.8385779140906687, -0.8610989187877967, -0.8804940411112759, -0.46626315823267417, -0.2585060078224643, 0.03388781767836459, 0.08728232596565766, 0.4190340671665011, -0.09788478726965535, -1.5963684662964148, -0.8058782287148818, 0.6554954550193748, 0.5240017168195745, -0.8203581905978281, -0.4381799379423458, -1.6042450433709068, 0.03181739296920319, -1.3772575655914079, -0.13758572235186559, -0.3919048849971828, -0.4577620939322796, -0.7605427553558191, 0.012730785483161488, -1.4481891079622826, -1.2476875414326996, -1.6228741091284795, 0.7028088971296935, -0.3827527930892049, 0.8592977353777341, 0.7623366797754364, -1.2429028790829248, -1.1131283925695294, -1.3920901153263734, -0.2654591644116393, 0.04202524046989614, 0.5785407318917215, -0.10357720504260255, -0.9148667477357662, -0.6434875194547128, -1.093727232789807, 0.37590347589409967, -1.2782736267336736, -0.2826011844509135, -1.4374805133652544, -0.16442705083347167, 0.5185828361933532, -0.12376658159044894, -1.2718676798812871, -0.12477087058830963, -1.6631705873160576, -1.3683565368620518, -0.4475764482099898, -1.153040448017437, 0.14715980141055818, -1.437775218314565, -0.9785241468122313, -0.787525570498806, -1.4822501067964855, -1.2955781814992038, -0.8875919984821532, -1.3242297208893172},
    {0.7704086212930888, -1.189501041446597, -1.829427617352162, -0.9843914452416734, 0.48555272296290364, 0.19796945294937174, 0.7422822804835831, 0.8479480103985713, -0.0687009450835275, 0.9117767777680416, 0.798087684740684, 0.39023478200572187, -1.6574756786536327, -0.958648416095266, 0.2094013178083884, 0.10930920531390231, -0.3541267541609637, -0.2049664033821611, -1.5126743538814367, 0.34196227536583973, -1.2245040874638702, 0.5066804815039311, 0.4130438489023334, -0.47148681428378086, 0.09942149068837547, -0.5606502234866466, -0.17829123166105484, -0.6675398608047025, -0.27450459247685277, -0.3233918407124668, 0.7061048923658946, 0.6974261257642589, 0.6789584624835577, -1.2080846617913317, -0.12605911835431613, -0.27777722931083265, -0.3865320884696597, -0.4394904000447274, -0.12072893058099764, 0.014127043728443839, -0.7274819299298102, 0.5529040819507739, -0.08860848232333926, -1.2529979833502847, -0.2061321644669529, -1.2849350229998096, -1.3864318801517337, 0.4282347905591075, -0.21167739981361247, -0.45048324633855136, -1.1050466222945625, -0.9737774219561843, -0.023755517442451378, -0.7893401105387201, -0.18675293265113693, -0.4564015401493072, 0.21448564558361502, -0.00934949863102669, -1.2902524585625073, -1.7717794370295579, -0.9666264250454883, -0.4453228947596494, 0.5576748411240761, -1.0504611459889068},
    {-1.656053170217445, -1.364652747613257, -0.556378388784553, 0.957798863234562, -0.011191357733582541, 0.21755746271032983, -0.4498987303058305, -0.7605261453263217, -0.959572020756107, -0.7267852754528663, -0.10417476781251428, 0.44772007654424933, -0.7585023465585957, 0.836398121373179, 0.2838414525935598, 0.04546905495389591, -0.27462754356277425, 0.04268563994014684, -1.4449126703750093, 0.6649390436522198, -1.1816228354142067, 0.29219885747823604, 0.38123926291089144, -1.3744816626170695, -1.3104458494826607, -0.7852841317212685, -1.1886817274102155, 0.6017083115881287, -1.5441112852858987, -0.4645307291535088, -1.0905386421654406, -0.2230993651626207, -1.4251690971108661, -1.2903073266212626, -0.9977481289978348, 0.042015967613170495, -0.8505272410362068, -0.3599721410945528, 0.5976770173057172, -0.7222071070411477, -0.15103798699648835, -0.07426603305044735, -1.5926780813055357, -1.096461120738628, -1.3641705805032698, -0.3929672774970896, 0.0337090056845397, -1.4636495257909923, -0.34645050895416457, 0.8491723604054927, -0.2692948141130328, -1.6295892418627116, -0.597572552475513, -0.2082973187878601, 0.6426845893348462, 0.1375577530003537, -1.680024663591824, -1.4539922920198387, -1.2945994864513308, -1.5709933568514225, -1.593432753987547, -1.1583161480255366, -0.8934490095718203, 0.03474785550239631},
    {-1.1872602223451842, -1.4071780636831186, -0.4102941512777834, 0.7276407601768212, -1.1489668976557819, -0.9152806964467354, -1.3449688965422648, 0.01826299556168823, -0.7350739255172749, -0.22605577986763, -1.0355964697639224, 0.011949836438387842, -2.0769599134334222, 0.5489332177923903, -1.0812935719309973, 0.16477167322633599, -0.6891753473889708, 0.6900314223638649, -1.6224028411127955, -0.5772363431037495, -0.32238257545592425, 0.09041642341767556, 0.5355745956437078, -1.0177069916512482, -1.195560615110745, -0.9007693720827477, -0.6091199040485783, -0.9055692581431968, -1.3318113698899416, -0.14776360708365485, 0.4196670546635317, 0.5696814374388057, -0.6776860344901234, -0.036928183537315244, -0.2846867828686247, -0.7099215447607335, 0.5276763222739093, -0.30616481016284014, -0.6149333936317596, -1.1309745732065457, -0.386368194305565, -0.294658947575876, -1.1619616528951857, -0.752257521013281, -0.3973610416590974, 0.3202869795870711, -1.7750851229705975, -0.15332985570018526, -1.0495327006683335, -0.5657878341461937, 0.39546447421782, -0.5090694104761224, -0.9419891851219768, -1.8328039520523078, 0.534140503530976, -0.3876449462504394, -0.9791012618551814, -1.1994159584054762, -0.4837218810775272, -1.2363284065113664, 0.13314200115166336, -1.6418180885944338, -0.45589398108740947, -0.7666998841710454},
    {0.31171127975236024, 0.17918661701576086, -1.7511287430530849, -0.1198931801551635, -0.6113978251283099, -1.0314602562340214, -0.6096392890616191, 0.056861731355505846, -0.031911464519526, 0.3636143674176534, 0.05685288692130932, -0.8107161677452869, -1.7782999564376145, 0.4389383581763143, 0.05353307081029373, 0.6196294480338582, -1.2849654783108782, -0.22423013721695806, -0.5806784836209554, -0.18008701181888417, 0.10353492546812036, 1.3756678053040505, -0.19135590382255854, -0.643010409933547, -0.0166431121920366, 0.6590951865022058, -1.1136750761143428, -1.0306077287817503, -0.35680846945077827, -0.13545493563775227, 0.6798038116767623, 0.5740405654001224, -0.2878062655335146, -0.863942594319572, -1.2584593992681536, -0.8865220514688178, 1.1022253508944935, -1.464381453459634, -0.09331859714695696, -1.277659566821829, 0.8257578001238245, -1.2157174924259972, -1.2687152705456806, -0.9183159209022426, -1.1825383852168367, -0.500603146080858, -1.427639606290514, -0.7619514370323102, 0.3440793962238891, 0.8984411615990425, -1.0720624307622562, 0.44011323814842473, -0.637523368969884, -0.16451835211672408, 0.44801731845880005, -0.7041929407597163, -1.697220339354444, -0.6339665831726491, -0.4448251006869136, -0.7233566162450333, 0.17896052726702416, -0.5249780462742387, 0.9209042223243991, -0.26904265363911034},
    {0.7106069827249909, -0.1708084109378855, -0.9865096149416273, 0.48758567391156515, -1.467253827313434, -1.1042517372729752, -0.19543654041283146, -0.8200299157396697, -2.0414212060568415, 0.08998718093518784, 0.0306424061133209, -1.1187598459118584, -0.5930595753763597, 1.3413299386584274, -0.08943452522128481, 0.4337590392511154, -0.4094295762056592, -0.8172322361237337, -0.5014782964013536, -0.2354717431694182, -0.8695673897804259, 1.569922414026662, 0.3702407197290484, 0.06679093330956498, -1.659364224094819, 0.6961419557774466, 0.7088451525909996, -0.2899752307201616, -1.2259836298868736, -0.4042457403932441, 0.6628639992387386, -0.5892902316354043, -1.1946805679367696, -1.94148475037627, -1.6456950665523138, -0.8053779284334266, 1.0903185458705738, -0.248405292348553, -0.8748952380397391, -2.005564402978829, 1.380811753657258, -0.21562318101389047, -1.4346788655343639, -1.1985963018137569, -1.2333210415449534, -1.7917986792992602, -0.13588980772606124, -1.1298468035025908, -0.01993116071740004, 0.2629102367128047, -0.34963389013282253, -0.824552361562446, -1.488961102233889, -1.5611043763772887, 0.6555500058231223, -1.3102699666019748, -0.23448688743229062, -1.5558667718136512, -0.9738541345803338, -0.24979802679658203, 0.13258919160052332, -0.2085422407263018, 0.849114840496272, -1.5575980434315577},
    {0.3827510885906463, 0.06733903339245476, -0.057703381689397606, -0.9043100145932353, 0.39932445550953155, -1.619520951073912, -0.8674226645852484, -0.9351000916329832, -1.7161824032155724, 0.5248971381589413, -0.010985913559720511, -0.25193649319214195, -1.3450033568980908, 1.2216748500383907, 0.6097441828436797, -1.1968585692850333, -1.3933324773192652, 0.32335541332532997, -0.7168361247596161, -0.6907373956430658, -0.6275710133314424, 0.4628488825329198, -0.0775346209868619, -1.128388121720484, -1.7916705817787175, 0.31142412818477155, 0.0992796992253706, 0.36934686052504656, -1.5860872862545567, -0.2186158831446409, 0.2031533237517052, -0.4318657403944982, -0.2934878725723924, -0.7669398813845855, -1.7375565984392938, -1.7103835102038902, 0.17040583633501846, -1.0589239797056815, 0.6265326115293416, -1.20356310458972, -0.2541744426951335, -1.09254354525778, -0.446895478273091, -1.0398836493897485, -0.9729762694136778, -0.8193845679483363, 0.055773864259138994, 0.05250447230530825, -0.5432081373009029, -0.39981177206679225, 0.6419964759802006, 0.1513352206885636, -1.252102831544753, -1.4369961504657591, -0.07437519406282976, -1.3265211594660633, -1.4281806489176196, -1.8176601919094615, -0.9414259738429145, -1.4579716366824553, -0.11283128883979775, 0.41321834516448097, -0.15562342524850872, -1.2791772593172814},
    {-1.40683102620303, -1.6531572711014981, -1.146435623974807, -0.96428200063722, -1.3680386600867216, 0.007837811510142, -0.4584367016308769, -1.0598439269994546, -0.906710492491884, -0.43701110749643235, 0.46343125640024174, -0.4099897150850368, -0.6112655909411931, 0.9175385154028215, -0.987728799323931, 0.008595800782703063, -1.452964005360259, 0.08428161493996761, -1.1431913020926496, 0.757183092649071, -0.47720475745600466, -1.0173504388307268, 0.287753289609125, -1.5709284228466545, -1.617186161567108, 0.5606553736230647, 0.420963177185438, -0.7698816446937435, -1.8288408134219785, -1.2714720343385217, -0.5858229371972019, -0.35183819330318766, 0.14764992462314125, -0.05077360245376199, -0.08548057670577992, -1.8042180233912533, -0.34193179291901377, -1.115524808137236, -0.15475571651950742, -1.5845836825722952, -0.9146709068677654, -0.7552416821855892, -0.09883045038246187, -1.361202719490345, -1.8590768371477213, -0.20765713076700656, 0.06407265302855523, -0.4971213082476923, 0.06423469991008963, -0.049121547177841035, -0.3931111416191355, -0.4230019024663929, -1.7429877419953257, -1.5354195733143208, 0.678594948170737, -0.09456535474187928, -0.503528582923116, -1.6542421832849232, -0.6304381069740116, -0.8075572072664656, -1.1685113709603459, 0.3420245613556601, -0.2975220993855635, -0.901340531372251},
    {0.49367873376910854, -1.6480261863938392, -1.4118790148167248, 0.1886362979592467, 0.2172727830349075, -1.579976765969636, 0.2518595686094289, 0.3014785625032401, -0.048223782028204834, -0.7413881509228185, 0.6801925684228302, -0.6025420672046106, -1.034859559198944, 0.4629891465679791, 0.3453424077760681, -0.5770422664642607, -1.591262821468008, 0.4110005265764762, -0.41798654172998495, -0.22256836070699845, -1.3185298518968747, -0.05688737712397999, -0.6599795385212455, -1.0982524635015174, -0.7873942605803853, -0.5635959359654474, 0.44345288947733524, -0.010334666814748773, 0.2185683117133962, -0.03619373141746184, 0.38244478919931496, 0.5007178534364769, -1.4101775489740394, 0.049686935292849455, -0.7854767347611579, -0.6613151973263078, 0.7169364982537502, -0.8855547185649301, -1.4402196342201463, -0.8192825198391351, -0.5608018269316504, 0.46749217778546714, -0.9713627143280772, -1.3837213308139211, -1.2566862754696124, -0.4008191088263974, -1.9057207687435416, -1.2403645622912132, -0.0016055983186212609, 1.1361695814519286, 0.11998682326745702, 0.3555298018929974, -0.8806684828979882, -0.551272749344181, 0.16135167203840645, -1.7315359059916784, -0.11044548014803, -0.6123766317209792, 0.17619434523628388, -1.291612646765307, -0.37358949370045075, -0.030394234831687145, 0.22903961048918497, -1.351100757638275},
    {-0.27357995987151773, 0.29944837293783033, -0.4544631197342246, -0.5655401671121941, -1.4132941383963362, -1.50026309399567, 0.7431349776443152, 0.5933491688751698, -1.204031670632261, 0.3184373104104592, -0.3874761541762636, 0.16910056038663324, -1.7696823903672776, 1.5394904967906495, 1.2320583850824323, -0.1618652133759002, -0.013825796003337734, -0.87883957522089, -0.87791886563863, 0.9517413213150987, -0.2357770984890477, 1.2137422959796145, 0.11890509007036092, -1.0851932849184889, -1.5556971776466888, 0.8091602231830846, -1.2223294078829203, 0.5011632023955602, -0.2070869626752331, 0.6702435559497101, -1.0104205023664723, -0.12827186450154063, -0.6166353231567067, -1.5386960243069383, -0.6135003684763713, -1.6659088001042832, 0.18087146830373999, 0.344130236849434, -1.137983399883708, -0.9147056163576105, 0.8694087131076877, -0.11691663038831268, -1.0663678849685094, -1.3967252472505123, -1.1713728189739794, -0.25106868223215717, -0.45229463676020953, -0.9438956610761399, 0.5051812042841931, 0.9438932651980669, -0.21084549534825997, -0.8912905559846123, -0.8412376971560299, -1.190729216348872, 0.503596709831608, -1.008031318954295, -0.8892659600047926, -1.6449296238859001, -0.2587442554028999, -0.07725951574615117, -0.11372966872963854, 0.007000995713515398, 1.007808731585083, -0.11844884866339876},
    {0.377079458640008, -0.44037675037157414, -0.15229460038771642, -0.7752668926282282, 0.1721040364929729, -1.6231978189839313, 0.047988118728466624, -0.5298801832182353, -0.7548060101424798, 0.7628331489377183, -0.23487988226728398, -1.2589002722336997, -0.6694740673175462, 1.3652365534867648, 0.06858496246761567, -0.12057515293282826, -0.16746422429939853, 0.5809652759543098, 0.6246135924645243, -0.1605758339085342, -1.3529591518600463, 0.39086752576431344, -0.6156538003154735, -1.1368318143461482, -1.444114994290548, -0.8258978614703633, 0.5050089239450344, -0.7537763005030688, -1.4580617628013317, 0.7680812823874661, -0.30973122940944875, -0.8652566624354316, -0.4655860341207857, -1.0948439403805683, -0.5308578022139702, -0.7691617891731504, 0.7430428694538697, 0.31004988046697096, -0.12054456636753821, -0.19253031193399509, 0.9817167559937001, 0.05920447700127871, -0.2185784538521364, 0.3785308004611745, -0.5211490052085147, -0.6948671383292645, -0.5236679467802622, -1.2203275263188655, 0.16809918424959988, 0.17115079583151888, 0.3110005560427669, -0.28017582213128284, -1.2936136682469341, -0.26084719170638715, 1.1792612199257144, -0.5027260213931426, -0.905859220636509, -0.9769374229294439, -0.7076309646579638, -0.4657252239836763, -1.3178603863138763, -1.1595742138033762, 0.5675709173303418, -0.9818885840175536},
    {0.4011903435353835, -0.18671978287035174, -0.5323757658061965, -0.4307996076675031, 0.3508235137197833, -0.09079107612027493, 0.7488721939509151, -0.29423428373928917, -1.575223890392565, 0.9316251991163012, -1.2307360141491293, -0.17422258535445478, -1.9475877028841355, -0.3691312020635877, 1.4034672421856709, 0.47731279343238003, 0.20805356253870524, -0.5270751709366014, -0.8012049944591297, -0.6251680354469566, -1.078782414855184, 1.3841740845534434, 0.5876157500391366, -0.06215963802426456, -1.2089468143459103, -0.8908555907448993, 0.6284806668866074, -1.3841474331561034, -0.36377442660136533, 0.023144519186004863, -0.45629456814568253, -0.7809882177307883, -1.098491847806133, -1.295444273564792, -1.7186359547275456, -0.19356525429562702, -0.1607570623343798, -0.9839947763021594, -1.0336740084817693, -0.20461239395902758, 0.6450844232930822, 0.4997462484831585, -0.47897409335538715, -0.03240430602210789, -1.4185552509844936, -1.9754167860438754, 0.054412611679579066, -0.5760072234733796, -0.24917123606615035, 1.253923997453992, -0.2946045053994454, -1.0146190595554037, -1.5987306152625154, 0.0628400538349686, 1.0205981561154898, -1.3711331324594835, -0.8807702791807243, -0.7160888335595169, -1.0073904746279208, -1.789416935814305, -0.5936193800039835, 0.4129491612885943, 0.8349292409841108, -1.6108130657789332},
    {0.18782220277758024, -0.7078742086764788, 0.3475620590033888, 0.16839517974834747, -0.4276364414494395, -0.36167970220736767, -0.7850139807300386, -1.071813307401637, -0.5376292006593398, -0.1694004808053114, -0.2619226798977525, -1.6494319478231454, -0.37058091475710153, 0.8542997519802495, 1.2775376868677386, 0.6073575341245557, -1.4676484413809034, -0.8985174692076651, 0.30289093739282386, 0.94147223502441, -1.6804643385598481, 0.48643170010949005, 0.7649171821132006, -1.844225961813196, -1.312059997368206, 0.3661729527580985, -0.8798978010193563, -1.1664240132015713, -0.5952712446032036, 0.8316919057051249, 0.624826758542374, 0.2690472506369571, 0.5654458738372588, -0.6972112540463644, -1.724775412612797, -0.8736606489732055, 0.8129143633315308, -0.3229439347724157, -0.348704042583729, -1.8546313531425422, 1.3584786396606838, -1.5604672175273098, -1.715536050235368, 0.7549234549822444, -0.9249091818513745, -0.9824329639907847, -1.1151189480525632, -0.08700983705814809, -0.6483578256231461, 0.45013892412776824, -0.7399939209672213, 0.9900408941739022, -1.2661162031958761, -1.523782919418021, 0.9007542650303317, -1.6143130888434791, -0.2552200019132036, -0.05703892255931897, -0.8256343226987339, -1.047006451223884, 0.16289399254851675, -0.46466927638041533, -0.04468428994205107, -0.9913154542159703}
};

static const float b1[64] = {1.5317602008046147, 1.5116408946921738, 1.6589837243387162, 1.3039740604295575, 1.4293883840557575, 1.2023789681996464, 1.3726981512669936, 1.4376853387941138, 1.6319367192775536, 1.551038393494894, 1.6340790483645993, 1.0444319742780763, 1.8491660301328186, 1.45449650482672, 1.3735048767899316, 1.246922459905248, 1.4075212846740066, 1.2525859186773143, 1.3460780412753859, 1.5097234821068939, 1.385215714189697, 1.4904885027588184, 1.6224674523645548, 1.3881117175093391, 1.4770396777855919, 1.4929811557901926, 1.573085660913146, 1.5395616306677011, 1.5955285838247213, 1.4776393961886733, 1.274883835711189, 1.1062430753845849, 1.5683504999617477, 1.4507414615718788, 0.9776732216409573, 1.4745037233840912, 1.3840238326623444, 1.4647778879625915, 1.4036436321522652, 1.7347240049662422, 1.5101257719246162, 1.0719178455064415, 1.5062646911839985, 1.4464950807595869, 1.490843937914921, 1.0348150792117266, 1.5164478069659157, 1.407051460101557, 1.1882098624108255, 1.3037015396062568, 1.6820550909061913, 1.6600937108663791, 1.4407685567758135, 1.2007156489437159, 1.4905467181705365, 1.4268655565477686, 1.7466538804670273, 1.2965149085965524, 1.5250963818493974, 1.5097899479323025, 1.3847003572145977, 1.4830250659237807, 1.4269150859514403, 1.3947072554486444};

static const float w2[64][32] = {
    {-0.9007845348023297, 0.048346936313051064, 1.527441897144796, 1.0248168574179088, 1.700914793168595, 1.2991029193879449, -0.22402810201051981, 1.4637139539412716, -0.5065236667894203, 2.1379632822754173, -0.04629248054425346, -0.8773443747298998, 1.1087575557795781, 0.38338645381526454, 1.4413355688647929, 1.4384656668547844, 0.5986529402363281, 1.1781033001735037, 0.5444184805937109, 0.48107734878556246, 0.48510122002921663, 0.2724996784962421, 0.07006859927899373, 0.3673979875326753, 0.36414550400022233, 1.984386883229344, 1.166279146036586, 1.8372389458994716, 1.271820268787248, 0.8322714642167942, 1.2365074101283524, -0.1449790595808792},
    {-0.7803026483973468, 0.42060834846737327, 0.9821114733295636, 1.9056238271087285, 0.9182480080794232, 1.8379970006633537, -0.4007903837032235, 0.31414022796701396, -1.0533606311242076, 0.8893264615496819, 0.09952598342954311, 0.6142002166240337, 1.4859406360819272, 1.3626793607142529, 1.8335500462891066, 1.023594968762772, 0.06986723421599317, 1.9247819811836757, 1.3985102833789653, 1.3292012423568635, 2.2335184449660077, 0.1435085956299227, 1.0886802321375886, 1.3180774449296695, 1.354489744773845, 0.3123074110482097, 1.5565448894867127, 1.6641378285419433, 1.1274784747452224, 1.7179179117658552, 1.7519350359604895, 0.244096531973324},
    {-0.4758256375700953, -0.5334207062217938, 1.7670041147116375, 2.125471175906401, 0.14684661916854003, 1.8853250309427252, 0.06852831442389781, 2.0433190235618333, -0.08908215007659748, 1.7665634799914296, -1.0197577052332771, 0.32038099273991894, 1.0162627338163128, 1.2276440871658418, 2.1592224483642037, 1.9215741456686906, -0.8746144929991141, 1.5210290008970386, 0.47828565059923234, 1.3648259780211416, 2.2369033278517962, 0.9151826124560271, 0.8939325820206256, 0.5239796342799876, 0.5018654158802527, 1.1933572932629162, 1.3152107525286878, 0.7981833140536042, 1.4208811560168433, 0.620991802878213, 0.48411885289634954, -1.1127621829800338},
    {-0.5568652644398969, 0.33145531201226597, 2.056514404251769, 0.7893510010188605, 1.0862276986631176, 1.4402099842863052, 0.7191842323336091, 0.8048083461580837, 0.1061770410309514, 1.2199547738883243, -0.7792313105125364, 0.2905352459014938, 1.6327024147538898, 2.0685626127776016, 1.0597991013609949, 1.572118021111228, -1.1487115768438463, 1.0493434458380373, 0.6919835523286971, 2.020286293782132, 0.7145630549190843, 1.1181143112743754, 1.0874758924097114, 1.0920729025038762, 0.349967634889134, 1.9245184925435865, 0.4442239002672723, 1.2681829300490988, 0.38522622949352364, 1.6821523242767236, 0.5385550513841983, -0.7468907622223917},
    {0.2863239039467057, 0.6677358223989428, 0.4588265998729736, 0.7213271917134874, 1.13110178807058, 0.7242553247827246, 0.022336600373131565, 1.3383217560045098, 0.5585048591612357, 1.7843065108367961, -0.9074159404771382, 0.7523206115240136, 0.7592515520312515, 0.32869234003906034, 1.8867994607823892, 1.5998481484752565, 0.03100579855995465, 1.4152365807010256, 0.8865286151231266, 1.8754685545548426, 2.147805022330799, 0.5412498125917139, 0.9212621992428777, 0.4134800590521566, 1.6731667511921913, 1.7264451368538112, 0.7717620978596879, 1.7794172680132034, 1.8354978544017673, 1.6432833217402962, 1.3220379218351521, 0.8285211746188754},
    {0.42673722308618467, 0.725211401946852, 1.8993919355170834, 1.2143666919780185, 0.5299494487928744, 2.0822775119321073, -0.7169322829872241, 0.5677129012041229, 0.4230565675141473, 1.9885064046808616, 0.2124044274923084, -0.12822686034205233, 0.6744296599909713, 0.5048181032780997, 0.8905361970645539, 0.819201051668501, -0.07697850103627449, 0.8301109696565268, 1.8440178783235852, 1.2661239665671156, 1.5631040729833672, 0.5516288364732446, -0.035110950358855586, 1.350948501529099, 1.9608610272303983, 1.6986107613042638, 0.26427539100677055, 1.0786613847904594, 1.1845284531527047, 1.0161526192064951, 0.7967490260263799, 0.06410670980336236},
    {-0.3992564046053635, -0.11367268968698281, 1.9432406791599468, 1.3439389060425044, 1.1931972758046585, 1.957364116206282, -0.0413946751091661, 1.3496152395704024, -0.8974565335033642, 1.8426914346508698, 0.5083175465788242, 0.5226436827221261, 1.9944856510319453, 1.7666136871555995, 1.3861231381758823, 1.7687223866832396, -1.0813169458171255, 2.0841182382091676, 0.9686111322467128, 0.7713850164800705, 1.9803525974546956, 0.5189779551473734, 1.376617703173069, 1.6457327723240995, 0.24967586367785452, 1.9483816317304294, 2.1224708264552707, 1.8967837518400292, 1.026718392756393, 0.10236779580749289, 0.33298825725680886, 0.05916769509569651},
    {-0.20071276145491443, -0.9382275595551751, 1.8405144080732565, 0.7506401288191187, 1.4972282376272437, 0.9557225243981322, 0.3221653957013377, 1.3719291932654725, 0.685898674917152, 1.340298575339583, -0.2457760241496914, -0.1398552009246451, 1.0643187150049689, 0.4077556822133823, 1.2587250261180885, 1.935560579892831, 0.12501296011682136, 0.3683722143154899, 1.4875528600194114, 1.5404158651147095, 0.7308527869359094, 0.6773385534921503, 0.5763826297659721, 1.2499263151226687, 1.7029876481690551, 0.8074723024318633, 0.48137393556082425, 0.22454491694922288, 0.897736301149037, 0.8806186066852909, 1.3373972738742683, 0.14143010131281566},
    {-0.055549766297686605, -0.6801170169386974, 1.4354368620749858, 0.6827265871395236, -0.10908179039852482, 0.5785568008934325, 0.26002165331938415, 1.598453904887724, 0.2810851556090998, 0.9392036322798617, -0.2324601068452278, 0.4278106752969513, 2.1355471398165777, 1.6839952415555466, 2.1290552575434236, 1.0919044323485267, 0.5089364455089281, 0.9181660948555854, 2.194914130338228, 0.8590095424265144, 2.1320767929266173, 0.001322929149649006, 1.6837871319414253, 0.35445800155374135, 0.24770701671441675, 1.3982428681158556, 1.8409032185909326, 1.5619744693342112, 1.5345221948822412, 0.9728244817195234, 1.8645436492198497, 0.6444375498420168},
    {0.7185751612035302, -0.7267751427593333, 0.9017849368921724, 0.5684376736868562, 0.5012200227780866, 0.8858253412705847, -0.5180169890500941, 1.9060911726133012, -0.8253840586838097, 2.402604043971195, 0.8385184701775172, -0.8997090368004155, 1.939433575069135, 1.0732354732177494, 1.5723180955840004, 0.7758047070345444, 0.510959273524527, 1.3326293525277257, 1.2442302659194704, 1.2459056209875783, 1.0212755140112448, -0.12208509828244679, 1.5115930081485534, -0.016414920721944136, 1.2382075710664384, 1.2934972287920699, 0.8457268471921146, 0.7666844248540717, 0.44377233515238085, 0.5144425791216448, 1.110255983621009, -0.9761955617763822},
    {-0.9747073978742278, 0.40314037311155854, 1.722688021997459, 0.5202651386098456, -0.04916790246027628, 0.7667893903055858, -0.607911896345076, 1.005465272908169, 0.6499023672049435, 1.7017748493833613, -0.6314422151113146, -0.5486928131458182, 1.0857087348993275, 1.454486708847303, 1.9431843209714998, 0.6556069481751007, -0.6269492935578657, 1.4122999455663194, 1.7400937949833482, 1.7204081966963372, 1.2446888513868148, 0.2544183028343836, 1.338156389762317, 0.5276967071213162, 1.2968022552097886, 1.4352742326956083, 1.2673954042865954, 0.2586237694589019, 2.2928843940737638, 1.1342541674439, 0.7729863770398748, 0.22113268541110676},
    {-0.45418840155280005, -0.4294606145987107, 1.4088958820294468, 0.8886577742453475, 1.0600972371675204, 0.5794305325574484, -0.12412407356848766, 0.23555652449273692, -0.9356146705935905, 1.1523378626117398, 0.7159779683557774, 0.43154956291601726, 1.72192166756997, 0.3761726932404699, 0.5273105283947948, 0.9333812123700278, 0.7268969446046198, 0.6930609537867765, 2.251792575390283, 0.7171578123453195, 0.5797272523570433, 0.7593670667239223, 0.1379280318054708, 0.6143175257692204, 1.9889891161563595, 0.6828074213068881, 1.358194455941468, 1.2164046152395025, 1.2869494863842115, 0.3790546882274182, 1.1287251221120833, 0.371494180110711},
    {-0.4705555658218997, 0.6506854974771047, 0.439620442507492, 0.44363736691272265, 0.9239300292859939, 0.576608811590296, -0.18805220241203435, 0.9708869907533582, -1.05150550415585, 1.5673616680090954, 0.8169499535476512, -0.6358158006194602, 1.481200977505715, 0.437427527405302, 1.9496073241787752, 1.3843541490702933, -0.4404456816489834, 0.30721307006089227, 1.5665282047677258, 1.211005801238804, 0.8607014827907412, 0.053554413913642615, 0.7447178015377182, 0.44107685938394714, 1.3789848937491003, 1.818219218581572, 0.3827285905695564, 0.9697132074166915, 1.4333336344736691, 0.4878310952336035, 0.7062043459704068, 0.43883797226793747},
    {-0.7574797926629344, -1.0604099074301532, 2.2031633104052935, 1.6371369621153926, 0.5689325428454316, 2.053555899844, 0.21283773648318444, 0.30497716486780513, -0.692187411835897, 0.9329932724959599, 0.04337593946851531, 0.09120215104987578, 2.253903419482325, 0.37422564052833435, 1.090647645019962, 0.8285730161251317, -0.003593436137531045, 1.0933698837536872, 2.1124831053184816, 1.804104534276048, 1.0452610127560922, 1.3546673652729466, 1.6862116092220838, 0.7551883737579791, 2.150809263671159, 1.9687356626654318, 1.5671811038162204, 0.5867924211389696, 0.5049300588410024, 1.513778627125469, 0.44120416809365054, -0.6138215717032719},
    {-0.559462492204928, 0.29129064916660463, 1.6419659988541688, 0.9786058754049076, 1.4203792723779054, 1.7428721791781916, 0.15612407361078295, 0.61163772260009, -0.6474078984531954, 1.8414127370702333, 0.2955487023091634, -1.0489315475367804, 1.1092807903033433, 0.5800425825601556, 0.4936966428993921, 1.6019448462129502, -0.8082908036043479, 1.5021401522234679, 0.4256071419135088, 0.23090498061442663, 2.0303628227806327, -0.6195061388114821, -0.0838290972596629, 1.407831841724713, 1.742225549096076, 1.2257962070453352, 0.7665882616055382, 1.4259576264418525, 0.6436263843793032, 0.4776200968200929, 1.505267547504201, 0.5072553528020843},
    {0.4493108724474346, -0.2549019086570987, 1.6441754254237164, 1.3903185464012147, 1.759898328174159, 0.7548933194566995, 0.034117236798396774, 0.9563685597644015, 0.7381221278972838, 0.8531535002473315, -0.5542649582393315, -0.34995995435004523, 2.2160325344034537, 1.810329720764653, 0.7573408446640408, 0.8693004061347543, -0.9514337000964704, 0.6502616357026358, 2.210452571313923, 2.2087159310690727, 0.38696540110529243, 0.2531167531053709, 1.5085356015626086, 0.35011906130045084, 1.9007543695873925, 0.5380253413909369, 1.925669860020225, 1.652753400332042, 0.9677914470721932, 1.1518398052904821, 0.4296079320753454, -0.3757098354769784},
    {-0.445543557565501, 0.4896533736174996, 1.050503148110465, 1.7275896859996167, 0.12494943196441652, 1.5654930740379447, 0.13861285766220016, 2.0127416249730934, 0.4200241328599082, 0.3555495054648909, -0.7312624877219337, 0.3276134545615764, 1.6188962495252956, 0.8207243120274558, 0.9989250928550356, 1.6444763340064217, -0.968046785488014, 1.4789358904057204, 1.8315441093615736, 1.356443339073399, 1.2075888529684071, 0.6376269007333446, 1.7670865007253465, -0.12334963700632137, 1.1560043233311992, 1.5889109046931362, 1.8363662996414123, 0.4837460898914026, 2.0276466969516416, 0.3740712160529585, 1.3565965562339068, -0.8345849988790949},
    {0.5443303887775364, -0.19834109743141734, 1.960309386669731, 1.9727665378051935, 1.6015575768269217, 1.0384559980158443, -0.48981286420678144, 0.7733674696426882, -0.5653106526340468, 0.6444429157225463, -0.6214364276929704, -0.13270686284127403, 1.9495626635828112, 0.48197767690571164, 0.9835149454328089, 1.1258285873091776, -0.8058222574935796, 1.821374819209971, 0.9548684247587191, 2.159371459835603, 1.6307066188720853, 1.0355223710174757, 1.160577433659884, 1.3931323654001866, 1.8985768965611292, 1.6321995297810212, 0.3740706875989335, 1.6237618168844359, 0.4907899392450417, 0.5835914365199778, 1.4516359035253827, -0.9421520489644568},
    {-0.2635271128366617, -0.6321554915860499, 0.8295250531602227, 0.9532408995460688, 0.617004778499626, 2.0665253160249053, -0.06966515551217736, 1.137387249318569, 0.28379776972700865, 1.6196012688448387, 0.20302767470332103, 0.4428676755612252, 1.5229190947427125, 0.7335156078730745, 1.430714217102528, 1.062403000243036, 0.4569661675077839, 1.7560567356906391, 0.7116994031741513, 0.28901428684141334, 1.2287977577474893, 0.538714122568938, 1.3316622784665149, 0.8305412449804861, 0.8729502592844299, 0.868450161625678, 2.0952449588317834, 1.7828460636480503, 1.6995423027189662, 0.40943237600189764, 0.8328282660059586, -0.7441765820894405},
    {-0.35065108307350734, 0.6185426168459225, 1.4773828632869601, 0.49517650362497917, 0.9685808025765159, 1.0299834060454471, -0.26468341239984283, 1.5051279532155657, -1.1050350533478526, 1.919956860028974, -0.41040439592352174, -0.32569863123136944, 2.1397386756906553, 0.2988564987126512, 2.07096850458726, 1.5447269446888565, 0.48899075843729306, 0.6629946721651461, 1.9250699127126314, 2.1450776856020095, 0.6650292917207942, -0.054873120741405226, 0.49164635823727326, 0.12837678611098033, 1.8780710930018474, 1.1583596019477667, 1.700027857039331, 2.0145137203062196, 0.8632145585596318, 1.856914129886041, 0.2470037267670171, -0.47497530316690423},
    {0.5933327068786802, 0.7695503559024164, 2.2120039334085737, 0.22054805840786293, 0.8607411739670497, 2.1014920745594803, -0.5125273103283267, 0.1835297248605254, 0.6269978615342566, 2.3436602459396783, 0.08924040590406775, 0.11486942859969095, 1.2913482219250432, 1.4603465770569088, 1.842357159663799, 1.7356518551558349, 0.41246891744363856, 0.6753883455389734, 0.48493795372997145, 1.0097427848088802, 1.2375681811731318, 1.2831660693054403, 0.2522895311064324, 1.537194956962365, 1.6121828655613442, 0.7512540375135637, 0.5025461489066868, 1.9978441348145017, 0.7416071834060477, 1.484522444264936, 1.9585922163384433, -0.048446572845167145},
    {-0.20819876636792128, -0.002013248462323231, 2.1259917746979715, 0.3046303233158243, 1.2153417033170737, 0.7563349483924253, -0.9079296849081118, 0.34379874270128624, 0.3459012925878348, 0.6896668950601591, -0.07604667522800487, -1.1316745071547676, 0.7203774515930746, 1.4175737041488852, 1.7475580621913664, 1.548432718771076, -1.026200051218881, 1.419436477880515, 0.568549848512953, 1.9275391515149236, 1.1390594860350303, 0.36693389960459905, 0.1264122333891837, 1.440687102383601, 0.4615459805677454, 1.8926426142849733, 0.8253328543861861, 2.113127413333956, 1.0383855822510526, 0.260208408533721, 1.2108431386560248, -0.8286171705880279},
    {-0.6655254810846063, -0.033931115912491185, 0.5502538038441569, 2.099735346135937, 0.2353312786859352, 1.1748155115616994, 0.2608508427082524, 1.0878014121215924, 0.6116905165791457, 2.2030297328607817, -0.016810796974579267, 0.007383803589603647, 0.967794701216753, 1.1482500063724477, 1.5850927009487996, 1.9885506211388768, -0.10297269680416855, 1.303192002001652, 1.9540212500005232, 2.129376525301008, 0.6411857684121791, -0.45545290166033015, 1.2993087533492966, 0.315016188332117, 0.8850613009494619, 0.8042418634367863, 2.006439658771288, 0.6974091956031483, 0.9145608252648292, 0.5439054805887259, 2.1332920097724912, 0.41103175570858946},
    {-0.29032695870037645, 0.7995440039805196, 1.8666550432312687, 0.2839577802306924, 0.7331286930477301, 0.5135819544944855, 0.8513648019404766, 0.7974145326819013, 0.7718262836862653, 1.6314412648411496, -0.5066091782618019, 0.38032881736386853, 1.3930916758420018, 1.8717738025663322, 1.8918117129409178, 2.068242639038863, 0.4575448748787375, 1.2245609195635592, 0.699639294250784, 1.086763478011804, 0.9251612736970963, -0.332130815884295, 0.9289041277053645, 0.6876659035433972, 1.8653060842814833, 0.710195528943758, 1.851811487655757, 1.9913550395256046, 1.8399804008139773, 0.8708694277018381, 0.4928087497244951, 0.35781212474672325},
    {-0.27595727052407737, -0.43853844676534254, 0.40845611256956943, 2.035494889110232, 0.9399668264393288, 2.0251186300852835, -0.5581045587448413, 0.6430362301465612, -0.6367949364146203, 1.6516359818152782, -0.43117982031359275, -0.6757328494598996, 1.1474018413481208, 1.1541636432800917, 0.7972312674686001, 0.8256013274950651, -1.0045608085481774, 1.794482581153311, 1.9441460231790948, 1.5399768279289658, 1.4832000659670497, -0.4118699696984705, 1.6313965153596381, 0.47772759844987883, 1.7660877793634284, 0.6902416341767048, 0.5417166524642016, 2.1087401969914636, 1.4198383018866905, 0.5119698750264887, 1.227018895769473, 0.04570991608362142},
    {0.5856151496156672, -0.8562504339070109, 1.3858232810756013, 1.6459865128046964, 0.049910990430725034, 1.473121564573024, -1.0095140834266265, 1.3603690453144417, -0.41088948562117417, 1.959217132334012, -0.8123904589135081, 0.3278375420687352, 2.0550017848932685, 1.0980607960291366, 2.2355824316151853, 1.8412589528924341, -0.7251952473561846, 0.5151273311232842, 0.9207440819973219, 1.591086814951812, 1.463942144134539, 1.13025436840027, 0.5870163028222538, 1.4956563413401098, 0.8310198717252611, 1.3528044041372296, 0.6178258987212792, 1.9386672083881822, 0.8808387793396412, 1.4618990502793212, 1.7988569319814889, 0.4447940149890034},
    {0.13653338526861045, 0.14342343846226002, 0.8812144292954771, 0.593366532177578, 1.2304266092784126, 0.4783702017819723, -0.025786739824032824, 1.3923623520914274, -0.3748961128283575, 1.8363092662332887, 0.7395220933369125, -0.6746357714416128, 0.9030234466580211, 1.066570068452212, 1.1796002737383688, 1.4469338309563555, -0.8616972173223897, 2.1394916658539556, 1.3678499990365405, 1.8855290013216657, 1.4660954658684977, 0.40296701558303316, 0.7859313265930065, 0.6104102621766239, 0.7712217345047716, 0.6288168240364685, 0.9789091434922875, 1.9855730249646473, 0.8036270401961675, 0.06357372596770443, 0.7669644136694733, -0.24890527260555878},
    {-0.048036074445136225, 0.14839699378102947, 1.0342784252988084, 2.0732072289792582, 0.5676077245232827, 1.9070236418711548, -0.5840218011245989, 0.07608431935681412, -0.8084086786256022, 0.8439685346385587, -0.5273908446992219, 0.29898986749378964, 1.3539756758315769, 1.96628524606044, 1.9198163460267468, 1.5853570069330025, 0.047088125276753254, 1.0750790037993316, 0.8337302286831626, 1.5023034297785647, 2.0347046183946507, -0.082368173926149, 1.5770976587063574, 0.6365406504720031, 1.5336613091694378, 0.3762440575086204, 1.8067278425529243, 0.4803232167849005, 0.973595728674621, 0.6031683301169687, 0.626413849652781, -0.3066318950818543},
    {-0.20173188249313254, -0.45977227408052046, 0.7833442749003432, 0.644545387163717, 0.2327663357480708, 1.3978402895767639, -0.15662846448626958, 0.45361975680881356, -1.0021365483502889, 0.57234740234758, 0.47853482574647216, -0.672365207976094, 2.033952569499074, 0.5016652692763746, 1.7444788839421845, 2.1121485662909483, -0.209120656197663, 1.3042423538235095, 1.6080339992877815, 1.196103604500613, 1.964962183481009, -0.22307897985982378, 0.812868605610839, 0.025070418294638724, 1.7970606990253437, 1.7448424382125989, 0.19963383554098568, 1.8146893398950328, 1.3115927617916596, 0.17019833222877895, 0.3324567902425805, -0.4210628289687772},
    {0.5598697929003252, 0.7853046860423657, 0.24432068747080746, 0.9119215639305724, 0.5916428736403483, 0.4711861579877698, 0.8687650337905439, 1.4441261026992038, -0.10146326566965744, 1.8935299106155012, 0.627814670736937, -0.19220327885705177, 1.5767408245400851, 0.6819741771923705, 1.7280604443364982, 1.9670707215878678, 0.5747887184364391, 1.9827572027330784, 1.3942677331623696, 0.6535928848301948, 1.257409237779075, 0.6003250935941499, 0.8005955411902563, 1.0268259390791794, 1.9027795757856, 1.1854214376219867, 2.1228190124602127, 0.2633736121336917, 1.9615550163942768, 1.0021147200158058, 0.48540035177279983, 0.04757348271596057},
    {0.6563851081711158, 0.4201835750081359, 1.1124943217277783, 0.7467845468842922, 1.745663221478466, 1.9661637807714392, -0.10659624310838615, 1.5025599023925122, -0.4054135313573137, 0.8722481465855714, -0.062417346966569934, -0.023031630694320238, 1.720897145684904, 1.3577648509306888, 1.3137514256936602, 1.154069872781096, -0.28780314356030384, 1.4656309495956845, 1.4607595790921017, 0.5028517259816095, 0.561880976945267, -0.2221368000534868, 0.16189557220453252, 0.371541004326818, 0.8383746562901487, 0.8519666625481346, 1.3619252895059062, 1.0838596420511326, 2.1641678159663367, 0.8576053123828902, 0.32370350890981986, 0.7048677018544073},
    {-0.36914675754273185, 0.4457651587680883, 0.5982588558792168, 0.544035586091828, -0.056527978685179676, 1.219435572029462, 0.05408069692505788, 0.43734324815065845, -0.7395877652215299, 0.47265539439415544, -1.054152276759927, -0.28771342769033026, 0.6156272599592012, 1.4997073261375962, 0.5419413967223838, 1.9244340366155153, -0.45854445133392063, 0.8905119307496969, 1.6978871247925273, 2.079740463547407, 1.316747788536427, 0.2184958383885844, 1.2504261790813427, 0.6969029078694595, 1.5488913670694726, 1.7005218565018754, 1.5362536627866257, 0.9158539400849337, 1.8802987036409178, 0.9671894690582028, 0.32391635349032033, 0.43617084360776887},
    {-1.071707743051925, -0.6723656903669387, 1.4516992805684166, 1.2202622411746495, 0.8958689551293074, 2.068689846469107, -0.2049504737144999, 1.4347158977239167, 0.7272267846870765, 1.6705992526980031, -0.7690348562415841, -0.96603350204929, 2.118997769491751, 0.45603734914349847, 2.051100624708537, 2.0547101301689885, 0.17387880926310023, 1.5876201400216634, 1.0065228339658234, 0.8406195950914155, 1.8203585703865328, 0.982495962932599, -0.03262651680711219, 1.4352400394234874, 1.3195507857724922, 1.6326499348892154, 0.2785244967825517, 1.2424803490892695, 1.9435006669800803, 1.266065019673257, 1.090604447490683, 0.19762070442873916},
    {-0.8244687770954279, -0.2670530210605158, 1.8291515100593088, 0.6819961104214757, -0.10184544665537125, 0.5042355732515231, -0.7116898545177553, 1.1827898187374197, 0.1380563956096968, 0.8508895419146882, -0.6401062029460659, -1.1234530180013407, 2.2966476056584173, 1.0422832007816238, 0.7241609996136719, 1.8625480843095301, -1.1770098000900684, 2.0488290771577065, 1.5644999887057505, 2.0546888544190676, 1.219929728235023, 1.2835298862723241, 0.03807966851668227, 1.6209260871237328, 1.9943930421699423, 1.4142114298993298, 0.6574146414943776, 0.8284287808358122, 2.187667882555486, 0.9421745259395596, 1.907314882802481, 0.41995328496952317},
    {-0.6681087016536704, 0.01844843509946349, 1.8226779740827537, 0.37230365851027364, 0.9908267834049334, 0.8019669356350816, 0.017015532275563364, 1.5644584103645265, -0.29241228739992986, 1.2634697583472803, 0.16160195870419458, 0.4413923486474813, 0.5488709947232008, 2.018617307892297, 1.0921797314336141, 0.5145026791535375, 0.1509799235767972, 1.3221639493406059, 1.5946696069999462, 1.2952026142220465, 0.3292522929294585, 0.49177845024843386, 0.9840865847113566, 1.3372228529094559, 1.7329132005403791, 0.6624769324170445, 1.5500368798193669, 0.9334534997772274, 1.238144194733067, 0.7344331751755605, 0.22219835385947775, -0.9051389923850055},
    {-0.6041703719616996, -0.5645741376187501, 2.111428617223232, 1.195510990838439, 0.24586698365911713, 1.68701589490604, -0.8673917960701777, 1.7310735678398836, -1.1695332573483512, 0.8336671688430068, -0.01351848851281587, -0.07368147612389814, 1.3908655805668941, 2.032248084631877, 2.560170062942117, 1.2077219458235695, 0.3877457562000301, 2.183857142909096, 0.7194231349308935, 0.3766337675875191, 1.4468188143737568, 0.19568559446365674, -0.01989415616301188, 0.7249233012915085, 1.7451716737435339, 0.6999265624262065, 1.4555713945237383, 2.0458787095292226, 1.1942599070634803, 0.45138678274997546, 0.9242995515315277, 0.6594445555744604},
    {0.47321616969146596, -0.12382485794337258, 2.3208382213556806, 2.0082775619863487, 1.5823323998825767, 1.3170140130132475, -0.03128754386148242, 1.7145654914749116, 0.5945733652546683, 0.6405530310742602, -0.3901500139975937, 0.12545598548415077, 2.3364195264412118, 1.8116843963091716, 0.8633015453266888, 1.9712091511453644, 0.31776212287728106, 0.7798732663882623, 1.5255648192825475, 1.7298140114837097, 1.5951234527738938, 1.2446730704109237, 1.792406735566392, 1.5534724570569773, 0.7468966038523387, 1.3813527564027726, 0.8746185328000344, 0.6888185374536612, 0.6492190233828935, 1.7101980333822777, 2.260099506408904, -0.3862204199658578},
    {0.22319798024987142, -0.764247254207479, 1.3187074508325929, 1.178029833631236, 1.4265786048761386, 1.3995885748477794, -0.1332664529829898, 1.9677440610936172, 0.5318020496427718, 2.3006978629480996, -0.7021227001811645, -0.4874843333176612, 1.3505854482641484, 0.6459301272447023, 1.059076547023058, 0.4567517814161747, -0.5395851987408856, 0.7168462236244322, 1.6964181372380458, 0.3313788777028723, 1.7135341195016514, -0.4497007350500962, 0.22054894835000274, 1.5858706097006554, 1.098502659734644, 1.1161792018542662, 0.8679849713521353, 0.919216085603563, 1.648963308835773, 0.6518186433465573, 2.1317486808868815, 0.8152818674959195},
    {-0.4045321258128981, 0.32274260160213564, 0.43851246247002174, 1.0444165598954573, 1.4604258147475149, 1.9123334799449074, 0.6826830039167737, 1.136744900163401, 0.07914626074680832, 0.574038984653184, 0.4019561581488408, -1.0906764975692251, 0.4302685898381989, 1.6351172216167458, 1.9647150605525197, 2.053405144695411, 0.07170842889334632, 2.323576368697957, 0.7364085976443699, 0.9670003836548777, 0.7037278315550302, 0.17572111417461192, 0.49857471815693616, 1.4101617583733312, 0.24765370113238552, 1.615890814155326, 2.0099783697193843, 0.4964152817046976, 0.8306684941817544, 0.258244831294986, 2.090168284538854, -0.3683213990282688},
    {0.5796031419512206, -1.026040033448, 0.7905165552438113, 0.9636419175257243, 1.0116712732293178, 1.7797720574694489, -0.18677579673936234, 0.9003883837128815, -1.1763841717841252, 0.8217836921921103, -1.1310299532846424, -1.038464646907318, 0.6013190882136819, 0.988133862180639, 2.407150136436097, 1.8927740080204851, -0.6622622850026115, 0.5061266841623547, 1.8322348019360022, 0.8302762758376369, 1.7652686138990368, 1.0504300650339549, 0.08457898621370152, -0.21795916114815844, 0.1889407947756127, 0.6395473850694489, 0.8804765586756418, 0.37884134700424227, 1.8497174090659463, 1.328200345136437, 0.6974032264016574, -0.5679821269283252},
    {-1.0711663356857992, -0.8092787874947119, 2.0090851897508855, 0.3096750913104644, 0.2726874913139609, 0.9864832959621136, 0.6954971860574798, 0.2804382199608178, -1.1174837608180475, 1.510092463690521, 0.389177639892437, -0.6121614456956225, 2.151328668891143, 0.8267068797034179, 1.9889126496256715, 1.3117527370218796, -1.1660397595756862, 1.9294095963108542, 1.6543076822046767, 0.4051854334833017, 0.4530900332082831, 0.6159717964050598, 0.8636067547079658, 1.2855215501972816, 0.4346354667316543, 0.9668943119477271, 1.118059509049301, 1.7741700612191829, 2.287984326987134, 0.7412996470197426, 0.3576139352172595, 0.13823887222063205},
    {-0.001950228642471798, -0.7260894319696344, 0.48051918057555576, 1.0728639157748536, 0.16106664392097508, 0.4095236937841851, -0.8502099836730749, 1.4226386779045592, -0.9631826552059843, 1.9116028956730169, -0.8737009445086026, -0.971011017829564, 0.4897012512438778, 1.149670146466143, 1.6348998132690447, 0.6560844106515412, 0.15126098588591425, 1.0762013913509543, 1.1114723754600724, 1.866588845497204, 0.7336932057254082, 1.3997255793532823, 1.391705662584278, -0.02925913424432092, 0.8269076001897501, 1.7428731522928675, 0.7480157889573433, 1.5178420970317437, 0.3382272533587332, 0.10150056055447661, 1.3004104908010046, -0.9540105175428698},
    {0.6262493537318562, 0.7092952341471324, 0.6407182251731953, 1.4153902295514542, 1.5928220747727146, 1.3068038962387374, 0.8059866452171759, 0.6451289613449345, 0.6846066007484837, 2.0868499395471365, -0.02618478599050419, 0.23613761083496917, 0.9178595044595085, 0.4838047832245006, 2.3406214903190086, 1.3449553235138176, -0.3434195674114176, 1.6114550405079255, 1.245223371025303, 0.5395751019248269, 1.046354398269195, -0.4944810659667011, 1.7832139223852328, 1.064432411678685, 0.5039999379603839, 1.5582049102745248, 2.1450722574081027, 2.016779586884047, 1.9694598579467184, 1.2147837592689767, 1.0055500196006386, -0.9366150854652081},
    {-0.9328935526750779, 0.04665951046804031, 1.837710050335011, 0.3997953820723974, 0.36469342184124676, 1.981033455542108, -0.47123991458376296, 0.7484030561521017, 0.4718271044881155, 2.041833487787336, -0.4766865497950715, 0.6806593721104838, 0.9338789686046353, 1.339573379396881, 2.19597490968937, 1.938567881934079, 0.2623750791869345, 2.0731471530335663, 0.9605662294335388, 0.8621067005213903, 1.8941949295098286, -0.2313187874647474, 1.5787170417422858, 0.6853575658092665, 0.8677444665263305, 0.8290205443063665, 1.1878231798793446, 1.5206736493950825, 1.9297761599109575, 1.0431662669989332, 0.523352910036594, 0.46408967406981805},
    {-0.8162127647977394, -0.4562234628131349, 1.5210787660999816, 0.7110268435182768, 1.0255354971592574, 1.0321231037278273, 0.3542868015386965, 1.5349858732591293, -0.14071889129866463, 1.5210783172845295, 0.6512010863960866, -0.584480816495678, 1.9088831163833322, 1.4051510619389358, 1.5490507075695903, 0.38085653120612795, 0.6426632280724495, 1.7692916906459497, 1.1945109541525663, 1.4952139849471737, 2.198763406134231, 0.7379687286468614, 0.9886890716662279, 1.3717508758263404, 0.22840960866555415, 2.0178492101714247, 0.3723706180050504, 1.5310309097792385, 0.8247462874511929, 0.8189151173132035, 2.1804372569570813, -0.8684701014590543},
    {0.7171737916012041, -0.8826114560416879, 0.2786683379013639, 0.21231767352700573, 1.378461632210106, 1.0445172285213449, -0.2896333289520524, 0.25752943385448435, 0.23207379035016293, 1.0713475442742622, -0.25691425181016747, 0.4663658901500487, 0.6693501231238191, 1.6837709870092445, 0.6366330746219817, 1.2306855334175721, -0.16067945520152999, 1.8298713421549984, 2.035323648915488, 1.431897943451072, 1.405102281859718, 0.6225856842026528, 0.48155443048034446, 1.4393243830507296, 0.9128325498993576, 0.6583957355907413, 0.4366342605649911, 1.4035543008507345, 0.9091832931746174, 0.16675811990445036, 0.3644309500164406, 0.4370783091256342},
    {0.5939537620009815, -0.8059546448132807, 0.5836488514407534, 1.5297259953460354, -0.004073771308443424, 0.9167482772847251, -1.0197227238672613, 1.3564290322705235, -0.08675509843807289, 1.27759631211699, -1.021664906515946, -0.17132973668667706, 2.2020394012052162, 0.549580312157779, 1.2389560504321555, 1.8830245916607748, -0.443729053204552, 1.1904241881313713, 2.0607250240586117, 2.0850811104814597, 0.33280549003647913, 1.2192679205241552, 1.605480238257829, 0.46719153677301023, 1.4533102272777825, 0.37785068289334345, 0.48934198739575346, 1.9821439018430203, 0.8052171777426123, 1.2628342336311116, 1.4863410412485656, 0.5640681006398254},
    {0.09246740212766934, -0.3473497276869256, 1.5717158344131872, 0.5808466662196813, 1.378123833797222, 1.3241020014062002, 0.09841059400885167, 1.5679016685339817, -0.9245773842356393, 1.8486931442852717, 0.35373409713024684, 0.5589570687562138, 0.9758880451829651, 0.34733789794835895, 1.3010826510671276, 0.9809353352290794, 0.10460951442310905, 0.9680628819664949, 1.715105330636289, 0.8900630721508336, 0.9222569027230701, 0.3312312399585683, 0.7200182611863762, 1.585733866773201, 0.9198788085551002, 0.3008724319036116, 0.4827173518468226, 1.9140191406009202, 1.5525098017241283, 1.6756176098423656, 0.8671850496753328, -1.0821009374964425},
    {-0.691324056610239, -0.9986562429052736, 1.903728519534778, 1.6283037812791146, 0.14246330717095884, 2.134226316498988, 0.39222969072132147, 1.0634299292068359, 0.4984271184872158, 0.8458119499006648, 0.7901684333229012, -0.6752533939077309, 1.01098322362507, 1.937070898691239, 1.1351628345576457, 0.4480128196988229, -0.6374533989360003, 2.2781494920706735, 0.8985864441858867, 1.86761667095708, 0.6605365446557632, 0.02547887113834346, 0.7576443731823531, 1.5736044102718973, 2.0023814510474605, 2.0256627504389932, 1.9143314346543294, 0.7453390916337059, 1.495886486845693, 0.20627124261866955, 1.1493651240870189, -0.2901547456605788},
    {0.33131994508134677, -0.37272283907841486, 2.0830560034293932, 1.9542017064360284, 0.8330265569422747, 2.062656120994625, -0.9341363456997965, 1.7056185667801216, -0.2777043028387514, 1.7269711523110678, -0.26872267962287416, 0.7019335174176242, 0.642702662881973, 1.8754893470076375, 1.1106177113106122, 0.7916875709539841, -1.1068470505358956, 0.9733315078126006, 2.3311867149585175, 0.49969964295885383, 0.3775093388563787, -0.2925451463507015, 1.1687744403296159, 0.5496136081384256, 0.21737035682577255, 0.28511458226637737, 0.7882794285600779, 1.5357808066492828, 2.0013823071642194, 1.8630731771117852, 1.5777578373865961, -0.9331013519396157},
    {0.13680106639907152, -0.4658725235373695, 1.312155019771673, 1.093866557753903, 0.6655985602689773, 1.2735441759185258, 0.24678008985634925, 1.2370924582422584, -0.48036595280740313, 1.881047207408234, -0.30383017783542143, -0.45665767863359685, 1.953622935754369, 1.0727888483293446, 2.301785406159175, 0.9524772352697397, 0.2011762042394956, 1.5846956801981957, 1.8362935900408839, 1.0537922053791415, 0.4739470342839767, 0.3789169128445551, 0.356712656394023, 0.0189294953265603, 0.7984278647201676, 1.5971457903957103, 2.083280589770665, 0.16725544470940362, 0.38309532902459464, 0.014380263871978305, 1.091008722547663, 0.6483283348306509},
    {-0.6698681334306394, 0.6887648178305631, 0.5616716540978441, 1.965279187785021, 0.6420272897867727, 1.2683194378278988, -0.5073589909714696, 0.2238842759728982, -0.8184883651804766, 1.7141769015592532, -0.859563164442485, -1.0443703508349478, 1.3770527065385096, 1.4082445543808892, 1.5720847170427747, 0.5743955796268254, 0.6768146301865465, 0.6836815705984837, 1.8211413007054873, 2.137570701701161, 1.0956195884832634, 0.7265861451722508, 0.5913489424964337, -0.15526307323360833, 0.5455511099364665, 1.8551455829095218, 1.7337079471491355, 0.5402075477058039, 1.4139849855437094, 0.33279313364406304, 1.3915025538186596, 0.5451252474544006},
    {0.424583140398553, -0.28844968164162127, 2.011104853905952, 0.2797160248268691, 0.035808735032525706, 0.7060334953579243, -0.3765939562691956, 0.4380472293422981, -0.28416598223551526, 1.8166834028084298, 0.19565001535678556, 0.23057175159691684, 2.185462045296017, 1.7099409506360317, 0.9385012780796975, 1.8364449064453094, -0.3545405731437286, 1.246773770006761, 1.9441833969744993, 1.6740847637573695, 0.9765363671277681, 0.30120595595010263, 0.8448255614301543, 0.38667355525608493, 1.9285743999210914, 1.956177791545098, 0.3172937401910517, 1.3965933584419319, 0.5375390084166505, 0.5035099191141141, 1.6075829750386288, -0.2362148531544238},
    {-0.47846429757968617, 0.7902343521183463, 2.0517188799658705, 0.8736224840442248, -0.1689127761255659, 2.017174678270537, -0.01378146283707067, 1.1820618909817804, 0.4788639171738048, 0.5177705747986164, -0.2078721100745501, -0.5514100835631305, 1.0239378016969856, 0.935277796658517, 0.7442691863728039, 0.5060944536640295, 0.08356701628665646, 2.1553917070071646, 1.0678351637382104, 2.153995139027777, 1.5655145353110067, -0.015548934666953024, 0.3018560994106632, -0.09700461040173698, 0.41109409352902526, 1.3038251578738063, 1.9167460669914709, 1.7976400322906456, 0.7663698770045844, 1.1285702896914158, 1.5925382226833629, -0.5074314961628453},
    {-0.5202003400015845, 0.1054748703710201, 1.8787054811312758, 1.8188734637209405, 1.3490366310150732, 0.5179579037807689, -0.7179685203798495, 1.812911045390831, -0.37327320868563446, 0.5456695149048507, -0.5317387123099528, 0.560109445311068, 2.2657294783524025, 1.317042592569461, 2.0831062755923755, 1.3220626647305627, -1.1180059646053837, 1.3152070030188878, 0.49889035029971823, 0.9173841404749447, 1.1675541375916327, 0.9012945870314648, 1.021785785174796, -0.2421192940429729, 1.7927383258224245, 0.21624345570771825, 1.3174013751979816, 1.7397749843115848, 1.5330466669551812, 1.3675163194941167, 2.1162673562657552, -1.007727818028807},
    {0.16492638943989074, -0.22745853004040648, 0.9565202335041947, 0.2513547579817996, 0.02673308616386339, 1.98388219392348, -0.581450587890158, 0.3404578090366661, 0.23238642378775523, 1.162095262738262, -0.5154491973392448, 0.09088957053763788, 1.2301163287760755, 0.3959821083110499, 0.4719174461096875, 1.883729664556985, 0.0420017015006144, 1.213231850022077, 0.5785244642810783, 0.7643739899589909, 1.1409817634729098, -0.0578458411162652, 0.6800955494720813, -0.2623508877192604, 0.15586543147290297, 1.1213419563371658, 1.8627713468459217, 0.052411641335422005, 1.5541510679473678, 0.5859066383912048, 1.9543383874462816, -0.09330676045335955},
    {-0.2497093008186725, -0.7905720888452308, 0.4742790347855171, 0.7528527451726171, 0.7749516654193758, 1.403240880103248, 0.6905544501978212, 1.878887415216165, -0.4042742766152494, 1.0975955769191537, -0.26620589312317605, -0.24768796747442517, 0.6157547942422699, 1.742232823476066, 2.3943374781068445, 2.1252730746405653, 0.42229363518890445, 0.4075879517026913, 2.2726017669877736, 1.4072342449310191, 2.105190247539327, 0.09513862242833444, 0.5834930036782464, 1.6201004411698001, 0.640676136761408, 1.2350682714121228, 0.341269556750479, 1.0590568966726814, 1.2798203687407024, 1.6850499891351185, 2.0061539948552114, -0.1151380883067216},
    {0.6021850817045356, -0.6248797554536134, 1.8469837712677926, 1.5193747119157897, 0.27973546794550797, 1.3563329400309294, 0.0593446423168528, 0.6737760051969465, 0.40491093232185593, 0.6375498728602995, -0.7698004303935523, -0.7009515083012302, 0.43966469976637057, 2.1660982868549374, 1.2183180504702746, 1.819608103666648, -0.6326968907297683, 0.5834198131178348, 1.0540269010630843, 0.559619177825822, 2.01439723363805, 0.5733162366497996, 1.3000606505186865, 1.643612538489634, 1.5375131564233506, 0.15436142498433778, 1.6202009237517079, 0.8110327851296155, 0.7849917414711858, 0.7158865429838452, 0.714031186024301, -1.013381843340832},
    {0.2912335005439143, -0.11250279466913482, 1.2556896305019862, 0.6923960033763242, 0.14654442354018568, 1.8109587403552099, 0.1897574800691974, 0.9187375979373021, -0.08395052136770395, 0.7366128525641987, 0.6540799402936723, -0.7056949093168124, 1.3763822644541093, 1.207675786084768, 1.957635502216786, 0.7418914218948724, -0.2866024195149478, 0.7827370623816498, 1.8281777103756647, 0.7617776377145217, 2.050556760765282, 0.9592184883880428, 0.27931511841042883, -0.2531287995329699, 0.7776643138594173, 0.4866881086121728, 1.0317906293676415, 0.016109799822367675, 1.2200210104949338, 1.1315801975867152, 0.42781489261601074, -1.1442233605817638},
    {-0.9087134441057426, 0.6360769757365191, 0.6940875576038886, 1.8598350266456678, -0.059368256788791346, 0.46203481068662355, -0.8346928857705618, 1.0104858203759193, 0.020288346900274777, 1.7119993235010798, -0.7426823271663731, -0.6927949106764743, 0.442108748477626, 0.9331599053159281, 1.870903665883581, 1.885421595585271, 0.6779411740679456, 1.5343850202594298, 1.3559977951066429, 1.7814718607806317, 0.4229326590661932, 0.48907473569853477, 1.7603521174151622, 0.9017476999780379, 1.3854852545190048, 1.9030541849076874, 0.57845434367306, 1.548091437853825, 1.5938085251171625, 0.7467638089001718, 1.2127317198950531, -0.5435496247502282},
    {0.2565643499289577, 0.19204971299812498, 1.6962366966635336, 1.8823333370234763, 1.797837538528547, 0.3509121799013043, 0.4035438664483278, 2.065508004945415, 0.6770315804499937, 0.9213101974156092, -0.06232162990853404, -0.38781046525565027, 0.9162664921713556, 2.0179631064682115, 1.198891994007572, 0.7375575283885824, -0.7534437451991114, 0.3506847568006796, 2.0573527213662106, 1.8890329614227013, 1.9517927127972818, 1.2016341429273525, 1.087986061174921, 1.0758085320329318, 0.8275640293730014, 0.9750194107777108, 0.7116697524380821, 0.3926503445025571, 1.9713290619513624, 0.8060987072692127, 0.3414245096473746, 0.19112201538872012},
    {0.7088858478935046, -0.8940397774823605, 0.7001550681045865, 0.663488701475695, 0.06944266889648534, 1.8006892332052427, -0.3592366159969254, 1.7309581912304268, -1.0685256342427174, 0.8654622804981282, -0.8953848593866179, 0.5199039078502803, 1.8021344454784056, 1.9574296759192107, 2.022757346466154, 2.174239025382027, -0.625634171483271, 1.3570791133113118, 0.6638396209207481, 0.7770381570555827, 1.5592442234609396, 0.7440083595604083, 0.6878105227994616, 0.5426905343914435, 0.5058083285223871, 0.8468419777209893, 0.8529941655787467, 1.237047157568852, 0.8276295918375374, -0.07007504814186465, 0.7026956258195232, -0.7289133487314459},
    {-0.3040423177404797, -0.8170096905881318, 2.1346526795511997, 1.6462829900729343, 1.55851171407461, 1.0109770413282473, -1.1128444014517185, 0.529221906238256, -0.058701866947331, 0.8130415994278557, -0.46310477784548587, 0.30757079292683503, 0.49531099872817014, 1.3119139438492504, 1.6890500782338345, 1.232206026340577, 0.5683880819892924, 0.46240398666083504, 1.905157725598446, 1.8518497433528254, 0.4276026001373491, 1.0257585445388335, 0.13282739738550264, -0.14365078033547538, 0.2015615511140252, 0.2348543745746883, 1.944346596867758, 1.72836209701122, 1.2270267939371908, 0.8653083300627713, 0.4539393378478627, 0.7788226697380604},
    {0.28204335319624835, -0.2399580067787512, 0.8252636395924268, 0.8142567723933223, 0.18432698357062213, 1.445598489492659, 0.4383298576819226, 0.34025585982432066, -0.4878657920940376, 0.9182165628492168, 0.6970050497699356, 0.11026659720391183, 1.720178641502676, 0.8709249682994782, 1.409232891730953, 1.4461276212379475, 0.08404659143433996, 1.2255591882360652, 0.8112897859608644, 1.7262528641984187, 2.119086144933376, 0.11734651266558804, 0.40298209632810394, 0.691753318743665, 1.748983625431078, 0.9358531393051335, 1.70279294637642, 0.8048434243724869, 1.9747038996700406, 0.24996875419029585, 2.064342977495183, -0.7603461536005982}
};

static const float b2[32] = {-0.1951225780414338, -0.1863321226328645, 1.225417139871617, 1.30262738066006, 1.0157426147731565, 1.1481550501326014, -0.15827103210350663, 1.1454115374256415, -0.2493713698045709, 1.3721686487394176, -0.2488954396257591, -0.34196442503852237, 1.229087878671538, 1.1758571631769632, 1.55846061539988, 1.1919739795139495, -0.3455372102680223, 1.2795624994981443, 1.4034481472130995, 1.204704579569091, 1.3497819084347586, 0.3240021279410736, 1.041897527477555, 0.7529639339976799, 1.100980195856667, 1.1364423721333363, 1.2492975013272858, 1.0553376166356594, 1.3785708002195411, 1.1407482200741557, 1.3665765662693812, -0.22660144111814226};

static const float w3[32][16] = {
    {0.7310288254650338, -0.6218642734957996, 0.5265927622257689, -0.41496829225787, -0.2746526585216679, -0.039869940012367225, -0.04954031615621246, 0.8198583850390397, -0.4173430713996571, -0.886254723205802, -0.7374987266355099, -0.6073629949865992, -0.5774771879841185, 0.610238704150352, 0.671333925074589, -1.076740668075853},
    {0.8557596869023235, 0.43938101293934284, 0.22817702812002505, 0.5296673638032945, -0.033499499961805394, 0.09569923238880387, 0.6175544901941212, -0.48424602007188083, -0.5641480159881592, -0.2858939528028001, -0.12989452006970065, 0.7680104174052579, -0.6430336264992352, 0.8478371609357582, 0.7913855962886864, -0.2632224713346624},
    {-0.31424390177811545, 0.20834691005656647, -0.4133145094291754, 2.487979027610175, 0.439316971242266, 1.6902597070277792, -1.027017073057581, -0.7920419530675459, 0.3508011858105691, -1.138482790365836, 2.062275215452788, -0.37584303866721464, 0.6568102355505131, 0.6152632244543494, 0.9720539082422887, 1.6652911460978717},
    {0.8085099809394709, 0.1373195698240315, -0.31945070719726243, 1.7888022240216437, 0.7513845447044012, 1.121678227900513, 0.6869174114716983, 0.37957736236958245, 0.10537512568519915, 0.15436074506980052, 2.4143642972844437, -0.6433888297258278, -1.0668535426579724, 0.12351729660697555, 1.0662666754219592, 1.1199791729334072},
    {0.7013554670271207, 0.00837838080634139, 0.3977776554805851, 1.4509342668119585, -0.6849445337902086, 1.561848040687553, 0.2390610275619605, 0.6093786741356189, -0.63295882895796, 0.43185131501467455, 1.2787550028871297, -0.12592092330596932, 0.717702639860052, -0.8847847144984614, 1.0935233815822258, 1.3066324131064162},
    {0.3711264309949561, 0.21550892686516163, -0.7845875755587536, 1.6731713039548874, -0.8696904953620711, 1.6228255056869072, 0.30516865515510905, -0.43077684191908727, 0.19909278802471614, -0.9392046216411047, 1.234612249590633, -0.3361940124874442, -0.479739536363973, -0.7748989629965493, -0.2643968060031531, 2.158241767127989},
    {0.3910764787331488, -0.7965929592238374, -0.27067615981246856, -0.3405316715356481, -0.7699807408106576, -0.398784263349625, -0.7812435461391841, -0.16769478546175742, -0.2046694061487014, 0.6286048282820522, -0.6221794383653608, -0.8264285582649925, -0.900033106071408, -0.1805962465341203, 0.10250723773088846, 0.30457821834479515},
    {-0.3285881644620623, 0.7379832652790067, -0.081862694216131, 1.3275031136925857, 0.8523574331255389, 1.8004172818162483, -0.2975752495487325, -0.908177616204659, -0.9897436560649493, 0.4646392768752341, 2.4462882903507412, 0.609432030206324, 0.6314799387882605, 0.49932928952645805, -0.21592114816277044, 1.2006583663497679},
    {-0.04090568954285401, 0.5967240224866098, 0.037340858103626896, -0.1338541734622612, -0.7697566684553873, -0.13318046711272558, -0.6063163606063838, 0.6648509648517262, -0.1823610176186286, 0.4817240117727736, -0.7197898624280208, -0.6148417800212627, 0.13132589065202954, -0.33308940497711853, 0.5518787650320759, 0.29230621267266377},
    {-0.1714536526511842, -1.0027970970825095, 0.598093530687896, 2.109599488405001, 0.22242086333100342, 0.5196729406607821, 0.05707884966031254, -0.4886279256771286, 0.27729453058254694, -0.8346114342355121, 2.2679200176420875, -0.6725437934213787, -1.0104699707989886, -0.2532359229277466, -0.8471865101052691, 0.9921499529255817},
    {0.9395995394106995, 0.9262721028204901, -0.09418373926813055, -0.21692984082120909, -0.30225121509416214, -0.7979208418465351, 0.5626476348709171, 0.2688975417165547, 0.244866385380785, 0.11045230136348781, -0.044622308330066474, -0.3959382655882926, 0.10632668991606394, -0.24046742517522587, 0.4344808379034516, -0.27228199808846465},
    {-0.6097537819699842, -0.3390588318635227, 0.5310205556315891, -0.4890204233311565, 0.23725643191380177, 0.5220318400792572, 0.10721345481889595, 0.21961907748890117, 0.40789464796011243, 0.1763978178562309, -0.2481023192364937, -0.4895138118701462, -0.10428849172713739, -0.6909983878323033, 0.7019630468442685, -0.4586143023856099},
    {-0.6581846505234653, -1.042633319796861, -0.7856859057799546, 1.803844729474385, -0.9514164687457015, 1.0388688729351403, 0.4771165352887583, 0.5473274542028722, -0.5868007568512422, -0.6009724857684788, 2.3151350854972916, -1.0144637224502038, -0.8422260505095792, 0.5275811938975833, 0.8466059775289375, 1.9680470671691979},
    {0.2742772511495763, 0.14938250768658964, 0.6608038297620507, 2.1883840499282186, 0.6123449418339548, 1.1068709068134446, 0.7776596435630863, -0.43902863266519776, 0.356236531689008, -0.25878115963260245, 2.1095639734939247, 0.16891854562718603, 0.35042812619170394, 0.06274966281090612, -0.1939589259046761, 0.6241982060072632},
    {-0.724849624726065, -1.0848520345889319, -1.0381407044896636, 2.0116905680726633, -0.20489845789176528, 0.9134872918216437, -0.1605198325125144, -0.9139170117142174, -0.6737557851532628, -1.0828426109276306, 2.193148777282854, -0.6151963868020566, -0.5105822593116346, 0.39737990366295306, -0.29131594771606895, 1.7812655772150672},
    {-0.44554633693004436, 0.6831269737105199, -0.8033133401899265, 2.444552004446948, 0.8332084792403128, 0.522147962542406, -0.228283752684932, -0.16630327886705998, 0.1343574949727134, -0.7198013425022329, 2.190049038723204, 0.9131959475856394, 0.6559995845050312, -0.22192056500078725, 0.9047976265353936, 1.900860932582147},
    {0.23868563140706106, -0.03980000891296401, -0.12799848449399556, -0.6815484023483485, -0.3999899984475364, 0.21573159455454588, -0.19468695875945485, 0.4333549729633928, -0.9438998521937106, 0.32561215377846603, -0.49646700801781135, -0.8752320492950091, -0.6682102003780404, 0.35743401284731285, 0.725930843708698, 0.0376341289601965},
    {0.8280301321791556, -0.6781491963904108, -0.011787050950938944, 2.099848326757821, 0.23946511725144778, 0.8306342040267533, 0.6257494428327304, -0.06889835285481254, -0.931537194436546, -0.2569847256355874, 2.320719063038768, 0.5074925865185188, 0.3145632666573202, -0.15998359658403144, 0.18344845406250468, 1.2474233431418202},
    {-0.7841828129876415, 0.00473476111373534, -0.7547324981144365, 2.312892173551588, -0.47409382487734447, 1.2759816457822815, -0.1254914182599608, 0.18896006010491728, 0.40346510321998424, -0.5585216980769171, 1.620040487710573, -0.9932483903251644, 0.6252354664212354, -0.11645655641647493, -0.31592865670350895, 1.392664846328927},
    {-0.07095818129126129, 0.5451202731066435, -0.5646360536322174, 1.3222706759633895, 0.21272838169227845, 0.5271767467204743, -0.4325865393277106, -0.6748663686073184, -0.5399218939895679, 0.5683682534105596, 2.022773563881714, -0.2341800084635926, -0.7009398602375727, -0.8415122224210675, -0.2423289675165652, 1.1310817641366704},
    {-0.28134548846926755, -1.118802447288963, 0.19109888958927443, 1.6280129972854338, -0.7293646629712169, 0.048042560228680656, 0.236843960573985, -1.15471254121813, -0.5196640825420714, -0.4091987169012424, 2.035532704144317, 0.7480149194376148, -0.09328052401704934, 0.6391953355083843, -0.01721995508894003, 0.5510929983239323},
    {-0.06009775434465961, 0.07682297722756076, -0.957191733659798, 1.032731737978834, 0.6050584689307184, 0.8126881447336175, -0.034297633763066854, -1.030661444929988, -1.0147763699723877, 0.4746743877814531, 0.15123343223503322, -0.2571135530085909, -0.1906448426023791, -0.4241415867480756, -0.9119076332633332, 1.6188163149147188},
    {0.2662897381996991, -0.7134443355037233, 0.9136579096464518, 1.605359666869233, 0.11390746372153146, 1.1784835363218222, -0.7396068530250671, -0.15023479579818927, 0.036790191945004096, 0.5830361855346221, 0.9007786448652855, -0.5233090130126066, 0.6684064134045683, -0.548006851218979, 0.20514899797568906, 1.4481218587321742},
    {0.67025742569151, 0.3572491882211583, -0.2730245011399328, 1.5735694434268688, -0.9702630939872622, 1.5417965636233442, -0.07461696182882865, 0.7945208255745786, -0.17062591117362907, 0.5490503026642763, 0.8094438701958989, 0.37110942626076787, 0.9363205646438961, -0.5207501444802654, 0.41822603998734026, 1.2172983561945547},
    {0.04039231981499257, 0.6800470428184902, 0.6549744311551261, 1.3500879141427018, 0.7381609260206808, 1.7305848231028007, -0.4011068789340179, -0.18076226720776836, 0.13090160619024044, -0.45683721234207375, 1.6953640771698608, 0.46253901630364164, -0.8671235855027344, -0.17761138252896325, 0.862296398563272, 2.1673610521585465},
    {-0.09934707779746364, 0.11334929073438083, 0.6450380444378815, 2.245545771319658, -0.35961334267920053, 1.8390894093552856, -0.5649624912811908, 0.5234365133464759, 0.4800766136140237, 0.2851579665236074, 1.0724663385052957, -0.5030714813514073, -0.8871471881690516, -0.8534324041076569, -0.37463403450930294, 0.6168770090164091},
    {-0.18078173805721842, 0.837924135428655, -0.6882362080154734, 2.29435718438737, -0.12769518345342804, 0.8019270874413507, -0.6695401608812205, 0.3448710588502037, 0.8230626907054738, 0.4990345726399606, 2.386442073001537, 0.537821051603843, 0.6505086893706713, -0.07632402312662963, -0.49555759241735936, 1.4983387319844452},
    {0.6997550337739136, 0.008376795678432256, 0.8662588728115451, 1.9273515246919013, -0.4678650224384122, 1.5161097559697676, -0.09789796411184681, -1.0624071524487557, 0.6683137976907827, 0.028592899815380907, 1.162876546963882, -0.6020578350889146, -0.5340433756387384, 0.20596651875369712, 1.0163422540529168, 1.8281728284305692},
    {-0.7812916380039806, -0.6293744338803158, 0.6984513293416931, 1.4717740470182645, -0.1925682035696413, 0.8099791546521472, -0.9783366955995499, 0.5077530055341509, -0.7071270393732213, 0.17682025360372264, 1.4407466442847896, -0.12007999268694763, -0.03091415421457311, -0.794910980587316, 0.22510949726261228, 1.8600395420538718},
    {0.24124602596217046, 0.6103687931917284, 0.15914389976768906, 1.4206554355902645, 0.398169909810921, 1.6522122933002457, -0.9391947660098952, -0.6867405530191213, 0.13198720770214628, 0.20150665569939769, 1.6034840825974854, 0.5698475631278024, -0.2737010077054961, -0.17685584098048007, 1.21636938406806, 0.8276796350270692},
    {-0.9676286619673723, -0.515228100154253, -0.46531748899980113, 1.256459509311455, -1.0225250231925465, 1.4320445794166816, 0.11181407247372464, 0.8962093382152865, -0.5938330807038984, -0.9658046788337763, 1.966196966104888, -0.0002408809288894824, 0.028152401261650927, -0.295304170695342, 0.3997524888443941, 2.3572239484835538},
    {0.48451111375121975, 0.6487809446004724, -0.7466471546375082, -0.09539372730154975, 0.8354440072642532, -0.49809658435287163, 0.12150897780203271, -1.0190749207319576, 0.3046182644363433, 0.3203023616129311, -0.19896416131808653, 0.27251370341470404, 0.6391065823981642, -0.4551916595239269, -0.19488740298903695, 0.5425320792758002}
};

static const float b3[16] = {-0.016875634511609065, -0.22099054283440053, -0.0983675031563325, 1.0526484053520586, -0.21567488681594058, 0.48360404947756414, -0.38075162335498997, -0.20959596875107528, -0.1842637964163255, -0.25681306550327054, 0.8697285258783511, -0.04720957022394597, -0.1912432623153037, -0.14158569900703577, -0.1251753699307405, 0.7396529265126016};

static const float w4[16][12] = {
    {0.05654217983991205, 0.3854376171257134, 0.2306039929487284, -0.21927244596048553, 0.619518176738179, -0.6876333543555773, -0.21217505492134317, -0.3098041195106982, -0.6830535515805715, -0.5198969859635452, -0.7588375138024921, 0.23943103935204965},
    {0.29351361153711975, 0.8276891607343815, -0.795025514649715, 0.8448139140273423, -0.41700553386551675, 0.6893820563618297, -0.27154925936097457, -0.38864506391763615, 0.7352916548657124, 0.8863812211930294, -0.6981524558920542, 0.4558222324156079},
    {-0.3588218916458684, -1.0118746199696778, 0.08218426037623973, -1.0344159984855894, -0.8885685528314573, 0.21864850335572594, 0.8324608434793983, 0.5982699629959279, -0.1688602546701384, -0.865586421123914, 0.3117220201674361, -0.5417228243223791},
    {-1.3957642457778037, -1.914379693090606, -0.5758319369327383, -1.5211641586835922, -0.7158824979714165, -1.9862120793119962, -1.7705640570821475, -1.5656744790147692, -1.1921168117446796, -1.155103194278674, -2.220841356971217, -1.0348267388034729},
    {-0.46603582529102666, -0.28359331513461195, -0.41885571546155015, 0.8051353758398571, -0.7595666592825505, 0.24375440468357532, -0.14722662764287406, 0.4280241259723128, -0.1431905829090466, -0.37469494356847116, 0.6909468328030298, -0.9069684198310942},
    {-0.9641543684890328, -0.8945701129843882, -1.6382926596993126, -0.7752427215331817, -1.5779046195415507, -0.5713289377568664, -0.39695641705013884, -0.767915526716438, -0.6577747661098792, -0.8773256812525367, -0.47708887971760566, -0.7638618662668977},
    {-0.02559413681218116, -0.48066176598145394, -0.42029494820612023, 0.5279740462135141, -0.29561636106999317, 0.27287366556735837, -0.42491067719403264, 0.5581486833625715, 0.3037457531470526, 0.44469772155123094, -0.05204960076877823, -0.5520680703400181},
    {-0.3108936914128947, -0.9765363529690606, 0.18984153006766677, -0.3048058866787349, -1.0226360542800474, 0.2854385799874623, -0.2925079713694213, 0.8014179334438363, 0.7744228104407134, -0.24695356821412004, 0.38921700147104804, 0.7580406249529434},
    {-0.5123738515190494, 0.8835065695506987, 0.6739342486140721, -0.9276185231497706, -0.23185539508675154, 0.11300663426618801, 0.9282749327585494, 0.9090520613382573, 0.6996078028143696, 0.6019224582058318, 0.11904792377615504, 0.8385022028870005},
    {-0.36961625768584516, -0.4954059580834393, -0.8061819598954524, 0.44717263298705184, -0.8537175836776467, -0.5560885373449416, 0.621638267367601, 0.5388665306621534, 0.3115778481849631, -0.48816409895393365, -0.18807630741119974, -1.0309590533853796},
    {-1.8813665607774894, -1.550454674699467, -1.958943807898031, -1.7016671596217376, -2.050391681241427, -0.6675484204770022, -0.9226955233831616, -1.100474210908689, -2.133060639613732, -1.7604161008176091, -0.3941494281910259, -1.0902239031225385},
    {-0.950519546949225, 0.6623660611036308, 0.7368368768882955, -0.1084956163353882, 0.4265657584379356, 0.490381867839521, -0.5060149999434707, -0.9232789443505193, -0.027192748897024947, -0.6273848385959764, 0.42694108318229373, -0.8224434655604965},
    {0.7207278770074332, -0.9940740556697757, -0.6194073166235621, 0.9538413221916546, -0.3393098635823489, 0.3029281021992986, -0.06993979665634782, -0.6224614244652775, -0.3876336236992579, 0.7071125162068659, 0.17446376652167767, 0.13746332676778394},
    {-0.3907192828099449, -0.8315879756328551, 0.05713545610915414, 0.38433333261183145, 0.5689138839032765, -1.0533671216108926, -0.5620071986903619, 0.6269177955647786, 0.3762484821943971, -0.29632812706163675, -1.1835172317056186, -1.037391654234434},
    {-1.2846209777095225, -0.06619322894761175, 0.3025407077617737, 0.29939851790518673, -1.034897358507425, -0.913763845619019, -1.3924681810960737, -0.27975424758519707, 0.3125956561268784, -0.09437831028745926, -0.543042700117417, -1.0020075988464427},
    {-0.47221960312768363, -0.5103501167319894, -1.1454774278869169, -0.9604863397088007, -0.6966288466655507, -1.6345606235157293, -1.679629550006156, -1.5157413218578686, -0.8352963027046879, -1.1633756814683591, -1.791159177751144, -2.174770916278357}
};

static const float b4[12] = {-0.8520380866238306, -0.8099043112058766, -0.7062950270943072, -0.6478852534562812, -0.7060178347089411, -0.8037536060221999, -0.8112436843396004, -0.8212079149787437, -0.9012008535096805, -0.8243984595998726, -0.7583118215131446, -0.7506646234853334};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
