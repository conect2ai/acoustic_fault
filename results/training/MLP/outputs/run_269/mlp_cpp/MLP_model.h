#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {1.7312734352418728, -0.9462322634031595, -1.6483412180525965, -2.023151185156076, -2.4376034667052764, -1.521217056599109, -1.1736461456749716, -1.9699219572035678, -1.3003107204412565, 0.0011490635497506845, -1.1562208386258213, -0.4816861970045508, -1.6475778612821954, 3.541199872930642, -1.6263090829714013, -2.4180170345819794, 0.5318931078937159, 4.992339064405233, -2.252207658980323, 3.8815079776711205, -1.338241338982732, 3.680642494187971, -1.11336867234289, -1.1483217223841207, -0.5893099519431626, -1.4075818174744952, -1.7331248265926376, -1.5882781852563903, 4.384756801196289, -1.3495474777781873, -1.1231073894867276, -1.645852388801174},
    {2.0549217122669177, -0.266218088986878, -1.3505435455504275, -2.7523145666798077, -3.074599077148436, -1.9658548942523406, -2.3794444677434448, -2.500818533149869, -2.5583624076592972, -0.21646245776717865, -2.4894628278121522, 0.2618650290109093, -2.265791122336066, 2.778262612472782, -2.285748098810682, -2.4472621915365815, -0.07362186364628297, 4.666827098353333, -3.2703457066552732, 3.8805123866852713, -1.9825313250785275, 4.100610583529428, -1.1479988790121143, -1.7446560992445872, -0.540012527707351, -1.8851854422899, -2.74435007828259, -2.459069117383046, 3.9793738295838, -1.3095588973714714, -0.9667095310765218, -2.340817217972913},
    {1.5963754399317596, -1.3098091522681035, -2.5396223956996185, -2.8139355203898058, -3.1442844129676857, -2.086675409759109, -2.3577889808566184, -2.807771074295015, -2.371079184929051, -1.1409695796306267, -2.1506390706323115, -0.9241269901166771, -2.5239764833847143, 3.238386253257501, -2.373397136886225, -3.1898812488502464, -0.40518569124464665, 5.347963925932284, -3.014163468712222, 4.43454845347432, -2.4944737642411776, 4.134600541791347, -1.8139525292320737, -2.2237287625076703, -1.438980255146237, -2.1625989296290538, -2.60313249711874, -2.4268979278141276, 4.302084292608316, -2.1104065585290037, -1.6604038293006254, -2.5071061896405458},
    {0.22920084558794945, -2.925983453320484, -3.4166094148975845, -3.9566978206885546, -4.118432378800062, -3.4500590917413496, -3.3012287183352274, -3.843260241872895, -3.2798907668968886, -2.7551598838077758, -3.117346015440041, -2.8131015325395903, -3.5663090789121177, 1.019860194920751, -3.5653099663434134, -4.131136416453168, -2.6234540842465237, 5.075825967808604, -3.9242725277245167, 3.1938832372994175, -3.5419252491701543, 2.8775181516595945, -3.139107003221762, -3.0922597671318997, -2.8357694993897336, -3.278050634370701, -3.56887839460179, -3.3962289998522666, 3.0882555023380114, -3.0884789872853804, -3.2669469625902896, -3.8434840032047575},
    {-0.5326133226100279, -3.481680064701708, -4.050431995876999, -3.9325363327011127, -4.363335317726991, -3.652288659847504, -3.4988339262381762, -3.752600250699221, -3.634577838110166, -3.4522720560299693, -3.104232671169208, -3.3662434338096894, -3.686617064803019, 1.7901035117605484, -3.5915508341560582, -4.439436365078547, -3.049296330335954, 4.246980481820836, -3.873259267260809, 3.0040622382456497, -3.7044206922235756, 2.4777795271245884, -3.4205393476268524, -3.288054579586035, -3.5324442530596594, -3.7176466872934886, -3.791492673079496, -3.6250175193127254, 3.035293261862543, -3.3316563251931166, -4.0036830836837165, -3.886662008576625},
    {-1.0435175385711861, -3.468171452600134, -3.9642382299080543, -3.9470380902301656, -4.433736100385833, -3.381496797989185, -3.3505360244627114, -3.542140451546414, -3.461772656345775, -3.6753449181616613, -2.8120932129700074, -3.4792577447825783, -4.157763757438692, 2.401960552864116, -3.691665227065724, -4.346167424474359, -2.9520464517741947, 3.3336001653898117, -4.012191523687521, 2.8106861269162633, -3.4394065081450873, 1.611872254980209, -3.2391331802858567, -3.4995216259104573, -3.7495259915172077, -3.6270826319539395, -3.754460295335849, -3.5305057109744205, 2.531101844305477, -3.226949069245536, -3.93696809466989, -3.581366805354855},
    {-0.7773612116763099, -3.2260047079507443, -3.758412753686257, -3.758053938561708, -4.196522612295583, -4.050741270973044, -3.381226235456823, -3.6173540060716167, -3.350446774232043, -3.3046496540184345, -2.8440543923532196, -3.0275344532624358, -3.731165048001799, 2.6477327646532944, -3.755690700390941, -4.013158035486356, -2.8895292150607927, 2.7052068731293684, -4.025962060307991, 2.6311235698933313, -3.561326422181543, 1.319895542672967, -3.0951059263155156, -3.3181606013101135, -3.2557333368988517, -3.3767767655924197, -3.515366933200563, -3.5094837826753262, 2.2854000954879314, -3.3612365344170283, -3.353991841356178, -3.697561655682166},
    {-1.8018077812201685, -3.961665043273786, -4.134822320481695, -4.3364051657599925, -4.399123291932811, -4.05476742429916, -3.7285249205877613, -4.063293372631621, -3.8803987571739236, -3.8005765384656938, -3.1466654771268376, -3.509495130524808, -4.0066117884840295, 1.7625316979636074, -4.048447777602329, -4.2229893174593265, -3.448218280729364, 2.482615554900569, -4.471766855913829, 2.0492620918364675, -3.9872990589181154, 1.1008979963958423, -3.638167204034176, -3.4199263881058672, -3.6989298548589042, -4.152338366384869, -4.1382339650915725, -4.098405754201874, 2.023472987945816, -3.7688618234432796, -3.648771280894815, -4.305258018658871},
    {-1.4508055536609026, -4.039072667306961, -3.890563090160206, -4.097903581483394, -4.268031188259272, -4.038455157122306, -3.8827311231290835, -4.451770258913261, -3.987566103256193, -3.7992349129453795, -3.0366432284009095, -3.7177124550710148, -4.249572860020414, 0.33303563881693427, -3.536266144504028, -4.361352909039592, -3.016432832089611, 3.0602425343575277, -4.454112549990777, 1.6790244838188406, -4.085401884379226, 0.7776980453215694, -3.302400707289817, -3.346110187948091, -4.031416861199762, -4.106641742245584, -4.206229652946097, -3.929956457167081, 1.3347610950492088, -3.3036688980485867, -3.959623907214246, -4.232904670571678},
    {-0.17369613625352623, -2.6847629884482855, -3.6009058938889957, -3.9466758935375537, -4.414259600359837, -3.828318415972012, -3.70000222042722, -3.9194264977537405, -3.698046822439412, -2.980688916003641, -2.864058805348474, -2.9875491872296647, -3.8649011911422604, 1.344336692181048, -3.30655674628361, -4.1402739243095095, -2.4875191955008185, 4.083184802741287, -4.291950915506288, 2.8084833439024526, -3.629848117612212, 2.079474686446813, -2.85591791694307, -3.192269469848391, -3.112370545481743, -3.953588620726424, -4.118096329811626, -4.035586612405572, 2.6158065214130763, -2.826814492018704, -3.1120000861597643, -3.9701629981451654},
    {0.33741478644267225, -2.392497450215366, -3.0897324777390467, -3.998829866086979, -4.026045598312957, -3.516250162572017, -3.608936655477232, -3.7296185399363093, -3.5542088925490236, -2.752077609410012, -3.025523594733885, -2.077756178644114, -3.9262053564527797, 1.2505415158500923, -3.4233058846036366, -3.6655423245476877, -2.2961175277067176, 3.921313465020198, -4.270232638763195, 2.662507352072838, -3.5637843201719615, 2.1450550843172826, -2.897947772771601, -3.1196962886258053, -2.4793410102295756, -3.6193985012903944, -4.014489231769355, -3.4992034302527086, 2.4312662892335815, -2.978128791928246, -2.6053834499440454, -3.6960450934018176},
    {-1.1882486535383616, -2.9742452082172206, -3.1796044014571097, -3.7009004094885123, -3.853784335977022, -3.474520538000375, -3.6058942924558397, -3.7869938675118435, -3.6412381613647797, -3.2080986810441754, -2.474460605294121, -2.9672130110716717, -3.755493226204504, 0.9212257425773821, -3.464434712506368, -3.700173090647575, -3.1268733107955575, 3.035692514035288, -4.159558245531852, 2.06859719709981, -4.051274531564542, 1.2764222864334023, -2.972449853391376, -3.493305783267544, -3.3012665187325494, -3.6703915022036773, -3.9310157583640053, -3.6752407683247594, 2.06378154439762, -3.2713178936028617, -3.379666777572263, -3.663991694468863},
    {-1.259063652374938, -2.8812843244750295, -3.436639075989557, -3.6359458565790628, -3.4982599785980795, -3.9465549634096595, -3.67563070345535, -3.6415346918803957, -3.576771550833354, -3.154106490427954, -2.3859243794533467, -2.919478037916581, -3.7718918332396836, 1.297358047811481, -3.5867935847093912, -3.425967577517412, -3.4300824242046093, 3.401884838725469, -4.169490921916913, 2.39286682707643, -3.9079934800584524, 1.7214950137833633, -3.4117877325764314, -3.3005521422509068, -3.358224401279322, -3.9795951561039145, -3.5896195118254117, -3.8481020548138445, 2.1487128653775245, -3.3883703553534463, -3.0829319757910376, -3.929958092363665},
    {-1.6080537353708566, -3.0714132353232064, -3.534027667394626, -3.7178589863721574, -4.082519431593762, -4.342496779789573, -3.8174156935824333, -4.307821755814766, -3.859695684793477, -3.4459947273363096, -3.0764773221332744, -3.1068101265451546, -3.912123559299332, 0.6321221456132857, -4.046527913049166, -3.735619567189562, -3.1861565526578968, 3.108778975627198, -4.16314444468636, 2.1624793746911544, -3.9497244230713124, 1.3353481203933921, -3.597110932690977, -3.557605759759163, -3.6824708175846097, -3.587556654061321, -3.943729437359544, -4.107214179604747, 1.7900541888037995, -3.666256834360164, -3.3766053761118195, -3.915405330163179},
    {-0.8309807577756094, -2.935578954125693, -3.2566199101928914, -3.7866563582891133, -3.901099215887914, -3.8854756597315934, -3.4545594013018084, -3.8552924491157152, -3.5851932252790846, -3.043902178915219, -2.829175865278101, -2.7587383310896163, -3.9663537287895867, 1.7281974064476393, -3.7213646619303837, -3.9562078628311665, -2.8821769626285447, 3.6918571511575133, -4.066931194665371, 2.4940138138039014, -3.9181589555725997, 2.1476328257089783, -3.3761301420415597, -3.2061467226241818, -3.1228075154067163, -3.620457859342637, -3.904827629815794, -3.516715785410412, 2.476155212907502, -3.3093412220059473, -3.0760173030240763, -3.6270066328830772},
    {-0.9121222787829539, -3.1790120066560874, -3.864612457326115, -3.821361561569036, -4.029326184544089, -3.884097190432535, -3.6693682195052353, -4.025820152690469, -3.7795609551167915, -3.1886959382977804, -3.3371067905539675, -3.156598353790005, -3.839285589454325, 1.3245223980775078, -3.9464848743548724, -4.206216183403715, -3.099230207098438, 3.975079515549178, -4.330998588513652, 2.641390990015966, -3.7572630528285917, 2.188946025856887, -3.4116183177107366, -3.5767648532426835, -3.3620776773665875, -3.9998659878415816, -3.810147712481174, -3.8093316014016803, 2.5518446648318553, -3.3021925498578795, -3.3393526491146384, -3.9621240880237067},
    {-0.5161399658174195, -3.0438024814405074, -3.285570738513443, -3.839990920412659, -4.327663070016688, -3.450349406422555, -3.212078396252015, -3.7453889148814463, -3.481326084282514, -2.9419838876687403, -3.0905778751264665, -3.326065930177756, -3.658250808754506, 1.2325429473250349, -3.4280417715471274, -4.008102118350032, -2.912609485333856, 4.539464252801944, -4.043495009522696, 2.5020091087601934, -3.5145473437471595, 2.5002094149910272, -3.1991878560667333, -3.3828385612030263, -3.4070356265748782, -3.2270956496707974, -3.811032532438746, -3.6149480931014653, 2.7456962352637952, -3.01028421023217, -3.219320193784908, -3.9073784548979207},
    {0.2688546367159, -2.698359476288441, -2.5333217061167104, -3.0398821426632505, -3.221723151643131, -2.9545054979972925, -2.9285405966718336, -3.0996901822389757, -3.0243467441783505, -2.313883254371573, -2.198537722136636, -2.395427421814407, -3.3595020554699855, 1.9167314918718517, -2.8526641043899095, -3.472060945807082, -2.1131019791175794, 5.023179768062885, -3.428687145924779, 3.5488740559883394, -3.015008117300203, 3.61267740977552, -2.5735142429536144, -2.61055064132137, -2.7349679168385856, -2.8727341685352537, -2.915619370837313, -2.959470429524059, 3.940094812234182, -2.9988627391295894, -2.641275856729373, -2.839381497085453},
    {-0.3585528586974798, -2.530484685030443, -2.95750783467991, -3.421377119568808, -3.3533584567393455, -3.255882480208766, -2.8112365468791123, -3.279277387812524, -2.9088366743687883, -2.457425161151394, -1.898677192727355, -2.484008671911363, -3.1797940265501663, 2.1615718488321574, -2.6758433859848876, -3.4548829341667564, -2.002922996066699, 4.410149876496639, -3.3005122633253734, 3.3238965038156945, -3.2206958474482126, 3.0460282400385568, -2.737592809241458, -2.795094737670278, -2.5855903358598464, -2.856323055699798, -2.8327030555683392, -2.852370262892906, 3.542862372951387, -3.030218996595644, -2.728921321221412, -3.21646534367955},
    {-0.39870018296223847, -2.695046600884523, -3.50664089703014, -3.6591263143306056, -4.0470212617870285, -3.446252031845407, -3.2724592130102663, -3.766352804446504, -3.323141638777171, -2.5666148356571816, -3.051578539564838, -2.810525066524063, -3.6248998233863623, 1.7630932227544849, -3.533967494547212, -3.9343383532337604, -2.7643361784191054, 4.600386703244324, -3.913667917480053, 3.04851951324505, -3.312766412639941, 2.502607311773398, -3.164729382862075, -3.059220573582291, -2.9912764575756636, -3.468287929336149, -3.7749481248359644, -3.3637236014501055, 2.7469850169844294, -3.2464512522489186, -2.927960283970925, -3.457686647807509},
    {-0.254505701308153, -2.5675592739504833, -3.1216430169921123, -3.9691960013055803, -3.931210990012839, -3.5536977193755406, -3.587894307664829, -3.883488928522565, -3.585574080981864, -2.662513498741831, -3.262229173926931, -2.7152431430817887, -3.4195625905612435, 1.1910523601307124, -3.5886663908570933, -3.7459338153696424, -2.5509776147706056, 5.024174483537928, -3.9879466192865043, 3.1788230626150384, -3.7744954761412544, 2.594743109460543, -2.996181233287327, -3.2534373767175873, -3.025307890095816, -3.4242369707162705, -3.5907554525465106, -3.549894893160478, 3.301757282046652, -3.0296383867285406, -2.7127455541710543, -3.5147249481876193},
    {0.7196681624987313, -1.943461374274179, -2.629627840365838, -3.157504379636062, -3.4482747552884634, -2.9383499265242405, -3.093246969733791, -3.0709563205625656, -2.759652698963183, -1.7413146984516552, -2.6282457588445025, -1.9465325721810114, -3.090046841830663, 2.1487502617648353, -2.8624482696232385, -3.0227841693999005, -1.5958455260308537, 5.658142104234477, -3.5525573377947017, 3.9841056427629127, -2.8363115749867114, 3.564535178512916, -2.4393717153730368, -2.5736015408701, -2.1414889753457707, -2.9354908539442985, -2.984722370179082, -2.928198853188375, 3.9413314194839666, -2.401424727918342, -2.2830952135259444, -3.079991950372461},
    {1.6530814354314247, -1.4487746286854886, -1.6912809913819373, -2.749813304802892, -2.823977509786699, -2.5014561470515115, -2.426439556091644, -2.561136199631219, -2.3951467190230633, -1.020850690650583, -1.5537313337463543, -1.4747529262400576, -2.3329279058982366, 2.6986831706055723, -2.614759194911828, -2.671541465475214, -1.0755226530056596, 5.659965638650616, -2.8821414953204134, 4.084897503328147, -2.3737796861374827, 3.9228592197456034, -1.8079209750557779, -2.182033503999057, -1.810966027647438, -2.359216484683188, -2.6312791143822043, -2.4476343520120096, 4.655784305885764, -2.036943984246657, -1.682971472619951, -2.705020998910536},
    {0.49716326941285927, -2.1772077955894877, -2.363175309211881, -3.2310988398460414, -3.4170561242039423, -3.11103497956501, -2.811332514826276, -3.362160292415358, -2.6516940676918654, -1.7827756641621362, -2.6598178954068508, -2.2873974308330434, -3.3558777569847704, 1.906178391575539, -3.099855067008475, -3.0562186717985056, -1.5160945055144028, 5.260620713798528, -3.50993620558095, 3.607317513320392, -2.83293514876205, 3.452430364001413, -2.723558580764612, -2.6638494683748917, -2.4322654627006948, -3.048332560933521, -3.340349800364717, -2.9156928936765305, 3.74078129852788, -2.6654615473582215, -2.4215817408737754, -3.303904161248409},
    {0.3941044096189879, -2.396559081906229, -2.6561051877435524, -3.4331134002673793, -3.7032069383757356, -3.162405829072106, -3.0725705739880294, -3.672012041077929, -3.230399617650865, -2.202561153490843, -2.8421391806351117, -2.281797537030039, -3.421752989314385, 0.8820620356536003, -3.271274928934592, -3.309467900875345, -2.461464797165037, 4.8306846658647835, -3.62885298721363, 3.2066191510026147, -3.391119402465663, 3.3420078634516908, -2.825663899101037, -2.8546009428347294, -2.885971234700511, -3.362911068483223, -3.4625509735414997, -3.144689889912494, 2.9428020569636026, -2.4373240858431835, -2.608663622797239, -3.102237904202114},
    {0.3293497445000761, -2.1469478712178955, -2.415285924920301, -3.1273518116362244, -3.2333879562967853, -3.0123911454408883, -3.0270614266941234, -3.1505362558157493, -2.854873372864556, -1.9386602303132, -2.3365223988682846, -2.240204602460308, -3.1431263244895997, 1.5786053113657603, -2.8892984834359763, -2.965912320953241, -2.221664608990938, 4.6896686359556705, -3.5384771671911697, 3.4663986132303606, -2.9070083779709295, 3.3434665422313463, -2.4510935663477182, -2.6314377891473884, -2.1994177131436117, -2.6143034061534545, -2.922064984567271, -2.6525433213909, 3.410419242457722, -2.4820382860838444, -2.183669701956686, -2.8405900371053865},
    {1.1023265664861142, -2.284262093517954, -2.2983354525998787, -3.2170141224214364, -3.568098042168811, -2.9030264188459376, -2.953193214166796, -3.067795004849517, -2.8453772772457397, -1.8757370027253661, -2.339944898469977, -2.163062859109718, -3.0613768875354155, 2.334470108980134, -2.848419941772064, -3.1149567121088926, -1.7909175136497109, 5.307643882035113, -3.652856981257027, 3.737832872247032, -2.8022449249567556, 3.870603529317585, -2.4426084507970454, -2.5825431036977613, -2.268542180063259, -2.9275528312061914, -3.035130964245669, -2.8211196949702053, 4.115466542377829, -2.272753630729468, -2.2552493456382154, -2.782067951249744},
    {1.065223147137655, -2.2852463796205726, -2.6118945080012583, -3.1365073957084175, -3.5599703007141232, -2.7807078640382716, -3.108562672284002, -3.2109383393278974, -2.8531056725203308, -1.5916815282852919, -2.504001379489827, -2.0237708619060015, -3.105646164931295, 2.4630957480316606, -3.047598147009403, -3.509206548125098, -1.7888727333400471, 5.4599249454096705, -3.637388531501979, 3.8184166999102733, -3.0996889968282133, 3.8466392294590763, -2.429645505883703, -2.610702151516896, -2.1635642712634415, -2.762819844584923, -3.3337251827501024, -2.824087759497256, 3.9923735543267975, -2.3415671001778353, -2.173716716289819, -3.128710433250188},
    {0.9353640171823613, -1.9662602214434415, -2.10430914854398, -3.350313339265619, -3.501571655883762, -2.803077569816505, -2.7250066321281814, -3.1723315628480324, -2.916980589888862, -1.6558580694416782, -2.3749719565538174, -1.9562407908452846, -3.0244338357722285, 1.6295586777410762, -3.1549994368243395, -3.2729335099640813, -1.9429013249392095, 5.139644207445717, -3.3433108812935433, 3.7174751666477115, -3.122387638200747, 3.6191055410628548, -2.375102579195958, -2.697822986648964, -2.5326300215404207, -2.6712790337608334, -3.120263429016346, -2.884689935809997, 3.8440814707953743, -2.484920674307482, -2.2804342004185516, -3.173306975772161},
    {0.6193332877624865, -2.1273029946860817, -2.0274702826493245, -3.2941027115774384, -3.6733544606201614, -3.0797135095130863, -3.148815859863234, -3.3677817125389353, -3.1191993902238777, -1.4232014333488112, -2.885355361987736, -2.0881423518380737, -3.0193376344318446, 0.4424426400254615, -3.1942453700621285, -3.2031458870426444, -1.9610864234365222, 5.018404383755902, -3.6438966989984496, 3.062177319877495, -2.8467594276686508, 2.9938465278465864, -2.4732646092751183, -2.730099504180286, -2.7336237421317704, -2.96949994257426, -3.4570230831343767, -3.1987639890887216, 3.495440150339205, -2.393605142639387, -2.5427151762850526, -3.2562681051339997},
    {-0.9446466703722357, 1.4672634081783007, 1.2475217769308362, 1.6183967967223847, 2.0484076915489884, 1.107400754092562, 1.6904699757074133, 1.5353374244624443, 1.6860501268408215, 0.6525369451256992, 2.1260779239198233, 0.8985224412368291, 1.492910973324898, 2.267774650931898, 1.583939219148808, 1.5829594228447157, 1.0533139768082391, -1.4705735611350228, 1.4458561273452748, 0.5791245846763232, 0.8345411974698196, 0.8337992356092638, 1.4313367841098468, 1.5556337853284739, 0.9232103065157614, 1.7350703024170149, 2.001378959917653, 1.7917274930890437, 0.3474082687683271, 1.446492634658228, 1.6732218208468652, 2.1447486190609553},
    {0.9522211059834883, -1.2487852740140273, -1.4309834510327715, -1.935342312480304, -2.5574003311066233, -1.18890065155475, -1.2708819639919005, -1.8031337612619183, -1.4452572998182267, -0.42942722115544796, -1.4090138823483274, -0.7225401118021586, -1.7032347115278716, 2.505363923023145, -1.4957975716222187, -2.6041330673427643, 0.012099467439764812, 3.5162308975392715, -2.584004248696103, 2.1938200748898957, -1.4255092926056032, 2.3029057765581835, -1.0225382039077222, -1.248385524498555, -0.8142702599936592, -1.5162137893234726, -1.9894526895054052, -1.5184081081345675, 2.5230614069648354, -1.5312689752756223, -1.0997815337721888, -1.7933854707274757},
    {-2.8492345281491, -2.542667510508628, -2.1879993844950527, -0.6427821888300036, -1.4966241390893837, -1.8815051638745628, -0.7212283217100177, -1.0487047875507238, -1.204593718510099, -2.576486914220306, 0.7457505314096197, -2.432787941677529, -1.7758171271817038, 1.102013724152732, -1.5656637570298526, -1.9576664782189401, -2.1316314401106156, -1.9240186317944712, -0.8087477321154377, -0.9627254571625482, -2.106856690476268, -1.6391485093189488, -2.427581504372277, -1.4315055855147243, -2.593967955154894, -1.6445709394546277, -0.6803878025022765, -1.3873320794798036, -0.5610798537687716, -2.0341842195841107, -2.635561054062454, -1.2714716656622214},
    {-2.6838813730638447, -2.8291711035237204, -2.0623352918544273, -1.3836593455723238, -1.4364621305638434, -2.0072081396267887, -1.3896180976428039, -1.790030621720805, -1.5875124006578931, -2.288807597498426, -0.4514780928190154, -2.5986484836415356, -1.9722839487476105, -0.2765601157044657, -1.8399065927921312, -1.6803930791792994, -2.2811434670054633, -1.1819597691316006, -1.9687734068325649, -1.0687325622771027, -1.8300341863125704, -1.5195676186831113, -2.4133403557053588, -1.5206191259620623, -2.492695991318176, -2.0097473680828415, -1.4078215188350205, -1.9897773568588497, -0.8470882463972021, -2.477673444401393, -2.602898896244136, -2.0774122714379204},
    {-1.4836070087029347, -2.2880083993238816, -3.0849113626828104, -2.859272054283987, -2.546989714578408, -2.6616277220647997, -2.2915676791038253, -2.2508581496057025, -2.657665455471944, -2.148843738558822, -1.4344878122518097, -2.155809278152458, -3.0884844242134384, 1.3365132018927577, -2.8327167133592317, -2.824567674932667, -2.390636866626461, 1.4097962432735232, -2.7978599120083927, 1.2269045325830574, -2.771622061582735, 0.7218099631897349, -2.907251531876526, -2.462422716849677, -2.332861183238268, -2.9916882273171232, -2.0690409268434045, -2.576293595160493, 1.1790866108404614, -2.812012042570877, -2.6402348948950296, -3.21353950341327},
    {-1.9033448371208361, -2.5018009042741975, -2.9946359070045228, -2.3064158800404964, -2.6235518318627467, -2.4120153184973234, -1.8744299529337294, -2.2141753118777117, -1.8402281973692771, -2.2890004686752667, -0.44118389613040054, -2.483410119332644, -2.554788273583782, 1.518500266304212, -2.263127476114071, -2.821022553750591, -2.294755748832656, 0.7669113050661316, -2.1387461205414233, 0.37977218143930824, -2.2565970618576023, 0.06357525703798775, -2.5671336008839165, -1.8906474674989169, -2.7198024555485767, -2.368212339875508, -1.8388172891616794, -2.2011800198136906, 0.44578731593446413, -2.288212897684281, -2.8547248689273363, -2.6958404981806052},
    {-1.972733328593191, -2.187078255997806, -2.5566148906771624, -2.3861580774780013, -2.0837211445778054, -2.487508404500824, -1.6600062827969473, -2.249299034719703, -2.3884491737909257, -2.8605000256622275, -1.064208592174698, -2.267782219808441, -2.470003796943704, 2.1108903447689, -2.6679101661908384, -2.1257109991610523, -1.7614981452117964, 1.0417295447473274, -2.5142668793218963, 0.817420685968558, -2.3631270928260637, 0.20740293178660185, -2.333303932318154, -2.1744065280084723, -2.1836074934323246, -2.377527070177432, -1.9618377415067307, -2.219386638538813, 0.6510020788576402, -2.369421475886637, -2.4028087777171616, -2.699963599837906},
    {-2.4626449978914016, -2.343537914724528, -2.8574749192367777, -2.6984591436769056, -2.1463404783691935, -2.753652511927544, -2.315358486584829, -2.430946198735922, -2.5941986358902875, -3.045553776920054, -1.4548407686151896, -2.1970102261774307, -2.9873888247416818, 0.8155073316988343, -2.723289463352542, -2.2943940827469786, -2.3480004096158424, 0.2851506128157488, -2.9264010597105887, 0.06576424950944261, -2.7417126299271266, 0.11154798609742023, -2.5009553251410095, -2.529617899100104, -2.236193632258449, -2.882225899559487, -2.4295360283965453, -2.756030736269253, -0.06827245603219292, -2.680118801825124, -2.3885085929577885, -2.8306126144928667},
    {-2.6563264397429993, -3.0543730490009944, -3.3096080656140927, -2.564630583905903, -2.8092967113925322, -2.8230697311020836, -2.0730905046842225, -2.5327061575245904, -2.579580096814958, -3.4125839646714575, -0.4420419686057795, -2.7922931211533597, -2.96598642367202, 0.9500847815784854, -2.442447322794229, -3.0791794614660106, -2.328898971524047, 0.7534521844979768, -2.935248255995594, 0.4223777593327215, -2.856343567940147, 0.0013749906536298507, -2.755772500355376, -2.7521458669221395, -2.537400398995312, -2.798149053152537, -2.2101359396478797, -3.0584036057760584, 0.22953777588338997, -2.3725322276564884, -2.9029491711066444, -3.232531570741882},
    {-2.8083886732871948, -2.7588350127497616, -3.1054313545163112, -2.862541409307775, -2.7931069584814647, -2.855483085949019, -2.3858211398328057, -2.5131056169812385, -2.4206987424505897, -2.833288966808879, -0.425896124757496, -2.794961084133787, -2.756541710824984, 1.4144231328929315, -2.495556384658089, -2.8037156812995168, -2.3575008651322253, 0.591199439398106, -2.6158621835799725, 0.6228878291965729, -2.948207367360271, -0.21045752914710433, -2.728366199866449, -2.3836871456902053, -2.7174628626657715, -2.793303731471155, -2.6226586312828384, -2.9790465972397415, 0.4731223814796665, -2.480774098226524, -3.0667508514317925, -2.9316405598798787},
    {-2.487483454761579, -2.0344396161183576, -2.2098747865554933, -2.5592601057581286, -2.321681168070147, -2.2490355647475146, -1.9742165627159483, -1.546977384623412, -2.1987919343969566, -2.4114290525191846, -0.5014589256407246, -1.8867803610262113, -2.1852299747592605, 1.1099300661350209, -2.3223906431045487, -1.9636295081544182, -2.473455339107138, 0.18190893451187493, -2.295759884001246, 0.40134617275659484, -2.795143661293134, -0.31603371950314046, -1.8203510609501026, -1.9134087382959448, -1.7034372038589702, -2.1444312231964835, -2.0248199318262627, -2.073724870577076, 0.4011474490871231, -2.007215387933209, -2.1867750932873613, -2.3009946502217944},
    {-3.224759237224877, -2.7815301151163188, -2.9239061094242955, -2.919507662463718, -2.652512059234131, -2.7018848646349003, -2.445325863482436, -2.362310645254442, -2.4972418884940715, -3.2191089626622538, -0.17316150305602518, -2.6696114816811733, -2.641972132950527, 1.113428810490782, -2.21194013276923, -2.896848733887987, -2.77727871840954, 0.04612498926933293, -2.7466211534928973, 0.013917251937986933, -2.8786365903832887, -0.5532115648289241, -2.998259058195348, -1.89627629732166, -2.665009566391683, -2.867607864058231, -1.7358104226955247, -2.637742390472023, -0.5293926502182777, -2.808301176608867, -3.023056918735479, -2.7049129379297834},
    {-3.225509271843667, -3.1310745766787367, -3.3615780440189065, -3.1877919591414536, -2.8176836318650045, -3.139219191722627, -2.7738037628119936, -3.1761677094002314, -2.7790734768869645, -3.49248695800262, -0.5470684411262411, -2.9458666379426557, -3.0719394712793306, 1.4803908383957194, -3.0823293947838435, -3.0947399010794476, -3.0624825011459205, 0.1964914899997005, -3.013810571388022, 0.24007196798895147, -3.0070499894379905, -0.4727100383621601, -3.1762922981959387, -2.796719598443367, -2.7201941803389755, -2.8297673191061024, -2.5115643803167944, -2.8691573204068597, 0.09407455036463121, -3.2683984251357305, -3.31406479036795, -3.2685514369559434},
    {-3.1982613988284894, -3.051110480788161, -3.310348410516135, -3.2227946495971436, -3.3606108758343565, -2.954010264333469, -2.8290407623674887, -3.1446032742440733, -2.8597085363637618, -3.2982063042358067, -1.0001261493644724, -3.135733916319713, -2.957593274093406, 0.7794961847138772, -2.828540247940034, -3.5284963670182434, -3.442536349461164, -0.6598056900457882, -2.9389346431440093, -0.28876985337792255, -2.9739989794133743, -0.8216067205852351, -3.10485205227549, -2.8641156362623734, -3.040929310709318, -3.05404645345808, -2.7369636348193276, -2.9174479942875964, -0.3768826406898159, -3.1410282980560678, -3.346420430518176, -3.302306134440884},
    {-3.231692002187089, -2.868113941605591, -3.2011482709399104, -2.971081559929836, -2.976609399266716, -2.9857713337404674, -2.571774173885618, -2.9112320926249042, -2.7595761075723697, -3.378858150089804, -0.6677895933016269, -2.7807467012902096, -3.1593703263081228, 1.6311220190104696, -2.6415373346075635, -3.2570163367328475, -3.0405398534002597, -0.3559307741188119, -3.0461658029890644, 0.0093514970451394, -2.998891640692975, -0.6828046084568345, -2.8713938456864314, -2.578033757637472, -2.6568424993445507, -2.877915397816027, -2.1931151303809466, -2.854978050541401, -0.13933422210027432, -2.7028212683478214, -3.1537218852472635, -3.1913770993742534},
    {-3.4168216212416525, -2.9851107154631564, -3.449038492276495, -2.656312257216949, -2.787732631360737, -2.667992537679081, -2.1925433246649346, -2.251064974669397, -2.0659190108550542, -3.080931199002296, -0.5913213091695009, -2.9986198728701314, -2.718512750271508, 1.1972848483793108, -2.406215738229227, -3.307628882395804, -2.592199623550924, -1.3392231909336818, -2.2908823014577777, -0.6567954542300338, -2.8538758446363706, -1.1918922361440827, -3.001928543409438, -2.333819210308559, -3.0372136507411938, -2.446159544832373, -1.9876203042098022, -2.6897200790996494, -0.6538758515859444, -2.855183551750503, -3.208050932971531, -2.756987082735813},
    {-3.273593425913305, -3.472131986467369, -3.2920158818357153, -2.8790765770292124, -3.066378956669515, -3.26027826570725, -2.6036231440870408, -2.778804027820602, -2.572084268443686, -3.3133083008830804, -1.1057486854028398, -3.0856070597716734, -3.0940723610449465, 0.7304591695941143, -3.013038295896542, -3.0271747212555065, -2.8103260942605788, -1.127783938149065, -2.875143121689052, -0.6324462722303024, -3.0777694540085982, -1.10492260952866, -3.1628676681627463, -2.476390275388591, -2.880998449534541, -2.968328848680078, -2.437560589921203, -2.9060981660637677, -0.7968195632005919, -3.3588657487270073, -3.3221604581898037, -3.2832940989690886},
    {-2.5883450175141154, -3.045013981522645, -2.593527270056203, -2.276804947440245, -2.3616199912954166, -2.771608680652904, -2.3702043205872325, -2.473059331525661, -2.333280162432173, -2.6327113362469956, -0.7929356940866766, -3.013613072033709, -2.772459886974499, 0.9665006359571385, -2.449806426724716, -3.2211387980662223, -2.3345049658430015, 0.01061524136991394, -2.197112969077622, -0.16766176332651983, -2.6279228465202533, -0.4268675411091234, -2.617693720092282, -2.156744993662286, -3.009956807749694, -2.5789941045457536, -2.106640696019298, -2.312072684101134, -0.21680986520100343, -2.535050993844261, -2.9774942777392863, -2.648647031197798},
    {-3.947918893241701, -3.2416338445365613, -3.4209479695603227, -2.354550081908103, -2.908673290244013, -2.7143363100011557, -1.8942892670795117, -2.0679783048099, -2.1578914965928977, -3.316469906669129, -0.4437549476148876, -3.2512708965488213, -2.833096827004874, 0.7005280338920525, -2.6023720182095156, -3.43022472100876, -2.8773028316122176, -1.550941327672079, -2.0690873093997433, -0.8390301172962131, -2.81336532407587, -1.5804897947978918, -2.987102369838957, -2.521026972841326, -2.9631890188679413, -2.6708909237987872, -2.125031689113699, -2.5739129536930148, -0.6821650414094232, -2.9895934038986405, -3.3757764224058944, -3.1323543288983204},
    {-3.9633311190774148, -3.3047232878508357, -4.08165120694276, -2.8137903378386304, -3.317717393336982, -3.0491567935590367, -2.4418307085759885, -2.917007413000884, -2.5984066917409976, -3.4977747115188356, -0.7679942835115692, -3.1774352413312372, -2.941578771166904, 1.192563969630869, -3.157365944456863, -3.9202541714534664, -3.374383557235569, -0.8646374074965683, -2.7581572883075505, -0.12172194220741638, -3.152176722375211, -0.9838792059584257, -3.255835942716946, -2.8558458900010955, -2.729781738884736, -2.8787877809689437, -2.387369170070539, -3.03003595797552, -0.026053236504501025, -3.763112905173917, -3.470120670911367, -3.5949190645663625},
    {-3.192348628865939, -3.2154904816135454, -3.636013692424422, -3.1990030005715733, -3.415601915222416, -3.209999212801763, -2.900764367299931, -2.3817793816224806, -2.8786015716327507, -3.42551386009436, -1.04903388616119, -3.4121736667575466, -3.2769502141811375, 0.4513836126551292, -3.265224902960567, -3.5646756605096495, -3.3865186964702563, -0.432003565200099, -3.065360592118421, -0.12176619652339761, -3.0710316098495074, -0.8478171282660354, -3.457690989776567, -3.050257494030595, -3.108566772985127, -2.975415264189104, -2.7665930371099106, -3.06467691592928, 0.06574022336994463, -3.7749848585624743, -3.5856044915874667, -3.832624608363868},
    {-1.9670817241147904, -2.8881720152007584, -2.971003892121043, -2.069663506783326, -2.9038275687401187, -2.0806416970554995, -2.039743932465182, -1.766877768209709, -1.6187660197790936, -2.413960147434395, -0.275320984859221, -2.3834299863000212, -2.20582189009106, 3.178217444036534, -2.0199611491081972, -3.4534335162415535, -1.891248706333628, 1.8877509437463036, -2.0286846444287243, 1.6049530249349386, -2.3195610667061435, 0.8745514305132785, -2.5271271844795486, -2.2927229780026135, -2.1275203764675163, -2.2414677503745524, -1.4416548502720636, -2.1200809297647374, 2.1182038567511525, -2.3471826753047265, -2.9765422768236216, -2.6509244483520207},
    {-2.4653569316318835, -2.697624659348423, -2.4160034746109282, -0.36287130620225155, -1.7515029709133572, -1.1153280856204841, 0.017199393322839675, -0.010967970383141786, -0.268907048782569, -2.3013642442886213, 1.4935361340496234, -2.1708620607050335, -1.2832708372789818, 4.067775921550453, -1.0789369805863713, -1.8505124830782231, -1.125298101371914, 0.30648271741877736, -0.13080832595702663, 1.5456672254841581, -1.1475401099369238, 0.36919071397143244, -1.8934791502967332, -0.9267392277206891, -1.7140915387035907, -1.2952773659029027, 0.2703715797259427, -1.2353233193226127, 2.189152315182147, -1.5249129335270752, -2.301694498549793, -1.2396065683736426},
    {-3.7939482230056374, -3.0886896151966, -3.3901684025051355, -1.9827530320764015, -2.2275336404091806, -2.433114523215635, -1.3053927387851205, -1.5565064308863505, -1.6881746510388944, -3.373845354277328, 0.8552632031498506, -3.1982909055405213, -2.321234792423776, 2.6218087740069915, -2.513705893649941, -2.8978714231514138, -2.719175802249885, -1.4396351981859963, -1.2999903651959428, -0.06554454171083456, -2.5436176997205933, -1.016051588225333, -3.1360673217675505, -2.049883237251904, -2.730638155305234, -2.3678740358592645, -1.2960606267973496, -2.1681024459091414, 0.339794307029728, -3.2151367838078597, -3.3233384501684076, -2.2108213320786936},
    {-3.949579960693349, -3.4508773879528105, -3.5649771734506994, -2.604619596777184, -3.142589487026008, -3.416916450948471, -2.369351035802541, -2.7274037762349987, -2.713840591222994, -4.10284885981399, -1.1038402416435493, -3.467366681001884, -3.2445380317693986, 1.1603023506578611, -3.307294422133137, -3.7608526503078203, -3.3977883467721446, -1.283792556955154, -2.516416350593279, -0.41973709489279554, -3.545434631553522, -1.0451239726662052, -3.7211541374601254, -2.982999135090357, -2.9831967036783724, -3.459251001696067, -2.5116711550688113, -3.138705593159184, 0.11895095111749304, -3.748613085102849, -3.6696278873218593, -3.271939725874142},
    {-3.804863926647676, -2.7141885983844642, -2.696358923884961, -0.8347382395239121, -1.6247480553905247, -1.626046148420747, -0.4158623695205998, -0.800203486380345, -0.8215125362607139, -3.0456493111523764, 1.0294107759478035, -2.855684981194837, -1.905032012978158, 2.2898971382841706, -1.240455782745406, -2.119887734045498, -2.5866875137058147, -1.7797458557151484, -0.608252601195332, -0.07562166227836012, -1.7636347928454157, -1.0088232861619508, -2.579951427697562, -1.8618591288112347, -2.186822194738069, -1.690033029733286, -0.7307791389365701, -1.7251421906086515, 0.4804345040334664, -2.3300203633440306, -2.7438849247166828, -1.7067070621184743},
    {-3.2714194739138875, -2.5813579183247, -3.103742932356257, -1.1300766986809643, -1.9031474832625066, -1.9124271898337177, -0.7727079813013857, -1.0489959648465559, -0.8250705833719111, -2.728301082613076, 0.709523505859982, -2.516691511083042, -2.4149269668211866, 2.9248467792363164, -1.7011143059088247, -2.3574087830497277, -1.7336413761625813, -0.639755796663308, -1.2563684496649627, 1.0596888744601758, -2.005554109115941, 0.2170256099993049, -2.3109451345587018, -1.4309070382014486, -2.285735795217674, -1.8606699154861486, -0.7638855246435702, -1.557522950217317, 1.501689237141122, -2.4489540686763527, -2.7722790286833594, -1.9770865050186768},
    {-3.836756119378488, -3.0008474797598983, -3.1261909977800415, -1.9193556277773998, -2.847063463620276, -2.068227184147652, -1.7627053424755803, -1.5327080402952185, -1.4788616084216841, -3.165876400117392, 0.02126542917297503, -3.308838725069438, -2.676217498146029, 1.996250723344854, -2.288689974185136, -2.6128887394233304, -2.874077040243017, -1.2030804801811033, -1.6920144351348803, -0.12972701904993109, -2.491369769535786, -0.5283835522342667, -2.9115691248150823, -2.040944490753999, -2.6802166979188384, -2.255889619285982, -1.3673567554403219, -1.9236423181606492, 0.6267163853225478, -2.3295807765029557, -3.463762983760451, -2.27895293616463},
    {-3.6253071196935607, -3.151488196166305, -3.132677806044914, -1.5098616771301072, -2.2368828049448184, -1.882565933945762, -1.2221440232361367, -1.2822361076787603, -1.1455173848451503, -3.568861951767442, 0.84605474044771, -3.1256231680960083, -2.1235435339063446, 2.556247248178019, -2.144849817638885, -2.8112525589987167, -2.514476394861054, -1.1221462465058385, -1.0705123031144579, -0.004781318053792465, -2.26215106465574, -0.7223872272890991, -2.8972899419234417, -1.7757184881831924, -2.802485432533759, -2.0931779351982893, -1.064279300502727, -1.621617617549533, 0.29284341355159155, -2.502056849348459, -3.4723774333178357, -2.1355289637848043},
    {-3.7751568213025175, -3.0669190160533426, -3.000090836415022, -1.0760258981033504, -1.9778635965562932, -2.122091908451614, -0.8779209434921755, -1.249766530439086, -0.9223976702184199, -2.890867359538629, 0.7865050069543611, -2.9644064323452426, -2.0387041919116746, 3.093358338564505, -1.8856221361574557, -2.5145366301497285, -2.1213432602233833, -1.7208557849860577, -0.9237204947129014, -0.07932326303996637, -1.9136948357263854, -1.190907508810205, -2.570362082297431, -1.4704549232417456, -2.9019879304063076, -1.6211692457543356, -0.694803458244648, -1.4604667559247086, 0.485396515670686, -2.1888457549568257, -2.8682277769473035, -1.7835425119729098},
    {1.3560016853477665, -1.8153870316224032, 0.5233960799189454, 1.3477428503553337, 0.07776939630722475, 1.3166634286619365, 1.5533693558095052, 1.1784157747738027, 1.078511016173326, 1.1282218633073247, 1.6026851246908946, -1.9754937565178994, 1.3512818385527483, -1.27479708808825, 1.7963363601511573, -0.23652488439869224, 1.8574152815192837, -0.3911575142787327, 1.1169798083528604, -2.8685538852093195, 1.4003868282391716, -2.29605872687304, 1.6929682538388895, 1.9804349086168087, -2.2886549709711876, 1.5296277328430108, 1.609643527177239, 1.504404988012191, -2.778988960929658, 1.759014117396617, -1.3447490674942284, 1.3518801733284873},
    {1.869793018354938, -1.732629863293427, 0.6776526562900499, 1.3996093013440676, -0.17692097083524985, 1.8601755979366235, 1.9906052297164316, 1.5893364813763844, 2.173538041177025, 1.9996337882393505, 1.9135570342389543, -1.8885765852626348, 2.0791313594547858, -0.8661606411615966, 2.2874487264624155, -0.0569465506234343, 2.5672446628431893, 0.6457092856967471, 1.2393431474044108, -2.7122149274633993, 1.9945945409967836, -2.5838809850103597, 2.1341480718949173, 2.6480478238244767, -2.0355454133630344, 2.272971690878776, 1.943602345891045, 1.8598944051397102, -2.5467591553346427, 2.222123113394411, -1.401682634726697, 1.8243099027549334},
    {1.696785152635948, -2.174499536534597, 0.08626590471772852, 2.208994136913381, 0.5260247198820721, 2.2555777378562083, 2.757002647434606, 1.7247669297603274, 2.3750104910967273, 1.9594822604497046, 2.376495237107733, -2.2966804081373158, 1.9216267490819487, -1.392614680404549, 2.690894258644905, -0.24404358124609357, 2.270763016097071, -0.43599863737174865, 1.8811347006037125, -3.387119909787146, 2.5021495834015086, -3.4393012184473, 2.5060311015546315, 2.8863219530845505, -2.597363627466034, 2.789244215209926, 1.9701558112659312, 2.322169033736147, -3.2114683210361967, 2.408974124414631, -2.0652580287148807, 2.2636547104384546},
    {2.0739822257129297, -1.831831625576014, 0.13918120285771457, 2.1022363653649974, 0.4012762344782669, 1.9504951530010672, 2.222135978648461, 1.5859500600673022, 2.308816736416797, 2.2015960537540087, 1.754790896634287, -1.833546502795265, 1.8425043766519336, -1.6474355277349544, 2.425061686498779, -0.16324978838838466, 2.420617580072972, -0.3724744345970849, 1.7751271752641136, -3.3849777280750075, 1.9685628250105618, -3.0952880131272513, 2.0713807301156777, 2.4745271343357644, -2.6775177915846378, 2.3822988172455752, 2.0688202970114813, 2.006272186855892, -2.7679724671740056, 2.049641398283683, -2.1871248133723644, 2.0790192845517943},
    {2.238226449584387, -1.8483010564358036, 0.808564496039652, 1.9007895805840156, 0.32127462925085104, 1.7987331076843687, 2.372299305516295, 1.395420749223424, 1.9075396432060139, 2.1909891152204555, 2.1972720088838757, -2.0879715094718008, 1.4745615971708959, -1.7940186246902512, 1.9374060082451277, -0.2965506531379602, 2.3730761771622197, 0.029133960705675806, 1.5570703723983377, -2.7993732144347905, 1.9856656280122578, -2.70564454508639, 2.2451514858786763, 2.1483170766459097, -2.5530428367546323, 1.9729343981875977, 1.7766379580700191, 1.9470342539127174, -2.3483321920474176, 2.126609976819433, -2.1084877103994613, 2.467260713648676},
    {1.8473659210825653, -2.208708360849618, 0.6824220353645032, 1.9761183259784343, -0.07797968799003338, 2.0326722135836937, 2.887064573210931, 1.8005617328281376, 2.1462420203583092, 1.9496673587000588, 2.5548955798707054, -2.331527190683476, 1.635205843529677, -1.7880450683584013, 2.112433602387138, -0.19933979666753865, 2.226682504009699, -0.5766110612886279, 1.795229772244623, -3.482185918205892, 2.152060246926568, -3.574419934936283, 2.0678179209610716, 2.470158857555258, -2.9153492324656995, 2.294658077568498, 2.3858213700663127, 2.2877842455674915, -3.140319410173622, 1.520138986310647, -2.024110165452393, 1.9854496031388131},
    {1.5747555053445268, -2.745998167461737, 0.14994362418987253, 1.957702373556868, -0.0722001048149074, 1.6670226002028865, 2.836287747600617, 1.6641594124305876, 2.3940601847518628, 1.649509922959111, 2.3826511554208105, -2.825985579453246, 1.318029153846558, -1.9607089219685363, 2.3932934166520745, -0.2467189721386715, 1.7208586046762875, -0.8249081449901654, 1.6867126991398624, -4.199888973954947, 2.2805392194499623, -3.6121568462093667, 1.8059882265126486, 2.7967950097095287, -3.040762798399514, 2.1350912814019014, 2.4835491966663983, 2.362507534168993, -3.4385932812747155, 1.547395053468189, -2.419979082533304, 1.8145168251079815},
    {1.995386681875253, -2.6701361865262734, 1.0268829791012615, 2.478807117238848, 0.7233845729525923, 2.2647126351196207, 3.0429647635356893, 2.381698273659763, 2.636529944809864, 1.7199196125631164, 2.4262076073822847, -2.2539971488190016, 1.9029195978872275, -1.9007177661797505, 2.667728902886179, -0.02895292674172717, 2.415328095074213, -0.7613704098474612, 2.143964438047713, -3.550939404968677, 2.1806001699168567, -3.443810017457306, 2.327388503486692, 2.4811704492937223, -2.829934817836516, 2.6479638135843127, 2.789207941169417, 2.3052982769014494, -3.722963597832508, 1.9377306268752446, -2.163256790343407, 2.3277621227158374},
    {1.9878317507622119, -2.7308270559108094, 0.7736214169258735, 2.490964929129372, 0.423373525807574, 2.3449510895992476, 2.9881655421509796, 2.338919019756018, 2.890303600762637, 1.4491611730223726, 2.6097110635175893, -2.6460602299438727, 2.267124847147739, -1.4297364588773545, 2.6649602468717206, 0.030017523931552596, 2.2316558907725055, -0.44967387578534285, 2.1847927335931105, -3.7083524167191833, 2.8037038857756635, -3.2897352911588844, 2.206994096843878, 3.082097942402181, -2.9045299937951046, 2.7253448406251506, 2.5425781265015273, 2.626623110774617, -3.6202533930816663, 2.4348200095976464, -2.0248288297793935, 2.4024934828258897},
    {1.4233697975654185, -2.459845044856731, 0.8052669404715529, 2.683820001560958, 0.3717533106662166, 2.4099546892343318, 2.895932942522396, 2.3432909143434513, 2.8764230265496153, 1.5194311832350864, 2.857986071962644, -2.3039016749336905, 2.184310989101528, -0.8797555053743051, 2.8662576552136727, -0.1292763070325879, 2.4605477843041283, -0.7449346528308347, 2.2669000216948834, -3.6911530926952913, 2.5818396382250377, -3.522354969945778, 2.737174496023087, 2.9643770940839254, -3.011241351113087, 2.7763944821218836, 3.0295214626280016, 2.377881449403419, -3.4657273787941683, 2.398211084445465, -2.115817300195813, 2.2706465134593006},
    {1.7396237110606327, -2.0607114532852937, 0.4856909285984015, 2.175436872895723, 0.5747301342425021, 2.1231115308817645, 2.7783160944944134, 1.9366576688237536, 2.6223443078035302, 1.6604866110231014, 2.6540799060295903, -1.9263480764606906, 1.9760319223121965, -0.47876038803524795, 2.6601009254417347, 0.32593130289218164, 2.5211877733813677, -0.11342077508334764, 1.918501690476062, -3.4813507486237003, 2.1806510517731357, -3.233156154952873, 2.2599045561751865, 2.888802442499715, -2.381245631117162, 2.754566517407162, 2.199485360759934, 2.040132427218143, -3.5505113412985505, 2.223396810453447, -1.5446584359974862, 2.049439800225118},
    {2.3464131298996147, -2.642055010273641, 0.9270380274254445, 2.57199357383975, 0.6336908816950263, 2.2887724287285542, 3.218674748051866, 2.722545967335811, 2.62475570930242, 2.105667730247047, 2.3937841299041307, -2.375677332322814, 2.113334339483373, -1.4827970199554046, 2.8746648713449385, 0.10324790113663782, 2.8896011547387848, -0.15188056416337592, 2.2251740571839465, -3.8030138423868514, 2.213245577184119, -3.390418863283315, 2.3801395382324615, 2.891257346341243, -2.642269208264243, 2.5874997465798404, 2.7071346246054895, 2.453406390719281, -3.658277502514605, 2.979852251741984, -2.101908703459345, 2.4704854937953966},
    {1.7630881211563407, -2.6526022136309217, 1.0206756258664846, 2.521607804939635, 0.7512400776262047, 2.1239483846408134, 3.0179903234249696, 2.57889354164601, 2.6599790957859013, 1.7142649494342554, 2.5705639967546094, -2.7707086004326063, 2.0144383583813834, -1.0432061178671863, 3.1090768635768504, 0.04827789135455911, 2.8553161075941653, -0.5894181759549912, 2.431267107427865, -3.4258423779487277, 2.4278345307834, -3.3579301005865103, 2.257221296539004, 3.123380460630701, -3.1530098420499892, 2.8728514096296354, 2.6297612705629194, 2.5990303243966264, -3.2597318908403303, 2.6194926129608818, -2.2367863527015, 2.4691970900202134},
    {2.1142925512364483, -2.6083524831949347, 1.3382666016998086, 2.299334646242386, 0.3678190358279977, 2.3751971179118314, 3.292738298560915, 2.5037182355669167, 2.7886743855186866, 1.908967722396818, 2.9770542641048547, -2.328444076636356, 2.213413912127403, -1.069174640364038, 2.7907946885470283, 0.39612061281465755, 2.5749175338386237, -0.8463677415326266, 2.4085194280638405, -3.876033023495607, 2.0834281673522685, -3.3648601000640053, 1.9165854066293166, 2.986675135022021, -2.6093389836352383, 2.689166265952466, 2.7447464052629176, 2.588062190988647, -3.045748354960499, 2.280028898899697, -1.8804854625836886, 2.4458628159508993},
    {1.8644929345337427, -2.0205791002704516, 0.8475486744560364, 2.3964714231532733, 0.5039025423041917, 2.206288550433574, 3.0565466834315056, 2.0028698729337298, 2.530681435182579, 1.8878885931211593, 3.0970660797740797, -2.3079089901583125, 1.9543086897762174, -1.3277452262557863, 2.2896976590746942, 0.0002150010818296917, 2.438695167356031, -1.1523446682224727, 2.5266095715287786, -3.633968598752994, 2.211955531667149, -3.1866414693594125, 2.378881900833527, 2.9747106586680863, -2.7516713444307457, 2.5445518104121385, 2.676224774048638, 2.4124089052361057, -2.794634121651246, 2.0709864793501165, -1.9123323300173427, 2.615779598869581},
    {2.4406023125627456, -2.5541417316657813, 1.2061042853172321, 2.282429202572363, 0.18218603677774745, 2.4807943548826743, 2.600485080911706, 1.8880536507840204, 2.846028550699422, 1.6574592933074939, 2.9325107976306466, -2.868018744875273, 1.9957685329175476, -1.1981812156890392, 2.5453676938861247, -0.4228961709795847, 2.6993228265161, -0.8414424717765133, 2.250291111054044, -3.8372044839670467, 2.5115749726263914, -3.3299013416681036, 2.3655866709118083, 2.832185597497774, -3.143165314054697, 2.4777032634343135, 2.366341016388716, 2.3445655260417486, -2.870841442094866, 2.25748169175855, -2.4151543859143407, 2.3473029754349612},
    {2.152910292581661, -2.7991469063028958, 1.3134883063300353, 2.5689115784521523, 0.5093865428848112, 2.167702021041007, 3.021074684555577, 1.8045864709007193, 2.9248578970761234, 1.4414220519953662, 3.0097870378739957, -2.992611765292078, 2.238495617724743, -0.9828755152379108, 2.5672156448106356, 0.17657504767097623, 2.7762647187545606, -0.021274944246160034, 2.1269702858526665, -3.5942462150797834, 2.3940750745467128, -3.1693876827085203, 2.395686809554458, 2.7855581727077507, -3.2048066642152375, 2.5724286026876646, 2.4796914185118935, 2.4802847495508296, -2.9454528746445505, 2.678219169415136, -2.406039918233875, 2.3223751530906473},
    {2.28487280606564, -2.9285972486587206, 0.8184454536867958, 2.6786571981460643, 0.5016591098399752, 2.281046207733553, 2.8118906239088695, 1.9223272991899993, 2.8606767956303596, 1.7584034922768719, 3.114797060995172, -3.1086836995602196, 2.129767011183806, -1.2351608621594992, 2.5649028960617355, 0.15921680461961998, 2.7324828459485557, -0.7591630784514386, 2.062026953312368, -3.993378025073432, 2.493245440097762, -3.7213735522578064, 2.4871236235597927, 3.0832222710263917, -3.4107167107690337, 2.7456726163981835, 2.684197165377116, 2.9101049129132255, -3.4108044472654453, 2.370748379878439, -2.626499475027836, 2.546094612312289},
    {2.570051277961018, -3.0911265929313028, 1.033932567965072, 2.483026237313827, 0.7642110768128823, 2.5384808390489244, 2.712557605675188, 2.0314310474720876, 2.7969634510969312, 2.1324729374951743, 2.84112181937674, -2.734410266458907, 2.326988120368524, -0.939312622061379, 2.734737174894931, 0.2819520960441428, 2.817190030173819, -0.5726503315493251, 1.9380168983443393, -3.8302981592816874, 2.3196014682863453, -3.36353170460372, 2.6590436220387046, 3.1303740055041303, -3.450941894929736, 2.9298365909908934, 2.739559268543406, 2.7150936595227773, -3.245948713460284, 2.76320252597222, -2.294813035815872, 2.3462767540417295},
    {2.291034628711453, -2.4283219137958194, 1.673877888493051, 2.7632973649975003, 1.185015491179041, 2.6592685395784508, 3.479252079048149, 2.6122914963925523, 3.1118775083485577, 1.7337568597455344, 3.1834814992572262, -2.4543039237748183, 2.355618954633116, -1.1356074563511072, 3.005239945986563, 0.5895847358127498, 3.1350525818046115, -0.35553094943702873, 2.4400883470603416, -3.5404112634813925, 2.588011543355126, -3.3213074151710145, 2.6642559020091854, 3.0790680626614915, -2.9317623589018273, 3.146525363300882, 2.8087805893815334, 2.7671449604151346, -3.0127826156120894, 2.875512996153373, -1.6921310204304207, 2.6626705793178482},
    {2.0961785587853807, -2.708944076467532, 1.0826440258505783, 2.6012966598714153, 1.0290070462906513, 2.4921520216623927, 3.3285393595704527, 2.0334667511422073, 2.799314285628067, 1.6947972227953318, 2.8628869356095534, -2.4150010036491945, 2.2538034308046417, -1.2185741841570719, 3.2153653243860782, 0.24643749980519777, 2.8805381320795185, -0.5074722521581463, 2.22906993828727, -3.7928223302645576, 2.541991148982507, -3.4724511943521748, 2.5522751349723567, 3.2789266354825184, -2.9802616106855933, 2.879968252753594, 2.256896425266282, 2.735307146177755, -3.064367121005831, 2.6631125891013525, -2.357057444026428, 2.7990336507779516},
    {2.882046186947335, -2.5503613846655213, 1.1086839219108162, 2.6603584035988317, 0.5528911382102093, 2.6453436734961655, 3.2383313703992758, 2.2977344213575934, 3.1100155103460696, 2.150179281810834, 3.2096173614739465, -2.4865542041632502, 2.317583400595753, -0.4271874220360911, 2.8064766161688466, -0.06549831118132411, 3.250508675276103, -0.45535992939544695, 2.318772478299224, -3.6240823538410396, 2.512040220778392, -3.05130417821555, 2.838161831931506, 3.1242379886780838, -3.0288315493382925, 2.8050447685877105, 2.3347576203816693, 2.9938636255275624, -2.9450432701072864, 2.842025647647038, -2.430392260477191, 2.6705967274424265},
    {2.9363641287234814, -2.736172937041798, 1.5207866078725998, 2.8489527788800832, 0.7755256312910396, 2.765579599091654, 3.460073997248271, 2.2625654769525037, 3.138211651101179, 2.3772882143770278, 3.3176597725248445, -2.638169695373473, 2.5704852589392737, -0.9042781590847724, 3.1984014716935034, 0.21245203176935532, 3.114601769045188, -0.8829645184231593, 2.3420002662481396, -3.921003559274451, 2.8765045960435454, -3.6878946375247486, 2.863583013655635, 3.1731393260846352, -3.066302349536044, 3.1155353444114295, 2.809252254149104, 2.798088777371695, -3.1874997081399266, 2.867175948410167, -2.2647978749542643, 2.830191049997859},
    {2.6926701872348158, -2.8515833231289465, 0.7288355276723633, 2.495083169916396, 0.6099538818616251, 2.809401078077416, 3.1641710719222367, 2.4074208100933183, 2.8520363430825113, 2.559140231703615, 3.13865504170094, -2.834614858855629, 2.157976753904451, -1.192359040724926, 2.986501162985617, 0.10728898038247688, 3.35171866918509, -0.778212361383129, 2.43519780992477, -3.8938794065852536, 2.690428794697787, -3.8840471836884904, 2.978863631897874, 3.1867980186436764, -3.75730998186182, 2.912245916227183, 2.6615052919802507, 2.7094276650203084, -3.636134159825907, 2.9694211785079796, -2.8155241303143907, 2.5336171480210625},
    {2.5814546392360413, -2.7717714739893493, 0.8325663757713664, 2.73283997883887, 0.03790106445516656, 2.590137709085668, 2.9838729975963787, 2.285669703291771, 2.8302744572025156, 2.321712549716143, 3.289514631265033, -3.073986203749393, 2.2874538839188614, -1.2326945804693592, 2.881500115538628, -0.3071691660265233, 3.3668733373051496, -0.11877984373884433, 2.4499705662201445, -3.790920002323715, 2.7025207559403377, -3.5460497059767118, 2.8736233671367115, 2.9183454450100594, -3.4443138386057175, 2.940530805419743, 2.833217192399738, 2.911106840701301, -3.2510353239039245, 2.5855326020049088, -2.3509645567692385, 2.3370393757094883},
    {2.3382309136064463, -3.153183888762825, 1.0256929315993248, 2.7140599075642027, 0.4513460734767165, 2.894574163718461, 3.4877023898653454, 2.248914223162438, 3.157681608757642, 2.4201122488866873, 3.1700471246867172, -2.8257640830995543, 2.5497593783088703, -1.1883905298142872, 3.0968277503439303, -0.1303481691899304, 3.2112755990086015, -1.0530771245842843, 2.467850426277815, -4.0413680388335855, 2.890490952287791, -3.7448690443483708, 2.9193217353376886, 3.451219266852377, -3.3843304905025224, 3.5653149202093997, 2.9134862024492767, 2.9631710180039357, -3.740160132594452, 2.952275154169413, -2.537157379603372, 2.761480529473326},
    {2.743827782720264, -3.0227726284319587, 1.1707631872075217, 3.038550514644665, 0.597945060766096, 2.954660260815541, 3.3630548613435782, 2.5760374601142, 3.0715985451148207, 2.29854708103575, 3.2548555346516173, -2.8492746639562716, 2.6214959694541524, -0.9939382751154943, 3.098541772641764, 0.16453566847593845, 3.5793947728752538, -0.8614991347357025, 2.4088658802463843, -3.7411453259183354, 2.804847409170907, -3.764043903789766, 3.0739800827577475, 3.5615183347080297, -3.1355393221538117, 3.4423835182730746, 3.0962001272772905, 3.111174105903399, -3.2812080468444753, 3.062089331299795, -2.4873932666670733, 3.2590716848565924},
    {2.522923877882783, -2.732994673998862, 0.7030392009936081, 2.784071954935813, 0.322830606610547, 2.5224794464022553, 3.465319804713569, 2.565683434925333, 3.2504723237883186, 1.8574273531363747, 3.4281686744880386, -2.7723684262161283, 2.14396497016247, -0.7682997099078362, 2.8433787261671, 0.004989028661246276, 3.4138546851189755, -0.5429414870154865, 2.454672739012385, -3.6164968408446088, 2.521596301610237, -3.609872654690643, 2.7519175098544877, 3.4071432549382843, -3.2884929494568813, 3.1445979676839286, 3.0485848848163695, 3.09325160765844, -3.250935423579287, 3.070683992753623, -2.1919988516949576, 2.8327595131221326},
    {2.7691027804891966, -3.0880636151710084, 0.5628913703205031, 2.6872779702213068, 0.5472957349695183, 2.720826246369684, 3.1971117361864736, 2.4532200835312294, 2.831831120802475, 2.1273997847207187, 3.282522104197938, -3.3554969141961286, 2.2841993012181505, -0.7035622245848686, 3.279700951200762, -0.04528549598727938, 3.550463996055922, -0.6962795306247129, 2.4325850243845104, -3.793779841558153, 2.8130885669718606, -3.5978322038704778, 2.821190356134074, 3.464476647425873, -3.352048493816997, 3.423658637947125, 2.957878333307172, 3.071881948079682, -3.236344754792825, 3.2284947340550465, -2.4421722612172645, 2.7850011354656647},
    {2.6160100605335312, -3.123715413250359, 1.2333571436532547, 2.490035737117879, 0.2851419612843389, 2.743133026399635, 3.305724913798018, 2.3866840417789312, 2.9298337535023378, 1.9097957923457203, 3.0101637021077043, -3.1260788442777394, 2.817670643701102, -1.1351515152891618, 2.8282328984469207, -0.07176196577534044, 3.583827588707029, -0.6320783575275977, 2.501064120523756, -3.8997236238283355, 2.6733336876874767, -3.642447243210259, 2.8335527427620737, 3.23796003802245, -3.3887854978717575, 3.0445552072563142, 2.8572092300423693, 2.7550486341237512, -3.564869045521651, 2.753787017803917, -2.438592837176383, 2.697796032812213},
    {-1.6721326183913003, 0.37165318472424225, 0.9970657758877359, 2.2162997876265216, 1.9096327317967978, 1.3393227100701377, 2.188284203306838, 2.123907023278348, 1.602466344907015, -0.36449536690027107, 2.5209313826253474, 0.06902838197921433, 1.6419361896454383, 2.007768536331428, 1.6914229974102692, 1.9199983517008492, 0.2600957688445769, -3.033229324527379, 2.128869925995578, -0.313277581829975, 0.9020017462189156, -1.1438231734994764, 0.821062513750648, 1.4641200021095349, 0.2582620657718519, 1.6133701017931743, 2.0555848992618633, 1.8198286758513413, -0.35452471965979043, 1.4086769982319505, 1.1138962619761428, 2.0159209070334367},
    {0.5566711263627301, -0.5402554649196765, 0.4427360343314766, 0.7575039464290043, 0.011389060036875702, 0.5338091026818718, 0.5010207224510338, 0.7982900117538754, 0.46970625452976483, -0.019987240655591727, 1.3395586344666834, -0.10616048636043418, 0.4459785007308985, 2.5330014181264846, 0.4523923475312321, 0.06574525918614262, 0.37027616256764, 1.389478503129897, 0.40665655324965366, 1.3128076135014874, 0.6110138376451767, 0.900002632814915, 0.07925085615562429, 0.12921663999881589, 0.09468486862845824, -0.03606112740605313, 0.747614479384326, 0.5870906713131736, 1.3485101992214938, -0.34090618864445726, -0.33708780982213443, 0.7217403850566265},
    {-3.262111180036904, -1.847123824037319, -2.035799222472921, -0.582705606396152, -0.9382083123150078, -1.496227559539446, -0.7095196467892291, -0.7619646125230688, -0.947408268600929, -2.3956045901083565, 0.5343033520831971, -2.100940096940143, -1.498866883016308, 1.649728793231695, -1.3906669099762166, -1.5023881290527619, -2.382657670252006, -2.1591485350624153, -0.5088051099897343, -0.3367408125849746, -2.0250280962460483, -1.354592853851331, -2.3250466984768927, -1.2071376186516254, -1.6752738619125402, -1.6230094560101782, -0.15231158858668115, -0.9912271595141179, -0.23465714414205643, -1.925163745363715, -2.168195906587833, -1.1032619726720287},
    {-2.620765422935492, -2.108669083094885, -1.6446644741730096, -0.7366372363054715, -0.9376350647026597, -1.764019057231191, -0.43650397538961994, -0.701928396944532, -1.0046084709118024, -2.283643278848116, 0.6077817717910869, -2.488103384471171, -1.9522128485031258, 1.0860669223893926, -1.0950874835840478, -1.4370753782425096, -2.274750631117437, -2.0950786185767565, -1.1576913050192967, -0.7478114770306725, -1.6417784398386328, -1.461114746533316, -2.4442994371470137, -1.101210632197687, -1.5221374161908146, -1.6897861699669303, -0.48103141020244455, -1.3870594228680877, -0.5648711790576653, -2.3805659948901994, -2.09367132244619, -1.5549017260089752},
    {-1.3083527264039942, -2.6467213004216306, -2.561581240061097, -1.8461246915563505, -2.002135395530007, -2.1194440818872757, -1.4416528860502646, -1.7178996737699288, -1.52657093202915, -2.1063367024976034, -0.4191683226709555, -2.373589307752764, -2.4007788664877254, 1.6815580818660383, -2.2560267176493123, -2.2199842858334815, -1.9672775746728666, 0.28739355419248114, -1.8707192641078842, 0.6727593679729849, -2.4156138602606947, 0.13799189647320437, -2.3731114058632428, -1.762380071702467, -2.150252643292441, -2.297730027931579, -1.8399223724963008, -2.0197194954029714, 0.7758165875027799, -2.4262637109244958, -2.7254356214963087, -2.4917160977620605},
    {-1.335064540960874, -2.081793841156596, -2.24470303067881, -1.5506475286092591, -1.8297674269767272, -1.724521381620124, -1.0509737431052955, -1.4525909672149695, -1.4904118887106093, -1.879219308627229, -0.25375237091310415, -1.7336573761041139, -1.7685649094801754, 1.3417572805963494, -1.8588488985333593, -1.9056424518358686, -1.920170039431009, 0.6482803532756279, -1.227830692986819, 0.38170602647679375, -1.6207802261963153, 0.06982396882643269, -1.9086456681787187, -1.512229992879517, -2.041130094499697, -1.7269268506681974, -0.8102782887078464, -1.3761380728896366, 0.6827921632097158, -1.7220096869919923, -2.374431602604715, -2.1846194351409824},
    {-1.1733066997122414, -1.8336777833141045, -1.6375571534290905, -1.525968472861863, -1.030513083614678, -1.7259867037197365, -0.7424495999209615, -0.9877144126482177, -1.2663163602711918, -2.3364744781557945, -0.19218505593274504, -1.639810655938857, -1.4187831218136593, 2.166979737911209, -1.6170646843087466, -1.1764440629425377, -1.3345111454399567, 0.4381962763779819, -1.4552388620934615, 0.6698571130397164, -1.4475958096551185, 0.36004572279840846, -1.6329609079610872, -1.4474536257075583, -1.7360415553459323, -1.7396095469140092, -1.1345594161973387, -1.2685894202875574, 0.8161477607323748, -1.7883604035145892, -1.8456178803179297, -1.4063629249173513},
    {-2.2964296003584286, -1.9632491952039999, -1.854287588401454, -1.3001867336796842, -1.3068753329164997, -1.7441074090722002, -0.9877664806656614, -0.9873950010297424, -1.689115535473837, -2.258907057394446, -0.32295155846332774, -1.6938964245598025, -1.8885277669844784, 1.3074835278351393, -1.2854182021925202, -1.5946826629269875, -1.4223488606742654, -0.1468245375704419, -1.60398225145502, 0.0465149040566056, -1.6775971644795868, -0.2517595796133592, -1.5662080534195302, -2.0229563624538387, -1.7413443517896394, -1.2897570927313948, -1.1724949455215283, -1.4816017747861723, 0.17660662108900713, -1.7935965946210197, -1.461172026899435, -1.5784707053252576},
    {-2.1932512716949906, -2.15051858180046, -2.244047459415127, -1.3414843703624393, -2.064230390608103, -1.7776836451696152, -1.591023426162246, -1.7282214793268649, -1.6867391004164218, -2.5440775791988717, -0.17113252167267617, -2.059432282186571, -2.206336250606805, 0.7537389766389616, -1.5109476183426371, -1.9681197039177052, -1.4914349128763902, 0.006771015666524487, -1.6158763792637423, 0.22548611534627677, -1.8724108437150322, -0.34489974488031594, -1.9605484130334276, -1.365825158823943, -2.0899069186974923, -1.552128407740988, -0.9563076891175839, -1.6172912454856745, 0.2840164202337062, -1.91356259794381, -2.1608362220937583, -1.989892235279005},
    {-2.2643436732047686, -1.9907918640190125, -2.223002277518163, -1.4628636788690526, -2.0512821834017227, -1.777749411923956, -1.2047519476041353, -1.2623801612957468, -1.4622924292875512, -2.310619032422761, 0.21596534545359086, -1.9400916669097765, -1.7583643318849889, 1.7758408300566935, -1.5311878145512177, -1.9397671044569669, -1.6294970376622027, -0.4732850572349852, -1.3098586537930628, 0.27148141723820013, -1.8155696625634459, -0.2530636268604494, -1.4296614416507962, -1.2228643624258122, -1.5687344650916493, -1.8092814598923217, -1.0865156887560423, -1.6931818901928513, 0.8735695345579305, -1.371024271579576, -1.8081047594647968, -1.6524114490202426},
    {-1.8383079305847736, -1.0126005678631413, -1.6777846080782317, -1.2656295311932197, -0.8736727538592021, -0.8803398729740549, -0.43144417042327876, 0.010782993258439354, -0.6681449483664436, -1.3236363215340163, 1.0565900356284241, -1.3359919095553963, -0.322433993137528, 1.7588605662202608, -0.3279741757166086, -1.026407887857098, -1.4398875454343205, -0.4468018677978715, -0.2525242796735771, 0.4963286617170771, -1.0396742674057033, -0.031836071912640436, -0.301267611320122, -0.4412147814964733, -0.3817325066274565, -0.14902816964147872, -0.22850471340643413, -0.4329459368216484, 0.11030195805892552, -0.6383561912611472, -1.3728290891144779, -0.8652507322553626},
    {-2.508269213271013, -1.7963270684850854, -2.2385542876220756, -1.5180878355470133, -1.4168244329641515, -1.229902710543503, -1.1659055370814613, -1.0575661574551254, -1.2386767920537627, -2.1356675375596765, 1.016938009218772, -1.8709226054349475, -0.8780798913326606, 2.0372475336958917, -1.019060246166835, -1.724626694991247, -1.8508699596094458, -0.7526380828237696, -1.1008032180184477, 0.43812706875300567, -1.4630248179281335, -0.12528911758458516, -1.6372199551595692, -0.8603435151077359, -1.8342860011856086, -1.0864471673413443, -0.5027341186469957, -1.1675417078141588, 0.3481029895955764, -1.5303860768350825, -1.9290744068001326, -1.574398350927781},
    {-1.9591398503040007, -1.6612381470816144, -2.146080939260564, -1.4759453524042077, -1.5505005988563092, -1.4725968147422814, -0.872339488202653, -1.5928276392882803, -0.9267536095600591, -2.1501943535587738, 0.9137403743275498, -1.4023388602695304, -1.517453932960086, 2.2351316751884345, -1.1820204796405056, -1.7444462953022513, -1.639864806006334, -0.3064891976558799, -1.282526405897491, 0.7639242580872084, -1.5423798970275435, -0.10747702207990055, -1.7503673049646413, -0.9007306481617997, -1.4894660429722963, -0.8043436767670057, -0.9155784271736813, -1.1016559512609663, 0.26808986753496794, -1.7539782736308003, -2.219473349763133, -1.5529483779217539},
    {-2.266142630713409, -2.155257070398455, -2.5077822424695326, -1.7776790077170617, -1.8402634138206255, -1.419458180976893, -1.310738228947745, -1.4810375010007997, -1.2637338513306524, -2.345865048435097, -0.10825833233954532, -2.1375689712613246, -1.226169721177592, 2.2281921949756565, -1.5445379038775229, -2.158313356097775, -1.856319529913463, -0.695910485969636, -1.5204414382779718, 0.27847487035402474, -1.5743376948583268, -0.8133110284662218, -1.9057984207465017, -1.5312551370211758, -1.9185757943325836, -1.4398309355217762, -0.9895740265468279, -1.5746613221844203, 0.130390394115335, -2.3266142261882075, -2.3417517321016645, -1.728732187558059},
    {-2.992017491271514, -1.8953475767674721, -2.0298947104966256, -0.9674677590584573, -1.2130795538367556, -1.4908312757250246, -0.8397409281262919, -0.7969241336759684, -0.8257287279028864, -2.669412132675211, 0.7050889750903755, -1.7544897800153658, -1.1938009915564607, 2.7293731726058503, -1.1460146521959453, -2.12743777193626, -2.1079289563365116, -1.2222581282543508, -1.202831202932903, 0.2614881238523579, -1.7952035350968791, -0.6589294412924435, -1.949805819471891, -1.051347715299617, -1.5337860463840154, -1.400362380423603, -0.4310215778171049, -1.577082998458103, 0.3971819053639163, -1.7896218073064813, -1.8461446078967483, -1.595080604749821},
    {-2.4062969722577296, -1.8688979608065288, -2.2215462237281622, -0.9648962484715743, -1.2712563732741553, -1.1471439302901387, -0.5739509242384666, -0.7365179508393603, -0.4409297078694464, -2.3293752844323303, 0.5022648711783813, -2.1432726171709358, -1.3131637159497793, 2.071361570331551, -1.0694549258728676, -1.7486261256201978, -1.5408030518800078, -1.6647132942444693, -0.6705590118034416, -0.3141892837853158, -1.576872936322607, -1.0895937588599034, -1.5769947677664564, -0.8394499090827124, -1.8778770235532323, -1.5193906846723118, -0.6639446066625503, -1.6272544381842502, -0.41071107697224585, -1.1151488113177004, -2.2605509678482774, -1.30811019146612},
    {-2.889753377381226, -2.2798479011059762, -2.463031679769879, -1.0296280680499281, -1.8301758328568971, -1.9029526182897387, -0.9765650245106736, -1.024357179337121, -1.1281902442353344, -2.9092979265735677, 0.40009375232934163, -2.1989577451620317, -1.2513660436337222, 1.8117699226841673, -1.3974170520549032, -2.0865915644584327, -1.6085892721612527, -2.2450804037171808, -0.5567244559035537, -0.511824204398555, -1.6454815773796778, -1.2342097979627078, -1.9263367108607474, -1.2828451489374322, -1.9625777017350734, -1.3329966069331944, -0.8072712691058964, -1.4957530867625446, -0.4972569814792747, -2.040012070615418, -2.2462233734612584, -1.6452762720210752},
    {-2.8394411031224105, -2.54769285674385, -2.4809279738836185, -0.6501507943831208, -1.4986046281180925, -1.7935546772880044, -0.24508864089650512, -0.6327391493731085, -0.5656292250467037, -2.5467986877918483, 0.9788892540499012, -2.3326351920623334, -1.6067164132753229, 2.426899978002281, -1.2181342584231116, -1.7228901707910305, -1.5198468347358922, -1.548022859365426, -0.5603900832196056, -0.38334949918331185, -1.1506954625853496, -1.5024207444479845, -1.7767074154753273, -1.3322560905118797, -2.3164115536158794, -1.6834398437282083, -0.37011195693133586, -1.4699806624689862, -0.1853127947251144, -1.891453256846424, -2.957304268919499, -1.2032356417383774},
    {-2.4643638652155744, -2.3334221371846535, -2.273331461639244, -0.3825814926770195, -1.3127484551379702, -0.8548738177389996, 0.02477368383447131, -0.3541313956561809, -0.38220764216887215, -2.4762396229439303, 1.6499695823631728, -2.1672036159195125, -1.1006234931597803, 2.293351450437995, -0.5712235158844389, -1.715997469810109, -1.471231824368919, -1.5666521541130278, -0.10011700992414804, 0.021928736995759795, -0.9954747897789876, -1.0064627884830497, -1.9030750696725351, -0.8576724931525704, -1.568754771958077, -0.9654897808025025, 0.05678120854051286, -1.0825691300976243, -0.13125455450470414, -1.555108822054539, -2.401384551123693, -1.0860431684130283},
    {-3.373359969183224, -2.601553335850852, -3.6206470679790934, -1.272333242518904, -2.1738526560543816, -2.028652310818752, -1.0561035929744902, -1.7114678185697891, -1.2608575806943638, -2.9753848726084384, 0.5547613642306415, -2.2579558170364566, -1.9191884034905997, 1.8019817536923712, -1.872056261967534, -2.844388057996366, -2.544848561131985, -1.8239507274897806, -1.3347473481509677, -0.11777871854447267, -2.041885761692821, -1.0212758158500757, -2.435713911983769, -1.861282065740546, -1.942903755293517, -1.841833827529525, -0.7171343977184332, -1.987928062512951, 0.10558539752141297, -2.8620096599400044, -2.721213845524905, -2.6423331158673093},
    {-3.0688400062552836, -2.7871189383603463, -2.5047380580386536, -0.6576308508938801, -1.8208302459783887, -1.5670258469648637, -0.6960101429523077, -0.6012165869594915, -0.7152021631406331, -3.1334397936343343, 0.6399579655437568, -2.7763900259573817, -1.560791909901666, 2.1788148286824693, -1.7340070306438828, -2.1168678488087376, -2.3791233930404356, -2.557839151073485, -0.8356081071055866, -0.10374256444577648, -1.5112088973968256, -1.5145973441376726, -2.2855097226288716, -1.667048526213394, -2.566493319806074, -1.7294376342653184, -0.6361515314200962, -1.6472333142382103, -0.051651066111375536, -2.261738870509904, -2.9672547523835973, -2.0810178838224065},
    {-3.7460270126008512, -2.792598143675509, -2.3005622754673394, 0.45862244089358917, -1.3975542454322758, -0.8214754680708802, 0.600996476578285, 0.643044618641106, 0.4192960225821672, -2.8588656735944, 1.7351988421856654, -2.904478993344712, -0.7734907495173104, 3.693168927539079, -0.3022137274724878, -1.8628153782695596, -1.5204397435260977, -3.3011544496554666, 0.5771914527024219, -0.20344235216580198, -0.591886822831035, -2.1990299709401144, -2.167592922330335, -0.7250738477938319, -2.0118412057791124, -0.6652990580218742, 1.0210650216535162, -0.7570705309719337, 0.4648686884183912, -1.5503952342107237, -2.9218139130466603, -0.8085439655197467},
    {-3.216557067496547, -1.5505541998001018, -1.5987628200953112, 1.824177434670368, 0.4863870317063453, 0.20831990741987744, 1.660069310247298, 2.0857968588638833, 1.8739455126195148, -2.210859298823179, 2.988733200474894, -1.7472639847068105, 0.30062789383134747, 3.8440857507654527, 1.021895564090838, -0.25565872072883056, -0.47176091284399313, -4.083190996496918, 1.978250133884898, -0.07170294588324716, 0.48387077567977693, -1.875987618262633, -0.7732084553290988, 0.4759651225672766, -0.8893820114375401, 0.4049346936164626, 2.047782760804637, 0.18839122590460194, 0.6943993966200153, -0.8415088440783607, -1.6580874359816358, 0.5943708022877366},
    {-3.4287401901597176, -2.3011385490453655, -2.261840819892497, 0.9032774620803394, -0.5998146578797976, -0.9182074878571124, 0.5667584583948972, 1.0676561856829478, 0.5021790930956566, -2.825128896228839, 2.0195608309850126, -2.6103469303371467, -0.9151402964882254, 3.34583500962905, 0.0461887926024482, -1.0639263896359732, -1.6801960248047705, -3.9449100187925046, 1.157125302961541, -0.6295666096515476, -0.5216012355031016, -1.7693588872804078, -1.8472265511544255, -0.4519929106244322, -1.9764822951165149, -0.5711129984656188, 1.3923608519843484, -0.4543027945717418, 0.1442019492392884, -1.6352828377397732, -2.168622384056413, -0.07915815653239207},
    {-3.738949192581022, -2.785289208559404, -2.7200389243590526, -1.0311436787686221, -1.9578732118052748, -2.0900107417945795, -0.7898730996585799, -0.5463342118202044, -1.07600930064808, -3.144178641574345, 1.075513443245672, -2.95622796321444, -1.9274553717230127, 2.737824422937532, -1.649306724801744, -2.4567665859025514, -2.6109726414206067, -3.076649342485367, -0.5153752775065762, -0.5758446106616563, -1.9529404206059595, -1.9405051942025178, -2.69209725003678, -1.7491397721829445, -2.446395758645973, -1.7822322169309501, -0.5162847399356638, -1.6104835299894993, -0.3058027075665282, -2.7973620058552604, -3.0977117218306693, -1.4619148135646578},
    {-3.862602239872916, -2.2486939761139215, -1.5776509134681673, 1.2164013591373228, -0.0814561435031727, -0.5251260272918857, 1.0983213148112194, 1.087808780726894, 1.0531687728693915, -2.5616894408643924, 2.422104010345993, -2.4900604939826487, -0.34649972124009026, 3.1012960436503696, 0.2798017135196556, -0.55057359156915, -1.2695171672957697, -3.8630652349104584, 1.1529985127914306, -0.5273121872553622, -0.5432362773245376, -2.2686259180366, -1.3165586113995036, 0.05587805690825033, -1.2630477700868823, 0.09226132341234962, 1.253985830970961, 0.031326223951907685, -0.06336159438193056, -1.2445941167540426, -2.140277380247228, -0.32135267972064857},
    {-3.6500274008332436, -2.143585866462987, -1.8094569685733075, 1.2748319056236102, 0.20910924069165238, -0.30392080476922023, 0.8477816517599803, 1.1397011856327626, 0.841171759076761, -2.7691407325439603, 2.189253559592867, -1.933502939485627, -0.43480658659626353, 3.8967034866334354, 0.1004306030008101, -0.7297627130217942, -1.417230168960241, -3.8829225774543663, 1.2321690278080177, -0.008796473714052228, -0.561052359798517, -1.5096887138069812, -1.4849136855470082, -0.2437822093014419, -1.4593171600922437, 0.02321003416189181, 1.6184495661296239, -0.07977092691415565, 0.5712129411778979, -1.2593907009767218, -2.011919770758653, -0.035294759552282826},
    {-3.680583391634166, -2.323120784006066, -2.0906513147126353, 0.848958195094794, -0.7046225941815905, -0.37711980951254614, 0.31151295032088633, 0.7968256904322871, 0.41252466491618606, -2.847914470085871, 2.2156366405574777, -2.7003299971364343, -0.8916198116515062, 3.192965932342263, -0.17028909607931617, -1.198047154768935, -1.6926783660386076, -3.824664420730011, 1.0777477674622689, -0.6691721715381255, -0.8036132320578845, -2.135401328159351, -1.585755665202066, -0.16248363508382946, -1.9573753980313062, -0.5776477486431496, 1.2613063064704044, -0.23637214836092613, 0.03032228028553827, -1.256719610654668, -2.6414991824165446, -0.4073829773365938},
    {-3.7108216118956645, -2.6013686807482754, -2.0278383059373057, 1.1195105557095522, -0.14493627951397048, -0.14566865434269355, 1.0306291139629338, 0.9866659273160486, 0.9453529487538552, -2.9484524067430464, 2.4260909043958434, -2.9383582696392287, -0.27870415339108373, 3.565036186739724, 0.05007846672040833, -0.7960527428032333, -1.4422111065791556, -4.225393452515863, 1.4338641675525576, -0.6111112023842133, -0.39901107215070614, -2.1453641956718417, -1.7629198688839385, 0.12771287921338587, -1.866545543541098, -0.0593532665854217, 1.3542058051657335, -0.3214164070399702, -0.42067225566145233, -1.3361652285721426, -2.268163132522859, 0.028699135714886463},
    {-4.008473078194413, -2.060745142596736, -1.8971578235489661, 1.6678291708425514, 0.3064936709715796, -0.0711075482488951, 1.0885801833110522, 1.41539693322706, 0.878721460130878, -2.558114411180294, 2.530556050917366, -2.373073093698445, -0.21099702835312276, 3.669671135364886, 0.2691856505056066, -0.6955525843644055, -1.566411671623227, -4.62204344489007, 1.4073684684815067, -0.8582377570347948, -0.24894331617328413, -2.572010881281641, -1.5210638716870473, 0.17695611338038653, -1.6842435101396784, 0.09623649613378246, 1.6284235713804887, 0.15564659145919008, -0.4887881775279177, -1.1562074364942503, -2.259531125386361, 0.259821330265646}
};

static const float b1[32] = {5.77228892930848, 5.643593156603534, 5.450000549457349, 5.3109314675387616, 5.205529502158514, 5.308038441512932, 5.400205088788571, 5.251597079013269, 5.180157718448328, 5.5049903155342506, 5.638155706834928, 5.6517522479763835, 5.268407343977416, 6.2884453959874484, 5.365408970674782, 5.347541384675634, 5.43864251955464, 6.249536045371187, 5.321553131911095, 6.444985446206104, 5.336860807292201, 5.974205354501018, 5.355507029977906, 5.293882307337675, 5.788478809535498, 5.392089078321857, 5.276659420976752, 5.265321036681914, 6.291273405009621, 5.3081427601850555, 5.6207915220851605, 5.471000008239763};

static const float w2[32][16] = {
    {5.064503430863888, 0.06479065998921864, 5.263720240824992, -0.08889185309886623, 5.155814833215129, 5.328895991286584, 4.282609934615362, 5.449229224808678, 4.540996395239534, 5.039207906254205, 4.980283890032771, 4.916538841004628, 4.491894755144373, 4.711248917781346, 5.073070358064764, 5.192772229536303},
    {4.605248437769429, 0.16420247045193245, 5.086886888519308, 0.21130132568249657, 4.946731009427399, 4.2153591951992535, 4.0237487681251825, 4.782508924842969, 4.338876052906428, 5.2120510314350135, 4.9488656373506865, 4.752653496717752, 4.410925412013403, 4.5781492479537205, 4.764142855960026, 4.9058469450633595},
    {4.533588878535043, -0.1142422069866722, 3.9221078232463085, -0.04054841075215569, 4.36987514674006, 3.9958817887843647, 3.7789178909403445, 4.389818613244182, 3.776746145100448, 4.299834080284747, 4.59475583187153, 4.34683261382468, 3.6048458911956986, 3.671258215535309, 4.391703220099688, 4.214512814849608},
    {4.4754726951668555, -0.20992955963673443, 4.500676862659813, -0.11103179368539093, 4.500493667584002, 3.7737742849135354, 3.5567157483025618, 4.534414929407312, 3.9805465920478516, 4.413935991906614, 4.448675035456695, 4.387033828034711, 3.474474339992205, 3.986256880981532, 4.495406875792149, 4.19718973992197},
    {4.338239296010017, -0.07635290438750433, 4.429112533362609, -0.1192777451669075, 4.820000433174281, 4.296199568278889, 3.6481867909155836, 4.634287211422445, 3.753573525232631, 4.5364879320521805, 4.2892142829439965, 4.263796009352789, 3.8562159946467514, 3.3207951240693268, 4.264316644279421, 4.813925065447692},
    {4.260451948438686, -0.3129170558702972, 4.364418899272013, -0.04989650027758787, 4.080753575702291, 4.06593136371832, 3.1826611825150772, 4.531501332963428, 3.569550973914489, 4.31585999106376, 4.547548773020042, 5.1232179153118675, 3.5897935058449493, 3.874227423870709, 4.231968224484362, 4.489538902275262},
    {4.701222920607212, 0.2757765471598065, 3.8821426498871903, 0.1268564093394229, 4.174994561493053, 3.821056765247776, 3.855299856191204, 4.523391568255251, 3.7124938827177263, 4.763150955783947, 4.526831182912123, 4.57099681653401, 3.7007560007820777, 3.693722593248263, 4.3834434248934615, 4.509231489623967},
    {4.54583575684698, -0.3974653509818936, 4.863723113000551, -0.1479359194441617, 4.588281625784738, 3.8822389177222805, 4.073635343145563, 4.500925484751942, 3.457551427895879, 4.380083106252941, 4.739197156743755, 4.5132885494864246, 4.061813272877738, 4.135427875628926, 4.674775278087036, 4.263282011849026},
    {4.142298104603118, -0.20495889695723066, 4.015461006771359, -0.6505963752454434, 4.887043103720571, 3.904640492205514, 4.4584473997927, 4.5725472338709485, 3.9693015539573757, 4.446546331433167, 4.276178105667697, 4.552910730762665, 4.032873006160838, 4.061635646710471, 4.340553398205516, 4.75312107815053},
    {4.480039729195516, -0.16619016389909835, 4.524632017504429, -0.19408882780638828, 4.692424623189994, 3.7853159138019303, 4.125345583804472, 4.402450657638869, 4.107541484911681, 4.807150736970721, 4.498246059963715, 4.2530092029232955, 3.8489097030054116, 3.723042404907322, 4.276823094871221, 4.216964495958045},
    {5.049277209666302, -0.10603910379114087, 5.286699744238586, -0.19962773888527519, 4.605832329683447, 4.167384882629894, 4.085023148502562, 4.534411846089862, 4.324928981876088, 4.876522133427339, 5.1269270384107895, 4.765199340550159, 4.314079609877121, 4.598973306703102, 4.922754108921091, 4.364675195021895},
    {4.9318703088175635, 0.2386927599214985, 5.366174596696318, -0.14433627329538168, 4.442966988250759, 4.743802077349235, 4.621391876190287, 4.532752666298769, 4.132373366520094, 4.591732660366737, 4.9412703954915385, 4.702905154900211, 4.084433871260071, 4.13098772435209, 5.140053673423475, 4.5065073535315845},
    {3.8998653150475766, 0.1876530521755994, 4.1577684594736795, -0.4575572106056975, 4.088019915199852, 3.8755720816213737, 3.995651608323271, 4.320789914419545, 3.819886709023061, 4.347437378485982, 4.3609917307102934, 4.768897721395374, 3.3635843721630856, 3.7336457917208983, 4.510366818923036, 4.840102903883452},
    {4.7504008795956905, -0.33189716287459314, 3.841181519526459, -0.1737674379120173, 4.303607738020752, 4.008412768641341, 3.3291285167648765, 4.470144957312019, 4.153716435146572, 4.790469131763586, 4.48936171360102, 4.6156417986891904, 4.044318406164026, 4.061932366624334, 3.9018089117808015, 4.94198019843888},
    {4.3914528960850925, 0.018560096368413336, 4.524788909518194, -0.29334552664787394, 4.203078716618944, 4.026741333091949, 3.268202224719142, 4.579276133354169, 4.1184677877241365, 4.756547251735623, 4.3574209104567085, 4.347290918145359, 3.910569989902645, 4.145170648864081, 4.071567351923282, 4.371564659195973},
    {4.025950929305721, -0.0196523611911972, 4.728200131369329, -0.26061216867983894, 4.302993662211696, 4.015671553998295, 3.654938247314015, 4.36729026898736, 3.3906653175879033, 4.065051137077164, 4.573660669710299, 4.427189934416017, 3.696010097942288, 4.118113087563782, 4.628819922975163, 3.9996591807924196},
    {5.106075175550385, 0.03233739300613776, 4.266164291933939, 0.11638506848128473, 4.601707518446781, 3.806329647271179, 4.13227727109685, 4.235720928390961, 4.1362525278374624, 4.77645234184971, 4.43981947825713, 4.701500937532475, 4.241350054223703, 4.01460483128595, 4.2276985815885775, 4.825081879069689},
    {5.9590045449297016, -0.141949547325916, 5.211950885534022, -0.26242239911943627, 5.910653068451324, 5.320541833377805, 4.993853022472212, 6.09308064060158, 5.093373986621988, 5.7786857802346825, 5.578578739694723, 5.379547158227046, 5.064712821974412, 4.886490149862823, 5.721712625589781, 5.522568692098166},
    {4.293367283346914, 0.19003470440836606, 4.459829329741354, -0.15651752496570018, 5.063631771427051, 4.11064688652448, 3.3596202020240122, 4.4469849064463505, 3.745319394782209, 4.749549284864982, 3.898648155263511, 4.305986382383071, 3.6616466457009396, 3.8529468815143586, 4.372356239152897, 4.569393858562447},
    {5.152369576817522, -0.12688051649045065, 5.025158546594623, 0.23685508483154258, 5.418183157645112, 5.081646726469141, 4.010983720398383, 5.221360945638029, 4.584779179227671, 5.340862137358916, 5.225802015104423, 5.301664589497884, 4.434824286438955, 4.667639795153795, 5.201703225301193, 5.338104576064182},
    {4.351707778527321, -0.38040578602505015, 4.187979740846989, -0.030968087199074207, 4.658287940465749, 3.9935091067563415, 3.860981252960409, 4.092990113420188, 3.993365202837277, 4.250757992861049, 4.482777002146126, 3.883330890158515, 3.7230267534062538, 4.0173199969027795, 4.53563371647769, 4.6659198180797965},
    {6.414163253897862, -0.24974850272096705, 5.271267564611175, -0.025094548750238074, 5.639949616927815, 5.2223239224584095, 5.3536509541924495, 6.206384855978786, 4.99343489691232, 5.533743674530573, 5.27366191481572, 5.915942693571727, 5.342106555991072, 5.307359460443598, 5.539671731942105, 5.8112177918179135},
    {4.819544595064641, -0.44246936962927413, 4.139199056344612, 0.025957404787123033, 4.6199493817106, 3.776604279704508, 3.7177063527971286, 4.374979110604917, 3.288191914489156, 3.9908418696358594, 4.028140935220973, 4.479288753103805, 3.9642654940095565, 3.4956009779392585, 4.460600235651976, 4.7811188774101545},
    {4.617003563431995, -0.2654210751246808, 4.824608750648148, -0.7297114440183033, 4.267089893413261, 4.288215338639047, 4.198090221065858, 4.4974204510954525, 3.9940789581688274, 4.170559721606981, 4.541173289507055, 4.486353055764213, 3.7734567668683767, 3.745713581315888, 4.64561489707935, 4.155582787192841},
    {4.893181229520767, -0.27720028915272815, 5.241084266268422, -0.422218628026543, 4.8448090427064345, 4.682992534117587, 4.183921105592103, 4.415037839776838, 4.124209695728121, 5.010480990164406, 4.52650265682784, 5.077595503928258, 3.967360464828423, 4.168344380303537, 4.832230872906943, 4.612973264448628},
    {4.1075866898110265, -0.1949357393073812, 3.976546033425968, 0.06359485846087126, 4.367877302608903, 3.9999220643469324, 4.0409893044220695, 4.509144374383173, 3.6612086572575695, 4.566422736046471, 4.120521642133613, 4.552489985483248, 3.5562072078522275, 4.0989369170648375, 4.2782820765248495, 4.491713809202292},
    {4.341828569862081, -0.16939420739335545, 4.44798230991619, 0.031460711622165675, 4.266494862087932, 4.15033700733185, 3.9097808075027047, 4.541704754454103, 3.7051043027417765, 4.798215013367665, 4.392185603788075, 4.577406025807106, 4.351516196329034, 4.076471092336526, 4.421852972347013, 4.843248864341283},
    {4.673063845234658, 0.0155714264880789, 4.304833175578603, -0.347647253378095, 4.552189419583585, 3.5218270997074645, 3.888223909407479, 4.315544441693055, 3.844256463697625, 4.581270047475183, 4.215883997121268, 4.60155718130519, 3.560569473587931, 4.011327283830217, 4.217192992725781, 4.879122603961609},
    {5.456286427287146, 0.02023082850286546, 5.033041801355133, -0.15033294144679832, 4.823398628371966, 4.851957110496399, 4.4609711618799395, 5.82693794605859, 4.6218217112214335, 5.676996164178434, 4.843913224686404, 5.492056812608577, 4.808742298775742, 4.771227024707285, 5.236282733679719, 5.653945530720414},
    {3.803024413079168, 0.28160052698534377, 4.20393911820655, -0.035800472457645977, 4.348360305064736, 3.9215105161949624, 3.6488330302217897, 4.350063754453697, 3.7074529534191583, 4.734824004617835, 4.699344581962935, 4.4258652484720225, 3.236144594492396, 3.612355834725083, 4.62955642802305, 4.593854694384173},
    {4.810714514643665, -0.41982192488292724, 4.427962325083711, 0.1861335118835802, 5.165559789156297, 4.137941174627937, 4.064907598481338, 4.810734661433942, 4.1675258695865995, 4.815904246368816, 4.912867996896974, 4.4662528664023915, 3.7661182552694727, 3.963038154223277, 4.376277080039104, 4.677541356215204},
    {3.9822054723036473, -0.13046867650493205, 4.229809664489546, -0.18624531298079863, 4.317820342348469, 4.280077262640092, 3.803978139251539, 4.009341420941143, 3.484291745856841, 4.360079286406499, 4.502631100252458, 4.2908270024639314, 3.639757008922706, 3.6402822632089067, 4.138198856075045, 4.1240703986066265}
};

static const float b2[16] = {4.888246196449446, -0.09441798032429831, 4.756652112624171, -0.08851357476447334, 4.896315881435812, 4.917279970235177, 4.586391732329381, 4.907242596245277, 4.859723619602939, 4.683356509323528, 4.5294053541599535, 4.802762713609641, 4.642602466639056, 4.926695060334315, 4.550813176240095, 4.747336744922427};

static const float w3[16][12] = {
    {-3.9009088141321193, -2.519455672257171, -3.3511768127814294, -3.6348720656609097, -3.5240715631085164, -3.8575190500647056, -3.111167891491113, -3.2604062003381187, -3.2862848510371663, -3.8893485107503127, -3.3676920328063793, -3.1406021665475228},
    {0.06259524923550654, 0.2344023135032843, -0.17395598013299732, 0.0812316749433744, 1.138847682601698, 0.020195725983827257, 0.2786322611330244, 0.04109479279074364, -0.3972782245598811, -0.05616357935554562, 0.3296392798551729, -0.3402117048463695},
    {-2.7319049798950585, -3.6712327645022507, -2.809993433832702, -3.0681471208989013, -3.3373192923469763, -2.9930654827130203, -3.6839577200299716, -3.803032335935199, -3.0933653703367034, -2.7771392336093697, -3.356340766394767, -3.406619508693356},
    {0.09364370659957623, 0.002554037498116712, 0.34392054125040117, -0.22321490836789884, -0.6101657451747621, 0.02627734439891223, 0.757939368151883, 0.5419898990724855, 0.21334156258522197, -0.5458319099106264, -0.18847311592464952, 0.31443889209045056},
    {-3.2194670864464356, -4.191353654049721, -3.593025498075044, -3.223000407583192, -3.8856889023238015, -3.6641406362274678, -2.903273648325572, -3.3540620355299824, -3.1248893349406486, -3.545901798223084, -3.4926571335495087, -3.5506726159998623},
    {-3.206512200016035, -3.112852150914039, -2.7959668378608318, -3.4896476789852136, -3.3060942559902675, -2.5780864130155816, -3.861853724616656, -2.649328083849341, -3.534873737185027, -2.829653090413727, -2.7822339586835834, -3.2891207641266713},
    {-3.4723656127480096, -3.0754832917298316, -2.8711572334559237, -3.675815961790515, -2.851577396834953, -3.0927996749855575, -2.3090338534000194, -3.7434487282330577, -3.9937595887642505, -2.7674334089111197, -3.303873943283791, -2.080660983396501},
    {-3.4485163303769157, -3.3513992009315694, -3.46834028161456, -2.5781487786143997, -2.936154505839739, -3.6227622007318634, -3.3041270161704106, -2.918965799330749, -3.1658078364581033, -3.5775362653295297, -3.5066173600179864, -4.432145082574344},
    {-2.539999299241264, -2.9512387062260164, -3.1310431663522262, -3.1234519004953083, -3.3993744338558605, -2.8009706255894886, -2.8627879018632187, -2.9958544704153, -3.4136705608193414, -3.0069365750861516, -2.9411612517239822, -3.002473160293126},
    {-3.59019700172291, -3.5815996279776927, -4.289550563225584, -4.051538162330158, -3.503658761300215, -3.303673233170079, -3.279576253012927, -3.4259986133184817, -3.0026833808117686, -3.520139343665697, -3.287072660282948, -3.6508822912552765},
    {-3.2591430050438954, -3.0067580127599016, -2.9387889666613707, -3.519414752021002, -3.5590753916774283, -3.3805122757777046, -3.7760277524935706, -3.162386769787026, -3.7746074804724987, -3.606847996210914, -3.1643960912695057, -3.2461212381150646},
    {-3.397288146619425, -3.189205582280666, -2.9268551785567953, -3.4332804957064025, -3.24755883406487, -3.6282026906119547, -3.2929846476796576, -3.5153644410465725, -3.045430332851566, -3.3473388895889973, -3.560790587729361, -2.8892728472278004},
    {-2.7749551180900034, -3.701072815527234, -3.022792062014189, -2.028359313246755, -3.259124005423623, -3.390709744168572, -3.0786562842064913, -3.8127003752072475, -2.501760129319909, -2.5401459020255603, -2.795856554810877, -2.4786618063125867},
    {-2.976867487609518, -2.874633208271808, -3.30920409845324, -2.706858530187482, -2.900048698961976, -2.756550299344418, -2.979956181183341, -2.7801136539180997, -3.0782937655816727, -3.025771846366618, -3.555566936450153, -3.0616914619736386},
    {-3.5598928646773618, -2.7307117936153857, -3.86510626533271, -3.345786398959993, -3.3212493591628136, -3.401220709491022, -3.799403966666454, -2.5378687610338106, -3.7934067429094744, -3.850462160697458, -3.811882405052717, -3.447045007143888},
    {-3.558029153902845, -3.839655652751892, -3.2515773859006716, -3.7308493882909115, -2.7725834716855804, -3.121851168623477, -3.4883597257082855, -3.8050874481482175, -3.046827550971479, -3.2191693619442616, -2.5214354477176477, -3.8654369763104865}
};

static const float b3[12] = {-2.1889035470670226, -1.5364917733452899, -2.407672910498365, -1.7213944208237453, -2.210331342784222, -1.8131516679718604, -1.4193306662038838, -1.437625401010994, -1.6652570243260698, -2.4369934826764568, -2.503021859842682, -1.6901073484036664};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
