#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.017305211878010766, 1.1130161453961034, 0.3988551590681701, -1.3441446401677366, -0.011577272337853058, -0.4202384490008259, 0.23329611000853814, 0.377567252234854, 1.3988325006548035, -0.1567517841330177, -2.1932403826107367, -0.014858055795098472, -0.8707918791890296, 0.26978791316458794, -1.8561943244370487, 0.2678111558217792, -0.7325918206948034, -0.21837806185090142, -2.1975885778332622, -0.38522966789709456, -1.2414497805413702, -1.5822149021941678, -0.8315831764328204, 1.5149592735289445, -1.2927207505740177, -1.0261618443823723, -0.48899229051951776, -0.8119253221783794, 0.5228108633990675, 0.6464651849292482, 0.8659948616782607, 0.7377902721913735, -0.007537113787259833, 1.4688714731994155, -1.1070081615224063, -2.1264789002972013, 1.0623813914049947, -1.029645209515187, -0.9245742020475728, -0.3694636333790294, 0.13245905092460789, 0.2780783504142779, 0.7285226135860854, 0.8859765785981906, 1.1106238010372451, -0.19980471260741978, 0.43035373212215794, 1.714928593278574, -0.668597185569315, -1.2534369180429032, 0.0030876981644600543, 1.088612780157697, 0.6621211023230611, -0.11531801994419476, 1.4650946975027168, 1.508041933871925, 0.058773903704701036, 1.519615248357894, 1.7125161430627276, -0.6390168856367362, -0.7885988222096796, -0.37145789845998567, 1.3819291894126826, -0.6729429495036385},
    {-0.9320362067391683, 1.0457155375862843, -1.261307940553806, -0.5481271097355598, -1.1268240946624528, 0.09908570979293897, -0.676051257369473, 0.6274970918150742, -0.7911108063022692, -1.2010313914093738, -1.7841193010173673, -0.7598818024861872, 2.08507744057149, 0.9943455518102613, -0.9171926387446285, -2.634059001783039, -2.8047018693123587, -0.7150603335932665, -0.8305184354023692, -1.701960257895944, -1.2636896843471772, -0.6117899812767821, 2.0644759648843296, 0.6490996240336097, -1.1892145519405346, 1.0591003818481837, -0.027630562200953643, 0.012335723669063442, 2.426202052773574, 1.1947867395533507, 1.5729942908235022, 0.09787518600439482, 1.3526452489534073, 0.5730406844357466, -0.6400759607679253, -1.1535363123807132, -0.7903700316818963, -0.33033892429128753, 1.5880111471092575, 0.008781191957626226, 0.11317368837138407, -0.2678941127893239, -0.3802267527765861, 0.16846134376089253, -0.6407621609080458, -0.8396866201108485, 0.39169242086719563, 0.31913146862310676, -0.06776122438049312, 0.5888535358290053, -1.7908451544273085, 1.2432192250779117, -0.4554429448377501, -0.1420580175771141, 0.6472410887226859, 1.722025576233949, -1.4193623086869624, 1.3301315854999292, -0.5919456405445113, -0.47899859425111274, -1.2423554666156138, 0.7567923818950687, -1.688102483283826, 0.007776190069544459},
    {-1.7739489172717082, 2.0670534919051193, 0.5786550193779172, -0.3804614063251501, 0.09616617299092053, -0.025448171277552206, -1.7995890177596647, -1.1683817105568808, 1.2927770470886661, 1.1301108467799115, -0.4752157976223293, 0.5535673017292836, 2.274895935364286, 2.124052641832059, 0.5107044423710375, 1.1639401429387166, -0.19924886628262808, -0.43261556397315054, 0.1161574526369253, -0.9396503266986069, 1.6213867653873164, -0.29820711624857, 1.0753481098745152, 1.5423048896017248, -1.521101489354393, -0.6398563667728592, -0.47916742325334566, 0.393227527583971, 0.30745297965017415, 1.9453312310628905, -0.22239552203124976, 0.2828452435116498, -0.12204508609833248, 0.9196556140565365, 2.2570446019692496, -1.1335704738000123, -1.2374797963646964, -0.8418538301960814, -0.527653567862507, 1.8221545643608241, -0.6018356820860256, -0.4198417649640477, 0.5352798718154593, -1.3095520720900768, -0.8565008555438002, -0.7570467808543963, -0.4273284524745593, -1.0671283049154987, 0.8190670636964248, 0.246727409443772, 1.2723462173834676, 0.5792799481796256, 0.6203071899927258, 0.14466379031863255, 0.7679279144574691, 2.8976626831290773, -1.2995626291995002, 0.7347829192127256, 1.0175451259448915, -1.955058121439124, 1.9069349899459047, 0.9721045779906164, -0.7130956328037809, 0.6976032148742565},
    {0.041493360018867435, 0.5596740186729052, -1.3202041928829913, -0.5871803188005008, 1.0660207614791173, 0.4413517307690085, -1.5884346893987158, 0.8386743500549951, -0.9375877508881091, 0.1612342953511626, -1.1263458832971665, -0.8760743215977973, 0.4048447964503531, 0.8615048063366771, 1.4715607701651727, 0.8958225635003926, -2.4671225491892064, 0.06593284229264687, -0.08489165755331932, -3.0345855370481467, 2.211922419656418, -0.24434126177184032, 1.4719756352079054, 1.4936838740860368, -0.6070638227738109, 2.3166468371929634, 2.642941192562765, -1.1096182750905244, 1.2653731345455865, 0.49031395129606425, 0.18879139970938108, -0.4775382975966265, -0.2490278910538959, -0.9802612904984055, 0.6727952524127953, 1.105847184106547, -1.6168183489663546, 2.197415694343394, 0.12361904480325789, 0.4974238616932537, -0.10732299530767196, 0.08330885569050574, -0.6278046090414819, 1.9024295007520255, -1.0402192946051085, 1.4259160572949334, 1.3155158389826889, -0.2562306821141873, -0.6199639961435982, 0.6805772005289353, -1.3825483635219402, -0.8406693623233935, -1.5627485051687353, -0.8998869127871879, 2.3058118804323486, 0.35511898567808753, -1.7252981090040747, 0.22939102611578377, 0.9789143634675471, 1.206743603804877, -0.4147700335616978, 0.6178399074373163, 2.380691958922549, 1.269354290728628},
    {-1.0526035123931745, 1.7084561169513068, -1.5708862622335538, 2.1876487331443353, -0.7101671567324703, 1.285903550329903, -2.8871112828804666, -0.5452827556953678, 0.6364098678489057, 0.5480597967924782, -1.6569175280098645, -2.9164586950068934, 0.4826405532747363, 2.5022743625896067, -0.8082029732645789, 0.4489540741160303, -0.9413509208762708, -0.20504930630267895, 0.7626712548186771, -0.6475038888764603, 1.5094672597752876, -2.8202164948039665, -1.5801491348378482, -0.18363366543945453, -2.648058746949178, 2.408804645881341, 0.25734685367663396, 0.39161654420904995, -0.7011191473284556, -0.0658613340495582, -0.5823106763425805, -1.1145869896492484, 0.378961940018539, 0.18626432575563448, -0.8479774077345495, 0.05442257574408637, -0.9128941226026664, -1.7388862755277694, -1.1471659275769404, -0.14354905134095491, 1.1449331682457906, 1.00281940199886, 0.4388946362525183, -0.1748474266531642, 0.6283255109228496, -0.9564287531615279, -0.3168380235330343, 0.24560486041772595, -2.1768727344912797, -1.777102849904697, -0.4247416355362317, -1.080570733691168, 0.6226209747776095, 1.6546604197555612, 1.1004755744459231, -0.3106547884443893, 0.12560616204481015, -0.5100693596631726, -1.2628329348422298, -0.33884685721827523, 2.8010936671768665, 0.1715441651564582, -0.5177950265193074, -0.4685956955317569},
    {1.842687699977072, -0.0961623800400684, -1.0538061030042294, -0.2367098512119908, -1.254928988842866, -0.16275381300577743, -1.416671885046211, 0.29071400727997393, -0.709217768924712, 0.778400536976959, -0.32782873152459796, -1.4493372316492075, 0.6422587319981318, -3.192546867837573, 0.059932155703066876, 1.6567923360369694, -0.36032212169435796, -0.53218458744221, 1.8997038829938946, -0.825879531767455, 0.5313034572576824, -0.8479232291508362, 2.2156439365625147, 2.0457888666118205, -0.9310014833078584, 1.100564574045407, -1.4047927595356462, 0.37547049562995094, -0.9121450530315791, 0.7117194844790452, 1.82683207937348, -1.8352225904695116, -1.5516628439864575, 0.5294866346466299, -0.0580972238755664, 0.9130455875233976, -0.4480185542990129, -0.9631588173529165, 0.8316116143318081, 0.38113458484762736, 1.068873188597825, 0.9399136689399009, -0.7523270989879448, -1.106273688405629, -0.2651604119299278, 1.0072598587135984, -0.3629534385570505, 0.33729572895626375, -2.9588766968024935, -0.5886491026935939, -0.9758358898022623, 0.6456403619738385, -0.08060490746028366, 0.9975491647408201, -0.9318732469303542, 1.3853576418651525, 0.4813080857660181, -1.4569259472191642, 0.44479206162601703, 1.4934523174826644, 3.1062374121209038, -1.556854652212832, -1.1158562666187148, -0.8042858408569333},
    {0.5940459271117073, 0.7794837763146666, -0.8877893145240283, 0.6999684996352711, -2.0442291122666294, 0.8829929666395906, -0.09993706815305106, 0.7458457370439352, 0.23006682492914, 1.0934414498623908, 0.602726128348682, -1.1502190939251926, 0.3950427208179223, 0.7269814962698039, 0.5452978274367369, 0.39996336485901635, 0.35488560459552754, -1.8479980348131866, -0.39305862186193896, -0.7124042343640311, -0.14313389259436454, 0.37722885364605574, 1.9989566492415105, 1.040373073401984, -1.6408756208493935, -0.27166541610948297, 0.996124773491006, -2.7695888237586503, 1.3005919820222172, 0.5701977040125477, -1.2719894912518879, -1.8563175091191204, -1.0443756887436233, 0.290185613108846, -1.2198170718237495, -0.21777175999995446, -0.7397549694707797, 2.21923069895433, -0.8676040274789569, 0.014977471301836133, -0.8393142556502878, 1.9378874993662394, 0.8230568543583273, 1.1918350389057752, 0.20217791707598326, 0.025998394412383746, 0.1790520645334792, -0.03950900022865758, 1.1328879907070348, 2.1296883608793453, -0.04910465100484511, -0.6815739892172183, -0.1994914029576103, 0.9990373634569413, 0.018562404429645015, -0.07367684597995225, -1.3029156962197048, -1.147284486823306, 2.203520477387536, -0.07836847048429509, 2.277953869927851, 0.38002474181378076, -2.3478570362969586, -1.1878918334453703},
    {-0.8316176194717204, 1.7322904935766814, -0.6470025056552567, 1.7752004382659963, -0.43399076473552056, -0.7233019811340962, -0.05696183268635067, -0.36723698504737307, -1.7188265343200473, -0.4482516121405133, -1.3790362637926317, -0.012443868889040307, 0.8877434983796214, -0.3417946945439023, 1.2920573193860176, 0.7958369270371749, 0.22004923802942078, 0.10479158669080352, -0.3804523211597619, -1.0145721179389522, -0.6801690267542881, -1.7387615093596385, 0.7284838492410346, 0.39863028942361967, -1.626101063943676, 0.9547608970556827, -0.013997048477710916, -1.4520744490213446, -1.9145139330909393, 1.5474464307659364, -0.30436477105494647, -0.937153683522661, 0.7005419611945201, -1.165673012702643, -0.8278461761217942, 0.2673053677528454, -1.2030011853175524, -0.7050911721281091, -0.0737699273624548, 0.5908026136964707, -0.5083291549242219, 1.0995279312024469, 1.869824993871011, 1.0229879540177598, -1.0389063293901586, 0.8590164176985929, -1.0771687034076514, 0.21191084501196417, 0.13078752637427277, 1.14224338751034, 0.39470758985899657, -1.4442328714402592, -0.45586197080353974, -1.3251444354187194, 0.46164032042324077, -0.3592545130995371, 0.40768680515375993, -0.4996959052402887, -0.7804598730610792, -1.582564347394478, 0.23072404487088607, 0.3747786355854605, -1.46325338650219, -0.8733872591981956},
    {-2.1037595176471147, 0.1800082234005724, 1.6069228126646449, -2.2109860843137494, -2.077304540050669, -0.08716793299525627, 0.38776245547654054, -0.5987603687214849, 1.4609215193429868, 1.27943945543787, -0.1084233142135861, -0.3404746143631223, -0.25162443689129954, -0.2928769537160556, -0.2636315357045633, 1.4192287623313156, -1.0856805830935448, 0.18049284239362828, -0.5765119666945537, 0.4700343207107001, 0.5143720541095254, -1.7293327205245714, 0.943834837292672, -0.19416346911982238, -1.2245826634983026, 0.08893634867253165, -0.6335442072045917, -0.4637306509985142, 2.241173056789319, 1.0768473799727714, 0.9637335949778001, -1.6660726220042077, -0.28066598146673755, -0.10924715787002881, -1.1633453897977697, -0.9663189094120104, -1.7900512995333533, 3.133032510727797, -0.5651382150045048, 1.7463091910216353, 0.34401549117002617, 0.5716828504264148, -0.8429126114983415, -0.8100583961878763, -2.7859455015918835, -0.4271964603406172, 0.03213940663242551, 0.6501808792842704, -1.055814717570231, 1.1494609906287105, -1.5124825598101355, -1.0983749067357294, 0.0030640854068243292, -0.1384086858401852, 0.2842516998445964, 2.5623668490622364, -1.568119702967513, -0.11075093808549792, 0.04667157385932895, 0.08987734430619142, 0.5572803301742904, -0.746055401604944, -1.3949765821820617, -1.8920550009328858},
    {1.4956858963203694, -1.2496988593316791, -1.2136250500975982, 1.2954245067779664, -2.190547099824678, 0.7498807640534797, -3.2319199150428797, -1.9095447239811063, -0.47085837452379997, 1.3551524250141473, -2.199997149900185, -0.9460680026997615, -0.07022382611071387, -0.4955335360181393, -1.1876704313780457, 1.6104163388331394, -0.9686360630209242, -1.6590139797966366, -0.8851230935995438, -0.6979463252473405, 1.8122466226343366, -0.5077573564293619, 1.8476428484421215, 1.3445798583527746, -2.6203441434103105, 1.2093469807207424, -0.2726518643994184, -0.2710268174057696, -0.05963397175259482, -0.417060614109484, 1.0086709726929155, 0.380178346696856, -0.15699471361875442, 0.9167518131908496, -0.4238029146876806, -0.2619019600630122, -2.6725748686871813, 1.6913815758607391, 1.4607060184073866, 1.824986991882963, 0.11266147993062368, -0.48087700288357477, 0.6320262002395167, -1.1567902204015226, -1.1564315182395926, 1.1636804072057536, -0.02596001629899768, -0.21031286639620353, 0.7654043808026351, 1.394279932326403, 1.353747953973724, -1.0318574917551184, -1.3021121930099866, 1.0530765761423082, 0.7209474352259059, -0.1022739389612983, -0.0889833347545594, -1.7159081605100912, 0.13706579597212154, -1.3286248480805092, 1.281044537586545, -0.4559166803462945, -0.665066741339978, -1.1578714715525367},
    {0.643889005920315, 0.5870030910792146, 0.1926644868492504, -0.7985032069445563, -1.143028965725174, -1.2822503946864867, 0.8861493206666884, 0.4326058981082577, -0.9638711308142234, -0.61366259292338, 0.6993320653635717, -0.7698898614184816, 1.3372794523277038, -1.6421482659001478, -0.5727583458764013, -0.07458803132100862, 0.13597657404539168, -1.2475682055773714, 0.7605512260899684, -0.38084078517929176, 1.3533740590740126, -0.19508839326822516, 0.5641720664365698, -1.1032830225866321, -0.4740433714605022, 0.070417998297704, -1.341495123056518, -0.2434056804702939, 0.43753577642025937, 0.22973619713871973, 0.784802765654019, -0.800422663502039, -0.40425190328145805, -0.4650428148942387, 0.8308840845962207, 0.20123339772623283, -0.7385026526161047, 1.1421028283718777, -0.641045342051341, 0.02299359496052515, 0.5621586910054277, 0.5270811166174162, -0.6182144499768705, -0.23490209989538305, -1.8739809357510804, 1.538586027937782, -0.261747746354346, -0.8369606767959428, 0.9807256397498533, 0.7168535684064661, 0.3276194812459419, 0.49793664875983795, -1.0968750481722134, 0.13075657753094375, 0.15178359941309322, 0.18533067308184853, -0.2601452303973691, -0.731394176432145, -1.2545148116899931, -1.6755569818355682, 1.5662483320637324, 1.1490163137387333, -2.5400541196562405, -0.665965590628081},
    {-0.8750245031028063, 0.16423073650489914, 0.7804007931262504, -1.5526937457999839, 1.6512491664376316, -1.5214615707732382, -1.495094329896088, 1.056366643135645, -0.7717903982836855, 0.40617432828787353, -1.071214311271971, -2.5136986721890358, 1.4392486714256565, 0.690232028241008, 0.07614836539057873, 0.29243699468455037, -2.6447776371878806, -2.9701504819822158, 0.9901784182284588, -0.7372180500954193, -0.1944465984677863, 0.5308257260214692, 1.40601518845952, -1.292559103625829, -1.0632614488319143, -0.9884256618712939, -2.2541943951619947, -1.760765780859191, 0.7586310747639496, 1.7080823788068153, 1.0301509555913446, -0.19497815986296657, 0.6343888269701846, 0.4960650805292644, 0.011884984116402611, 1.3930628612015565, -1.6238364937010983, -0.4867808935709972, 1.146131492218359, 0.0601122463166534, 0.6856932723662581, 0.6032397039432116, 0.15568595134734647, -0.40445202901832406, -0.5879459949085283, -1.378580842566355, -0.07616656040299968, -1.0376462986833899, -2.2438923832112994, -0.8401703334157036, 0.009866489786452133, -2.3156071899208475, -1.782424098313365, -0.712744773586008, 2.021454330516301, 2.0274380268388836, -0.5736477393901072, -1.3410841977565882, -0.1867647434501716, -0.8201725152399443, 0.20128438654398775, -1.4757340345512875, -0.5319485697486361, 0.2641078909105121},
    {-1.0750682490607586, -0.8690574044191005, -1.3886942638398256, -1.4651686589599957, -0.36849266803534764, -0.6229953996335132, -2.29126640190891, 0.3337703549236181, -0.7598774216503614, 3.0397643798118748, -0.11975151692393286, -2.009392696295313, 0.8117270534884443, 1.9341025777537377, -0.27346401608063864, 2.153882272158125, -1.3158056874824096, -1.0091605690652854, -0.15513000739024893, -0.9414326126510394, 1.0185437265143509, 0.8025292133853289, 1.0083125027573245, -0.604337793239257, -0.3369408648729805, 0.055259974723088585, -1.7516153909459364, -1.1238652226952457, -0.7798557025466306, 2.0133917589470496, 2.593396844601761, -1.8110324214410174, 1.5132876107646838, 0.9784122099053499, -2.619083820308703, 0.024050389160467495, -0.5959037780880341, 0.614540292298566, 0.7447085400753244, -0.46011052133682345, 1.0498941417994314, 0.48171318476413105, 0.20725867383176452, -0.3279151653186736, 0.549488441274109, 2.0143903521384448, -2.317751912253622, -0.3574129249393564, 0.012246382504164257, 1.6779662039699967, 0.38689036048671194, -1.2137689995678598, 0.9587788004255524, 1.1090784203504058, 0.8016555002271354, 1.4203579361170127, -1.4475626074924934, -0.466229089818659, 1.3300178415852075, -0.9745978769369861, 0.8660943025247816, 0.1462530487453545, -2.5585879572128225, 0.10888869878633306},
    {-1.6591828288614119, 0.6226454422333562, -1.5917438176894703, -2.0485105452621744, -0.6209763094605907, -0.5143951686017639, -2.9750979291657944, 0.2492772208285192, 0.9696411286774154, -0.7692554453044141, -0.17077740638029468, -2.5695596502585816, 2.356957135963308, 0.5429919558717059, -0.16353128063627523, 1.3769161890860215, -2.237590171636257, -2.2886179949037646, 0.29205503248367115, -0.9923702073068699, -0.042401854762323256, 0.6840012922263992, -0.5753724039767408, -0.4795309013145594, -3.022395079469814, -1.0613848966331094, -2.037898039565622, -0.6336496051968262, -0.2228552262010124, 1.9606346420048566, 0.9845527147950793, 0.17943491927412064, -1.602646694840054, -1.054075822470657, 0.21590558864305787, -0.766940928479282, -1.7114847863528473, 1.4351756646261775, 0.3169785679694484, 0.656597720377706, 1.4451274394647664, 0.2769450202180613, 1.6799953366192064, 0.6622101375479192, -0.5187089190349552, 2.9782968177031295, -1.4381314933262874, -1.174346592728872, -0.09418271064796033, -0.23840847354194966, -1.605987137790291, -1.1443451990923956, -0.8344473672399237, 0.22600464545286145, -0.425208541239783, -0.05705176850244776, 0.009912942838443078, 0.9293539504085346, 1.2433141681719362, -1.1690716952836029, 0.5141584557823, -0.10445028894278731, -0.04802378852476292, -1.9444183208617214},
    {1.0715270373158996, 2.1454871020593247, -1.5145935916060396, -0.9065226991096713, -1.1074563355235496, -1.2433273397790692, -1.8076267288501233, -1.5748990505701026, -0.4343470199012352, 0.1278686104987162, -1.3480953864117815, -2.944359255395113, 0.10583865872613003, -0.9009818351783009, -0.4039764367127079, 0.9627353480228957, -1.3289391557849037, -0.7822345280076309, -1.4958969900114327, -1.2054332437321282, -0.35304866173641153, -1.2211433619082857, 1.8916494921804825, 0.8065844206991554, -2.1817883070675, -0.5455223483425136, -0.39179079220388624, 0.8143605142160998, 1.2742751962959147, 0.7495994617308436, 0.7131416167617696, -0.9882260468024455, 0.09626427976945044, -0.9037301833205884, -2.9319118482178994, -0.7020553307955799, 0.6013517699693611, -1.2245577765051727, -0.9122091198619883, 1.215589504996715, -0.9911023217724212, 0.8092303988399729, 0.0009405188386916104, -0.870655937805679, -0.44349982465905385, -1.4817553397416805, -0.1406688136531951, -1.1496172997889529, 1.3366851744188233, -0.693831762916084, 0.2300056613438053, -1.2328903597873553, -0.39298788732376977, -0.5102422845586144, -0.007258269100827066, -1.3278127055341142, -2.96590519574034, 1.4113596634671277, -0.559905545629543, 1.4706093314935766, 1.5488381087337857, -1.868250217184887, -1.9583859674997042, -2.0769171655656993},
    {1.775055410287507, 3.232236334428892, 1.472211578490009, 0.8619539993132166, -1.314966045564059, 0.9460360229283192, -2.7168178230126983, 0.15449501789407008, -0.700140710963809, 0.896399419030688, -0.15619172276735138, -0.01391697395107788, 0.2312034319223167, 1.735255338968367, -0.9897178155682523, 1.3556175968177033, -1.7115484123071496, -2.10934853006921, -0.6698662953783755, 0.9770385108762206, -0.652284869463174, 1.3063312365655464, 0.6843470352619747, 2.104154103752504, -1.1590048168884972, -0.5277038002296723, -0.7053277550028426, -1.24177599591511, 0.46597685839554503, 0.9296867060355622, 1.2706210853560445, 0.06301663289212814, -0.5267331131089003, -0.9263198755312101, -0.6023494531820819, 1.656830852250126, 2.227186596646407, 0.8763861001335569, -0.08841600386780867, 0.8738938328951071, 0.20109497423091816, -0.9186174221196135, -1.86131012603902, 0.11383450316046419, -1.4320565600809805, -1.216012693088526, 0.9126386732797894, -0.16340340821454008, -0.7268276764374525, 1.009673911500035, 0.3015557267785853, 0.9130665586479549, -1.3184030327815706, 0.7537544721667305, -0.4275544677193254, 0.06837568928491451, -0.7058402511669819, -0.16501432632971924, 0.8300788568494691, -3.6518332986931177, 0.9435256122557044, -0.1410181480608198, -1.082986370954579, 0.3832762949800485},
    {-0.5159247845800154, -1.163705898569364, -2.580890740415712, 0.8255805551031564, 0.16380370028229987, 3.690717064961692, -1.2813500137406875, 0.4821963342629603, -0.5482691383727489, 0.14986419469805315, 0.29917846066990333, -0.5983770846650409, 1.2890282288279116, 0.5049631530887838, -1.158125084255268, 0.19454886033434074, -0.7911476574644831, -2.22142286053985, -0.7289419444942596, -0.2375368838726177, 0.5802730141580791, 1.147346396398739, 0.8155421466391823, 0.8566842932256832, -1.7506269982860523, 0.10164014422149827, -1.1669908067374972, -0.19117997764591915, 1.1883388853096524, -0.19509361009690207, 1.5323833564299958, -1.049638685706064, -1.8475112939492948, -0.22079710125893273, -1.2948254144967453, 1.3656100183643451, 0.7184042686193461, 0.094000347225775, 0.1237447530052556, 0.5370955277077137, -0.5624135629341819, 0.9920737706014195, -1.6433406461150255, -0.7160698050605632, -0.3933178747312595, -0.981157175288072, -1.104702724842946, -0.9493739080637328, -0.15222202435241966, -1.1323090185895894, 0.42297318171029147, -1.2984123691776817, 0.7513647125316042, -1.5212195872744134, 2.6217963258920767, -1.532898663419799, -1.6439466803391125, 0.6068851585981853, 1.3003880169683941, 0.16806816825992077, 1.1939524733588855, 0.4423927116196388, -4.297014794925816, -0.1216011606688156},
    {2.2059109516282387, 2.0658766933914516, -2.765607896630056, 0.6076053145793582, -0.2721665531027426, -0.13536594239666247, -1.009444995461206, -1.9597291000516255, 0.8493693728391553, 1.9191855454298212, -0.0016023300671940013, 0.029735366490988343, 0.2850210019405247, 2.4859926643760533, 1.5860800409593387, 1.885105973705771, -0.10130897962588077, 0.914654723106123, 0.595702712655734, -0.4773096417063574, -0.26965158570777503, 0.12811259140699624, 1.3111870660496492, -2.298532091546422, -0.11231727554988499, -0.9931307941289677, -0.6247689675191489, 0.3249908833201136, -0.26264827657854817, 2.2100212138382176, -0.21231185494904617, 0.42412986396333086, 0.3318057377769215, 1.3493490052727104, -2.188494807809982, 0.5997422689026513, 0.8024794736492289, -1.3582593952450768, 1.5606000860298488, 0.25222414911297536, 0.10916904256267661, 0.2669101887561456, 1.574980271680521, -1.1816997431911225, 0.3369622460055722, -0.27134783407958396, -0.9317241170153616, -1.313241365712935, -1.9845077113786058, 0.947761708056207, 0.3555567414207129, -1.7324982522676755, 0.22478134842180578, 2.2739365405215555, 0.9607806245245666, 0.42378844734975063, -0.9751247258473733, 0.4172571104802058, 2.845982125448332, -0.4983927957851477, 2.1013798840659383, 0.5550849676801907, 0.4775848457072343, 0.7444962891520579},
    {0.7579391098598077, 2.183831976605957, -1.2813090999912495, -0.6376206850449111, -0.8277418791278158, -1.119356127378966, -1.886648080919666, -1.584758332402953, -0.9834180069741689, 1.997867397535718, 0.6085816907184273, -1.631064212497223, 0.19776994471041012, 1.946830884177726, 1.3429384083302023, 2.2630333267509215, -1.2212798602077328, -1.4869928072045995, -0.44921812553570206, -0.43067413626007717, 1.3641473533094455, 0.15957126326795965, 1.9373236620562762, -0.3200195014805408, -2.364772853439041, -0.9130082890647047, -1.6880388289927175, -0.8425376989062886, 0.4492375128232856, 2.6002584707318053, 0.9210089905510639, 0.12152986212112449, -0.3483197651281565, 0.22448896743087327, -2.0681271769919993, 2.690565614644306, -0.7504826425384157, 0.49202558508194, 1.6756027480058213, -0.12538577626978226, -0.319026988903908, 0.37014574051631316, 0.1958041812695376, 0.8013247989598646, -0.8348570474522268, -0.651545066977925, 0.38477827903086737, -0.18886823781646325, -2.435006096154527, 0.42826260352248696, -0.2157541715073247, -1.0183948278295136, -0.9056187503047047, 0.3214232567740458, 2.7643463795940724, 2.976315507059606, 0.0541743762601223, 0.5918354315272203, -1.311980760271277, -3.098725397473338, -0.15385078301816044, -0.6936115064608083, -0.0451343360666678, -0.7383195332359436},
    {0.9974237440759642, 0.4697844579865675, -0.13845792660692235, -1.1449206584751725, 1.1536722209956098, -0.4751977028395018, -0.8647457817272977, -3.1535889816320575, 1.1900335083951574, 1.8737958561787948, -2.088283726509136, 1.1324539868993166, 3.022796561312564, -0.48300055997271224, 1.311907307518682, 1.0000267381416383, 0.45217330970593284, -2.2627854028220304, 0.3063854942416433, -1.7406909933319519, 0.04881092077796097, 0.10667961221314234, 0.6562826708792987, 0.048157602016561364, -2.079285982536891, 0.056125780115675136, 0.38679570175646777, 0.24240981013389545, 2.498781751487333, 0.5888599103327915, 0.3718496168469185, 0.9981136033425937, -0.011383371705829497, 0.4959924045837135, -1.344615899526881, -1.2457491025917609, -1.882771431644799, -0.3755125585790038, 0.6372058841241123, -0.14431919906155996, 0.15180370754871647, 0.6157654170758998, -1.9337101678183712, -0.43769032592642876, 0.1728077398057904, 0.7242329601586295, 0.14102490540580204, 0.5487720011886708, -1.367651354801384, 0.16206265959556043, 1.359823766855745, -0.7183668218196979, -0.7634675443243097, -0.5398553289992201, 0.08013895138880946, 3.241183860036324, -1.1035595242420067, 1.4067344055510769, 0.3579284858382597, 0.07838142102528557, 0.6892673097812786, -0.598823863812922, 1.120439161289789, 0.6991264313256881},
    {1.0547157134334941, 0.6793216370602772, 1.4649261568247403, 0.9459126469657945, 0.986878766623266, -1.5190088610088575, 0.2246263866111743, 0.8403856850156485, 0.6399818744609426, 0.4457662685875773, -1.2567605575162615, -0.2721884537142655, 0.5499745878111212, 0.2224646514596382, 0.6380070027326129, 0.2485082868963617, -0.047112617192233, 0.23341858051508774, -0.299083056056545, 0.27650351111908655, 0.9490466518485047, -0.4706855659751429, 0.12521661009729018, 0.25196755273050625, -2.5502282030918995, -1.3104004480070692, -1.94019089240452, 1.1745639019595837, -0.006773881331596339, 0.384199415525223, 1.1058888417571073, -0.8595008724500955, 0.21306107432096213, -1.587731696144397, -2.9420822508880313, 0.054980783254223724, -1.7955570298659118, 1.5306332125288487, 0.5007190652707468, 1.6200741330064223, 2.008819750760331, 0.9786165135558953, -2.1205287239007564, -0.8251693071280277, -1.4744371488178596, -0.4620066431605793, -1.6076128879394294, 0.6944384711363657, -1.7051603506470723, -0.3777368402052189, -1.7638336910935495, -0.9781561913795056, -0.6105666082375593, -2.4392825001618856, -0.61196730497863, -0.3648852328414015, -1.754664537426873, 1.07369198235577, -0.13596186882045097, -0.7144406015625023, -0.7404943310617133, 0.1942409090614838, -1.5929869811696393, -0.45532737965148057},
    {1.505716694399085, 2.2280104124876585, 0.28469967844831634, -0.8316052836712714, -0.8831602944565607, 0.5656466678844881, -0.543453995069115, -1.0173265822829454, 0.07447738168310108, 1.9084133429449184, -0.48401726922218485, 2.172485596235583, 0.4447936587753295, 1.5281133327359484, -0.31712366504569683, 0.33326655024020396, -1.4697599854046175, -2.3710751397031338, -0.6295133947607674, -0.3414565434129684, 1.0092062478426351, 0.9830360939857544, 1.7102048146816167, -0.3962839314519613, -0.5771820284662955, -2.3435639869072116, -1.7776840517766945, -0.15930514351350086, -0.559292582975241, 1.3245121903741834, 2.5521770893117375, -0.20517316455929374, 0.11031562214123619, -0.7838933811590542, -1.2785676060518063, -0.17217929186435021, -0.3579669238178578, 1.14797018338509, -0.8355344482455299, -0.42592690884147555, -1.0836067977233372, 0.22791345487432424, -1.0089791999992417, 0.8113089548602289, -1.069382540439754, 0.8840234452523154, -0.19994952912875658, -0.8780110233791015, -0.5344646970565868, -0.6318788878816894, 0.6817468526466037, 0.8157951312119348, -2.3872859039490497, -0.10587441912099659, -1.8938577832477703, 2.2585550778449606, -0.37784236594053505, -0.09873569532504924, 1.999916781104623, -0.1509704413109089, -1.3156290546008842, 1.1525783163183547, -0.38807221220503296, 0.18088086729277061},
    {0.9066667764815144, 1.2327364272693548, -0.6508931257260278, -1.1158652420820534, 0.871919314015747, 0.38131813280086757, -1.951853122100717, 0.9000517088960147, -0.6929418397464633, 2.3129150684942386, 0.030331815275976736, -1.6459225999934899, 0.9250278528062483, 1.1465678176718184, -0.22426841676406653, 1.2250660422551323, -1.8887687302169323, -0.16800321294508305, -0.6363370171595235, -0.7803616445569425, -1.0612144774360432, -1.3321011714011237, 0.9876796125531453, 0.3502798148689481, -1.3065054053966898, -0.6979643758997399, 2.0991780708957024, 1.244147833389776, 1.7730040303719463, 0.39652202414289045, 1.335074123908958, -1.2479668079746646, 0.8375418288060192, 0.5205135353262174, -2.090982696811204, 0.0521933816235183, -1.0366924471928567, -0.6059725900281749, 0.7690949131542799, 0.26354839488239157, 1.2898346733110042, -0.6833442008744992, 0.28685912045430667, 0.10799778958767953, -0.2558648198239552, 1.5067678296197264, 1.8392145912931532, -0.18518816320412235, -0.007642759566867585, 1.7815022576858646, -0.13233899954750386, 1.1140403814285071, 0.8178746998563835, 0.3817471707728936, 0.9895809953621286, -0.13230188767957626, -1.2365026095832887, -0.1398080409119086, 1.6225519895366365, -1.1426941758953075, -0.029925062056804792, -0.2981795320462049, 0.5085458482593562, 1.241176398787899},
    {0.11920463730124299, -0.4871583620637802, 0.4464306142305505, -1.403445645745415, 0.7459901239708844, -1.7395146230386989, -0.4785588405590806, -1.0524693001559926, 2.69181481555893, 0.582267388450839, -1.7390524656693802, 0.775241779917466, -0.5510799154574934, -0.6056522215221667, 0.9489162451920772, 0.5846191609442831, -1.1551517960752455, -1.4417978472236725, -1.747808526481385, -1.4599992298438098, 1.6773949056121822, 1.3516065383079547, -0.40545313029438734, -0.2203443270258951, -2.2108460740312434, 1.4817487171064183, 2.081768428435159, -1.0570141203966248, -0.08862775768774424, -0.4063439207772133, 0.7399000447708484, -0.24934428540606282, 0.030796843085465025, -2.305650797488517, 0.3372611358519085, -0.43819827445854753, -0.4403196716765031, 0.5521174679691419, 0.7701244906966951, 1.302248655855927, 2.31007235426646, 0.7375801620034763, -0.21137760377623244, -1.1075451264748457, -0.047761708829567, 0.6699916313645182, -1.6691953712405243, -1.7913819127594943, -0.8485466082799775, 0.32449935398575547, 1.4287462741678008, 0.7132096420236935, -1.152873141677223, -0.6154901034502377, 2.1840841071782937, 2.0708671672842396, 1.326942306607348, 0.4409278903097295, 0.7141197189328501, -1.1591745113630925, -0.3933650579572676, 0.21595773279545402, 0.4656726340430876, 0.8489493817755375},
    {0.007787750077433173, 1.356322887125396, -0.3691064464350252, 1.4972922800207138, -0.5500007279772569, 0.17592802219255999, 0.07425306533667916, -0.15208370071401978, -0.48396729236727426, 0.4807287930042936, 0.629039833419014, -1.2699498385550574, 1.1256644376946365, 0.4162214035094001, 1.391182733270015, 2.0824843304025813, 0.17434450941325114, -0.31614262642054136, -1.077297271940754, -0.7400041295671039, 0.8220259969238087, -1.0014387918274332, 1.4399322307907714, 0.6988506841147452, -0.9583766190683319, 3.0312750597644316, -1.169069865206609, -1.8505035521005309, 1.0723052957305688, 0.30080682485495275, 0.10265518860847408, -0.1905290986848071, -0.680784821896116, 1.0097376449337492, -0.7531871787137718, -0.015537088336720016, -1.4892458941900564, 1.2859537512621182, -0.36373947092657166, -0.8508106501034506, 0.2542166427768222, 0.6122179287539806, -0.8446054225378288, 0.26873891369903335, -0.6102857566213559, 0.2388008255346872, -0.4161947705555428, -0.9889438316150281, -0.8211237576705105, 0.3731110003464701, -0.1560423350802392, -0.21162467353912784, -1.1554743144394388, 0.5455146895997286, 1.1243517915347152, 0.9312069522555155, -0.4234354976510958, 0.727279345170486, -0.1622632397947833, -0.568439564348448, -0.820585761086667, -0.05847176611337497, -0.8976216640208878, 2.3738568400725883},
    {1.2368630511091376, 1.5089208893075825, -1.610334090342106, -0.6650541530695335, -0.6878141999616607, -1.0816605618381745, -0.2284915314495716, 0.6858615268889106, 1.3744226038573015, 2.4540606138584207, 0.5503287777300031, -0.07657641906425829, -0.14769865474228064, 1.7567883283128185, -0.5071942082600808, 1.438846948668933, -0.8560531935379135, -1.288029422615065, 0.4825806597554489, 1.3424160982415805, -0.3038569903877121, 0.19368696418295925, 1.8565768331660635, -1.7823257473088596, -2.2007167328836887, -1.808541703171233, -0.3167121887479564, 0.370173160557857, 1.3642590444570668, 0.2523055551391047, 1.3042868919414525, 1.4000711478678263, 2.4884608478945953, -1.7278054624967047, -1.5980295035927612, -0.9708813441760803, 1.1704642882351963, 1.0915200352826002, 0.5462930163283959, -1.5651331590138067, 1.4616791911922824, 1.8714893537874375, 0.658162775792336, -0.13493395583306717, -1.9204997339220753, 1.739535384757875, -0.9650283841839986, -0.8214326965737309, -1.5659483502345075, -0.831548328963446, -0.28411033234783545, -2.0219399522790433, -1.1433876414221815, -1.8685521103383078, 1.1225692845404016, 1.8454875979095224, -2.0259609936634857, -0.7309894722039908, 1.7445834454550206, -0.5736864908307411, 0.21951433405725915, -0.7380076893068549, -0.5451733490783689, 0.9280787913461688},
    {2.198706998649265, 1.1959786601686933, -1.1785247061432405, -0.8578305611357114, 1.916357712582602, 0.012601871372680038, -0.5978411151409586, 0.7819242170513386, -0.027037007806648517, -0.7549363040377831, 0.1858103115841074, 0.5661052587296168, 1.0612776451321662, 0.689784931124891, -2.062162251832943, -0.6094810451057635, 1.3219716169267162, -1.1223365411364183, 0.5610262368590915, -0.6658387282458335, 0.08509367178373875, 0.5948653866779599, 1.7054859644724427, -0.42906917018819346, -0.4742121933105227, 0.6078756041102997, -0.33480231269023064, 1.5772336348064475, 0.9595200701217121, 1.279310453935542, 1.395541188127212, 0.5597633753382654, 1.6617483898806944, 1.5024124749697636, -1.8153897752907933, 2.6162899181449024, -0.004343709424815935, 0.05730530454904348, 1.083772430845712, 2.0585227484923214, -0.47478950318407254, 1.119764823239142, 0.31086656517586, 0.7725692041278759, -1.77807260905615, 1.5391273176307532, 1.1660585308399711, -1.2375675770749888, -0.2767038634062402, -0.9853629341385074, -0.3612607224152061, -0.4597722000176019, -1.8126943444022428, -0.000395978091493342, 0.31063809866939535, 0.023561300402851638, -1.3752940636576516, 0.2891680397551176, 1.2164516027125247, -2.137020923784533, -1.1173449437377603, 0.4151761676916893, -1.7917717019277317, 1.7587314855396445},
    {0.138240017665136, 1.3650367947641124, -1.7534221141264985, 0.3329354357781036, -0.5509042846231248, -0.16664641822826612, -2.4697670910761844, 1.8390368847084995, -0.21355406774363644, 1.1739798963837906, -0.7718369449179255, 0.9355104238218286, -0.032921658637368525, 0.6111863574808869, -1.0120846948296116, 0.3721576568403286, -0.7056036305106066, -0.20765400376157755, -1.4789334114138084, -2.382917721968392, -0.11527184738025559, 0.14418406511310686, 0.3163588459948479, 0.4767171506363718, -0.6455647204957043, 0.9104330284556009, 1.1054380443837557, -0.26367271613610593, 1.606053935382269, 1.5063224556208388, 2.3157510478416947, -1.347635280703459, -1.4800270126377157, 0.47484176330496547, -1.8904501734980674, -0.4801856887690669, -0.3512570050467061, -1.0164032875119773, 1.413282039404439, 0.13195899851366122, 0.07107272963527783, -0.6362224700041508, 0.2812289603065477, -1.8634980393685188, -0.5460010690154273, 1.3635089668589628, -0.5598411521117475, -0.9827846893383319, 1.6521473600927923, -0.6893435765376331, -0.15069720073251242, -1.3122211209728931, -0.05524938099674945, 0.1174674720150429, 2.8415283398828706, 0.6849229143415778, -1.9131115500477784, 1.8217083752742558, 0.8904245890383892, -2.128158291628753, 0.21602396205210905, 1.1448729442829675, -0.06333285102608555, -0.8834361254938856},
    {-0.19551617969097695, 1.65036680452429, 1.1055417020338947, -1.7965362231491386, -0.14030497907476575, -0.0007283222916770836, -0.012470438347095247, 0.28354008067225317, 1.935057692008257, 1.6278413175964206, 0.6761144710482427, -0.9677864282547357, 1.0291386166009782, 0.21356307427223464, -1.2162158452706602, 0.48659075827670667, -0.6827313459433603, 0.3191316460613516, 0.6767068194988244, 0.6574663764655166, 0.22275530895321122, -1.8467160256568986, -1.0621354605644087, 0.11606410134584437, 0.6327585486976054, 0.5467666821422638, 0.29641669700184103, 0.8115123645709779, 2.3828216498704218, 1.913185654675572, -1.6022606539492623, -1.175715293436541, -0.09044129346297715, 0.02246655903762276, -1.4181750405637368, -0.1282627142698296, -1.2065017328897263, 1.5006894587530422, 0.2817844888916454, -0.23733403411298984, 0.027932796062879964, 1.2212178050975722, -0.03990649442325437, 0.590893527204279, -0.8199618630395862, 0.6210623946734091, -0.430280594488939, -1.5155010661029618, -0.9899650770079249, -0.6627035965829854, 1.50947823581095, -1.73180261065079, 0.2037069025857584, -1.936480408254137, 1.7819377947027588, 0.8827052267418927, -0.4586603918732248, 1.1239862049537972, -1.033889407724039, 0.8828256746923282, -0.2685040191287546, 0.8489643278008526, -0.3221129790327073, -0.682666158580562},
    {0.17507500205006254, 1.8512054942243, 1.6329064361377519, 0.2190593910775325, -1.070316862954465, -0.906988056715096, -0.8507450021594997, -0.0063308949746352485, -0.08180379715144487, 2.0885633817608853, 1.7310525292052092, -0.8284469660794489, -0.041737976242386954, 1.6421751047551745, 0.10932311741162257, 1.4052691782350566, 0.0919066478822049, -1.9344517208834509, -0.7801209227956426, 0.28498617707033025, -0.6069224094112895, 0.22668239335211599, 0.9597651226315617, -0.2751791532533318, -1.4064877065989514, 0.6620005252732236, -0.26271654958369356, -1.4861555325628704, 1.2431552900965723, 2.3470681511215283, -0.11986943773284638, -1.1753374443793492, -2.325127619396495, -0.29816422141442067, -0.6004012645553237, 0.60520500123778, -3.3870797107433517, 1.343559306351043, 1.9700847837663418, -1.7087916819190656, -0.7387470886196723, -0.9001935289098911, 0.4604221850732673, 0.12967701902908316, -0.022276741737893437, 1.1474316830183457, -0.15125796154008492, -1.8193570550567393, -0.033905176652357455, -0.7420454651796488, -0.06337048765241429, -1.94792257636304, 0.027993397281827807, -0.4769098820446075, 0.7867095635556944, 1.5487421959361753, -2.3757412316623863, 0.9985446136920442, 2.0049303963469596, -0.5677970429507693, 1.899436127251722, 0.4107595465458044, 0.26722925416167975, 0.7636888152452024},
    {0.5747727436959539, -0.24567339461781124, -0.30944963207165954, -0.2751436164887898, 0.00036124213762033, -0.2883944373094739, 0.661786701550629, 0.1493229016560739, -0.05322980823227027, 0.2551898513864869, -0.02325140693712915, 0.9865532496826463, -0.24166704780251125, 0.034997167028466766, 0.895320347922958, -0.4831184359447522, -0.28437504491106863, -1.5967590690216367, 0.23976062291783098, -0.32177524415270065, 1.2280412944621173, -0.4374502861371459, -1.7583722290809451, -1.371099756853021, -0.6444977952018212, -0.8228018252852142, -0.9065779308724707, -1.2643479426716668, 1.5907328897281572, -0.7391437844790134, -0.09766720417343724, -0.7019779890443602, 2.844028210787293, 0.8372617858522785, 1.2031400899784066, -1.153669849057456, 0.955403261176061, -0.09232328034432691, 0.6434832512857234, -2.092192574469662, 0.048807481643551136, 1.8100348414160745, -0.6988880902577291, -0.24424681458947112, 0.8254602065958676, -1.226893579655469, -0.9236399719120082, 0.004369126986950773, 2.1582426864163, 0.5413715052136022, -0.6212714602836609, -0.8541062737561138, 2.084723563861198, 1.3895247078002628, 0.6205820531580003, 0.010917369781085566, 1.504478521481077, -2.0993067032165365, -0.10176769805732115, -0.11538362920488092, -0.21281128223153167, -0.6242571940139943, -0.3624243609936207, -0.6435700518823804},
    {0.7682330467656658, 2.5427405503535656, -2.467344627145722, 1.167758549400969, 0.3021283817977741, -0.502758969815515, -0.8342292733908862, -1.0542775690976918, -0.29438411955260185, 1.7417507116191118, 1.0494960745870685, 0.6774433469232496, -0.887127825331944, -0.6476670076823421, -2.357682666716187, -0.0493385320632627, -1.699436898493588, 0.8791431746219821, 0.182397854436801, -1.3306860317500555, -0.35182011699600435, -0.14150822904512947, -0.09373756808079889, 1.0180261413321288, 0.32223782463114176, -1.398425978265267, 0.8639929889431941, -1.613654490400572, -0.34317118340671515, 1.5532956879229398, -3.22071170580184, -0.36053258948904154, -0.24930916887272744, 1.2427793366010138, 0.6582201107131248, -0.6976260558596363, -1.83667484551554, -0.8062061428582153, -0.029276232683543766, -0.591776736914595, -0.4957769375850067, 0.23094020446488833, -1.3881504123306594, -1.135248613039184, -0.7590653116659326, 0.8688809520173683, 1.5704853991720713, 0.05784198940316319, -0.35912611922238286, 0.5657600648018565, 0.09214535424343337, -1.3205639316667968, 0.09068502364061572, -0.8844351740632033, 0.26475942489084325, 0.6221097992638026, 0.7341302593791142, 1.157667552910203, -0.19295800180982123, 1.3238973864922532, 0.3230111805035308, -0.25594592429064583, -0.12933883233279447, -0.8147644108866197},
    {-0.5955675261489248, -0.19333197754423653, -0.7665078423319319, 1.7421628284874486, -1.714872100924309, 0.6962125397557263, 1.2310072253378885, 1.4413661505603612, -1.3210181265929337, 1.035781727318581, -0.2985846167820396, -0.8907179077184775, -2.167535415547661, 0.7211435883919367, 0.4351630833039591, -1.5578965752118314, -0.24380898820277447, 1.3944252561224988, -0.018189554016329233, -2.2484205136849855, -0.23801780138183973, -0.011622926563935725, 0.1558926694874509, 0.9103538731671365, 0.42869698905734344, -0.45279419213282185, -1.324711070022889, -0.4347795955344588, -0.19558832433202217, -0.25200472968169624, 1.7664882122745964, -1.6191611339232561, -0.7592096975740739, 0.7217126287705747, 0.06983501155612196, 1.1433179794961545, -1.2843409084995365, -1.0273856823126235, -1.1574621970473258, -0.37962883194241126, 0.12501475437201007, 0.33911378202809533, -0.004175741227324101, -2.084710286378138, -0.34069456227630235, -0.735950942187122, -1.7159175983454167, -0.7425283614188624, 0.6213913112361495, 0.013964357156177165, -1.7207918583403807, -0.8261904620818578, -1.7762451740976084, 2.558250525544169, 1.6647509970601726, 1.2749526743060615, 0.41666323909257624, -1.8117875208532912, 0.4981589252555936, -1.577592013453153, -1.2623204331189062, -1.185693451018703, 0.402763808177248, 0.09256599172794412},
    {0.6844026772958519, -0.6600409659063174, 0.26494507465107336, -0.4636251422390491, -0.5335668524007282, 0.17428445677130366, 0.02505955265907176, 1.984106501101895, -2.282709685977563, 0.040762813174555386, 1.0018468891380334, -0.014589078263855464, -1.364786585359408, 1.2948621859515357, -0.8679365281621305, -1.2721812733447626, 0.26139476487127805, 0.12552052467139796, 1.60722747975069, -0.4087618990079563, 0.5684298588511841, 0.11373425556487099, -1.479597632793707, 1.5329294440997634, -2.6534694493687447, 0.5652516185583742, -1.994763522412254, -1.4379936437767984, -0.1448553883458752, -2.1346732847089234, -2.1835542213845813, -0.5211831831846625, -0.20094303617955944, 2.183021176840125, -1.1318596399608778, -1.1824010451788214, -1.646198054677157, -0.3517474551139073, 0.12849465176150174, 0.8771325701971477, 0.7031889457785674, 1.304748830019675, -0.45083787174341733, 0.9145274094932928, -0.07397192248669171, -0.12636405270184234, -1.608706598079222, 0.4989111525263149, -0.3550048015707323, -1.8751060960677817, -0.015365735558030573, -0.7841363773807077, -0.5258643775870989, 1.0188366644481714, 0.3734402418372401, 0.5070227751535111, -1.115028590029875, -0.791226614021621, -0.5879840932814725, 0.705913837178959, 1.5427990976420785, -0.3155126105885595, 0.6515818394277714, -1.084677982992822},
    {-0.8458081528308631, 1.2251540297557506, -1.1108066941653756, 0.999173851799712, -0.5994787149560112, -0.5033241338709034, -1.3107804261967526, 1.579301956515466, 1.429875243778036, -1.1303693707307625, -2.274889830668536, -1.0473860186040427, 0.1521462612626593, -0.9437676988128337, 0.46318527934526366, 0.4989632314168083, -0.21898551223987892, -1.2518547419710266, 1.2236620460731549, 0.47155427485419177, -1.378468377702611, -0.40608339388818276, -1.2280574026096314, -1.0948451894016737, -0.9275599804626408, -1.4476492253099478, 1.1197516448763918, -0.42710930181486223, -1.5962895718689454, 0.988527329312024, 0.4652907923500866, 0.13107945965891904, 0.06944019048321876, 0.21299778105063458, 0.5768154749279935, 2.2334164062995283, -1.0237379188805646, 1.5047789495721993, 0.43098862543385963, 0.6140976843662499, 2.6951760499101782, -0.9486302033822586, 0.5550758867097841, -0.9211868324269487, -1.55379577140257, 0.6384615149216379, -0.6555889109465779, -0.7113187682555049, 0.7579877378782501, 2.4212707239745646, -0.03965584527895446, -0.8594661976376452, 0.11519384831836138, -1.5402447657857408, 2.1356598302226284, 0.9020367402331515, 0.20688239713122977, 0.006537239062222291, 1.9542367922539154, -1.5190694938516756, 0.0758820544152304, 1.6643377926919272, 1.0120331215144769, -0.5440365137389035},
    {2.7117419553862057, 0.22566523531049656, -0.8670855406773661, -0.7037786697808617, -0.11967772467710808, -2.9546313652818186, -1.8400728159634638, 0.5880898569239502, 0.4535145516071835, 1.0236456760922752, -0.5160503553193379, 0.27171568852941674, 2.3748157850223466, -1.30383436196631, -1.0007967322395421, -1.3177077076804073, -0.5383988712681174, -0.19465676445688007, 0.5857251692451351, -0.7331450259216346, 1.8078252177110663, 0.9674748605865543, 0.46769892170965055, 0.8045267468465113, -1.7315365995527454, 0.4574689167223361, 0.4432406369993362, 0.9465348764816361, -1.3250418409875044, -2.16103546877214, 0.453878785476614, -1.3288115155139926, 0.17078726962024665, -0.7637515376454148, 1.3867976361082648, -1.136704459502613, -0.60042791816725, 0.4776340793904566, 0.3671848387196343, -1.4442871919246387, -0.9504564671511492, -0.2746027774920479, -1.1577681358167546, 0.7237816094669638, -0.6989279962682522, -0.5526459684804105, -1.1094589782052091, 0.4954679718563757, -1.8775458623339731, -0.37702313256756337, -1.7614698561585227, -1.351799011160545, -1.1097765121134013, -0.3344220476109903, 2.5019342207663056, 1.3794632808928813, -0.27781770395911326, -1.9788335118150029, 0.42616960057380954, -1.2664777012648827, 0.7509241448242776, 0.5946179701504933, -2.7599408983234164, -0.39191266961498544},
    {-0.39173831286869526, -0.724699994878208, -0.41456556991943877, 0.3565216195334331, 0.07197161578068002, 0.10466019790637204, 0.6163513931159118, -0.9730700778270447, 0.9548061144799121, -0.5193932931410438, -0.08974766722415113, -1.6916791507166353, -0.6153086988524953, -1.1026213520912742, -1.4955190471086728, 0.6125860419369548, -0.6186993103861308, -0.7510058511253402, -1.4298913385605565, -0.35876527158797666, -1.3341790780794929, -0.4388647952457354, 0.03301923249828295, 1.159038030255952, -0.9868834216232991, -1.7024482887557386, -0.18650749484175907, -1.2221027812589884, -0.4027049296075114, -2.699104381844683, -0.1743631005550885, 0.21025060273963253, -0.9742960863965772, 0.8575395948453086, -0.4608342714610298, -1.9807536743684007, 1.0025815990548408, -0.035296754722336364, -0.09129265728443227, -0.016900163744061617, -0.8278734010220191, 0.17820090069386385, -1.3336146027724256, 1.4566422944330155, -1.1482436657621482, 1.248469927600319, -2.2425662458321316, -0.7115435556875779, -0.1615955577635549, 2.37848716634224, -0.3953522790450893, -0.9705657574975141, -0.5046770438830878, 1.0637975502709756, 0.8386656920354039, -0.28047382382735736, -1.282050268227036, -0.5113188508677934, 0.34724656290298295, 0.5928190124383896, -0.4399004712473804, 1.2879225260208842, -0.449420564174366, -1.393394559634049},
    {0.11557408491461842, -0.2298351967298136, -0.5117311400552546, 0.05861996614309469, -1.3335893982408566, 0.5176329097150827, 0.495172918532214, 1.2443111607552733, -1.2851612223042765, -0.23172096758574687, -1.6473305710624677, 0.5687590001233523, 0.429923924282361, -0.1953333512546813, -0.880641200308938, 0.3113111015621075, -1.2091067961207609, 1.51821764116184, 1.8639974146786342, 0.18719279958470642, -0.8945415100074838, 0.12467426629372952, 1.035652933857947, 0.5258001848819477, -1.4216606023713674, -0.04502280967812336, -1.5785293022784972, -0.37449212909466933, -0.5494251553306154, -0.981251022655434, -2.7818153181361582, 1.358996407257856, -0.16276940086662545, -0.9268097094095503, 1.7911721274115058, 0.18583626316219498, 0.01833405870333954, -0.4570773222140994, 2.4103076201182185, -0.4184355418388513, 1.731246856584104, -0.7935090879049387, -0.7918997612099979, -0.07769225182028135, 1.1233307651842568, 0.050862472695995406, 0.17356719989897798, -0.33137110710283413, -0.42368955093056937, 0.8971581877460639, 0.7299957354932927, -0.05107863492689804, -0.17913804971362424, -1.0853964656908734, -0.5880677298565573, -1.713117033655806, -2.2023564759250043, -0.5684424121214144, 0.09363152864845911, 2.533119534254898, 0.014204642300046576, 2.4627038239069288, 1.11105696394117, 0.17781358949244702},
    {0.3696809743791731, 0.09504347507705929, -0.5683837279116248, -1.1065661491841243, 1.2418902804963265, 0.27972622925599927, -0.11493804642144578, -0.4107748293829188, 0.3004320392934874, 2.2427979545845114, -0.7906531536193556, -0.5363693814391816, -2.361040693835295, 1.6126044444879828, -0.2655534370748676, 0.8521815038916117, 0.6311173799119824, 0.5018819711222259, 0.18569834096625268, 1.1468715347046223, -1.5945681269065188, -1.9225438940850321, 2.388759274554067, -0.8610710555753698, -2.1778833475669903, -1.058796375889533, 1.8425742465747854, -0.8896724693267536, 1.9871231723515672, -1.374786358778231, -0.6927774690196561, -0.592288440714916, 0.5515189084616368, 1.9134437233660357, -0.6468512217811753, 1.8888698384569433, 0.5490421351458791, 0.30955748648104786, 1.3627625573729476, 1.298220309013121, -0.9244931833779917, 0.6078325841667719, -0.024391781888494602, -0.8692275601296904, 0.41201019797409, -0.006735917788430549, -0.8605224326332443, -1.1330343744317701, -0.4416863705940543, -1.4381448077046555, -2.1903104821721495, 1.9483518337211332, 0.45800526811198744, -1.3374382555500295, -0.45419787661705396, 0.5501897745366969, -0.017317430819418042, 0.17152495647325025, -0.024348595584828946, -0.9222891376005341, 0.7837061570854597, -0.14484548262733968, 0.44261650389588264, 0.8519937552767641},
    {0.953251950709641, -0.9631846233842111, -1.692948504413477, 0.9717625202720557, -0.6242924962985913, -0.3811719817757379, 0.09216608968281599, 0.8034713218555416, -0.6481777040541482, 0.02185158081648335, -1.1508440809276017, -0.15165301486200072, -0.6665317311224173, 1.5724486188156834, -0.4617369081579518, 0.058636704782807615, -0.0165137421641098, 1.7781581138871105, 0.5393415164613728, -1.1552186619144447, 2.003247208813218, -0.9393639845406689, 0.4360080496883496, -0.5426697359502024, 0.08426938039070432, -0.9837519696199368, 0.17136812150478606, -0.44604547017614676, -0.4018540961423163, 0.9492703513414743, -1.1753024610902425, -1.9134473898651831, 0.5827257003087702, -1.1986332745609822, 0.12316729639532338, -0.7969851759298503, -0.05692648830704835, -1.4492923052670645, -0.9528534154400946, 0.42886312111943325, -0.7563622032388817, -0.5538077912358084, 0.10517653749851959, -2.485186952784411, -0.7177770604101884, -0.7768472170143911, 0.7654087281072638, -0.40247393012875493, -1.2153672693761313, 0.8575662155556832, -0.5026545333003781, -1.9520715715830161, 1.319255872477906, 1.2216949139930773, 0.013303624230897643, -0.5008429603380742, -0.22689497312895385, 0.7474639674178922, -0.5722185586840814, -1.1381940602852338, 0.08843390144790486, -0.314859831736161, -1.9498478687085699, 1.5983838257869603},
    {-0.1350354849763311, 0.5344447027960231, -0.4765469994236012, 0.6763875999942478, 0.250576184584936, -1.086452010928193, -0.9598215020763897, 0.5881923546270025, -0.1727921388749283, 1.5008127950386003, -0.6117534376935759, -0.16312040024289873, 0.8230105327767033, 0.22944303038754468, -0.04421992971195471, 0.6592266091263435, -0.3666791752194758, 0.4371893471669457, 1.0578088308288913, -0.5296340892468306, -1.516462286987627, -2.0340715573937, -1.0498676688828594, -0.4950301850938551, -0.10270112529980743, -1.6190036003121333, -1.9129605615677954, 1.4360078264595049, 0.1378610578309592, -0.7696244704946661, 0.9089434974505335, -1.4992123727589242, -1.0098085120059541, -0.6394719985503988, -0.7300662648147588, -0.6629021212357972, 1.3389541023143434, 0.7294641750559187, -1.421180359753621, 0.9090142271391242, -0.8807685722250252, 0.35881085877681496, -0.7080929601214074, 0.3149862243886219, -0.4093042518665439, -1.1600913147730592, 0.7859736920061253, 1.2358026262028403, -1.8137472183986703, 0.6282693054402106, -3.1471701903881666, -1.1713410305570044, 0.4637554179901575, 0.5578249208866529, 0.4886944091260563, 0.39751240107953434, -1.0113433178618012, 1.0180758641576926, -0.605646753839996, -0.30205543283315617, -2.138451579744287, -0.9857614403997126, -0.25179141629311064, -0.26991268860469264},
    {-2.271264730888601, -0.1488439198888641, 0.5662257754445673, -0.22891409783325495, 0.8615565835440965, 0.07847590383233603, -1.5943939416307287, 1.626265991270886, 0.7084604624019244, -1.0087233338231616, 0.12074953222174699, 0.2697439646843196, -0.4479241433178691, 0.118475694318261, -1.2141119580692006, -0.8764188327701007, -1.787434747001783, 0.874884992314178, 1.1228104220875246, -1.3750195474398157, -1.2750945843619832, 0.2215163221663312, -1.581790170587817, -1.3786035278205673, -0.1119303524946116, 0.03120339401802126, -0.4389926347167886, 0.019071549719531653, -1.8665061637719769, 0.6362448036190205, 1.4365672905233777, -1.0425192009988866, -1.236156059333993, 1.4008211854232526, -0.23490696027147343, -0.07033501844756002, -0.20576884489670785, -0.40850619755955975, -0.14594244419568092, 0.054679327697510674, -1.099166601425972, -0.32600352277515177, -0.4987128426230099, 0.6511921839677859, 0.23202995857413217, -0.5009261673495243, 1.0844233442893239, 1.1094290528632094, -0.6352241013164681, 0.6199141309683303, -0.3383856996565193, 0.26143836191323333, 1.125074346088464, -1.4794132583356963, -1.106041942161196, 1.7487418338950513, -1.6904698270111178, -0.19248884189750992, -0.8111117436295555, -2.8340837904472167, -0.5713186332762815, -0.5772885441644837, 1.8943788456357462, -0.1508990350098584},
    {0.09153328175392557, 0.1399034262695765, 2.0104625868539556, -1.0884320823786224, -1.702304811473169, -2.1412018509373243, -1.2750912190161636, 0.8301912477149567, 2.229014385310207, -0.4905797190460267, -1.5074213786067034, -0.968158696941079, -0.6503126926390427, -1.8037507306276215, -1.8874950719783627, 1.9138494811629148, -0.5612482265008508, 0.7610213481463194, 0.764858685452879, 0.9973235488655168, -1.6305643498867515, 0.11313400094142655, 1.3572726485691107, -0.3172204614196182, -0.3361792464820838, 1.8174123653698968, -0.8971973261320668, -0.4772191475146966, 1.2656993303586863, 0.8045125403441408, 0.12995895808826508, -0.2537852741714405, 0.18618927298101617, 0.363215921707367, -1.6919256484334684, 1.412047925224435, 1.0948103257594137, -0.5001368949753439, -0.6240485026585066, -0.10442019331356285, 1.706756408543987, 1.191490084492985, -0.7417224308666707, -2.923031922371357, 2.3985673774133263, -0.1132988775033995, -1.4903133186497757, -1.1943985206164964, -0.8254637148428685, 1.1338455927452114, -1.8771490429969118, -0.2328605130945638, 1.5843682043613592, -1.290747074210564, -0.09106303696326387, -0.22062769268732857, 1.0311804505545004, 1.764017305003829, 1.7492976683029262, -0.8660278048203781, 2.0172327393962237, 2.2809956564774723, -0.10552127716087806, -1.072958865963864},
    {1.2717296776178322, -0.31505100112040496, 0.1680224371099604, -1.975277046958045, -2.3341114262691938, -0.441771944421173, -0.7686520335304554, 0.4522809068097695, 0.19959058401304736, 0.33260088532393484, -0.08060658488582373, -0.40019335451557814, 0.9506638212466462, 0.4184482401821575, -0.7807064762857379, -0.5347050650840504, -1.8639068750857029, -0.7621638071456713, 1.4932555355665436, -0.45454509402667065, -0.7849280378327522, -0.6651156591742003, -0.1553366611737524, 1.5799522535383828, -0.8836059278755317, -1.275015811033862, 0.3798098582393901, -0.294087486042917, -0.13095458936608023, -1.3746752608695305, 2.4393852862985295, -2.1378449598068454, -1.7041923095141684, -0.8658797869744309, 0.7486677511846036, -0.5623639548873737, -0.906170520840046, -0.197031440722714, -1.3519873711661043, -0.9549823140636029, 1.2970455808921262, -0.3184506810810535, -0.3091460581591459, -0.0677449505121272, -0.6820558758140307, -0.7692801532445644, -0.38177127908355213, -1.9110437489424428, -1.5065618569127992, 1.068114466417743, 0.9686946420816672, -1.8825440906475686, -0.8931487177900506, -0.12647959069337314, 1.237263000409177, 1.346753523755367, 0.19378666278321416, -2.6873467411548875, -1.9981854221204096, 0.14970071348649325, 0.49794996151348697, 2.2560494000450007, 0.7323159266523386, 1.8754780554394634},
    {1.009921843480773, 0.046466392447024885, 0.7867458018508862, 0.42894128836065337, -0.7146260075469235, -1.8411035643194396, -0.775983796348309, 1.272302583667847, 1.5025822733929213, 1.856447401435463, -1.7481773266990985, -0.527530535704621, -0.164440495591274, -1.046855133249184, 0.24545062980404356, 0.2166999012012634, 0.19138932312256418, -2.1303005780516306, -0.24666265187576966, 0.2863473824354736, -0.7431537984924185, 0.9968945880875169, -0.9801130656991107, -0.8819613698541253, 0.16361407191545527, -1.061897354906428, 0.3835175951679212, 0.3091061162627086, -0.2367420802134101, 0.6315922206659157, -1.327690783757854, -0.6768662233166478, -0.9512891474631344, -0.3966808868954653, 0.4324894264775819, -0.31615041603999355, -0.9419189019107614, 1.7284838585038662, -0.07906462612123355, 1.5441297906066163, -0.5339637740643897, -1.0871200859440242, -0.0344283111674114, -1.4818410539033497, 0.9342578481770432, -0.8953563126457039, -0.7721224047034523, 0.07148824765981493, -1.2462810203710677, -0.20300354566908663, -0.5029643587559823, 0.40844277093285786, -1.4423898731398594, -1.317546528682454, -1.604962140739074, 1.3863442025393584, -0.19119683242851393, 0.686716513772142, 0.6813641600222025, -0.12560587786693173, -0.8522678978710223, -1.2440830715003595, 1.3284507236020258, -0.2589419606903898},
    {0.6239858156712942, 0.20510046476042168, 0.5978110768449469, 0.287520115366756, -0.5034765266040165, 0.7125329275672524, -0.5371304283081411, 0.7603351168817263, 1.6808094605659916, 0.8584599634195959, -1.2859645453631285, -0.09352330988671193, 0.09970317546329811, -1.3628454957764464, -1.1798188509736747, 0.10976398503484681, 1.1483372873133062, -0.022722641914501067, 2.019671515216901, -0.6600169338744036, -0.35086929530105077, -0.2520841314879407, -2.95879996853097, 0.0839884001041587, -1.2902723196157584, 0.5485701344374693, 0.3557774624761596, 0.07012479150654152, -1.6073468001778604, 0.5037066230891236, -1.855013114083657, -0.6670373390606009, -1.7128374421707002, -0.5483755376525732, 2.1595210947284595, 0.7459893967692476, 0.49486058590912907, -0.4316779839595071, 0.25156443805072437, 2.0138996053233615, 0.9535530802999234, -0.6281537290714754, 0.33375096202454513, -0.8662753494173882, -1.0746145551021988, -0.27563237995394846, 0.9822415101152554, 0.004776619708000388, -0.11660384266997886, -0.06992869527184982, 0.13373269203555788, -1.4479483271110243, -1.1037505122294946, 0.7353764499653442, -0.6417419382673026, -0.20088462639845903, -1.0881261514407088, 1.2146208203758957, 0.2051875683165376, -0.9427922837348038, 1.8186469853813678, 0.5899197896466409, -0.5157210957322079, -0.27418409192852194},
    {1.1812417431456224, -0.7675339355328699, -0.6206187924785256, -0.8657252402772248, -0.30991509545235246, 0.03406942590422132, -0.5298590202078386, 0.4296120037377065, 1.2329289217294819, -2.202234100341338, 0.6942672853088777, 0.8218832216643385, -2.2284557112614976, 1.7741093683458937, -0.10977202257433173, 0.23675328003477802, -0.019877559039971213, 0.2812629727082417, 0.7028200405584905, 0.2451468928233599, -0.3771580850423717, -1.469803185065638, 0.04407112369904354, 1.1238214723609632, 1.5142920922402485, -0.8839696585359799, -0.8152667377746414, -1.6117675545692782, 1.2223629744043814, -0.8923904519237483, 1.1874347923754431, -1.6566871618488521, 0.09047265652236994, 1.6370921332558732, 0.5034827003245916, -1.111116775784282, 0.9183522044026496, -0.707275981966641, -1.8978218662099278, -0.7265884358087009, -1.2435846122460752, -1.5269319459596264, 0.601081973312106, -3.4596705946117403, -1.3053168471114927, -0.7424816006777333, -0.8925726471413379, -1.0596388702670914, 0.0485043526678255, 1.0798633219121314, 0.34619146594299216, 1.042319930837379, -1.2401333650068729, 0.678291375116242, -1.0164116651395905, -0.10972589551345208, 0.28769944794073304, -0.3563390097337353, -0.5984082319863977, 0.5732554142793914, 0.017138027900117685, -1.1100194856554293, -0.5184356011028582, 0.43275702800403565},
    {0.2823768399117753, -1.0882655080648465, -0.9924742000104386, -2.287426137033092, 1.7436596462234675, -0.7801433405771917, -0.10658583916612957, 0.07972818749464065, 0.5568007856958201, -1.0616268892249825, 0.43541095439456573, 0.9941420399774026, -1.3250815859101985, -0.47052437450225143, 0.576831310964746, -0.7501646567389791, -0.466349963268302, -1.4522433831805903, 0.8911026472161367, -0.6976577336044395, 0.42681230149724325, -0.5561563958059962, 1.3601356238840612, 0.963165078108652, -1.6716609318586635, -2.13870392137049, -1.2487063643625171, -1.2076590235361209, -1.1663146727044515, -0.21003001553975076, 0.31964257838379895, -0.6899144831832901, 0.05611824602312212, 0.42106283056788557, -0.13505524083749182, 0.31544142452709567, 0.9416713711577942, -0.11759760002459665, 0.9354000324482096, -2.4849894309299385, -1.5408680477845418, -0.21069534643014745, -1.6339122466027665, -0.013505776579675213, -1.151704392983503, 1.0714627577909477, -0.18027089260682397, -0.22250080173757403, -0.3609937733778194, 1.0111347744570804, -0.601469653199285, 0.15110734188825592, 0.6764301310344308, -0.3649440062759061, 1.2113404846647267, 0.2537780425503535, 1.1542352115695445, -0.19786309998254858, -0.028435204165931652, 0.6669259793302468, -0.19289883951614084, 1.0193276056270182, 0.7909189612134909, 0.9577170395920753},
    {-0.6909988226433849, -0.3521815180230325, 1.360538569447987, -1.5682572135994008, -0.9154726836085293, 1.6439090047301195, -1.7488284340899636, 0.720252377832294, 0.48451413446641933, -1.27597958674892, -0.6264771311608258, -1.0389392428552506, 1.2826427193828653, -2.536972238073624, 0.6861152093623174, -2.4748300595790003, -0.26224443536397146, -1.636693289861377, -2.2206022161226335, 0.19155300997046237, 0.3490313988684697, -2.175592477419442, -0.6827437291327405, 0.2728764430738134, -2.5425409209142242, -0.8522640202862318, -0.9014764338643317, 0.12214617874257502, 1.1069121358512384, -0.8507048983246654, -2.2781321881478327, 0.78141297903095, 2.6630502145055024, 1.139142218805, -1.7976454883782027, -0.8861646076493118, 1.6159507003852003, -1.5399697782418147, 0.45358176112488385, -0.5710455410143283, -2.410502585214357, -1.0178647650377994, -1.1391816012859513, 0.6109831860367739, 0.8689322519016794, 0.35819377235828526, -0.8471902461607638, -0.4748580328040227, -1.5687665455229802, 0.6978655938772974, 0.20525895869012276, 1.256102355331693, 2.050317493831579, 1.1079061659689269, -0.005740049670212536, -0.10263128941347531, 1.112241906650754, 1.1305664492993728, 0.008751200231479033, -1.3171183027938314, -2.2879496552717664, 0.10388391231929196, -1.5772216354764632, -0.13862874141108406},
    {0.16779711106441147, -0.6131943516099991, -0.6293264450590602, -1.4420186224777594, 0.6347266089448783, 1.3037297277264874, -0.999829919785976, 0.46733263765089506, 0.765259470739243, -0.1707185967791657, -3.030813144163661, -1.0913623187247437, -1.0348194078268125, -0.9719663494542868, 0.9464948149784241, -1.9786106052442418, -1.484452600550325, -1.330916922462608, 0.026675284239228516, -1.4652558121573838, -0.0390089064131433, 0.6364269485595375, -0.1262779975268423, 0.3742842671000717, -0.6611362724203562, -0.08403117749124067, -1.9296237588956031, 0.1153810738216324, -0.9684664381939265, 0.8085384206800459, -0.561748612026972, 0.2593670621024583, -0.5082298709014215, -0.5702585620330277, -0.9802571640591541, -1.036880136248224, -0.42682209884674016, -1.0938422216969514, -0.8690149210157978, -1.1598271316510582, -1.0320478208273967, -0.27326469061454517, -0.8767808002492086, 0.7552157236883013, -1.956656807246043, -1.3440778373153717, -0.6703041485214579, 0.5697359128563917, 0.0644054257519356, -1.1255093768274005, -1.2880659792971363, 0.6467045698700252, -1.19990727965353, 0.45364860342931607, -0.4022840314926634, -1.523449427508771, -0.11313588656283033, -1.009848723981595, -1.3282988712380828, -1.535719069548214, -0.06576182629069255, 0.7427995434291342, -0.23016329334903626, 0.0963075430506856},
    {-0.4937335713559283, 1.1087403389302557, -0.17350122418809966, -2.285502873748469, -0.42913422233891524, -1.8609572572551332, -1.5859699494159412, -0.8467546298176669, -1.1654825363604988, -0.5478606200214197, 1.0719632705724427, 0.02580404913339246, -1.3966693194032591, -1.3894720274794605, 0.1430489248634865, -1.0827912100194452, -0.5350778028965885, 0.07726598850794125, -2.3732751178170393, -0.6373378962104747, 0.027058864348081475, 0.5293617971107679, -0.5070436950537648, 0.3240126405848914, -0.23446518360193216, -2.081151116615714, 0.2899593495748117, -0.2913741739452695, 1.0002765819181163, 2.7951551560344687, 0.6815060185097106, 0.24657404037083816, 1.2548428446484048, -0.667463337570275, 1.09155737037845, -0.9940684200862283, -2.090330335847469, -0.2879141675020267, 0.00036034181440015937, -1.3955950221901374, 0.5419604721793441, 0.004690689309148614, -0.49173188411474544, -0.49467244509449526, -0.26204053807646116, -1.728377277920144, 0.3936674245708146, 1.2391719709782396, -0.13001325134851502, 2.0745083645761615, -2.259837692741792, -1.4044170076471398, 0.2783922161555637, 1.6925791467139528, 0.006979425113913995, -0.09766375566522154, -0.9184085063271128, 0.26025171650783835, -1.3990366941086496, 1.6929878440337223, -0.9533751444932078, 0.7952944395396709, -0.616349825831617, 0.3074303968960977},
    {2.4876467188128526, -1.4286455179466966, -0.8702534988308216, 0.8401531815170611, 0.9851911861516248, 2.0836243607733693, -2.127654846945599, -0.3639751381581887, 0.6840928937309169, 1.3763458293001498, 1.7756630142301528, -1.2108147694958757, 1.474524764987401, -0.5124552958509316, -0.7177011085057814, 0.822410576946451, 0.09644598535950724, -2.154990674846055, 0.21592477797555854, 0.17669631238103017, -1.7342138330923023, -2.332096728314927, 0.48392387430058914, 1.0842008119221729, 0.9177259545489215, -1.1947830112726952, -0.3819488485154089, -1.5838539168672092, 1.7542578593753433, -0.42479886758835145, -0.31411705705701753, -2.0827963861078844, -0.6449213663514393, -1.2164360323895185, -0.9725176479472105, 0.32852419794985627, -0.2569816137963042, 0.4302468494961674, 0.06698759633024508, -0.33423351444812444, 1.75112123881514, -1.0297176890343067, -1.5636870056748442, -1.2209990357889342, 0.28683491588094007, 0.7057272929098339, -0.9282459029723328, 0.7270459196317391, -1.2879007287610684, 0.8166921974534759, 0.013329085259592028, 0.08027051734787334, 1.0676348601452306, -0.9011886358114878, 0.6329224820519761, -0.3545588850721045, 0.07874343115846909, -0.06721593208194732, 0.2906302156281701, -0.5971920535920465, -0.5970124536911191, 0.17021811095840017, -0.9845397767793533, 0.7531972824297238},
    {1.8000682856119545, -1.04029651742936, -1.9926383884536727, 0.5388028961616621, -0.4466851369386046, -0.7507642216745376, -0.41019795507275664, -0.42182212436822236, -0.2686161437647054, 0.3241783087908126, -0.7110587206266593, 0.14327898939287806, -0.67981806239974, 1.2727328446367625, -1.6609140893651038, 0.5044159939849406, -1.938032036951621, -1.9457346014952173, 0.9436557918216285, -0.5874141366365527, 0.3756776333257105, -0.9961619848836719, -1.1793558583108108, 2.335900146116899, -1.5624201809057168, 0.22314115460156964, -1.506433659199508, -0.9062271620583225, 0.9447626016789796, -1.2466674794547374, 0.6258938833685138, -0.7528198938310727, -0.10730954028877666, 0.004127998411887764, 0.22934734635277534, 0.6100559682343696, -0.025025919228509812, -0.13561518843624845, -1.1589674903540337, 2.042961495625854, 1.8462890805139172, -0.010113047886210012, -0.13036783544849848, -0.14662473840991622, 0.5393749113362648, 0.3697309428846453, -0.7634764192158505, 2.524652720645981, -3.4006684361990396, 0.6680914693012203, -2.227805900992159, -1.4175612194902176, -0.15165169043422352, -1.3097034513203762, 0.6454425286921611, 0.7314940419183337, 0.012251306463077155, -0.10041656661813762, 1.2369432150931972, 0.36845579808445295, 0.22757520343407697, 0.2841341440745898, 0.18401643608694138, -0.8433698489557162},
    {-0.5722467288374816, -0.4604405631565085, 0.7642086706100114, -0.7485945626703004, -2.0238420736422738, 1.2073513558095856, 0.34335566568248704, 0.8645267199029224, 2.8832455477124155, 0.1652396447975723, 1.0570839916931851, -1.994327848233553, -0.9162927992736065, 0.6569496466942923, -0.22911654572622125, 0.13613098685547823, 0.8395657619603901, 0.3204017179060708, 1.4460588790541518, -0.15528073251324767, 0.0934439721124457, -0.14763491656988006, -0.8028861610207569, -0.18011663834785124, -0.9207700615263666, -1.8059169944588873, 1.0004776708216663, -0.9469018574209989, 1.0581788018350753, 0.21329819073681416, -0.1927689636293802, -0.13873146980093076, -0.8207883852548261, 1.2056728023441425, -1.0195704686424087, -1.1926431947161478, -0.9577570515778865, -0.8013012770553486, 1.1572929974293986, -0.15493544931409148, -1.3009236664059556, -0.5244273748034766, -2.3525333803047284, -0.4851691898535039, 0.8888427686103, 0.667677853816849, -1.209171593525389, -0.031542357915677714, -1.1699204760860313, 0.7508751048173513, -1.5649715955322696, -1.649360900044941, 0.3941551114657372, -0.340528138601724, -2.1768758846051885, -0.8947538369098014, 0.17251930941956958, -1.0443863734750451, 0.6119383220688849, 1.4057401451590308, -0.23562959439241726, -0.2592993057920942, 0.40661516899775824, -0.9315815497842879},
    {0.2141257582808451, -1.6494317981419124, -0.0904989064431313, -0.45754037553224197, -0.22719873890574888, -0.04104303591110394, -0.8221205700487588, 1.7687987509648015, 0.3715065923575704, 1.0636124972046554, -1.1780294142433676, -0.7324287404012066, -0.33047263939089006, -0.3771670286755814, -0.40661014644538535, -1.0508903684748965, -1.9171686916897734, -1.9299901446449836, -0.20781010565887464, 0.7268945908169994, -2.851745361198692, -0.811232669876375, 1.190604619814152, -0.5492302607490258, -1.7617633988415935, -1.6870911632281465, -0.22874167538193524, -0.6268977740689665, 2.7716994650981386, 0.5653224109421298, 0.48116402806953273, -0.1676058471442762, 0.15762222978587306, 1.2277360494482266, 0.8701220296641394, -1.7376963867717234, -0.4787704404120624, 0.43390173173341584, -0.4209236424352627, 0.8323902009345175, 0.6154901625662927, 0.00869793324884088, -1.5187004373066941, -0.2126622773167587, 1.240028480645145, -2.1442259580230867, -0.9153959027947688, 0.38086516187091446, -0.21081264369112074, 0.5937736584999236, -1.0111153828513888, -0.8101996949173815, -0.8161789236087119, 0.058435773645531985, -0.9327229799695751, -1.6461230337000206, -0.34581014497842516, 0.3378036499187275, -0.8986124282021496, -0.42259178329489516, -1.622345553508448, -1.475919848167317, 0.09749250869150437, -0.03727083290691393},
    {0.1703660009005158, -1.0626547938089046, -0.8945052158687822, -1.134857777112743, 1.6332806760378842, 0.5734494419861691, -1.578524474763671, 0.18776285342321278, 1.59146547285193, 1.130437577348485, -1.717263363539614, 0.56594535902782, -2.125345609034114, -0.9839785197284052, -0.9529537574894252, -0.8001562095245259, 0.009841945076437035, -0.654880786121964, 1.36660690825735, -1.2493941391977454, 0.4003961041917914, -0.588347805767475, 0.49871899756580357, -0.37414936833955864, -0.8227953713326706, -0.03017319797499065, -0.3440578823930539, -0.271520496561907, 1.6120609982271048, 0.9918398350481648, 0.2575777863955462, -1.5862448158082971, 1.0548625858358671, 0.23706640908157325, -1.7368539213091294, -0.2697653363119299, 0.6776006145036715, 1.1285992161295983, -0.5201121038749026, -1.254913906931714, 0.6539965104959136, -0.3274320587931724, 0.896545773399107, -1.161186626883382, 0.8110745856799838, 0.11788576006167677, -1.6856119401232168, 0.9711501073351313, -1.0296120656667078, -0.6215822821090694, -0.7652690875354247, 1.5259139484505682, 0.8949767953814856, -0.7556926507459336, -1.8516468783508002, -0.7038491649994983, -1.2300241396478244, -2.084844303977247, 0.014151891369115462, -0.767961442513971, 0.6663517059002461, 0.08253533913480264, -0.773570645412971, 0.3979526763804565},
    {0.6153335633795428, 0.4505870698754717, 0.0017555637875382442, -1.3575883102523143, 0.24457271378601977, 0.1088857150187268, -0.818183261542109, 0.9651606651314119, 1.2851678781563936, -1.1943888695990292, 0.31931123916631693, -0.4992193274545619, 0.236956890395606, -0.5899388294206563, -1.4504657448687939, -1.017484814422668, 0.23989128166200777, -1.525191263003098, -0.6549844293186646, 0.6017471900618648, -0.3614867256333993, -0.04815540819957075, -1.857112047966078, 0.9099628022427161, -0.2868609901986911, -1.127213708585634, -1.334352525863645, -0.42835860735528725, -2.043720929682851, -1.454585009661637, 0.1556639948842283, -0.08373589814608079, -0.4353134421878261, 1.133028093642793, -0.6410978532859412, 0.7628094507631371, -0.5771017139230477, 1.2189534004166585, 0.4325160665797225, 2.155153364654204, 1.711788352912866, 1.30600184540694, 0.23085647856282518, -1.3341696991358423, -0.2759235474337293, 1.6107607879413774, -1.136347221625814, -0.47856374923347156, -1.3868100333780247, 0.2506474478395049, 1.0009276774823779, 0.18054901594687697, 0.24287100938962997, 2.393772759937491, 0.132270710537013, 0.02983260464006377, 0.21310279673653326, -0.8765922486687251, -0.2391636024221683, -1.648091972169019, -1.0439130743270693, -1.221177649406753, 0.29592405930707594, 1.2700513746421986},
    {0.2912576850385896, 1.7033860959180056, 0.09745022916087336, -0.5909707513052975, 1.4681374251084673, 0.406133728268383, 0.6012018143390169, -0.4783512899277721, 0.46060981772804643, 0.30209277062698797, -0.705938143130394, 0.31020627464753164, -0.2883222431967176, 1.5480423278943307, -1.0018275604807345, -1.3725314994663436, 0.3553019239794663, -0.2745339797204072, 0.6512451150483543, -0.34212390602224796, -0.500331546690318, -1.5176440832401874, -1.9460250197957096, 1.5054190033529529, -1.861281153354839, -0.4078419848536654, -1.135800258606297, -2.096084101642099, 0.1686806048457754, -0.4698561443069698, 1.5683389773343441, -0.06052720144539966, 0.45866548909039173, 2.939534532356026, -0.5339571127758543, -0.02171234469212183, -0.28862075690726857, -0.22746958859502608, -0.8987916462463956, 0.963025913900014, 0.013281242681128328, -1.7512897986389684, 0.44998700516000345, 0.3431071268993056, 0.44767242883111885, -0.9429210457751483, -1.257456432539579, -1.9817864218851595, -0.19105440692222134, 0.4288882050461817, -0.6312196626429166, 1.2449382094073658, -0.31502550196064133, 0.22293047947405906, 1.465367081824281, 2.3149214307951604, -1.2985425453243795, -0.8003678490274887, 0.6835841100292115, 0.7940378515314661, -0.19798715195697836, -0.7648915663129844, 0.42528559976858715, 0.2911802603688458},
    {0.3133354283332775, -1.4241645731430437, -0.21533519047873528, -1.2527109986181038, 0.18740197474973289, 1.8026560700659746, -1.6008021053120445, 0.09681910327601266, 0.8294122528714447, -0.3649622756684297, -0.8442723074004813, 0.6296489984262936, -0.8749899342283171, 0.14825322545615005, -1.3396833274492985, -0.03853291617434529, -1.7926174951889888, -0.8793817718823419, -1.391733829403418, 0.38397550518085205, 0.5776766601233143, -1.5382315093228898, -0.24954837489486356, 0.4573809700861267, 0.3973236544725468, -0.8033053329668965, -0.2715101913102666, -0.7091885956395866, -0.2823470122858428, -0.8110967472205138, -1.6868271721274568, -0.5505907527269138, 0.7891255309879985, 0.2573947810384261, -0.1788256930397397, 1.172731860933057, 1.7102638201799258, -0.8953277025602733, -1.3278103531186394, 1.6817330621017654, -1.3706419858380718, -1.6851978963178178, -1.655117903544517, -0.006019920817278598, 0.48068122373368294, -1.3118681154342127, -1.983170144292174, 1.931879104393675, -1.0516831123756742, -0.6187388551214144, -0.5867109336776866, -1.9122627881198389, 1.0595293095160878, 1.566326370493888, 2.306539787065745, 0.7329972306295731, 0.05727681570113004, -0.21097293276578521, -1.072605186796514, -0.27820706165666925, 1.1251444111768163, -0.049354473310175485, -0.5457361995174745, -1.756533427573035},
    {-0.801007610438853, -2.6260942268563507, -2.203472423810387, 0.043094369789918895, -1.2174902516777257, 0.5717196145579659, 0.8270125997103928, 1.3368368929092853, 1.2725180479393656, -1.0969561866365036, 0.23061652545527192, -0.3990354026457193, -0.8698838043242004, 0.3537369110061317, -0.5246231622612332, -1.8551041152641068, 0.4277263296611607, -0.6363769894682324, -0.3105292730492536, -1.287357768467268, 1.0952406382596016, -1.2358576108504595, -0.30987009455180586, 1.3585334482279594, 1.3318313179392225, 0.22933318947406986, -1.1723373417441159, -0.3065093185568281, 1.0618631944869967, -0.4200062169186858, -2.0014562503161533, -1.2113770825971326, 1.155474988569941, -0.8511469534650549, -1.1890632487341226, 1.3636000527242773, -0.981618445165796, -0.22098073218876435, -3.53950788861081, 1.443321585517809, -0.2646388334238224, -1.1867088086719513, -1.0925732177481609, -0.6847823512282819, 2.3111282347046136, 0.2090878896626858, -0.31879955552507855, 0.26087301006218844, 0.6745550419497632, 0.34030983522615393, -2.0353075763531536, -0.1295706720919693, 0.17433009714022143, 1.6178995094527195, 0.42864747631664407, 2.009752246220028, -0.7588695628612598, 0.13991400568888296, -0.5831629486888502, -0.6375620831515544, 0.5938863856833013, 0.5817187176665782, -0.5872542184675361, 2.148697208824076},
    {-1.0726520284356225, -0.14236431199222618, -0.029408287543592274, -0.35796598452225187, -1.0203737834067297, 1.0073236918806474, 0.5371986168976406, 0.626000043018743, -1.733905126425932, -0.4742342778027828, 0.08250159156650262, -0.343665904853629, -0.2766154336402966, 1.948000356503508, -1.0568841605292953, -1.1714050414718264, 0.6265271420280185, 4.372117052113819, -1.562727691987527, 2.189371636836586, 0.7925179765647122, -1.2149126868301268, -0.3263791080302734, 1.13130179187413, -2.4723727755425227, -1.7414447915035824, 1.025749535086792, 0.13903561226088648, 0.5751549068565911, 0.14161733517855973, 0.6342015552952208, 0.625747915632501, 1.9572615003284877, -0.5184603252129192, 1.8181228848811306, 2.19696030861212, 1.3132887682046117, 0.7364995369649894, -0.6216411025870006, 0.0884189007581912, 0.7669964278444413, 1.2696472835221027, 0.680879190633767, 1.1534374667655416, 0.1551531274349082, 1.2128461442643053, -0.391907410368915, -0.16831051804031627, 0.02176675633315657, 1.4532367898404654, 1.6067969451326645, 0.5043244751394, 1.540390533686734, 0.5984440432856714, -0.009728592004492173, -1.395440581123679, 0.9514360959536623, -0.34267064328875446, -0.13957976581467038, 0.9698958766867134, 0.04832389191973148, -0.7785388662779495, 0.12620771940296652, -0.39630473409801864},
    {-0.26761747934571023, 0.6478200945240619, -0.5093042347916719, 0.36591899705177094, -0.3655944995123364, 0.7215036814119633, 1.1332460674320581, 1.3462489768655388, -0.6313672033111246, 0.19469310455058697, -1.5899809163206162, 0.8702123619141068, -0.6089032050110494, 0.21141482505354237, -0.40151785246432353, -0.5294403563005997, -0.94109490559304, -0.4986610181387926, -0.48436107900675934, -0.48902540617081974, 0.2319225104965673, 0.04422387487795839, -1.4033362564963414, 1.0157731728271517, 0.26010718903414504, -1.1351525313124395, -0.04601116722170669, 1.9061434439520955, 0.4043765200262426, 0.0634915648361574, 0.3105195856251564, 1.1949652399615955, -1.1842992757931212, -1.3488785303994038, 1.8635928249138864, 2.7285004080027107, 1.1594395493876366, -0.000529070689553347, -0.11081699844862995, 1.8048389479636522, -1.0296135418018662, -0.6981590766334566, -1.3914198193683862, 2.1395715697962245, -0.6874207748455201, 0.11918752397725309, -1.2117083237770852, -0.24952285179507322, 0.16828636410167136, 0.7738731222672204, 0.913441460343405, 1.0769747627800723, -0.27725152796999303, 2.12139434352144, 0.2177436477657546, -1.5178275765309657, 0.004751346160006806, -0.9261042988527401, 0.27646413565343814, 1.552380184540673, 0.0852706705731053, -0.3565627840083789, 1.3270513284136425, -0.8542917209893806},
    {1.6281368132026839, 1.8400015449598608, 1.8027522076236726, 0.1065082300444404, -1.1135870298943622, -0.5984657169145561, -0.5588733386663743, 0.2197219837386035, -1.1553463569113323, -0.07265895258071678, -0.513013814172786, -0.6881560022093206, 0.3722194334857279, 0.6045833490971961, -1.7654647094683955, -0.2455328544162136, -0.7023522710487476, 1.1164179924798043, -0.8418879786664402, 0.11858081665691016, -0.7110799946579768, -1.5742186507300449, -1.3524692435085581, 1.0486147129606458, -0.9037567458881786, 1.4739470263865715, -0.6924524009051444, 1.5110167505449374, 0.3347216956645504, -0.13191953473888632, -0.4595508563915377, -0.45475841123271465, 2.034824731647896, 0.43716657531864117, 0.783759280820959, 0.1506694768804317, 1.0036052479933002, -1.261764014120616, -1.7914523807351808, -0.17042768205703446, -0.7556114184772689, -1.4651664657489787, 0.6759479219232776, 1.2610403368826035, -1.1113626708656636, 1.6701847005780481, -2.1461885657242945, 2.2826790778855717, 2.1193935218160873, -0.15252325860013188, -0.5538326292427389, 0.5432645959936031, 0.5908743565507547, 1.2465963253509038, -1.9851855586775045, -0.06198773066823713, 1.4433411819038655, 0.3385133918040583, 0.6406580314365725, 0.41892755075519855, -1.3761679980204327, 0.06754863914951233, 0.5061259804351502, 0.8591841778581087},
    {-0.23695148927423282, 1.2000065262972825, 0.8984374475684584, 0.24935968285543295, -0.7963772970286527, 0.8914086141179305, -0.5260148243498877, 0.864199862870727, -0.9280669159979851, -0.040147515248688724, -1.3725056293762719, 0.21954374459227016, -0.037804754770937324, -1.2872445610204066, 0.04643933164046999, -1.3091173986743907, 0.8619966679468107, 0.37912348008759167, 0.43627545039229026, 1.0319378624919464, 1.105894448873033, 1.5111440565398861, 0.1439851621462159, 0.04240338727794205, -0.6653250831289005, -1.410454286698058, 1.2329931267969672, 1.2508734044833487, 0.07962736956442434, -0.36158351846563425, 0.5825881130402281, 0.07026470682599403, 1.3793781199825594, -1.6277414070010894, 0.48686769944546177, 0.16848400172093594, -1.1959042414555734, 0.6057073696725147, 0.985929692613933, 1.0413197269047145, 1.0060386777517187, -0.24329233119312024, -0.08848001111163258, 1.526770956941772, -0.48140839753296044, 1.822104409631707, 1.1726437655118258, 1.9682349868812197, 0.06875722582218577, 1.0384503754637624, 1.926857043017328, 1.9863467498764367, -2.0670124298880332, -1.4304047529944144, -0.3629695032814107, -0.35776075067708774, -0.5490907177016878, 1.7354450161648887, 0.14085625678347333, 0.4018352660707601, -0.06553718832862392, -1.9337033571467486, -0.7527081119366827, 1.5698943650891435},
    {1.38822796484745, 0.17425809316243415, 0.6354439976341285, 0.4166528909411411, -1.286097486516723, -0.0432831253714848, -1.6271215047518455, -1.3071516908180898, 0.9568517038167177, -0.4596573829601692, 0.07891028026601628, -2.4100978470540313, 0.8558379909343388, -1.2587009041667512, -0.5181892374308992, -0.770171211083589, -0.8315473627049101, 1.5810770165354966, 0.9483882548962953, 2.1079231485408636, 2.0120032153766316, 0.37679085337402923, 0.4797278795893001, 0.19410296114982808, 1.2769335703530207, 2.501866827262855, -1.5875702032639636, 1.055524893326299, -0.3288754254662298, 1.3460584618553564, 0.0585717680536336, 1.4488831094192198, 0.33345346273373094, 0.5337740922594528, 0.4370230258354104, -0.6538085376675217, -1.1864156728731023, -0.5982617372194009, -0.29912161908454565, 0.24707723906109597, 0.33279792198233366, -0.18153520419223326, 0.30517318716133657, 1.093129487986867, -0.17191998392516777, 0.6634993900805057, 0.8470104105044268, 2.3242729638751243, -0.0993288486614812, 0.9477456526289786, 1.1496183311649195, -0.681554496893341, -2.213964687932687, 0.5822842698463222, -1.5245304362906855, -1.2460923645601714, 2.755176776774248, -0.9386441517428197, 0.984640606761844, -0.39229133760546114, 0.6005543481273962, -1.2160448922876514, 0.24766902203058747, 0.7958503593465265},
    {0.6810755151315241, 0.7738752606477749, 1.7314159951439487, -0.231985549667081, 0.31440097758959235, 1.0895458192355358, 2.4015362803669644, 0.9193329237828367, -0.8921514462965977, 0.3612762716288166, -0.007689942041832731, -1.0787506083213287, 1.0393024410012324, 1.0552938155227503, 0.02792449423819351, -1.3684718403207743, -0.5550781912971141, -0.047446888620849205, -0.19716431744053406, 1.6761121415408895, 0.18720094633042275, 1.4339309319751472, -0.48218958574216986, 0.07218591071706999, 0.6031231489286514, -0.6446586828629547, 0.848470507379169, 3.2935276214453633, 1.5393591108371414, 0.8236356593986893, 1.8064316887266865, 0.8882077316455407, 0.613854687493366, 1.0480733862272256, 0.10588292163840188, 1.345830010220455, -0.850868789645903, -0.5995931101039841, 0.3961025397720044, -0.7670844755166276, -0.2525954354058664, -0.05351938017787759, -1.2880124125010413, 0.441409758528241, 1.2753788114920102, 0.246350136633385, 1.5736827448025748, 0.6919656498358072, -0.8290980212157044, 0.42296499546184824, 0.5181751065237906, -0.36500298394030967, -0.919752542891937, -0.5813073710687627, -0.37752620039176044, -0.7241799991838634, -0.05411185331172292, -2.165149714555592, 1.151114121299222, 1.5672871031561462, 0.726030461269874, -0.3993288573215731, 2.6587773392043133, -0.4852446946379559},
    {-0.016285698949598304, -2.4343639611321475, 0.8043013695971754, -1.1651115218517047, -0.16092911328722678, -0.39282235378269614, -0.6084457705964508, -0.8612643417195219, -0.6613923485109107, -0.8991659994375956, 0.6870555390363038, -0.08193576660789569, 3.111650487287783, -0.5828112436183996, 1.2161362416222707, -0.9464918087816465, -0.9885253870475565, 0.3695219352237331, 0.012597554965522974, 1.2472883357584197, 1.4945445629168979, 3.110060597770506, -0.2523453630119123, 0.29566588122773546, -1.1678664815089839, -1.9029811067720694, 1.771209923168389, 0.6712418953112989, -0.21699178952754425, -1.115120109727185, 0.17791714682409732, 2.7249958531464715, 0.2592493208060978, -1.2025749309470724, 0.5032769606195339, -0.5573521765458087, -2.1987043164648226, 0.5416836234662459, 0.24217116338163186, 0.30212096984670517, -0.2815404705096032, 0.08121689362125398, -1.0679387003048202, 2.025011641305784, -1.1421156925286975, 0.5795074588215061, 0.44359563278685404, 1.2578463256156507, 0.12815860841327067, -0.7762473627850465, 0.800099275672914, -0.8524926103088188, 0.6578532473621462, 1.007263516170183, 0.9179638831057573, -0.6307406365906565, 0.4061563351931672, -1.4363636678468394, 1.3609883159993301, 0.5402464238842472, -1.0858233907817527, -0.6872119872729335, -0.30478570430287144, 0.7933505375335398},
    {-1.7157729503412582, -0.2938721870585343, 0.9610515021533528, 0.5151755553803239, -0.9065722026551187, 1.1093282600756293, -0.6715851780586302, -1.4104070562077904, 0.06044672458640844, 0.4312903225158334, 1.5299915537349453, 0.10159830772172725, 0.08289741773912884, 0.5672537072949128, -0.7808217635928599, -0.09911468320823313, -0.1445050499885085, -0.4802708187780641, 0.6526825912856955, -0.15927597576924815, 2.8482485199619516, -0.1503826878090745, -0.09444031143522029, 2.4405216445496034, -0.6935438925818955, -1.9551468068474303, 0.301198181667492, 1.4588650796143239, -0.9429304364877019, -2.8630267825317404, -0.8548815410204352, -0.18057291895369368, 0.07187063173213898, 2.1472634698392787, -1.780104469805862, -0.3339731816978899, -0.5819541767993791, -1.4684971924362962, -0.5306081293275928, 0.6741897117597785, 0.9968979481753916, -1.9887395147381344, 0.488317000914456, 0.4623363775142504, -3.2961016690199947, 1.8445081700241017, -1.8053534751672204, 1.3752841408243937, 0.9650041245369373, -0.12908306746045836, 0.8672503670892302, 1.0607318800284147, -1.3823791413820474, 0.4466701975853202, -0.6168234051008614, 1.427371728272072, -1.0939148748488867, -0.9202458251529902, -1.6582160266800732, 0.7829380736082723, 0.48172527535050796, 0.8700833084284195, 3.017204597097465, 0.07477596659445487},
    {0.04490990687786697, -1.1461577057735508, 2.4009593510681033, 2.2986098194161153, -0.481622536930658, -2.2588608149554434, -0.22466272316572125, -0.8924696614366997, -0.3096095465614799, -0.708450482407183, -0.03301666955419787, -0.022922067512861043, -0.6503392149211836, 1.1018109887699923, 0.5678766183118173, 0.529896228831568, 1.8697449788925806, 0.3565785891759008, -0.022290229177487724, 0.6306375593453967, -0.4807713624534102, -0.7816546741416682, 1.926160914337365, -0.005808318012461907, -0.009460661740829653, 0.47881375356388145, 1.2283096787493544, 1.054479627447848, -0.8290797145632054, 0.36982514935592903, -0.4930788527301726, -0.22147375044268003, 1.3185531447783079, -0.473404881108518, 0.5418579039523864, -0.6840953993897554, 0.47421991459175655, -0.2039631017325671, -0.04519401326878305, 0.46749706098835764, -1.322583691487657, 0.9754710519863081, 1.9654747077589183, -1.050067205465541, 1.2380213455761169, 0.6767414167938918, -1.8676028298294318, -0.5732861842443189, -0.8778419072906634, -1.4514288406790865, -0.9501780609504655, -0.8919531533042232, 1.8886497875418462, -1.523690000835384, 0.1709685730017012, -1.467773168770512, 0.6922125912259672, -0.11360680488697987, -0.28775369951846747, -0.3163033619221744, -1.0228151666305412, 0.748089791674894, -1.2006488162892128, -1.096168389551144},
    {-1.3369310599887136, -0.8381009875894646, 1.3804369907045864, 0.8217628255074264, -0.07069010634980212, 0.2834126279101805, 0.37481744772833775, -1.2436362835517607, 1.3816365055623023, -0.3888957973962361, 0.7216212161259139, -0.6675304630188874, -0.38201862854155305, -0.7777115164784448, 1.406705349983774, -1.2985711623858498, 0.17315941367039514, 0.19497618070402858, -0.5204614581316445, 2.2722961471894823, 1.22505282935553, -0.3580202202004521, -0.09856065233310113, -0.8847825640203414, 0.8119056662419105, -0.7818774976426844, 1.3995117523967981, -0.32502097340272795, -0.7437648991322866, 1.638116089223093, 0.3896414396167061, -0.9832281148165353, 0.49133266704904527, -0.04951992149859554, 0.6762207678777018, -0.34757503929918965, 1.4181616289134307, 0.5757537688132752, -2.006920333013186, 1.307014770296001, -0.9294070612365533, 1.2207361588974406, -1.0445323286711465, 0.4232191579417109, -2.293707873912798, 0.48267483598122496, -0.05413363947581768, -1.20295603901578, 1.16186128516693, -0.12061501719149484, 0.47839243934583614, 0.07866508245413131, -0.621178177863782, 0.8169649482676378, -0.49714820364327045, -3.3351401213494425, 3.9058023522596073, 0.5039003127621754, 1.042692023900105, -0.6820019172340198, -0.3856559739728594, -0.14786453957843435, 1.0518633247936005, 0.42584055562613826},
    {0.780702696857322, 0.5324022257323878, 2.4677580364462477, 0.2260434820908838, 0.16568188986022994, 0.1087668112532184, 0.10122089180060127, 1.0793254307348747, -1.263057934501207, -1.1308018239882067, 1.262139703899849, -2.2204255593762396, -0.40899268636142894, 0.44064014799765555, 0.8804721199216919, -2.9600118644097995, -0.2290589214361405, 1.139997432483298, -0.17721897241481463, 1.308426344759826, 2.316992711154414, -0.2545739767735551, -1.107739787491622, 0.5005491479570193, -1.046586261036192, -0.22018418125163355, -1.3496413483684968, 2.053002987989617, -0.25681959900811024, 0.0753578768413017, 0.4404677272988143, 0.8403629803696258, 0.9559466765442686, 0.9071578356745579, 2.337433518428252, 0.6146411158263145, -0.10742691112000079, -1.1901529944802467, -0.4638040421704317, 0.8688671205930181, -2.451115954854158, -2.5382895185485523, 0.11211442175610888, 0.5843388609973019, 0.18702717107087852, 0.9292175089495572, 1.6194392888371567, -0.5324160404410225, -0.39273139355014314, 0.9126189650887897, -0.6863471220186113, 0.811596259414962, -0.03889307618860488, 0.9053544082660975, -0.4466247387555527, -1.9915410432877965, -0.6889236558982147, -0.1795941388702729, -0.6980045945332293, -1.4751743015555239, -0.8796300042160199, -0.06509556792327753, -0.22157890394670526, 1.1829586717413414},
    {0.1799071496217053, -1.6209115114042612, -1.461564539102233, 1.4798464964594513, 0.13515608569161666, 0.3868254189991558, -1.0645264036233058, -1.5306262961254715, 0.7012326530224583, 0.09930445425081902, 1.2372447791781496, -0.1982823926360763, -0.9809684430645668, -0.4677132432057468, 0.835202839565643, -0.13880438385215915, -0.7352587693845604, -0.18076102365876792, 0.5744841071628085, 1.5641745075693931, 2.6299235025857453, -0.7145403805514238, -0.5020764995102422, 0.39456186125162584, -0.7159876213028273, -1.107071642115556, 1.0496427479076156, 2.9574264236729397, -1.366388803808029, -0.22206375605411952, -2.2041191662109845, 1.4412382641658472, 0.8331306360920018, 0.17086583534873345, -1.3572253087886048, 0.4663336833160533, -0.28978918572577195, -0.5569088104054728, 0.7520202433458871, -1.097690401955075, 0.11436334424737815, -0.8557071575706352, -0.2798616980848414, 1.4176464048316988, -0.4722309159974217, -0.5941697354305976, -1.3974434800045177, -0.051747490197277465, -1.2076561255216494, -0.2829536216097589, -0.06164380560260395, 0.6951808490445399, -3.036009312896796, -0.46290493236999947, 0.072604226496526, 1.22975779777759, 2.1352695751852364, -1.0828555972723612, -0.31514002425787435, -1.2065543349353325, 0.4444113642537841, -1.2693051446393835, -0.48872138798782305, 0.8227981688237229},
    {0.430463678732751, -0.09652284114058335, 1.455901573086561, -0.5742714962930524, -0.5129674157849092, 0.06308011987543957, 0.8813597528893248, -0.16540520383350085, -0.357771550418427, 1.0563808840368294, 0.34613310895905897, -1.1561921923415288, -0.4187678235374333, 0.570544350081975, 1.3566990417414027, -0.20997577909561307, -0.35566543771704306, 0.8030983321591728, 0.9467762038739432, -0.8991122233493153, 1.4825947452113006, 0.3341243125590197, 0.8576023138985057, 0.2997738471582935, -1.8304934020643855, -3.315376217484452, 0.5117866719631513, 0.6330495967893756, 1.0713623785723807, -1.3380058146739884, -1.2859978857971917, -0.11464393283519207, 0.8450224454507143, 0.1334125591883228, 0.9376091391671321, 1.3200831275540525, 0.01521717149972035, -0.425553047599385, -0.9024253775041202, 2.321701481032006, 0.049078541126568336, 0.5831799823246153, -1.2268181971095435, -0.293942062738895, -1.0613809362219642, -0.950560871250451, 0.8501842639570195, -0.2457872089673301, -0.32997092775152626, 0.8416995013908587, -1.6758481244925103, 0.4568209007993925, 1.0161197757626048, 0.22992086978509355, 0.03813644821601729, -1.353018190136864, 1.417286289929362, -0.9934642822916018, 0.18143434697952465, 2.4604511306118884, 0.3549842273404589, -0.455441440805126, -0.5963180617375894, -1.3453213917435198},
    {-0.8512642719934729, -1.7503199452386209, 0.8634588342142265, -1.216714514363943, 0.29502161484731626, 0.6937036822245369, 1.4013736249033246, 0.5068949599796826, -0.05458863824779547, -0.308531470373007, -0.3557069631404559, 0.009397556292478092, -0.28523064884003435, 0.10377353007690021, -0.8640226224874711, -1.8799510481772432, 0.7806293554894053, 0.21245950302209768, -0.4440527216026732, 0.42871984077714537, 0.30174591758613384, 1.1393631075988029, 0.9154695515009197, -0.29719578654055023, -2.0962267168922795, -0.3731511915827013, 0.9392656052008157, 2.5789221129076765, 0.10373475515112753, -1.0611582051348578, -0.07745810938071082, 0.14392040664754802, 1.0907093493295044, -1.783462758086326, 0.9428587602807417, 0.8580642703521664, 0.059070974797892244, -0.4183704594624087, -1.4480475401957802, 3.111139207447522, 1.0503658221208032, -0.828640135832218, 0.09957249437065982, 0.8150834062241845, -0.47555561654756007, -0.5472773107186634, -1.0782749115664831, 1.4005891972077857, -0.5139116504928127, -1.913955495145275, 0.04573934928455274, -0.15511755099898464, -2.0296279497488783, 1.6887434137767294, -0.3671733367378127, -0.48999807376513155, -1.693775955890795, -0.07627656089541118, -1.3235840517729827, 0.8461675947814771, -0.1320173085784981, 0.06640049267493679, -1.4690585311774098, 0.2269063622466142},
    {-0.08250322245573957, -1.271733908000217, 0.65220400234837, -3.1202535769072575, -0.5635586805677969, 0.48278763937237806, -0.2984313001870176, -0.9665483547568299, 2.114359672055986, 0.019666579291358878, -0.509547172758756, -0.9956264410882527, -0.8469992848967973, 0.5820569295945487, 1.5284580319182028, -0.7579801870137921, -0.9920304171167629, -0.21219765450696784, -1.9131391140634235, 2.4974782337368624, 0.29123182646753043, -0.1991675564149082, -0.3309952092439872, 1.4027617620481725, 1.8507185892994802, -0.8176995589119029, -1.6030643811308627, 0.33974062115192943, -0.8605013575652083, -0.17684369293259583, 1.9164137793959206, -2.0494077267551543, 1.3919461492879683, 1.577720086503949, 1.674981814484512, -0.13826217498429763, -0.013569202140054188, -3.070886639225511, 1.4359458897523276, -0.053791025299563665, 0.674660755479691, -1.1312378211681515, -1.6161888236294721, 1.4307241885186197, 0.018373140163339116, 1.099441618484362, 0.9404330382082177, 1.0005421453154177, 0.31115740950767307, 0.6593803152970749, -1.2784226354362318, -1.1224302863100943, -2.1227365866485948, 2.034588332897751, 0.9441438538557378, -0.9144313019629904, -1.8114143563497855, 0.4323280736337703, -0.9248334619602564, 0.5617630512158153, -0.5077634536622859, -0.5292627232304941, 1.4601806919704714, -1.5663421357646403},
    {0.6809478401956376, -1.7822471185634057, 1.745965746564171, -2.5521075123081665, 0.467599475637166, -0.2404730565999037, -0.5424262411241498, -1.4123925434768523, -0.4476664199974048, -0.13813233936632338, 0.2558358395834395, 1.1966135827011202, 0.1147618229469037, -0.5708897591565848, -1.3870543048096347, 1.96715100136935, -1.9676549505108338, -0.4992248032530572, 1.2160099244151052, 1.3977641443276918, 0.05531364335203667, 1.3565130285629008, -0.22845408687819457, 0.4543016533184529, 0.22342706609567992, 0.13915677146343503, 0.6541167906590843, 1.5845346575098342, -0.47159928986535105, 1.1223948575958114, -1.5268384541226259, -1.1202407603879505, 1.722859825235669, -0.024477476236664172, 0.3953471084619565, -0.5768468980989151, 1.6832147258635977, 1.9771456972320325, 2.0371988522634528, 1.3380905034120807, -0.3212089655897, 0.6000006298068001, -0.4275656038315118, 2.296891478406602, -1.283693652774815, 2.1798427264739666, -0.07695504945025418, 1.401577099946504, -0.9139137726356995, -0.6424276603945499, -0.09541376448069556, -0.11238036735981055, 0.28170859843371854, 0.570653360395238, 1.3015695749137153, -0.15620097615416997, -0.5102318794101998, 0.1789820209082527, -0.7186140162045916, -0.7633391395566286, -1.8095732898294972, -0.2169726483585436, 1.5315666592722397, 1.1132504029733048},
    {-0.8425630182329266, 1.1767757947756847, 2.0020832694007287, -0.2816854383582193, -0.5722545117182409, -0.16535761017105102, 0.9240362502700133, -0.06559910069766625, 0.20535742005643062, 0.9637582714566651, -0.9472922214702886, -1.6994249834870374, -0.16343285664029397, 0.6980295943275947, 0.8876412219488155, -0.42588590929308406, 1.0483344182506436, -0.2680798764693614, 1.024929713399946, 0.5653190272835718, -0.49986281915645053, -0.35269908611629025, -0.6852952396919697, 1.901373487435978, 0.5412706999583778, -0.800639368391976, 1.8499892761576904, -0.42352459680351306, 0.5795591662046683, 0.15274936182456444, -0.592833462268506, 1.2310308210620198, 0.5598635949967973, -0.11703501604275017, 0.2862395837567623, 0.9131629039805311, -0.16584851288353616, -0.25558663793126146, 0.049655226428445165, 2.7859321726245394, -0.6629956607391935, -0.10688848964217978, 0.2488854476834273, 0.6636874119652115, -0.8316479777926993, -0.5723701889592304, 0.7628074769959724, 1.6016753296042654, -0.37059468889947866, -1.0255034494249295, 0.23733418904234485, 0.08364611639619986, -1.1484047552238938, -0.17598800367640424, 0.3203891379490857, 0.4679601351299374, -1.2755780393182263, -0.6315768947158739, 0.4187706541533205, 0.37342574093504505, -0.7988976542479791, 0.26245965440827396, -1.4365860172510678, 3.248806612820063},
    {1.028090749062546, -1.3313075298487742, 0.22763065696207885, 0.189263834692861, 0.06312373414348829, -1.9919924881833644, 0.9718418788134507, 1.1513034007662906, 0.3932625652410108, 1.5907916451877753, -0.3814497573236043, -0.22785287776678392, 1.9574294607458804, 0.2887785778660633, 0.07064529165597443, -1.35874985188089, -0.3491867725318963, -0.09151377146748814, 1.972049184981531, 2.076854640111503, -0.4598582851836222, -1.4046607589752154, -0.2254691964631692, 0.9150404954932265, 1.460354027240209, 0.1789502563151817, -1.866873055771733, 0.34965657928244326, -0.43562284152964315, 1.0038728444104736, 0.18952211691564816, -1.0185507534729104, -0.060575528901678465, -0.5184901782244196, 0.9956268044700677, 0.6572163804848191, -1.3289685987251232, 0.9921928200362792, -4.838646910557171, 0.4998824015779498, 0.527722516778928, 1.5880314653568832, -0.07433044288913931, 2.3172498944451805, -0.5585535617158293, 1.4565912861940562, -0.6897130429009172, 0.23422954708783952, -0.4126201161111324, -0.4871350896240147, -0.9107405003192321, 0.2955044091213111, -0.8414090410558672, -0.027640451480671013, -0.28050679082283364, -0.933434397299291, -0.009841348668810684, -0.27845590817750143, -0.9886436324246545, 0.41395122337934903, -0.7982557901693818, 0.31741963716852983, -0.22679416564502197, 0.9657749283546355},
    {0.39329341757405867, 0.4858182082278247, 1.7955492706741873, -0.4248398103711159, -1.1802707909691594, 0.06516607430213005, 0.4351901157511032, 0.18902684871063502, 0.22067270590752835, 0.27803878792712283, -1.665882116625194, -0.5213028215675409, -1.8405169607407361, 1.4320620602378962, 1.8056658980975038, -0.8018919890350091, 1.0340526231696083, -0.44496466106065663, 1.5444829862141933, 0.6290807659223169, 1.10052743475007, -1.4083128597437615, -0.9918256412846508, -0.03220020494349372, 1.3081002828668054, -0.3869724984909192, 0.2986127687591252, -1.259946251584391, -0.5299252125800741, 0.8324590886385046, 1.435484913407701, 0.3946264682899195, 0.5467996903537994, 0.2551652418155953, -0.8460388901357897, 1.0366494692955046, 0.9553047981184889, -0.7954169112318903, -1.2454476315395897, 0.07818034599018829, -0.32636305285712386, -0.946396922410688, -1.1883338485202979, 1.147370290734841, 1.5748792037632138, -0.8560202726048773, 0.3033817388032994, -1.3087280240894434, -0.7040042389306747, -0.024573662814699734, -1.8569863931212796, -0.7889228349285771, 0.10411738706500881, 0.42905613835933415, -0.676179641525797, 0.2818175034969145, -0.25110177961350033, 0.2563542970833424, 0.11010765591058444, -0.2051212761081483, 0.6579638312896445, 0.02291986941439082, -0.48436408113299584, 1.8421109375419165},
    {-0.3502782159490529, -0.6873003937852645, 0.13457947732120457, 2.3386268157139227, 0.6606304975694618, -2.251583419564746, -0.5266311148625722, 0.9230729003334734, -0.6260827919676738, 1.7495312210640082, -0.7024293734794749, -0.34515498915235143, -1.1364894615926948, -0.6258923581526632, 1.2035425733743672, -0.7020642147733038, -0.2697938593520238, -0.3181145686092692, 0.23537412194772586, 1.5962977586823248, 0.9329404300191562, -1.606065919719647, 0.6713300210290746, 1.278067601799234, -0.18501909976173847, -0.15052134031620798, 0.5021286487092981, 1.3327260689601217, 1.2965116505194583, -0.723778717799232, -0.5768115441674532, -0.07036759019969034, 0.22476127631921883, -1.3135981224718756, -0.8967751042998547, 0.72328871976951, -0.7795474433226267, -1.7049463059006913, -1.6579796313375388, 0.1747562308061411, -1.3892367352417407, 2.3054663211985806, 1.6371333415734186, 0.716088427268967, 0.21390572751991022, 1.3234589723151358, 2.903579079100675, 1.3103062331492519, -1.799427237811679, -0.18807060013723245, 0.012993245298053761, 0.4926825860574782, -0.4428175440770474, -0.801793906461888, -1.023299973145537, 0.8252065926632363, -0.7604409421128124, -0.8649445994411892, 0.1601143974075202, -0.4757924789709893, -0.0627431163605835, 0.5292266612560013, 1.5723465673722452, 2.061921026368416},
    {1.1911891011369842, 1.6727744017351416, -0.6455351249585607, 1.0224097310968396, -2.4025647906682814, 1.1116061850081174, 0.15400742732462158, 0.2764751448417803, 0.9680607168386967, -0.5759675068884754, 0.12065193972309067, 1.019098391403144, 0.2222439622003655, 1.4832152919046373, -1.4472384249783878, 0.4356206457462568, 0.4655369265268264, -0.60357739034352, -0.18665407132018993, 1.392026013638639, 0.08526608066626543, 1.2962831181502301, 1.3184688308631696, 1.0637643848711877, -1.17812285801629, -1.0263737484892788, -0.25042716535182635, 0.8958717002276327, 0.7456651227284055, 0.1694911872438448, 0.7673672277081326, 0.13232894221472855, -0.17668431298327048, -0.05878251845276731, 0.3752214401842296, 2.543831655411715, -0.35707133915796996, -0.8216513904888748, -1.036610257184366, 0.2625506087269663, -0.6313752347700383, 1.4496875406370828, 1.0938114816255475, 2.4219839071930407, -0.8447233017918937, 0.373467914168596, 2.2610828984415137, 0.14996798843328976, -0.6276992540588853, -0.25283848510078194, -0.5469227197906704, 1.740152342970214, -0.30158831512670004, -0.3498545928114803, -0.6094341296710282, 0.1304017236237794, 0.5810579048642509, 0.4993033723129631, 0.8164326241064351, -0.4009441630487933, -0.484035392280648, 0.6985783399189607, 0.004551559313901555, -0.5738637969329364},
    {-0.0725776063544345, -0.48658463928541773, -0.0735259705933447, -0.16451432975003977, 0.08179031500734743, -2.0620016108672847, -0.07153130370343579, 1.1372964884023093, -0.41648289130813254, 0.4815032133859665, 2.1657317138439103, 1.2514124801469415, -2.2929243565478727, 1.416932831425802, 0.10802031111727152, 0.6175387437238122, -2.3028451120165685, -2.0764312371913642, -0.18359102946544142, -0.3764633041315607, 0.9239147444644403, -0.24085468549874875, -0.6880937366627126, 2.5916300006628936, -1.2655928800696448, 0.49667251426661957, 1.4396146358109618, 0.33001871021742435, -1.0722226881358623, 0.9031571873912312, -0.85576939968027, -0.5044589095321207, 0.20849296550585583, 0.16757222134930258, 0.37487288141872827, 1.9545413412056944, 0.7040719947430021, 1.682907093205984, -1.6141647720533083, 2.1937950717811483, -0.3567241424024989, -1.999702852899113, -0.9694778026441997, 1.0175129478878506, -1.2482134289540918, -1.3407662522439427, -3.47873463461819, 1.0638213088818393, 0.20552819796815164, 0.12819432663568625, -0.887858973274995, 0.8503097049287495, 1.1867991072264392, -1.2370986951656517, -0.45817955447741265, 1.3702432072163002, -0.1013721437938375, 0.5918110871885858, 0.11154794810622537, -1.8258572794946193, 1.092868013581294, 1.0649475999476954, 0.17476993217667125, 1.5320831492359026},
    {0.24506964681198531, 0.24441659383000747, 1.1686979507691475, 0.05589992678981077, -0.40483415246623106, -0.023743203038426756, -1.2754952204376748, 1.870962173634549, -1.2165529642432578, 0.73916504417029, 0.6177993043704851, 0.6248431000022827, -0.178872677663697, 1.2220646745728645, 0.844216507993852, -2.152956492588618, 0.2003471158044336, 0.711866699443198, -1.729909248092285, 1.9161386435879975, 0.38308135563671886, 2.4936848589896345, -1.2185115051975528, 2.063015146025838, -1.8485190619574323, -0.8138753406065391, -0.19421585808265848, 0.17850379495813437, -0.8131079342580203, -1.2931001369196427, -0.38281142629213033, -1.4838353663811896, -0.33886510339758813, 0.7760899525526095, -0.813449955942704, 0.5504670644369009, 0.0806935841776913, -0.7720928632864786, -0.8357398295873761, -1.804249346431329, 0.7038028608606588, -1.5402993939713043, -0.1909255332259573, 0.4659393395367878, 1.3722316346794259, 2.52398678976113, 0.33577866837092285, 0.007055137534751908, 0.5389372541632476, -0.16027431262308162, -0.019755569990797864, 1.5881895874502319, 1.7644231967374109, -0.8104174800969025, 1.6036874047591596, -1.6565388385136413, 2.03641565884196, -0.29680265356311736, -0.7384861120019653, 0.4807574214180944, -0.4862582029613438, -0.36697337137379527, 1.0804625983343668, 0.24329159170439763},
    {0.7850623734365572, -0.15135397868339287, 0.37801860273063465, 0.4395042964399985, -0.06626764089003181, -1.0184615577309972, 1.9615159405015008, 0.43958932439081927, -0.19959440120919208, -0.9104088802347581, 0.20848175226613053, -0.9671442828295037, -1.657816913533826, -1.0468331704072744, -0.5095956237383469, -0.37357202720905186, 0.7447897739194907, -0.12025699582905579, 0.2889692697781812, 3.1390099636839692, -1.628449060555097, -0.03745273151188074, 1.075375164348086, 1.5383497249389302, -0.7345276087760896, -1.0154193502330757, 0.7279714821698253, 1.379248574501479, -0.14581956135994348, 0.23962925858903772, -0.6064258190675932, -1.6101702617817748, -0.7695826031598932, -0.00595136655618319, 0.5265508196398563, 0.38420771031881157, 0.3339593789302907, 0.653132139364841, -0.08175911798012042, 0.42953008257650976, 0.4519558732604941, -1.4509627813312729, -1.1815535691546861, -1.2833997893514189, -2.721508068003661, 2.176662504201204, -0.4808728673795149, 0.32242326774675906, 0.3163503131454867, -0.36140059431655597, -1.094428665820847, -1.1263680010760735, -1.0248723977256586, 0.266795244181613, 0.26630081234255515, -1.8725359621004827, 1.7928475092380531, 0.42580352904527186, -0.9464558986942798, 0.3891019900065771, -1.0074562700982066, -0.9468385654703904, -0.8887867093652014, 0.20946390713617336},
    {0.39188277513725667, 0.7235588946285274, 0.14557217024008656, -0.2392630981788927, 0.8151804553805816, 0.1140018549545183, 0.04181160875158641, 0.7752295864489659, 0.5704353827755466, 0.6059801471332578, -0.4347991762040787, -0.5219228098111877, -0.04050558612166275, -0.7163869934787487, 0.014768715156344958, 0.06484870312860104, -1.7346901839912512, -0.1936178676323095, 0.6207976223025164, -0.24697379982136092, 1.2877196445036678, 1.4209304726478167, -0.3469182401109267, 1.2119062588092917, -0.19271659447433523, -0.7882287400357938, 3.195342438504214, 1.3524381126137441, -0.8093690677288586, 0.38506361131823585, -2.8383999541948444, -0.3198546032583491, 0.014182484439467801, -1.1535048777684063, -1.2556358971904442, -2.0652067556160714, 0.21906955794298183, 0.16475387277486928, 0.32937975775993533, 0.4634269680105113, 0.0593865504368066, 0.07393015052592312, 1.3249076008121854, -0.20350147883696357, -2.1681418584491614, 0.6423589708234767, 0.96746026324, 1.4328239194308938, 2.114848832404964, -0.6136964839540741, 0.48019684562685755, -1.4732891364520402, -1.6568098558029256, 0.13014891724807293, -0.4805620472660458, 1.1563513078966936, -1.712357168246115, -0.6581985862620787, -0.7422941804844237, -1.1943556075590211, 0.601542126175422, -0.3386686540873302, 2.120311462971391, 2.586735968034979},
    {-0.599202467480832, -0.7019308512964618, -1.684115412092077, 0.8916083033745411, -0.31753397071082806, -0.40887616154136613, -0.272080839724539, -0.2630597623838726, -0.3916324457534051, 1.2499574498118702, -1.200326756444909, 1.0162305450981626, -0.30351086897888024, 0.15916283335692433, -0.6383928370122485, -1.0610989865940075, -2.134976817637241, 1.1351292966283566, -0.06519559715394785, -0.4588329318795347, -1.4343341364223088, -0.7374417365201271, 1.1793730140583378, 0.9018605107930071, 1.5633187757723919, -1.1684461629312977, 0.8478937795550556, -0.13479332779602876, 0.010822787482482879, 1.8246975112792874, -0.29130751783025594, -0.054967376164437434, 2.9349304726686087, 0.09628838680146576, -0.2657684828925456, 2.0833175645947906, -1.6664666453144448, -0.42534389402076167, 0.2714259765160214, -0.0893015498155041, 0.7904662519508819, -3.0749307577174627, -1.7759834978363402, -0.93460693938853, 0.24387592812240536, 2.035487524317931, 1.5560254759848697, 0.5126936081138006, 0.732265764891744, -0.9683836257250069, 0.14566122508716217, -1.1404560418158431, -2.136407564522073, -0.20167468891571616, 1.374012288508634, -0.5623568920820227, 0.10617406157108311, 0.4709950144716391, 1.757178908110066, 1.3218988346805218, -0.40727799926465336, 1.3584680010674328, 0.011583971808213911, 0.7352883204879568},
    {0.7693318093064364, -0.30591378771527244, 0.048772067619911263, 2.474264556795374, -1.1481526836161302, 0.4427272628515244, -1.526534046754249, -1.632885066719979, 0.21942534358743943, 0.6576322640873256, -1.573387509251117, -0.9025534811908708, 0.5755466193628366, 2.0187466639745675, 1.190064735685761, 1.2900579726602477, 0.2996353781382656, 0.7281735156721819, 1.967501876136303, 1.335225256840339, -0.26909706500453023, 2.915630300539625, -0.06768706368005721, 2.8235946076325344, -0.43545359011729434, -0.4443076647943172, 2.6668193963018263, 1.9096338118101435, -1.0262723738338557, -0.18784276615690948, -1.1141125892666541, -0.964464807539244, 0.9121647556174995, -2.399684179242763, 0.4758504900808511, -0.40806603208741926, 0.10568889037450267, -0.9736965324601967, 0.7578616466628381, 3.028866087428579, 0.5748309114232175, 2.83213975663905, -0.08441230905125681, -1.5077843017034394, 0.6371595284015269, -1.7487739471045882, 0.26968691546992263, -0.9893132163959952, 0.9437384508055774, -0.23684246419330884, -0.11543752814291006, 1.3262049029636382, -0.9677260594492066, -1.6739514539177178, -0.13686999695821236, -1.0204403414069676, -1.0814429837026105, 0.980560696003278, 2.5665223079615394, -1.489771485336487, -0.8156700963950602, 0.20518099863841996, 0.43088238832734543, 0.6173580308463696},
    {1.145731828682253, -1.6848176604259173, 1.5716327876063692, 0.9785193410366536, 0.09744060408605669, -3.2345290238868034, 1.3954690067732431, -1.8045822409074952, -0.5349340848340479, 0.041982839542411964, -0.6707977006860077, 1.6629426809321777, 1.7106981984547058, -0.6260099273731939, 1.8995598870112553, -2.6187129858048794, -0.966104614271332, 0.8028601254604057, 0.7110332831552618, 1.7994353508674754, -0.042454835678767504, -0.03973582693913779, 2.866954587443388, 2.2525543389801617, -0.22657890636298386, 1.232564690261352, 1.8997858880711187, 1.8825529549799194, 0.14374089500052498, -0.711690600491777, -0.15851270600424722, 1.113652438542373, 0.3898668304374115, -1.813825606509853, -1.006559455384912, 0.4737007073979074, -2.458840702681797, 0.5673861489333443, -0.8915107402848281, 1.7469693214610522, 1.9901031896493442, 1.149729288209461, -1.8136522476683976, 1.0765521715321547, 2.0074236062860686, 0.8656076087257707, 0.052927454342681944, 1.1205801711044956, -0.6368663820799298, -1.2324655631764247, 0.27612896341112886, -0.35713088543730326, -1.7974384564375636, 0.8851297789022421, -1.2262305249016876, 0.29147593297173036, 0.2843141703287654, -0.5220360569385367, -0.5826599358340425, 0.6855455923872584, 0.27651546925887754, -2.4157708242944214, 0.6566816545928398, 0.6081343077683561},
    {0.5469559735703636, 0.36918586204368, -0.5472081126919536, -0.4778933373074351, -0.5707726783091316, -0.31002876863798967, -1.9089544648578338, -1.1406555740432713, -0.3007283870537588, -0.47033446474766055, -1.9782002244241041, 1.2030035856771502, 0.28171191319481614, -0.11362366958056508, 1.0261585343737258, -3.117036040389537, -0.5281740013586652, -1.2358292440708887, 0.3773912358554117, 0.6751900156790318, 0.7609340697038456, 0.8648161289288167, 1.6474923092391494, -0.04559430394874901, 0.5430465231640024, -0.15104890958481346, 0.38560810091344294, -0.28760444485381936, -1.1991020076135255, 1.1187817831731033, 0.23750195739896823, -0.2915860346533624, -1.2137523551602962, 0.7154839262099769, -0.7452203087530677, 0.6392515765131886, -0.8945895944304236, -0.19802284190088312, -0.26473795983075354, 1.4304648308319223, -2.424818489738161, -1.537166778069382, -0.30100511204425545, 2.2545978537017275, 0.21893504931779428, 0.11779248607009121, 0.02126427755960283, 0.9036834073542261, 2.6570160844195905, -0.022798457098136677, -0.26187460563615605, 0.09967105470834259, -0.06349347708755446, -0.7622095770133096, -1.6748711077750094, 0.6460191523771178, 1.9141793717689786, 1.3825078849419956, 1.3275344641522129, 0.9454702941276836, 2.0967757076837876, -0.43929560789805383, 0.48552139852582565, 2.198800801770523},
    {-0.6078807983461636, 0.16643900474821754, 2.966409939623009, 2.4496879784369914, 0.08274169972971641, 0.352266855752892, 0.37394472059795114, -0.24339320421854846, -0.7163959345941903, -0.9518966136222297, 0.6231160189997557, -0.9808368606476451, -0.7515843954629037, 0.509529331363913, 0.9936093190675599, -0.49554093355746226, -0.17844455692984204, 0.6040382967834179, 0.02639232033064492, 1.5951881173033897, 2.0609558661608576, -0.9803449466091085, 0.9012072901688272, 3.48485108761783, 0.05184949551971665, 1.645164035523059, 1.9520105712906095, 0.35757964942592846, 0.11438479338557424, -0.41218345075264023, 1.2504188159116283, 0.4889005508925571, 1.0763180931171645, -0.38708945677051343, 1.3976106923124976, 1.1127351811596355, -0.9962119247534471, -0.41299210310362783, -0.4542172614923795, 0.6159266118191167, 0.713397230992031, -0.4649645041486582, -0.5404304755945865, 1.145480218172707, -1.5500788492218636, 0.41312307296247924, -0.6304549830609706, 0.22042528774382042, -0.5453756679125242, -2.4277319756321063, -0.9819194883351974, 0.1907732366877674, 0.027447847208754168, -1.1780454263898557, -0.9088957548554893, -0.1677663112264056, 0.03152504037303459, 0.2477358900151172, 0.37135292821381416, 0.744352274595011, 2.7241882084510127, 0.37171160351998445, 1.710008152626972, -0.2960790211391147},
    {-0.2967679659122658, -1.8609076159582905, -0.6741993583571233, -1.15508101400254, 0.736811303205734, -0.23386131976115512, 0.5810095442405124, 1.4536436599118518, -0.46683063529116825, -0.9551070644915488, -3.0185342441245844, 0.023108947613681007, -2.5388845293557467, 0.7601306397848985, -1.3265560725189145, 0.6669922622216725, 2.1519792571086067, -1.196224016837225, 1.2277086531869483, 0.828325095503678, -0.7511204990563257, 1.1796182792706826, -0.7920572975310404, 1.5593468362937901, -0.38144016907078376, -2.448374433539582, 0.9807726821721322, 1.2517461692158152, 1.563064413068583, -0.4817102639397973, -0.2665329708854237, 0.3188971047120771, 0.017208358403784745, -0.5298418739715233, -1.0723645548470315, -0.4716377552755005, -0.5998394547388176, -0.9591565684362964, -1.3025341331832752, 1.051051557619671, -0.7805604757498871, -0.4637911989604916, 0.1674706346795003, -2.2059362035703973, 0.573835679573762, -1.385106782794576, -0.18033555269585388, 0.06213036723026916, 0.5665246034652848, 0.07937067799655766, 1.1939459003362365, -0.20977588482096546, 2.330808375163599, 2.438676778675136, -2.0056166125769135, 0.8725209058662206, 0.9341685639603138, -1.4186367714784187, 0.1361627470211765, -0.3937126160842422, -1.931439085858732, 0.05960055877142209, 0.3447751847525799, 1.3535879664901196},
    {-1.4562237496028623, -0.8251489949946141, -1.4934010835775944, 2.2438890473836484, -0.929659143478232, -0.76135626262889, 1.9377801794930494, -0.4262252500379437, -0.13399250878035307, 0.3936506441400546, -0.8128977125882854, -0.1562011681929829, -1.0938626814875931, 1.186605516454375, 0.16983176296414, -1.0907287684181584, -0.701771355608414, -0.7756461809992973, -1.256160246469131, -1.3724805951912482, -1.7374408435463815, 0.11466178503536609, -0.9066769312989955, -0.2562079538783483, 0.4267548799636727, -1.4695041770097395, 0.7925363819685941, 1.1511925907806126, -2.366603303947501, 0.5363459500618066, -0.17679713291863988, -2.229607550430431, -0.19010385265961885, -2.5441078533299355, 1.6714213338869721, 0.4375791922142779, -0.00915778264042503, -0.5892931158600777, 0.053861272440960464, -0.025908378000512162, 1.054336814401106, -0.011894743176223655, 0.7305920797055275, -1.9452261521254912, -1.0510891256640897, 1.5097211025412758, -0.9893575592510887, 2.1504809689823623, -1.2279704017074924, -1.0676890350720831, 0.8686830172127683, 0.3832287276283024, -1.1873724228439693, 1.9921406149798189, -2.520398897761828, -0.01716615460483477, -1.1375618906315557, 0.6456637991161306, 0.0032329257950612657, 0.4954355002846151, 0.9640863415077906, 1.0505029392974907, 0.9321884515455753, -0.5295519943890892},
    {1.8502862429752884, 0.6657586434288963, 1.0640013721678359, -0.5313209150742191, -0.9495139957063709, 1.4344648841884844, -0.5584486834203668, -1.7577034887070715, -0.01613584938054929, 0.11635168268889982, 0.10209238367886393, 0.11603629147698394, -0.6333089774258361, -0.485904059690661, -1.965491636095464, -0.20466846620802534, -1.0022424954788338, 1.8275619835022983, 0.7023299963169483, -0.10718770147398735, -1.1663542259401918, -0.9794899939160631, -0.3907379484667674, 0.4806329302157555, -0.4523025202047161, 0.09018247314450481, 0.2342445356135262, -0.11466254362200556, 0.0010039295476424728, -1.8469059305900655, 0.6567775536172372, 0.34723437832360843, -0.6807822232714886, 0.4044585221456376, -0.12873990036374836, -1.0045355218772332, 0.3932273333261393, 0.653506708389833, -0.05923555916593261, -0.7811998770919523, -0.6716309985085422, 0.992009509381937, -0.27408643176769215, -1.905745804279904, -0.8997030798884712, -0.861911814893517, -0.2574521871206556, 0.800291334991494, -0.4239694198422489, 0.5926677550683501, -0.9219765394727099, 0.15056675541338047, -0.3036364612611344, 1.031292248568396, 0.10340871141676258, -1.9778918108198875, -0.5432186112459387, 0.6415576816848274, 1.42213690427144, 0.28423782237701073, 1.1797143558436156, -0.7552789320812866, -1.3748173145048754, -1.3193863961123873},
    {-1.746076514515368, -2.0704156618668472, -0.5953908222577183, 1.1742184897147412, 0.6578622296511462, -2.1348679805029653, 0.12869463731638606, 0.10924904531615888, 0.024357511999475154, -0.6510702517936955, 0.8288841470068528, -0.5716979987121302, 1.573575169434515, -0.7433636164380241, 0.2352270727419565, -0.02923644825367355, 0.9646281002350892, 1.079267186973413, 0.9069084490986079, -1.3917527904224276, -1.7838601427822662, 1.8802993567986368, -0.5279751680760313, -1.4599549937376244, 0.42315895637640194, 0.7599148070469938, 0.2529720829910936, 1.1380300328133977, 0.2091123470069794, -1.2134884679491222, -0.5336476016546465, -0.38084871285719535, -0.9202292607906031, 0.3800179902929488, -0.2943672973392343, 1.912556891646616, -0.8355144484149597, -0.39839874342622505, -0.7671814004026952, 0.5609580053151844, 0.4081739321968707, 1.1710322626229055, 0.051608061207573816, -1.3051031113655946, 1.1343884283307786, -1.086935490139294, 0.33964700026849254, -0.5464909915359634, -0.08755560580750943, -0.22806903167144307, -0.697189040668191, -0.0632030497652297, -0.9033484308333686, -0.8422645793104846, -0.6215318846124945, 0.8161189359882884, 1.8890430159902463, -1.349598891350302, -0.7966083246036902, -1.5694257488700274, 1.6650281557590054, 0.7619557288109726, 2.2312253738830647, -1.6709634606190502},
    {0.9163194508796043, -0.42182397580860154, -0.4540951573243992, -1.12977038316904, 0.6310239361784455, 1.81225129934166, -1.2256113293902473, -1.1475204401089474, 1.0348940159411097, -0.14604530822193182, -0.5456780034912563, -1.0723109865259677, -1.021080607151886, 0.4573169714671078, -0.18318796878314744, -0.24556018058129045, -1.1176942651307107, -0.41862101954740105, 0.41390894016033364, -0.8337641805562708, 0.4987779023435714, -1.077191323043623, -1.9192559250537038, -1.212394836411806, 0.14477708817366633, 0.8938871592091301, 1.1162431345252215, -0.1694669498148991, -0.2625881551761737, 0.09396139643674346, -1.1574345317515464, -0.67987195107618, 0.35444230888851225, -1.1729509848029975, -0.10639024447716589, -0.5405976651955792, 0.04530763994167889, -1.6995196266170094, -0.8494040621053776, 0.00246776782148558, -1.3176602751954707, -1.3095324636405195, 0.8710035333829956, 1.3696732954033994, 0.008906239463464114, 1.5307971895951444, -0.07930681551015466, -0.4639011150771113, -0.8311738434899754, -0.21839285255290591, 1.3218999370777118, -0.7925162175405298, -0.3207529372357352, 0.702640492607882, 1.6719973131014674, -1.1769493052871962, -1.1921597912945012, -2.5452223980297948, -0.26441484583133384, -1.6334806837185847, 1.2375432584553314, -0.22485780227685043, 1.072747934662091, -0.5025821270398663},
    {0.3337427825085628, 1.2213725500674744, 0.5110297928881594, -0.4667168457936223, 0.8510761544425566, -0.25047421090343613, -0.25984274587925643, -0.3443598628377197, 0.4672057005714149, -0.4979670566154358, -1.2252914701027313, -1.757283098893938, 0.5027855406715355, 0.6352996140488697, 1.3970428263520072, 0.24215915870313104, -0.812479116552849, -1.8893997007647974, 1.7250877634957569, -2.3773553022203058, 2.3300106764413018, 2.6189037084743347, 1.132978858988932, -2.619810245829233, -0.8935189494089311, -2.5414871204713254, 1.0605960832072967, -1.395260905645088, -0.33329049548786205, -0.5974548523303878, 0.3444404859542691, 1.1115008746361983, 0.5134927713704962, -1.059068293682327, 0.2301679845346268, 1.1281422819854339, 1.8955092754301806, -0.1254867407051179, -0.7902899348926103, -1.1399482433009618, 0.9539921286997267, 0.09474331369072585, 0.6003963400549727, -0.3679219909839398, -1.2209798598285964, 0.7448597170563286, -0.6365019553616676, -1.5456955191016222, 1.134169879387672, 0.4331226174286574, -0.20456448214103248, 0.9604876873103094, 0.47669806650149754, 1.2493087604989905, 0.6104357067407555, 0.9496442784120357, 1.499272329046959, -0.9447647715896897, -1.8793219838839503, -0.4040475602474768, 1.366709827728922, -0.06310510958779107, -1.0572609975906568, -1.515805193799386},
    {0.963400012983397, 0.2899104423458274, -1.8903938734887968, -0.011099303156215556, 0.27238538501599646, -0.02292023909266346, 0.4471489634533483, 1.4230973102923385, 1.006910645626755, 0.7130584640871631, -1.6135777440154273, -1.5288179891930544, -0.7691881427667222, 0.19267998137855027, -3.1430737584907256, -2.763984111654524, 1.108641674150489, -0.3265365920871132, 0.8069161469435564, 0.26039131544783056, 0.39490749882451953, -0.7867939045740902, -0.6049634979807884, -0.42686424210679846, 0.9857360458089083, -0.976127285530353, 0.9552177170808311, 0.6384868919230811, 1.9586026194346637, -1.5312436371081122, -0.6099045439792976, -0.18527640589837663, 0.4077356795448988, -0.9070226739659253, -1.2582838301297095, 0.38369215972143367, 0.25995119102412234, -0.6411061719711002, -1.9976128153072783, -0.36350476281704236, -1.9411899100029215, 0.17884122091586796, -0.6686590837030022, 0.5752125668607062, -1.5982504639689206, -0.13078520131196403, -1.346438703790774, 0.622947223183647, -2.273289878380523, 1.3946508438851404, -2.1570902668775234, -2.4631859869818515, -1.3800416049018065, -0.26055876960935365, -0.4645390610009891, 0.61283655177133, 1.071131752086411, -0.7606718381615144, 0.22822728632010877, 0.3158768246401024, -1.989792990038535, -1.1488228518057215, -0.7507234014100487, -1.380039735114184},
    {0.5834954795770811, -1.475273965788302, -0.9639897247296584, -1.247528636845788, -0.42707154634560157, 1.8823015068089592, 0.6375055367089993, 0.6290691359663968, -0.3601820532669031, 0.7786106594662568, 0.6262171158837481, 0.5968102324423695, -0.5934573529891836, -0.9816932618037033, -0.8220476140695077, -1.1976665381077283, -0.3176765152578579, 1.2503930006018813, -0.5163784846795667, 2.558020007719155, -2.8223076522464696, 0.07123132286556243, -1.3000665563015468, -0.8217329985340692, 1.236866196519593, -0.9653700134481414, -0.2232577428196703, -1.4423435824148394, -0.17613008846617664, -1.4624730649878293, -1.099079026194628, -1.5840773717670291, -0.5937511080037965, 1.0041814677898073, 1.0051951457093802, -0.18302208053885302, 0.7091895683281542, 0.33942911675184345, -0.16976775567581487, -0.1856229751404681, 0.9439509021010286, 0.11425709798343486, -0.8219599070167729, -0.8050744514803141, 0.4421426167530588, 0.3328831791444984, -0.17738814608353362, -2.506080137253936, -0.7114254049046712, -1.696053680702113, -3.008211025264425, 0.669375794023321, 1.9110879634899751, 0.9400394743447825, 0.10818790820381927, -0.9874428119013279, -0.1601832461676422, -1.1270832637893156, -1.0049616090028688, 0.9633695743442116, -0.12088731104956656, -1.7599216880595423, -0.07465588854539447, 0.8537001484730077},
    {-0.2870736200515854, -1.3417274436483677, -0.6728296155298946, 0.6206527070324566, -0.8924252566782706, 1.3167670399242648, -0.48572475734426157, 1.982918274219164, 0.5277743941773648, -1.1894218029339685, -1.6783121621701793, 0.43096140371951086, 0.3404756905696055, -1.4860491077429745, -0.42738897518280106, 0.9788666669231512, -0.9111537412326204, -0.3919723422853337, 0.5600562953985275, 0.35539154660803757, 0.16350419064526908, 0.03642465616718436, 0.44226282362092845, -0.8566927009677616, 0.26705017604488446, -1.1340990473760804, 0.23294755361782443, -1.3566788203896503, -1.744813312452502, -0.26137101958637515, 1.4826518975191207, 1.390562677196385, 0.08852615355505852, 0.1603234671881841, -1.6593777511319416, -0.039897677266279304, 1.1210850528920964, 0.18214763249580454, 0.4005929265780196, 0.02721628507891953, -0.9101903344371618, -0.20038218401213592, -1.0731248332196364, -0.3152114124689722, -1.2700510443479678, -0.2861035440739669, 0.41604384231038727, -0.9208724161059509, -0.6791431698459647, 0.6500644522074409, 0.6516986089511294, -0.7559563992706022, 1.281475455899934, 0.09350046420685186, -0.49586486762218623, -0.8783004528715892, -1.2813796542513483, -0.9743086340160995, -2.036372082499992, 0.8220447058985892, -0.21336385943705147, 0.16811687463731032, -0.6696635110963703, -0.6858908731686528},
    {0.4905476609183151, -0.4147995299387286, -0.9006021616740582, -0.6312255031849464, -1.3919650870030256, -1.2260848143554155, -0.29154692991481734, -0.060097077564094555, -0.5621879537824215, 0.1363458569027921, -0.7295028481551661, 1.752750855453568, 0.5654897439940616, -0.37634808806781067, -0.21032613230477562, -1.6898441235478765, 0.8602806886121157, -1.3082782669118012, -1.2574282591578736, -0.003614689312995965, 0.5800378868658566, -1.7272749623981223, -0.0505973435180604, 1.0678406521210644, 0.8707425258872123, -1.3650545031308126, -0.34855382313775035, 0.3511842260679118, 0.140026256628108, 0.6569280720437187, 1.100644745399054, -2.7200050366345714, 1.98334969546868, 0.772801791754239, 0.9003892637785901, 0.6352214041266684, 1.101382047345381, -0.5154795512806792, 1.3324006258578631, 0.9649445704049431, 1.82857208399854, -0.7734280433840675, -1.5302209598338696, -0.8307595862324594, -1.2536575909947716, 0.653216838950285, -0.836906254074053, -0.03015678823574733, 2.0574553018224986, -0.9171327334771383, -1.0797031965523851, 1.2594981377541237, -0.06422348186586273, 0.1498830364850589, 0.8008750924844861, 1.1004110103578952, -1.9864507157869995, -0.9967206377585427, -0.5963813736230521, 0.7481246749271588, -0.24986039064721682, 2.320276346187304, -0.49404371322771473, 0.473968030197448},
    {0.6649333542958429, -1.443427293939564, -1.1709917590861214, 0.94655739320628, 0.6223418533305171, -0.8335018314251136, -0.6457158475908298, -0.20861357090827026, 0.4650987300026718, 0.2992599801160388, 2.0323812069183402, -0.3260711581516907, 0.8356380476291898, -2.8828304422774433, 2.4747873258711373, 0.0937611871691323, -0.3991609002119077, -1.378061369738217, -1.0593967142147018, -0.5364430042029117, -0.6914405947722182, 0.09736316902821533, -0.9886774340986423, -0.5534786345397908, 0.13943457780337198, -3.133864979456028, -0.6714904844300174, -0.17616333633922257, 0.3265533199951279, -1.0406441382399263, -0.7146875866604201, 0.7119893941037636, -1.9578264798132459, 0.20850816267766265, -0.25462686145092095, -1.050321908614022, -0.810260458507436, -0.5555743768848962, -0.6528702012873422, -0.033523099921750926, 1.7364448565368258, 0.34588218370649537, -0.2938443546888458, -0.4239307786485148, -0.1829786011613695, -0.6498012335264503, -1.2912989256754643, 0.043528853541682566, -2.231344525420782, 0.1796196086488967, 0.1690194818796141, -2.1052160009999294, -1.0772700388976386, 1.901875734689914, 1.1523665267422607, -0.25173293914762995, 0.04390991630095928, -0.7403056245685896, -0.9803207871031305, 0.9988899761320061, -0.7074337697396688, -0.41686968345961073, -0.267583262719936, -1.874163650086443},
    {-0.15858468211441354, -0.7106061407783659, -0.4716964787745814, 0.6661798112093343, -1.4487975972944662, -1.6393517843953471, -1.2036757672338416, 0.10616301657048631, 0.5282475858386037, 0.3739444957475403, -0.7214042560839992, -2.039185014103509, -2.2608359673761655, -0.902800820235705, -2.0219112844389344, -0.8882317554701287, 0.6106018257296203, -0.44777869569619505, -0.11880522763194434, 1.2464042990333761, -0.5704737795417664, -1.3148733305191487, -2.023606707826575, -1.0434147954201474, -1.4980938167623206, -0.5045206270397476, -1.0172839779325922, 0.1940010026267412, 0.3420256767308042, -1.0146850694854759, 0.179848125674115, -0.5709150418487259, -0.5096734640443148, -1.283832289452913, -0.9544531157994389, 0.19920930504863624, -0.2395422398580927, -1.1553130458970122, 1.1032119593659606, 0.7853610674837173, -1.8842313668224602, 0.16388538660813198, 0.6398701630414801, 1.5455785268977196, -1.1450442202178213, 0.997807957457884, -0.4095297606452586, 1.0613932240736905, -0.5079368153212044, -0.6303833760623591, 0.6656668613362563, 0.37426788941408795, 0.12380857659134267, -0.7913578340015236, -0.8994431593797155, 0.3797715434825668, -0.25018695085107956, 1.7400232348092175, -0.7933513779711341, -1.0392756475939382, -0.06517381102009298, 0.9838909509460163, 0.8514660662356837, -0.7611491092132905},
    {1.6657222069585145, -0.08303580380293174, -0.8411716866158867, -0.348092116211125, 1.099874441717577, 0.7121795072940106, -1.1101228725374521, 1.8147340724555803, 0.1573305251520303, 0.6779986885133672, 0.20512733482736398, -0.7161400092550168, 0.8796221929446104, -0.6531771684843515, 0.07921109230211379, -1.0408841050926345, -2.1951673930399407, -0.9085157092742391, 0.7869834135062287, -0.4418351457094241, 0.06432093634551739, 1.5873254537124, -0.31401003022279284, 1.985465493487953, 0.1310589265909093, 0.8938596872627762, 1.0925114678062222, 1.1484597246099817, 0.49163922610934113, -0.2823419791531529, 1.1729951665195955, -0.22474220376217488, 1.0001575777861964, -1.029013096292068, 1.0283760652945952, 0.2588058756051456, -0.6907164410345918, 0.17739269709523084, -0.6532734214904283, 0.1322047252436022, 0.1921569037507564, 0.23857257473641574, -2.119373655996031, 0.1967758906120391, 0.9934801217924693, -2.112997322407999, -1.8713244258489863, 1.8887920963228484, -0.9054523111836256, 1.107839630228673, -0.9749250798865798, -0.04913881086083304, -0.5380555386097254, 0.1680115015655138, 0.46680688586507063, -2.9414299038184852, -0.519310738762598, 0.9712271325524103, -0.892418848901909, 1.3624514739313702, -0.3568659588166205, -0.6449374981464288, 0.23796704943407765, -0.227550040283496},
    {-0.13979378363471506, 1.0624354757674648, -1.2569675169753765, -1.5694308428883692, -0.9222796702710893, 1.5375175678815287, -0.3296694911383092, 0.8237467777775207, 0.32118176199943893, -0.23288067073386984, -0.9496368594750753, -0.8352359416034039, 0.1999660467395636, -1.269646355539741, 1.7881567011851174, -0.8755411740510487, -1.8986384625707067, -1.0903649856013569, 0.03652463256747796, -2.447126774973334, 0.09836053796874304, -0.6524509438312408, -1.4359585580497711, 0.6923521511400743, -0.7206754244835862, -1.0565884150821647, -0.027307013597207806, -0.7305701131064818, 1.2318342531097557, -1.1880220923614122, -1.5251447754916594, 1.0915927966922492, -0.06160163596674422, -2.6427614750160724, -0.11440916244471312, 0.7639954707412268, -0.48495516757581847, 0.2618545644093155, -0.6090993321802612, -2.9753578182369282, 1.2052786469248633, -0.5280326367205629, 1.2220763456329715, 0.7573022604650285, -1.086115980750337, -1.9655052134569728, 0.7894355498114143, -1.5011251364401816, -2.0121046954647426, 0.32437945387451633, -0.3064109901325707, -1.1913437629447787, 1.5527524049767216, -2.3127735055512666, 0.7366842411814455, 2.0518250758911627, 0.8602516423313608, -0.6951595657270757, 0.6964553347045139, -0.9165816582798986, 0.6882998577551732, 0.6571593414749011, 0.7155718775710415, -0.2710056662860633},
    {1.575915610822303, -0.4259358649164634, -0.11058186406454958, -0.45594504772553546, 0.034054987487200095, 0.6469252321768028, 2.113964851557497, 1.228519258894736, -0.3091385566546276, 0.14357096002796196, -0.3432711774603857, 0.9614453843319462, -1.3189787678115243, -2.021483724218428, 0.24370413387460355, 0.4674501770404874, -1.030685715923044, 1.2422917995801381, -0.16310457328494737, -1.9322325944473546, 0.2895021186378881, -1.507954358180625, 1.590341456448371, 2.3127048915848705, -1.6791084603907778, -0.9292673244086254, -0.9733835254946948, 0.09745261836374905, 1.6336469673750635, -1.7741539934265589, -1.0255352224763905, -0.2556961546733441, -1.8075178867673534, 1.1989210644259023, 0.46388604565378444, -1.6961319270640813, 0.10972704945208347, -2.154410051188639, 1.4431938799846105, 0.16947269940861423, 2.624670139273433, -0.409717396578605, -1.1699649029062011, -0.10587927178123198, 1.1316576489406531, -0.4149648546792984, -2.3473878491743165, -1.4994312324693955, 0.943856863684293, 0.41729209821754737, 2.2673392426011203, 1.4040622037232542, 0.6013656886298991, 0.6636718117211056, 1.3310937515433245, -0.7120983509829978, 1.0113192827319109, -0.8162339181961001, -0.5334118864641384, -1.2118525777108946, 1.6484442403619273, 1.0764861591753598, -0.5035294359891026, -0.36102263372261845},
    {2.135702615694331, -0.5157804173295001, -0.9770928571635287, -1.95470839345869, 0.3885834679372145, 0.5301720321865636, -0.5015910967109557, 1.046782595887277, -0.899376773798268, -0.17278619995877167, -1.6005823119174334, 0.32617404934364114, 0.4167382828535881, 0.8220947019199457, -0.9275989442997841, 1.307003399708402, 1.501607151140638, 0.02224331592786978, 0.07676418275049697, 0.9285712320190074, 0.5189724487604718, -1.35865493448755, 0.4338771426669507, -0.22636153360278877, -1.7260331600275218, -1.7385207623528234, -0.901656112482967, -2.568768354717036, 0.7159428135555768, 0.7854899080112169, 0.46641001900480394, 0.7063598811870077, -1.0483267722628318, -2.019175216182157, 2.2375494126443485, 0.5024770478120898, -0.798023518388626, -0.4400576412341775, 0.3849034180767025, 2.3982111832235566, -0.8945613508737676, -0.45139409471873393, 0.23835533232028777, 0.1264935584861423, 0.7527596090256444, 0.6924225962435623, -0.778014475725706, -0.21955601844150271, 0.1560192011860355, 1.6840829595791125, -1.7835872092820027, -1.3589680540262203, 1.0123534823589442, -0.5207438831249527, -0.4572745379684541, -0.4288362969895204, -0.5879651455480412, 2.2602619091645186, 1.2638820718598363, 0.9465331752236263, 0.8188946938270634, 0.8106250380113597, 1.4009249327794246, 0.650726710997613},
    {-0.46716299304855147, 0.8109894063815518, -0.5211736821799559, -0.7764981172448603, 0.7645486156704465, -0.14352604850672573, -0.3921955403512843, -1.4987112494554813, 0.18841946184164718, 1.6825219070202224, 0.5723324758341755, 0.676722409218715, 0.7248272380681823, 1.1820744080350782, 0.013200969029058002, 0.45429377237616714, -1.9120684570375888, -1.8793157193022918, -0.3650039707949192, 1.1669269902833674, 0.22900806764302925, 0.404964879763044, -1.555977436078855, 0.40250776719738196, -1.513234666207638, -1.2231321525386958, -0.09828246293634076, -0.14626673839328483, -0.8619314410167227, -1.880964448832585, -1.9720779727511495, 1.659666562385025, 0.13913502767785918, -0.3715430940888663, 1.5671420220353975, -1.1096093330323014, 0.6357032564665245, 0.12208183941775648, 0.17693166539516797, -1.0677569982166228, 1.6344071456851053, 0.4011194519016826, 0.8458262912609035, 1.5417518224274305, 1.257830804916178, -1.698309286659503, -1.3855883764995602, 0.9382444764029508, 0.16739926287496712, -0.8302878410150313, -0.9618830259733393, -0.9345541168979548, 0.1106051084592885, 0.5904543611605202, 0.4071743392800725, 0.010816323408389669, -0.02742265370714259, -1.3869110171337644, 0.10280725257590141, 0.09603563285701995, -0.9594848381357182, -1.1986173002106228, 0.5378390386423781, 0.02217713433886457},
    {1.126082609737594, -0.3332516798281301, -0.4230925059813591, -1.3788223800521735, 1.3149299735094901, 0.7275248521012674, 0.2980011539038132, -0.24339767064334938, 1.6233813877507681, 1.2528106937567156, -0.3455625079626244, -0.25294727480561446, -1.0487990127163667, 0.8137297949783348, -0.14259408427610923, -1.86437667034848, -0.15018864410164293, -0.6893489139333856, -0.9639465807076529, -0.8506264788646073, 0.16803177960259988, -0.6084251509451288, -0.4914725649893681, -0.7483918557641667, -0.04693946933398134, -2.361669296430934, 0.0583577501200163, -0.8122124652293476, -0.6237826079325464, -1.00166450200754, -0.29584336858565496, -0.8856811316675719, -0.20922800018992405, -0.3088163519111694, 0.8158172190224755, 1.1072321960219005, 1.1803079739322395, -1.3684240418217335, -1.6582304348770915, 0.7162793738725028, 0.054247790073735085, 0.38743592695349827, -1.3656766135060459, 0.2665247318833352, -0.9345071526876642, 0.09414603551259662, -0.9070524174084048, 0.6590474031057201, -1.4552345223979688, 1.0644540068819495, -0.5489432880241114, -0.8240729783220638, 0.5841615090955088, -0.9055777350052543, -0.19732343350577017, 0.6326185784723025, 1.0859182722389265, -1.3157946165187262, 1.7394415026409422, -1.6641203826341329, -0.7694947884081619, 0.6644072319757867, -0.8069656824743439, 2.083092724299533},
    {-0.11542850648934028, -2.337795760238532, 0.5298839491697915, -0.06346585067231372, 0.5538333052633582, 0.6528660422532125, 1.7290615804598133, -2.1881438978280316, -0.4339221156834654, 1.5809191562284577, -0.2882821972844828, 0.02894893431629437, -0.610652812007617, -1.7515953814877934, 0.3635033657001755, -0.15638627255147794, -1.553619440078603, -0.3939224685130965, -0.8698660794379208, 1.0086087508396024, -1.004733671768357, -0.4114774505047157, -0.7005359665068509, 0.5412693260117901, -1.4028656306195868, -0.05908708172228638, -0.416079408903777, 0.26190481383784575, 0.5572099000910119, -0.37624982690063286, -3.341664484126087, 0.21926710688213039, -1.8281515675019122, 2.4592378720067667, -0.41418000460278326, -0.526846491977328, 1.3757771952036861, 0.26973182961954906, -0.6893981334074873, -0.574177575610822, -1.697762428576928, 0.19210227182368697, 2.3528474108392685, -0.9487225759210652, 0.5087351385402705, 1.5383656599123874, -0.9779456306386352, 1.336313931716137, -0.234123492965521, 2.2274451795647248, 0.16908645802629982, -0.10187214278547112, 0.5621320679376343, -0.5244742590312846, -1.2847687013826183, -1.5983083739662591, -0.9037320799763073, -1.0264693901760573, 1.7093304223139292, -1.3900122484602244, -0.8696093574779094, -0.3551417784297447, -2.0247099647710805, 1.3029398421230054},
    {-0.34230744352620934, -2.2526483617539204, -1.6555143338448741, 1.1213138057525218, 1.8306615136651534, -1.1029502114953942, -0.6922733453969447, 0.7960875799086622, 0.8383544611043432, 0.7765517809484582, -1.522101242420149, -0.7528264358599314, -0.7609464837322143, 1.1254505464753728, -1.7023281421180123, 0.004304150179235477, -1.698529024878335, -0.3023473992166766, 0.41611476347732856, 1.2826220954710608, -0.05469314687863553, -0.18610410036427788, 0.09455213189423003, -0.5390137143468651, -0.8722646681507392, 1.2627555602068632, -0.16521321834334363, 0.24223056740269433, -1.0478835497508996, -1.6179428944823688, 1.7477081588380046, 1.6918565815932918, -0.367467629905026, 0.8856856517327536, -0.6748629347851202, 0.15355208717441057, -1.4033344623058437, -2.481102793073029, -1.3260934790660606, 1.4488444196735728, -1.1931160113565455, 0.5712994981157142, -0.884386849215494, -0.46146872433757063, 0.05154193505106823, -0.32995981125644813, -1.1694527321068282, 0.9464901221825368, 0.5538625550854003, -1.5368995134686296, 0.4006947440959435, -0.10203584785395617, 3.76478162405606, -0.13597712586650024, 1.1850132546042416, -1.5198388530248605, -1.6822801159987635, -1.232444659200081, 0.025393842021014693, -3.3152368011910966, -0.4882636526884515, -0.1663795912329498, 0.26026284750521106, 0.23280714428640145},
    {-1.3915643457659423, -0.03082261141818656, 0.8059340323178533, -0.16597553248237992, -0.12806377293175764, 1.1211008954587531, -1.382562959305794, 2.1316889313600216, 0.5390894862884898, -0.8054626681998429, -0.15223444231952804, -0.3638922978495157, -0.4407975191296193, -2.9849922617600693, -0.28709886182659755, -0.5999874139572458, -1.3020207980137135, -0.019892472496940653, -0.8269177873733785, -0.14249704070093402, 0.17818673659723666, -1.260869325371281, -0.07826219674119186, 1.250105696294608, 0.016557231542631657, -1.9423660059836894, 0.4874449829335534, 1.4080670140351403, 0.35824068006829957, 0.5520394064826234, -0.4704142442201523, -0.662610242732608, -0.6413182481874374, -0.43840252184387346, 0.34651342903828086, -1.1970960684337923, 1.3106835613276742, -1.5717819401213036, -1.2846133075793098, 0.8263437214192505, 0.2837480058677684, 0.016416821841680036, -0.9482318314753088, -0.23872527932265047, -0.5961520852074242, -0.1944905493230197, 1.0438612526429332, -1.172119001371544, -1.7618673790892103, 0.5176879936226417, -1.3117148151866704, -0.1505701653171687, -0.5060130129786251, -0.43324665143698626, 1.9316820008557456, -1.8665912885203273, 1.6863922486584324, -1.7664606583791214, 1.573332922079688, 0.5621658782489725, -2.9183247151164418, -0.14291333093093717, -0.7718657434254358, 0.23710530197965915},
    {-0.13048548414786315, -0.8321401995910099, 0.025715397906571225, -1.1733613365432136, 0.6561852015039671, -0.28014037141423387, -0.6132178043314815, -0.22828339558306493, 1.3555478363249847, 0.212844358050058, -0.5551266431259059, 1.3589204665075623, -1.1667468875225888, -0.29512051341909357, 0.27809184672121195, -2.2050411483760004, 0.7516388440070888, 1.2482312762635064, -0.5503614257811066, -0.029260593367658006, 1.0263383572335616, -1.0037932507790754, -0.5844920855664975, 1.396906209569884, -0.08879802086426995, -0.41982438173758363, 0.7978191661403553, -2.0129261848566795, 1.5075293000014847, 0.1972857892869336, 0.9799807785547029, -1.2499184254525213, 0.49888057610250225, 0.8967352011064859, -0.8487993518459429, 0.035530075757271094, 1.6507373089566024, 0.4126462783504249, -0.29617802716737024, 1.7901419865781576, -0.09199379798124635, -0.46050881000395066, -0.8496800316402114, -1.0879002117645213, 2.686474750308682, -0.36386418985080177, -2.01323935898435, 1.520219189296392, 0.7527105136758516, 1.2523690620839465, 0.0625785726009184, -0.6880881066518466, 1.4656720561433492, 1.1307777687966893, 0.591560563555965, -1.648796454167771, -1.1905796696450468, 0.7226917542988799, 0.7484895017349449, 0.15917048840740297, -0.09835559406511832, 0.8806567718987421, 2.1410810192900476, -0.10710102566754139},
    {1.9367609441984577, -2.0964533587315684, -1.7548924991994785, -0.25211839208992676, 0.839220742461138, 1.5232216374974166, -0.012145147233007945, -0.8883217714708657, -1.597354326949862, 0.37737936488122775, -0.5902082476167507, 1.8446506201558033, -0.15546916814053524, -0.9844979291622284, 0.11013608809435448, -0.9024909862007734, -0.39231359142141353, -0.9579042309331376, 1.2328311111981132, 2.740917106587868, -0.12601467257956134, -0.9067875335363262, -0.48752015871436977, 0.7944912338626734, 1.9541078794964843, 0.1490700090494245, 1.3973515515725263, -1.1405366547779918, 0.44743738806844374, -1.5397538635765127, 0.38923129511725163, -1.2534827096320325, 0.9343065007711234, -0.12945961993454935, -1.6042708177302873, 2.0534830999353577, -0.2689028742669368, -1.5402988039538001, -1.6821650307019684, -0.4934475399016588, -1.075049006862094, -2.36818813181888, -0.5622222626699994, -0.07660057196592361, -0.8308872180512717, 1.3409468594919167, 0.5595802556135218, 0.5016935114953613, -1.0567812556919192, -0.9013313420236777, -2.5966242866041145, 0.38068080127976345, -0.5096907459188799, 1.5576472593719803, -1.1353521307500392, 1.0367234072544371, 0.8609733252427346, -1.9516353517154896, 0.4662319385788796, -0.3347287733851728, 0.7810876274819661, 1.3610744615786299, 0.5535229604683723, 0.5225333857699715},
    {1.2897372021476252, -1.877351891924365, 0.2234175941457717, 0.37019634135501134, 0.21261558845893563, 1.906878346505359, -0.0841967600438646, 2.4026881252815335, 0.8352707991885827, 1.0404071320774733, -1.464009476781342, 1.4557229855593452, -2.526236938890315, -0.10350993607185606, 0.7320966326232612, -0.934280666217743, -1.8589257892836588, -0.23854358670690984, 0.32874860411779394, -0.5476352682521275, -1.0631315144779871, -1.6103530308045664, -0.11151805729103292, 1.2047935244855648, 0.7222846322847309, -0.12813528404473243, -1.0932580477880294, -0.03306535665979859, 0.14285648780583945, -2.25042494472631, -0.3895703864842047, -2.5889846450988894, -0.017418064487027398, -0.7715188684057542, -1.7021552007591547, -1.5101111981896496, 0.2252831912163363, 0.03422366558006807, -2.3479291467537178, 0.6988930726780561, 1.068642192020026, -0.6455757099725007, -0.38370504146213563, -0.3936849150831175, 0.18359936053262899, -0.9295140050567082, -0.2868313752384825, 0.20258122023339065, 0.09165842720160534, 0.49940626262946336, -1.4313333631725829, -1.3537736918948695, -0.2723016182258168, 0.6143676614925403, 0.6057546319315266, -2.1989126930710827, 1.1368181001245246, -0.056558015825609285, 0.5465105419063474, 0.23609664598828678, 1.6776601719958553, 0.6677372774108961, -0.11691435893309048, -0.44193306425782675},
    {-0.8656889433610416, -1.5587906812086072, -1.8251005987352005, 1.0026967492962897, 0.009569910564683674, 1.588909939433928, -2.2645130058478675, 1.237482480131615, -1.4174427416212834, -0.3289506432282147, -0.695952762627168, 0.7742611377276823, -0.5554953195583847, -1.5215454657634475, -0.1357546567613606, 0.4019697033127146, -1.9602883942014164, -0.19495289039910496, 0.022622116904892114, 0.18512791168423762, -1.0764141884287572, -0.9958850938624532, -1.4239122735305778, 1.8873812066208442, -0.08332804104364774, -2.373835923617715, -0.36001486083694656, -1.0046159762844602, 1.0856296698091916, 0.49983905777695115, -1.2880272607162084, -0.8388233374738132, -0.19588046178962873, 0.18486419706158075, -0.48332794318332933, -1.11188907059795, 0.7251376581143802, -0.9184236557607477, -0.5254823564350386, -0.5296002346752201, -0.17259877611232324, 1.0145351043118849, -0.9388183493472833, -0.9985194251668226, 0.717440829400068, 0.9269885392301463, -2.965801256061018, -0.3216644560541112, -0.18315733913793017, 0.4416827907914425, -1.0711577948937063, 0.29668461586420475, -0.48238180318365786, 1.587590457930476, -1.3344811714381966, -0.9076003065489774, 0.1740938189735106, -2.2941983479109735, 1.0610303533146106, 0.44031436523797185, -0.35368563039431866, -1.1876163760088403, -1.6479372662174703, -0.32849410328594886},
    {1.2195218970706132, -2.129504582793774, -1.1582241348570625, -2.9109214539305106, 0.22744793816863104, 0.41965722740538214, 0.47879846454332387, 0.8058512697924562, -0.11200712175365267, 0.5145510273048305, 0.338079919345437, 1.1194189620987032, -0.5733816962958159, 2.04629180593668, -0.6372577977814142, 0.13750042314207708, -1.7263732837577916, -0.9181415188020517, -0.19488904555184244, -1.8297750082770166, 0.707901882410834, -1.7442294451324425, -0.3705816478360146, 0.39393023289132617, 0.025555357926835977, 0.024578779714666828, 1.4661959319194362, -0.36018630918747513, -0.37484532082546257, -1.8521190137856174, 0.6820056807836865, -0.1722357050971889, -0.39784459456815097, 0.6105327417120443, -0.2283984242618688, -0.6757893448053605, 0.08074349855850141, -0.8713616843021419, -0.8987183833151212, -0.7671487943157022, -2.626593698909292, -1.6338714916040757, -0.6058668210568523, -0.14664484779832096, 2.951575840647054, -2.5509667801798335, 0.3401732563647176, -0.7450218255658639, -0.9282317893598144, 0.2035886354963704, -0.6394228536176504, 1.0987449574252197, -0.7894728622744545, 0.5204389812768844, -1.0339483730525008, -2.057045758083, 0.16821446135002782, -0.8076868503572776, -0.18874902867074628, -0.5222543534099411, -1.2094151345354338, 0.5038320209831028, -1.3087423113173324, -0.20297997100555745},
    {1.0286653101460013, 1.1253933670709564, 0.040260156774663505, -1.3134812605429573, -0.8853502897108116, 1.5135988590945384, 0.7008724282194835, 0.5725280754868721, -0.6011518767145267, -0.671799622794928, 0.26727081623772847, 0.1230738358284468, -1.8521740768181145, -0.4118754514128049, -0.03457072569664703, -1.1875166566470532, -0.7724262896040816, 0.1944224101381636, -0.9095519853012994, -0.6028486980645289, -1.5983383051041302, 0.6922416863291156, 0.3001069364799045, 1.0383099910275277, -1.2479748407992044, -4.089914750193223, 0.3286307668508314, -0.5829725071287822, -0.7078403578763407, 0.4951625398251007, 0.817065614364588, -0.29219146361050674, -1.6502064821956446, 1.7953116427299014, -0.38142382343947084, 0.9209300251767263, -0.3472552479376158, -0.13108920182748757, 0.5378898055678604, -0.2884560498974855, -0.4863723877359714, -1.7817847654494314, -0.8821832264252116, -0.7202109733037229, 1.97591829051615, -0.6398667650720303, 0.04681606589055045, 1.3891756782648625, -0.5632056286894489, 0.6847323237387571, -1.5838153588022088, 1.763039585663017, -1.1230855537002606, 1.5946939375294877, 0.6350841226412056, -1.3464642468114583, -1.1446479826634068, -0.9655687791949946, 1.3618787985052743, 1.3797235636303882, 0.3835428429319927, -1.3935700274304135, -1.1903215047851374, -0.2743777403359448},
    {1.3644695628250592, -1.6854614193139692, -0.1713183381616076, -1.5374829282241336, 1.3944487904577498, -0.41279077568624856, -1.5876781636925716, 2.304460443783437, -1.8172098292801377, 1.4727469511438132, -1.1983816063819028, 0.2744529108713425, -0.3228824374056306, -0.09363884641181155, 0.3815727027320943, 1.0800587526644607, -0.4755810079854961, -2.1335658502349037, 1.925412017993665, 2.018872999648099, -0.10411681842510842, -0.8532578501423272, 0.9631977298826931, 0.7593322428740165, 0.19909955181745312, -0.08764483737342875, 0.7127154852115862, -0.20636865181436737, 0.5875381782661093, -1.7780334109661704, 0.8689510594534032, 0.5211288442726157, 1.8315517555080407, 1.806461320827509, -0.08551199371970154, -0.4071230513511815, -0.8682723352813533, -1.2159289104629023, -2.083845931117323, 0.7889495267034334, -0.3482190269753544, -2.148595778288816, -2.8895342531368757, -2.8295260291571473, 1.7558244716968592, -2.340077960858832, 0.7138148525388138, 0.21412960929969527, -0.5956568401527175, 0.8406330628837423, -1.7561641986845775, 0.6112424714838044, -0.8542996246197815, 0.1359254995146263, 0.6024940417076231, 0.34108225204661924, -1.0172253701189886, 0.7569438179684664, 0.9850476537681909, -0.59797423850375, 0.9806792967968807, 0.8050128684798712, -1.0351525556496726, -0.6856412828477549},
    {1.3053698143448986, -0.6777065584996876, -0.8884449468802844, -2.9994437858365544, -0.4274143923978337, 1.0298920037486226, 0.20989900468841907, 2.5743572587309282, -0.2670004957693676, -0.5534438328546926, 1.7204271739887336, 1.1867642143155053, -1.6842222840535588, 1.9129269320691973, -0.2625619256660898, 0.7171048682532937, -1.635583490941763, 0.13188267394049508, 0.22429931615736673, -0.18655565639394092, 2.192631339592309, 0.9399090399871763, -1.348305648128378, 0.3983075564253512, -0.6615616192859034, 1.042096965432681, -0.9563371190725729, 0.20918204539092936, 1.1783436628064088, -1.5766443114025328, 0.003662841312495389, -1.1672525931827034, 0.9539559068356352, 0.6086191641908083, 0.9095229845171297, 0.6646111006466969, -2.5011413105106386, 0.5291093073384774, 0.10118715791324298, -0.8441908384891335, -0.15496614334227335, -0.857836874817825, -0.05660396274163516, -0.491923919684483, 0.24151909912143918, -0.17416648183017117, -1.4198495107396936, -1.2126144545151407, -2.4867590307721827, -0.7189378997300828, 0.6076294591627539, 0.5809791550050365, 0.8746792263493661, 0.6594376863655041, -0.2780096525887303, 1.2872364471245852, -1.7225468671443445, -1.6623256503834392, 0.29310728672696984, -0.8993091762097523, 0.5630651818741603, 1.7006505387641078, -1.0721674264466952, -1.5703678607251719},
    {-1.5076470172563765, -2.132564924582834, -1.1299627079513406, -2.4567862527133113, 0.3791670140362988, -0.14603379765603902, -0.15566255005397422, -0.051226053754591605, 0.113150470977652, 0.7879964277396886, -0.5532527960118345, 1.219323452848296, -0.73803310729434, 0.49489916674407436, -0.4624044942636275, -0.9296204799263826, -0.43565037230402215, -1.3136048141111465, -0.45068339204710295, 1.0729959266894968, -0.6678043533999619, -3.022627406460345, -1.3672686377704943, 0.6709825088688148, -0.40951634203665765, 0.7814349609482341, -0.9553264887931132, -1.884387088922059, 0.9866046038813415, -1.0935585566613677, -0.09402696541132316, 0.2341526108439424, 0.22373299468983723, 0.1722365589153761, -0.18677461454280245, -2.0291517243439037, 0.21418944732609735, 0.2917230513368072, -0.6210944538968842, -0.1385417604653549, -0.5403769205238642, -0.42291133863392333, -0.8946528649024801, -0.5555942183740985, -0.23513151113848932, -0.3640856218647844, -0.13791772852363562, 0.3631097970590977, -2.1647535805033944, 0.3720321257931726, -3.389618845983469, -0.154830281421977, -1.0871059716340359, -1.5518656001012168, -0.5403699742651141, -1.0017794253908219, -1.4736677653263406, -0.3155594671102551, 0.9042911196282102, -1.5697906009463563, 1.4297896065378686, 0.04329327024820164, -0.40857007099821374, 0.18616744012606767}
};

static const float b1[64] = {0.6633270997870144, 1.8006750009981742, 1.7396988512510914, 1.659093277241972, 0.6283092257990763, 1.0124590729841427, 1.6899934202264202, 1.2094949673654374, 0.5531730578408801, 1.5991218025837084, 1.4719120140513429, 1.3405799195374983, 1.3786676004025793, 1.9893652355384768, 1.6483060060615846, 1.5209456895774314, 1.2962626878733021, 1.6189458499581284, 0.223355629500997, 1.344098227883325, 1.1035166658539686, 1.2520016825301141, 1.6262668485614131, 1.264342862426136, 1.7743973585620338, 1.548287555829651, 1.4617928352949898, 1.4002899814151915, 1.3096164458928785, 1.8720013928845387, 1.6069461863781014, 1.142449091620338, 1.031715224479225, -0.2511012994169299, 1.3649676819027057, 1.0759167174117956, 1.3637891120568513, 0.7614417711603263, 1.534780422095795, 1.6266336863579232, 0.3267004423896674, 1.2195050693187222, 0.7432894203437758, 1.5990781090015584, 1.498896065120686, 1.6318733946013622, 1.748798864734906, 1.1962204218191235, 1.6734005007125974, 0.6066250279443157, 1.8769780521037638, 1.0350437962037977, 1.0482818748508644, 1.3102252216885024, 1.1572185747280936, 1.3567580787509568, 1.0109794291843872, 1.1580586721976291, 1.5832130412255039, 1.5463609375973177, 1.3480504739986214, -0.6599644864001557, 1.503836699558308, 1.4652803411721127};

static const float w2[64][32] = {
    {0.5469293455348228, 0.8676060055101535, -1.1506610179871153, 0.9929088115708388, 0.14879884922517128, 0.27877637297107616, 0.36666297275399157, 1.1634583487818784, 0.4729077421027853, -1.376216228128172, 1.2280295736898579, -0.7922277216043473, 0.43870922583930155, 1.3670629291864183, 1.623736260335429, 1.6378410328297233, 1.7080384574795224, 1.025587894663328, 0.2746632160172232, 0.5307690835282273, 1.2462873557372887, 1.8821903698623497, 0.5007270648493111, 0.28032317014082003, -1.0248001334087526, -0.26724126626757483, 0.32262796419912154, -0.4387866178918867, -1.691345489061294, -1.7755740231238621, 0.7129411263375591, -0.6010748317749481},
    {0.8345274676708611, 0.2862490688522654, 0.006915990231540983, 2.146648954736229, 0.30601171318367826, 2.5278543751419362, 2.9368756953115427, 1.6068439047722765, 0.1374019141335229, -0.4395278984367362, 1.0541165206964513, 1.9599292621743398, -0.07806212575988355, -0.44183325557518455, 0.7191774021236781, 1.177662933331703, -0.03298743911526156, 1.718751891373895, 0.8663127114889133, -1.3154863772204215, 1.860527305329801, 0.7628659355347662, -1.2065285695370704, -1.3390613821003559, -0.4346095952185307, 0.8990859042302557, -1.1748619697350124, 1.522873786990834, -0.2925831482050333, 0.5754825798358187, 2.343378349869888, 2.6324247764094846},
    {1.7712634488648087, 0.8429831816467603, -0.7603587647219059, 2.8453084638587547, -0.945892892279343, 2.508433409456386, 2.999196443755882, 0.7127734030581526, 1.577980791565323, 0.27903766198017854, 2.4904235224802265, 0.48490123477020247, 3.355112556371251, -0.31649109605276377, -0.655256032792077, 1.9704430699533746, 1.9039860635912758, 1.411895448372897, 1.9448429231561135, 1.5329509027178523, 0.9302024273004351, 0.3163291347872121, -0.2631347578940464, -0.9814999840458923, -0.48476694198436826, 1.1128379579724026, -2.4173729696976154, 1.2963710956739236, 1.0042359330858996, 1.3989029676771043, 0.8371304989198229, 1.7459502321059313},
    {1.281219133765614, 1.3021133818541417, 0.10851824797723705, 0.7023017296587092, -0.8307228608604675, -0.7259165169084508, 1.5135874893200079, 0.8553675543631778, 0.5992329853730718, 0.3702300760211953, 2.1116836786753135, 2.1019244528005543, 0.6169994760790662, 1.376908841400482, 0.9336270918819538, -0.6383939623052457, 0.8788924518084983, 0.0438169565447173, 2.7087976876414444, -0.48259046057597116, -0.14660218983795462, 0.5871858193171845, 0.7885056986369835, -0.9036236708434775, 1.092017598079117, 2.982212802801273, 0.17072547820542772, 2.7789769811907767, -1.849170422263719, 0.9583981623952088, 1.6753485488349578, 2.8521180191271824},
    {1.187923691368014, 1.3216814450244436, -0.6866982832745734, 0.34012101897570407, 0.9146992959743119, -0.5994523405065442, 0.0888617533595395, -2.008285451193281, 1.3203474201025909, 0.3322045937940063, 1.6202104277916227, 0.6833989476138101, 1.8590831933344103, 0.8037582869449383, -1.105861705533293, 0.5959634779672546, -0.6880000834597255, -1.1070899599995991, 0.43777042957033996, 0.43593427110414257, 0.980433794120922, -0.9402903646043301, 0.13076560761975187, -0.19188009983698104, -1.945071539798621, 1.283483978415273, -2.738214687620506, 1.9977147161392015, 1.2932887770747243, 0.6197575532332216, 1.7864656685277454, 1.2549959410795197},
    {0.6767810320575909, 0.3259850800582034, -0.5959600265181766, 0.2478856208594058, -0.18816310466849084, -0.23097519023355023, 1.6079626212373284, 1.5714172292962678, 1.589148993048775, -0.33598322378276557, 0.11677613906197226, 0.4100744420968691, -0.12207799843383248, 1.256705900250886, 0.9112427461928374, 0.10851910048311054, 1.4790513701732457, 1.5909113676312212, 0.3645821287330914, -0.29582201051736584, 0.8236366133678951, 0.2955929150723199, 1.1055137275344271, -1.4190770558593528, -0.45205950473978507, 1.0546284656338099, -0.591432147430441, 0.16372593448741904, -0.5277287470607737, 1.3843319668313383, 1.5334448046375146, 1.5652451525443536},
    {2.153363378184534, 2.0586517829685653, -0.9564067819084795, 1.183708192344314, -1.3674097887961492, 2.2777746396207084, 2.3513204367593983, 1.0382299301238391, 0.05779006949104025, -0.6597376057117899, 1.706492227656307, 3.418107532028744, 0.28038243988115374, 1.3881685494967122, -0.19274001073640656, 1.5498639883649905, 1.7513652289575736, -0.40802243859160037, 1.498814803231212, -0.43340674353595254, 1.4881094695373271, 3.450214331957252, 0.8395234078337195, 0.730414567130271, 2.255689183091448, 0.5689775384647855, -0.21062786528202218, 2.5779920567721164, 0.8107882663822048, 1.2615932109966796, 2.6204381666948824, 0.2274697682469774},
    {-0.27619102130766976, 1.1406375251000418, -0.586406565160288, 0.8651839138821722, -0.13278023154228352, 1.2981667077353225, -0.04738218552912816, 1.8163306232903111, 0.3463045817647006, -1.9462593979083131, 1.7898244282958367, -0.37818112686197747, 1.3959384019864878, 1.4955515047029313, 1.2019112322171408, -0.08477110737200796, 0.9413051709406642, -0.7221216377471174, 0.4689089503731833, -0.2470336891780879, 1.0538795585755516, 1.6729831367262644, -1.130058978283737, 1.170482616142587, -1.4900472974226102, 0.7995653434995071, -0.19415291910940527, -0.3193387951040128, 0.08202429473320494, -0.2478406045057435, 1.1022474763030168, 0.2847366636920234},
    {1.5484176491282327, 0.868235575123551, -0.5815267515096719, 0.2708458786752906, -0.21546893739564166, 1.2460340924618358, 1.041542674740676, -0.9410138848607945, 1.1717363888984498, -1.2664701860554113, 0.6427815228835603, 1.2738627224903334, 1.7238575016170825, -0.25827625711978025, 0.7102959121711616, 1.6633068494678647, 0.817629248798961, 0.3533879380777713, 0.14202906755459485, -0.03481381026329432, 0.6436939384826605, -0.9124247456317253, 0.18202717942526117, -2.0871692852452846, 1.954515735743955, -1.7891825334853304, 0.221739359098891, -0.17401414266389734, 1.6887405829617101, 2.05548389395918, 1.0205761759062033, 0.5931288115961424},
    {0.6277064995383069, 1.1267831001087072, 1.0945347739865945, 1.1682153918940736, -0.29505339276449516, 1.5827307550138139, 1.9625204817532391, 0.6614875965065741, 0.38958631365125485, -0.16311830716080586, -0.12453977164876186, 3.1395458405494883, 0.625525533704139, 0.8722673553840984, 0.7937805022584975, 0.4656736562250485, 1.2935328886953292, -0.6371989660757973, -0.25550395848392454, 0.8316622839994119, 1.7037235028747857, 2.3702390998686385, -0.5930988181472021, -0.6328114697974343, 0.22503073015534553, 0.5570279511533357, 0.7927019375471583, 0.45631647317229107, -1.2027259971976365, 1.35955900997212, 2.3360989266036674, 1.4010742984482076},
    {1.6329975731377606, 1.3300369867382835, -1.4400011810934674, 1.0473939453124506, 0.5212297584231529, 0.6806226302401982, 2.9698894696276503, 2.1518219875686024, -0.9387836441613242, 0.9224919718658738, 1.9152051607310452, 0.235621153637343, 1.877453985710386, 1.2937752308595427, 1.9669289170387616, 0.6704690603648472, 0.8745714747846374, 0.5061227566899758, 1.8211002387545263, 0.6374523811920977, 1.0002450856612344, 0.8423846401079429, -0.8004496437231595, 0.26440963907937526, 1.7452491247800475, 1.3211613405702696, 0.3166462356698439, 1.3730966017976534, 0.4807726634468824, 1.679069949828523, 0.8132826572062789, 0.04797424740506685},
    {1.2370609855276304, 1.0083546652229414, 0.07477657135590098, 1.3893692779306444, 0.10107705974890405, 0.4060425988720092, -0.053081912071808776, 0.5280093680873312, 0.5875013493807496, 0.27096065124101404, 2.2169397224355007, -0.9929701914666561, 1.1556179246570748, 0.8946861474893154, -0.686194664702073, 1.5579289510627026, 0.9201155360372183, -0.1495022209841383, 1.5783643082803753, -0.4748377063321785, 0.9278307844345359, 0.5383142720656694, -0.552099313122525, -0.304873942899864, 0.6642632199673956, 1.24770958062483, 0.3446233962478379, 1.6155525734783969, 0.19243005926430132, 1.0237956268620367, 0.444625719531581, 3.1791352678360476},
    {-0.18652373760575655, 1.7754927721937954, 0.7591182208605677, -0.32369184863835226, -0.45911815826312746, 0.4872381686287232, 1.8593407523517944, 1.56641416746387, -0.1677105215413019, 0.06855599267126757, 2.61890448484299, 0.6474817778491374, 1.749951372899143, 0.33966444652349037, 0.5435937798303013, 0.2916853154855072, -0.4424701733868851, -1.1534249657335403, 1.4175359393818565, -1.6890530442898157, -0.015788277264874282, 1.3358681278273767, -0.3482414249750542, -0.3536794707680938, -0.9519658344074412, 0.7017923269031803, -2.1399912760268474, 0.817553230841664, 1.5508377163786518, -0.8083166091174301, 2.5399870056424363, 0.8032214481148043},
    {0.15687423351586616, 0.8714630284684783, -0.14359341993355318, 1.7443695826032852, 0.15534865377737533, 1.5262724380137622, 1.5297436152291943, -0.4996228007070895, 0.4303569580338118, -1.3903237084588718, 1.7486214717829898, 1.7671533652065319, 3.082099585093471, 1.0103580017566547, 0.047201141623970246, 2.650251896608339, 1.249269718997396, -0.36202066677255557, 2.857697758111774, 0.7450110241381442, 1.1365017686647798, 1.5841772423162783, -0.9140824763003991, -0.8243539476012949, -1.789335068748097, 0.7916799096668083, 0.18564252410190676, 2.8085210706768216, -0.5601389507973425, -1.2174177003700122, 1.7634579776467418, 1.220350553437353},
    {-1.1138194443910652, 2.908395068617516, 2.6129083864744467, 3.3152802920857973, 1.1048773006854729, 3.3710994084653096, 0.02279205106550484, 0.7284431616582828, 0.3208115822926234, -1.0774183834360163, 0.11329121057427029, 3.002156375017873, 0.8371321676320119, 1.1079437327421127, -0.9916288031250012, 0.06390265510532356, 0.3099863948973134, 1.0027478596108976, 1.0382668358303209, -0.9183420064626237, 2.570603244247099, 1.1318877685983855, -1.2224820906015885, 0.4846814493265482, -0.8526167837758728, 0.12260430897888129, 0.49860715627533747, 0.6735928959827933, -1.4079077847781043, 0.7158222780078141, 1.8509693268973288, 3.294493722307626},
    {0.46929973141548137, 1.1515052137817465, -0.1028272593239787, 2.7232982069695586, 0.5598938567646954, -1.0475552662119998, 1.7735098777546658, 0.3757571521424559, 0.684321767909075, -2.162093291028104, 2.1911946584152604, -0.49051405625054634, 1.8074881494972734, 0.4395700522974391, 1.4061373835934765, 1.9627828630562383, 1.435787525490748, 0.39618278085756675, 1.9865554285542149, 0.0703460862218703, -1.106281073515358, -1.0079358395543365, -1.8861650310376186, -0.3565409192996956, -0.12999750592412135, 2.7547203197720034, 1.2378450526053968, 1.4299976114334856, 1.5002649339052723, 1.0486566325449513, 2.0256229006762108, 1.6962836681429536},
    {1.419895533718656, 1.0400289986123807, 2.300602334740596, 2.7409659477981267, -0.044837404895458365, 2.18104947823337, 1.1342927285164714, 1.3491421547326607, 1.665320752775219, -0.19471675840116526, 0.38786741300505967, 0.3478769632195275, 1.8308845833385154, 1.2886310043405667, -1.266799653103464, 2.5851796704042815, 1.0116956921290157, 1.4237096472071376, 1.800212406804684, -0.024117460256684584, 0.9978823630380889, 2.325224029251806, 0.4194682247443356, 1.44888478210255, -0.9788314764711223, 2.402808150758497, -0.29761638769288834, -0.7172073611529923, 0.35598035761470165, 0.38211735775434846, 0.8732181659904125, 1.096226833015526},
    {-0.36078990466766425, 1.1444725586054931, -2.6887045139116164, -0.5064252048579473, 0.9867263971522253, 3.1593107386066883, -0.09613020677839797, 0.9480978251736306, -0.4500873714839006, -3.2725805079332866, 2.128862719592345, 1.712923361374784, 1.987288812741668, 2.1435283678755765, 1.0006849479528301, 0.8721355647376872, 1.8762704999059625, 0.4174316300352811, 1.8829566001460276, 0.9017534232186831, -0.5342393227125983, 1.8931050806594323, 0.009513247257655401, 0.4636499727108328, -0.7247074093282727, 1.9965606960122904, -2.095086220054503, 0.28075283017153246, -0.14568943336166407, 1.6666761287108511, 2.286101054167446, 2.3397036601833885},
    {0.33791752660252233, -0.026605402840624414, -0.5222317166221068, 0.4986502210810145, 0.9581574407203445, 1.5924918396170875, 0.23926314210062555, -0.19218319548675014, -0.24954981092282558, -0.7133155182701597, -0.6653678806831084, -1.08576332674876, -0.2248081244446107, 0.8697270718461959, -1.0840086264147006, 1.559194396645525, 1.7695255231710108, -0.999696545588089, -0.2929819327989897, -0.5732275454657684, 1.5500669464420742, 1.2830480906358686, -0.46780592124444353, -0.3792300367073649, -0.886664784590559, 0.6367616262237139, 1.0077689019690501, 1.1982077952421617, 0.7097219493379299, -0.9366791755322645, 1.478935723543561, -0.965306613863984},
    {0.09909751207335313, 2.633781719889035, 1.7601365126533812, -0.29812766988510647, -1.5903014611267967, -0.2879150531499829, 2.6964629638991906, -0.28014161523713904, 0.6823431106702921, -0.33823708078855563, 1.5183608775595303, 1.4396400397211304, 0.5469880618867244, -0.42933481249171124, 0.04161304243644852, -1.2256753970579475, 0.7328616769566013, -1.522351752577118, -1.169297734409928, -0.23871916923816175, 1.8162942950531415, 1.3953772705140817, -0.18125388851286448, 1.174053329529314, -0.2666592318931467, 1.4967378338357482, 0.23567391527264112, 1.7531825550847706, 0.464069219907217, -1.4150532540546326, 1.9539391225728944, 1.392757512194861},
    {1.3190269925752673, 1.6493689864357777, -1.3713969724926356, -1.321490169690756, 0.49014453063333246, -0.10631450362538583, 1.1060492507075075, 1.0452872589505018, 0.5316815193681181, 0.37305529948221733, -0.45574175334178574, 2.114535069616993, 0.3843075674019513, -0.0214474802122587, 0.32462324768867407, -2.543987309723231, 1.8056907523830243, 1.1846383010950048, 1.6978116620720032, 0.6451128976202514, 1.637779470327876, 1.7549491030464368, 0.9179482124397296, 0.1869096806501986, -0.8559416425406491, 0.7152404455199977, -0.4424537074130448, 0.4331336846692373, -0.1751215532814089, 0.08318622248091656, 1.6893825386839425, 0.8230296908056789},
    {1.5499085483454682, -1.9061872757987148, 0.46470560758295226, -0.48044759971412143, 1.1963829694660568, -0.2877742670889991, 1.6142267720214003, 0.2636735375814571, -0.02107368696768025, -0.2591960284733557, 2.221188090684862, 0.7836249538869591, 0.88303668583394, 0.637481563571114, 0.49035320175577496, -0.10169213450894068, 2.4810829628446864, 0.3418177913513402, 1.6694261147517528, -0.9927254222085048, 0.22338165763612333, 1.8718998990688493, -1.372316040758731, -0.22140677594133926, -0.46171065352670376, 0.36093680466344635, 0.7593522756677288, 0.6642871640294363, 0.5812595200408054, 0.40515991230678894, 2.298023255038206, 1.1518043604349695},
    {-0.332795122242941, 1.2256500395068481, 0.7750920488379655, 1.550996471002662, 0.6748167433372777, 2.392674602083809, 2.9818755086136766, 1.880903493897683, 1.478936726317489, 1.3469052626852978, 1.0786887594276908, 2.7809257459256833, 0.8920177290952108, 2.2284282260189108, -0.7034772797284715, 2.2091690807702786, 1.2973624230180278, 1.8746988632237007, 3.574674091739684, -0.0761258355727413, 1.0171702278315031, 2.4197490792600855, 0.18992853230779055, -0.10025371352019652, -0.600478930489801, 2.098676193001955, 0.18712276256415236, 0.9571476454629034, -0.06632935701936454, -0.5828779315392768, 1.1549379610672974, 0.8737391648116932},
    {-0.770839476657598, 1.4463631326039257, -2.541016037761283, 1.1851475116865686, 2.4482720302229413, 0.08307397972479845, 1.5645512611936323, -0.23754194939643433, 1.802066405333561, -1.085370940309218, 2.9134530203886344, 0.8222046013340661, 1.875199868415367, 1.8954361257520855, 0.6493157505857606, 1.3931581150417498, 0.49191455771307957, -0.7494385628003682, 2.030135176697685, -1.529391682317088, 1.568901428074907, -0.572050344213854, -0.7141884073464864, -1.4768984067720452, 0.4645171785519524, 1.8697651355557, 0.8669433880958725, -0.4335496856205191, -1.4586002156615445, 0.3761486302695866, 0.2246098129693659, 2.2306846262394764},
    {2.4210382829445436, 1.844566564741231, -0.09415517883641009, 1.1714326444013363, 0.18187529517589973, 1.9570855238886633, 2.424195604123631, -0.16275367929845172, -0.15754747360090127, -0.37445650633015465, 1.9279461583466904, 0.7807153093064844, 0.586426613862196, 0.30067897824115686, 1.897462767625705, 2.85227366799576, 1.4152808643975476, 0.37357264595749995, 1.519591263600981, -0.5226972016959557, 1.0854507564149771, 2.04976628645821, -1.7644789422852627, -1.5531105718165554, 0.3774676375259214, 0.18605599997065095, -0.21000557167697045, 1.574041942916227, -0.054374579895426496, 1.7033186785337049, 2.1068582450604323, 1.1507072624365078},
    {1.927512678034839, 0.33320987081256664, -1.4368291801515347, 1.8516142907867665, -0.6025214100670517, 2.115604295224444, 0.22523667181622647, 0.14220173546908227, -0.472632418251223, -0.19475638267220952, 0.12889656502118177, 2.2478000443743924, -0.41322951505828276, 0.5732266188149243, 1.0861207555443704, 0.41241437647661505, 1.6880177951062234, 1.7051303621260114, 1.1073838747266134, -1.0791953462470394, 0.6256065483296313, 1.4398615330298274, -1.33344563473218, 0.3580269540488104, -1.194540025669685, 0.5087054358386758, 0.30875400166420147, 0.5047844134599224, -0.9007139996826159, 0.9041854537423972, 1.754488070261742, 2.088778550842886},
    {2.3106396751093343, 2.7227453543482776, 0.1480442292753113, 0.8886243669328734, 0.3085389822622555, 0.500507596176595, 0.28763873674065826, 0.6976512143773421, -0.6291915556490976, 0.33602452557510815, 1.5648160734554215, 2.051500827673554, 1.8692898079656453, -0.36795888760581813, 1.6802730357536022, 1.3502351737389882, 1.1202489786368137, -0.835031900754431, 1.3968959104806653, 1.152274335076184, 1.610189175915931, 1.6768995112865146, 0.25367504389592394, 0.7387756859057215, -0.5302005221116433, 1.5780915384351235, -1.0479638740390613, 2.4911981211425815, 0.6349548550780584, 1.4388927350688876, 0.6564327484786076, 0.7943234820509629},
    {1.2938637186832715, 0.310062774711991, -1.3962811696266297, 2.5645203908354226, 0.9422680745031803, 0.8130696472436701, 0.5553668970152782, 2.4055442120061596, -0.689417981236988, -0.5705715225902254, 1.7050901902396765, 0.09789746933609096, 0.6403419874165666, -0.4455260035456304, 0.707458773430936, -1.464988972756581, 0.41596393236016455, 0.8608215228571551, 1.6466819261420513, 1.3175747437227618, 1.7476154137791773, 2.6024928587201464, -1.2775274432312516, -1.9191704416934583, -0.2785426257678001, 0.22158107536735522, -0.6336869121266627, 0.2074315747966016, -1.9552787167037158, -1.213188982427599, 1.6353501308379985, 1.5178336175080382},
    {0.5676418539695994, 0.9763926518224175, 1.5946016668962508, 2.571718519782581, -1.0641015381136494, 1.7505011214582853, 0.8235584442044794, 2.246941500053416, 1.1101939352723393, -0.899856116657829, 0.2080647613140819, 3.059407595888178, -1.4075858102291932, 1.298463891717139, -0.9636854834797397, 0.9650066300218398, 0.5222342655774924, 0.923360358884591, 0.917633023682314, 1.1916318926222973, -0.7644335155514811, -0.034416065846083074, 0.049364629560045774, -0.7756411211749596, -1.6382775528251075, 1.0225363397593517, -0.45412572552709535, -0.19578393077522988, 1.3728501608898407, 1.5327728751653877, 2.29408091891814, 2.208675076024053},
    {2.1310562885890922, 2.830539355763704, -0.3630103149539326, 1.2678702969680842, 0.3114608546165583, 2.2716428639108432, 2.741792119061875, 2.2996050741022174, -1.2509034253132476, -0.958406856434455, 2.5932543056472053, 1.8092053111239847, -0.7811248124743891, 1.5842647587814973, 1.3220008981414593, 0.5508776203987911, 3.0910105787433046, 0.498573974886577, 1.4992283985533352, 1.057347941144513, 1.2212528754053906, 1.0444106909783055, -0.3252259806387452, -0.77808715395823, -1.5018971600346118, -0.9145047073097806, 0.3596688560887913, 0.8704356779814947, 0.4898184996095321, 0.572768145005588, 0.9997137283184803, 1.6159640589587674},
    {1.7150124880473294, 1.6005884995558415, -0.04005344673891699, 2.855413246398041, -0.44941903525778426, 0.06034095786583368, 2.332502449242785, 0.6200708091502315, -0.853569893336645, 1.8611232765158092, 1.0123803836386027, -0.8711167030037528, 1.201129708757382, 0.9344570154901654, -0.12460708613597415, -0.7722706656987818, 1.5493251814175413, 1.1759890798126762, 0.7699999435604168, -0.6027476040307757, 0.8776438852589684, 0.24554829413615437, -1.034671114882738, -0.4025446379505495, 1.0740846147219423, 1.2829973127506384, -0.2888799597752272, 1.7588494188333206, 0.18152086474987178, -1.3445130920815729, 1.8027599056825605, 1.5316320859586499},
    {1.9134577191431235, 0.4485001748803263, 1.8536593665788108, 1.687827488115141, 0.08524472826640511, 0.25928911912790586, 1.410114800476412, 3.1566865410015073, 1.0268317861963772, -0.11001121873566645, 1.0477647119871658, 1.9391088495388522, 2.312553528611808, 2.034528412504566, 1.7515210201375935, 0.767481776586433, 0.04910630164863921, 0.6219348148457384, -0.09493200086446356, -0.5693434408758914, 0.5152163220515845, 0.08535271690617445, -0.32362311080511036, -1.303001278185261, -1.5028237468946966, -0.30085229766217436, -0.24343968984103262, 1.2247678478552277, -0.014408397984739087, -0.172207682462214, 2.1000930834525358, 0.30849449339102875},
    {2.127373037153289, 1.4691950395714997, -0.07349924298565993, 0.39581174511431133, 2.09169041051604, 0.7739113651985584, 1.0758336843763876, -0.6112167077607537, 1.4081897995128136, -1.2925852741122248, -0.7771875635408986, 0.8624193569633324, 2.295879188439828, 0.5916499692736142, 1.9292134203113689, 0.0053655410571848, 1.042156205148659, 0.8882913287943263, 2.129205625357988, -0.4835409463029992, 1.3021890342248803, 0.17740917112470025, 0.2203838038149168, 0.3715222188420377, 0.2752101358870236, 1.8510569965074117, -0.3600843788169114, 0.5248550569434035, 0.022967476999220162, 1.1443613488133466, 0.20634544675476277, 0.48719147971514354},
    {0.2297627943556138, -0.17038188836555557, 0.1849780383048749, -1.3699585249272765, -0.7235832775884926, 1.9038008155683765, 0.2016726000735707, 0.22301912840875937, 1.6315314882394627, 1.0112817524431617, 0.9636418935435357, -1.4030138750580556, 0.2866019935962509, -0.06877999913977322, -0.7869025365903076, 1.027087405531756, 1.6987924188019474, 2.00771626969755, 0.5115812895957794, -1.6169486764474112, -0.07011673913516321, 1.5356257253906318, -0.5278788624289622, -0.38260574004025516, -0.5988382994049233, -0.260814731624192, -0.16871683398866938, 0.3366248053322051, 1.8404608280956027, 0.20900571138509116, -0.10646157552244451, -0.5780958237182378},
    {-0.47514701868570813, -0.39538180874430967, -1.0831603875750382, 0.7892867403770398, -0.4971886582895531, 1.0014147882581934, 1.6372861886716827, 0.2782296281663892, 0.9567051093777883, 0.7285199227959187, 2.2004840269714205, 0.47941601740623424, -1.3720741776813083, 1.9924485404522079, 0.4675280072465448, 2.49372030467817, 1.5028693725667621, 0.9184301262161879, 1.7531247440424536, 0.7049105257293861, -0.4834957628735128, 1.0940358148146427, -1.8402402732352645, -0.7964016534516436, -0.3114014830849077, 0.11386238336443778, -1.5618748942758782, 2.265907759859631, 1.0490283263751015, -0.5551842270378715, 1.606181352222266, 0.294747536233016},
    {1.9911591231589385, 1.782723471857972, 0.2207787687680784, -0.17959426796685748, 0.8095657447664565, 1.656068575925521, 0.45736639157050557, 1.7155482417156032, 2.2620595066332405, -1.2617261606613903, -2.1894974913244494, 2.5996406058984673, 0.17121750715652762, 0.6321587336734609, 0.29384602742781635, -1.0034544112437056, 0.9098103623104777, 0.4191901921520072, 2.357284843267713, 1.9828655589743869, 1.6217160441896745, 2.4962807670702487, 0.8172836824281613, 1.6819406257386722, -0.03403590291520581, 0.034963231880296916, 1.6433440877764005, 0.8896649865365968, 1.3904063779831721, -0.5646561669573537, 1.1859811552232973, 0.4424585900264839},
    {-0.6827098733811756, 0.8002484503027677, -0.7907025215689016, 0.7019862292481212, 0.5300948661724315, 0.1336603226348431, 0.8001347633350511, 0.36541782800937145, 1.400524608541031, -1.6375054353371354, 0.0756694740323986, 1.3150962669714172, 2.5647329286993554, 1.1570900068282313, 0.21937049007049292, 1.5929680514756228, 0.928880678925057, -1.0654746399456272, 1.3072505278653124, 1.6621284997207277, 0.772376445021411, -0.2259244996184108, 0.45795827244026155, 1.5127951779120892, -2.6548076281611244, 0.6023689019981887, 1.3182943440871606, 2.32638377324826, 1.2495151062099639, -0.054491691379355424, 1.4296831516646533, 2.934087285225493},
    {1.114571116556413, -0.08092139683718162, -0.5367264159123251, 0.7898402382190922, -0.6577038617064387, -0.7119189342859943, -0.5274803009476341, 0.18404106123647873, 0.4757134010819968, -0.4912979560477151, 2.1099563307030262, -0.11539223902972431, 1.570903369655037, 1.4975596671811382, 0.3368188707457382, 0.12183938145760508, 1.2130264446230294, -0.23792250382091243, 1.6768246897284493, 0.891190761347602, -0.10545592978424387, 0.05890304268755414, 0.9844289124064546, 0.016529832846189366, 0.47348936232559885, 1.7182769119128511, -0.15918808842577856, 1.5604753612846045, -1.1742532073460932, 0.7801850680515412, 1.5350118511583208, 0.7591659110948075},
    {1.886564731958727, -0.06151194346489266, -0.4493621455249701, 0.9532273816352075, 1.2559981722572147, 2.407581354037885, 2.620906706182505, 2.6100909199918707, -0.7591318782886499, 0.6708899733202285, 0.6865052270326616, 0.19651536681426848, 1.4122341862762704, 0.44598730333900416, 1.226395380465165, 0.630286592379963, 2.59254694470922, 1.0710912785356153, -0.010541002093271305, -0.28211527374270545, 1.46268947007668, 0.19535364075813214, 0.2373575378758475, 2.264328894510368, -0.16255470745295272, 2.4203609081028272, 0.3915904130688939, 0.7856975059054075, -0.7495760033423788, 0.751841530679976, 1.6802444326923571, 1.972077778070526},
    {-0.1861194651171893, -0.39257234002669206, -1.3453008384999745, 0.9841788187260397, -0.7520370949997708, 3.5610236751547877, 3.3459229432722104, 1.0618702006077978, -0.09581189133222401, 0.8439708931025248, 1.0894829490901339, 0.08697308401172962, 1.0448893406117752, 2.957367429409793, 0.9637734519765795, 0.9397319072330059, -0.4740578779128873, 0.08997807721639249, 1.1178653854093497, -0.607426007967303, 1.4965720959935902, 3.480734667170024, -0.12046366148409889, -1.2791818479380421, -1.0601053850842654, 1.8659959237124473, 2.175891643820706, -0.31297065742492214, -0.7140518436056245, 0.12527111889660045, 1.6747111541844735, 1.0033805767778547},
    {0.12348129037501905, 1.7821580615365198, 0.06905913593852013, 2.6241483170679634, -0.19380050342081473, -0.9715940543016482, -0.7595900411910355, -0.03542056797762782, 0.8363215699815609, 0.41654509430994996, -0.14296420212596336, 2.200869407422404, 1.8380333908524054, 0.3455569434685716, -0.34992784512150454, 1.4375600051461475, -0.4311400410079456, 1.7603279262254015, 0.6099899040816461, 1.800158693274981, 0.6523592479057942, 0.8545357250635123, -0.7396376417659877, -0.8268845763653923, -0.5546930759620127, 0.4772821600111576, 2.0446274256516577, 0.5586781578068969, 0.8313142291847775, 0.2613419142631056, 0.15162775558184788, 1.222112822130903},
    {1.4095060954937333, 0.7568272714765759, -0.3266484476487836, 0.4973336980008903, 0.041635108091966834, -0.341717714700824, 1.8235778546112853, -0.673493808008618, 0.570862170437003, -0.7429537065462707, 0.4272317045146369, 1.1588324487901251, 1.356440949063196, -0.19892782371199932, 0.02671885481203724, 1.2910163000066446, 1.319789423857202, 0.6175216862118854, 0.09386041521089557, 0.025680234121584055, -0.04195440435976616, 1.236114045553833, 0.58919694966866, 1.772744056158035, 0.7152348197606179, 0.26340736601822656, -0.8937983914868299, 1.405810202748826, 1.0414332583772432, 0.0265162628909473, 2.68560606068776, 0.1591114737205629},
    {1.8824982774322654, 0.8264945044869549, -1.1602916690234333, 2.9131981774626907, 0.1058700612288864, 1.4927770776569627, -0.2564385306534065, 2.8588835877803396, -0.21526003782181613, 0.6671129414492072, 0.940196939854568, 0.7819826472383113, -0.2634660798459275, 1.1311721908221513, 0.5366290732671233, 1.2698964376633, -0.08878886282675516, 0.7927487968814205, 0.22652831272512552, -0.8507654596730477, 1.5689608782647273, 0.5962994013119755, 0.2910183912619906, 1.0968920756791507, -0.8068805274923974, 0.5587600830547774, -2.0265605626696956, -1.6548403828694114, 1.4141852397088643, -0.2199309608693202, 1.5333422731026396, 2.0739576619840094},
    {2.7041908410235833, -0.29539049070269413, -0.6453990554773937, 0.2238262190061015, -0.016890660165491237, 1.706482123692367, 2.246027122719329, 0.4139472934249381, 0.14255622621344538, -1.0804110315465145, 1.1816456678697809, 2.69447552720021, 0.9515426202441941, -0.15511562351828254, -1.5137201958181112, 1.4126097527970571, 2.3897712413417995, 1.921957600748366, 0.09801128877960552, 0.17051356478764834, 0.34415452762558046, 0.9702045699602206, -0.15316603087891834, -0.035232457702603234, 0.9070947896880039, 1.0732014245662886, -0.35103883226648996, 2.5708503356625867, -0.7913262777031533, 2.058874646256545, 2.1417409652595434, 1.6690373846527136},
    {0.413145634266983, 0.6591855013432011, -1.2540034533942352, 2.2394644614596078, -0.5002379438364105, 2.473722936011997, 1.5322832252801277, 0.19304837121851862, 0.8094993377522314, -0.40853410785409866, 2.7618191485939607, 0.5675844572755961, 1.8863953151438602, 1.4302271518597005, 1.2729071685158415, 0.7001993476870859, 2.2081914175159767, 2.949293981452176, 2.2027527220576326, 1.525777029896759, 0.23145462902263475, 0.42709540141946634, 1.2150989540027513, 0.16094592383859493, -1.234948440458302, 1.0049405455300717, -0.7561379955925478, 2.595826508947278, 1.2523424034635522, 0.3753329230180962, 0.3637798937109198, 1.637703363602637},
    {1.7105068628345146, 1.166825488291861, -0.19258760807096426, 0.7750568555748039, 0.5784268177406033, 1.5545008688365147, 0.849348817013683, 1.1889425959472408, 0.00452403707943167, 0.0653811642255295, 2.178184351937583, 1.4314267242014502, 0.3720001231367527, 0.5569754622642085, 0.549953244971803, -0.7660788834180545, 2.7329045600750823, 0.16222638151924937, 1.0881505452424898, -0.9714592225730831, 2.7833187116746094, 1.3210188889672152, -0.7819723354329507, 0.41112524326555266, 0.2030713975705338, 1.4169140270053375, 1.5067198830039863, 1.3653487072570274, -0.24351298578787947, 1.9443621010150676, 2.465033902414113, -0.017119828068987916},
    {-0.3616567649864051, 3.181809333083066, 0.07717582046162318, 2.765060611385352, -0.5588790271781255, 0.7695303845901523, 4.214540900878595, 0.5904265895160657, 0.15494256726037345, 0.7231418876526267, 1.2494200284865005, 1.8749300564052789, 1.2356632887957153, -0.006382302617709535, 0.6313678704781784, -0.0079045486203065, 2.859968473836654, 0.47453530740543354, 1.9224845918355096, 0.5137957686182703, -0.15944259447403272, 2.984105049694712, 0.11553564638019709, 1.1849001013080647, 0.7512898113390588, 1.920151382464378, -0.4806761731467138, 0.9663750315793124, 0.8104935980163535, 0.06540639628141089, 2.93289406742397, 1.06471258280007},
    {0.4698774861596364, 0.4244941800471285, 0.2086854443540576, 1.91805010743507, -1.2852838690013015, 1.5578441298531174, 0.48192553406282185, 2.1864731097451595, 1.5025829637414838, -1.320232809257593, 2.1016100184052884, 2.1540595699249434, 1.1628704350094925, 0.604232760157222, 1.290440802971439, -0.6625072366328859, -0.12632579502145436, 1.9552207906811272, 1.9629948978485243, -0.8725594119669229, 0.5334623002249503, -0.19380437921308472, 1.1835428873412297, 0.38158513489294926, 1.6177310348062917, 1.461981302666418, -0.4274532294031964, 2.455019888871005, -1.872140888311374, -0.03295802105861129, 1.693134507919562, 0.5089645564471162},
    {0.30517020999105154, 1.2883997481184486, -1.0059246267964628, 3.4131312829908342, 0.023827762745650644, 1.4225913842469557, 1.7427351149805483, 1.619575406890631, 0.8102852291584527, -1.0162185008999682, 1.898329613285507, 0.9268451666351734, 1.5370732591032223, 1.199988886984494, 1.6687319840575447, 2.9865748355139576, 1.0579559628973907, 0.060523710765717574, 1.409767773797426, 0.6136055246986373, 0.7366839494225388, 1.7388463998219574, -0.3903137649514638, -1.0531865952409594, -0.49711036487189564, -0.1649381296729714, -1.0717604901734767, 0.9141655399225996, 0.6931153301969909, -0.3878728006592612, 1.0576823934536868, 0.29591419104070005},
    {-1.1032142781685066, 0.21559322609680245, 0.18614659578981924, 0.09458930485906578, 0.5589602772060197, 1.2502343489360077, 0.76742877781804, 2.4058450026049556, 0.9190983430349382, -1.0537157835599544, -0.10496178873965961, 0.41039454112850204, -1.125883065142027, -2.27879682334012, 1.6226878373721085, 1.0945941003456967, 0.17799469361055728, -0.4119836192679417, 2.0697470854629056, 1.8825353359791495, -0.34659737667769225, -0.5252635727697176, -0.84379430717417, -0.5070575144594953, 2.0946369352170238, 0.3236551065766924, 0.9091559756320123, 2.3336353771055496, 0.6885567121178204, 1.4582235977004459, 0.4190234631671484, 0.23174739266375594},
    {1.3389206004882361, 1.715061836454586, -0.9469615415568273, 0.8950933506815, -0.14912319221857523, 1.9960704284237063, 1.4399933902083777, 1.3930310402178558, 0.026374549488393784, -2.3805904587900213, -0.039958720528608625, 2.8776568444957835, 0.9157060897103041, -1.120361708535337, 1.6468296964239506, 1.5851515617354663, 0.31385489490126706, -0.5703969801178028, 1.5659786754236533, -0.5565990015425856, 1.4007764256508697, 1.4475223396786072, -0.45114931153598864, -0.5858616186274748, -0.3946397195100393, 1.310406648472931, -0.584431896137688, 0.10817194298718609, -1.294299760050273, 0.25111493093034915, 1.2902270383776246, 2.665960410084006},
    {0.5406205144077385, -0.2691913740498416, -0.07046079961009528, 0.776570101435521, 0.45406351032026465, 0.25585626630743435, 0.9419085915848044, 0.12731807503965675, -0.3425475182233399, 0.05154222661488457, 1.0497510237834258, 1.9350802878486697, 1.8639153211256367, 1.2088912359526016, 2.226852460504413, 0.8632538636442855, 1.999126135728749, 1.552224312728887, 0.0070420807855322365, -0.25280905986109337, 0.646393980238866, 0.47295194742364766, -0.10258214689355338, 0.04979565385829976, -0.05750775244241197, 0.05490527672032767, -0.3750149181927606, 1.4225758352915228, -2.47905992636762, 1.9153147350849757, 2.35541902930424, 0.7948217672039758},
    {1.742887646405119, 1.617062347410193, 0.6601827818802383, 2.0862704743300395, 1.2704202300749683, 0.8420800752494263, 0.9758235745147248, -0.7478931325139931, -1.7687751991224037, 0.6050159447708109, 0.36290446547389626, 0.08500808744547476, 1.8401789780912396, 0.6926520838199103, 0.055405546401426024, 0.5720255582605566, 1.4295190597047789, -0.8609216532617969, -0.3698278618152734, 1.6237352783966426, 1.0216023035979378, 2.247134386440907, 0.8217571173632673, -0.11036292621579782, 1.650304357916776, 1.0530837442109404, 1.0205293570080765, -0.18274974501299984, 1.6508806854509843, 1.3662352836611502, 0.6870048238809293, 1.930254461960166},
    {0.34524841939542655, 2.7395227968853697, -0.6055814870524858, 0.5203071433919749, 0.27932228596651376, 1.0374532446778089, 2.3242687516286624, -1.4694043808331367, 0.4677112610594071, 1.709408929469225, 1.3898956775841556, 2.06277605897669, 0.3781413768728842, 0.3663463392337611, 2.5982758169656783, 0.8582538421008999, 0.826677237720131, -0.472200328134822, -0.3498671840434913, 0.8740905063543261, -2.225043231586608, 2.7394958924655626, -0.7470243474722422, 0.9113111019019768, 1.113250182528176, 0.3610794650168702, -0.31482651671235123, 0.9439142868835292, 0.4365407692454403, -0.7244015986959185, 1.5463752199879892, -0.35129220067546457},
    {1.2223337389060591, -1.7109337385873227, -1.1670688563260754, 2.3621451520764514, 1.4592630703160976, -1.2953019578530067, 1.9457929970728787, 0.09753715096275037, 1.731452045277351, -0.8664779880227866, 0.011044785085714277, 1.0278814566014438, 0.011888459019184965, 1.4868554126758706, 1.7623740698931234, 0.19404757928736435, 1.9280245587694997, 2.1878131173309296, -0.29438209553518774, 0.2496090553889612, 3.1998126836073695, 0.6559725583617061, 1.2401674334050155, 0.1314546259165629, -0.5554261869569505, 1.5315778102246618, 0.35979587496900006, 1.0352139147122827, -0.5466359723438388, -0.1719886770549807, 1.5149443930154172, 2.605716586611014},
    {0.25759985943620195, 2.632312782848896, -0.6418983667762866, 0.29434136899800056, 2.423444841746684, 0.8668078410029559, 1.6923420138375118, 1.8146212984973993, -0.8976871329612305, 0.2654765933491356, -0.12382208972937865, 1.2231278309034097, 1.5678190955546636, -0.1262301442439119, 0.7883482878668668, -0.42956481712706673, 0.5404387531587486, 0.9228393296786627, 0.7652555527171045, -0.01576992463553062, -0.13111703498283842, 1.823019013270595, 0.9415184181290448, 0.6917366850946541, -1.6999100237127005, -0.06489487190895608, 1.0132366573763671, 0.28056096941878683, 0.6936764653206898, 0.49502933262118665, 1.336946447106867, 1.8658913890663937},
    {2.68642017236419, 0.7732865276693524, -0.4077372801082787, -0.23713795953146807, -0.06552116308191908, 1.3774234694258638, 0.720854173288787, 0.17461318891963185, 0.8532274846116992, 0.17394524029949018, 0.44730134958344453, -1.2380481833839185, -1.1137643962210708, 0.6427761111406692, 2.559465147186778, 3.1287721540040336, 0.5179916433407601, 0.20282175427731636, -0.032927736508656685, 0.5809388204216406, 0.48002124422047404, 1.5344634829075918, -1.4910946844856907, -0.7721954981479259, 0.6469918721734833, 2.3604124466467504, -0.09776107465972873, 0.7039348503908356, -1.4037199415889798, 1.4805090411369806, 1.7400943821582346, 1.3616580970609509},
    {0.21784806119296465, 0.19296394648470933, -0.7218843058607775, 1.7155860283811517, 0.13387372599623137, 1.2706728276077341, 0.5495290851364457, -0.13263256758898137, 1.7701262038673649, 1.8532108460917323, 0.23011593225796131, 1.4044030463057673, 0.11761471144762148, 0.3018706325899323, -0.26680255142364373, 0.09815312289995012, 2.078170999523204, 0.3246039185494155, 1.60714324418637, 0.8961304308890892, 0.18748342084479608, -0.2773575515280407, -0.849601363653541, 0.9455727389687777, 1.4535766410136108, 1.7438531126224617, -1.2821419316831466, 0.9714071770858007, 0.8320059154490791, 1.1942065548961935, 1.997742930811215, 1.6539089351893528},
    {1.5335762695443442, 2.445556917768833, -1.7686831170079382, 1.473010450282576, 0.7823071794897624, 0.36905484064197003, 0.4141899069498621, 0.7334146406547998, -0.11480087740040698, 0.5124384394289755, -0.6021581415291338, 1.5946147646545772, -0.3617913293042737, 0.6610050980522065, -0.4513416364407075, 2.9974048315538586, 0.9832916613280799, -0.1665640418850708, 2.783808931935141, -0.8033432096850026, 2.1044336284677585, 1.6341951907181513, 0.2503472596017022, -1.2200193141933426, -0.4359701727599876, 2.199632125980866, 0.2442636622482287, 1.318881947517463, 1.37385531032482, -0.8886185517391844, 2.3039030517362744, 0.49925328156693155},
    {0.49429325255213663, 0.02203274429243526, 1.2492518678394844, 2.8514011135187154, 1.4493752795407884, 3.2657140187064972, 2.2564359875113946, 0.905055454602828, -0.34022420542337456, -1.5177966379766383, 1.673002378862715, 0.6109569356862812, -0.7993071943677751, 1.4310639155791316, 0.7896309254655043, -0.2140995938367717, 1.0913485139297283, -0.32970858721752205, 1.5769480670831235, -1.3526471050633784, -1.125283513252568, 1.380405694616766, 0.7500514633821066, 1.2753463042825302, -0.5194908965246215, 1.7060182751190582, -0.5964164880051386, 1.1383190747160197, 1.2512327165435342, 1.2081116094510045, 2.3230535843822904, 2.4655689485302976},
    {-1.3890737634869255, 1.2408653630734483, 1.1842788919249045, 3.7731651484763007, -1.0055236319779488, 2.6034763024166305, 3.439807279398168, 1.2369264407947875, 0.016023842084370542, -1.23426294576977, 0.6396837356940921, -0.5516962339260781, 1.3966132719801831, 1.8168167481374216, 0.15977693463498382, 0.8053768681144651, 1.7784108238302414, 1.779735502259714, 1.563233696622517, -1.0923564165053334, -0.6616478027232678, -1.1133790106732628, 1.946864443980935, 1.8100799496819653, -0.0357838263701941, -0.9001394486933126, -0.4919592529982708, 1.1098805955290074, -0.08899602036561606, 0.500317334207468, 1.2731906129508923, 0.4540656887789896},
    {-0.5553484243560464, 0.5902411856782701, -0.7956853992822434, 0.3128115789844046, 0.1406607619402305, 0.5541731643017666, 0.9094317384306134, 0.08147530117420217, -1.3231938388102702, 1.27662255639875, -0.35235379547460305, 0.14237703279391078, 0.6613805142998668, -1.5152984804221052, 1.2587771256525142, 0.018659258111431747, 1.0717212090702575, 1.918436932969827, -0.15910802126686988, -0.24781379827077865, -0.4635192381530764, 0.02683471781766632, -0.1614938009984572, -0.5658454894658701, -0.32157967372769053, -0.4837193098268521, 0.3802976842198405, 1.2049517719609582, 1.4219214969588516, -0.10811323757349328, -0.9485265743445757, 0.12736416435956327},
    {-0.9312303677552876, 4.008765193768926, -1.5872406017526963, 1.3742910421644128, 0.3630969340197146, 2.3169887493580004, 0.7809455749552959, -0.47242322667275055, 0.7379639050609544, -1.6261217671341237, 0.470040170932506, 0.21673029288623813, 0.47620604350882495, 0.7305570257307916, 0.49608071671574866, -0.16879213133837784, 2.217478966838386, 1.4880618540138877, 1.887366295161363, -1.4660510758545025, 1.1166231009785472, 2.045032388167769, 0.6136652396719716, 0.5070680669681275, -0.9933732224261819, 1.2698893838349974, 0.8970923059824514, 2.3916482116927553, -0.18390537725256167, 0.8155426902941019, 1.6984014672148637, -0.28767250294817204},
    {1.1193027388906813, 2.567911157360412, 0.5962435218170641, 1.1675517983782748, 1.017087897200352, 3.5753106434055413, -0.2534511379391597, -0.08845663632155559, 1.5480124387462306, -0.09970244358730931, 0.3800499172708944, 1.492153504854631, -0.13571554316669163, 0.5683246855943078, 0.8343747617280755, 1.9221418746323875, 1.2328124211231923, -1.226869313122264, 2.67925623622552, -1.3748821253594747, -0.6841840225878999, 0.8134045463684876, 0.2066552143913564, -0.7041203191485071, -1.6450805283960583, 1.3144672683732355, -0.6932473562955802, 0.39375796165642607, -1.5103525461771905, 1.5280183753881411, 3.297528748087787, -0.2283002508711788}
};

static const float b2[32] = {1.4805390500172029, 1.6164100369534637, -0.15323487576875314, 1.6625493901696973, 0.31825504916246666, 1.7930780859650077, 2.2106190287640897, 1.0186439437301902, 0.6488544317388991, -0.11423046800841215, 1.6694554069749714, 1.4860907342033924, 1.6939694263077667, 1.2314598664686627, 0.8786040621948299, 1.4508286517920217, 1.4483715459400262, 0.9496259803318016, 2.0785854703065274, 0.12291885345623704, 1.2444824568455253, 1.620166969875839, -0.44195516865990686, 0.1812454031542834, -0.6454787807866452, 1.3446492127186085, 0.1802048061660926, 1.8178489292709479, 0.3647033485352668, 0.6838886470612229, 1.8851959087070174, 1.9006616501519842};

static const float w3[32][16] = {
    {3.159928036154251, 1.5807419798592262, 0.900082687069991, 0.42009266888851554, 2.365122866501699, 1.477183561723749, -1.095827427564223, 0.29592342739158634, 1.4277308060679725, 0.9381663929367039, 2.1077351411178897, 0.5202290215024168, -0.15771771641654028, 1.0437257014921153, 2.356823840140977, -3.101612567501494},
    {2.2604054921521333, 1.335354399797555, -0.4735128932319003, 2.8103399078046984, 1.387772325961158, -0.29115465496205184, -0.4910938746006593, 0.5285382780923703, 0.07049230655839205, 1.353534397416197, -0.7643512832702187, 0.3419251281665412, -0.23038304871627754, 3.594269808847652, 2.266593866968723, -0.8137835493665302},
    {0.04917187557482243, 2.6256629070689956, 0.3508021688905339, 1.9925385774339546, -1.0840707473873883, 1.635714929348637, 0.4924011213848665, 0.4025052044356957, -1.1561142397372361, 0.6314407521443158, -0.3700730943845702, -0.07214173628186404, 0.048124883127278265, -0.5516036920655804, -0.2763799703181911, 2.128957136844881},
    {1.2082323764135374, 1.8397167724384265, -0.509590565659954, 2.0749304707586025, 2.8406889964173456, 1.9740960667437373, 2.0228127227949644, -0.9453734351324513, 1.2920073348144216, 3.3649231996058417, 2.427066056545293, 1.0519797842790548, 0.2191787556984516, 1.3963304219585835, 1.3540969236088911, -0.013226610074744053},
    {1.3950514819461393, 2.3027762324211, -1.9355974652612078, 1.2820012728647252, 1.0863119221181874, 0.5458515311667241, 0.3458504380708079, 0.6399088358623781, 0.7917101767694728, 1.0299338704216783, 1.7004535812832704, 0.9899515814023894, 1.9600540296496534, 0.0043237987849866705, -1.7503438192065628, -0.7301971927264267},
    {1.9186266643867234, 1.28147425823724, -0.39396582074908887, -0.17943098914980643, 1.974753059021674, 0.3498812011895387, 0.2534315326987881, 0.5115713271232655, 1.226454866895243, 1.915260406843302, 2.2728370912477636, -1.120142144952338, 0.622288352295805, 2.2730531439673776, 3.1261222773320667, -0.1732378690481017},
    {2.7924879697471012, 4.854121548542995, -0.565065496858628, 2.7876064274269807, 2.81872087967923, 0.25637350726762076, -0.9611520152710894, 0.597887092890195, 1.4648479613881116, 2.021999302232636, 0.7226688708201455, 2.302327862610477, -1.0659806378302272, 0.8905214391994214, 2.2708876843864263, 0.29245951070313886},
    {1.3782813592121528, 2.0231124147155115, -0.8692837893525703, -0.10964080700573378, 2.153057403971316, 0.35886214496592106, -0.22820690162808685, 0.37051975958447786, -0.30689217280405406, 3.1673970219678114, 0.9798072265868737, -0.29789639783340094, 0.7823835125124433, 2.2134656683355223, -0.03492703005669159, -0.9254306592039113},
    {0.6618569193604436, -0.554430398526639, 0.6657388239755987, 0.9244112401361015, 2.247005298533089, 3.4199438374513007, -1.1335960880730853, -0.18748072532780719, -0.4058204305804107, 2.0139993575179926, 1.0459925943465864, 0.969203657207977, 1.3446102584406046, 0.8014901564742616, -0.012503942602536185, -1.8105603593787025},
    {0.10652475031763542, -1.1853651202894044, 1.3833783131889386, 0.44755882989341655, 0.05355914584772232, 0.39699988518123985, -1.7993136205761437, -2.344373451931148, -1.2906247995568234, 0.8643578803482139, -0.15108997954558245, -0.28676401899392323, 0.256555562469562, 0.9177568233373904, 0.16685215273723167, 0.3084581559370129},
    {0.8326078195853356, 3.2930133742312133, -1.0836783100636502, 0.7118505995629941, 1.5720381625816133, 0.9605656623460008, -0.639345361251748, 1.3097264597345573, 0.8536510939431137, 1.4779668391191179, 0.8481096666938572, 0.823831274464885, 1.497613394435924, -0.09223065759246879, 3.3962829826257517, -0.1466724956033097},
    {0.9156213754374731, 1.447127545992455, 1.888257792172403, 0.35372882533051586, 0.5636289240891275, 0.6678178038596052, 1.0895678563572062, -0.41056756345364565, 2.0213810668568404, 3.529094220773508, 2.549500270597255, -0.002579441222547316, 1.7812068712188598, -0.49008134770326756, 3.0351807353968803, -1.6211528556828327},
    {1.2997474243530678, 2.1123248577358447, -0.22135257683164877, -0.4094683281432671, 1.7095278833637098, 0.3141584695431471, -1.0755225732171474, 0.039534173763635744, 1.3598542727880063, 3.972720067092375, 2.028411705939676, -1.3309557851912974, 0.951111991539499, 0.5333548557918876, 2.52808050216023, -0.8505762079158241},
    {2.3668885641219974, 1.8235256135343931, 0.07940924832811276, 0.8142792474521982, 1.254211408796351, 0.02711732452046329, 0.6705061587760065, 0.7014983628845258, 0.25127706558620655, 3.2769332366102044, 3.2053095171921027, 1.9870897919130626, 0.800918112214552, 0.5713038989335457, 0.6428035003219633, -1.1191555089361345},
    {1.0125202397745088, -0.5075093265624112, 0.4592885547071818, 2.3752368418861494, 0.85418381403801, -1.0452083807872627, -0.11359448745916403, 0.10104645679941807, 3.435215152239608, 2.4076813491489575, 0.07930385798277306, 0.06369860088230749, 0.34608595659025704, 0.33735963573214506, 1.399750051759301, -0.016517468659177702},
    {3.2249207746230595, 2.831302315064197, 0.7393051205348357, 1.257431324984116, -0.02275398431444034, 1.6105122097761626, -1.2441600880733124, -0.5975660565563948, -0.11278579890770388, 2.3244367966652186, 2.6649242527586177, 1.5256616818565678, 0.3861027148696459, 2.437950183107095, 0.5900052055565081, 0.18313172911941686},
    {1.1735874264281894, 2.0710038871010767, -0.3443197541136724, 2.0339844870458292, 1.6919030038743372, 0.34033762427831477, -1.157226202493159, -0.5975040670188617, -0.10345913542615469, 3.0570601841936633, 3.347800718007618, 0.2850919291015647, -0.10341563411780681, -0.4013432076086911, 2.7954060730361387, 0.05936975857895351},
    {1.169653613938794, -0.5033955068081823, 0.681894634499653, 0.5934145346703793, 3.0071077712902143, 0.5418222284745507, -0.5466419747959681, 0.5580148377908114, 1.93236740285553, 1.928018653738096, 1.1129097010051563, 0.1963796321245351, 0.40415507856391614, 1.6843089193019172, -0.1270936515031464, 2.207562102265831},
    {0.18938255061363848, 1.7326314078591023, -0.4579477191417015, 1.7760670461535146, 3.0879164187768713, 0.8668107454149375, 0.25569796667430106, -0.42160438722503774, 1.6378183061620553, 3.6863370020940174, 1.7743822768604058, 0.485689045986117, 0.3182698807835169, 1.5703335931070095, 3.7401574159326287, 1.468443378589695},
    {0.2722848404046533, 0.025385263134789605, -0.9612327559988748, 1.254217885727128, -0.35022887792990504, 1.035872047046808, -0.7354973679747915, -0.14021360478079276, 1.145087051737256, 0.08919628067215732, 1.0666920375946427, -0.0884037284471866, 1.4191800580340872, 0.24524699609929673, 0.4127306714037861, 0.8375923711081708},
    {-0.1903322754375262, 0.8773131728363895, -1.0971247260866293, 2.016899223192069, 1.8815693159165012, 0.8445263445412436, 0.8231526654865173, -0.280457075932713, 1.4444241240128888, 2.114482444177933, -0.6163761509202955, -0.023286264276581484, -0.8285751093914183, 2.1472494271216984, 1.4166556592148214, 0.08985422765288321},
    {1.2026302553390298, 1.6289127824595675, 0.5995590026807495, 1.3215261513935743, 2.372634609540361, -1.7124686830035325, -1.4310753218559862, -0.1177916179064735, 0.2640840728404512, 0.666329981670843, 2.8034580084828935, 0.9443235973656612, -0.3586788408515693, 0.39082287561298895, 2.664296722255049, 0.5377000371444257},
    {-0.04500514538675878, -0.8359135507315076, 1.721037057026221, -1.2183167027616102, 0.5731990337553462, -0.03935595718110354, -2.2032539592020277, -0.42007794801007986, 0.16697246876583685, 0.8767846653192033, 1.7986931803564166, 0.20068098500443843, -0.10811775602698498, -1.5574937164975977, -1.2952418766381648, 1.1979232550326357},
    {1.332053640356005, 0.1339845323623671, 0.2796791570005291, 0.1945805650837567, -0.15525657373137736, 0.3310862191808213, -1.2632893209274212, -0.6211711308653344, 1.6809521721464433, 1.2613278036808409, 0.38813298228769616, -0.2164996165320391, 0.24491606662820944, -1.0056273245155527, 0.18179555455449609, 2.2114412940746515},
    {0.7820556718230541, 0.1745065684049048, 0.3873058382393353, -0.8555821610171017, -1.2858681559818126, -1.2966860752740001, -0.9201884266975351, -0.35369738652535837, -1.9445755749758957, -0.3108225549637711, 0.8286348302729281, -1.6649934497036363, -0.9232587870627517, 0.9361204578376828, -0.905657420246754, 1.0508329237526783},
    {0.8746435584021538, 1.6433332155975786, 0.8946724002355164, 2.4676790721365554, 1.6991495249697617, -0.40310445042670495, -0.41081257124234183, -0.25050772158213575, -1.4286842607893266, 1.901651757289281, 0.07939189809223902, 2.3858068268353745, 0.28910016404802913, 1.4135008819307637, 2.688948324748736, -0.48585701025301486},
    {0.6536626192003708, 2.0181183582276314, -0.4457429067879834, -2.0761275154183134, 1.9956369974230583, -0.9147350400332863, -0.28148556618070486, -0.9016788057126917, 1.0140002384270772, -0.49675900417309093, -1.401675092661856, 1.7244286214339646, -0.18356024818356995, 0.40581954199510195, -0.06422309914527373, 0.007716940421736804},
    {3.757389037338964, 1.9758889641864092, -1.4019440726375239, 1.5847458634587892, 1.7066215206656599, -1.1532023745490676, 1.1816722618668325, -0.9303002044539525, 1.2030366816139706, 0.8255606494075253, 0.565359427835955, 1.8507466758038555, -0.02423486983353071, 3.6915489251253377, 2.7346422473630376, -2.259157765004558},
    {0.5051095870451916, 2.2535379945413405, -2.2159096005608467, -1.8727333978921432, 2.642330892132542, 0.8402811321737549, 0.44526360561104245, -1.0048736796049604, 1.0477937898352576, -0.4297182427022324, -1.0572624289023433, -0.42192438258171727, 1.6577394982197078, 0.03008453335663345, 1.6547690787309475, 0.30820997076885237},
    {1.4789798671388845, 0.9815568144630177, 1.563493907967414, 1.0832339394768593, 0.672912588363247, 0.8291836258822369, 0.41546870901791133, 1.1687292924252823, 2.783699714416719, -0.6020896016805823, 1.8122443711406666, 1.0518265903480912, 1.4476681108415612, 1.1127194728630678, 0.7110234434114341, -0.3432027790451453},
    {1.7970137646316937, 2.9998190094267074, -0.8601852465830465, 2.4538976575578055, 2.691401529094901, 1.34927687034855, -1.0019899663397454, -0.5047347371656884, 0.5743970544506757, 1.8694978489873386, 1.485173692953435, 2.11245167380181, 0.02571590339002736, 1.628061516327902, 2.1854867870165524, 0.48578537705909325},
    {1.601100218456479, -0.08647736597213733, -1.2304771532933267, 1.1019823929483568, 2.175991417165761, 0.19083850395406518, 1.1094365907744517, -0.7158481222969426, 1.0378861006269915, 1.7052411571197739, 0.8257592657465495, 0.6527688516475163, -0.8187181715422845, 0.6006032878250042, 4.27159257229878, 0.12676510797147525}
};

static const float b3[16] = {0.8847896564676765, 1.3889498731004775, 0.01759765422236411, 0.6260716792039902, 1.223637567866767, 0.13407999175051344, -0.1421046285590892, -0.06062186646640543, 0.5930675761434553, 1.660945024309622, 0.801659696805028, 0.6810861388970785, -0.21294950655093292, 0.9465243377441643, 1.7893133437123963, -0.14730947433992578};

static const float w4[16][12] = {
    {-1.3967294653293778, -0.5268126979758367, -2.219632165076312, -0.7583214024295363, -1.2713316408152548, -0.43100590909124564, -0.49805735559944747, -0.37493654783813646, -0.7946098313301077, -1.584957319133302, -3.2597817053098526, 0.0031271472720635135},
    {-1.1816876739423121, -2.3815143408689665, -2.010464408364257, -1.662112342344532, -1.6907592324507301, -0.6672262402045073, -1.140175848050831, -0.49627976443132366, -1.4030995279963545, -0.7762000925532043, -0.24377538721811035, -1.4007851784596241},
    {-0.1224103636524498, -0.28811152662345474, 1.2300312439638497, -0.13787584702097755, -0.43363240145876003, -0.9924950698943629, 0.8661946196451701, -1.8805429123968618, -0.6169805228434052, -0.7064337572676956, 1.5732515508666007, -1.1244145265879426},
    {-0.4196313924387796, -1.9174579633727622, -1.7062927104832246, -1.2035126330333656, 0.6517762767635727, -2.590149880067608, -2.1288087518197116, -1.1171774728933208, 0.33818637631430026, -0.4861838102004434, -0.8683918864080422, -1.2212978005377049},
    {-2.6731929216190102, -1.0815910721069824, -2.160313056381332, 0.13889867636342879, -1.6426225523304505, -0.35853868036090436, -1.1872005356166688, -2.3480416841684373, -1.4689010634485038, -1.748008482996367, -1.7807017433593064, -2.681695789055342},
    {0.6995467713119348, -2.2027645168939975, -1.2203940173240087, -2.4316394026140866, -0.49455772740131904, -0.09152245249674121, -0.2489483922300782, -0.5786270893100344, -0.3511441754177365, -0.3009215894953607, -1.9027542927284515, 0.9377519431048132},
    {-0.600746039361423, -0.4738549586253881, -0.5327897669641227, 1.1254443971487138, 0.7321786609516779, 0.8096717167214761, 0.46084979920493746, -0.23425934657168201, 0.8442011462045825, -2.007078881822653, -1.8806155026862508, -1.3682338243017242},
    {0.12826084530992832, -0.6014776661247984, 0.6221612084322519, 0.8394598077702349, -0.685913033758449, -0.1722023937526593, -1.0825755076793693, 0.3926136166476293, 0.0179987089677691, 1.3586867195090069, 0.3993820290134287, -1.181223164273758},
    {-0.2688146756989861, -0.19319509820108213, 0.5149665842658547, -3.1814917051002642, -1.5281704177823707, -2.0216883070810896, -1.0950432274437505, -0.5037472896731776, -1.7166371690010753, -1.8256652716181616, 1.2321538084170653, 0.5151432240953512},
    {-0.6453242085717937, -1.0156959372496268, 0.22375141775778626, -0.8025273875013588, -1.4444462227023191, -0.9581715840549317, -1.5010287511484142, -0.9740894408467485, -0.882875592360413, -0.5148627433914709, -1.809667167650178, -1.1318164045711359},
    {-1.6846968340625115, -1.4443414349980794, -0.3368444490729454, -1.1777951534353528, 0.28538350400687584, -2.472701964412477, -0.8878050597239642, -3.1347828404685116, 0.4518940218380655, -0.23480457894385187, -0.837457496093773, -2.197585636840906},
    {-1.4321136841507545, -0.1021299468151303, -0.23296630365910445, -1.700771587104926, -0.705476458659965, -2.521013386569591, -1.6951478718764135, -0.5560560922664961, 0.37457667616708373, -1.3833572241489767, -0.15366598578085872, -0.4262492608219031},
    {-1.3358509590076728, -0.21100565780747466, -1.9228302857586506, 0.7184176650763209, -0.9326394333040394, 1.460746736139482, 0.2634199472446988, -0.4859970601162052, -0.5053389513856129, -0.9087551731091162, -0.17683205550818923, -0.597111869230684},
    {-1.3606583353845487, -0.5933593254840333, -1.2110938136320253, -1.3260338875325681, -2.3354538995480976, -0.7704442226517692, -2.295638217478408, -0.5474254670215409, -2.039406270158651, -1.6912147126303634, 1.416584134727267, -1.647286532883912},
    {-0.9740539603703351, -1.0645726954967918, -1.3874913816288965, -1.4038332493118288, -1.6446406926513188, -1.1863018427693859, -0.6202922889310803, -1.3575072999537783, -3.4342856707959335, -2.014096010271135, -2.467723782922657, -1.0711243012262388},
    {-1.0648288197169404, 0.4592008679862889, -0.4186120931093803, -0.07324218754000406, -0.22832089896563248, -0.4226943323217044, -0.3720543289469539, 0.33015466467636817, -0.5066783593065791, -0.8502176914453321, 1.3833420831136223, 1.5156112179487025}
};

static const float b4[12] = {-0.49113159741507284, -0.6848252048349535, -0.5772118077166839, -0.8079304913585961, -0.9180626470285237, -0.9885762623337373, -0.5385432533476576, -0.7058032605426782, -0.6562513258758231, -0.6699306054059703, -0.8892612652197586, -0.801660464863165};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
