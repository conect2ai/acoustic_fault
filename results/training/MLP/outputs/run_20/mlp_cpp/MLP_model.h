#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.11131551105674702, -3.003486482476017, -1.30748847783697, -1.4493811381077628, -1.151251946456542, -3.6541850777451907, -1.3345805784071287, -4.169708386369054, -1.6850002489360514, -2.9248094814268875, -1.0664747191615367, 1.1705530947202, -1.2255021869714593, -1.1964661918613742, -0.5748491129767234, -3.211613160453733, -1.5784734173180628, -3.8952154844690035, -4.184564342979138, 0.23056781396622741, 0.5033597915547111, -1.5234901982688942, 1.6009882700649904, -3.1812173926088825, -2.3876179513758387, -0.6071331661320818, -0.9598416885004875, 0.9098166670638128, 1.0887219118860325, -1.601790645948458, -1.9475506916974645, -3.3100360652024325},
    {1.0500080874886353, 3.047855881369159, -0.37889543127144565, 0.0077211314793736874, -0.2203642232235776, -0.9152346163989381, 1.2327134355954705, -0.06217213827979167, -0.15669828187255824, 0.8187304011863314, -2.2564539565709025, -0.41940134995724865, -1.046659147302783, 1.6873125538808877, -2.5956374433737848, 2.7703616474954003, -2.1985796755615588, 0.7631646671562986, 0.9097966155182435, 0.03270894943615682, 0.5792492134197806, -0.21228222274604724, 0.15571615486113746, 2.4378815345091467, 0.7262753697963206, 1.0742132908646551, -0.1893418737913488, 0.481619768887747, -0.873880195359345, -0.395424526185085, 0.591830507815865, 2.4592775931545092},
    {2.2778135410862586, 0.13721062446580745, -1.3927364744080941, -1.2338944540196628, -0.968542369430306, -2.682012400727512, 0.5732730140257202, -1.3638223128986928, -0.9159583846534711, -3.1444086603546424, 2.111382993422323, 1.4745223476081204, -2.3059353700870906, 0.6609643380839741, -1.8514760564811081, -2.969703849882478, -1.8649400640559508, 0.14661685837761873, -1.5112191063645546, -1.0192604917846073, 0.8177422828468888, -1.2586050280338048, -2.2931871393089915, 1.3255924711242633, 1.6027558197746499, -2.3898135014241477, -0.8912240373891477, 0.7303717302886793, -0.07195944332732178, -0.02213082141600827, 0.764458481414234, -0.6228579253590765},
    {1.7842877215797972, 0.8985381482255519, -2.888692382420688, 1.042239324751515, -2.263760774721448, -3.276773171358075, -4.294362962553011, -1.1907977858648857, -0.4464443334052852, -1.4413037882909345, 0.8907502472510619, 1.5422058407318833, 2.5778820511510294, -0.9770941181697398, -0.13593398019201022, -0.6310293507774347, -0.2492692899799945, -0.15837600156648857, 0.6087144964485816, -0.5843850799340455, -2.200299702384549, -3.2079719517464516, -1.6911499350806387, 1.493094688012641, 0.966291834683036, -1.1619738864974931, -1.0118586625833934, -3.7565132259504415, -2.6408301292293834, 0.6376304235105906, -0.8658327278551331, 0.6858301436710704},
    {2.4066758517305837, 3.17651394365422, -1.6623212733132307, 1.490571662288754, 1.2942303048237962, -0.9101953508395474, 0.30902649955102407, -1.362001904343912, 2.500505334274842, 0.8170688664309912, 4.281762016545576, -0.6019496234152436, -0.5659258228203343, 3.0991435486780463, 0.8531030017301708, -0.7426186682141677, 3.4860873438698623, 1.5982043408152236, 1.5114278882684058, -0.08809896347151748, 0.3672766582706502, 0.7237635819625902, 1.363241967158935, 2.2780501814068015, 2.203218342336659, 0.09051287694581991, 0.21501857116297896, -1.2372258567110104, 1.015804178901132, 0.13146130108939436, 0.9730122048926001, 2.8885536567443992},
    {0.7666314274368798, 0.32865768141754803, -0.8855237394259555, -0.016095681075804096, 0.4586394251897666, 0.1010340336744625, 2.111586494875977, 2.751901637770027, 1.1680842759386205, -0.3354764213996583, 5.0684383685520205, -1.622506841095751, -1.1168264525451685, 1.1934243392081236, 0.4503377919911139, 2.0458341266512896, 2.027164066322315, 2.964570890128497, 2.320133760637978, 0.5592594184262737, 0.18538313561099296, 1.2873636425026962, 1.7961558790490604, 2.101269050047378, 1.5393762754232196, -0.6879877447076498, 1.413937016944153, -0.6669803125057472, 2.3750714464053417, 2.0752387324129553, 1.6979871489212748, 4.858386924163455},
    {2.164435982839767, 0.6598892780917842, -0.3864725980671718, 1.037937078465968, 1.0990987636655187, -0.5084667022215874, -0.35321592204249996, 3.384189523482394, -0.579080596443691, 0.3024807347138976, 5.058571562861712, -0.31737534914740795, 0.2201869477147666, 1.4566246110570091, -0.11213269647016928, 1.7313165845064167, -0.2083112472236431, 0.7982785129054559, 1.2601448622745917, 1.0069557984799036, 1.238369154442084, 0.6101530876277546, 1.1161552180619352, 3.126961616385192, 1.591089756287561, 0.6536130199117083, 2.59779158309183, 0.8636221736823055, 0.17129765376250164, -0.12064173387071148, -0.8888359042204124, 3.026037590178161},
    {1.1580102880710634, 0.3996927952967408, -1.6921726589976414, 0.9083354019583502, -1.5688025970171728, 1.4202459996514714, -0.667040894752527, -1.745145520615919, 1.453010873192519, -1.6099975046813628, -0.04068179377573509, 1.3029149996373952, 2.6102543918778642, 1.9532677945697532, -0.34170161678095146, 0.35608968176032196, 0.5917319067572948, 1.1955110465742615, 1.6525386533963098, -1.1114721105007839, -1.0476979789483136, 0.32019905063352394, 1.0310454820713373, -0.28790564410502334, 1.8140520457175775, 1.2866293174166135, 0.3723515575546488, -0.6363648621515129, 0.9893745603420937, 0.31369361151571085, 0.17421256140351649, 0.18906942464736778},
    {3.296593098053932, 0.39863530649863754, -0.8559838343942673, -1.0052097862146705, -1.205284226033409, 0.5968004471655527, 1.8281778777348685, 1.9258666038627363, -0.9981057074859814, -0.36176753706561515, 0.8786825228907887, 0.35497764176427304, -1.3670025317837322, 1.4892765897102829, -0.3245189485868601, 0.4057930427775234, 0.25314927402747417, -0.784182085142536, 0.7489252101236297, 0.28120749978037135, -0.6882085855941965, 1.9765647518289653, 0.5883996766223242, 1.2337084016998148, -0.49775455727360013, 0.9186999204051717, -0.26414353502466753, -1.1422062440529162, 0.960390864367349, 0.06518903999947893, 2.850507666610044, 0.6911483787108841},
    {-1.4385991684303014, 2.646276571929398, 2.2911474099697284, -0.3115048194757582, 0.23346657567474047, 2.6552846519325644, 1.9456572148346998, 1.589063029436277, 2.400659539614534, 5.539431990733384, -2.179545186586448, 1.8701792537125534, 2.833339695940761, 2.4974956539560935, 1.0584315705346825, 1.4000518894082736, -4.452577837380905, -0.4414048435236117, 1.76518419546873, 0.31496014584964155, 0.9762609025510613, 0.8295191524254167, 1.3119596379809662, 2.2716423982784675, 2.388732917925569, 2.0543183938636993, 3.804712249371961, 0.8920121033610894, -1.4300287410290458, -1.3910131513343351, 3.120692125267103, -0.5371248810168805},
    {-1.424482152618041, 1.5937621730648892, 1.824856181945021, 1.0407546391755613, 0.6047362283762389, 0.27529451262149923, -4.258223653716864, 1.051602378434712, 0.6429684106754276, 1.2440652303924944, -1.0602660936237065, -0.8999797559576548, 0.15331257933563516, 1.7283096001814704, -0.959772452791729, 2.818211356600501, -2.368620883639004, 1.7994175755416364, 1.5960776935977665, -2.0469235248247193, 0.06857158998295859, 0.5707622562516838, 0.029920205360460434, 1.5615032405802942, 0.7478474856334354, 1.7491353618077505, -0.16281432248267907, 0.04654470784365218, -3.8030628592027185, 0.4981576654705391, 3.317541063344006, 0.4892401356721201},
    {-2.253897496775082, -2.25587492992265, 0.6655416154927286, -1.2201051264012992, -1.7212426702180463, -2.3865558031654026, -0.5328747564297003, -0.9207748547722225, -0.19045702227871966, -1.2004999128105645, -2.021544219185728, 0.6476769225166479, -0.9761899757869515, -0.15793949570992571, -0.5381855477088111, 0.6585635009164345, 0.16168385138267297, -3.5177991887260824, -0.12341045241564896, -0.48073073659035986, 0.680659519389338, 0.5226570069170029, -2.6030138118859076, 1.4540099504763095, 0.7858044304896261, -1.0969025710473777, -0.832282261011344, -0.5617652524116288, 0.018031712248942504, -1.4561559131375819, 0.31532642385472953, -1.9070444781459008},
    {-1.0931439533069651, -1.8263328242493286, 0.05733213211398349, -0.5106943354767752, 1.3053449559102581, 1.4726472356279643, 0.928389907159616, -0.5079943856964242, -2.9768957462481866, 0.5113979913690659, 0.32787216107736283, -0.30706994705588353, -1.1246766716380947, 0.4294294483389807, -0.27470876363940383, 1.212274690729095, 0.6442185052316703, -1.3804035903741594, -0.7047098145160932, -1.0333720267889632, 0.19274004289630495, 0.9901648743834828, 1.5209934203656819, 1.2613228508118317, 0.09777493646643744, 0.17921888183161339, 0.7317452587000938, 1.852669356383808, 3.1956819560844356, 0.970119854434111, 1.9744659217269875, 2.856879812967507},
    {-1.910257588906444, -0.1907648377202437, 0.04389896684735877, 2.0224838196897936, -1.6426099369714675, -1.0104745001291315, -3.0859415250137823, 1.3836820555898712, 1.5405340961441185, -0.9387029970859981, -1.03764282744875, -0.8535700401707064, 0.543080795182391, 0.48960471849129744, 1.670274038886547, 1.3931863137641336, -2.5849679965096124, 0.98620815739732, 1.2260175582516195, 0.19717976904009402, 1.2365169800210447, -0.6584364019868404, -1.736638868150914, 0.778905272745427, -2.6258337484404257, -0.2685751119020335, 0.9189802719376964, -0.4630173570004713, -0.3703238343866828, 1.2661274128391622, -0.5494882546350184, -0.5899746506870288},
    {-0.3522049057873398, 0.4732677670503976, -0.9168756292121364, 2.3059398535014513, -1.0635580568156957, -1.7791904926096416, -2.962709851369485, -0.8452572135627401, -0.7463100547859601, -1.813126292936051, 1.6434591608914486, -1.1036713439660657, 0.81607524121312, -0.7274563669028092, 1.0215944156898966, -1.0167152485641482, 0.89040026731669, -0.5798633626828713, 1.3774832825255094, -0.5573244135759865, -0.48022698994305996, 1.2975366278305334, -2.597152007119996, -1.1340167886065466, -2.6743823118721175, -3.2864702578198224, 0.5287620929793216, -3.0540173278216893, 1.2271797434034564, 1.0317218528132654, -1.0027756674782946, -1.605414073077228},
    {-2.4756307399757116, -1.772212456238153, -2.5249850523681294, 1.3199900320827251, -0.08907101961562532, -1.2661761313804771, -0.6413908469676346, -0.4682004488201786, -1.4175999134026043, 1.6049655570511039, -0.41438460048347703, -2.282799216355099, -1.576296148488643, -2.2634295379088454, 0.8835518049669688, 1.2945977174830723, -1.719266028972217, -1.2098335062168337, 0.3887071010649553, -1.1095311785760829, -1.2947660568553365, 3.433041642931361, -0.7039049083005342, 1.092407565637765, -2.650938004255433, 1.7235683495625698, 1.5558407120946103, -1.200491735317258, 0.4322202466686115, 1.4895849583322098, -0.8495975323496611, 2.4260807691392596},
    {-0.06410080367924188, -1.7952575528228114, -2.648723948966344, 0.7170298337275923, -0.544859911515969, 1.4337284452475592, -1.7486964740710702, 1.542881492071314, -2.0966428888185593, 0.2859236638827207, 0.13968048948974565, -3.5461524259032022, 0.7784724693154942, -0.28034464584708263, 1.9708075759988182, 0.8291664341108611, -0.6584682958761194, 2.9715269831243267, -0.4007889938192058, 1.449113909031857, -1.7028180459566051, 1.3247005292080314, -0.5664087894824639, 0.699426379486094, 0.7666582824321454, -0.010442036099721212, -0.04310597466981088, -2.1502195956874903, 0.7400645033273424, 2.198948026122249, 0.06955516642089217, -0.6356920763687081},
    {-1.6474744632953187, 0.3334065419303046, -1.343702106443391, 1.3160296546684875, -0.1883998296623661, 1.3497761908246466, -1.587092031541997, 3.2462811997093697, -0.8662748314823697, 1.0840313942032764, -0.9508085989051787, -1.8092205220716118, 2.7452324154975405, -0.4495083074672572, 1.9272191742845335, 2.841369527977838, -2.0449634338322715, 1.026280871946357, 3.1159840008732624, 2.6865733941244465, 2.3195122156038956, 2.1089416151275016, 1.4376748405344861, -0.9011482755650546, -1.0820070374595734, -1.1436074884010856, 2.361261043480718, 0.2499860463889099, 0.7187580755537295, 2.4550051236642942, 0.7813643470657673, 0.45579762653129074},
    {-1.9674173410062619, -1.9652015765053603, -0.0411677277580329, -1.6277332063275596, -1.3268825895125906, -1.3011116364882833, -2.1446095003549046, 1.6022464893349517, -2.9902652393236346, -0.47878307625049527, 1.899542207705901, -1.0793832877867162, 0.22525607031051081, -1.7002114212397932, 1.038188384398926, -3.4004227363043857, -1.1024615556766502, -3.171593158509154, -1.6684997933156098, 0.4446555329777224, 1.6978360086824753, 1.837873433716206, -1.5626416460305368, 0.32625024891565746, -3.3726288995622613, -0.49985598805472226, -0.6272543344482379, 2.407316324154551, 0.8371382213490587, -1.7729214733342282, 0.16784811475428765, 2.188672600620027},
    {-1.7222975508867517, 2.1498627490345323, 2.2858639505361102, -1.5260956485051782, 1.8757456375464712, 1.379527774054144, -1.5542154379712971, -0.8362065617737666, -1.631432323384989, 0.8464311891415722, 0.9201740715661352, -1.3691384704702994, -0.28480971630277796, -1.123489039292935, 1.5509457073420734, -2.58401747314218, -0.7724372509851407, 0.5455410075531467, -0.9593431245408254, -0.2353924054774855, 0.9395140870620531, 0.8189513259454797, -0.23069826809546906, 0.43136109579083737, 0.5752611176975054, 0.1702571036457281, -1.756156652969921, 1.4713045931164543, -1.3671186771444497, -3.6607210852125265, -0.5321424936303135, -0.2817747111816315},
    {0.004313033552827667, -0.4073651914686711, -1.1992721569913674, -1.6650650071478232, -0.9573336124956391, -1.229106959667168, -1.8100022360841665, -0.6969070549586632, -0.12694631106425425, -0.8146798712545034, 1.1667777000543849, -0.7878053354200852, 2.0067799343048023, -1.7897191377873751, 1.1013777486569725, -2.0830902113053336, 1.5406141024061772, -0.08802226406264481, -2.7683161872840794, 1.6162180470892735, -1.4217203837032628, -1.138153103861544, -2.441744535412748, -4.496448082398223, -1.4288514316742507, -1.5720571023226704, 0.882719676301592, -3.965696095759493, -0.2674696553811642, 1.2407726549287657, -1.89645718242492, -0.9128158275675229},
    {-0.9829599255666165, 1.2660037277255287, -2.7561645880821333, 0.7603801074090086, -0.6880061077579124, -0.7888141139038585, -0.506509831622288, 0.8815254587487164, 0.7838781632090345, -0.19058622368344869, -1.4753721000652604, -1.7133241417798573, 3.0635942000641347, -1.8012471401944714, 0.8924504155060273, 0.5013781321592964, -0.41627625459563783, 0.8287804752104367, 0.46932331289327467, 0.9751598015540902, 0.19252384532113412, -1.4388046071839793, -2.4207698248822567, -1.874492674741769, -2.222943402177632, -0.5343303737979672, -0.7698508892324681, -0.2991367121479675, -2.002671442916807, -0.12330800470461911, -2.4368671680455045, -0.6555802832538478},
    {-2.330354673758606, -0.4899426323202594, -3.5771290741922526, -0.5115899750564123, -1.1729112276105826, -2.197920586378369, -2.900524575214047, -0.015941277980059686, -3.1030790953065184, 0.002837077420400537, -0.7918145090730457, -0.7181885791556516, 1.833663044617429, -3.868594324804031, 2.6590123974535764, -2.180401022155069, -1.7274826512054138, 0.12132456481546797, 0.0038021420939179456, 0.8503344886612884, -2.0409038959114643, -1.1654538872150992, -0.33284835546951463, -2.1052893962322714, -2.7305525166984124, -2.027139362963824, -0.7875808554244141, -3.2754696429940324, 1.1815680674777838, -0.938571415146352, -4.1810202636923535, -1.0856539925572293},
    {-0.4362950101718634, -0.4077526356730697, -0.6842340878575538, 0.16827443312085313, -1.0852620602772565, -0.2485125537491549, 1.8932872093680582, -1.4836458782578454, 0.4446583210034636, 0.6524219562041097, -2.588201754678003, -0.20310759245243656, 2.25374804138245, -2.625180369284182, 0.6653944060799224, -3.1612298616054195, 0.10360333180907609, 2.877772865248796, -0.4056618852100687, 1.0314094619471177, -1.4286780648630149, -2.2871936636685914, -0.6405386973549252, -4.434278744727371, 1.6471293721847284, 1.3635896804054457, 0.8569032905148919, -1.029192730969466, -1.477542243747245, 1.1683187394755217, -2.744679927052007, -0.5299556418291158},
    {1.0812906036099033, 0.0604145639365591, -0.5184998380682236, -0.3961696469097296, -2.491622851650758, -2.5098461167536144, -0.02145237140978483, -0.3090569170275111, 1.0430138185127276, 1.2348467927919267, 0.2594508425154234, -2.116566506739509, 1.3141555740489923, -0.08858616292960075, -0.8110586720601877, 2.245293203433169, 1.243160918398915, 1.9811867528869205, -1.3013786252157442, 1.1404719001964267, -1.015104578870064, -1.1096810162212045, -3.1146349139624916, -0.8760500802198344, 4.435517701058318, -3.3824985786885233, 1.6105952745020857, -0.4934947408465216, -2.6729624438154467, -1.6641763557946472, -0.9770756612828337, -1.8447759086700215},
    {-1.895320703657476, -0.31645690067922533, -0.029516621523753915, 2.5303366311916218, -0.6145028608251369, -2.111378884007491, -1.3287222023656973, -0.2787964408330307, -1.0642546330643268, 2.761846556737738, -3.4213050895216415, -0.39220459561536275, 2.0833448022612253, 1.3993845910366434, -1.765973204660154, -1.239779289812639, 0.2953714261856146, 1.9394584151230982, -1.0942495332843536, 1.5507493255102778, -1.3516926975500074, -2.9254119034316917, -2.0572578848736573, -2.4592056641983717, 3.3852853030769787, -0.13926334327719336, 1.1984616021132282, -0.5527437328901624, -0.0789772736667561, -4.157144186123885, 0.8000049146545026, -2.7951422860708623},
    {-2.2286159042681715, -0.045314827024007985, 1.3473555316527968, 0.6851218744614747, -2.2600608929866572, -0.19807542733026062, -1.3451389788854486, 0.5830142435398491, -0.7482418336264883, 0.48689382689819305, -1.345732641511741, -0.6746398567093339, 2.636919985207015, -0.7335973232943451, -1.3607393857345915, -2.100431870213383, -1.8797931226727038, -1.34975502758616, 1.0842947185441365, 2.3768495759355024, 0.21340988317409676, 0.24383300814721728, -0.23200212188189345, -1.8201784605293814, 0.20445809568727324, -1.3799217798644439, 0.24186905499548858, -0.40613609872329676, -3.242340664131903, -0.7399171589661646, -3.6920855659675977, -3.3241161454373236},
    {-0.37128521378153334, -2.04056151391423, 0.39841706757663464, 0.8860624582865073, 0.9686134742188492, -1.562182829526181, 2.229578797881809, 2.0881844057767553, -0.29149010033738526, 0.4783237953131946, 1.6397689215153382, 0.4685047566362826, 1.1165676974231515, -0.05129571827158144, -0.9618852220912155, -0.9051958174868686, 0.16859684703270383, -0.5182916391556837, -0.4904955945808993, 0.5270297178240688, -0.6996897572937284, -1.4126347976839657, -1.9631650717902247, 0.529031352814522, 2.7868873544676522, 0.6424122596209872, -1.4086217419345048, 0.4343238359900423, -1.885534099556122, -1.1229020541608399, -2.8987671119455216, -0.9850476619046068},
    {-1.5685861514085395, 1.071122968264143, -0.5253982718232231, 1.689048582608988, -1.964531211129992, -1.4426716520180978, -1.134430111481507, 2.760970320166985, 2.7280775185634694, 1.4094890503164137, 0.5244009272993084, -3.798234526292364, 3.1367042973140284, -1.1153384365047818, -0.5882294016865725, -0.42566792906406237, -0.8118532383881402, 0.8620604119316227, 1.7863943579243444, -0.32522563840916785, 1.1809446181334164, -1.2392598423649033, 0.15590184797794576, -1.3166191523948763, 0.7297409126333699, 0.43908565558686863, 1.6323234758902003, -0.6689058045606563, -2.9787879261936956, -2.274356519719059, -2.010696647196065, -1.2091605571723876},
    {-1.2980852270871959, -0.9138703859949238, -1.5576071624258687, 1.537502056081186, -2.3696129438385314, -1.2652084351053743, -1.3819919973854335, 1.330994196402638, -0.5881328165627306, 0.12802948075902054, 0.6387691187152437, -0.5086231925898104, 2.8178825496740507, -1.7077782518176192, -1.1508587514202726, -0.5967171709455378, 1.5137584309425904, 0.937524260190213, 3.5550316994384277, -0.13028065016620083, -0.03215459807243665, 0.32743542996958624, -1.5848366115087793, 0.6432961493091557, 1.5301501425810329, 1.6611906522129782, 1.2125193296282342, -1.5214617171640745, -2.6040391931332665, -0.3281555830280936, -1.0046293218816236, -1.7672362048638885},
    {0.019473252966282703, -1.968754137983897, -1.6146698991931114, -0.6290666075491873, -4.139453437137084, 0.21561887521380177, -1.0463853036107618, -2.539245517401987, -2.2933771672875887, -2.9652804947770974, -2.8903381482576562, -4.197907451320125, -0.09455967965616585, -1.0259432821564043, -1.8486475660666852, -1.9532473771863066, -0.6828969348713172, 0.8688374325334712, -1.4717583293216892, -0.6412551325225632, -2.636029849654688, -3.532572484329433, 0.07312711372812204, -1.7339738760770604, -1.1688134946113908, -1.8501024187562674, 1.6975050320460767, -0.48637616052768023, -1.7790855016377367, -3.669513772723604, 0.7005547133939423, -3.310232265935325},
    {-0.9316292150165039, -4.122198646957606, -1.6602954434381145, -0.3843760126018785, -1.6578852522614558, -1.5654426758094424, -0.7334372799432084, -0.8377693876457595, -0.9531375341064382, -1.8734599923809439, -2.4182081064292213, -1.7710511913122808, 0.8950670648198371, -1.238779299028209, -3.8723572221278157, -3.3663896196580794, -0.361392030272933, -1.8947588014871963, -2.699058625196857, -0.7659248386031013, -0.8353260569739206, -3.1312598759379835, -0.042620730404063355, -2.922031716599566, -3.8038780922351734, -0.9852932482590706, -0.2863172112496079, -2.4280250779575545, -2.6263323667677136, -3.3019744008047427, 1.2905894784012824, -4.042892202605443},
    {-1.383328072329217, -2.8917679824683957, 0.7291537695495885, 0.2524059061308375, -0.6876047709768724, 0.14280581645509796, -1.7589890392232406, -1.074658058158404, -1.9314319242003815, -0.9491288780670372, -1.7710104888353795, 1.2212151370245092, 3.3261237445679748, -0.555591187248637, -0.9906594748289986, -0.6333514287947007, -1.6501046643738682, -3.022442372959565, -0.6541556663915813, -0.4544664366873441, 2.4964636700884877, 0.25810374375406464, -0.4578189815415431, 0.2273607655415676, -1.3169618212040812, 0.2231368378392873, 2.369170650617613, -0.03320946041957317, 0.10819908890788187, 0.6391717337730316, -0.2181068241071497, -1.853571955493882},
    {1.1186609470810636, -1.0882391752763012, -3.0414120364369523, 1.6617552198647185, -2.507179021968731, 0.7012565969470472, -1.718445393040972, -1.2950173354244117, 0.8452227217309253, -0.35981132397693216, -1.870008314541036, -0.5585196413558017, 1.5705116125763487, -1.4464318084704635, -1.2114621463936297, -3.061482302122485, -2.6737678491228833, -1.402665643794003, -0.9213782530157892, 2.9657300609793804, 0.11363763477739199, -0.6887622111931736, -1.6671275938432992, -1.2233776122582862, -2.430847920276558, 1.7223032685134583, 3.4103158854955993, -2.861127142273695, -1.0903698172245044, -2.1087933163195847, 0.8865121728126646, -0.668082130430024},
    {-1.771398100603893, -0.46458275546874317, -0.44550281014142484, -0.970659993449527, -0.3716430601815436, -0.9235148366331856, -1.2181468211807964, -0.014195015921916436, -1.5722455732463412, 0.8267416966478774, -0.5401454040511626, 0.8029501973606423, 1.7973918727391653, -1.2331629314923769, 2.0041391359385337, -0.3782566483848501, 0.18674292434675738, -1.6901932322303093, -0.5939026536767197, 0.004870366917852718, 0.9975986953437506, -0.9909088642003681, -0.15540086980968496, -0.574378010065112, 1.122437063081155, 0.9893311995599984, 0.5855296635917968, 0.9212550260992003, -1.9531147559051723, -0.34074281200496753, 1.2890798621020532, -0.08089276524042367},
    {-0.14753408077339245, -0.3829440607553637, -1.0997459824946445, 0.7409060782559547, -0.19653495043887556, 2.1310722346558517, -0.9885870527502254, -1.7488963830996345, 1.1359331930061023, -0.32847983669889924, -1.2025567646478275, 0.14831537238463438, -1.435930001557671, -0.07641592113659798, -1.4408565978433396, 0.6547785859575452, -0.21392821042604768, -1.0324475914323286, -2.9452133659499116, 1.6249845404250107, -0.9397937214830357, -3.223154556509108, -0.1632851492705149, -2.5443017794757345, -2.3762016212548827, -1.0678123267097108, 2.0206235585163106, 0.7499087389813694, -0.5797895108458189, 0.1300758161937726, -1.7936913114475408, -2.105310708139145},
    {-1.8535082295994856, -0.8337042843695546, 1.7086161955626424, 1.7567063162199266, -0.655607153109936, 0.15241593295575265, -0.14699470031474604, 1.002349478782761, 0.4044674654559012, 1.8166074064232198, -1.0705563248843755, -0.7921358545150701, 0.45593076312663106, -1.2197505040569387, -1.1446671646742943, -1.2896029973991243, -0.036563191321397764, 1.2254557526182654, 1.0658078086069451, 2.203755863754317, -1.8561681526349325, -1.8057934140445184, -0.44357500553050544, -0.8052490080367101, -0.851511417418497, 2.1624329069951953, 0.15052460294768427, 0.6479006048589451, 1.8678049011606017, -1.0607896060875606, 2.1445661144611794, -2.5736707761600086},
    {-1.0894393852218967, -1.1468524191234637, 0.531919921338156, 1.4647950545918502, 0.1515109565983919, -2.6641806278984244, -2.8326868691876466, 0.37415582153895666, 1.1922761720600747, 2.4991455123247754, -0.5673132886672774, 1.3031595211867657, -1.1983721902225184, -0.8221979529896182, 1.637024887744819, 1.0205382423916984, -0.8583645987951195, 0.6641455587965037, 3.7567722702678608, -0.8605585445964425, 0.5043250178461319, 0.32906225121728366, -2.9954092328365367, -3.5324390334742337, 1.9913666030239798, 0.658321724273911, 1.7007899914349913, -0.9182415456780177, -1.0746171111823883, -0.37631156098083485, -0.6086518198815948, -1.7921693477194647},
    {-0.3118169209205821, -2.2665142975025487, -1.4330980352198748, 2.452807276836305, 0.06296857541395261, 0.874967001499442, -1.4271232595070387, -0.7443978562182487, 0.274020648912765, 0.38287742570629385, 0.36238798097162533, -0.8277072192283762, -1.8338421633385262, -1.1583652591404308, -0.13462562329490987, -0.10958760506996172, -2.8135359230058645, -0.8280633637672077, 1.2816443472032328, -0.26766599901903654, 0.06423790571829939, -2.1879144213710657, 0.6703502855148074, 1.0936907471598352, 0.7176562253170106, -0.4335430147009958, -0.07373818881689172, -2.120084800693099, 1.0984922240443218, -0.577836282550135, 0.8325493268728333, -0.7580098368923552},
    {1.7253699316658702, -0.8795849386483526, 0.2263521117438681, 0.16574741780776867, 1.1238808914162637, -0.4116781808605069, -0.27067275154470066, -0.3701207303529848, 0.8247214740529691, 0.6925521315237936, 1.1526799825735965, -0.1113093181554864, -0.3748685256710272, -0.7186971528448173, -1.3697012197357683, -2.579258376720309, -2.0001771094012657, -2.664044413540515, -0.5701725682671511, -0.060242039508171925, -0.8837349490618901, -2.0225518833937626, -1.9518653890356146, 0.7968105700721473, -0.42108293326416907, 1.3563902745809704, 1.4146287528908459, 0.4634783686474316, -3.4734845057653643, -3.9270475467728856, 2.1405778848306514, -1.017685685043221},
    {-3.8979735196023624, -1.085280301783053, 0.6412830568865512, -0.4248469281508378, 0.5699783210325612, 1.4250930042301528, 1.2680312594128162, 0.585110675876679, 0.564728257490259, -0.062402552577263244, -0.7629197619287982, 1.194782917377517, 1.1249805882112558, -0.4035934280625872, -1.5628603544496882, 1.1485765112081228, -0.9481259118115187, 0.2021328628542353, 1.1845297028881074, 1.0173634700511676, -1.210144763343599, -1.792989109735885, 1.3599562899769417, 0.8804362870262918, 1.7041621919769545, -0.977060261984574, 3.376398698126807, 2.363988143782518, -1.3371723677258267, -1.153780661962144, 1.5828207772890661, -1.5463543828850719},
    {-0.41561507258607777, 1.207541412643475, 0.4286970229920876, -0.37324085113976097, -1.2319080102970907, 1.1321709296772586, 0.1171271813681814, -1.860004477111786, -0.4841404239970286, -1.787759754214262, 1.2263495478250446, 2.2117324188231398, 1.523018563832986, 1.8922947944535025, -3.3680950719016693, 1.2868894077072734, -1.6022064251047023, -2.7386114898762566, -1.759661544304301, 0.8072537464836576, 0.4231214428612822, -2.6045696075774165, -2.15053286916346, 0.9136761757984214, 0.3843233878964523, 1.4353116389986866, -0.5797290025065035, 1.5592609615327964, -0.8311003988244896, -0.10374763211882741, -0.3213964754839606, 0.597395818714254},
    {-1.3366131005775028, -0.32344213588029574, -2.980065324508489, 1.0693850206852356, -0.7900888901582319, 1.3287595887269585, -2.8655328617982794, -0.5923512290970515, 0.22247210485813135, -1.379662242449444, -0.9876159557117202, 0.9706610620359707, -0.10553488597486918, 0.4339041564497396, 3.0133369876246086, 0.007224208667259476, 3.3276509553592186, 0.12369483363057197, 1.2503325386497464, -0.5949970367291278, 0.7639396911284552, -0.815498598254628, -1.6503779133851975, 0.614668831411203, 1.1840562876140088, 1.1654171886540534, 2.973585789699865, 1.0187019796067502, 0.20707331566009993, 1.05722301964106, 1.9203374789541727, 0.4488273481695129},
    {-0.36785956437902334, -0.9348198945686026, 2.2242614830414906, 0.47218727647303677, -1.2929262154654322, -1.891008801766232, -0.5353109660099533, 2.2472280379567118, 0.15783268626001284, -1.9605971799873583, -1.3841658643547714, -0.3229696954656571, -1.3398374208319255, 0.7145732589585868, -0.5163201959974787, -5.273560419207432, 0.9309482256370399, -0.19524090448390224, 0.1673443360495356, -1.6104198610823335, 0.10933246090007352, -1.102136246119334, 1.4070772708332477, 0.17665041459941092, 1.267647086101063, 0.50711702168319, 1.0569254218089943, 3.108913800649896, 2.427799715248342, 0.5545393351201142, -0.48701456379060787, -1.1830944860920736},
    {-0.6364649969710703, -2.20583230431271, -3.3390802744955126, -0.32427612975790365, 0.45922710490499774, 0.8320624930090532, -0.5336129032787423, 0.7929898112112991, -2.0754351030208245, 0.8214418530889307, 1.766796034257637, 1.7469366158628983, 1.973546052844376, 1.7547500616184286, 0.8176867835720509, -0.8494350882011362, -2.0867610829121768, 1.7420315270532336, 0.703113344014326, 0.2345848383788363, -1.4609412406829014, 2.752742358699885, 0.1306258048184303, 0.813281732451605, 0.32194349746262574, 0.5311339978551537, -1.6160019333931523, -1.3591336752703553, 1.0637818076459322, -0.7786032100072847, 1.6732369783694467, -0.9054936957719726},
    {-0.8354647121334139, 0.008266326127734314, -0.2742840083560401, -1.64376675255294, -3.257194825962522, -0.42000355964600883, 1.3616518995353644, -1.2332558012317467, 0.7128824139854962, -1.707513345346711, -0.23780665319472283, 2.653592476117677, -0.9761476787058482, -0.3924116945099251, 0.8110571148991836, 0.8014876081426436, 0.7600198826488506, -1.9855027336902327, -2.0047600234190015, -2.5809302255096234, -0.040977232742613785, -0.27495110071988565, -2.2976665183634375, -1.4097018890163644, -0.7685564898324517, -0.25498086265703074, -1.0563885215536557, -0.24482815266236177, 4.687971440086714, -2.703112306762192, -0.39718425136387325, 0.7436854626925049},
    {0.5178037962874826, -0.9752307776093597, -0.6861530486511482, 0.11639769890167968, 1.389903930286109, -3.223485610248217, 0.3223377330679341, -1.6656839584899605, -1.3021730784751675, -1.140474726638376, 0.6880014384324109, -0.8685126132216723, 0.22858785552603875, 0.16653539149305605, 3.254464406166336, -2.3490076846696413, 0.2530033865166356, -2.462213717086292, 0.006284078317085657, 0.8897106045335087, -0.32399157796594363, 2.165591726835694, 1.042789218575979, -0.38709627067816804, -0.08900158570005937, -0.2326607195459848, -2.8847065117877304, -1.1737782645930006, -3.7510162875582163, -0.5946846451658133, 0.34319858402084524, 0.467387607629799},
    {2.1736242767975793, -1.0796200980304917, -0.4283587063034554, -0.9701406157969807, -0.031198030980464406, -0.8405615037790297, 1.939925902336074, 1.0784429337078, 2.063520879375565, -0.8583351701427502, -0.8898711734424584, -0.6300130637594268, -2.0383736691747085, 0.2952512282325264, 2.4316851265773862, -1.3318120474177622, 0.4019056570610479, -0.370792438303134, 0.07596057213623252, -0.8440896444461629, 0.3632643103871999, -1.0833215129550442, -1.2840896336878524, 1.1648493980464654, -0.7005426961319946, -1.1938800717686475, -4.332819508600597, 1.6283208297673575, -0.4683133683544577, -1.1400569930898503, -0.5360350075622385, 0.38903060611964274},
    {0.8131165827135047, 2.608931495072234, 0.9122615879418704, 0.08886510335689832, 0.35198583139951056, -2.7248991257018296, 1.536328600413578, -1.157336450201121, -2.452190082787095, 0.17293942832355236, -2.3282361351811347, -1.1011975471661366, -0.7943254258676584, 2.0980830126551395, 1.6853034331131898, 2.694996660902168, -0.6298819378287264, -1.8526252425033647, 0.4322130856014181, 0.9421439858249002, -2.426967174653436, 1.2668054494508278, -1.2956622595605587, 0.2363867319104799, -1.2607789496021016, -0.8673538081810235, 1.2377616378542258, -0.44124997420509204, 1.9117383421546474, -0.21171422676853077, 3.5647257227520996, -1.4643187120009926},
    {-0.1619785416583196, 1.121768400363355, -1.471307457831184, 1.0145146412303405, 0.1312634835885988, -0.7746493840851549, 1.0534028842305518, -1.0583828760737446, 1.108224491734612, -1.4146353588199423, -0.7186836373971218, 1.0439862366141803, -1.2322878346457073, -1.641673898878146, -2.8685086682174985, -0.7090846284839931, -1.2616518566812212, -0.9418706500364243, -2.391261125348472, -1.2305813055916688, -0.3909087987989377, -1.2414220659623643, -1.26262856740003, -3.0488066565635505, 0.07643585952146828, 0.28650252999174874, -1.938453196122755, -0.4941083093913506, -2.7453945940201008, -0.9838288376117603, 1.5849117490308289, -4.339919089461931},
    {0.4566939169069942, -0.5807865955419939, 1.9031724470877944, -0.9778816497720585, 1.406489099336874, -2.375313383475607, -1.9974608091783992, -2.5553634301506363, 1.2498581333874526, 0.02811968972147955, -1.1706043537600068, 0.9303995695097351, -1.9261863619018393, 0.19161921828367606, -1.817583509676578, -1.9669117317046683, 1.055937624886757, -1.1842144867235935, 1.0024819434419425, 1.860008663107586, 0.7339649912479315, -1.1548320060316475, -0.607958868916426, -0.09743442478982611, -0.32527368767462805, -3.1964131047173123, -1.5631630503364013, -0.9935695224864044, -0.525684552675029, -0.4235961181369423, 0.5541369921598668, -1.305261404674835},
    {0.5431588879070447, -0.14618761018952287, -0.06475240709007622, -1.6751573534036357, 0.014435835569779221, -0.06617561426698869, 0.31992015073861507, 1.1306315501028465, 0.9809991534190026, -0.3200044687892774, 0.09452144336637165, -0.004843064148542612, 1.1581437977630342, 2.535375346099618, -1.0711560285988808, 1.8216606346904862, -2.040506877768009, -0.23337320665431502, -0.48762452940417794, 0.8341668644930202, -1.6379353004169246, 1.0363938094890848, -0.633901116695087, 1.9401257841869708, -1.7707764866400801, 0.18055802776355, -2.953132419533843, 2.9006208990448505, -3.956135726601007, 0.9650616424185645, -0.04028313370595301, 3.2872104854946955},
    {1.537024983491406, -2.1995597106394404, -0.3241327529006687, 1.3004987549586864, -0.4084977239901998, 0.5003521802737608, 1.9306836459706402, 1.1155954120509084, -0.9511708402312344, -0.01760691757043115, -2.5517909102065364, 0.529178026660582, -0.08901606719744348, 4.0533718114029105, -0.5242054259035867, -0.31262415619283884, -0.570498750305979, 1.4605398197383601, 1.2465464013419003, 1.9143211379982137, -0.611862226856106, 0.9837119157028167, 1.2035928991199303, 0.06228377938841939, 0.8049205372993483, 0.6487736610901691, -1.0187710332478765, 1.4899998559232979, -0.8782332660400843, 1.2210221098437068, 1.8932581877166241, -2.5689683262787963},
    {1.3035311795323499, 1.6358266210913621, 0.3351168566521883, -0.11040286016674779, 0.40633780142212794, -0.33847046339559705, 1.4534505139230123, 0.6364536113101532, 0.25779617248989883, 2.431041802575887, -1.4720591451124323, 0.46953171558639184, -0.023884947036076562, -0.9344115254333341, 0.10540398708184831, -0.8686115566946052, 0.20776133789974247, 0.8380656163184445, -0.10684501232346774, -0.5279180763690969, 0.8772663696992593, 3.500624383942961, -0.5373388813688366, 0.9901052076707803, -1.9425344757288407, 1.1683000901805802, 0.7847090708305335, -1.3731425421082426, 0.21158922051755186, 2.5883327604274307, -1.3648663012669902, -2.0165909869890575},
    {-0.29088738493964905, 0.7175941113120499, 0.16064533214961216, -0.9721260867160081, -0.14478955687905737, -2.875760076013046, 0.9502898903708906, -0.7870655382067389, 0.5785397981911724, 1.5549922088621144, 2.7909711766322056, -0.5072078485159117, -1.0293953610455244, 0.10593794872352146, 1.4709165401335664, -1.6129335275709131, -0.06338384249027146, 2.066120446346937, 0.47698676430241616, 1.8702389472873548, -2.3788784446268623, 1.4357252167698848, -2.7884785724383923, 0.00011405097112207737, -0.2504479782117723, -1.1622901089630815, -1.4414009231191893, -3.297939230391619, 1.4094908138917388, -0.21967269392005462, -3.0887811277540913, -2.087065316316905},
    {-0.8185372299386476, 1.8257911332157897, -0.9640919083270661, 0.5556346061350824, 1.2147275890374967, 2.522676351749309, 0.481357670246568, 1.2302867539975488, -2.379165728091602, 2.391827958659203, 1.1538199687978437, 2.9072243443644723, 0.21264773237445136, 0.5714642121902271, -2.824701571884833, 0.24056773636172496, -1.3346192986494554, 1.1300675547203565, -0.2493273100208695, 3.741059592370832, 2.103109243234694, 2.5607619244044306, -0.20821027648966028, 0.6486133070466036, 1.3078755081931042, -0.10300772181054091, 0.0005193191796086887, 1.2869522637913493, -1.3290348045872449, 1.3068029894381135, 0.5557376959506293, -0.08844454334408317},
    {-1.880331945259185, -0.19419074335386646, 1.7325916121726146, 2.7774846753157485, 2.3343151022976607, 0.5912057518046391, -0.006074656015685882, 1.191400183513565, 1.46590229700597, -0.49437404920899836, -0.6038991522555259, -0.7607840836733512, 2.8582511734380547, -2.189595383465149, -2.370817629300446, 1.6077219787075436, 1.5221080960770226, -0.9045888752464373, -0.7591382319757196, -1.1072732001254215, 0.6673716767797931, 1.3195064538769954, -1.0600736891046412, -1.1631613470906443, 2.611825273397055, -0.4605860646938654, 3.0308815533570423, -1.6021983117880818, 1.5140253668353614, -0.12303606267441825, -1.1360395011397313, 0.8197524789134496},
    {-0.4398824324543544, -2.047226456799679, 0.7733254341427949, -3.2591682113335683, -0.38293860055098305, 0.5644461989996947, 1.5878984061556607, -1.3460651003330857, -1.1401186039274944, 0.31009613138869535, 0.03497140446427907, 2.849420391824187, -0.9811891854787176, -1.2173248192553567, -0.30199488750436904, 0.09160624929198827, -2.207859767185122, 0.025743692204772784, -0.23784571330693427, -1.6735878397188202, -1.8315068981874476, 2.1349116808786683, -0.67946479853607, 0.17426029961970027, -0.8389439123377821, -0.05004292268626142, 0.8714347873275947, 1.264299193858063, 1.5893324773843118, -3.3557215856955924, 0.9783863363676648, -0.24064232213367695},
    {1.8804159371978877, -1.7115001870362825, -1.4327841337118596, 3.2979732938596786, 1.3131002289028124, 2.4441218674044, 2.3109026763355756, 0.7209645118336079, 1.5279968230381291, 2.0421008851229394, -0.5426227468898498, 0.7529107060192733, 1.171515525515689, -3.367601546389273, -0.9985167057255299, 0.4273060329484851, 1.7844164309717008, -1.2226082886068177, -3.373571006230381, 2.0279138841319178, 1.6533385771970546, 1.7434350488445334, -1.6029669588426636, -1.498258084707202, 0.9838727952022045, -1.5900419570746804, 3.3030837712561776, -1.823288506476076, -0.41942671337513704, 1.8190979035672288, -1.3822773952799414, -1.757874849211155},
    {2.1138323583915035, -1.1797345040795613, -0.10971157788882181, -1.4935492736525453, -3.172821166604512, -0.25532291494326737, 2.5889623478307535, -0.43381704285252, 0.9948477257410675, -0.49433817548068465, 1.1030111949283086, -0.7554468204168638, -0.9654455133083156, 0.09460029698259975, -1.0092044721581621, 2.0846279406288115, 0.09082692213694582, 4.01402689492811, 0.4766966590972025, 0.6260512803189656, -2.5988006704957405, 0.8820986882400996, -2.176658058058197, 1.092945964006744, -1.2034769129116456, 0.6866152734114956, 1.6142199903280439, -0.5736842361972979, 1.7596710325867966, -2.2258992964302022, -1.8072183892659819, 0.10995264360461628},
    {-0.37678770236640347, 0.6317314259891007, -0.3693315741648278, 2.9509796310596115, 2.807805821367079, -1.2647765009957093, 0.7958416946579132, -1.253166346266646, 0.11276210186145685, -0.7689616294891586, -0.42855808867264644, -0.5468915912872376, 0.33729752575290295, -0.7782226468074239, -0.7167261878457367, -1.0916603530740436, -0.9950190521157521, 1.4269452420441262, 0.5677711618545457, -1.4086452850188733, -2.418811633328922, -2.456993816677791, -0.7312674753913369, 1.2266655947530756, 1.8568414851891828, 1.6011475231159398, -0.8679195676737708, 1.7551400132767858, 0.7142120956129198, 1.7250590831447172, 0.3714541783528096, -0.1736709639475607},
    {0.7114995406697672, -0.42584721157584987, 0.7860217307020306, -2.2406500228722384, 0.7863193252295967, 0.7170069991392796, -1.1649707489081016, -0.8784483283300686, -1.7724056254223695, -1.0183911879740533, 2.5008907206542053, -1.1447055040967162, 0.034487042074549966, 2.099250984966021, -0.41695039504917636, -1.7171442448652408, -0.8039686436285903, 2.3343568796675576, -1.0574984287466567, -1.3716979338132054, 1.8321243498088444, -2.3328178968361346, 3.272356962937051, 1.4132837045812405, -0.03596643237942447, -0.9061753499151293, 2.9704558469584113, -0.3497278429113881, 0.7922134380923676, -0.3414020524367009, -0.2862223496601898, -2.2997705982186627},
    {2.069828187607232, -0.11318098524073648, 1.321989899406978, 0.09823435438696744, 1.7577435689290262, 1.6182829224324988, 1.4931404807986186, -0.06696884903517783, 2.5136670955743914, 0.35560559626512644, -1.1095237962218212, 0.1734512133709539, 0.09143851720762995, 0.597866825479914, -0.9398955077978827, -0.9352168167513868, -0.8729519749253358, -2.519907037760857, 0.6735430634420784, -0.29249946086908235, -0.7716830318490759, 0.596015104450363, -2.9227964712431707, -0.9567226759447891, 0.04652002200378717, -0.8766154686066409, -0.6460969914911973, 1.307739084112059, -1.016158438041931, -0.015053697263292809, 0.47729419740361884, 0.7610432847249894},
    {1.37106545874279, -2.751683414976803, 0.4779062033931079, 2.920726425443072, 0.22868241024278288, -0.3059404068367772, 0.7235194125570932, 0.2915139405222632, 0.39968661479666023, -0.6666053082807344, -1.2955017902626, -0.4200286472648692, 2.4181182683069, 0.23030890517560765, 0.04429764330544521, -0.2368001225304056, -0.0033982052333457733, -0.13524361314922947, 1.043883610531076, -1.3806773632076255, 1.7406237501928397, 4.034297244870669, -2.5554103597302364, 0.6606692340118469, -0.8165201297833915, -2.091547053668528, -2.0970946030961417, 0.4568427875695575, 1.4673527301254048, -0.09813894517823002, 0.018213304793550433, 3.297527547984942},
    {-2.381731302516628, -0.35766594504915716, 0.48468477109252733, 0.21513762000494674, -0.6996832179937167, 1.783746847333021, -1.122561866721171, 0.4671970914572128, -0.49163458157909307, 0.24496659038416035, 0.2907204773813012, -0.42888921405529434, 0.24703061493644576, -1.7239803180155528, -0.12099804663631449, 0.6512176906305909, 1.4121025807859025, -1.6417292648065107, 0.6559189640766154, 1.1048564665309986, 2.0508941546688875, -1.0188194412152853, -1.9670231889125835, -0.954476020839956, 0.6466818898819018, 0.5686316617531442, -2.7697707256508237, 1.1560871942525792, 0.11746784281732328, -0.18320516832987485, 1.6640017943886034, 0.7668630643648907},
    {-1.3993432298952537, 0.3131571841254293, 0.9422019062187105, -0.49153692367679913, -0.6783134685206476, -0.5657600407455293, 0.39024405285781266, -0.2881515269670518, -1.2260341858470887, 2.8229128638418124, -1.4898686927475624, 0.4360023409027455, -1.1595986774758915, 2.980836581371469, 1.156414751380416, -0.34900952638817984, 0.7706802726390264, 1.2870485078824239, 1.5389584051033236, 2.1696483816579923, -2.4927125243506887, 0.30719195519533, 0.9628663860360934, -0.31496591619612313, 0.8633523420461922, 0.4317122393715354, 2.3403179918218475, 0.3074291423097903, 3.667145017672808, 0.4140671238129638, 0.7767249258668786, -0.39489156872337705},
    {-0.783278132829865, 1.115576516740688, 1.7372606871186207, 0.47096815296151434, 1.377487730514257, -1.4642182124930239, -0.46945622644536866, -0.4230294930223091, -0.5583609497457677, 2.6169976774586687, -2.217754811711139, 0.8199202602245932, 0.5286618251666105, 0.5661216966341526, 0.8238973457800555, 0.31060946111208004, -0.09766787342644377, -0.2911427413979949, -0.7045871365255617, -0.6702788841128885, -0.3480514709913783, 0.8035510113063494, -0.2360713888660275, -1.383987827164133, -0.9911989282462934, -2.448490139507958, 0.5476432740214423, -0.7254478324508642, 0.1373902072377062, -2.4668099005892596, -0.4215135900634376, -0.09746773285725112},
    {-1.682317979985735, -1.5972898058034812, -0.5324372291414871, -1.7408828652913084, -1.5422121672469586, 0.07538154565395161, -1.1711054021060403, -2.2719854755726763, -0.038363606881214714, 0.2020994093090382, -0.26873113924744957, -0.2577034741903522, 1.8692877703074153, -1.5362673616683367, 3.9797752069505172, -0.9904834364734596, -0.8047367235428897, 1.776382846491911, 0.2713700144794021, 0.7971842855425645, 0.588686113283041, -0.7596960254107451, -0.3989877842471631, 1.6878949791750038, -2.5046490136737867, 0.5440216898485112, -0.15545327548949342, -0.6956710859566791, -1.8441156870062374, -0.7029124429746041, -1.2516135904216323, -0.8990198610630841},
    {0.7706710198607167, 1.8299956531746377, -1.4915518549254387, -1.1127948453231578, -1.38114402614197, -1.1799320059018998, -0.24493008491199234, 2.471934990977138, -0.30494417962991704, 0.19395409080545037, 1.5423290647271988, -0.04281058727291734, 0.24283138383025293, -1.2360861684355038, 1.7970003821455165, 1.2155978389832962, 0.4906488261822832, -1.1573801064254163, 1.3959890033671414, 0.5612940799916027, 2.163502382770134, 2.14546513115401, -0.02153352283272352, -3.0090787016594835, -0.08400925763522207, 0.7641065313558243, -2.092201306865134, -2.56008364421451, -1.0231206728543518, -2.7013666844582054, -1.580428713848758, -2.9590060312198756},
    {1.328954514297324, -0.939100033822499, -0.5378031459805562, 1.33758840761037, 0.15191390530411042, 1.3723022914580507, -0.31938840232673626, -0.4329745630022369, -4.04775911961739, 1.164991780032271, 1.5375237998086555, 0.9720051111878935, 0.08529508956935988, 0.7602897827608683, -1.477446936295205, -0.6228585544079829, -1.3590257175266727, -1.0679842230145502, 0.24583677738722645, -0.7183292855699833, -0.3853607712016124, 1.0616096370863957, -1.7668189275089061, 0.34279279944093766, 0.04987776220716575, -1.391913276955445, -0.13157877592974732, 1.3453719865122253, -0.5611284052885389, 2.028937605092153, -3.095901650781438, -1.1726045003712917},
    {-0.972867341038008, 0.9638339278536947, -1.6277409026680505, -2.422424124027152, -0.9596046603904822, -0.24849917252609463, 1.2705925185413072, 1.0852898629128613, 2.062460285537664, 0.33358940528411385, 1.5974073820551844, -0.1590568103030333, 0.8064155022260411, 0.8027586355253554, -1.7744214401707856, -1.5112267345071222, 1.0260694671074941, -1.9048215658984973, 0.8993327031984668, 1.0411800270690614, 2.6997606361183935, -1.3493286707728527, 0.4843120584981759, -1.6112655558673061, 0.3717276965770192, 0.9327711138022649, -1.4703112683000308, 1.1641290885383124, -0.059519094811594904, 0.21442084724642213, 0.8506338006130431, -0.27086144492310193},
    {-0.6266836668965995, 0.8912156272819973, 1.773884684211705, 0.686247640831606, 0.399482837536311, 0.16224991675098946, -0.742467817471788, 0.12360496594821943, -2.9110169055203565, 1.301998070380871, 0.07958823228499114, -0.8133636885348399, 1.0848176577814197, 0.2600993577428557, 0.2617870447568857, 1.9986243187966126, 2.2718925873300604, 1.8563194876981455, 0.36150105768756463, -1.0947499909339389, -3.272600505336647, -1.3932035863794605, -0.8018306500409446, -1.2709646412357485, 1.2146729386385862, 0.26429995356321206, -0.37579308900607716, -0.1904486122377002, 1.8608153122355269, -2.056660708380701, 0.47176513990806473, 2.242543017014074},
    {0.5945881154227081, -1.6530332518358912, -0.7211309059576794, -1.050214909283266, -1.3201215489694749, -0.5277071245129834, -0.9549276453310067, -0.13135198279265595, 0.6430949279348039, 0.08552796497861989, -3.1094952389578077, -0.8035203600754228, 0.4131853019257556, -0.30396078713105756, 0.47601177114004084, 0.32282487654791037, 0.8475977749392232, 0.679021292999425, 0.13426762250569774, -1.0669964689311429, 0.8421192608580548, 1.2222726347769162, 1.543984708315426, -1.8366420257228957, -0.3721961626356762, 1.8121515614557266, 0.4558399807071311, 1.347130809519771, 1.3394955783932792, -0.8719738179347024, -0.1899965040360468, 0.4771470517459785},
    {1.2863944319488123, -1.420923956576152, -2.270470047175384, -1.9021049583201972, 1.7898103806805425, -2.65602376575075, -0.9415283615188849, -0.1947763617005465, -1.3823138606169958, -1.4418340184126852, 0.9809283399501193, 2.2145584235810474, 0.645625605020455, -0.9207380084921727, -1.3485734839589076, 0.36499644827727423, 0.0456089886668991, 1.551186677981781, 0.9531135119329361, 2.407031895944732, -1.7386203314591393, 1.3496772705159656, -1.3427690336464166, -1.1737473235218796, -1.745079755121989, -0.06845606742526471, -0.3114639599551108, -0.9591121615423064, 0.3694834442905413, 1.5345043934635763, -0.19492096323756777, 0.6813933343092123},
    {0.3026458705645196, 3.829425591630232, 2.5745941161700046, -0.9072812043506667, 1.2667873353977703, -0.5310706340999574, -1.1728943020582994, -3.2504945641692116, -1.8125984183163775, -0.7409748626104519, -0.9713397125705928, -0.3697751585082345, -1.3419425402623861, 3.0874169594595604, 0.39990195796250716, 0.7117803387533593, 0.4229931166994663, -0.9156073548153694, -1.5678993620941546, 2.6077975392754538, -3.0981328290346704, 1.9305793404836593, -1.3930303187694824, 1.935823602758083, -0.943855862014831, -4.3938162104408, -1.7319272759773376, 3.034338758584227, -0.6678453221349301, 1.1374215864911248, -1.3219926188525415, -0.8735318288167805},
    {1.0761900199088261, -2.351359318365352, 2.4513725190521085, -1.5991158543061441, -3.9096759916576076, -0.4402827819096369, 1.022842622040996, -0.43209739617305526, -0.5244581608577356, 1.1456384724041866, -1.3813523081398498, 0.6281204031507968, 0.4475944958814951, 1.156519552102736, 0.8402154241770786, -1.4265010848183322, 0.26440616430927977, -0.7347262030284204, 0.24711470839397098, 0.3519543044004881, -0.739925194211955, -0.46223935536586397, -1.873444583241189, -0.109776034252158, 2.492214784224112, 0.04807391501542258, -0.7544376065974945, 2.8186634198689, -0.6033741488659224, 2.800414420347634, -1.5341847472183645, 0.4266740916633817},
    {-0.5737694222856907, -0.19659551365278535, 0.41398797059521736, -2.2861000470266712, -0.7635837138894437, 0.9751425637045307, -1.7086131125047503, 1.1226122336733995, 0.19098958142608224, -1.0250057157922454, -0.9453918789964333, 1.2186630392420696, 0.5807421395503086, -0.5822752254778502, 0.06501251744293306, 1.9673329004111608, -1.8119114181448506, 0.11012215468202362, 1.6904312953440523, 1.2748273786891986, 1.0364700340869188, 1.2025807962668982, -1.7487321974260255, -2.1323446967216055, 1.4989469498805472, 0.11595247802753351, 0.12272806873456352, -0.6703413553003966, 2.041053756047377, -2.2199944543844365, -0.10404563654430854, -2.036365310844874},
    {1.6912081653120115, 0.30599170010064936, -1.5987348853179466, -1.7509139716763449, -0.9178824129462234, -2.6021589376987397, 0.22664700277395652, 0.8413699627867117, -0.18166310792644666, -0.8558993128094672, -1.8007064336810716, -0.7974457872855725, 0.26187698504713175, 1.7661893141309326, 3.308227710030845, 0.9354102433532169, 0.7051422610180518, 0.9299713471056633, 0.02441189839136989, 0.7564267004064014, -0.9155520494583061, 0.8799668771779126, -0.36547564811884775, -0.30652084478158254, 1.5152056170889794, 0.40429540630794825, 2.238706180403024, 0.01763681782154555, -0.5233455476213257, 0.5585632918919688, -0.5556410433689104, -0.5450324373901388},
    {0.09685425655137948, -0.6027541808202015, 2.401332386391973, 2.330303851909281, -1.746310413104954, 2.4805158478553095, -0.09999693402462775, -0.7382841938583915, 1.1883221697163509, 2.405210624197047, -0.3905182306203067, 1.5960273958107072, -0.12092626564753499, 0.24343351427806045, 0.5698826149900127, 1.0221889740329457, 0.8209002797264675, 2.304101008125433, -1.2748560755312264, -0.6039995393031156, -0.2748936287743251, 0.8221488338690358, 1.8613775689234808, 0.14703179811074119, -1.033770706804146, 0.2204526519050044, 1.9257854757248187, 0.5920695107735562, -0.819616848267787, 0.034220597095097484, -0.996816873529039, -1.5032003529631963},
    {0.13922159148685967, -0.5633681770396757, 0.46864355036508315, 0.44524222601281827, 0.6572966418884199, 0.588586515152648, 0.07008264311457645, 1.0771222471388713, 0.016287313979037477, -0.6989836162568748, -1.6042418847037316, 2.817463361985764, 1.8115391076342782, 1.3452430552475345, -2.084133662196278, 0.6742149471825901, -2.04398164512272, 0.298091138165424, 0.720713910158597, -1.8084360742953502, 0.026641666439312577, 1.3709049500521813, -1.2725176497436639, -0.3738381103878405, -3.9885339742657817, -0.38571176386312217, 1.4353384410538312, -0.43243591445471674, -1.2233672123223307, -2.058063064942673, -0.7920458224086655, -0.7456993480707124},
    {-2.3282709044811845, 3.320748408884357, 1.229724948501483, -0.7433965818983351, -0.7671705690709202, -1.3707089269486197, 1.6907158860357936, -0.3959683290865745, -2.820180992946132, -0.7379426014433909, 1.3793857423337244, -1.828773111442526, 0.833800786796352, 0.16498762566659025, -3.580219446687317, 0.6561922763785902, 1.0771134515358467, -1.822673708050871, 0.03175818106519196, -1.2826540717574892, -0.6865818639702073, 1.4481165298842973, -0.5450235893701367, 1.2293246046268949, 0.1885887272147761, 0.07055551177117149, 0.8280902762340062, -0.043597846698322514, -1.8257245491833944, 0.9347467226306297, 0.6641811171703367, -0.23402840394974922},
    {-1.336808641031475, -0.19443191310905691, -1.0462847767183117, -0.39126786805163133, -0.6426162654657639, -0.2950436779200181, 0.14790796224684666, -2.723248124714397, 0.7046062883565006, -0.20640249484509351, 1.516469925567834, -0.37046471358282823, -0.23868358035251191, -2.6692497529782724, -3.4343025399040785, -1.3124878898424113, 1.054749734420233, -0.42705809933505695, 0.12118075219870675, 1.1334193538893005, 0.5760581050753345, -1.6415157649057426, -0.37023953652350033, -0.3568630856354326, 1.1649081400717625, 2.1616801862230526, -0.7611722409489485, 0.9528524517717969, -2.033187494496208, 0.27373437090825536, 2.282278318610467, -0.6891511187781139},
    {-1.3867029384026455, 0.24966780014966702, 1.0809316702952723, -0.922889393619456, -1.2164829277753515, 0.27799757178681916, -1.3401017052575595, -0.8312545379124686, 1.1250753867049061, 0.5319836668374062, 0.8228108935382888, 0.012541622088013342, -0.0163734843859471, 1.3836858258978282, 0.8991111886679869, 2.900093696484666, 0.7129036537313778, 0.44967592763431397, 0.6987305759470074, -2.201566137373196, 0.5672040934712651, -1.2323376437540505, 0.22974815622757241, -0.5458852915521765, -1.8615402741399785, 1.5667729298044633, 2.3404263366871074, 0.3073456285531514, -0.46158168265960514, -0.80542003864905, 0.8350994627061485, 0.2369259846967265},
    {-0.02819914383470176, 0.033908366416308865, -1.4342299914676928, -0.982359139788017, -2.110622654910735, 0.4782168450283367, -0.6799148328723207, -0.05931522612650311, -2.7040167145930236, 1.6623707601181852, 0.3355323818345578, 0.7701994729582421, 2.305575095725622, 0.2781343248118999, -0.1190517386431529, 0.4004817548830035, 0.8526619179374756, -0.2282670169421504, -0.5654271410849957, 1.1278640738624217, 1.2562488585713234, -1.4712486506093518, -1.0340189154974186, -0.6125997268965458, 1.1989889614919982, 2.2404395549320766, 0.17374627259030137, -0.04788292787044978, 2.315224826916935, 1.2497456480353573, 0.09943170892957107, 0.8522336766789711},
    {1.6017634060488763, 1.823146681266786, 0.8391404197557805, 1.4097071303826336, 1.1419642496392854, 1.9374844130959301, 0.7763427077396154, 0.7025624995589712, 1.7687853856115063, -1.3710048798710701, -1.0287794477482801, 0.7286253842362139, -0.5266940432850881, 1.5843710877382853, -0.7017754660307876, -1.0782178975590648, 2.6946205865700956, 3.1579320456711573, -1.290200358309304, 0.5055499683109225, -0.3790983127833386, -1.8735167601980738, 1.513118773792069, -1.8979338152665313, -1.8491473083468493, 0.8799334582413164, 1.7154894590254492, 1.754225309546818, -3.121252021507138, 1.0762967216223003, -0.49420358207278503, -1.4314540727186913},
    {1.3290432528825105, 0.868767129256004, -0.5628498668068606, -0.9840444048147557, 2.7264233744346997, 1.1091948594341012, 0.03429287535316544, 1.9271481800578698, 0.40216362042179693, -0.9163370260153288, -0.40975630639979965, 0.19957834812767408, 1.4553768240696425, -0.2797093336505012, -0.4643929668001407, -0.9773806707955592, -0.3881933930513981, 0.4178296847701408, -1.0901302786214917, -1.4505360775507818, 0.8965276641438421, -0.2593683935684372, -0.7378365789824781, 0.5717913343751576, 0.9875246310610319, 1.2940807105725944, 0.17189009303560485, 0.14386460572203677, -0.7345106324424269, -1.497537766112084, 0.6760696526724714, -0.1809500277353617},
    {1.585011587071092, -0.560976313911462, -0.7064864599986644, -0.2467165280848913, -0.5677333896514315, 1.571065761265407, 0.027855916833959944, -2.290167970403821, 0.906198443332947, -1.3147877045068483, -0.2807811359923381, 0.431633266499054, -1.3065856202747337, -0.5363243987552445, 1.9450748097901565, -0.6254489923080665, -0.557904810147125, 0.6318261871467747, -1.6436327700511129, 1.0858534389791996, -2.1228885132160262, 0.6378251512473135, 2.2459349882054487, 3.663594050342226, 0.9888384711032211, 0.4531141263130998, -1.9589734455250623, 0.34394184664351757, 0.8683376948385977, 0.9956307798237822, -1.3482325477973633, -2.0486540908548556},
    {-1.4703104534651512, -0.32925080121665967, -0.053008239061269405, 0.9616342867920549, -0.08345273096339134, -0.40287562902926843, 0.5584955107867479, -2.968002197616113, -1.411121293997469, -0.5751348136029955, -0.8430034568181467, 0.5386388136221223, -0.7554996343836468, -1.440030181230653, -1.9141563431380264, 0.6431714202324692, 0.6900831280664826, -0.6827873964823812, -1.537079245294787, -0.2234539251215911, -0.7362894914254762, -0.4500319357317742, -0.39207968625878536, 0.8673230877655116, -1.3257043324091327, -1.718330124245285, 0.8041049420156586, -2.370689053186768, 0.1246041638061676, -1.6376570837475224, -0.027621263722969795, -1.4156047588340104},
    {0.6169857984278597, -0.02400949829492304, 0.742546716686097, -1.5516985902991325, -0.225150606301831, -1.482766504670309, 1.147137761487056, 0.29956977599368667, 0.3299818637220848, 0.23940099825802705, 2.233076595212453, 1.6788578744267288, -1.4539802325893705, 0.6926430610262737, 0.3093545884815731, -0.7868724315558406, -1.3911883154493836, -1.4425972441899686, -0.14161269023693612, -0.6997554304161085, -1.2371520099961917, 0.6285834614458289, 2.1484865698471745, 1.1085412323742225, -1.167995586999042, -0.5654777754410673, 2.021207192321682, -1.9191501447012043, -0.6258509242677369, -1.8392214342617283, 0.7203495014871748, -1.657726450143973},
    {-2.0844727073777607, 1.1998165478639302, -0.6677718937965337, -0.3822847920315369, 1.5611067689953864, 1.0649620258424786, -0.9327814518029485, 1.000516926753331, 3.93011755928463, -2.0065768560532087, -1.6279023897503078, 1.1678666788596026, -0.09194110433156547, -0.11714639886286576, 1.377005612622506, -1.1255400581550514, 0.45471458633186607, -1.6979079151388217, 0.4535923300135646, 0.16381584006806363, 0.43296995468584715, -0.9981520435978908, 2.502528781368472, -2.84205419364585, 0.047062373369790064, 0.21256171161414222, -1.7638920455944123, 0.0853771271574646, 2.117491058727967, -0.9948874244575459, 1.861806808626472, -1.2121728655721795},
    {1.15811849924707, -1.595955215484856, -1.1840383045525364, 0.7509445206729378, -4.328360463240068, -1.061155135548556, -0.6577747016475498, -2.494005712300915, -0.17427286105528858, -1.6870038159085174, -2.5959813166016072, -0.9381044322549007, 2.6042622396744077, -1.5776040408262508, -1.3574796986086226, -2.4229122240985355, -0.4057307218046405, -0.7176853021704899, -1.7697671256935719, -0.0621456838774731, -1.33889372892651, -1.2368481074229807, -1.6230723241879221, -0.02236884212487867, -1.3479399345596235, 0.6916135701767799, 1.8448635567783451, -1.999786085536944, -2.974694286700138, -4.531577167491292, 0.5601099063551787, -2.5508919820478724},
    {-1.2338281962396795, -2.553523677134991, -0.031267087530338494, -1.3360495352909374, -2.8773168661392106, -1.5770639826873014, 1.0049902258375638, -1.6575557024522771, 1.1586318826248017, 1.102782939191784, -3.1779581240434855, -4.230929988615304, 1.3365214968458161, -1.8822666057604929, -2.247198042563513, -0.6143091607905686, -0.17639151590518404, -2.542385115498394, -1.1933036760889382, 1.1283812181125974, -1.5685815383686723, -1.0773408536830507, 1.019854735086191, -2.9952374653992995, -1.8979280970025665, -0.8907992599195275, 0.5121864173846558, -2.754287860801655, -2.4191971813136073, -3.2021031316179824, -0.4897944315481502, -1.5974863058195357},
    {-0.6859595198010083, -3.0654580553115407, 0.2865720223936239, -0.23266308673859223, -1.5305410982790888, -0.37304329481600323, 1.5855375993000356, 1.8280066766346692, -2.675462848682213, -2.4811918214900386, -1.7965432021139827, -4.384919801500269, 0.004346392708216061, -1.5565986125474682, -3.3714652028287353, -0.7490280507703228, -2.1914355882454877, -0.22990397995000617, -2.877479374646402, 0.8776334692697693, 0.6799997844767103, -2.044218470317676, 0.692124131629443, 0.07893597696344921, -1.6419151690796816, 0.2660213015498025, -0.6943490909691804, -1.11830645692636, 1.2092967666162038, 0.23378429805527387, 0.10796916031794658, -1.0736778405015692},
    {1.1582699608883968, -1.6578261882064234, 0.5834690607420812, -1.0741224212584441, 0.14672330638743417, 2.0191539122209585, -1.5431465128139499, -0.18900688639857727, -0.36351669139231385, -2.1553897856997364, -2.9386776347308277, -0.509808778423568, 0.5387316617455412, 1.1278234987653897, 0.6340750078166951, -0.7923965063611187, -0.2822678759829884, -3.265219171804375, -2.3221325527539887, -0.46778648399601774, 0.9334663272658542, -3.274039660241789, -1.1134013934501896, -1.8490788541996028, -1.4010026936926328, 0.5536561925281569, 1.4076737957451242, -0.1010127891850994, -1.6167216078422324, -3.233735831433545, -1.0094510008676405, 1.1167603754545894},
    {-2.0764674847725026, -0.9143690750507388, -2.892037532387321, 0.06624387842177995, 1.9899965170150091, -0.1028264214755124, 0.1645675221932627, -0.905051021925938, -0.4152611591512344, 0.8321045300599561, -0.7651789051685395, -0.5020745735871411, 0.2399076489494143, -1.9200751074672746, 1.062640407654266, -0.17525758950574266, -4.1858109975336895, 0.3723640504581762, -0.6143275635781639, -1.34528931724881, -1.9700851764496108, -0.08914456599842645, 0.4515285480175568, -2.16236080739152, -0.09979049271207167, 2.1904037641279333, 4.434719309933207, -0.31490622519347605, -1.8481531508057665, -1.3362344172917124, 2.2228310621032543, -0.763828624276701},
    {-1.1408051270395008, -0.3195658584065973, -0.20862132209086875, -1.4953287911492186, 0.9108333187044589, 0.6471622971822086, -0.9690253654496002, -2.0984294020424836, 1.1778207231865263, -1.8127239126410701, -0.6311377824646041, -1.2911395233939464, 1.2156378348716788, -2.8983912819163278, -1.818258690841846, -0.7152476614145985, -1.710769401020288, -0.673140214137716, -0.8036064599039157, 2.2052403621652177, -1.9633820237878066, -2.5023579094854846, -0.20503003921882823, -1.5101736611070407, -3.2825725654137403, -1.8756403954351644, 1.3622513301975465, -1.8859855909091514, -1.1912762140863415, -0.2772299837130973, -1.3913413394043612, -2.252711608147482},
    {-2.689897101296055, 0.481119458346734, 1.549167624263011, -1.7182137481142357, -0.8929945350937966, 1.8123842803822736, -0.26115207334469764, 0.6180854371475756, 0.8242499493231396, -0.12770865928541955, -0.11130306773776297, -2.348816179230065, 1.441906075485718, -2.381479952410707, -1.347020209685021, -0.34801758813381733, -1.015945125029926, -0.009212584679353167, 0.796361795702037, -0.6157385738706378, -3.0536426860496118, 0.788949600939962, -2.209219116048994, -2.8515689190340128, -0.09595855899248272, 1.9003830268083117, 0.7440229276718365, 1.710598907093083, 1.0459666753707768, -0.3666782992577301, -0.02427740794904891, 0.2221056255928278},
    {1.264172501157785, -2.930565314857828, -1.8584337444996009, 0.6701672335151193, -0.02627671872825662, -1.2043955423430832, -1.95150903256519, 1.3226482734603022, 2.5637440113836036, -2.4638483952704116, -0.6827854588046797, -0.07832906177986829, -0.3449708493374884, -2.2811508348366094, 3.8135351544653777, 0.6755807154586784, 0.002789883066015816, -1.716854655197583, 1.2894608901851445, -0.706287229207531, -0.6809199884794264, -1.8476575782294682, -2.97859753328481, -0.9332033602682167, 0.8213030435254857, -0.5711879456396178, 0.8853299788648606, 1.6680529503352146, 1.1309023084145244, -0.36338511973692744, -0.4076191456310376, -1.5798277715183549},
    {-1.0760307364076092, -0.685457538090618, -1.153861980489732, -0.2705522252789775, 0.7023195706206842, -0.4465934835884072, -1.0563643289162286, -2.838028170229625, 0.6470429567140333, -3.010628521824433, -1.1665819497907532, -1.4687452682136712, 1.496278728763964, 0.016611606257883157, -0.7419704092758455, -0.2710474075263878, 0.930022806291606, 0.2519202605683956, -0.42929750619090523, -0.5637769462390674, -0.7537032405268841, -0.42015917782552975, -0.3861476593824785, -0.976774392443973, 1.8047725219787285, 2.0070846819910697, -0.6487825045081955, -0.3001797354209958, 1.3084506980030741, 3.5913026516235833, -0.975621860525577, 0.7815625569938995},
    {1.351739455989821, -0.9592210303624693, -2.5203231291285055, 0.554603683798023, 1.406998735397006, -0.0345471355596264, -1.9615084198345238, -0.016826053342464047, 0.5432450577291092, 3.4777122887109297, 1.1233274910385387, 0.5239210667422992, -0.3979790533474764, -1.2970125886610377, -1.800681809707391, -0.0899793482604559, -0.26315722763665145, -0.6392307922008212, 1.5338437626258152, -0.1641990486494272, 0.4175778876463828, -1.3738430284768526, 0.035967790558203254, -1.1616056528365901, -1.51325149439905, 0.3154638456489569, -1.5192210034648796, 2.392806032392631, -2.649761867046914, -1.6501726687641, 0.49867152563604034, -0.2452290780308948},
    {-2.5306333944450556, -0.17295325713666515, 1.419755543555846, -3.5219033647189257, 0.01582564795116336, 1.98823519387261, 1.095334675400303, 1.5539533591945733, -0.4506820526358864, 1.5564622214719086, 2.609903323054794, -0.478134631571381, 0.9445681349178254, 0.23454523216387269, -1.5007081320860134, 0.8832139949742581, 1.0027983012265367, -0.45699237765772, 0.6000909015642749, 0.33863516963388335, -1.045615539100704, 0.035121400215402034, 0.1873660415842423, 0.5872728988428467, 0.2522622393880924, 0.38751077382801247, 0.2795080477333918, 0.9495907985081358, -0.5476992971235367, 0.08637084969276873, -0.9145707092834753, -2.6565374322923705},
    {-1.2289481547591412, -1.0686610320042076, 0.5279596523160242, -1.200471700939759, -4.034056242713827, -1.0421162964521107, -0.14741534070908963, 1.9234515604122708, -0.6862570667231473, -3.108554657200654, 0.3918148540349239, 0.2721352053077073, 1.1374662211598012, 0.5830661662252544, -2.187327842614538, -0.30157967896706217, -1.426051634947546, -3.081160568844148, -0.11670394068999237, 0.7193856637172998, 0.8372844749562103, 0.5917409108567281, 0.040413980528151684, 0.5497741028824606, -2.118041108702443, 1.2067300858360834, -0.07556396807482688, -0.7704813591340305, -0.42746126199546297, -0.14809061529081224, -1.077141310281433, 0.20052599965945042},
    {-1.316624384936695, 0.5875883277046288, -2.4335861089952986, 0.9797308266637534, -1.0718045361670385, 0.7531598713583084, 0.9538533169909763, 0.5177062745945294, -1.268377722372466, -1.3619011527465574, -0.805053205305886, 2.0767902974680967, 0.3814386266783661, -2.411731794135502, -0.21133762192344005, 0.34714906863697736, -0.24490917381305086, 0.8190852642673742, 2.093262205016906, 1.8236453661908008, 1.4348414786981913, -0.5469702838068424, -1.1934071670207824, -1.1236308481789756, -0.041993291416711424, 1.1002535282476515, -0.41692512135386356, -2.013752790284959, 3.2821716268793857, 1.1142906703837017, 0.3770622209313858, -0.14798539011283912},
    {2.0138637500555343, 0.6599045786673203, 0.7512550576755166, -0.018654018349701353, -0.1559647397248495, -1.8670821056408338, 0.7048846265153434, -0.5109344474116798, -0.9439289993606943, -2.206001412483652, -1.8509274218059075, -1.5528353322442159, -1.6448222172554727, -0.09892074106064125, -1.527096756008672, -0.43477247285898174, -0.7861412397409893, -1.4685891902780346, -0.46384995384154953, 2.603807713490212, -1.6432663222113932, -0.5355273006856042, 3.480623566898818, -0.1513081190986785, 0.04918913728999175, 0.48092536212898485, 0.8555077442010105, 1.3076810937071965, 1.3724228680719075, -0.018498230801526787, 1.2665898655630798, -1.498939829722516},
    {1.4874277119235282, -1.4743641872493323, -1.188746393530517, -2.35887663386254, -0.59647862839725, 1.8258223236914894, -0.7737166372283002, -1.4959256001396102, -1.1101638015644821, 0.21199748370555088, -0.1363891029972874, 1.7359162114577957, -2.023061475588867, 0.40609377934351654, -0.610194154997496, -0.27395928839547634, -2.185806963402888, -0.9392860925248238, -0.0429738089489165, -1.1737097297339167, 1.010626919920761, 0.015722226116724695, 1.8230370667244797, -0.9050294381319324, -0.1874776396906655, -1.4318796174277757, -0.6490038421353538, -0.30057509734975796, 2.7611439667964097, 2.786536111102244, 0.0440556856631959, -2.066013103987061},
    {-2.508861980524732, -0.9377092448614769, -3.1060447470324415, -0.2902839154159349, -0.2950148048498552, -0.6373293650539842, -0.6980550130559889, -1.692444920730849, 0.9537641126394275, 0.4293265135812757, 0.5986481503122655, -0.7355984915081301, -0.05995659320899686, 0.5510429530779621, -2.777074957399479, 1.1540458226284027, 3.315196437216256, 0.4685836693991591, -1.6561119516430722, 2.3471146861012504, -0.23817414374619958, -1.430795754060646, -0.029117191122134196, 1.5540521237746658, 0.3171230265316612, 0.9657926148064369, 1.0332475687207288, 1.047261215789834, 3.0941496085369096, -1.0597177496702697, 0.3375975946512913, 1.8276485198273529},
    {-0.29468163678592935, -1.43735376398409, 0.1280346843431493, 1.94282750420499, 0.4788610599959007, -0.1662580990809397, 1.5823411978792985, -2.0523341638997157, 1.2593420344754849, 0.4618495766569817, -0.8652450963806372, -1.8345255679149004, -0.09208373029357048, 0.5103041883491329, -0.41241801253362764, 0.5751799572441614, 1.1437878561625672, -1.3557055010007455, -1.2599121305351197, -2.008929884783706, -0.5251572197822453, 2.302926391831289, -0.09675552210399267, -0.8363625328018974, 0.43253039079646266, -0.8013626589006737, -3.7802964222156703, -2.029926104025903, -3.5023755688359053, 1.039749275083304, -0.2537804702913727, -1.2442347828109606},
    {3.267216592253593, -0.40004677472339084, -0.1589578829841514, -0.7176246991822098, -0.23536940202257656, 0.2078455295530618, 3.549759049203029, -1.1096656430099954, -0.054823519325340284, -0.9652237212392474, -2.2033133185224507, -2.979470122828788, 1.3148980455790127, 0.09798798297940352, -0.26297350663881963, -0.32675231338542426, -1.4763249579877025, -1.9958885534598017, 1.8659846627396666, -2.3997863929641894, 2.072136650780234, 1.085335856494327, 0.026439147312233204, 0.3553936995440877, 0.5457872821245132, -1.1654429679978788, -2.4762481120106403, 1.2699431204412943, 0.20943082362964657, -0.8029501698773582, 1.6171504456427643, -1.4521379618942694},
    {-1.1733448988880446, -0.4117358853610462, -0.025090498989567396, 1.325834349381192, -0.9725260970646237, -0.46400570918531736, 0.1822415246774183, 1.3838279852128121, -0.33461915864437686, -1.0335280467336045, 2.4767735924422944, -3.2298026473130745, -0.5272850777874536, 2.0166467907035703, 0.5293575521860688, 3.012802640898229, 0.8075448656150502, -2.062533065199016, 0.6157791896810253, 0.539711728466924, -1.9622384027392863, 0.5462092692249635, 0.21335742882587683, -0.8075763298638452, 1.1135944499546417, 0.17867474621612603, 1.4982068506921191, 0.48579232075349005, 0.10441406386408446, 0.7495510389893649, 2.1961161828216276, -1.0593701322843359},
    {-0.01821471311414513, -1.8393987751111691, 2.1435511294167493, 1.2731688285817482, 0.5042629468651135, 0.6999016604815921, 1.028032335099463, 2.24912472048405, 0.36294611684814176, -3.457434314743399, -1.0193731493721587, 1.2648560438052159, 2.923965144831558, -1.5459853866627558, -0.8132924143370412, -3.017241727629775, 0.6990811423122965, -0.14239996614806244, -0.8808799247930011, -0.03315036114892351, 0.26824802070390874, -1.1234571504961093, 0.09933834506500452, -1.3784616399810066, 1.8219897557305658, -0.2041326638989582, -0.35342350190861266, -0.5347786661560057, -0.839305377410465, 1.1514923609032677, 3.077125429241224, -2.4559807240877136},
    {0.06507115948908779, -0.8263634690888503, 1.3579318409668333, 2.08371279581138, 0.5471342486122205, -0.024382675897329103, 0.9177388821998783, -3.354415830752339, 0.6796011478388375, 1.201377573440124, -2.1709814509354146, -0.47354709969066827, 1.2256281453323514, 0.49702605597026, 0.8630397964647553, -3.6628207468786997, 0.25841753769701975, -0.04672807856530648, -1.6805993569344078, 0.7891578492548336, -0.9692208760444728, -2.6530386121283978, -0.13079424848385127, -0.5028438374773114, 1.2012099288711182, -0.8108040147522222, 0.480299050918254, -0.018314350765887034, -0.11272514944295414, -0.41547012154921165, 0.011964803267029235, -0.5476954581378636},
    {1.9750649614698657, -0.4874324618912247, 2.6024140331073515, -1.4353850014058738, 0.6034847200088589, -0.28295497604978403, 1.0862350848592848, 0.05916699467253785, 0.137867701230473, 0.5345657372229072, 2.9469494864750954, 0.4431755392263701, 0.5219701803703887, 1.9370371022499342, -0.5955875479116665, 2.662009709728165, 0.23092672013995788, 1.0799357499884628, -1.8029006687574274, 3.194861489072559, -1.344876499833672, -2.298978709326887, -1.6405041413477115, 1.226965084318528, 0.7439756510354705, 2.231187626314509, -0.08072299839083538, -1.3775504875961384, 0.7451512845770311, -1.0443331354694105, -0.8386173740187297, 1.2909888482423322},
    {-0.12392604221730671, -1.7001581198070386, -0.8478959334484466, 2.148798721270755, -0.6786624509926275, 2.764969609547984, 0.6257368297463552, 1.0021767637786663, -1.9824832598546676, 1.2930732169228356, -0.7141626429179483, 0.16416793099661064, 2.176372087899613, -0.2631111151394713, -1.1155735115485244, -1.9875667704399274, -0.4501747272854055, 0.3587321563300867, 0.0833770765896841, 1.0043051189568646, -1.2797572580732834, 0.6019162321117137, 0.5525390715563666, -0.2925990036141919, 2.550291186431597, 0.6036992087162084, -0.13938989623713935, 0.1811968398385982, -1.1652898246236927, 0.39307104700617645, 0.7548555907881108, -1.791525161360999},
    {1.489480385938208, 0.6347403488014856, 2.0653900064692112, 0.46992521244774554, 3.8311615914216546, -1.5957055274047627, 0.13216862297315715, 0.32793358837342246, 0.29412566394934425, 2.01328315857183, 0.40392444930062565, -0.5768500038030488, 0.3050136227825127, 2.3003145967073935, -0.34441922398214325, -0.23466279348894659, -0.9982742980117847, 0.32842131962138893, -0.259185386154332, -3.3988098167185443, 0.006843085582468115, 1.1776248820364732, -0.7388368260664038, -0.09984306987747606, 0.4757025165278482, -1.6020583498919039, 0.7267702177299887, -0.3194639811117143, -1.6456325234953793, 1.4532936201158662, -0.7780888115247159, -0.5587237348007899},
    {-1.365099695346154, 0.5043698716038644, 1.1381892553962556, -0.7175764240299597, 1.599382835976077, -2.0621820194469724, 1.0303466129109327, 1.775386302735828, 2.594633595640993, -1.016570388225176, 0.9781152548618457, -1.3438544788328517, -0.014412652120233125, -1.7552916860654533, 0.591294357071251, -0.22992907116826936, 1.3299265485593046, -1.4607495311873913, -2.3661723098678205, 2.5284961445327614, -0.20072312825090818, 0.5984736688062275, -1.8570004370749087, -0.17248889811927035, -0.7831709673420557, -0.398605965298245, -0.5902369054869444, -1.8760080659672362, -0.38199591737733385, 0.7507022210177042, -1.3290027169942633, -1.915853285879537},
    {-0.15865431774743907, -0.2309462120433307, -3.021140596643855, 1.9426867174478728, 2.169150166093562, 1.4970436058986225, 1.152144510013717, 2.063210431617323, -1.4274629822633873, 1.7381103541373122, 1.218963848819564, 0.6918049331009827, -0.0635280333866752, 0.6915352957553774, -2.779079559595593, 1.2335646666826243, 0.5886115515975708, 1.856609525057618, -0.7206338819307223, 0.39731686589574955, 2.1788208321526303, 0.6533732679585762, 1.8418518185331159, 2.118404009564474, 0.145715865477163, 0.9467614942192726, -0.03968883032233661, -2.4123697421945454, -0.8859204741581619, 0.5787325292959562, -1.8783253148980728, -0.3253362073411522},
    {0.0471640442657813, -2.417269507519516, 0.9376785961392554, -1.3746294983948708, 2.6987738543104016, 2.3766088862105477, -1.5875473873886667, -2.1992797408905043, -2.109962468665319, 0.26134043992803085, 1.0590117315866645, 0.7823853453407845, 1.6238835990088951, -0.6235173596474205, -1.6176770354368921, -0.3848532151942935, -0.21523152248678618, -2.3542844870106836, 2.325672844551178, -1.3774202511642162, 0.06403909931511204, 1.7007078941333273, -2.0958635854407794, 0.053128723754370104, -0.06256597843194861, 0.30534305251545035, 1.5392183537592796, 0.3491370234666445, -1.8449604953559533, -1.5085392672190558, -2.9646389122761567, 0.4671130206903529},
    {-0.5694045738680119, -1.8938109116858781, -0.6097851806316961, -2.134056905918271, 0.7768401859122858, -2.6601799786610663, 1.4765702470337159, 0.19070013348111828, 1.1651781584536498, 0.061569834235140175, 0.14637378427916622, -0.3292254234139845, 0.6789005448111615, -1.1498713188448824, -1.106286956102915, -1.7938054216929433, -2.569584862304729, -0.29030227178099777, -1.0233388386675943, -1.5230719234313814, -1.1730666844440722, 0.835898609485723, -2.687759084425497, -1.159911218302738, -1.7052898989640763, -0.5548248133979006, 1.329226317606692, 0.8143583438890087, 1.6843609234840398, -2.5223807829810405, -1.8805119070392924, -0.5295971151938413},
    {1.1262050888963335, 0.14311774514907646, 0.6839481217706216, 0.2847334887623466, 0.4157022056132541, 0.8632525491192168, 3.2030078413501752, 0.8844960728483714, 0.8593531251835409, 1.7666596202514115, -1.0972314530155325, -0.5819886837230503, 1.9380551131639314, -1.431314988217555, -2.549621522211007, -1.18159450054018, 0.899102904435924, -2.5743479023236837, 0.6707647548648397, -1.7636364689872577, -0.17208294024670298, 2.4874100405525006, 0.6119774484064174, -1.8672048540786912, -0.2569182786480742, -0.4133599947043308, 1.5125249265152172, 0.8802472105016014, 0.5115981505877769, 0.6117708925862702, 1.728964610475247, -1.6442942807574632},
    {1.4524700607189704, 0.011951433860949197, -1.5861268503274575, -2.3691874401224116, -1.1448905956505115, 0.3402517202887431, 3.5703601275356727, -2.086637229031695, -0.36877761780003965, -0.532958179735209, 2.0077123944602264, 1.3512363946557917, -0.01201643020438382, -1.266791673599204, 1.0485976924638372, -0.14268910013478428, -0.14873609402838156, 1.1990632485636985, -1.6642416870310393, -0.4122447993445488, -1.8253914305481325, -0.7270794552582126, -1.1548559868212116, 1.7775566361653181, -0.5849068920970625, 0.016703073142477796, 0.8479072390577138, -1.0979711644536418, 0.36911242413391376, -1.519803580862756, -3.087717142533638, -3.243377006605313}
};

static const float b1[32] = {5.466398027373928, 5.255058324437047, 5.676027637699359, 4.773245056166256, 6.158647881084384, 5.604917115697985, 5.654474993410323, 6.0267364589346055, 5.213929873603383, 5.931259021317906, 6.211385184994827, 5.520447144625296, 4.623893289804438, 5.217412234925877, 5.564480039685339, 5.813879871895919, 5.839444358183085, 5.600758661243065, 3.9530905744356337, 5.628072386867315, 5.60932318505417, 5.891390649568942, 5.803903736397261, 5.780337326494601, 6.4312849022115435, 3.978731328882683, 5.72999693255168, 5.928086085597919, 6.057321843634287, 5.760545543717191, 5.8380607478488065, 6.0712977632773715};

static const float w2[32][16] = {
    {3.7361203461552273, 3.1360450803530355, 1.9188798511397334, 2.2221526480182496, 3.3602626928097954, 3.3059747783438587, 4.204761684232351, 3.670451808911723, 2.00537643653592, 4.875695626311286, 4.28972895528762, 5.185459375308042, 4.880718993604706, 4.656693660976342, 1.500460897289223, -0.9567740622288011},
    {5.123364314811465, 3.180777522062921, 1.8389183549567336, 3.877589574016854, 3.166759708515191, 2.7846567869701953, 3.830505248948076, 3.3019688813136665, 4.17234898460058, 4.777344075605992, 3.6116148427461767, 3.3769465301374564, 4.953778207548675, 3.725101528287508, -0.07429812434886286, 0.8111059227068186},
    {4.696733945855786, 2.378023184669415, 2.2764116890251542, 1.6276932195286709, 2.3527353366979336, 2.399156263247474, 2.5761716435258712, 5.4965993790378995, 4.407143190281866, 3.2081250120830127, 5.329306654897789, 3.3455784398283783, 5.472863812615416, 4.267908432458632, -0.04544161314949235, -0.3713808866591737},
    {4.665543102893453, 4.679246319901004, 3.6086362978867763, 2.159394592164286, 0.974262647001922, 3.769750759302254, 3.026923755090746, 3.9079098926600597, 3.5624285010367, 4.310857183017934, 4.724673908075283, 2.095099406775761, 3.6377328031398743, 2.3426010852689494, 0.14632499799408386, -0.2887533437104687},
    {5.209145665538274, 2.9237390476706655, 1.1324488662134389, 2.294990200977327, 0.4152645430442753, 1.6951229603162556, 4.660391624524682, 5.224234829843509, 5.737145884952749, 5.7974473127934, 3.9934357452590454, 4.690355556056011, 3.8430975954174094, 5.162146016797955, -0.3525321192745547, -0.09664053782654393},
    {3.0712115686108286, 3.6081719855623944, -0.7230038059214301, 4.168381811559512, 2.4811615998844885, 3.625556914121054, 3.821292775762523, 4.268860228302961, 6.661888795883402, 5.660887603533653, 4.88326608257511, 4.912509986802722, 5.305147027961743, 3.392114207162867, 0.22592478576871666, -0.35424645183436004},
    {3.0508883386967067, 2.9854221062886044, 2.1614711151997814, 2.360562807760208, 1.8144242366776169, 3.083069148859349, 1.6927655849074286, 5.18077476813627, 5.472958656501017, 5.804056003730475, 4.351187550963446, 2.1767856669684957, 4.287053098966693, 3.733244565918619, -1.071193835055551, -0.2060524243978865},
    {3.5649739862509344, 3.398550449077207, 1.179325623222935, 2.778768897430645, 0.5790099311839095, 3.0916006430672285, 3.3563634557594666, 4.8950971708650926, 4.682562859101813, 4.7676794822177255, 7.712965704067843, 2.883483313951699, 6.096695899159898, 4.4553409592756275, 1.0471211161752163, -0.9360455833859305},
    {5.815554312957374, 4.668103863333044, 1.2720125682715386, 3.7120773828140727, 0.8070009814313301, 1.98294754110137, 5.093431559146337, 2.4951926282960857, 4.318018694925454, 4.016551883048989, 4.18330109943452, 3.274630152758198, 4.6514577828399934, 2.652526502539431, 0.6508921844424495, -0.9433115222242504},
    {5.510697808038473, 3.1368649469869982, 2.485703438390849, 3.1164601848251383, 3.3616996289612153, 3.2123393196810732, 5.266451115468503, 6.058624247769281, 4.346616909040874, 5.6417645552752935, 6.819263575822759, 3.5199885739680714, 3.9085414332336796, 6.24260142229981, 0.4361807277802546, 0.5568235408586549},
    {4.723945382952521, 2.8551439112867496, 3.146059895548005, 3.446821557082549, 2.5035603695028654, 2.395543724733388, 5.451625801356016, 5.682607529669629, 4.241935403639452, 5.89813420156269, 4.187433439380932, 4.562928467176791, 5.5695986666480275, 4.448207253677581, -0.25733936677716374, -1.701144831603833},
    {5.214898319042834, 2.159085969313561, 0.5477654181222278, 2.0259749524623474, 2.3780984931930074, 3.3204857889073045, 1.8922162963954308, 3.8410289804507443, 3.248280112337672, 4.348581835938131, 5.425970034227578, 3.795303676038291, 5.0174876900702206, 3.3113686786073813, 1.2996441913463355, -0.25388161988880814},
    {5.841613531952232, 3.9525531210626763, 0.8587626128365629, 3.1891254241907774, 1.8104094596473057, 1.4514903030199782, 3.5197711037770523, 4.278577849180735, 3.1571198338892135, 2.35302296329782, 4.405544971853242, 3.687158537474773, 2.4850654858788532, 3.36303636809301, -1.7345366599313585, -0.3520692932342875},
    {6.056925834187848, 1.8826837072682168, 2.6534549914125867, 2.5629155194685733, 2.891919815545826, 3.1989024698855655, 1.8283223690257182, 3.527958459878069, 4.895109448293948, 3.882302475653565, 3.928446298332253, 4.970763581984293, 2.7410758786418126, 5.6757524762720415, 0.44833322303930134, -0.39210825311588776},
    {3.6757746638515725, 3.5580947972269, 0.8396090370758267, 2.6719522356397984, 3.048555798881197, 2.1809742282277162, 3.3140953704430784, 4.409789730888473, 3.970777315743402, 4.2357612608041455, 4.717599731627094, 3.775594016633737, 3.4934835352267464, 4.16296161703433, 0.27651855391029156, -0.7339034396072954},
    {5.517156703295218, 2.0823655929851936, 3.322459629005536, 2.341136207350574, 0.1346907985900312, 1.4436952921272175, 4.324627806878694, 5.018376675526016, 3.595184442046821, 5.002625950799763, 3.684937275290135, 3.543708543175126, 5.676824610070149, 5.0721325019163706, 0.30566316616169037, 0.971022994580398},
    {4.282353937345205, 0.7584070586420665, 2.127958973277522, 1.5652012854312678, 1.6834299542762727, 3.9886330511101966, 3.3697355322127667, 5.509961314339188, 4.523738752399908, 3.945997563821388, 6.232986353239302, 3.917760511485746, 3.8584114009715718, 5.700660571933973, -1.0561869362232394, -0.30504556869335625},
    {4.344388098323217, 3.222490472460077, 0.9315995863306019, -0.01806720653942144, 2.0185238883560204, 3.16832623649767, 4.301961105506363, 3.7448326979010655, 1.5722563526699325, 4.8092682850660005, 3.4062810166890376, 7.266068576842213, 3.9101692405515487, 6.023976630668945, -1.8572422796600605, 1.0615933592115117},
    {3.6654924824322626, 2.1739327849124903, 1.6098290420253025, 2.9156576536315657, 2.0204399731338, 3.435055222780414, 2.16901253939648, 4.303076667000409, 4.586915043577894, 1.9986081898013197, 2.458800557025333, 2.343358279211532, 4.620400902615016, 5.0813541692543, 2.028847536879135, -1.6647538806947555},
    {3.6624423529427217, 3.9289569577467622, 0.6356248491605632, 2.149888514526024, 2.2975226765545607, 2.20254323511299, 1.84889493163078, 5.1292952932703, 4.044009427622949, 4.033906146679811, 1.9350634875082695, 3.5172448717547726, 5.030023221024777, 4.758194573512204, -0.0578387745278665, -1.0724741198154693},
    {3.979856428153062, 3.7869994434298215, 2.640564280335413, 3.0645417515529094, 0.46995420178760183, 2.7909960234272417, 3.8542486971220633, 6.188366981062397, 3.96016364323367, 4.71040426565776, 2.6288386037067517, 2.1896367990868097, 4.163231616813418, 3.116898221489762, 0.9164318376210379, 0.9022238484855182},
    {4.489009697812573, 3.1532794500346504, 1.8655923586228036, 2.5089028220916543, 0.2141336238664153, 3.21206595159043, 5.0829108738938995, 3.7530002794714528, 4.342661915114003, 4.3892201178964685, 4.328702677084785, 4.094359906106636, 5.731106395240197, 5.17895434408762, -0.1231340931646637, -0.9936071587170359},
    {5.781083911180432, 2.721521991225566, 1.1039570974007593, 2.0355501938992235, 1.3615975390317652, 3.1663638160211036, 4.56322595226086, 2.857944547311001, 3.4234053207565758, 4.002464799093847, 3.7239935751905984, 3.868632791493206, 4.8310645048828516, 3.6640969983751206, -0.3407095602116852, -1.7185563514856972},
    {4.890107558891874, 5.363095353228394, 0.15936452868363576, 2.5651562481168293, 2.3692758043064526, 1.6644346523411717, 4.068760015872992, 5.620842010097634, 6.044298916125572, 4.583494803419175, 5.275730764929482, 4.029650726143381, 3.8637769304551752, 4.236566840680036, -0.1862175906726339, -0.16831559004350047},
    {4.820708938607162, 3.5399611887555285, 1.7365821706678235, 4.2124460901686165, 1.748324829115673, 1.8586074929778016, 3.173054833828712, 5.363480561384437, 3.484619490073762, 5.479401801507487, 3.0274234098744386, 3.8597183371368606, 5.291401230681263, 4.608914605697227, -0.0646783411916671, -0.26004638485157183},
    {2.063372411278999, 4.42160041336981, 1.4025765292214363, 1.7025262399697472, 0.9178421481130502, 2.8702507361261604, 2.570043665678601, 3.340573669403314, 2.4997843779127824, 4.2850397261487165, 3.0014717157175035, 2.5787417593397457, 3.1681864988129154, 4.152056019812969, -0.699901900903784, -0.5559029806966753},
    {2.914477693384672, 3.977166210581102, 0.988398914022557, 3.023860349513311, 3.2951708108141684, 3.129347538781023, 3.743982007774013, 4.710979306232215, 4.2959230591204625, 4.919228067521083, 3.9329184230104794, 3.5821113046743163, 5.485499620721604, 4.585508954149821, 1.2279227281813145, -0.9452113920401438},
    {3.2162509578673633, 3.5859867575851894, 0.8209781878669498, 0.3222160707707528, 1.6124215243661428, 0.46069101320163486, 2.7258315745367097, 5.062511965444629, 3.3842110233517775, 4.02517180712294, 2.924208069105398, 4.848488109534173, 4.723182166114513, 4.468810956948252, -0.8952468955727352, -0.7257454505820351},
    {4.067956334657838, 3.4996970516207964, 1.342994699242004, 0.6961607549236639, 0.9391743196737724, 2.7996099722432013, 2.2922080498599864, 3.9992510580773803, 3.2958487764623157, 3.808211861384452, 4.823822644194443, 4.80626138221461, 5.172156537386847, 5.55665578373301, -1.1294717553064182, 0.1431050670107758},
    {4.400972906339523, 3.701760121901002, 2.1008658859181537, 3.269905213524478, 3.358770430658846, 3.652920946269715, 4.7459619703842915, 4.955918275626561, 2.730058858022402, 4.59362141143251, 3.7148552385167433, 4.236215140307553, 3.713063844872348, 6.321542533558965, 0.13616716751852978, -0.38389045711187364},
    {6.4371080169121555, 1.4911867762499091, 3.0708288567329807, 2.1113166653634647, 3.6107997402568692, 2.1862958805082338, 4.41368772206719, 4.6694746137255825, 4.258591800923587, 5.692753425970687, 5.079260629949649, 4.581855242703242, 4.651178575329661, 4.052388677593083, -0.2545346127329178, -0.9779181841332159},
    {3.729731711566652, 3.4591760643494225, 0.5007699540549793, 1.54138909344969, 2.9999545429708494, 2.987695115150041, 4.6883830000619415, 4.534091523272309, 4.574853778296817, 5.464400765599506, 4.736938688478455, 5.173892111739999, 4.029001558217401, 5.725515914577138, 1.3009248307757166, -0.04818168867203183}
};

static const float b2[16] = {5.865919183743106, 4.276069421250693, 1.6999620873476964, 3.1848497508230764, 2.47725882741196, 3.857794237428513, 4.72073074160527, 5.8930989655122605, 4.672722960068229, 5.86634233156283, 5.22718740071733, 5.1990581435871945, 5.661645538631083, 5.577731017516965, 0.05636802414408818, -0.4830494292239456};

static const float w3[16][12] = {
    {-3.58587654452344, -3.525071083698704, -3.6903725254026534, -4.118906052373513, -4.985238994863346, -3.9588086190427685, -4.218023567596828, -3.6970800010211997, -2.2897431995394864, -4.480117120663327, -2.7980081718097245, -2.3541972371629454},
    {-3.0250252919708007, -0.7587696933516431, -3.5463226895581212, -3.898979583027743, -3.948880805208488, -1.9307850299407363, -3.679703931008677, -3.7210225308199334, -1.9853757093484863, -2.437181663451007, -3.721699653357902, -2.2205925338263883},
    {-3.236471900671918, -0.8556052054841677, -1.1475075522853333, -1.772775169596955, -1.4783571266163533, -0.9621011676240014, -1.2819049240597036, -2.534427093184651, -2.944282672275932, 0.2990916225930112, -1.7579393367469538, -1.621590468327706},
    {-1.8458638601203974, -3.5481110344645237, -0.9201395819891783, -1.8633625705866392, -2.0434851787700836, -2.8678148061098865, -1.413512546488678, -4.174238715892557, -2.652396133907254, -1.0533191956240482, -2.0321303973627747, -3.436187640854558},
    {-2.08798343063624, -1.2480454226625606, -3.196126581763848, -1.9984655897958667, -1.6883565211902367, -1.8568068733824905, -0.463359924710418, -2.657617390227071, -1.7353396730390864, -3.4264443109194147, -1.9033642740369467, -2.6585017364568673},
    {-1.5012797627941243, -3.5128877237854534, -4.159244296310605, -2.305668577785487, -2.0947845260585134, -3.217234010161709, -2.1688119543730675, -0.4960174042494087, -2.8771427093121784, -4.2918220776591, -2.4527724974106477, -3.3097402308282615},
    {-3.239588690866893, -1.2602553981466589, -2.3591687218143806, -2.9485476987294943, -3.172677576605266, -2.5537793468015204, -3.323686611510355, -2.645402126334778, -3.36727300938709, -2.735563525891432, -1.955575492637662, -4.015075578000673},
    {-3.606587867078408, -4.446511559717498, -2.937374272263089, -4.550148947389106, -3.8218072415319138, -4.946179466370017, -3.245323540915509, -3.364098039012488, -2.5869372991952755, -3.151434171290995, -3.158136229035788, -2.9987175165854993},
    {-3.175178575800138, -1.5187163464478197, -5.127712133033204, -2.7472755560415143, -2.006679916295363, -1.832669771786813, -4.400013708768129, -2.4710933069088403, -3.782493322262961, -2.699392563008385, -4.5327104888810315, -4.739902761332717},
    {-3.414644992409814, -5.8915190587484165, -4.165405131649378, -2.688633929114981, -3.2328931188674703, -4.500055052027457, -3.9742783474488546, -3.293638798578965, -4.760568323072261, -3.886922360342484, -5.068309716550343, -2.7122858769906584},
    {-3.146767766891548, -5.736373641240867, -2.2886763225805216, -2.8195017745091957, -4.63839437142898, -2.978946181717293, -3.3301627733962382, -2.479878845437031, -2.9196811260584803, -4.250216987071161, -4.0781114191870875, -3.669667796259971},
    {-3.1919008284186208, -3.919260005845545, -1.7285710565902377, -4.306192826287898, -3.045039304089732, -3.4614018615138824, -2.7948036234154583, -4.714612194556377, -3.745615379807886, -1.4095621032307941, -3.500989307204051, -3.2542946597376643},
    {-4.46637978778356, -2.1258365838865383, -3.133572920863433, -3.4640765527062833, -3.7355238559820663, -3.820971980539431, -3.067843135614592, -4.271337132557042, -4.14856904977015, -3.78071458494707, -3.020457006284714, -2.5323947927198223},
    {-3.382602837351562, -3.0979972880684787, -4.302540104692391, -3.033966607493528, -2.1959352226196738, -2.8959948017018893, -3.7672749002071613, -3.0707377350157, -3.5296827103575508, -4.2742639050927895, -2.4567685351162214, -4.179845443740747},
    {-0.020501425801549737, -1.0319070378344282, -2.1187622449964683, -0.25818452613396997, -0.3298044087107867, -1.4217670149242214, 0.5096957830018808, -1.5374549466905045, 0.08544589270848074, -0.656464232336229, 0.15743772492912664, -2.2796284943226244},
    {0.9486173057835886, 0.8700623936665668, -0.03460458521094079, -1.7418061263894855, 1.0611056598053679, 1.3684338546191614, 0.45680466341695347, 0.6056851929365185, 0.8951961171152729, 1.1172989091133658, -2.979153739274701, 0.14388247562999582}
};

static const float b3[12] = {-3.0142719164711163, -2.8189412072520996, -2.7683474947839444, -2.8356604969715127, -2.646875676688999, -2.652920611933904, -2.8495383424246628, -2.517686081903256, -2.496610232253398, -2.54186379974964, -2.5689771238656802, -2.7924243339622428};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
