#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.20489173713805295, 1.3136727554095484, 1.1473991011299443, 0.875272213308086, -0.6254162798060167, -0.48364274518587413, 0.8391047654737107, -0.9399794197783334, -0.032196543843940335, -0.3360251465577539, 0.563311927467418, 0.46206359055352103, -0.6400568866698542, 0.9357616452197706, 0.3259939759296922, 1.2787819319984166, 1.4142764108478412, -0.13115576245778504, 0.4171064017234227, -0.4957202802432154, -0.20552285920979196, 1.0272780380665882, 0.06515445387069792, 0.3159227958009951, 1.2171137312885483, -0.7273913065012471, 0.4892140800205532, 0.9919213040881479, 1.3960501961837795, 0.06675002440338001, -0.7495135329999298, 0.5092751032949204, 0.3121312381373856, 1.335718840399724, 0.6257126434570227, 0.3556218742946471, -1.0315389887624493, 0.7899054136035177, -0.3934110999981427, 1.1535888069731355, 0.38535399851019275, -0.9566399638580939, -0.39443723804835024, 1.4259624696363729, -0.25045158853616356, 0.9565645945060087, -0.8499517874212608, 0.5979279553430081, -0.7008903060198943, -0.3408447583051472, 1.3097260242596251, -0.42730910146786655, -0.8299429976099418, 0.3482696658194948, 0.43879545631284156, 1.06846471240192, -0.5711965315421661, -0.32690532700308733, -0.7069483548513786, 1.5354638762187236, 0.6731082324733476, -0.0004050094191874325, 0.5180919441848132, 0.9057619722770207},
    {0.6012120613994784, 0.4916048372627718, 1.4022864864279925, 0.46739039644075625, -1.5971114292714235, 0.7257896879592112, 0.25378680000571413, 0.1538071482447131, 0.6800442654133654, -0.2584598683155431, -0.9604873547690852, 0.7015440440374989, -0.13914738838422872, 0.6235287758108047, 0.9221774139538007, 1.3097075969636516, 0.8132247907029285, 0.21026091634763303, 0.9313927636057691, 0.6260270230701221, 1.3702728390058498, 0.9921718579753064, 0.3238892067295944, -1.3090444420456082, 1.1785568073923167, 1.2109233933356682, 0.1450572930376777, -0.436759447337475, 0.8843747579780437, -0.786370644580447, -0.176557757148106, 0.6188354882264114, 1.0192685892664894, 0.6068546229288575, 1.2437960496092588, -0.7237557952218581, 0.04619823663728068, 0.06792643166687426, -0.4272417116567284, 0.5185365388773181, -0.711672775088576, 0.052597688686581254, 0.8121934771284326, -0.1952190290480982, -0.7610785724046126, 1.3221351928900003, 0.6630734549698019, 0.25150608168902994, -0.9423225628423175, 1.4694260220098379, 0.9592926117389194, -0.7042260099662033, 0.4023482955805121, 0.8758045645901291, -0.8757936116863947, 0.6953598447910398, -0.18236456039205562, 0.21344115251303986, -0.886082986612211, 0.7488717129112753, 0.4769593863477457, -0.2800409768352169, -1.137344922699641, 1.1738226621532728},
    {-1.0083267233595596, -0.3333950094355093, 0.26889384582721854, -0.7964128123026574, 0.5095365729511376, -0.08487680411331221, -0.06122499956091737, -0.6664042513782052, 1.5274485442967345, -0.3568320866953232, -0.1390926305664882, 0.04959559695528572, -0.2115257207378642, 0.9101865020608798, 0.740446318292536, 0.9513437729899136, -0.49609479052428884, 0.2386447227867137, 1.140341245384868, -1.0628124246543464, 1.4675995126688457, 1.1259007211855532, 1.666664626801521, -1.5546702790274967, 1.6917424534971583, 0.10634782282456083, 0.8448940796230254, -0.460763315191045, 0.6703188419290744, 0.2466307897473677, -0.3584067775488937, 1.0244818003173128, -0.29553171178604104, 1.203715347989726, 0.6256011423507195, -0.5880129917578043, -0.16656372752461535, 1.482403517741056, 0.9620342408757964, 0.14858516362984117, 0.5146361552824413, 1.0374434672181567, 1.3452276707312791, 1.0736741053438006, 0.2574704728448545, -0.36746803890072893, 0.2326250175937813, 0.5213218909407872, 0.11746197323317331, 1.0630922359163708, -0.3774671302574568, 0.015310419070728755, 0.8010828599771265, -0.38264067057699963, -0.375128541520539, 0.5074549994883628, 1.0776929891565676, 1.7033516852466037, 0.207195779933664, 0.8181976924037426, 1.357171057786569, -0.1177721555316668, -0.10904080311908376, 1.7430066454201607},
    {0.00807968265776697, 0.8672243470028624, 1.046828841406878, 0.3407771930379489, -0.7738146991962361, -0.7075326889330478, -0.5431784435931961, -0.6388062832836331, 1.179034927327431, -1.05196814833846, -0.1502675037258862, -0.40804932225122703, -0.31642386420693186, 0.23722577574409937, 1.354152303048632, 1.31136989600642, -0.5526920006689675, -0.2069182927497878, -0.10966080810886901, -1.122254133156403, 0.4551910165934656, -0.25437950414651217, 0.3354487081258507, -0.09496524123202432, -0.010482329411637084, -0.19721812287850324, 0.080496633809731, -1.0196107471831237, 1.276413458383033, -0.24835816462898105, 0.022504122763589537, 0.4447263786725374, 0.5257390350517219, 0.8631704661124505, 1.174227947819494, -0.2889175035053786, -1.6344537221088478, 0.463176109923504, 1.7343139716232043, 1.4855067810810088, 0.7180993250606463, 0.3908773420884852, 0.32204877813200067, 0.765454834386051, 0.5865109685636253, -0.9655484429219507, -0.7979293007433897, -0.8898484486375051, 0.4247903614532237, -0.2051784483754493, 1.1554791905313644, 1.1685277153120388, -1.2209230242990514, 0.8276927371128614, -1.1691126564533718, -0.965649048185987, 0.8320575644501951, 0.8072155824307558, 1.42105034008078, -0.12648837881997868, 1.1878089107529288, -0.1885542884452459, -0.39349249281334253, 1.6404951433794832},
    {-1.0545241506846124, 1.1158184137207532, -0.013703631413644236, -0.5605889005129864, 0.3641293321236445, -0.7569343710407482, 0.4990037912718739, -1.392148350028101, 1.0057747478855084, 0.2585660225099269, -0.7853449933861906, 0.6983888083744035, -1.507752020713929, 0.16578852469239513, 0.3110290217261978, 1.4739464402121494, -0.8129325554611407, -0.3747404331400803, -0.023268271515957513, 0.4149337164040535, 1.7115446359967603, 0.5845005808623889, 0.17088728188777705, -2.059860087109226, 0.25343762804958087, 1.1063360366549335, 1.2582871954233381, 0.16030698640798044, 1.637318844633805, 0.35374507659725046, -0.23368879327254172, -0.29399249275561545, 0.5913194541193649, 1.4293356915637632, 1.440487317448355, -0.6202959972430178, -1.3535594821734653, 1.4266192856562183, 1.8011583268164726, 1.050194969579282, -0.027686755499925858, -1.0194454664295627, 0.5725376549664518, 1.6954819531268215, 0.33949929403386114, -0.8938741659017876, -0.36592146421012867, -0.8090271571000278, 0.8104547247542098, 0.0455063580167011, 1.1089763019016285, -0.40631651482427616, 0.1482548317114664, 0.33057108114376527, -0.11470791298921797, -0.4172364749932338, 0.9039225348253408, 0.11502477583478571, 1.5678935166253065, 0.6499583168711428, 0.7774547967292573, -0.13434748450530365, 0.10553300655802607, 1.3806468979813773},
    {-0.5269194503823698, 0.7612607218177455, 0.506649025445971, -0.22316722161270963, 0.30570882752589273, 0.34341977019549924, 1.2380704495912147, -1.1722668973545465, 1.3903516953072088, -0.97390431236895, -1.1593026901367387, 0.15794396589747015, 0.2683475957335734, -0.19309822667039642, -0.3601380015984543, 1.0804019552128108, -0.6313053192621195, 0.009859676865318934, 0.7888096652053335, -0.7391402006060763, 0.10634795575262816, -0.5653318375533697, 0.29881229398421827, -0.8619822197600338, -0.006550625926246212, 1.0431144478471406, 1.562862698876378, -0.4504498089228136, 1.0987724025332763, -0.3020672820732908, -0.7590235659745618, 0.92012156403023, 1.1682608294526413, 1.032036512817153, -0.3976289259859878, -0.0463787404776533, 0.3190650682405174, 1.3558009956005828, 1.2059911291167322, 1.1790919170691354, -0.5372254728305035, -0.4800133415369052, 0.28973760289560513, 0.6394378539379926, 1.2524295639036767, -0.48901178198447337, -0.669873948371609, -1.4049384359434784, 1.6250782116141171, -0.903334596425876, 0.6100617615289465, -0.791982619252841, -0.12801441319868614, 1.0506834051381795, -0.6212967350372117, -0.7961121190214279, 1.52285710688958, 0.5526137423089025, 0.3890511162434958, -0.7291499300659064, 0.40689241399513104, 0.42613806591253844, -0.713947895561289, 0.05970239868918667},
    {-6.582039224646188e-05, -1.0157179553414701, 1.1386968699288995, -0.01881144230130455, -1.2509851585384306, 0.883362564712274, 0.8901238005775187, 0.5099367314585176, 0.06317623040866731, -0.8424222741209825, 0.31825888037054284, -0.060755198946309284, -1.7700597455841203, 0.9161001181173961, -0.2831697641471443, 0.6643362815749463, -0.8721810663642893, -0.975047410819346, 0.4758457903092145, -1.2180121833952127, 0.2019976038912948, 0.5824374727281563, 0.4422488775296776, -2.125371564622569, 0.04260150198360416, 0.6538543812037597, 0.41043491413136923, -0.22817908741324977, 0.6245679365112741, 0.10217827592628316, 0.5184525701520346, 0.8451235173550161, -0.17240281923097706, 0.9369282656034015, -0.32506414543252377, 0.7365529910609437, -0.5023553661544355, 0.6132416470845322, 1.087564790418423, -0.01627047679501429, -0.5762941445014205, -1.2496657116586651, 0.9246054174766557, 0.0833191535949515, 0.7628048651661616, -0.26600940791414807, 0.6439302412943151, -0.34308189069955297, 1.5854501702862298, 0.5550777413075252, 0.030009096081814155, 1.0010114249497075, -0.30030985208842975, 0.33074741370280347, -1.378783512938714, -0.668081445516702, 0.5143292380609454, 1.4864871902777006, 0.3013140732994719, -0.3135322469563587, -0.3189294923586008, -0.33749841986336687, -1.4756162173809917, 0.5935331368051818},
    {-1.9091768621264726, 0.536364058451027, 1.2541053010347096, 0.38678614385642457, -0.7784885277025709, 0.8008777381390071, -0.7563327728768457, -0.4741203784536415, 0.1469940259560299, -0.5595048629657967, -1.1990731640209673, -0.34585299224247323, -1.283571903961774, 0.09642731802074285, 1.2255264399760721, 0.16936614635828945, -1.1124868072545777, -0.4608485636259442, -0.16842230228399963, -1.1505394383594494, -0.3448694952134597, 0.05626337177176095, 1.1955781698776744, -1.8201260148321872, 0.13672968321291534, 1.2385949688591706, -0.38521531199052556, -0.2043671291672842, 0.46327666746729684, 0.640997746544139, -0.7836599168805578, 0.003618553673814594, -0.7578476757288539, -0.12678414466834745, 0.46879310233810995, 0.6501247014989138, -1.0921468621466275, -0.4396894708014508, 1.2751184640873539, -0.16647492609949774, -0.5909077838974951, -0.44003884999365, -0.36465535604399074, 0.9674940378462279, -0.2907322072843685, 0.18339658184516328, 0.352685913798254, -1.130891925675665, 0.5343932226646497, 0.15849186908242896, -0.7629669117542921, 0.522673523553455, -1.3659098313909042, 0.3075043654837967, -1.518556156904447, -1.4641658162702522, 1.1319106368360614, 1.4207275735669083, -0.28341067700481093, 0.10183447991504835, -0.38152724230938295, 0.6631111492020101, -2.044769517827435, -0.525180939635945},
    {-2.001360736321279, -1.2102761129548432, 0.8473153811407008, 0.24765600267945684, -1.0389366116929042, 0.4828539748403095, 0.9943306901477161, -0.742720816293975, -0.48959154915702496, -0.7353510981399597, -1.289350596806009, 0.5035117384840824, -1.0419397652858113, 1.0158754460585142, 0.4366076498183352, -0.36744439180355837, -1.3550106118583907, -0.9208670394443201, -0.5610617017015422, -1.19054003137519, 1.0078047065948432, -0.34309551493760937, 0.8261797000268897, -0.91568939062958, 1.2792622992398444, -0.14764077156822233, 0.970478604982618, 0.4413909449218198, 0.7836909374975897, 0.21672526067327097, -1.0688203175148583, 0.5090564993730843, 0.7561477193843114, 0.7618345262924617, 0.08369323705055083, -0.16301132797039963, -2.0452201190305, -0.30594069726936496, 0.5432750622048026, 0.7875236666791137, 1.182088326057995, -0.024189668927397597, 0.21273782980709025, 0.5045823333628507, -0.7213987565240991, -0.6623133519366993, 0.6750711289023821, -0.048608697971838415, -0.46291205740808244, 0.31066672376234866, -0.10342658970582838, 1.2384715359801592, -0.6294775811962096, 1.0588361952489411, -0.6041676761165632, -0.26715824989635745, -0.33426055733440135, -0.42705795871327346, -0.2955172581244714, -0.7607280048162159, 0.8182980275572911, 0.8559601581494305, -0.6249615977514514, 1.3528788301279602},
    {-1.5419062285429144, 0.09025837383040959, 1.5219079169718048, 0.7480695436399766, -0.748192085378759, 0.31121392203606335, 0.37972186075989095, -1.1450039650399986, 1.5811813956385627, -0.3944703777922841, -1.1765190649915596, 1.094134709554408, -1.9823374139124894, -0.2084821249455582, 1.5261560589288323, 0.7191627899355086, 0.4690093780777869, -0.617776029084244, -0.45012855683568315, 0.392513857839745, 0.10793094205251325, 0.2292047991263915, 0.8892365259719239, -2.0708113484861803, 1.5406928967291353, 1.3394417505666913, 0.6762992231761263, 0.5040153729526742, 0.6590694610214565, -0.4723649437615291, -0.9068047704338088, 0.4737594354048311, 1.3743874217335366, -0.4078052278143969, 0.6783563204289713, 0.06710188095497967, -1.6624466052414195, 1.331164123732652, 0.3642604088148047, 1.0630923183292373, 1.2294481623956606, -0.6501937658050168, 0.8582274426751705, 0.9701964429681679, -0.113438647474129, 0.9297583932867564, 0.898036441106319, 0.07072796181581514, -0.04959465597393218, -0.5070871135505108, -0.8199362962188075, 0.31290454571009346, -0.2633013841665785, -0.22912561002745588, -1.6440249341998239, -0.7146311562203095, 1.1466924669050929, 0.9403508247614906, 0.7177550478240575, 0.09616556362332083, 1.0272987032669803, 0.22230025291138225, -0.9898725416559401, 0.675975815286414},
    {-0.33850063036428524, 0.3517333550923461, -0.38090924749164873, -1.0197085932557401, -0.6356556848015966, 0.2676789940518843, 1.0257015168497043, -1.206107306958136, 1.3664741155262103, 0.29776202749624214, 0.008257652110541488, -0.3879768607698614, -0.3997203035909127, -0.25312217669114634, 1.4123485811000656, 0.5530741446794353, -1.1267842771610048, 0.21084087372615343, 1.0439044967252975, -0.07324185406072742, 0.4613026831515611, -0.31558668498715253, 1.491408055943927, -1.4025036020232997, 1.0338735917825823, 0.05895518112476414, -0.21014308801931214, 0.1810255033550227, 0.6955706713703456, -0.3757657050511309, 0.26038034718331193, 0.24469348562482737, 0.7883296410774736, -0.755130357365299, -0.17196853294017503, -0.30356047018176635, -0.053471789566867926, 0.17691337677430036, 0.3447558270776072, 1.051797529392911, -0.733744459730494, -0.6312568423456256, -0.2895339790472224, 0.4849732879616642, -0.16589841409350709, 0.16937760566479254, -0.32415855032696905, -0.44055402224438295, -0.3653723329074257, 0.2628351098825293, 0.16913283339069074, 0.34709069735695924, -0.6217367034617252, -0.2537466069284552, -0.752706453889776, -0.20245181760548958, 1.4297690963774445, 0.9147262429532489, -0.19116211042682227, 0.24745504474599583, 0.840081078322419, -0.4947609919512028, -0.10328304236287177, 0.7609722428127599},
    {-0.39062577575977503, -0.8057257117687597, 0.1865738897055271, -1.1340782725179404, -2.0474123032382816, -0.4598552790994051, -0.1455592720988907, -1.0474736258851784, -0.6001615619761733, -1.2472713136095184, 0.07944045741259485, 0.6533572382618649, -0.04676931050030426, 0.7189396287031701, 0.7546007188269754, 0.051692609396612244, -0.797808347849768, -0.5071540638615114, 0.4755367356924375, -1.1940624230324164, -0.11163054744834888, -1.2535600587183042, 0.9359352096752325, -0.6549980314950078, 1.300217205567117, 0.5246632543416283, 0.8548842267374333, -1.194003229089818, 1.0275146003384263, -0.7061716360389423, 0.013244532669526963, 0.8315426345324374, 0.39556767955494015, 0.1663069340828279, 0.7975689615258117, -0.7370557571975094, -1.8387105643661592, -0.42481220409422044, 1.1322554020472089, 1.3778235731234654, -0.7879787433609395, 0.6092651540265216, 0.23398034882096203, 1.2201752465263747, -0.8912672804892586, -0.6151795577035649, -0.5875522440729886, -1.6505790968537253, 0.07974495173781895, 0.515777076872739, 0.03132341815814695, 0.5647174027911991, -0.07147231712795259, -0.3163954770463418, 0.03568261995834215, -1.2377923550996042, 0.8091751361378028, 0.5686591108698973, 0.15547779657267885, -0.07974463574812304, 0.8305957920099755, -0.23643571404333566, -1.661944096647042, 0.7884240363270447},
    {-0.5744020116154362, -1.3837429572170938, 1.019920049012386, 0.3146870889185177, -0.42187429821821837, -0.045687237638679545, 0.6284564238778712, -0.8664589137309998, 0.3777968420894684, 0.32585295757985744, 0.1118646033233236, -0.06343645415006749, -1.194777962980499, 1.3816287806572491, -0.5840749217284511, -0.09252810777091075, -0.17570065359004067, -0.8341932763082414, 0.6771168982089985, -0.7342551115232142, 0.9156180020191426, -0.8464531413902783, 0.5719170791087606, -0.1792731216102738, 0.03529619613061563, 0.5699886733600747, 1.295152988087166, -0.23642660002104304, -0.39960267638855257, 0.043033564490712176, -1.1264583643292303, -0.02544603020186578, -0.9317353533897983, -0.477353282122089, -0.022461234938752152, 0.04367941454273172, -0.458150740772227, -0.36370118892665343, 0.6239752614418402, 0.14170411816333398, -0.6874834591452997, 0.8865269285259326, 0.3775874697133554, 1.1774816986985015, 1.0067887667318682, 0.5149164199069951, 0.8213373794175509, -1.2467176304909462, 0.036773344994342684, 0.1068960203400712, 0.04606238193000252, 0.9869852772470051, -1.0148491276690852, 0.6290011999384207, -1.2807847871986384, 0.41563088748032306, 0.62453540091257, 1.1840576599887276, 0.6899680881635321, 1.0595974340398484, 0.4565587977975238, 0.3713630842470001, -1.7127206575027938, 0.4449251744955842},
    {-1.4811037123578201, -1.263784025725577, 1.381621945213501, 0.10353751244370628, -1.7545587705226766, 0.8734691260860168, 0.8327941669618203, 0.09590107909747374, -0.06363062651574923, -0.45222183113328235, 0.20899370175672088, -0.37921870093471627, 0.017794284503926797, 0.973940584380613, -0.4295232523037591, -0.2311788065433259, -1.1611187503545373, 0.4209790590136016, 0.3730007990305157, 0.0805356549091713, 1.5236639776943384, 0.2627726259596777, 1.5061786923663167, -0.5542334687516837, 0.33172205897801926, -0.0926343303783645, 0.6941625907181405, 0.4431057489777931, 0.8274821779453561, 0.27421241272204666, 0.11957708341310978, 1.0867401302045543, -0.3144814966275366, -0.779726001902488, 1.3042843597968188, 0.6592925570236188, -0.7033881019547906, 0.7110731821429924, 1.3161632048555174, 0.2660528223279584, -0.4197016663282603, 0.5842697308844722, 0.693211765185852, 0.7566819779416322, 1.066058652235114, 0.4004287223288976, 0.4369380191922018, 0.1599412895864062, -0.3445475966806707, -0.49510129956051907, 0.6133925539967295, 0.06675061825368654, -0.7710852604270962, 0.1437672246387069, -0.06854994687356505, 0.4759819402881846, 0.4011630981818054, -0.26960217927310454, 1.390953654883898, 0.14931830316200453, 1.089784327597233, 0.9689291083529779, -1.4367783453341383, -0.18830562818400257},
    {-0.4916096160146542, -0.8445205456731286, 0.5964487060798156, -0.8121650190769674, -1.9246748327526901, -0.871967734499307, 0.7402063420899614, 0.09187670824813254, 0.8074956325651691, 0.3541082533175529, 0.034217293014749975, 1.3934206689970479, -0.9074170189640648, 0.8429281675827689, 0.8209390668150354, -0.41835895139438856, -0.646531681006887, -1.242412806461505, 0.7623601088253608, -0.9165427827972814, 1.4883394337035611, -0.2053250381888402, 0.7076628433186327, -1.0207760244019477, -0.01740795767499774, 0.09625078363060939, 0.2944735249836141, -1.013923496178777, 0.09207444239592308, -0.2509964425107873, 0.7736586142976868, 1.1843826399375483, -0.8789061821473384, -0.4385503753577695, 0.8976278034057981, -1.1646331197470392, -1.485405893242233, 0.4185228696700282, 1.3340393259794092, -0.07066656577061754, 0.4771650717128812, 0.6586490725053571, -0.09360975283888702, 1.0786915283026308, 0.6173183214104062, -0.11857200520821662, 1.1175664368718305, -1.5282358103984162, 0.7948500248979716, 0.6569008654558838, -0.49804174368617427, -0.12205902845962413, -0.2885556464998915, -0.19769118482418988, -1.2217589181857733, -0.4427744911088107, 1.0939838399167219, 1.1882937315835085, -0.4125500216635004, -0.39111161981439607, 0.9375100915523544, 0.9937852270449998, -1.2660248614551526, 0.7136237866126489},
    {-0.38013763636155157, -0.47574661678868385, 0.5971179931247825, 0.31994349147071854, -0.21691296378041314, -0.05909338561662711, 0.13944112083239166, -0.8589810137450755, 1.4531079316373203, -0.22051254041175927, -0.9021668069019585, 1.2594645977456855, -1.3157416935772024, 1.272640402472943, 0.6391723631978948, 1.122490638049638, -0.09814654484985616, -0.97618939741374, 0.1425558592948562, -1.3852472573736108, 0.8089542782208671, -0.0015451419830427538, 0.3918659832098408, -1.301112214962914, 1.3161309572856255, 0.7206603189870207, 0.8264858039065337, -0.5739930484201267, -0.10627800972609207, 0.47382329310987625, -0.367778118764385, 1.2499780632769621, 0.9611179091689596, 0.6095558202402614, 1.1920773742099215, -0.8240501012804038, -0.5427434790265576, -0.4922241413932292, 1.1600426031461917, 1.036102433233896, 1.3331491988329613, -0.08392428569087602, 1.090759836321204, 0.8474542784681994, 0.6088268380997132, 0.17534344547616032, 0.9564648363747131, -1.3385430260942597, -0.324391627234538, -0.4999304766510725, -0.49947864479242476, -0.6191741592833958, -1.129697079412303, 0.9782988190092261, -0.9509148006910139, 0.05343223504480054, 1.44788748348846, 1.6974172231731475, 0.569593535060257, -0.33855018694090516, 1.6424895326169506, -0.12528600567372605, -1.9270919734601883, 0.49181665339565794},
    {-1.3163578653112464, 0.4429584235528818, 0.11487061133027344, 0.21416530763627487, -0.7791880523587961, -0.5564173310136711, -0.2636487185487923, -1.0025096126385555, 0.6300081477884532, 0.13665342822044363, -0.19602610794268902, -0.1687276940762089, -0.4214063068012324, 1.3290240035563947, 0.8531947476711585, 1.463113888660257, 0.08547439967861796, -0.9001302430650598, 0.7447317805726226, 0.2038810483361357, 1.7893692909939518, 1.1532351617073568, -0.17410498899776472, -1.578094595849811, -0.06712006246631086, 1.135149651148727, 0.9390287539791391, -0.11177765017064786, 0.3236127665918806, 1.2412648625051887, 1.1596404938495355, 0.7729561856379656, -0.286555839191004, 0.655853718503905, -0.17933170577795518, 1.016345877186524, -1.0156013938682695, 1.610612201016686, 1.1570504423628105, 1.2116668836867002, 1.3415449621866107, 1.0955601222993898, 1.3577487193614928, 1.2032923087362117, 0.31614711303637316, 0.20198071595567293, 0.05891649287536032, -0.9183239231838949, 0.8507835894627676, 0.33419265759677125, -0.27900606199955524, 1.1251836418527923, -0.4703555881293132, 0.03474578286146117, -0.8101714546142269, -0.42014447159654966, 1.325817804530382, 1.4812139980566472, 0.9590107896774196, 1.265567162670015, 0.2532754203302802, -0.37511334039816085, -1.0610860118048253, 0.5633204046192721},
    {-1.4211149036766357, -0.5859736517708326, 1.7564545327586252, 0.7141716980776649, -1.2641102642472923, -0.9434197923287105, 0.1918449915583572, -1.2017163843369199, 1.089668501011693, 0.3254471667617453, -0.9867317782979291, 0.3734170825042708, 0.05172515371978268, 1.5294985045336302, -0.2168280842401879, 1.5126721457846155, -0.5839994096689523, 0.48532053689581856, -0.30238080019644314, -0.5811938963084913, 1.1994290083372496, 0.7801812458022286, 1.2111943051111584, -1.5935337746794764, 1.2517574907116247, -0.4994980776756121, 1.220417322953693, 0.6031098701652691, 1.5103542960329817, 1.3623452662256201, -0.6484240030393554, 1.3386118032284873, -0.02478316118984764, -0.0397368448252761, 0.08236054504514807, -0.8003575101836659, -0.3755092392937123, 1.6695241453956384, 1.2408492754894593, 0.16352069627144125, 0.8167943259134323, 1.2766460854434076, 0.4871984022595398, 1.418842335923921, -0.3718773630099624, -0.048865730612103774, -0.2722742984174782, -1.0105198178760895, -0.0856849625755494, -0.23029736423882852, 0.9619241154691531, -0.057095933411611205, -1.0163681614410192, 0.250788561410875, -0.38363380345836084, -0.032043620415069314, 0.6872033080785392, 0.28904426773468256, 0.9452258971042986, 1.2315527763803038, 1.4257711004372264, 0.5851836656653092, -1.5130946932965927, 1.3227887643136198},
    {-0.8034255654755978, -0.9068993667233435, 0.585967274547311, -0.5672370875129398, 0.027695439930011678, 0.2883298520971688, -0.7500102786542896, -1.494556738238589, 0.07961334012129645, 0.9357375978364882, -0.5509589008138848, 1.4739749829833908, -1.4124949903537238, 0.9775627012696293, 1.2526283086314902, 0.9501058421137483, -0.3505044944452425, -0.11603624367045653, -0.27313427804772383, -0.4434818776373669, 0.39011969707215116, -0.1982514936509703, 0.002407045589470626, -0.8929163319265667, 1.1279341673173198, -0.14852953802348437, 1.2164113649600163, -0.10411934316191143, 1.2748596897227535, 0.7054127057357256, 0.4889217795418397, 0.14233265398820225, -0.2719222062431448, -0.3731033849501716, 0.6200348040611693, 0.00972969386831807, -1.577583618511047, 1.5804917788374, 1.7852444889349368, 1.198334492786026, 0.5482803766849738, -0.024195859273651206, 1.271574228943591, -0.07735721585820717, 0.4673582553634935, 0.029554906160356477, 0.542074334619039, -0.8857412732337401, 0.014422110031116207, -0.20286633178059585, -0.8515025554646589, 1.4021818151040477, -0.6187008602569135, 0.07613851447335392, 0.3962429265435219, 0.8027780080078986, 0.865784426676978, 0.20487101739436323, 1.458583690112876, 0.12195577264946844, 1.5993679215057741, 0.3605214864742949, -0.2942056540951283, -0.3097288410500942},
    {-1.6381746914625712, -0.3039634001924344, 0.13746915348070587, -0.4689925785503743, -1.2589365339932868, -0.5664844686013748, 0.8629013856403274, -0.8586630451461039, 1.2171317576849812, -0.8662054398297739, -0.5570614622160298, -0.15436015150803054, -1.3279942730400367, 1.063438581667946, 0.7444450226068616, 1.6441773605281134, -0.27438235787818765, 0.6005484700161146, 0.7618963719232804, -0.09948929283119916, 0.018113182014546432, -0.7844584925266881, 1.7795355628010752, -0.39754416703328066, 0.8764681954470765, -0.10279779093361387, 1.4860338466518515, 0.3483906489019186, 0.06760454805855122, 0.07669493769274296, 1.0444670051479927, 0.8726592879913256, 0.6536351421378118, 1.156224734544998, 0.48369195915215724, -0.6898490702928387, -1.8636923671877947, 0.11887775435339168, 1.1654746916929375, 0.8888123980721604, 0.3585378306175187, -0.4862713647479556, 0.7982460334484173, 1.544062729900994, -0.6252760702558338, -0.7316022065345069, -0.63524855755364, 0.3970688024016592, -0.5166490772158995, 0.11802079996095169, 0.25415006574413673, 0.6945912576287486, 0.32732409503946075, 0.5957661539160124, -1.2726898321616806, 0.7477913100856536, 0.5774737528235859, 1.5932173651770725, 1.633082512670685, -0.6400417622923834, 0.641430279948453, -0.4176914818048126, -0.4311638393815093, 0.8497563064479075},
    {-0.6586903373362236, -1.0077572170375972, 0.7278667917410988, -0.8372436702868123, -0.7738859303592551, 0.40499242139297753, 0.3197382408818396, 0.11739228448485042, 0.5843286540691731, 0.11553599393525998, -1.044561391250617, 0.31723127185306604, -1.3998058639773816, 0.4897233146765731, -0.25717002558488133, 0.4830664958831872, 0.02458763514277578, -0.048124250365438194, 0.6061140923161067, 0.019210708237958743, 1.374654389256085, -0.6492717238193333, 0.9793918331240599, -1.3324760944886505, 1.4608319546749853, 0.18385056382985845, 1.593044261815083, 0.9158360676451149, 0.8488856094108296, 0.3922951800253726, 0.15401210833728818, 0.5538733765025292, -0.04366057884925428, 0.7861016655889107, -0.23402744119436966, 0.49038687685569277, -1.6407919359284329, 0.0994552424595187, 1.0094930935673165, 1.054431280977196, 1.5364154355150341, -0.032703866088200834, 1.2885009249142825, 0.795378875117446, -0.03217194998212039, 1.0531218036773797, 0.042456550576009916, -0.35017393242079514, -0.0535083525441613, 0.5411983452153777, 0.533718485634549, 1.34946778827535, -1.186633163488368, 0.28382376338239923, -0.534226213486928, 0.3186811252859724, 1.4631580809777691, 0.9145265832580582, 1.5443060662648616, 0.9614350030227846, 1.1433471736056666, 1.1387616803650322, -2.0089511104448143, 1.6398605899924696},
    {-0.7778524192611753, 0.8369403207171442, 1.243157393070292, -0.7705292098757928, -1.0047233925041226, -0.6538280025574571, 0.6620673837180311, -1.44161797710815, 1.2801144183957944, 0.389734886541058, -0.6863319349952546, 1.3894507418293647, 0.36574843308445243, 0.022276518268787283, 1.2265599474163766, 1.153379213529744, -0.3566332551260752, -0.25484738393339856, -0.07822759625601423, -1.111892842784633, 0.4566038568910853, -0.705946335813197, 1.016033824968842, -0.6914472282871472, 1.9726890031132223, 0.5861826374577195, 1.0499360144730816, -0.8798321438593958, 0.17870800235168732, 0.5865752216231441, -0.6762950889692414, -0.1570796378253379, 0.07089043039181558, 1.1162070662871622, -0.3723339541292495, -0.539189463567623, -0.9914089816154366, 1.5043273960201775, 0.30477117043368895, 1.4246496903423298, 0.29747666518558985, 0.7271533426383089, 1.309030505148177, -0.05382016993953092, 0.6481115504006097, -0.5670896871021683, 0.0785171835917437, -0.6392172171161006, 0.02215257288423318, 1.1076388859761193, 0.12557861607587004, 0.23964437266031205, -0.7462403554345334, 0.5485622000529102, -0.7569213315072791, 0.4802419035688002, -0.23362658224485566, 1.2567702614192633, -0.25802953552326446, 1.0273080016053833, 1.5441659720722232, -0.1863716367566431, -0.3810958727470162, 0.5649777390305337},
    {-1.0295553320246185, 0.5258993448562567, 0.7019043597517914, -0.4583249179737084, -1.0625550386819382, 0.8133505695633492, -0.37296097384259747, -1.1874251202175092, 0.5339467343318102, 0.22893532818695905, -0.8668281324747081, 0.31989303853200574, -0.16374999585932473, 1.671722085031754, 1.590606311674429, 0.9607422506635184, 0.23084486268154328, -0.6813393370635425, 0.5733542783694011, 0.4004606907903338, 1.2115829930015958, 0.9382297708197546, 1.6500902264428805, -0.5386789131265421, 2.0270100227902432, -0.25882521167378375, 0.7554065527860412, 0.1609260180861284, 0.5340411099575061, -0.0826631316688946, -0.5317433056943973, 1.5154259027863934, 0.9250357501155917, -0.2674496983516518, 1.3743134656932467, -0.9787028762505549, -1.2726396536232343, 1.5186577629603633, 0.8531641317260231, 1.5491939223867495, 1.824657284637144, 0.41509259372783186, 0.2917713114490369, 1.7566276245277728, 1.0322953358432914, 0.1098612087735524, -0.7055293234241726, -1.0596237476653112, 0.5814785840327785, -0.011218120748300071, -0.1633460487158521, -0.5620460801427212, -0.9067798341770326, 0.2767348965408312, -0.8783442123960481, 0.9090645526183571, 1.5465014452928878, 0.9379288925096615, 1.4971585679197756, 0.8112021389234612, 1.8031685233143606, 1.2266168672855513, -1.5211386688087278, 0.652412361958635},
    {-1.7326782986290112, 0.32024467939180085, 0.8685369488308128, 0.743149265752081, -1.8896099234269321, 0.2947095408241818, -0.14618542802996032, -0.2814370502079386, 0.4297201325887398, -0.6926468587976815, -0.07341472358379865, 0.9707732035533243, -0.9267462754911111, 0.3421321525047161, 0.882877037502592, 1.1942558842021445, -0.15537932513223093, -0.960667255203602, -0.32893041037721177, -0.07442869860665348, 0.014049162963242774, 0.7368360908624236, 1.19334667425012, -0.11734825606031946, 0.5448144527490731, 1.2587662928037513, 1.2935155493736215, -0.4373366516310496, 0.21714208602722665, 0.19580148630588717, 0.5883774028235566, 0.28104953963491813, 0.9269170242762081, -0.2398622564372273, 1.5147040920480397, -0.7535840221324261, -1.7374526281795064, 1.6102636060416544, 0.8734465940827382, 1.3455421485590662, -0.19482616488547144, -0.5609544808228123, -0.30194710139599584, 1.8079750911400534, 0.4224193586684229, 0.044549450220190724, 0.6286641019823054, -1.04668476965498, 0.8906745221683328, 1.0824869941320752, -0.39756169630803867, 0.7837245374062621, -0.4149797040519667, 0.2760517004304226, -1.0970000606447747, -0.6658862427226041, 0.135656046889311, 1.6165339631947626, 1.061340864864352, 0.8572979253734585, 1.1743533901554613, 1.3433855085736977, -1.6930797640651736, 1.5752205397401249},
    {-1.278283491425633, -0.49289932633125577, 0.7644570097608502, 0.8581414151567495, -1.20615825975152, 0.026627168963708696, 0.6664785141707115, -1.1822389564690725, 1.172639457635877, 1.0391782546331312, -0.7597992869477423, 0.12545726534936005, -0.114897475758395, 1.6836645580868308, 1.2009882075884242, 0.01983790828361546, 0.25697109900243065, -0.7855487379884455, 0.6446465638254756, -0.5827737294118586, 1.5915704282156353, 0.21436949443561457, -0.015033081538236943, -0.01763465179987725, 0.05637614245824108, 0.9413390161984906, 1.3505008156077565, 0.8932055574427631, 1.0037759595713907, 1.173224787950702, 0.8715857806522076, 0.31825638984865295, 0.1875770624074122, 0.057880699822763775, 0.7348766673070029, -1.1244221435083948, -0.5329581159839517, -0.4407084865808599, 1.5194863771396825, 1.605405340183602, -0.20403771756717776, 0.8174155800513335, -0.203883268633696, 1.4714288745113957, 0.6938032838799295, -0.2783507094249257, 0.9372188512058066, -1.4665658720162205, 1.2760628038346034, 0.43065089277987434, 0.5412508695605479, -0.45307937352972266, -1.2277095479933298, -0.6478302410833091, -1.1419893727616472, 0.0007390691292618695, -0.1896600654539119, 0.7216273330296141, 0.35739624203395526, 0.31021072128971666, 0.2617790824641643, 0.9130444050150737, -1.6038295591882439, 1.0144787937438176},
    {-0.9735090072722447, -1.020056380227103, 0.6915799050224595, 0.7573239856725928, -0.40754917856510703, -0.1663149818783009, 0.4725358342255148, -0.7978620548076483, 0.2802845612933962, 0.5948751898354733, 0.4873210280203874, 1.5584785274479118, -0.06042330533971496, 1.740787579206219, 0.8155103344407465, -0.038785636266609205, 0.8820170171213737, -0.7304771988817786, 1.3923062675331468, -0.05944754925886489, 0.7010743675044583, -0.822174958955339, 0.9594879140559384, -0.44820703510335985, 1.6868267318802241, 1.2228778678669296, 0.16112205824516246, 0.38977651509107253, 1.3149732295023635, -0.03613918818046748, -0.6726919005343986, 0.3550853362964949, 0.27642974884968047, -0.6662285650580532, 0.5026527847191217, 0.2661049523835423, -0.28078272535901155, 1.1874217523198138, 1.4293305050848875, 1.1010881085310602, 1.3792235753529742, 1.0701661286414952, 0.3811077880614981, 1.0213512322190172, 0.9931183718330262, 1.1862849697274698, 0.9250321471616785, -1.4835918620110067, 0.6576043073199476, -0.3274250805758215, -0.7729761933344339, 0.9540978021721497, -1.3782545662787262, 1.1934476156900347, 0.279966001145421, -0.2721867777003669, 0.699984438895857, 1.6920717226936535, 1.4248525035515653, 1.423658975602161, 0.9693240410272329, 0.3103087309973874, -1.5841628458227899, 1.6745745435219395},
    {-0.6837558317859983, 0.011322196590922356, 1.3117053349242827, -0.2214552023400657, -1.2208483808305797, 0.6129463938388046, -0.22270906736730844, -1.4018099571204843, 0.3071793446787253, 0.4698764724961331, 0.4904943429492072, 1.0646419581462931, -0.18701021926884004, 1.092138792533418, 0.4939055128139883, 0.3712496236949937, 0.01374229904157012, -0.7198599322415837, -0.23630517744116752, 0.2666728325485742, 1.3943619978481747, -0.28255408502111734, -0.04104272753785751, -0.8911254950039241, 1.6700446165567344, 0.2416394024096899, 1.4796161640559569, -0.3560006612519177, 0.49950915989411465, 0.8617940958274886, 1.1998431119575639, 0.43211456565668993, 1.1004452292843523, 1.3692712591535248, 0.000999018263318815, 0.8451965600963751, 0.05068888673563232, 0.9857862191151584, 1.839900935616258, 0.7851372295363723, 1.526043944344175, 0.04689747269523231, 0.14570402855723477, 1.6536458075183846, 1.0884005541757982, 0.7094296331473504, -0.009528416966130713, 0.16133661006611433, 1.1297364077361678, 0.39679539941147557, 0.41101310571318805, -0.09374553880885036, -0.37693375686418146, 0.09914186767725111, -0.5125589962618632, 0.10062109538012103, -0.23497509458898222, 1.715924947050828, 0.9026224147598021, 0.9424821127208451, 0.7969967401737785, -0.6475836823135003, -1.281718846198091, 0.44274234215475516},
    {-1.7545959917366944, 1.0679157507896002, -0.07176502079365996, -0.8051388445532395, -0.7014443965545167, 0.7560167505674849, 0.8748411595237067, -0.6449405303847322, 1.611384452745529, -0.841076689305109, -1.3434086378916856, -0.25790435318629906, -1.1718484854552695, 1.5111844714842126, -0.1240273642170035, 0.3529632980183758, -0.614991618037484, -0.3849672564546814, 0.725126810271254, -0.061312897467621676, 1.2081880414606307, -0.04591317194224817, 1.6514505647017954, -0.45791466862988794, 1.474116850983607, 1.340511412630261, 1.6439160973025175, -0.5345066690460193, 1.7570658348893902, 0.6652811086817364, 1.1077690859241942, 1.2619589878319155, 0.007383243226767166, 0.36038144451626997, 0.4472930428569559, -0.49899946960386027, -0.9482246595461277, -0.03341124843912468, 0.3161186218943848, 1.3314622550901323, 1.5707823800452985, 0.09922384847360893, 0.734559459910592, 0.9656937876560844, -0.08386115029717507, -0.2466531470515739, 1.1706706038084755, -1.1637879341005009, 0.6347190335605544, -0.21940026684589214, 0.038764344255380306, 0.30708980087329596, -1.1007044077990038, 0.6511675973221752, 0.4808528614148859, 1.0523375382781297, -0.3367881221041676, 1.1561263917714895, 1.260319553251946, -0.05903397032748428, -0.1919227429839363, -0.20698579115770244, -1.8372451301755421, 0.7204564436416707},
    {-1.627139446930906, 1.001107203577808, -0.09100093052405969, -0.03555805901901216, -0.1760034397838798, -0.5449632194839494, 0.6391223929319578, -1.5641807784688817, 0.1087992875684037, 0.23407970295430108, -0.8118568245787469, 0.34115970585707406, 0.11769291196592747, 1.0917533177967162, 0.3047631291176219, -0.19679535243732327, 0.2915260013525573, -0.2654582707002463, 0.39222844737343576, -0.607851713270108, 0.9303701898517884, 0.9500939860221598, 1.4751753057848276, -1.5940808331003378, 1.0200985892690744, 0.2748380355903239, 1.87594426753418, -0.6695313004891237, 0.4539514035020583, -0.4329525565721081, 1.2794085308081211, -0.058336306440366185, -0.5144837247090625, -0.294033759743252, 0.4221564980723255, -0.29512580153766976, -0.9007896026561578, 1.526424939400865, 1.5317499539859745, 1.7770336814115315, 1.350770316521206, -0.011154168502523768, -0.05223275320050634, 0.6480166966928589, -0.18170879224294892, 1.1120731640287331, 0.011062812828211812, -0.7699548261191953, 0.3447188751652729, 0.856765043411614, 0.5345993660123529, 0.9504835601286309, -0.707538460190186, 0.5470460464729072, 0.018698122541658785, -0.590820230504013, 0.3241538833967396, 1.0853686144637145, -0.06739738247630009, -0.3196539755767364, 1.2188007078412166, -0.24667322825964058, -0.7659401979858794, -0.1732821872300581},
    {-0.6049553514169536, -0.8666332254770911, 1.5310004431401871, -0.6707982152198373, -1.1873380072099935, 0.35635838375333406, -0.20589075517995015, -1.2619980868088485, 1.3608213613495734, -0.12028482529041515, -0.5196981213999547, 1.633404212028808, -1.5745600518620289, 0.740143223322001, 0.3648073016817381, 0.5616813645096603, 0.5387867372489694, 0.2444811699697968, 0.747910874545003, -0.8339167156143383, 1.7200793030655408, -0.26641792090846084, -0.17244430929188626, -0.9602647564297541, 1.4537455439220877, 1.445658558652338, 0.5949682104979074, 0.5258721948789306, 1.5687254030469648, 1.3034229920455886, 1.046047277453025, 1.2050332458757693, 1.0879659882266857, 1.2690269397531178, 0.16659309366119246, -0.010124702012372533, -1.4877926979904665, -0.09340159700294107, 0.9405882278671766, 0.11108498952872077, 1.524973754574887, 0.31935033430193566, 0.9646441231828832, 1.02247551456152, -0.6214354312446871, 0.2286219319185462, -0.1485434089623069, -0.5739517112937693, 0.5162647204286531, 1.4576854433414794, 0.11425054400108195, 0.577704364735077, -0.40904605348573797, 0.7041767876084136, 0.264815133568457, 0.1772341576188512, 1.3791411064455463, 0.8900714817252929, 0.3523318171739662, 0.3459915703391266, 0.7819356405785085, -0.22479228553853545, -0.5762598193083213, 0.5675446731111804},
    {-0.08560233455788942, -0.14060752981978764, -0.17431692433407758, -1.0098791749801603, 0.5061314063924182, -0.8884567355814867, -1.352589612547477, -0.5563319666158807, -0.06175864415228666, -0.5350017044349369, 0.3716343102144707, -0.09178716916846318, -0.24390823730668995, 0.2316485464693926, 0.15634361154654153, -0.9170099325202696, 0.8819919287007347, -0.7570053327236641, -0.914801765544068, 0.05728239732382787, -0.478562052576914, -0.37473416052089287, 0.8032210841113353, 0.8171335991089789, -0.784527202947076, 0.04629441224976107, -1.607790455681706, -1.6232995426972656, -0.25774216796727606, -1.3012417654061799, 0.0663317908995119, -1.00307714525484, -0.37346891905065577, -0.7266831856188376, -1.5552412114292196, 0.5900382851668288, -0.5777237222349856, 0.39791230885837864, -0.25690765552384676, -0.31016148626192774, -0.49817931609987737, 0.26604039924010736, -0.03902440387357992, -0.883464039240061, 0.08876725591544038, 0.30300672083867686, 0.32195967929139563, -0.2393958244356743, 0.4470951264510985, 0.6543202740000126, -0.7219472935967091, 0.10162342398126607, 0.8403282709704574, 0.19619509188809992, -0.9571473910352146, 0.2804140704955722, -0.8396098540533512, -0.6255904844697626, 0.7348088806070382, -0.5306554851913219, -1.5672475924149363, -0.7688000988203416, 0.6226045055163508, 0.3569913175825454},
    {1.248591455189692, 0.3161583814483802, -0.799281558299093, -0.012462109957458152, -0.659870955787673, -0.7957342013285419, 0.43232596905265697, -0.35587133915938185, 0.39279063620243654, -1.0090053138740223, -1.0056092185114838, -0.6551420295268555, -1.0137322253158134, -1.0296560986868555, 0.7070824559072955, 0.004816512394184855, -0.06179611945205462, -0.6305245344839241, -0.7686564698107914, -0.17832240104824842, 1.2209449699856136, -0.5867183198689706, 0.670942641612376, 0.33716775560216466, -0.6233470965732237, 0.9188038434453739, -0.3548069311844237, 0.1086462078531292, 0.7900131778597957, -1.0747795694799183, 0.6116140786144767, -0.7385698692488534, 1.1988047467798466, 0.4166572667489362, 0.8265869934928829, -0.710180217010291, -0.3880232738862528, -0.267729952483084, 0.8990781937077712, 0.7395938957465809, -0.9766762850141897, -0.7635191933120525, -0.04890594995565934, 0.15739836175334204, -0.30967715496444354, 0.3825038277244798, 0.3377669023670558, 0.9342624926968206, -0.05608618607690333, 0.0918185145214747, 0.56953615416669, -1.298119828626089, 0.4195431600958866, 0.8723721283158261, 0.5135363495727275, -0.4546928907562924, -0.6838324982884897, -0.6272691953403438, -0.7296398844165825, 0.5535385720053607, -0.5337826359352621, -0.8154142743518373, -1.2859722729187475, 1.0488445552168817},
    {-0.1376113785084162, 0.7000171298504082, -0.14914518942376714, 0.14785307422188654, 1.25495448852734, -1.0859892714262056, -0.3340637335878136, 0.955211305901806, 0.6221394345154686, 0.007347657253581258, -1.0340363726102189, 0.028777462053057055, 0.14062213414007968, -0.14620739434611654, -0.6557613455807179, 0.13283856982433592, 0.0312595266483581, -0.8611228847739675, 0.18252662938498218, 0.5947879781868485, 0.21431741836423496, -1.0630914040728296, 0.2769595222745327, -0.8870902430948442, -1.1441198270595565, -1.1950606672328112, -0.137449512652084, -0.9616739547542602, -0.02257001544264897, 1.0123095654893541, -0.9437331930561403, -0.6358007692374695, -1.381341289817716, -0.6196531338933347, -0.802668239740127, -1.1703519386929242, 0.9227384533164718, 0.34398804785902576, -1.080579212665443, -0.08685762765347545, 0.21847718787999992, 0.2312937579747717, -1.333355994386187, 0.012104380933639537, -0.14735311644024135, -0.8552094134157269, -1.361024091737282, -1.3656453766018504, -0.6887010395539356, -1.5325783983747123, -0.2161486836429481, 0.6841196966189135, -1.3093862366729203, 0.4694463655201336, 0.38706211690260783, 0.29644870523726824, -0.7431687935201017, -0.2707187314429557, 0.9159971988273345, -0.6991584195029626, -1.5024807707320949, 0.29458036421021544, -0.9815558006335823, -1.141595926314299},
    {0.7996650314789546, 0.5147806987935082, -0.5002762346244094, -0.2228453338446537, -0.006240913016285044, -1.1034926130269256, -0.4135126532094319, 0.6190491988309188, -0.3236457004030272, 0.40093532871506715, 0.4813200506958466, -0.028050023886162682, -0.23085248822251855, 0.40949590293367377, 0.6065230372516969, -0.9721747685347673, 0.5352912275450239, -0.39059164569481464, -0.667460519408837, -0.6910380213955863, 0.6538320650572381, -1.517913791640164, -0.15678611018010435, 0.17310322593774363, -0.9351511731836346, 0.4531352790337061, -0.240849264483922, -1.385521890811955, -1.4769996164798482, -1.317427802023757, 0.4560284826470445, -0.38448489623580484, -0.13095183048400744, -0.19106920875741953, -0.06967632888837791, -1.1873711318839837, -1.1191168854809483, 0.45930277913654904, -0.5346106758312849, 0.6189057295738454, 0.14713153029514275, -1.1433975223706843, 0.2043847219360077, -0.06666182981437653, -0.318131192302357, -0.4831124342548118, -1.6675851808023852, 0.24345004887880664, -0.43848319064734226, 0.3252612112535475, -0.8997934334726269, 0.9396568025769706, -1.1009462084804658, 0.4874290672052683, -1.1970193924905494, -1.1195554955881712, -0.12748531756702755, -1.026830725804086, 0.8478747572890504, -0.9693978154903702, 0.4623872487455724, 0.6559914538715411, -0.6739136023423671, -0.36027336585365693},
    {-0.5980946452198614, -0.3119453534491952, -0.08691090034941638, -0.6775771629170845, -0.42749388788427334, -0.3510895823311506, 0.17198913237011274, -0.7236731979339848, -0.8192935117110209, 0.12723415173937422, -1.51225811848494, -0.12195612043825643, -1.3631409202373546, -0.46128078297104963, -0.13450507880403825, 0.9769690829735411, -0.0049247597442955045, 0.9987690813205123, -0.6327636188573191, -0.6566170514010171, 0.7263863878079416, 0.30890999813709547, -0.02411761201600576, -0.9801097135642455, -0.6286976005913644, -0.12459097559966094, 0.9300283680880437, -1.2541823173919058, 0.20701564664872715, 0.8098518612104337, -1.1388720552191733, -0.8928962743848072, 0.37197417738566957, 0.18506624905352898, -0.28790105062246646, -1.1353464723944262, -0.37092134445854424, -0.6709644175868145, -0.08018461618516132, -0.29102415228366224, -0.08534946044697946, -0.5535701624457524, -0.39577220163235916, 0.60421122994975, -0.5156498350262382, -1.083937898870738, 0.5481496621712755, -0.14237809247656052, 0.40240682019820445, -0.3539771103210832, -0.8747412637301109, -0.07733155772326082, 0.5940862216958122, 0.3334975231973331, -0.29296162731191144, 0.2890657773638126, 0.5207253427517382, -0.04096235277499756, 0.7991647041412139, -0.8211357772975907, 0.8409732050680625, 0.16309410140683311, -0.9742078444488784, 0.3547703444325178},
    {0.8435924458710249, -0.8130150775327489, -0.9158323680196684, 0.5404881154541059, -0.6656520728974837, -1.2752156808849966, -0.7750063608504038, -0.3297481212833403, -0.45646451497491225, -0.055885217457570226, -0.7303958157471314, -1.1234496111335057, -0.7664634429605465, -0.9025192079315862, -0.6065618212038323, -0.7518675662828482, -0.27862064685006604, 0.6722608525082316, -0.7051611045555759, 0.7949680162081285, 0.37485028110430435, -0.40052387779469467, 0.15771199877988706, -0.665731686602095, -0.7570802151600206, -0.19101912609996632, 0.16601826500852027, -1.1577177100330158, 0.7684982891844729, -0.7513343306908506, -0.9290395949213954, -0.291878549829264, -1.5606072349116993, 0.6372058128655074, -0.6706529059084958, -0.8559194740488215, 0.43835255393037764, -0.8273760040161574, 0.7915947666299327, 0.5540775823967902, 0.4554977194942599, -0.11301045053630306, -0.014338195903054839, 1.1604076492651811, -1.1957406217246482, 0.40678289569574333, 0.32704955921467227, -0.32538232583320076, -0.5205600287591693, 0.6124843689630773, -0.056872577275219084, -1.431752591422978, -0.74997187700214, -0.6254543952717342, -1.0764544218440597, 0.17369186768255557, -0.5449303353174663, 0.15186865431649105, 0.3922814014779799, -0.6127081444713954, 0.6292168576238591, -0.5775697129233204, 0.07247127327957939, 0.671879843014097},
    {-0.4468407318948756, -0.9328956945851564, -1.0243769999395882, 0.6313451357221614, -0.12929733518059267, -0.008269748806428116, 0.12634370322786695, 0.6678926293236325, 0.6687220093663476, 0.3474773482697648, 0.44724299225069764, -0.24918852604440375, -1.132639019911299, -0.8333551535518614, 0.26530889372815775, 0.16875976125569928, -1.164163473851396, -0.7818431960068032, -0.002734735601372853, 0.10989284949285079, 0.5576274004757945, 0.13034906337247143, 0.9816527437584075, -0.2690204395499088, 0.2094118966266409, 0.3454130235199233, -0.77593391454684, -0.35200047168370374, -0.8673072573748528, -1.03752530068321, -0.3514334980915549, 0.5453186832244645, 0.28356460676776846, -0.9938026465305801, -0.6376794257244222, -1.2012973615489615, 0.8108664566637208, 0.38157587321209424, -0.4759990314278851, -0.6833225184697311, -1.2463601427195166, 0.14977467556553808, -1.2191205375559713, 0.9273154856848412, -0.6553275607004138, -1.2794622005435548, 0.3116825869546384, 0.36424139435334274, -0.6666024664797175, -0.9435700826986653, 0.02066820609311094, -0.7144454984310422, -0.006998091280236867, -0.5417856949660027, -1.2970539245432755, -1.1577051662630375, -1.089857773111439, -0.5878041661232573, 0.9693652534834062, -0.6445540122763137, -6.981080686573301e-05, -0.5789087631162712, -0.05243509171637797, 0.8017967255147233},
    {0.02777009834276403, 0.559861903824421, 0.08797509542941259, 0.03762526148613795, -0.7707938929199686, -1.1729432345164545, 0.41719262501154275, 0.564105585075717, -0.07309695915840818, 0.6725865317865476, -0.22056391440011294, -1.4008383099235309, -0.3341518435137235, 0.15919337631975522, -0.03275246953626874, -0.2570048589890305, -0.14799209881234993, 0.7133754247238764, -0.813166854139864, 0.40487443917471505, 0.2791230805497437, -0.5389542621304756, 0.9749121318242392, 0.29875814748029716, 0.2756295077974238, -0.3364749144512837, -1.3222276294523188, -1.0846778537893862, -0.33204291172246936, 0.1056126282567331, -0.3771823996306208, 0.2098897289493606, -1.055310785501976, 0.07141601338299751, -0.3885045808856422, -0.7711963729749279, 0.2024039834247942, 0.9173379938841061, -0.10152806326716542, 0.008217184353761696, 0.7507768804128195, 0.49703055446223326, 0.514755921738548, 0.09693927951728075, -0.9937724152879791, -1.3432048000505792, -0.5363905836992207, 0.45907358260067666, -0.31040153309656326, 0.3452214084187911, -0.21259322597598646, 0.39275774051532875, -0.8816243138954073, -0.5359070332979885, -0.7663055945379337, -0.1863907339343522, 0.21720670472808157, -0.990057293837761, 0.14996550643213308, -0.7751053623593931, 0.410920427742771, -1.0460359366647374, -1.3492057136804518, -0.8169644869118242},
    {0.08957256235591365, -0.30969699373531234, -1.261694762203228, -0.7549559459850788, -1.1509539455880902, -1.146987473968814, -0.8977324821765446, 0.4947485475627987, -0.7102873231539883, 0.43264473422863786, -0.6361431717671431, -0.884917376284003, -0.8637912506680294, 0.5635203334589636, -1.179248319309342, 1.0720013833719837, 0.4209518903644505, 0.5176107207961849, 0.21372139196369905, 0.3399288165145, 0.851962349370307, -1.731674147164276, -0.29871166554195583, -0.05911350236168129, -0.5957664394474198, -0.15892955481264984, -0.5098037464520577, 0.4972658346619879, -1.2795220045129243, 0.3849630208383461, -1.0899787506422147, 0.37088434371865076, -1.537004209378804, 0.4308268619552527, -0.19514948743392066, 0.2851997507298191, 0.5368750148023987, -0.9245640450764129, -0.6273212020404101, -0.33654531089525475, 0.623034676584753, -1.4749793899920964, 0.35967927252553344, 0.4020208307478307, 0.3367349116455933, -1.6121602332613, -0.9307259103842541, -0.8169968532774023, 0.06896019743111786, 0.5934935920126725, -0.620917015183088, -0.645630230842034, -0.43642537642183715, 0.7733384332290973, 0.7381113914024878, -0.40970717713430393, 0.8346048148286846, 0.015176158228909734, 0.05397916000149827, -0.8835112386615743, 0.4093700220999726, -1.142230347981535, -1.0806775078517412, 0.37940823015944497},
    {0.8022082438750289, 0.14627846388617238, -0.5396004237933363, -0.11117492396074231, 0.7745357028574235, -0.022311637210976253, 0.18963442966726135, 0.09317914219038324, 0.37667482341303404, -0.5631824052213139, -0.7581045113398923, -0.7057774279713807, -0.6104078687078083, 0.37389317109415365, 0.31115057628158393, -0.09032842358331138, -0.26122144581578066, -0.45327444010467277, 0.16355424068923355, 0.695423586514869, 0.6027161962362659, 0.5608422415088332, 0.018517086845013655, 0.044365093814877105, 0.8068762072705401, 0.53816858485045, 0.7006385503957789, -0.980986587097904, -0.15062823717901028, -0.025518747675612928, -0.8565607273864048, -1.2933621398174615, 0.3810080269335571, 1.1589713761110274, -0.8825894063352893, -0.3270048526027705, -1.366323047205864, 0.5584539881828564, 0.4365648031481387, 1.0895889476818725, 0.20777943333102364, -1.1291727794877844, -1.135164075072719, -0.4247333251493029, -0.1790915479719125, -1.4044071841732497, -0.5074285224134197, -0.31699851925743305, 0.38881086386475144, -0.6812969583950244, -0.8382675694123458, 0.47660924748948236, 0.368662416584198, -0.160297249671352, -0.22711694878504923, -0.5895536052679439, 0.37205525877168905, -0.38827401373164167, 0.3393009807779158, -0.3922568638980219, -1.2014109088052383, 0.37634586274188897, -1.3406995672201976, -0.7720105974714229},
    {0.28934453271908855, 1.0810528822597, 0.14323167005200027, -1.6273259001178886, -0.5026353063580553, 0.04063090162542067, 0.08780674415119977, 0.40719960319373266, 0.5451461642340543, 0.1796780943713792, -1.3770364568678823, 0.31723931185813736, -1.3635493641136105, 0.030772460944860712, -0.8946792123466059, 0.25239508654546045, -0.20555302200976833, 0.17270220720104784, -1.4875572872476153, -0.45861319761899005, -1.2923308009373615, 0.3012615416487936, -0.24479670950076224, 0.5546298169639944, -0.08340257474036342, -0.1695505687071941, -1.2643710721384616, -0.8188702744568201, -1.403478109964293, -0.12747100119309457, -0.42736550963475384, -0.1719097315805037, -0.48834812412981377, 0.6185298690608262, -1.2538250405483262, -1.4752872536941706, 0.05983999264724866, 0.8538448070074259, -1.015841872827899, 0.31299420456145155, -1.2067758490385032, -0.46375108269003285, -0.1517007909501834, 0.12230196316802457, 0.5360458314464686, -0.6785293324395595, -0.4696464612638466, -0.7175622059179934, -0.9427285739055479, -0.7025561768587045, -0.8895973317879305, -1.4182799817754412, 0.10714195465538884, 0.315227251088676, -0.8033744931306303, 0.3301529486024575, 0.27487407570517436, -0.7500064393401659, 0.147585305998847, -0.056417375816029, 0.13436175247324592, -0.5179660540567296, -0.4712227053805305, -0.5602324080382247},
    {-0.612068745641377, 0.1611863634984035, -1.149796140397257, -0.4186612066209391, 0.18541151103976145, -1.3359571407516821, 0.5756671188610819, -1.235762006472835, 0.8381670969171309, -1.3367442598499093, -1.4419232854350998, -0.5931194157510382, -1.4841770185805525, 0.4345049828079835, -1.4285035116290081, 0.08027871998902357, 0.5223090876185542, -0.2153134580267919, -0.786516782763735, -0.2125102699546046, 0.2790433518728677, -1.2157343053656522, -0.38476272587921373, -0.5858824585093436, 0.5999230492341902, -0.752762519060628, 0.07477878468137132, 0.32401373884927764, -1.273513037371821, -0.5112017033529273, -1.5666950742229637, 0.4866640298017972, -0.053713808299956804, 0.7855153343585389, -0.5087587073155004, -1.5974029788653474, 0.14236788960127925, 0.19813963661606016, 0.10461692018031907, 0.7888579542014279, -1.0816717304849877, -0.04966811310949995, -0.12357342649778832, -0.7261642358797676, -0.3621841010422257, 0.05286664574292978, -1.6021150368772026, -0.7779673431373436, -0.7119726337123262, -1.3974298917335095, 0.2382756587326722, 0.08680124243529012, -1.3363184335743912, -0.9437998524844606, -0.38380122487029344, -0.6889664208615192, 0.6597981046745665, -1.3381882235140616, 0.9000894581108401, 0.6852020693933173, 0.31531907212088656, -0.9602516451927606, -0.8817518305822643, -1.101882940185933},
    {-0.41711181142569476, -1.0528140222110547, -0.44938112854418133, -0.5860543344562935, 0.4104038628344855, -0.5333318666389686, -0.11197362835204952, -0.2875075268792939, -0.8602587666295898, -0.27178887282282244, -0.5909553194443141, -0.7758034275049446, -0.8764326589451867, 0.5150140788641185, 0.3462524799673543, -0.7616211526542014, 0.5931235697731744, -1.1673371807359527, -0.006468132013013887, -0.8487893385735982, -0.3904467937805591, 0.42231643642501715, 0.7768057274327788, -0.2644692037244292, 0.2567176315679687, -0.5843370394387495, 0.5581485706411796, -0.15329813355565655, -0.7907723938813285, 0.37475776947259076, -1.0243141206107509, -0.17525975517656464, -0.7690116646871815, 0.13000958631277074, -0.13477167594308637, -1.4406888112285887, -0.8790216640937435, 0.9922654630244577, -0.21994313572890498, -0.21339974137848447, -0.440741611825264, -0.04412029991555382, -1.0275159363832476, -0.009475666447452163, 0.48544001215017696, 0.21400317383066148, -0.14512837245381938, -0.7640318918579772, -0.8017076714831607, -0.8085854224780297, -0.18368953169561114, 0.3137937454249569, -1.4638996299606997, -0.4113646201632418, -0.9172506725908675, -1.1662673439875355, -0.7962845281116805, 0.47303151574715, -0.2136054246058066, -1.032709454591588, -1.2040398574337114, -0.5382346563168098, -1.5581398989940631, -0.9813723765740882},
    {-0.5753294654405104, -0.007274363655310449, -1.1154769752423994, -1.6417781296231857, -1.2053828448613484, -1.4848603772281903, -0.8912495560093957, -0.17386335519235677, -0.4337882451371061, -0.3446768923459236, -1.6842330082555057, -1.4418353696018107, -0.635772811439053, 0.5970482995637514, -1.135251512367775, 0.04716876109659756, -0.7272950793478876, 0.09349001477767388, -0.5643083673943163, -0.9433504708659326, -0.8387548817609173, -0.9097071501688945, -0.20362961681035754, -0.23520222829598478, 0.12359365881673934, -0.5840963789004033, -0.36384713729926216, -1.5249599447284123, -1.1816203293534076, -0.8625406084069369, -0.7533622244048849, 0.7071346937632155, -0.9869862802047616, 0.124420468406829, -0.037791820259423105, -1.6853130544018848, -0.9020170392904521, 0.9418120280585134, -0.18936684966180928, -0.0773815578403622, -0.8397625133062446, -1.6526025011665866, -1.0753711982544245, 0.26460003948338334, -0.6293060182834224, -0.26661978818610055, -1.128279055628265, -0.7656952037156363, -0.19042390041319787, -0.4358861620539354, -0.3001115115009904, -0.30112236454462155, -1.291737489532265, -0.4573580594519574, 0.32051697646510136, -0.42231062979385736, -0.479731613363166, -1.2854964066382937, 0.8102133373799543, -0.4412921733710462, -0.001183468266798987, -1.6482746384640858, -1.4994320036935653, 0.5475391599496671},
    {-0.2953005939278583, -0.12540844239601398, 0.11671859625204768, -1.1899799957774138, 0.5795997897671304, -1.0321905267800455, -0.13010060197494405, -0.34221878827166347, -0.2092158429172241, 0.659834742067351, -1.5007343432895548, -0.14315256820286457, -0.7655849456892623, 0.45035511089780106, -0.3372950022056826, -0.03211686856207616, -1.081533950041793, -0.8749383114211089, -0.32365002221814104, -0.7197535446594205, -0.5105556115650302, 0.12190308527144357, 1.0031175134707515, -1.6060827576714023, 0.6522121469457229, -1.0911351570753947, -1.224853975283368, 0.33356063680446013, -0.6451843056192397, 1.0495447766723585, 0.33162990293432526, -0.09613939823178469, -1.2106528619579644, -0.08905205983466206, -1.3890907046351761, -0.41240410555725526, -1.2353952891855184, -0.0796380217520163, -0.7194185637006915, -0.44963229671662425, 0.5791898794153626, -1.8261422007573422, 0.13601775925273574, -0.9769207769050814, -0.7028828859933256, -0.8751529940305544, -0.5644384764957576, -1.1790103471243594, -0.8660915204700775, -1.5510686199978254, -1.3340192519707363, -0.6125080729479183, -1.8461229267084758, 0.7406672712765486, -1.380120257060946, -0.4913045882478111, -0.06332932175669737, -0.46764297062487276, -0.7334499584880801, -1.06442642906132, -1.4371310640510047, -0.8127978263878288, -1.4365063540124643, -0.2921545205540658},
    {-1.1136870730209423, 0.1529739406519932, -1.5428675649608696, -1.6397971881650084, -0.5581669671637796, -0.7645925291276165, 0.053326743448836596, -0.49735138187824995, -0.5769881059691523, 0.3768006331872984, -0.04502704231121486, -1.14707303039292, 0.43020459926405585, -1.084713789157192, -0.573955795242001, 0.7025180450158106, 0.6540050509080618, -0.23831419562331552, -0.6555653770987061, 0.7139750102032778, 0.22396154258820677, 0.4814586838445381, -0.5094902499728458, -0.7908808777253531, -0.5928132966997554, 0.12434364323561115, -0.3265813443039419, 0.18568233982742444, 0.2310936275313533, 0.19171889207198287, -0.2299738923837324, 0.16943749168228447, 0.11222720649068153, 0.37878029866750756, -0.43955796755212134, -0.8155756037239105, -0.40620897293101504, 0.8282786685982039, -0.8649750738979561, -0.8917767615639973, -0.6883896711786288, -0.5273003860272473, -1.1980863939025588, 0.049898329094851625, -0.07729336091427401, 0.4208254557768385, 0.2609682250254989, -1.104964342231836, 0.7998830994435588, -0.7069647151758435, 0.38837834128120313, -0.005535921439652201, -1.294601878986744, 0.22429089308428038, -0.036952535193614494, -1.1186606276863997, 0.6494437807646589, 0.21935439934871295, 0.6604215519807496, 0.6544837617373668, -0.13969799333138824, -0.7390675448062377, -0.49579809165964883, 0.2629583924767333},
    {0.737939389639655, 0.71057604127897, -0.8307190730364123, 0.10230678454178337, -0.8403529118059019, -1.595467180703108, -1.290441368181601, -0.3608074210184004, 0.7627976282995084, -0.30648392582519834, -0.16546968786758356, 0.054389176966170495, -0.34799096235651283, -0.6711932781999, -0.4728102697412391, 0.989887604268057, -1.1850202654555733, 0.148750156554701, -1.1314697985388604, 0.6794986086730427, -1.2583277398196369, -1.3799421938665404, -1.1177072804346992, -0.5276407685388881, 0.5337240485397645, -0.8722839071770976, -0.921771022183421, -0.6681967957585814, -1.3457909900665423, 0.8648094254087766, 0.36250659546939107, -1.10536249827, -0.25075091911542563, -0.7123548959996859, 0.5769044480446291, -1.4501054430020335, 0.5121168743344255, 0.006024793056854988, -0.7912762945838384, -0.8816022646203779, -1.1773096973714214, -0.9003550221109281, -0.9471447709959072, 0.3779043971294198, 0.47031547277013946, -1.129256012625266, -1.3790474024565658, -0.9894204999360993, 0.3010766169598352, 0.2781247855557109, -0.9485898123978245, 0.06551452113915789, -1.4775995080490616, 0.9413708102225108, 0.7052912087932454, -0.5218905035468622, 0.43742582875530633, -1.4568894149766871, -0.34424698237337775, -0.2850594204418918, 0.27962024616496955, -1.0993620360726721, -0.26665754525705526, 0.06653466331634277},
    {-0.9932022928533751, 0.9116324134112643, -0.838967621933664, -0.7570205324789998, 0.7650735566898913, -1.5315932283275155, -1.6613377654278123, 0.10832903082016822, 0.38918950913218076, 0.6481064416854329, 0.5761723144180704, 0.23037984561622876, -0.8625854857330183, 0.6620934287280882, 0.5865091773715058, 0.6816253013728444, -0.9365741890382007, 0.7425051259550051, -0.3254703345803662, -0.7053474791925725, -0.8293608555045325, -0.14454594971121804, 0.12353850090717398, -1.2059154660471305, -0.9436159994598722, -0.6415678991547112, -1.2629305774013004, 0.06887195185372195, -0.3148748714132908, 0.9917753188598608, -0.7155512391084002, -0.525623105880695, -1.6526190494994604, 0.503211942901544, -0.022227566721926866, -1.0461679803440895, -0.44421712357119447, 0.9487799607154398, -0.31765131764011384, -0.14859686991303528, 0.9077031249312645, -1.283313638699265, -0.27573349295300364, 0.12615423801756195, 0.16612815840692408, -1.5797766432171017, -0.920584765546853, -0.4286205712418954, -0.7662147805796028, -1.275094966353039, -0.9118007700195514, 0.22378591091282882, -0.03713437738736918, 0.5856570094081442, 0.45188210566952774, -0.9473568879383135, -1.1134039280834827, -0.5852535405818744, 0.7916245470699587, -0.49280155562765227, -0.7373283429745944, -0.5161882722948827, 0.3416094604913378, 0.900410386962909},
    {0.7895810685463943, -0.593793356571674, -1.2299556607256492, -0.6311658781598137, -0.9418131786921058, -1.262974143228981, -0.6848532884058608, -0.06607881547515704, 0.7004626132646466, -0.3933476938188706, -0.41993602647272665, 0.10679099889299097, 0.26902117438216305, 0.10763335673182003, -0.9386047028884597, -0.11636773691246151, 0.3011973052950498, -0.9299407540622233, 0.7922755723171753, 0.8298459450135766, -0.8474621198739157, 0.7314057406562865, -0.30488103428238744, -1.3298217741037544, -0.6483047943728006, -0.9685149122866207, -0.06564750846720006, -1.6212611877797585, -0.7126091164686927, 0.12559276676350348, 0.3257622382352617, -1.1945465356293286, -1.6573127515380794, -0.37067780758316704, -0.917060087161913, -0.7925663561347535, 0.6038240415842986, 0.48616860521014815, -0.9884766018817709, 0.46552039318268335, -0.3804354775993091, -0.8979983937921417, -0.9688300450661325, 0.4938991409871077, 0.828056278534084, -0.513939187129307, -0.043589333889995883, 0.2076988824476351, 0.06963846646900873, -1.0665774673703194, -0.39353409412076534, -1.4378806075903579, -1.7074292934714559, -0.7969945507153667, 0.4101254013377859, 0.18345026620085583, -0.7629550772095527, -0.05186881569039374, 0.5038130671162894, 0.6512036811665207, -1.139747505462896, 0.3426260693753529, -0.9272371457675628, 0.6540714217504139},
    {0.5889592825939748, 0.8472849567489557, -0.6793101404084613, -0.7562585807338378, -1.1078258993438175, -0.3787096472720232, -0.7878498891852757, 0.5934166736806523, -0.16718643822355844, 0.08640511028142436, -1.401634709156422, -1.1722506687945773, -1.0626027739461086, 0.31418229739184433, -0.8517646884455454, 0.4207652595965284, -0.9360189421933077, -0.027472629710332538, 0.1620849061463173, 0.6382504129563176, -0.7946769637263188, -0.5468593038750293, 0.028465045747100605, -1.3024039383377277, -0.5349401020655871, -0.7310082342993889, -1.2945450696214347, 0.32285396694397767, 0.46961379579067447, 0.14104637269579465, -1.2217565352161721, -0.32396171241096167, 0.2872198006796526, 0.8958861464948384, -0.5953906874825275, 0.3494981612111593, 0.11634645758639377, 0.5762128860990938, -1.0156539720222404, 0.4063286653527428, 0.14503299903935332, -1.6906331123645852, -0.48216797570569714, 0.23893393148269695, -0.6306512694403839, -0.7522329341740067, -1.7028997817738227, -1.0315310473879367, 0.7036280707033439, -0.4743914588652403, -1.3331272260274467, -0.7765303712981669, -0.9347999239778889, -0.6636904602071934, -0.35863641865339363, -0.1395875586956121, -0.47846631199543116, -0.35982410730107345, 0.8957800873464192, 0.6621897593332287, -0.6061745684676745, 0.037520646561856046, -1.1287944732849409, -0.340929858687483},
    {-0.1562988150187907, 0.8669020412653662, -0.8035556255810962, -1.141653269507343, -1.1232082248810564, -1.3365550412374991, 0.2210700279480494, -0.9805763097350338, 0.24996925636786343, -1.2120320636713178, -1.7353264426550932, 0.1206349920815301, -0.31293050678509426, -1.0731253231660454, -0.6992766580275911, -0.28927482329614246, 0.4010478812741987, 0.2179200015017616, -0.8437030173180652, -0.8103390979734746, 0.3402832870751966, -0.07385705669193617, 0.6187167990827527, -0.07902339422098378, 0.6443276648200708, 0.6313924243005998, -1.1492203747280385, -1.78057616422995, -0.8522092762926968, 0.12737076483176166, 0.06328209091405339, -1.1486968135233415, -0.6560154753229251, 0.22743882325525097, -0.07801868740775099, -1.0223911377157933, -1.1086042956109394, -0.1850822396113575, -1.2153437867408576, -0.6648398078326289, -0.7419784101212454, -1.0901755733552951, -1.5376267368798289, 0.659567570187294, -1.061780218886037, -1.1764345235345661, -1.195218474663295, -0.17655882362927983, 0.7189184898569256, 0.1570907492167762, -0.5817260156541445, 0.5178075603257057, 0.05782184570053044, -0.3131818713628034, -1.4438196132800392, -0.931707909237007, -0.12696356093646652, -0.2894217988873097, -0.4996971565947068, -0.17971971043454918, 0.4494376055431855, -0.15635476328683198, -0.26280839514902804, 0.6562487805990715},
    {0.011971064895103708, 0.10429481078934158, 0.1872231924481365, -1.6375414472224987, 0.9557481556966256, -1.0976463374716023, 0.013536043309981547, 0.7585049943406514, -0.7792539090809654, -0.29102283684107094, -0.9406895011166121, 0.39558694152776996, -0.44657159833205606, -0.7828303558752582, -0.19205663276033216, 1.1654429718780046, -0.10921119052018864, 0.49341937306401445, -0.06829798314977238, 0.42016564944228363, 0.3445090723888646, 0.5565771966704605, 0.3444030648009077, -0.3605216145522899, 0.9421305773748049, -0.45254337392592975, 0.2733957535706426, 0.2638288903100003, 0.6357029234411761, -0.7408525687550302, -0.14341468186738446, 0.43776003267155555, -0.053448576417172725, -0.5810948945061963, 0.3679449166163012, -0.2543476412372379, 0.7349149969261778, -0.17384753117431026, 0.6878007908558273, -0.6227743516255302, 0.6887029540431695, -0.957194581225321, -0.60515508721456, 1.1690406772848965, 0.6785413869970085, -1.1628405466433853, 0.3257179681393799, -0.5237356961424297, -0.04393264806299436, 0.13718101265281524, 0.963214838578756, -0.44291475767879684, -1.0137408573475188, -0.1681135072245857, -0.8847971300082285, -1.6715185324328083, 1.011679655124375, -1.1630810204630888, 0.511694291281845, -0.3190597103875067, -1.0290589448211436, -1.51196720632625, -0.9885891948559369, -0.336807025212119},
    {-0.42720262203847287, 1.480650027672063, -0.6823188424716007, -1.1320804202162202, -0.39282617885008664, -0.8149912450319126, -0.38904926366400605, -0.28747672094110194, -0.46952445840128515, -0.18964448653443644, -0.9313679248922931, 0.003944621156631346, -0.6640748098608754, -0.2127700565933523, -0.25580777826436096, 0.4141184980735078, 1.2194356272146525, -0.3013527550712798, -0.30761266693822115, 0.6026083578270296, -0.3942120045470785, 0.4922203415248872, -0.7864070282223365, 0.789970873311965, -0.32932254172573794, -1.3819298052164293, 0.3091018684694496, -1.1722877712266675, -0.02612730687715347, -0.26044376099765826, -0.5198921649711459, -1.1622784496057788, 0.14921150674604747, 1.4604221749404676, -1.1320258202813296, -0.02183186401977768, -0.1324736113880199, -0.16757479400565548, -0.20937685073065113, -0.23968549467960482, 0.11997879771833639, -1.336431931492925, 0.12057107308559709, -0.7729290915534044, -0.4552512907441814, 0.6422356492546542, -1.0510933285827968, -1.0982737945075312, 0.06328100526583015, 0.001968309671702886, 0.700351440483397, -0.8480623717713279, -0.8003509129471823, -0.9622544821490535, 0.823683698267464, -1.788877065382809, -0.6420643039560214, -1.028596957721343, -0.4953879723773359, -0.31491525172882345, -0.8720230251661159, -1.3304761459767869, -0.18613084422557102, -0.13842212287327596},
    {0.6415038041545834, -0.14909203731898377, 0.43166679584804984, -1.2349374693862711, -0.36518441956170977, -0.5215385892088301, -1.3212339764950363, -0.5681662956457659, 0.29771856439115363, -0.9582428277082453, -0.3981437292831722, -0.2915356589522432, 0.5270521141762758, -0.051113333327983415, -1.0044836355303342, 0.4682269096144448, 0.7361645243892364, -0.7406429229463306, 1.0929247240913686, -0.4137879601056609, -1.1371898755987515, 0.5001204350802905, -0.6991076819076127, -0.3607429693470785, -1.2239555587135114, 0.20534417146452388, 0.5238063926941933, -1.0335677094804352, -1.3432644834115979, 0.41315290215352396, -1.3085618989397714, -1.445175526769668, -0.6858817898938779, -0.4567585774313373, 0.35041715370215365, -1.2277283394503231, 0.20334707345081623, 0.4321124225483035, -0.565094892334378, -0.890325078808048, 0.5405067591442544, -0.5139983535941401, 0.0007713199343020022, -0.8468709331500308, -0.48203249699061396, 0.028199067614110958, -1.2781367087316902, -0.24744980900278565, 1.1878749129695534, -1.391496743940725, -0.4106013255556639, 0.24833962113064983, -1.6842609358061653, -0.07605765763594491, -0.4198296531881418, -1.8324134948042972, -0.3062299600028986, -0.8172977798690731, 0.9976239583597201, -0.3485371971531221, -1.7417251680144437, -0.8233982472068878, -0.23601349418390066, -0.4812750119441214},
    {-0.24665635482366025, -0.6615623383989206, -0.01318605328204418, -1.6226077618516153, 0.12414818628825236, -1.5654789063060293, -1.7269441161291557, -0.5188734664027183, -0.15996767056384043, 0.24875787072262748, -0.4969143541986982, 0.35567431457284643, -0.5178826330061632, -0.8822120454904645, -0.6212128641663457, -0.03134120650126705, -1.17063758419651, -0.30372012064039666, -0.5815528272245742, 0.44718865010559106, 0.4994473666852381, -1.3800963127751202, -0.5059071678640281, -1.2997485412479528, -1.1420655502167953, -1.0261263753397571, 0.3598470677440857, -0.29673186662513235, -1.3702565518158405, 0.3168869101554858, -0.883183698879257, -1.5474917866065283, -0.521278462626336, 0.12264338632381015, 0.32099530593820547, -1.5788569935060748, 0.4838362528221084, 0.47745192516823687, -0.31878486376600546, -0.731301717942115, 0.3193160861206907, -1.093478975727893, -0.01647661473585989, 0.0291715283870653, 0.29230701196128805, -0.1756882563126319, -0.45712942802632917, -1.316924783985409, -0.10786146608477536, -1.4263530820455317, 0.3103672428685551, 0.06629010616596448, -1.4562846647396441, -0.43082150162941607, 0.14245557497841663, -1.2920120621198077, -0.6295493851526138, -0.5544989554945134, -0.1511384732971839, -0.06196825821205292, 0.026248952231328157, 0.061547404159670485, -1.068504138296749, -0.3333413850501807},
    {-0.12309011218832125, 0.4360796752340737, -1.7057285493975411, -0.30133437819175296, 0.8030295307994955, -0.6243686893067216, -0.501206163035625, -0.6187553254515769, 0.2260497768584576, 0.5040954965540694, -0.15343289298673257, 0.9002207703501117, 1.034180997884624, -0.46520051710753335, -1.3539760000977423, 1.0288998836501284, 1.0807743605819584, -0.38979597865118737, 0.7480636746718748, -0.4395248889961174, 0.394443307063062, 0.17767474043689185, 0.3794128341491142, 0.20238480048039117, -0.2575016098067709, -0.03945806442389568, -1.0147838934303417, -1.4417103713733797, 0.17781713156694345, -0.2809701455282014, -1.1601073899348056, 0.132392117959472, -1.4813335609279783, -0.2030023905125442, -0.8596624236075173, -0.026676667694477456, 0.18856850055071764, 0.7488168485066002, 0.23462032605026015, 0.36804497570142986, 0.37203130360893355, -1.1150058505260034, -1.6415214750859684, -0.26653291447513516, -0.6620497798673523, 0.08693864890130858, -1.4296256386368567, -1.3313904236062244, 0.29017868669147645, -1.407546526223023, -0.040645770026671, -0.8924624352844729, -1.0599487478266123, -0.5198377634925464, -0.9417904600091446, -1.1232380069103172, -0.45937172155592065, -1.4423885151244298, 0.4015914562736585, -0.03186144158569674, -0.8121070488494531, -1.178695047491231, -0.38595510704258135, -0.8867035420193472},
    {-0.772523170635998, 0.8631761346021979, -0.9871495241829434, -1.338441121681324, 0.9780739872789334, -0.3458836271205476, -1.3286661048325754, -0.4503839777942668, -0.6708878550412711, -1.2057090834705781, -0.7992236667381768, 0.763195685696168, -0.6045095762419808, 0.08702831737358817, -0.17757062913790175, 0.9459138794453893, 0.6302032221076675, -1.065085237701843, 0.6019512521340814, -0.44640665241147137, -0.20251678410345123, -1.1427682473760385, 1.040877363610345, -0.79425121208651, 0.6397261931427227, -0.38984921821424406, -0.2786711763629326, -1.3690840157445971, -0.4060680847327359, 0.2481497808765423, -0.5269873733137065, -1.3426828710446572, -0.8066329715216235, -0.2751052851483373, -0.8010174055370841, 0.11164655050236912, -0.9762635387342592, 0.6395653463768214, -0.21934580084479866, -0.9174296483264366, -0.5676445792759751, -1.1973369694588427, -1.1534611125840746, -0.2035554138700555, 0.8890168601488703, -0.29465955750709394, -0.25082056984478696, -0.838551759531967, 0.7716662218166237, -0.7519631275582044, -0.9658107209112307, -0.9802381527340044, -0.2669239166820588, 0.4548676885614617, -0.9520094092035569, -0.2803153560547612, -0.8158783804039924, -0.6619377475773249, 0.24071533419468655, -0.20359851156852946, -0.162029063658709, -1.1549880397396823, 0.39763342716528105, -0.9546595977198359},
    {0.6834041077491085, 1.1269247418651063, -0.7317733859805756, -1.5333278744034766, 1.08853677794443, -0.30969163044081766, -1.571788678496735, -0.874103413256326, 0.2185988264831761, -0.8337899420367998, -1.7612655635324503, 0.7560916144686464, 0.7457195850203155, 0.08092542672839687, -1.389288160628583, -0.5344165155928544, 0.8307722385285852, -0.5394939114950209, -0.9252453266171669, -0.29276011690458287, -0.27140458124283423, -0.9372927495419215, -0.8569169656622716, 0.049816902490794804, -1.0511976537163688, -0.434421647606329, -1.3406592333079292, -1.2973813440313156, -0.0788177295021907, 0.06503314392615196, 0.08365146647767203, -1.4651914222078235, -0.16033552333653697, 0.1457886344216744, -0.4640908246030413, -1.5371204256286641, -0.30375493928303016, 0.18324300802374419, -0.320876423368192, -0.13074017509353839, -0.45903875888976275, -1.5207972941443022, 0.16936574506090343, 0.2337276196838587, -0.33250016017694356, -0.5688988666695869, -1.7295831870271112, -1.5607603000588741, -0.21950220092747103, -0.7467451478692069, 0.6352001502217265, 0.19938730754379969, -1.7889311396334668, 0.1749899028665922, -0.5826316938226077, -1.28593030857738, -0.706482373574589, -0.9590226366793834, 1.0717584829210545, -0.16968478823012945, -0.5461787762430598, -0.12867177345532174, 0.42241090700770695, 0.9303308699541526},
    {-0.8657982908764167, 0.9828564362447756, -0.8997868488146499, -0.3375323033248655, 0.14425998304609647, -1.2252854913534397, -1.6272873693534087, -0.306862112834891, -1.048849809912062, -0.37744257402897624, -1.368808171299345, -0.6875132674350466, 0.2005197085916678, 0.07785600188976517, -0.9386231666132666, -0.011414117313306322, 0.09156775348231942, -0.6769857332479914, -0.4314039105445354, -0.1333684118067474, -0.8285805587856763, -0.09502645431859202, -0.5812575064240901, -1.1904371355362415, 0.7990026560368255, -0.8313585712412286, -1.0281140825343908, -0.8974321171331777, -0.6329149141081428, 0.6518895747972812, -0.2721181343063761, -1.7233293655996267, -1.1580112244023384, -0.9221154363008275, 0.2645112071415637, -1.2057010544159337, 0.2678965225773988, 0.7403505792969066, -0.2458092149958444, -0.35201821043618303, 0.9749356871204984, -1.0346056422474437, -0.5833337557450223, 0.7421102357373122, -0.08625720743239007, -0.22025014851005062, -0.5164460971287693, -1.0978119443526189, 0.17737487802556004, -1.7452639794876144, 0.2517531583882455, -1.5381498297458434, -1.1414822058510392, -0.340339447993459, -0.44073656600673683, -0.6681292371226769, 0.07652109604150799, 0.11054554902261686, -0.03720189940499464, -0.6612304871902968, -0.4854991784614688, -1.1681364919966284, 0.525724789368496, 0.3315481943038039},
    {-0.020324741664616796, 1.1115129350194326, 0.45436453717669945, -0.030897008127515214, 0.09231392499068676, -1.5110757688009964, -1.5377851526525894, 0.2506511341405355, -0.8812308060406735, -1.2599087211541091, 0.23467602374309574, -0.08241514341786457, 0.7870502873644288, 0.6973035537828114, 0.030753141453398337, -0.7481177539540262, 0.7220003754485065, 0.3872236481236974, 0.7436803010526903, -0.981609547779775, 0.022775007437515937, -0.9076729505587692, -0.7138375345274495, 0.8519889173561299, 0.9378062108121996, 0.05262954658311376, -1.0301912078939126, -1.440290886835868, 0.4038050973941297, -0.5302669830841182, -1.5028239485579544, -1.1540204993849685, -0.841330584076611, 0.22597739190498745, -0.8167710651549026, -1.1103713182193213, -0.2134563051103826, -0.1147067661159842, 0.6512084829517548, 0.007253937523561231, 0.8347454471205582, -1.0351367507088693, -1.4908805103683942, -0.37267084745724643, 0.1341753998107643, -0.7838657844815164, -0.3744826061549701, -0.6567894988248854, -0.3157379833454153, -1.3698024417962937, -0.5687047755488228, -0.069744376157338, -1.2755796790043068, -0.6602204587548959, -0.7382841995441126, -0.7483252789190727, -0.6718902800208271, -0.07619887043427553, 0.22706041299753688, 0.14024214220808587, -1.5659068621180054, -1.580859692195341, 0.01469215337761206, -0.7345570543300343},
    {0.464856482213394, -1.149880614341781, 0.13382536229123332, 0.7849585089375555, -0.012064152758652668, 1.3182155120399623, -0.22661564366331272, 0.6491588488271504, -0.1044572619459425, 0.6365306993190208, -0.8481980185920315, 0.7637815555896532, 0.9780656695728147, -0.045584034659460024, -0.4033529931789979, -0.00012248469640368403, -0.6748265453509876, 0.9042835896854963, 1.1256691195251822, 0.023071223241109155, -0.4139732616774287, -0.3578344256769721, -1.2710875014584913, -0.7236789534310354, -0.7343797499005713, 1.0109585730306938, -1.2800647359523047, 0.07754813157390406, 0.675839957915678, 0.4014385196699819, -0.9549487517659319, 0.2864567068043835, -0.06506145080755002, -1.3400100989936121, -0.23159793466994766, -0.32267836607379147, 0.8952354177164127, -1.2746928270289164, -0.8841761021746832, -0.03171848764264327, -0.01949048864383131, -0.6674789424140697, 1.0824676508670137, -0.24938471705694354, 0.30520336740379245, 0.6349696870459017, -0.6293411030652938, 0.8145704361896553, -0.17020587230262033, 0.7521253240878594, 0.6033777969176589, 0.7649342532037244, 0.41698053918816025, 0.33274158400084086, 0.8287368586499615, -0.5223549126475213, -0.14973230325380332, -0.026410245808952963, 0.3086106159791996, -1.103410378824373, -0.49840607131580106, 0.5325696493907983, 0.29304386412361494, -0.020368546865682062},
    {-0.5275747395723452, 0.5577744111147767, 0.08004263452224605, 1.0634455698638745, 0.13610727990937813, 0.9992574626112503, 1.18027398916082, -0.45462598859572817, -0.4036422797778512, -1.006116517874822, -0.05470450605890379, 1.3116556992314452, 0.05779454978119622, -0.8680710210922221, -0.06568634822874976, -1.0212238046252442, 1.080098007968442, 0.4588585191019084, 1.5900418812774098, 0.8428089403584924, -0.43578676171405933, -1.1192465621016876, 1.0475367335296186, 0.9433773091131125, 0.32435864485476346, 0.9404215064191537, -0.05963115194011305, -1.3658942217762662, 0.2951679449860448, -1.1265945022477546, 0.08254310093460498, -0.9412350981598439, -0.682517805243896, -0.8279668465744998, -0.7239220648392198, 0.2888980080481599, -0.7007663613023507, 0.607915393101958, -0.5698674665295853, 0.9115395714412288, -1.1475898771492925, 1.303930634785113, 0.9178766050490725, 0.4569741009932592, -1.0081911829277617, 0.4335808611530775, 0.6976587376493412, 0.3078742948366645, -0.4195281110095161, 0.36412291868543795, -0.6560286375234521, 1.482302296014851, 0.8834472364102798, -1.3402842857869575, 0.8478069120901527, -0.1308708673039478, 0.8346556728301957, 0.14452095475888452, -0.16559408067151765, -0.4574407957439445, -0.13113173388928942, 1.4645054128423067, 1.1118361345546866, 0.555865524624719},
    {0.8029353763556374, 0.07241314799440933, 0.8191404516874193, 0.5547053089964007, 0.3784887295617636, -0.023884033670507735, 1.1654253310328062, 0.3641853288860827, -0.37503190264632363, -1.5160134907443965, 0.7935652285028204, -0.009358215301886482, -0.04374107195715627, -1.3711989670949467, 1.2626393347069509, -1.1161460433135308, 0.9479623946500628, 0.8090079637670483, 0.5328190165351621, -0.6296477628577278, 0.564354511100471, -0.17796409439784977, -0.8818815773005667, -0.9095743387644073, 0.9690902508244595, 0.5623566751267517, 0.6165988819801991, 0.5675672898750451, -0.9879753929455724, -1.0093241173483347, -1.5048075646433678, 0.35615889703662973, 1.001840257982994, -1.3353961612337948, -1.2672436161129075, -0.8807471279612771, -0.5460761195010856, -1.0640468142175181, 0.6320819783498034, 0.4356559668694455, -0.6275572005628762, 0.19443985625970803, 0.9023014819078313, -1.2525490569019853, 0.3978540616306878, -0.27184797817456513, 0.08105694138066162, 0.7280437861437703, 1.0070272684710515, 0.06916856360233498, -0.07603528936628468, -0.13943334642545, -1.0609555274249747, -0.916517715838656, 0.4809863540545588, 0.24608122069650865, 0.21010338026172531, 0.7022094586804489, 1.4225523482584335, 0.4736696096275099, -1.1778665446200638, 0.48295120106833844, 0.13299613744033628, 0.5681041059278368},
    {-0.3303403496744487, -0.3559654629778914, 0.42736622630310317, -0.3525256739089559, -0.220377129587021, 0.320033767669225, -0.2087660353603793, 0.13118831727837227, -1.2472072800089942, -1.1630285351591414, 0.3436718038144251, 0.7462671912516398, -0.0500053635072869, -0.7579298625708071, 0.7162797793770451, -0.9889829314070562, 1.3418092776262756, 1.5154548033631416, -0.12435781681527464, -0.19417705305075666, -0.6387742746988232, -1.166739594377969, -0.40640718405715237, -0.7495106305078464, 0.442409216416981, 0.4672532986933837, -1.3488186512171756, -0.08933410088257059, 0.15140181452542026, 0.027964485561874013, 0.13969067533098362, 0.5939622450832273, 0.08221625826863654, -1.564816722612865, -0.3607680548113747, 0.955374516259768, -0.5147091159670782, -0.08739946509717171, -0.8493847098453133, -0.6204983338199088, -1.1347874980359967, 0.13436168216275327, 0.23737274525150517, -0.6679124306473164, -0.2681680433216358, 1.2536580648973021, 1.1986774967408627, -0.8439482086300321, -0.025095294034318434, -0.15079746810681996, 0.1099401649007861, 1.2537061606485123, 0.2764133084071561, -1.057857154160901, -0.5942182955641694, 1.0141857266360557, 1.3106387086255271, -0.4382246628864459, 1.3411010671853674, -0.7221720988345197, 0.7710551762209549, -0.3297147536044302, 0.5780307621498487, -0.5435846408572242},
    {-0.39598933445777906, 0.6000653648949894, 0.9651331616277952, -1.1087732521912355, 0.8192533591639318, 1.0797716783061875, 0.9166161863003229, 0.8710490815420326, 0.5420373182852558, -0.37083433939057187, 0.9051674748431751, 0.048851626763032445, 0.789610986916149, -0.6285466545966635, 0.7510445394342224, -0.8159012521521919, 1.5412907056508285, 0.212032440058341, 0.9474510395527729, -0.5722205884807468, 0.537046212273635, 0.4515165182752193, -1.0864524667457356, -0.10740595601308275, 0.307001052476172, 0.3702336067224558, -1.2573664665549584, -1.2483448162048771, 0.107812254633562, -1.163442818286077, -1.1303996821084612, -0.08170029025229493, -0.018134976711031797, -1.6917914908349605, -0.5481023509795423, 1.35306167273609, 0.3687030886613588, 1.0637814348883325, -0.04462250494275386, -0.8629945488405271, 0.23974410293539472, -0.09672678946209015, 0.5793493581285003, -0.7845294420794032, 0.5099945668688833, 0.1686141349580894, -0.007083625417628546, -0.9242629002801558, 1.084112894200173, 0.226235256685235, -1.0564121994805395, 1.5809370187455325, -0.7793647519270847, -1.086706619510438, -0.7036506419588977, 0.4019529291727941, 0.9905194723826491, -0.7150972192211316, 0.8989721767263742, -0.5127641051963258, 0.6314250985501404, 1.4587494326339914, -0.06714503601596036, 0.5405439986562967},
    {-0.0006346382888873875, -0.46679351509239286, 0.5247667114981728, -0.08019360770582974, -0.1356195111517027, 0.3606191679663436, -0.9747264227947213, 1.2593194648177672, -0.7594684646078158, -1.5207034587087964, 1.473857272441225, 1.0092892606168864, 0.5878469670445872, -1.4388145471267781, 0.38045027585130364, -0.8638467541371138, -0.1750201704501318, 1.1449337405431614, 1.213043700669183, 0.12857681032033894, 0.4382124071654343, -1.0061819882310643, 0.5068579081400166, -0.5219068962421407, -0.9352034728179084, 1.3082679323204258, -0.6776057060512446, -0.997930800511692, -0.2393610142105874, 0.21022711458465088, -0.2703749467422045, -0.05223917862827998, -0.6780231760903088, -1.6773967514020467, -0.39842644645830716, 0.7578551192547595, 1.0943780881005625, 0.6982123504365033, 0.37540997349562855, 0.6338990453970862, -1.2234071762304768, -0.14786995856191598, 0.021600873736789285, -0.6720653172650615, -0.8811886844253468, -0.5987859675172229, -0.4699849075311561, -0.216782314469166, 0.17304954824935026, -0.34468382235416306, -0.48387007190380293, 0.9171371908953777, -0.17445618088574805, 0.6827721120211864, 0.9938189529688953, 0.16245243139984425, 0.09712079511690329, -0.9996624900220661, 1.050471574914121, 0.23769780014851716, -0.46924389324801324, 0.8078308858663079, 0.32556913819665384, 0.3156167488027595},
    {-0.9160630729335578, -0.6032502363805152, -0.8447313295319517, -0.31744066840468693, 0.322818127531369, 0.16023269162856787, -0.06577037858606016, 1.0833840006370223, -0.9625491689528666, -1.002227537164986, 0.10523705144051926, 0.9686339412110793, 0.8626108086088663, -1.3082100636007192, 1.1580672525589157, -1.2232158410397511, 1.2778265449837307, -0.03194421492296549, 1.2683164119567185, 0.28365301214452515, -0.7950869518424839, -1.3555989396059138, 0.6549047112067057, -0.15294134867336714, -0.2066102229698043, 0.48896714646593514, 0.11737095245641467, 0.16519475205598136, 0.7703628048854845, -0.15868197424555602, -0.365796269567376, 0.10992622631196718, 0.9627412926452523, -1.5977658787025486, -0.25135896342932834, -0.0880709156639235, 0.943818326729951, 0.10367731665055001, 0.7348833799340385, -0.9187577681078477, -1.080204732245134, 1.2138935377626034, 0.24868135134905797, -1.4015139401849483, -1.0054667959857475, -0.42993221147488664, 0.5248298772876921, -0.8824208083222769, 0.39436396786829486, -0.8463587821812086, -0.42817634240374364, 1.034360012430731, 0.15411989108163782, -0.13428023093805314, 1.2273954420280746, -0.592754411032288, 0.3030023379650314, -0.5422557212177055, 0.6913202711580329, 0.12275546004531077, 0.2884899359361499, 1.5423848567863834, 1.2292256674577664, -0.2989268955150326},
    {0.5460032349083164, -1.1218296029380785, 0.8496475889620331, -0.8649771745524024, 0.9811257638796652, -0.7756113744040295, -0.24341712904084792, 1.5478070026868216, 0.42848795932204004, -0.0627066957861143, 0.5899710334458571, -0.08487314399756951, -0.5630518015328295, -0.5873286593101528, 1.0703559521789068, -0.8903708616232432, -0.43937827194615664, -0.5051180718119742, 1.2897812158182254, -0.44459458210809066, 0.3561284509998112, -0.8106088225932858, -0.580428095932544, 0.5122187187855025, 0.4147902212611205, -0.8182182661745239, -0.5418475771100263, -0.7230815645659514, 1.305506655795241, -1.7675164843416804, 0.338256015940938, 0.5782724165990135, 1.0429230419004305, 0.1927333892596936, -1.4476532867260197, -0.24872635696686085, -1.0724943316504894, -0.05442977576907352, -1.2587783452677799, -0.04239569147468502, -0.36146832677870716, 1.5181592209418422, 1.3844799333709632, -0.4119344299349961, -1.0802437186569904, 0.39093797369413547, 0.7798146466727208, 0.25205259995667045, -0.5034346082220837, 0.4179266531114773, 0.385161200006385, -0.5177843775786868, 0.5053050048325561, -0.18826120621256237, 0.83817342517993, -0.7464078686384247, 0.20686712421888515, -0.7890927500446177, 0.09369232999759435, -0.8209059884179767, -1.2265699073126137, 0.2896417762827156, 0.8924000869757214, -1.1294667279615962},
    {-1.05286103716132, -0.22701949092372178, 0.7390321523754354, -0.7468562276393182, 1.4452847469297498, -0.7005552830020214, -0.2553308776623651, 0.6749936957683632, -1.2271205220485024, -1.1224885874843924, 0.9605836721195835, 0.1515881750384043, 0.22473524529653544, -0.1895266320204489, 0.44399478266077474, -0.11262269403071591, -0.42102209723828987, 0.9898185545849206, 1.674589877791723, 0.5845873581860782, 0.36113705831549303, -0.8410141496143093, 0.306218895454134, -0.7314553539011565, 1.0476464947422617, -0.2352009860777092, 0.7037066746615879, 0.6085166987422687, 0.45020022585004293, -1.3882581848027897, 0.5266846078360619, -0.7079888070280027, 0.12756191279561802, -0.23459535151943073, -0.6379420511096792, 1.0054917171277542, -0.1980486738498463, 0.08531459229137112, -0.9980028511641966, 0.0426839455697431, 0.10539774196170351, 1.3510963615125018, 0.8590843261185979, -1.270682164474904, -1.0091105951524642, -0.36447506490270115, 0.46601106918875196, -0.5890575254894477, -1.010449062533549, -0.36955800746468886, -0.2028763719866828, 1.3465277626264542, -0.8140971050829695, -1.2994334750817826, 1.4534666439600334, 0.012627451855879391, -0.1782176647328142, -0.3458596428263014, 0.7702432912808124, -0.4170582692510314, -0.6933795941525549, -0.24612562544920744, 1.2248760434136339, 0.7126699193849801},
    {-0.8967811724102209, -1.3675023248656548, -0.6866936932619486, 0.5979877071342422, 1.088615945336537, 1.0139681503077476, -1.119700585797756, 0.6807222021562197, -1.4613597189114125, -1.0755582183187844, 0.7091948683786742, 0.9998524989902217, 1.1860802560371557, -0.24289344551147576, 0.9035838104347624, -1.2235020360072748, 0.1657323960080317, 1.6761699064238145, 1.5656906095854082, 0.0602327461393891, -0.4217211288314307, 0.5720483672848032, 0.04828683333216885, 0.1514005702818402, 0.9201343843641742, 1.0409751117571024, 0.8188077291840851, -0.6249297523647086, 0.6988723282520434, -1.2098776732642, 0.19722737408770213, 0.38120136219922024, 0.14995603063744212, 0.4938386861645933, 0.22157694139185152, -0.0641686299406294, -0.16202533708661107, 0.6383221203020435, -0.05122175738283428, -0.2192404719262014, -1.332015953072064, 0.3931476119284352, 1.376107381108207, -0.8271415817213781, -1.4901913728822376, 0.592666932419501, 0.3264698042164243, 0.004476262866486221, -0.5003013952543878, -1.1680142323595946, -0.159424383459475, 1.41628226967114, 0.3900093372093749, 0.24567531608716944, 1.4167259710081008, 0.9609318459045242, 1.1586566682781054, 0.15125777146489433, 0.5096333011808267, -1.0419253955556735, 0.01998588295975773, 0.7552214038008784, -0.12652163744633857, -0.9501260917986023},
    {-0.014164692846837624, -1.154534392250236, 0.23748459129409266, 0.19627650281517464, 1.1980490413635572, 0.6469439998925087, -0.9511901094362468, 1.4427422448362488, 0.14453058590759643, -0.6728305284726112, 1.3174395665763505, 0.03297676046670907, 0.87296897962233, -1.3258759526154853, 0.7314475780641227, -0.9245566212491764, 0.2103678556443211, -0.11015803305306014, 1.354570165190428, 0.5867703173896032, 0.597730292123641, -0.5331615526041417, 0.6605584353205309, 0.2982167760435635, 0.7059124501495803, -0.7466186388306671, 0.6774506026316933, -0.43199888133472786, 1.4681077056238887, -1.1712548048110283, -0.3780604154060913, -1.1834003793208356, 1.5674461113030411, -0.5136829499940474, -1.1026067833339628, -0.5659136987613556, -0.4708014636428765, -1.2349296564342291, 0.00832303803645857, 0.43984275170359205, 0.6029047322893453, -0.8379305622332742, 1.289261938657086, -0.23763988197536154, 0.014582561233401395, 0.7097590469943306, -0.08525605776045948, 0.7949200166308359, 0.5409568579429718, -0.7006994263946438, 1.2323241691196287, 0.5587311219733551, 0.36404564998121214, -0.8964422117719802, -0.24735587123653424, 1.1489123389009293, 0.24898358018087635, -0.5219586623600648, 1.2985552553339181, -0.5338552095181714, -0.7600771527767739, 1.2478882258294983, -0.0025194103941117356, -0.0768396447170706},
    {-0.3941537058957657, 0.6924740337968991, 1.2386466473155464, -0.9163857447245758, 1.190767878559825, 1.2532155257296473, -0.5614901073998005, 1.70798805138548, -0.8154462219911913, -1.1213029921147388, 1.5561360951922627, 0.8947329563284254, -0.5131746481434154, 0.1078335617923612, 0.45143111783791345, -1.1706754936868216, -0.25820579207668376, 0.8004777562829389, 0.4214800161895772, -0.037884601456349705, -0.23477753644342655, 0.01979524678250221, -0.26436081680288676, 1.3629904369326549, -0.7269827624096485, -0.14827448238799154, -0.6520075400234968, -1.0676953647220406, 0.08014464376422, 0.2437448933915804, -1.4464305040831162, -0.5873245829418089, 1.010600038516949, -1.4462696311261563, 0.4408702578247104, 1.0809382830822183, 1.1218371368854634, -0.39989372759295083, 0.3894745267684725, 0.05451533043247806, -0.47948586056756853, 0.2618436341826651, 0.3115578622243119, 0.24000342054585902, -1.4516349840139378, 1.184762807303156, 0.61615005969144, -0.2352164511449161, -0.7551985671386932, 0.8258392410523712, 0.3918333005387183, -0.5189963908797082, 1.243519197927187, 0.32825413912240475, 1.4343516930656184, -0.5862955252046645, -0.24418097659178714, 0.926774324823495, 0.03344352167954193, -0.4419437631222461, -0.12369279623432462, 0.14686108533646602, -0.19177320738890305, 0.49119783479040496},
    {-0.08422758990709327, 0.3919522216443434, 1.2277874491275118, -0.567087292078023, 0.46341735683419155, 0.14677080309651222, -0.6897130863986579, 1.719494064598303, -1.3830699501034118, -0.3903787089172266, 0.795881144650466, 0.4370436817891517, -0.4162399887698454, 0.37517311923563645, -0.5209111713956756, -0.6523249026707603, 1.14875388063328, 1.0492134745714727, 1.5580819576627316, 0.7668568889996185, -0.9014365454124219, -0.46680129810241067, 0.814681733182996, 1.2307136259534328, 0.7934924050784297, -0.41370643321597356, -1.1840459757713566, 0.45098550931838466, 0.4828867640202147, -0.2854213115753835, -0.8313532024666808, -0.2684510768752067, 1.0330159623306525, -1.586238575031008, 0.0575133937983427, -1.057641260312146, 0.618462868708099, 0.6617826055221918, 0.23932894603438015, 0.2096000450485111, -1.51311079647734, 0.7209266134406053, -0.10566898846310638, 0.686929470356684, 0.4820413586335559, 0.15211164705308186, -0.19130527849120232, -1.025370592763518, 0.18837570383177293, 0.8336946649873828, 1.1847921209566474, 0.24697895711119044, 1.0400691553865988, -1.2568623133551413, 0.4224412812288001, 1.1596428674188937, 0.5746858391364895, -0.5440067999867171, -0.5473294133746223, -0.41613664027014546, -0.5686219914791908, -0.17431638434665286, -0.061324927011129675, -0.9757565080778086},
    {0.8504415522436153, -0.917112949194181, -0.813528481271953, 0.3159008638090757, -0.2167012540275151, -0.4153865241665068, 0.7485357462062104, 0.45810353610678684, -0.2530627021037736, -0.33655205510935415, 1.611979809407495, -0.5050891440688101, 1.4021335087180669, -0.6598761785253966, -0.45882856658933646, -0.1340886852470811, -0.22094926347947044, 0.4100368076042846, 0.1544146445907592, 0.29226662134650777, -0.3329758713735317, 0.2672541648472516, -1.1491282473492603, -0.748914113610528, -0.5458957209964347, 0.6176709410806382, 0.6573380360045972, 0.6147335548555826, 0.1200315460969996, -0.03193376119282218, -1.472774086000618, -0.962719329100899, -0.7848946739765983, 0.3671145414526133, 0.5640788256136622, -1.211928767642143, -1.215422023602708, 0.3921944819496562, -0.620950321852361, 0.5353698415035655, -0.8945331919849694, 1.2680502275416041, 0.5113913572382209, 0.4725571367373119, -0.5583954572028894, -0.12916871991447398, -0.06081032716622415, -0.09066570365948774, -0.8647799708474648, -0.9776123200948486, 1.0383248811170316, -0.27705537383513723, -1.054598202519819, -0.6542803217770945, 0.03164287112732667, 1.1153951668209159, -0.6886777741146237, 0.47770605642149894, -0.16095247235798224, -0.9160978759334146, -0.9944568617280004, 1.2336814981171609, 0.6487313374903757, -0.42000433913694973},
    {1.1757128528938363, -0.9131248171443122, 1.0847761184545976, -0.4365123495386578, -0.35858107682658447, -0.4783334570069605, 0.08599086043437384, 1.595190315289721, 0.5523195470517622, 0.09139523914107396, 0.47233589073551235, 1.2565171096514582, 0.5174602287168535, 0.6231381346688181, -0.048871960944154795, -0.37664634615006554, 0.3189010850272548, 0.29248505483342735, -0.12202818332481588, 0.5984624162915851, -1.321213775195826, -0.02255139333682932, 0.7482190291592662, -0.8991571879195496, -1.1851275737761715, 0.831487923296683, -1.0118477744465366, 0.12405551145365562, 0.6330425187052218, -1.6284827351502684, 0.48433140125248325, 0.4565723001487423, -0.4028905313538319, -0.44103999557560636, -0.8779171121988458, -1.2056636022561542, -0.32577720149015754, -1.1324652164851061, -1.098159326889262, -1.2500426708254153, -0.3307444468742745, 0.494421881003099, 0.9450393546278243, -1.4332607601165905, -0.21862130296111976, 0.5357509862949914, 0.8769446188476058, -0.44013523857112935, 0.060126434190986684, -1.2854781907109947, -0.2354411948337582, -0.7182996351027299, 0.6831476929167154, -0.8141230729022145, 1.5061729569140143, 0.55271990026368, 0.7630012675488991, 0.23879606381426804, 1.3791703974582916, -1.7949404157812279, 0.4489431478766793, 0.10464783473677343, 0.9604721959129215, -1.1920388090663456},
    {1.2782859053042892, -0.946387640523402, 0.9806807509601465, 0.45329665264405977, 0.4122731099171812, -0.7606964263992954, -1.1980079093406926, 0.36226533979812015, -0.3086429762669891, 0.15938128356968412, 1.1941583026733424, 1.2165980204155202, 1.0721352871633014, -1.0998540113569815, 1.06066051384265, 0.11643217227735539, 1.656996828601138, -0.26667894871797343, -0.38126735769579917, -0.10362314487361043, -1.5266827626378454, 0.25182758877950995, -0.4709710128350112, 0.626809747823031, -0.7178814724016519, -0.1333438386264873, -1.3359933783276299, -0.4927540810010243, 0.28305207910383945, -0.3998921901301671, -1.2153450455740231, 0.40608739580034786, 0.35209298444236575, -0.8214475574219631, 0.37955077699187406, 0.6643689344231817, -0.8441637445815761, -0.8146569778237307, -0.5978031017046188, 0.6813906848959643, -0.21156591823569149, -0.6137695110755772, -0.06630522509118396, -1.2418227067886058, 0.4802489229007159, 0.44073528414177904, 1.4158288054177763, -0.7584516014214557, -1.0445740953024965, 0.06110340397235148, 1.0727686573528994, 0.4971547070914021, 0.2780109501615531, -1.2935493600157901, 0.04743321752059261, -0.7767439969023608, 0.43633914125215906, 0.5620340033603843, 1.4657530707580557, -0.687787838401383, 0.1494058891020111, 1.4043963377970115, 0.24831605848810384, -0.5783518543728684},
    {1.1261777266705553, 0.3458969380669658, 1.0723212011815604, -0.20379356802543802, 0.5612988412913776, 1.0158171124395956, -0.27136511979389494, 1.5108123869741592, -1.2283958784320452, -1.2483949568085064, 0.6333229163236803, 1.558002785916385, 1.3096077502020385, 0.37987447875227076, -0.5075118906701337, 0.5071241377516016, 1.2642688642612272, 1.3642234707161232, 0.7287203026443458, 0.7299085322149628, -0.6446748512109095, 1.0781565900760026, -0.7102610051809081, 0.7102858619815021, 1.1598289521019203, 0.11130486345853129, -0.9468763685028727, -0.5428007309883515, 0.6235128028470894, -0.5946676694833467, 0.13899383136227228, -0.647315310073362, -0.1572014750955268, -0.42334592443986085, -0.7763174188694631, -0.6519476814689035, -0.1376593840577329, -0.11696891433303407, 0.8546042741937845, -0.18417243499437386, -0.17191632032854326, 0.7329738423490301, 1.11521984568049, 0.2890180116435291, -0.8969957010423185, 0.18912758890122688, 1.07346391510708, -0.8048862934868101, -0.12422422714401155, 0.3959567003412877, 0.20345289113493398, 0.12498855262481402, 0.5995341076067974, 0.3608126595228971, 0.7850958161246501, -0.8307584683511205, 0.33986940859121356, -0.967697249796492, 0.7712868550031214, -1.5841806345663667, -0.3780178561308486, 0.889092566209157, 1.0844472310329925, -1.2456520805559077},
    {1.121344950334976, -0.5955826929531726, -0.2589415492899259, -0.054264237870310844, 0.17191597059452846, -0.9982640031100293, -0.8504233518612906, 1.7951856626775322, -1.4687164657071754, -1.2859663201061873, 1.1079785154208135, -0.657359252205052, 0.5944823214030263, -0.5424031240692436, 1.0265335804808062, 0.28582608984882835, -0.2986029501724104, 0.4893381027141401, -0.3954893271030525, -0.1776281094116608, -0.9265814917705872, 1.34090788347175, -0.24419791251964712, 0.11981417127597402, 0.10400546451496631, -0.27289305448810997, 0.5082792288570674, -1.0825514307071558, 1.032546530036212, -0.9589125695205437, -1.301361042699255, 0.016856297716041562, -0.29695542750396164, 0.23440820103712542, -1.1446463606730175, -0.3189914970736848, 0.7386741978135292, 0.046629419485573156, 0.03222663697876379, -0.5164827322728457, 0.24119878864790764, 0.8199566010861007, -0.29267660187434164, 0.6052588765117456, -1.5833797858402394, 1.0638079815720356, 1.241419476405218, -0.3330927146536515, 0.6950801318437925, -0.7901798706490707, 0.6527870301618796, 1.319673498095648, -0.8605933626246096, -1.1704736401201983, 0.656124201868705, -0.6881696775225857, 0.7310508003567108, 0.6605617921551857, 0.7515193159731303, -1.1506614855643431, -0.16968970726651286, -0.3399441101630035, -0.4426903544890775, -0.7903723086291532},
    {0.140954891730439, -0.685505835520843, 0.0571026248664223, 0.5721050305220295, -0.6119094410854914, -0.6317403388482196, -0.30973068892357924, 0.6342624244935487, -0.7105220597159132, 0.07791497676344823, -0.16771471025878748, -0.7349812881671156, 1.578107826917161, 0.5411374886472383, -0.022245230319362555, 0.6649547363314154, 1.5682378532511687, 0.953109496581695, 1.0985259133229783, -0.2981718041589213, -1.0439027866191637, 0.9310093554166975, -0.2061731184262008, -0.04882647186646284, 0.2860456944168473, -0.36616217200709794, -0.08968878468849437, -1.3373018850196452, 0.6425696343561875, -1.3994661443396617, -0.5870249311043035, -1.1401711958082446, 0.963486454445775, -1.4846170912390193, -0.003032772929133067, 0.7513995896817528, 0.23762607757123952, -0.9657865847878322, 0.013899344155503783, -0.6356190917788114, -1.0937167766749252, 0.3889234512661236, -0.05640892332013325, 0.01798407848828133, -0.42920399376293833, -0.26403603244987073, 0.6864618039770191, 0.9111200906297934, 0.5889000077397198, -0.9537841512038637, 0.7508341651879142, 0.9103392056715613, -0.9893909786840652, -1.3398902109018724, 1.2097614345287333, -0.7274003780451574, 1.4505390095063544, 0.19404526167385108, 1.0522737711941303, -0.625170116590176, 0.8447125765508461, 0.1163851452819745, -0.3170756397192287, -0.2872899608601286},
    {-0.19806955314788863, -1.51518778070207, -0.08715034196744413, 0.4083246123928063, -0.687150464249235, 0.23556408300725054, -0.5672510729277682, 0.8348258176775711, -1.272413984543708, -0.6238441612889918, 0.9415066215296148, -0.42097349087890357, 0.5786448459596153, 0.5021652052349176, 1.5253950981376367, -0.46275490582276246, 0.9671723005097569, 1.3099634964711064, 0.639914132289693, -0.007022438540147059, 0.18433982242836672, 0.8785699072000632, 0.22404833128827867, 0.3670219436349068, -0.09241113623618948, 0.4422377693414358, -1.1809174251324994, 0.34015217921501983, 1.4069615351220848, -1.7552258807760648, -1.373094156811279, -1.1211035998310699, 0.8566165150721903, -1.0298491551269848, 0.731840742435096, -0.426660314708532, -1.0084411946872807, -0.7721576164818132, -1.0791368491537099, -0.6354373190950615, -1.3165397571956228, 0.334446889872109, 0.4846709054734638, -0.6728479529956818, -0.5128752389933857, 1.1648339265816179, 1.6876281729200253, -0.3222905436949284, -0.5863639966563605, 0.551467772875029, 0.2855290299066988, 0.5056630708737111, 0.8203416940032149, 0.5918966042959812, 0.8783479028083888, 0.1354884977534716, 0.871103767194179, -0.6506821018837028, 1.3622546409986016, -1.3870015105852185, -0.5602621040937281, -0.47199821904953315, 0.4348090099540275, -0.9421023570479694},
    {-0.5767406127338711, -1.2813295584255837, -0.7974979168165456, -0.4310725923151216, 0.44374619247703173, 0.3244880384813646, 1.133642629847504, 1.1158894875440097, 0.21740697836351405, -0.807004093351858, 1.3498171619048194, 1.445564514565809, 0.45309978273763973, -0.09648881952387495, -0.34892776955124244, -1.1539034784728275, 1.6582364475118303, 1.0673935271487622, 0.37942373741323066, 0.828513941072557, -0.8277737234684757, 1.5670578160845103, -0.11706124838219267, -0.33680689587390106, -0.42179090672069514, 0.2510956017742553, 0.4759184835196001, -1.3016787038067335, 1.0940218529599952, -1.0814810332373521, -1.4704406349522647, 0.2673100469331475, -0.3744291990333369, 0.49459174537418077, 0.25429617635367824, 1.1205083905991025, 0.7243163843269941, 0.033520778029236545, 0.8624495421106135, -0.8829717834747476, 0.20088802881402862, 0.7776668831482901, 1.526561019060383, -0.8475242758565497, 0.3570937911842544, -0.4373749916579539, -0.11048224821291334, 0.1485964355517417, -0.6197111868599665, -0.4517738265455981, -0.5345814065405912, 0.6716540648397593, -0.14088143523914637, -1.3165388247931191, 0.5626828466472471, 0.8365033890402053, 1.3270470034603938, 0.533804789028119, 0.475436911149398, -0.2916216004943461, 0.19301309101076247, -0.3715872454058905, 1.1828368418341324, -0.5386158987021404},
    {-1.0111325107895277, -0.39816908425841824, -0.09734394787776394, -0.13427792977113487, 1.4435629533249312, 0.17123009053431087, -0.20650546787364552, 1.6876571214167881, -0.4534339888702454, -1.188337844533371, -0.2390800559359834, 1.174532829790774, 0.7261884721369924, -0.9707585103525447, 1.6051044862898527, -0.3489888569627325, 0.5082459228003221, 1.5426217777134767, 1.4318908542188158, 0.09261597777161655, -0.5365193261081046, 1.3657601468863128, -1.0055358607172704, 0.3880272084983442, -0.2429846146126339, -0.3920368001895148, 0.1394420848159134, -0.37112462472093294, -0.16697708422607135, -0.2550201289338574, -1.5383702746128831, 0.5568616563849283, -0.5689739828037844, -0.6830161672873887, -0.9851017882805103, 1.2673002916181764, 0.812916551024201, 0.06268511474216515, -0.9990463053025954, -0.5592804033830756, -1.2018905385064351, 0.5005111838143474, 0.20248359618365563, 0.3827768507265217, -1.1828912978193513, 0.9927108420477812, 1.5970537674634606, -0.8045399898394754, 0.029241460261037376, -0.04369941243070164, 1.3543200029319065, -0.3374256232934345, -0.7928410474190635, 0.47485782573929575, 0.18953056289970988, 0.6980666131114205, -0.11658747381187928, 0.32057228622416634, -0.1858259546443902, -1.3197071758190657, -0.48647679684506373, -0.2359603261173834, 0.7708191796940436, -0.24290138251335391},
    {-0.23295886485032097, -0.5927917001239645, 0.1017348777242278, 1.0805001478714473, 1.3542057735484554, 0.7348870699411162, -0.4109297161668045, 1.6160838098360153, -0.7111922059840612, -1.4615028989174825, 0.4971719965800622, 0.2910724235785267, -0.14773127115661, -0.22135012841570084, 0.27287440042021155, 0.2159871719501578, 0.0412505473915945, 0.26407173065591166, 0.18707193172779504, -0.5025230708854734, -0.5602263557655447, -0.3058695512055325, -1.1483031271373956, 0.31894143287352006, 0.8689534300877786, -0.1448861743718499, -0.8321349931411102, -1.1748056136754486, 0.8122521043197788, -0.49962837036062707, -1.2942332257969953, -0.030374829672706005, 0.08869487296882465, 0.0333708450924972, -1.1572111259572162, 0.18035696216143451, -0.6792336685883037, -0.19612215892155538, 0.3104749521971429, -1.2992860752346098, -0.4735242256240937, 0.3310496326444078, 1.3227755900922105, -0.3217385397682446, -0.9152323062818294, 1.2997002397973667, 0.005746327492319906, -0.5670098534533043, -0.7066985134286217, 0.5468987158455356, 0.19541744459676616, -0.5232549400861138, 0.6588727340400747, 0.7364532086931194, 1.3902663249060554, 1.2457287826703818, -0.26146349316534345, -0.34049089407728184, -0.535789454467823, -1.098477053521233, 0.20979121061616166, 0.7319500428817375, 1.5734956108340779, -1.263963193522821},
    {0.096433505757468, -1.1898446649584045, -0.9531351916661022, 0.020838579204913957, 1.1133531831332095, -0.6804649074857191, 0.745069624002869, 1.864971358485138, -0.5826480110736856, -0.45581524470254753, 1.12858791412019, 1.4900371542365778, -0.3419140418049504, -0.15081654831710847, 1.3904286389740854, 0.5679159133392625, 1.814047058908751, 1.2512058908205508, 0.21639672027227594, -0.5038961778153938, -0.6663239645997492, -0.5620664356552451, 0.19618968134875636, -0.2962354654553103, -0.23078161295310967, -0.14576815679184693, 0.5144065518127845, -0.743431099163895, 0.7828217019995439, -1.0999109380028311, -0.45712350546870195, -0.9298540578675174, 0.47804086269873614, -0.40292278161618494, -0.3105914912551044, 0.8177309341399556, -0.04876350328172283, -0.11869320467103663, -0.8771595590561664, -0.9797877302766581, -0.49278668616520843, 0.31693538352640516, 1.3376353752026986, -0.5868382662897004, -1.2677312711489348, 1.4349581113004624, 1.30249467604637, 0.5610351627204051, -0.26694725148286447, -0.4268615924311745, 0.34893230861110003, -0.15239331867954314, 0.7249763157049313, -1.1666772909566818, 1.6125906703714992, 0.06857766413217589, 1.505621866117428, -0.2798685576586087, 1.4597231643707809, -0.9776088197597602, -0.4352811508603029, 1.1525394564869678, 1.1349840216889733, -0.2591431126109972},
    {0.042644047212310035, -0.22799409767387466, -0.1769577058017038, -0.39769961558728495, 0.025269664360779036, 0.2252438121483454, -0.32193032293191187, 1.7377739225175737, -1.2545111476026525, -0.003781797441510243, -0.0021509127239138694, 0.9314880513308189, 0.9924564576909547, 0.7288019617925666, -0.0507413339116951, 0.7611714464153848, 1.6407341807144493, 1.1030569437307893, 0.6711683508236218, 0.08716935045935924, -1.4712659552858425, 0.704081521788721, 0.3418543506292259, 0.96358407925058, 0.7379904081025146, 0.24485046353594148, -0.005048031493464439, -0.03981901478101164, 1.4771173744200083, -1.1948644805896453, -0.38956283233065747, -1.2613849614106252, 0.9295866956276055, -1.137431660834029, -1.0850226428746237, 0.45602341745957564, -0.7840045702987596, -1.3444094365738162, -1.1917060192302404, -0.9331879322928172, 0.24718389873386645, 0.39474868611329217, 1.1772794200087997, -0.5961253588479737, -0.08315918520294652, 0.7135255966878734, 0.9737275214554755, 0.13783944125068695, -0.726960050723612, 0.677049544094307, -0.47866154324404014, 0.9885045432385942, 0.1731584128998616, -1.1056184642417164, 1.4383003004354027, 0.09249245048244713, 1.1684202604201266, -0.023944795889710265, 1.4963920389333407, -1.8422448212876559, 0.7510679574610458, 1.0636310657927293, 0.6748499718913487, -0.016624985505780995},
    {-0.03775169176550244, -1.1933043519433038, 0.5200751749493998, -0.5495803942626432, 1.1432577860000999, 0.8716265551416847, -0.1432480492745114, 0.0186933301434701, -1.4675810909295965, -1.3966160491772506, 1.0650617087909564, -0.12921657853199212, 1.1526703636385114, 0.6238379403572049, 1.440501200550536, 0.8920291622046651, 0.8604065274984397, 1.5436135447923156, 0.026210327102112616, 0.31276905678140215, 0.25911313595787466, 0.6535721275808931, -0.08933001268523477, -0.21037399020841838, 0.59447909731807, 0.19489948311503774, -1.4686676512930759, -0.9447801970707729, -0.1316169154385428, -0.00697791150224002, -1.458780440794232, -1.132352334832336, 0.5874447868035961, -0.031234524989668725, -0.9583461339402696, 0.13705929676544396, -0.2829534042100662, -0.13113206560223192, 0.01636950348306982, 0.693812600570535, -0.8927257984773942, -0.21812668516064102, 1.6809290594695063, -0.43831916566508905, 0.3439800305402216, 0.935135271145885, 1.3115290986220631, -0.4938254209569574, -0.7043076301541041, -1.2694700135393182, -0.22416570338802255, -0.32914836908679457, 0.8544262493485449, -0.33821891475569366, 0.9006446878871716, 0.7238560356086239, 0.67980468740874, -0.7334010077969202, -0.2444192126644863, -1.2424953606074707, -0.540209696590801, 0.24004756276725678, 1.03884419749042, -0.26585599611500216},
    {0.2501450724931479, -0.9542979130234649, 0.6345813157632428, 1.0297122599859028, -0.7276978403743403, 1.2974647595423803, -0.05796707573636166, 1.5306061196467933, -0.5426935955035177, 0.39033439087883165, 1.557698557132518, 0.9266197119579404, 1.3795249181187064, -0.494172410845708, -0.3415188114294115, 0.4310099064824587, -0.017641609709782048, 1.2047264472554176, 1.2341394377286299, 1.1377628751780267, -0.3226636928340195, -0.5780664051467586, -0.411077479120981, 0.7932019747785118, 0.935116758383547, 0.21083429678714308, -0.6087500059046707, -0.8776656267446606, 1.4492813776127447, -1.0347084962254214, -0.694483537465066, -0.578503793238562, 1.4762178640134895, 0.3090333081969345, -0.4603996399859871, -0.2885386196511857, -0.7930934459501973, 0.007117594417477902, -0.1704054422828187, -0.4949545388947618, -0.9706320467865954, 0.9118875707257893, 1.3923963124936414, -1.1976535822125554, -0.4373158599287189, 1.381935344932599, 0.5854490052607736, -0.5329601777272273, -0.321979502899122, -0.09008824776902648, -0.2462904533173279, 0.5315572880665556, -0.6021105883199204, -1.1475649175132339, 1.4138428226360336, -0.7067777852507375, 1.3557604184273535, -0.4192891477719198, -0.2784609257479339, -0.34247880166370637, 0.4378711767764383, 1.2778748625095442, 0.6278285204542943, -0.5580813790046006},
    {-0.8998803531457714, -0.9306660303777803, -0.47662990618585815, 0.8794492984693841, 0.4165632740765414, -0.16820171508222806, 0.616610147084244, 1.0334467497388162, -0.10266477109626382, 0.2038313335849121, -0.2851713747264618, 1.4516725738170886, 0.46341938349800227, -1.323199093221053, -0.009100375871047088, 0.38699763873443893, 1.7254012133519276, 0.9552735652157422, 0.5667868546088709, 0.24056367823026328, -0.5877625435458873, 0.6683092699328753, -0.9486172581627673, 0.747177904904764, -1.012653436214844, -0.7976473503594388, -0.06017106723414666, 0.547467489618999, 0.3340451381084523, -1.0144416901440163, -1.5526096904820552, 0.11925046288267002, 0.3814747001030259, 0.5874172656117099, 0.15390539065631823, -0.9446295975800584, 0.4063791473662291, -0.12239212721271285, -1.3059893363549655, -1.1138861819605526, -0.18756920458310325, 0.9092185055111437, 0.13278012505657658, -0.6675894912897683, -1.1278558603212252, 0.005035118481904476, 0.9720946277599818, -0.36301147337051626, -1.088023220057877, -0.2880764612100013, 0.6233134768057919, 1.0570934841874016, -0.3739775121444452, 0.6651884255296394, 1.4222862451046778, -0.47741551376691155, 0.3125857175731816, 0.25460035206411774, 0.9306678324954857, -1.8665487376997807, -0.5717319423172857, 0.5875337981334967, 0.4588058175430027, -1.1938681112981917},
    {-0.8310090671821281, -0.05900880267039445, -0.7000401928462759, 0.6240043177602478, 0.7764429968114607, -0.1421074666224323, 1.0147507880747517, 0.6506477427749567, -0.007674906415534715, -1.6588228791557245, 1.6351795558270144, 0.39746420254586623, 1.1882294818723678, -1.3360470543149974, 0.9991592705956237, -0.1927463420307306, 1.7163588405228498, 0.6444185135274206, 0.5813472671418166, 0.6810018943640723, -0.3594136128094953, 1.2496797807564295, -0.6198645190507417, 0.890556059297946, -0.9044083201411061, -0.28475026533926434, -1.1095505698557138, -0.8306717364537933, 0.595714827146929, -1.7500896321428239, 0.18685877547187862, -1.2578065122307305, 1.2396758197831321, 0.1405884635154521, 0.22474851288390027, 0.01564785524949479, -0.997156212201265, -0.7145939446635863, -0.5925554988985067, -1.05156926616492, -1.3320143975820498, 1.0530366558503033, 1.045981823367752, -0.7517747556862399, -1.6002483226382147, 0.7493103823846922, 1.5863415932941887, 0.5682375038589735, -0.9798033421552053, -0.4937755204610855, 1.253918593113745, 0.9417513873107745, -1.0008481174083892, -0.33797310181306683, 0.3790739575858506, 0.18957397736592455, 0.9802178779465336, -0.642210799632585, 1.2170911608256043, -0.9621447295755059, 0.5130504280515665, 0.13802100785746452, 1.0709228707566179, -0.418808443534471},
    {-0.23926404826901673, -0.7923548945489096, -0.2575626962437068, -0.8528852367269597, -0.7426122285710756, 1.177970323104591, 0.8391755359223729, 1.6470066640528152, 0.5894495765542253, -1.0857931165307573, 1.3406936296448795, -0.19782131810135922, 0.9187417618286462, -0.6908655409191564, 0.2793182121660596, -0.9001611696266516, 0.09499100180576026, 1.2314087257532875, 0.9445661203796554, 0.4102605868152655, -0.7447328375723843, 1.1541201972054311, 0.08306842486640306, 0.6217599237622172, 0.10905016293257064, -0.26185369252131124, -0.8414493536482499, 0.48452593489328594, 0.15448078772736265, -1.0281659174236182, -1.348077393751054, -0.16621661013711655, 1.4803674107261813, 0.03275184786250356, -0.7924626086680103, 0.30347457260822314, -0.2972106399222484, -1.241129821039591, -0.34391694466565725, -0.46401008170464475, -0.13447065456226298, -0.2812257575105659, 1.635026285474182, -0.13813160804732627, -0.23930166511599008, 1.1078365795823801, 0.8572477022136742, 0.5044242035375899, 0.15174258670987067, -1.234505300212095, 0.8165756638056488, -0.41041294941638556, 0.5495949745924367, 0.21432466177628479, 1.5921326773193, 0.3480499382615958, -0.153180722358369, -0.11635222872631622, 1.065294472710896, -0.5233098047967863, 0.6144669491523999, 1.1190372182185224, 1.4002909321395776, -0.8762777804571158},
    {0.34529644138701365, -0.994786133122401, -1.1170559275496925, -0.3850511745535945, 0.6379474023141309, -0.08703280508746601, -0.6013156533436145, 0.9862513010887861, 0.15720671759567584, -1.2778426388152826, 0.026277427790581617, 0.24668461489773616, -0.7502061082292569, -0.5321353906061002, 0.15034705130571888, 0.6221901211853136, 0.13113158132190106, -1.5086246501620666, -0.9196873548960639, 0.35599481233442276, 0.2137648558595061, 0.30987186169162434, 0.2633835649838006, 0.44971251830475745, -0.6101597774949876, 0.3111126441581787, -0.9798044220797865, -0.7173592723723323, -1.1948135037646663, -1.0232337391148978, -0.8387033032455502, -1.628423153742139, -0.24923315068745652, -0.44993661522433787, -1.0219441214897362, -0.8954095196294488, 0.09116840688909363, -0.7560688427686245, -1.0118949176571919, 0.17168328850637699, 0.3413236097508898, -0.7758503428985329, -1.3208353497074161, -0.2957268102591441, 0.6196032560496201, -0.18482185445661406, -0.9558589749164194, -0.55249595683648, 0.072082685820146, -1.2626786507912884, -1.4145431465576765, -0.6234134953989318, 0.4857412840405198, -0.0213729025349622, -0.8668704437280101, -0.3019681342384119, -1.395561250373719, -1.5864642216146225, -0.27888936489665717, 0.5919221835639392, 0.05805361834054161, -1.5852529235976265, 0.14323620903686854, 0.42762252220385366},
    {1.5995808597857009, -0.09041337908747407, 0.4629230753509737, -0.5457095420444377, 1.2281339467136072, -0.6421810745435553, -1.0108328081452096, -0.6124116364989673, -0.7180117484993994, 0.3278612613317235, 0.6430924840521994, -0.06566982738378646, 0.5278211796744761, -0.8382935301496495, -1.3190811054171077, 0.18719735832040263, -0.8697011872954844, -0.8839150326103166, 0.6131132435363049, -0.11481219389899482, 0.04068649293573369, 0.7293265648878607, 1.0494824784505814, 0.6534436689482491, 0.2506874020668452, 0.8212133595167953, 0.6523736181010953, 0.4760382104532796, 0.10539360468549364, 0.5110098673861778, 0.31144767392327904, -1.1062901214202294, 1.0255328360551568, 1.1443390453037372, -0.776474943026446, 0.4672949384382175, 0.8847501050708712, -0.1470506197833056, 0.43039901506983164, 0.7854671697554472, 1.0505516907642, -0.4635319472108273, -0.4274836475761413, -0.7759391151512991, -0.6587513543311909, 1.066124220800282, -0.27871982490864855, 0.6505896718609356, -0.7322913231710949, 0.32801234022315623, 0.12013616557787495, -1.164379785547104, -0.7436897291453463, 0.8651402005336395, -0.5920946604618466, 0.9525784919738506, -0.8181976725304442, 0.7659031068200505, 0.48072156291790236, -0.2618050948504263, -0.09635891284208262, -0.742896065021109, 0.0727559975669674, -1.096910973627017},
    {-0.3755760491521707, 0.5089927129784678, 0.5795070655758937, 0.1462470996123481, -0.20214776037669827, -0.073812836907164, -0.12087871370721025, 1.0398573327304783, 0.10656711518237674, 0.7762562566899376, -1.3746042886253442, 0.535256094058168, -1.1794237562302357, 0.023275905404531644, -0.9954540091514207, -0.6565311494570599, -1.0358651585640368, -0.673057448090894, 0.5004009521412492, -0.3178041801904701, -1.0555274981904832, 0.029115506771512475, 0.7558017885798783, -0.9365132367013305, -1.2062737944508177, -0.27503800455654215, -1.2636781551929361, 0.23891611274706714, 0.5265256679087039, 0.4985158339764623, -1.2353274580815408, 0.23513357463313123, 0.12375936955113911, -0.1346554114071194, 0.0649026728013029, -1.4551503820031852, 0.7137005747799271, -0.06305758084821927, 0.1898540343191083, -1.0185810807355329, -0.47429338757547207, -0.8219343721525595, -0.8261679173269677, -1.313942718376411, -1.0949415570669927, 0.5126289031530491, -1.6032712370249886, -0.45900784922181903, -1.0463995073889902, -1.0750151673390467, -0.18616685544970862, 0.6149028531781947, -1.0036674947874642, -0.874987630110586, -1.379100230239201, -0.30207034027010554, 0.30218060632808363, -1.4128381959248604, 0.5084135005396, 0.5443381185139916, -0.5857236170408145, -0.08609391333161955, -0.9015190513850602, -0.2382788196344263},
    {-0.21842592881076278, 0.5021056962346832, -0.8420196471813602, 0.19570544559150646, 0.44827792928984733, -1.4631108115002387, 0.3302432386572076, -0.8994009753179767, -0.1272723794353198, -0.06082596482085299, -1.2909747645247125, 0.4021000409549442, 0.7094694074906216, 0.5813728085732326, -1.278457977644797, 0.31857666418743513, -0.9718667638594458, 0.5503002958972926, 0.015269546150306785, -0.4738006970229804, -1.323922488028003, 0.28537120477693795, -1.3056202158723131, 0.08315281036935906, -0.29385471429696053, 0.2938486906495031, -0.24808717108199854, -1.275187202084832, -0.5790479521719006, -1.1111191994979113, 0.17567386840101154, -1.0441183133897127, -1.1378118726840947, -0.8793519697462965, -1.0138922045527743, 0.24771643769888313, -0.799834544340376, -0.20221406319836496, -0.3997909785108882, -0.8286716144315527, -1.128422065383635, -0.07615881936160152, 0.2009825609866676, 0.6554592268005788, -0.01247149852821337, -1.4547189894585377, -1.682697626072398, -0.7203495206863184, 0.48386397328212427, 0.07582234001394565, 0.3925217966113257, 0.039640649625569124, -1.0370873729637344, -0.058111559212773764, -0.3560498093500123, 0.26663038400748934, -1.2161380529183365, -0.6508680128244695, -1.0261732524402865, -0.3937064274485477, -1.4129658184650358, -0.25426066684886917, 0.11682792975585041, 0.5555263745696096},
    {-0.05333658191071475, 0.5367652842603988, 0.8604489217482547, -0.3701275934110237, -0.25851177704630973, 0.44163762036463694, 0.4018974809204664, 0.25843912758066306, 0.15467798046513107, 0.060224536143800786, -0.19352309570548862, -0.9662926949986144, 0.15121876238419452, 0.05619458090108552, -1.215007406097618, 0.9461441943229331, 1.30268425894609, 0.8128218645690374, -0.9235229048386895, -0.8478619602915036, 0.49646656451327154, 0.47533235921742745, 0.8636859611789985, 0.3362805513784452, 0.056935593749511314, -1.0716441630379172, 0.481828823893903, -0.07610062462044748, 0.1515098385417895, 0.5372239903833074, -0.8074759002225864, -0.30961194453127705, -0.30648668126426887, -0.8214613343592558, 0.294725899654077, 0.4239628170590831, 0.12448304107921862, 0.92736267585234, -0.669216599257236, 0.37112134631656046, -0.6496660617226103, -0.3080692406013313, -0.900689395192839, 1.405257180038762, -0.9469374165645543, -1.0391698934767761, -0.7678141316785887, -0.13974779628861114, -0.4602272911492673, -0.286494512874926, -0.6323321138136409, -0.41079107525985475, -0.8679200360490537, 0.24664625617229924, 0.875310005607397, -0.5636837435648936, -0.04363928961758711, -1.0367909171735987, 0.12559879368695034, 0.7406957231485656, -1.0626926526503713, -0.21257252891405676, -0.2229773537052116, -0.6217088486614994},
    {0.11090206948856193, -1.001899624238091, -0.9541560262819414, -0.4993638699117081, -0.9693652721302064, 0.02266217209327151, -0.12600132465745142, 0.34870464335457296, 0.840831306144769, 0.4114766741060513, -0.6277745506227463, -0.17758924940275103, -1.1578504076845473, 0.26622286793088884, 0.29476280946666544, 0.9277506316576818, 1.0917107993048984, 1.2449557647214906, -0.18833380421070167, 0.5373589494787835, -0.6740801688717358, -0.42862328348975604, -0.15158112828935044, -1.0799588696416123, 0.8152099506422652, -0.20713743877694815, -0.07066280922038551, 0.38547662955986656, 0.7605384993656467, 0.5202843394901597, 0.04388654820054788, -0.387912017884208, -1.2709858594700159, -0.07905809340552555, 0.6463595117441335, 0.41465164771173285, -0.4733744931641142, 0.37894068745188964, 0.46671675042108846, -0.16683798397985963, -0.9909470006261673, 0.5104886534781388, -0.5579419926847805, 0.8106532365676665, 0.4062718101402034, -0.9192458151966387, 0.2792622206512542, -1.0742530401629273, -1.172144751466456, 0.13979458430124353, 0.5550771641369939, -1.1982960595817589, -0.14425948565949195, 0.8139093752788453, 0.3698980173793493, 0.010443489048431896, -1.0208238824643385, -0.3556379235937827, -0.1501905608822974, 0.37804233667246584, 0.5041205937431132, -1.3262822181173335, 0.4292865199866901, 1.0570415446499473},
    {0.880624278233829, -1.3288599874190308, -1.5383579432501227, -0.16234940516590193, -0.378145278574571, -1.4652162269029139, -1.0925320785294967, -0.5948900519961104, 0.9975372582986333, -0.9848642781176714, -0.5393053493626969, -1.019411920993739, -0.04698414147195232, -0.3986168207500621, 0.24453359002704592, 0.04713123451875102, 1.1138534338843327, 0.406356188008251, 0.8079150521548926, 0.0888879510510581, -0.9877680271956631, -0.8543257014476062, 1.2472985420923965, -0.9880395518054236, 0.4967945523443665, 0.7187148024848662, -0.7633068184699313, 0.3211351033011812, -0.40946475246936853, -0.5158757142798114, -0.13550561993337967, -0.9362904016520605, -0.9939961986130957, 0.4667497040241427, -0.4778014044863905, -0.2524667721977936, -0.11047214037171713, -0.7993357829980237, -1.1468747173751137, -0.3008985483528976, 0.7673286835257186, 0.3213342673527414, 0.2730815737226535, 0.6430967239826576, 0.10033902419253907, 0.313220214041757, 0.2124080256166167, -0.21178652241610665, -1.1502920482639216, 0.6470785686205459, 0.7915748705187223, 0.29605597573147224, -0.6325397150403271, 0.46740508311801493, 0.26417025807832134, -0.39982631917614014, -0.34515939221327263, -0.26734858732063765, 0.8482440376601612, 0.5196449111193026, -1.2132330733800436, 0.714448542731829, -0.14628706481074782, -0.7512109853146751},
    {0.3204185237579873, -0.4012199743463723, -1.5043842959209877, -1.1785038618259407, 0.13782541994264502, -0.479726506162378, 0.5442231829793438, 0.820996320145286, -0.2493072719295218, -0.5710962475280571, 0.19193675750150246, -1.4410607963143034, 1.042552080083059, -0.6393724583201946, 0.47464015785957686, 1.0350468107166948, -0.6114618099911274, -0.9145282247315654, 0.24952355510931803, -0.21041268617917708, -0.3853350338878218, -0.9948037755485952, -0.7166839464895314, -0.36523478596421066, -0.6333772796938744, -0.5503370390187953, -1.1849195864648636, 0.12478285388000497, -0.19596080871598337, -0.6681979413021336, -0.8963451391634663, -0.2764151854064885, -0.3650388251898771, 0.10425158468381308, 0.5652828584186073, -0.022684626593172927, -1.1210831774615442, -0.4106784350708415, -0.6213040275257283, 0.06541535753493821, -1.0609691870043363, -0.8736245100804475, -0.42029459469141045, 0.2210558865416447, 0.6617598588240176, -0.4366892314001383, 0.70060781781596, 0.9096413835196265, -1.2620062361362465, 0.48283190377417473, 0.21075723192503346, -0.7863039758500748, 0.45063316314981466, 0.9795554779169416, 0.13341973311130637, -1.0369283887992806, -0.699661178496887, 0.19969100054129515, -0.0014241467004990982, -0.8898366233222924, -0.511250091248067, 0.23215025135159545, -0.6232086260926429, 0.7865659578935751},
    {-0.677704532928652, 0.2679487479878501, -1.3049425163510315, 0.5481615310250207, -0.5294567057548285, 0.2793832588696726, 0.589774235379528, 0.6360061228340598, -0.018286074017299016, -0.6930258647847373, 0.744549090914128, -0.782884513184143, -0.21115176524781354, -0.2098216794273265, -0.8812092652893965, 0.8340774743791165, 0.33119996659754075, 0.15889376350660958, -0.5016021132705503, 0.5459541195641053, 0.7092600070628323, -1.7002213646955306, 0.48585455271035155, -0.784300064468107, -0.6865716113422998, -0.8329801039401764, -0.41824573494679, 0.3267241741325064, -1.0086817800663723, -0.482631813657764, -0.7086945017534894, -0.3321268996867031, -0.9104757365026427, 0.1961423538427405, 0.7703733580608049, -1.2138341171098306, 0.23277181991399237, -0.49780254904973226, -0.9031035246178427, -0.4857758744254729, -0.7476569060433003, 0.19563961353777196, 0.6710642272807131, -0.49211004371579076, 0.6534494539406909, -1.221708592370391, 0.26923259149349354, 0.4349819292315619, 0.49944778284496455, 0.07914283467084711, 0.6349799040399666, -1.1228111971641015, -0.6547738070897745, 0.8260127821895888, 0.6957829555693975, -1.344258955893477, -0.5466597459456166, 0.30778624520169656, 0.8227819299377968, -0.26709224953945027, -0.9877871267618021, -0.016590709089269053, 0.08810481215454011, -0.37439410597038425},
    {-0.44095909271728706, 0.5935274509606003, 0.21553025346589388, -0.2381993941696192, 0.28747968894381853, -1.4589241975900915, -0.6309129003627073, 0.06380711526003206, 0.8399903479323299, -0.176109334319031, -1.5241914621923225, -0.58080349296407, -1.3533096989977873, -0.2842171992457074, -0.10908623887001498, 0.656788639959895, -0.8159977490560804, -0.8467975406901879, 0.033857931319858786, -1.0991345120425255, 0.9125414457125297, -0.5989575951953109, 0.5498755830220251, -1.3952028971656243, -0.1977171951035552, 0.45182366961126275, -1.2153580091160692, -0.15100221194108726, -0.24241163529514373, -0.8994716144219308, -1.0242715923786865, -0.9262821771337459, 0.3931427403192323, 0.713997739733808, 0.5772452645813846, 0.5382804836061469, 0.5084566096032402, 0.5420734286494298, -0.06049262547110502, -0.07552497484093774, -0.1435639273226062, -1.8122078623404019, -0.28505992380100037, -0.48200719245134593, -0.22613107242152325, -0.8658542841261115, 0.49776831602592075, 0.18774732255238913, 0.6050705212994889, -0.6610648121151661, -1.0203054425444176, -0.9797279999989172, -0.7017735484959061, 0.853205727830838, -0.7877509033271768, -1.1284190941663954, -0.7562292601570064, -0.6851151141496544, -0.10829275402394829, 0.20141732090092018, -0.9680392608348609, 0.43866337753515305, 0.08284558217766361, -1.0926434713356352},
    {0.41074722873188363, 0.6220296778503556, -0.6500645531359561, -1.3867807500418512, -0.3509598021180879, 0.23523708983098937, -1.1900338293291512, -0.10431120395160882, -0.15329325703978958, -0.9678369626472548, -0.9266523172536076, -0.8939808252924832, 0.2994688400148208, 0.5212577888669928, -0.7527221403306863, 0.45974587870873546, -0.5033511242251237, 0.8625833385655699, -0.1011272861390276, -0.11598812787442732, -0.7285664352691575, -0.6500350035603542, -0.8426046217301096, -0.2654740975270031, 0.7605162434209559, 0.21100549018402168, -0.17037605735230013, 0.43451632195570394, -0.8316352708096354, 0.07328400518659572, -1.4126136114961065, -0.9959972704465426, -1.2442690775467131, 1.10834855660236, -0.6153084918115277, -1.3342472784561241, 0.9926161078096007, -0.6368911421111145, -1.3415386855501392, -0.15901120108579872, 0.0682115964877292, -0.37887846038043616, -1.1968100755253739, -0.9891470122882307, 0.48975117530444146, -1.0434670296854407, -0.9643896022133593, 0.6345553240440212, 0.7061954884943411, 0.29833553138176444, 0.053919678459470675, -0.1557441374223624, -0.543223660951364, -1.0441684698444476, 0.025576914503994023, 0.7336299915027947, 0.32665178256798516, 0.6564637384944743, -0.16937021796652432, -1.140444005659262, -0.7950023432019503, 0.0027323408053765152, 0.024760647231612806, 0.5485165330863955},
    {-0.7692413857804542, 0.6987620470169261, -1.0988355591202905, -0.6789641229621038, 0.7232718340492498, -0.048754817099131584, -1.3398769364695002, 0.69157729733219, 0.6406982294826918, -0.240526876762323, -1.3229903975945245, -0.5907461534352588, 0.25902915205577076, -0.7548706123703206, -1.4721714155353876, 0.28968373952014936, -1.055053226083388, -1.203462133887977, -0.11234172966186963, -0.7505938925821452, 0.6503359461672052, 0.7343948795294577, -0.8670668086266864, 0.3439469484543263, -0.8182934011773655, -0.5069834617103802, -1.4191972346723436, -0.16963335801139756, -0.8916227744388712, -1.075735638951627, -0.16448168717757217, -0.08279311699363243, -1.2301924201613266, -0.7019328139657947, -0.08346344070885252, -0.6794997947762477, -0.7446565824011414, 0.855590574965947, -1.4086835848256503, -0.5504157733183216, -0.5783711121313452, -1.572627160244757, -1.3003085538981987, 0.4509549992267775, -1.2108477816311576, -0.952295736497957, 0.2879274171501877, -0.8964277739558111, 0.1609910510194603, 0.16595625650298973, -0.45279650643001196, -0.6648364026288169, 0.621253479415895, 0.40133275248067674, -0.023726840221545486, -1.252471084145365, 0.8270840937053395, -0.7812369747319483, -0.9336021133679273, 0.4110831834612751, -1.1421076747623191, -0.025805364997130303, 0.1673013971317815, -0.1548876940678508},
    {-0.6568809373594828, 0.07954772382028938, 0.12657489028375343, -0.5458106260700337, 0.014420446509037819, -0.3030286285334703, 0.3634561395794039, 0.13201046829917096, 0.43587022083505417, -0.9173390402391763, 0.05982356586716441, -0.9915833661389716, -0.6294075504489374, 0.45513952514640477, -0.016539918836625082, -0.3365447564110132, -0.259413973288716, 0.05710238809761434, -0.18340814694252744, 0.9158331489233529, -0.656976526536533, -0.20078676400138643, 0.36881932367946574, 0.1200294493930698, -1.0992097125583098, 0.40349398098065076, 0.03356383680213858, 0.613395118467432, -1.0957107060943694, -0.21683857222699246, -1.0246008695616797, 0.29625801822026376, -1.1188962681894072, -0.848985024218883, 0.5237975810876492, -1.0308615912225325, -0.3210801449429063, 0.49494798644220644, -0.8525442679388757, -0.1946621833924339, -0.7236059393620661, -1.5204435713972069, 0.7336036336546826, -0.4972690344849491, -0.5004383371991227, -1.3697927545935809, -0.6890045505753815, 0.6550893062050387, 1.0306954031953461, -0.5405824120474418, 0.2865961649581729, -0.7130887853995527, 0.08028851829687943, 0.10135334342203238, -1.3946480470238896, -1.1296535971105537, -0.42124698728001214, 0.3498288618403655, -1.0872635862846882, 0.07336719953454787, -0.418852516747461, -0.11648573970804359, -0.4496236905777525, -0.9662488967294647},
    {-0.5378103995799653, -0.3711382657605889, 0.20466015191544576, -0.9590082409110606, -0.8894565739632834, -1.6383920563463787, 0.553035100799386, -0.6656171402767067, -0.5339275000343942, 0.30315416039339177, -0.7546068954445234, 0.11673420984567537, 0.2573974090759488, -0.21754378561150267, 0.010696710876223045, 1.0637078419981647, -0.6786799221044361, -0.15972209017385672, 0.03930874857400482, 0.2882928907279977, -0.07371804514192541, 0.7946222310641553, 0.31410228884186747, 0.6741366295073483, -0.5487080565575938, -1.0460966988444764, 0.13341430154754466, 0.27993172045089953, -0.9718468549403129, -0.017083241175536123, -1.1833654199215649, 0.3754020972881554, 0.4124843352700158, 0.9399818056015697, -0.6291491457648736, -1.294742398716654, -0.04233801679634751, 0.49640406802770837, -0.28852551810643806, 0.019776999215849217, 0.37297665861038476, 0.0878765664066141, -0.7324899728189055, -0.5728707542299287, -0.9976538951860354, -0.9051366248090259, -0.5268563519043414, -0.4758914345581258, 0.1348467777551742, -0.20589478540742825, -1.321307805941191, -0.9448512308791387, -0.8071925698122513, 1.0661046070048126, -0.5375115394426462, -1.1435357361443435, 0.7931479544147856, -1.1639179855725823, 0.6395806147535418, -0.11965988680897688, 0.3440035081404078, -0.4090941951592581, 0.20570396298252666, 0.7766728008969205},
    {-1.1026890859883045, 1.22625886211944, -0.46373333733603633, -1.208636171210379, -0.5068128265427159, 0.24850655542124356, 0.5911618759128453, -0.797884925414248, 0.20855926972521913, -0.6550881042405908, 0.01799724534578167, -0.752493454233645, -0.5358236589777934, 0.3930111090046737, -0.9735352038559181, 0.7531548051171155, -0.7121879860488397, 0.5287920530334674, 0.157849108672007, -0.19431002100702172, -0.6634254195521562, 0.344293131409496, -0.23011455175529202, -1.4011880155038876, 0.4625596928114728, -1.3303686589044441, -0.2629490349558047, -0.7390674641510772, -0.17260615569034699, 0.5309104021659575, -0.6447161085878541, -0.834899739554866, -0.7999042600530517, -0.6330205137635622, -1.1359481911524534, -0.23939747025984096, -0.7060355094700208, -0.4269163161115103, -0.13343173366042216, -0.1067321578420229, -0.2673182681945866, -0.8818008914788447, -0.0177131471553762, -0.33980174655874545, 0.8289280985057895, 0.08401713960321047, 0.37334931947092626, -1.1268561960002155, 1.170035665912022, -1.0368074488393972, -1.2566419568712286, -0.848622632583321, -1.439278835994131, 0.101944253223785, -0.30785095996458584, -0.055959604152786314, 0.42537139623063763, -0.8578617551594208, 0.4732135443866588, 0.02270371683398385, -0.18992340583624773, -0.5749244832299242, -0.5630608638306812, 0.5330290205049006},
    {-0.9430959571134802, 0.8988067884909412, 0.5882458123159829, -1.63511548005167, 1.1623879916930047, -0.7923956770482327, -1.0012293490666293, 0.2927537254107686, -1.1489427193423996, -1.1511823332065763, 0.2908402521718379, -0.7730048035830711, 0.5037542137513433, -0.4214602138369885, -1.4625712456503528, -0.11159358069575477, -0.004807215852254627, -0.3507285836258741, -0.8003526142321953, -0.8403590748662011, -0.4241414763700557, -0.5956805475469913, -0.3043812823434915, -1.3258533832638058, 0.7888615855468265, -1.1891212467058598, 0.3344582421079831, -1.1188446684388393, -0.5166633221123748, 0.68911475508252, -1.0805856469761248, 0.5545155609366526, 0.06818622648618552, 0.43686461697870743, -1.3940640985820782, -1.1443126777502624, 0.3125433765597696, -0.9269716842290294, -0.7440751081733392, 0.3148686486672189, 0.2436073779758401, -1.6597200689832874, 0.12610193417577406, -0.1487380984551607, 0.9294154562866738, -0.4352394913830997, 0.13839647074889413, -0.315270337935192, 0.6661336907727154, -1.0343392584496294, -1.1908374094227763, 0.6328439111797484, 0.23643560230958416, 0.755563814935255, 0.16215796373493283, -0.030089531811015553, 0.11863514731692237, -0.24721431889554069, 0.6499705379623566, -1.0717941368794561, -0.25498549406765675, -0.7951951012397865, -0.5787886164206978, 0.21979404447350817},
    {0.3788912876338867, 0.7508696186324569, -0.3951363798800534, -0.15344924099231183, 0.3171567383307547, -0.6442358193265517, -0.16487123026540879, 0.03205939207329905, 0.6937045633961771, -0.042186225256240564, -0.17787161138440252, -0.5711631366811329, 0.895260220613792, 0.7622037521146975, -0.8494779563976069, 0.3731192824323035, -0.616530955396053, 0.520001404727524, -0.45899952060945554, 0.02580724298090071, -0.899832160464251, -1.2183762112240315, -0.7203122754070959, 0.6357912768457589, 0.20685359186201052, -1.5334139576223547, -0.09862230404312469, -0.7933087380701442, 0.583570674462663, -0.15204569653970082, -0.10560105867648911, -0.20420873354949862, -1.0812492201406616, 0.2623867936851224, 0.3974861053760858, -1.693138723083924, 0.5203014155511737, 0.16957862270883878, 0.010768593412444944, -0.41748837236592334, -1.1650599925879241, -1.061245119372936, -1.2065809098172968, -0.6386806512609463, -0.5268480983331144, -0.7391868870905021, -1.503215718438501, 0.522940246781505, -0.33465212225312685, -0.9149794036090888, -0.761881463029205, -0.04667656881051474, 0.25585676934246976, -0.2882752656618348, 0.07940900555958856, -0.27842577679303904, 0.6373851586121688, -1.181472556999348, 1.0134291382620686, 0.9826459317667179, -0.46976701596746606, 0.1300326304800986, 0.27940345511925063, -0.7650145268517334},
    {-0.7405832705792977, -0.15871759399836333, -0.1352335599177557, 0.06691421598331941, 0.0015187503945059938, -0.2775455118226284, -1.6985035749165356, -0.04660229696404729, -0.8869569549075981, 0.21879348033798546, -0.1302953895948807, -1.0031713380316132, 0.2900734518052433, 0.14428384781410128, 0.5846157474376914, -0.2545775746539102, 0.9017779012907366, 0.27624881344448116, 0.915717775363371, 0.8328500873234493, 0.49060178617775935, 0.8387188719998798, -0.40605121710655445, 0.8858704611426786, 0.24333598631545783, -0.007360305403371647, 0.1026167390636657, 0.16689331787495051, -1.185266089904937, -0.12968571507457938, 0.21170717148912407, -1.4543998391692665, -0.6493950579601037, -0.8374991817743384, 0.7439780334599219, -0.6118643293136254, -0.06324946416891129, -0.19940865382698095, 0.706709371330477, 0.8681792263788526, -0.7494242898606863, -0.4912620289775016, -0.7822467550030294, -0.21958119427439932, 1.0463638211991002, -1.513326452183213, -0.8458283296768966, -0.9778409263002265, 0.7329282978885365, 0.08830618519217208, 0.11186394464514392, 0.6251185731627241, -1.4781553104553207, -0.17060890772105083, -1.0222441227524313, -0.1564439318460368, 0.17989711096392705, -0.9529141232853454, 0.47381125750493475, -0.7207367277630019, 0.05065440454331349, -1.012205589548876, 0.1450009129647764, -0.8083687035235375},
    {0.0735417475360066, 0.8540566047787983, -1.1835327494387606, -0.3142141369832707, 0.3143149089238431, -0.2395028054879934, -1.603593461416273, -0.45883586893897443, -0.7284305753438834, 0.6405108401545191, 0.12188421926921407, 0.2801219887691466, 0.3177330844718513, -0.4443037475064615, -0.6626242062521346, 0.2636911487297892, 0.7617524456132414, -0.25986297472011366, 0.9680999158440353, -0.8445341302489802, -1.3965682613273989, 0.2061796625794569, 0.019604905258726157, -0.6059824289546946, -1.2389657428951721, -1.4164417607250255, -0.744919913487445, 0.2505372580172941, -0.7436273975084113, -0.15028817863869365, 0.11308278068425344, -0.9889891396821817, -0.45721844798533784, 0.003697050966924122, 0.341627574177142, 0.3532652867700202, -0.9110142740332625, 0.7284105994090345, 0.5744026439906639, -0.8994595357635692, 0.29607257901137807, -1.4421284662797818, -1.1112082108053303, 0.02111261896411092, 0.41062754217023845, -1.1620130760100977, -1.3668497692974388, -0.19160498675901277, 0.9804412430826143, -1.1055932346137154, -1.1281367849304293, 0.3709157698999999, -1.7161490484467472, -1.0317833842513577, 0.588865426252602, -1.076195412113812, -0.849755512609533, -0.7423096517933175, -0.658028114252722, 0.2053805044633985, -1.6148421844488845, 0.4677733640784149, 0.46727154751533445, 0.4093642499493608},
    {0.11320068679686339, -0.3454965818358066, -1.6665408235900026, -0.1950312257863347, -0.42463716809352614, -0.018494174317186692, 0.20218631334316958, 1.0800903149855567, 0.1894846089955575, -0.6119498652731608, -1.0855501828979264, 0.5048650815318614, 1.046337688469736, 0.4292098898300428, -1.0275755874244876, 1.1391603148269036, -0.05502591705393516, -0.25885080543021244, 0.9161656180563903, 0.48797735024578154, -0.3553931911413472, -0.35569539533499844, -0.5140308806641471, 0.5492003512381848, -0.014972262756361212, -0.5063155992075341, -0.06948386264391274, -0.9891709341865726, -0.6180501679611327, 0.5729456261174725, -1.5346297930943869, -0.24444758151052634, -0.2059545957083405, -0.20996285222937017, -1.0507638408704332, 0.6250789844066161, -0.9346718872394845, 1.249049870804919, -1.3547423130190588, -0.5593788689532698, -0.5076418995738518, -0.30316447709130456, -1.4014320919705539, 0.552982676248841, 0.37805502679765196, -1.2240553238682852, -0.7066101365129642, -0.32567128669324585, 0.5749877102586669, -0.6312483965092329, -0.792176811019432, 0.2735944171325423, -0.704182774701869, 0.7231461579670269, -0.3838278160652695, 0.25617086519531185, -1.325663615579869, -1.3978488319084366, -0.059201749613171095, 0.2521673567440848, 0.330617835408328, 0.6335675613788002, 0.13187782964254388, -0.7820100990067717},
    {0.3728833373116122, 0.672393551437998, -0.004992573951472097, -1.5314154140004383, 0.6996877403726277, -0.4457620552498121, -0.2557824886605251, -0.1572460123913573, -0.6318746099082541, -0.606519143481401, -1.106430406033753, -1.040990709091941, 0.26909686425331786, -0.46090172288391684, -0.39376669429727995, 1.1715589195347085, -0.5279886711334508, -0.9734001905028149, -0.1921590628915698, -0.04944483697045816, -0.23969553454557782, 0.9108151113847123, -0.5566662386629594, -0.9647525847369108, -0.32880609177709325, -0.02918717486648012, -1.5032812066975905, -0.8380165460366751, -0.8039191713211927, 0.09050253288745674, -0.36685543673333904, -0.4258929351754394, 0.34547030547979024, -0.5682860463537885, 0.39448030548364943, -0.665965058252294, 0.020289290253683562, -0.12212992393529896, -1.214467255949017, -0.4701547913499337, -0.4188103695033178, -0.26808493483865675, 0.04255752634902331, -0.16956971531227266, -0.525434942199518, -0.38853064946075905, -0.565909271345738, -0.4597528258659923, 1.2554196133004283, -0.24747305298702105, -0.37513854450556633, -1.18824096435139, -0.9158551701395352, 0.17226758060994352, 0.06256136009030135, -1.5633710507771201, -0.822232880684859, -0.07280589233847043, 0.004907020873554638, -0.9347240208742319, -1.013878935363983, 0.40575316374073395, -0.3871459708009645, 0.0980200413863816},
    {0.652933033889205, -0.12254169382533987, 0.2176753548532386, -0.24133332528821408, 0.9060068276752035, -0.7062078017771305, -1.328890326473872, 0.40351981730666636, 0.39347776402940843, -1.0512389554644783, -1.2920707988566935, 0.4080912505278594, 0.8864162248487507, 1.1895372308971155, -1.0493032347906661, 0.36842645153031833, -0.02415769248517202, -1.1508779923113912, 1.3513292679554432, 0.4462833077300495, -1.2179152749818334, -0.20568106202715658, 0.8855567887771247, -0.5206721036922918, 0.2392228224217958, -1.46334529162053, -0.694749085052831, -0.7810230825372542, 0.5063912548849123, -0.2868409809975416, -1.483550315627547, -0.38089156881471253, -0.5018547651076218, 0.4131178111061214, -0.4037891658473364, -0.018273034987903135, 1.287919003755188, -0.3703283043957613, 0.024621061021645716, -0.7185196352595655, 0.8666538614187386, -0.022044148713956067, -1.3772528728142446, -0.12571073327890303, 1.1461102950369846, -1.1970089476309218, -0.44149520345488125, 0.724131854385838, 0.23627783126712207, -1.1871049005805607, -0.6297856338689056, -0.05362620589372887, -1.5395860537942938, -0.054553930696229186, -0.746771294045468, -1.0267203976531514, -0.6646205708482928, -0.7305022740255666, -0.1941470456393805, 0.8968153086509655, -1.4255453638642728, -0.23129316236335717, 0.8248879513783899, 0.27303140472292314},
    {-0.3149885615586081, -0.1823729766243486, -0.12899871682687733, 0.05354708871696093, 1.6961048447928837, -1.0395215799468047, -1.4958033425343547, 1.6137928186993777, -1.0435467656839426, -0.40762669846219673, -0.30347702251838604, 0.4078997811920738, 0.36908235164054615, 1.0313136818521733, -1.1358431445751698, 1.286944099420627, 1.420557883684604, -0.7608971833318168, 1.0647332006665502, -0.40845606357588393, -1.4631789359066765, 0.9118897682936834, -0.32870949316892023, 0.11990112385742387, -0.7016988812408645, -1.4887926430049305, -0.487803293161884, -1.5908817270671942, -0.3711531006276969, 0.3221141208727883, -0.5976307746243041, -1.4400320041886832, -0.6160977204686052, 1.4909317478939126, -1.1211962292162505, -0.4981062078850026, 1.3662495375902362, 1.2744639259835158, -1.1164725741813153, -0.08036089291420537, 1.2079043668366811, -0.06432415975527299, 0.5490466977273765, 0.14795382557100195, -0.4749711267394286, 0.7604885266802381, -1.522061855874314, 0.44275458623965935, 1.1719921077154787, -1.5426887383936683, 0.09613507144600338, -0.9406007415789608, -0.5476215700603718, -0.28067907408410525, 0.84866812746334, -0.8255941511543314, 0.04318502919625245, -1.514664912257416, -0.661166579775552, -0.2937484226398176, -1.0384168910015323, -1.7834601300030213, 0.06862041120511263, -1.133756005876313},
    {0.5344353335756867, -0.5737909483555104, -0.5466502828518599, -1.7526219788424842, 1.4401881225566002, -1.3181525798859302, -1.3660757528152379, 0.7341426263675188, -0.10978780424242934, -0.11640174907800514, -1.3563883887902763, 0.450427234655851, 1.3251714496310605, -0.5375199069157058, -0.6701965729864647, -0.7882984106732361, 0.6844292381754378, -1.198081960213356, 0.3259447449426712, -0.1481129273673294, 0.33309837969937484, 0.006252790671182962, 0.063743434248914, -0.40561868906988097, 0.5832780450451758, -1.3518219868719048, -0.28861354644037635, -0.7332443022485129, -0.7908733094233503, -0.7348034256789074, -0.33713014905438315, -1.416512756113712, 0.5869532199733084, 1.0853774664810942, -0.3415093409096179, -0.811279971380329, -0.3957278052865161, 0.44344948613246593, 0.19258133677664596, -0.8020483569748708, -0.01612526244760552, -1.6838474507976002, -0.2052857579571219, -0.4221183004211799, 0.38582051347069185, -0.922898419343268, 0.11708492959814902, -1.3599926440777035, 1.3530889105207522, -1.2226985817357274, -1.1048085150186036, -0.4514283057994327, -1.8817051462281986, -0.6481898808732608, -0.6583561176055802, -1.6662568210688524, 0.5760448714019442, -1.8315457077790236, 0.4704031182322061, 0.18191456470439865, -0.431233115679313, -1.3390827988131309, -0.5396742234391463, -1.2794820949231986},
    {0.45877506109084776, 0.1525257366667999, -0.5246181705895714, -0.33715292458693435, 1.447653638898675, -1.9480487604545205, -1.9973456248229298, 0.17577846397714925, 0.3001274667000038, -0.7907732659733078, -1.6248672594238336, -0.8963373727922905, 0.16164614888802084, -0.8529449737608954, -1.7060752395443364, -0.21726981937881146, 0.6737958945158218, -0.3682765527854618, 0.44671195953845183, 0.9137230225951551, 0.375922647315935, -0.25352725345298927, -0.947152004907796, -1.0552994541035856, -1.317750282641056, -0.8013828455327138, -0.3757931417329693, -0.463035514773945, 0.2357797650238325, 0.6467163723897235, 0.5398331288363236, -1.2340387246261821, -0.4153855324828338, -0.18819233534269894, -1.6474832506440966, 0.4739727140698895, 0.14015182431562434, -0.7710932069514131, -0.16407274320418608, 0.5799814521184593, -0.5954686118462229, -1.1792982092915447, -0.3763326975456777, -0.7762681371324881, 0.9904544426310513, -0.6908704938404289, -1.2180305283847022, 0.20859702207075215, 0.6219720703271131, -1.5608202518366254, 0.19127681105035071, -0.274932868425082, -1.6572196076137378, -0.41649689948757684, 0.17622187544978155, -0.8580541202564683, 0.7137669811232091, -1.6211542709256277, 0.7496504419169213, -0.20703498984981636, -1.1704881534882998, -1.22943788287186, 0.7430008426897741, -0.5150252054938438},
    {0.25017116682966317, -0.3270345725462166, -1.5491240743555632, -0.9701784753823823, 1.3583655658596612, 0.23024657777438962, -0.8997535865532176, 1.1479335532005022, -1.2291674368708878, -0.6216953701415034, -1.2832894112481723, -0.04151462809148551, 0.08249834076115055, -0.7987525895969341, 0.058161344310219965, 0.5788729674592944, 0.11969678342050982, -0.6183150401629735, 0.6490439983653336, -0.08819426652943899, -1.4718160937356353, 0.4580740959013783, 0.13475617781535626, 1.2953317134209532, 0.6671042398306353, -1.7885415944937326, -0.7445872785701918, -1.4839640835602406, 0.002329130384113857, 0.5244110476837246, 0.1562194939097696, -0.6080669928421604, -1.6484636452507375, 0.11376891780154533, -1.2618218520504458, -0.19803026331052975, -0.02783558341437696, 0.05546110375244152, -0.22154311570495908, -1.0889318992663082, 0.2631516047594734, -1.2431494148934237, -0.45813539064117226, -0.022551326836976037, 0.9985424695559036, 0.10574158774913779, -1.4088986193748625, -0.8091757275506871, 1.2697626669252047, -1.4037755709270068, 0.4181304247136753, -0.6349726481196972, -1.3249191999059422, 0.16088983338761553, -0.3560408821513375, -1.8710416820949725, -0.9104867163260897, -1.5710095572809162, 0.8025176105476894, -0.6827903056073058, -1.9307805145120114, -0.4289698761121176, 1.1010377978733203, -1.2076492695706056},
    {-0.5067670189663913, -0.36772357838874814, -1.6641296809389567, -1.90555629970536, 1.6651837927828108, -0.705676021397267, -1.9084827381188814, 0.1771378746676133, -0.06539840074286929, -1.4306179435801423, -0.861311524198263, 0.4755787630881605, 0.3785305552726618, 0.8746586499347204, -1.601669151854019, 0.9672139279715308, 0.35794602866730824, -0.7939117819838827, 0.7614579962089625, 0.73372940324442, -1.1952874792801662, -0.11765850473108799, 0.5758566005751818, 1.0196303216422686, -0.5078716937647398, -0.6391735052752385, -1.387288795092573, -1.6851065731533958, -0.08616255222586634, 0.9375270371571397, -0.24631911513850502, -1.19319068535912, -1.5219758464404516, 0.3285450530194103, -1.2188252356768656, 0.7633667150074824, -0.3235540565075118, 0.6451784109548194, 0.004235641709293897, -1.0630288507683932, -0.8263660275489264, -1.7194167717445608, -0.55873901176609, -0.9190555641993589, -0.0316280558647555, 0.42548424013143143, -0.3781384750409271, -1.3556226493140373, 1.141890668036699, -1.1985199383633915, -0.44670660284816144, -1.1473628439818289, 0.04217095038283531, -0.4549752811494132, -0.7040050239719544, -0.25970924883038454, -1.1766957682417327, -0.13914836757611335, -0.8149507125674473, 0.9845530129308445, -1.23790061786973, -1.7275666237277265, 0.8859324151485426, -0.3820330410724762},
    {1.01169114320047, 0.703646477798613, -0.4998368590268166, -0.9403805202544248, 1.3420987087504803, -1.4529694355496838, -0.49133412797953196, 1.2543165630981554, -0.5011771311627891, -1.5712629975449546, -0.7038845444759455, 0.6566781271524149, 0.7747329001494535, 1.0924363882687462, -1.6253964546304396, -0.3883042560603931, -0.7522326165976808, 0.17460018205706035, -0.4566677162613614, -0.19332073464667343, 0.08068445581846034, -0.5508944334528987, 0.7819798513020471, 0.11807264286208143, 0.5354608451363163, -0.004143257372272414, -1.4007138424936598, -0.751436336888748, -0.6473363840271353, -0.26795973384693117, -0.49959596944719215, -1.2735105755526517, -0.6722091199541822, 0.988125722804372, -1.4602011079404729, -1.0201585418300252, 0.1837547572867977, 1.0010826339575565, -0.6095665701507909, 0.400512751832898, 0.6895587227100616, -1.8965366102460814, -1.0628636480501572, -0.15627114640134143, 1.0056061651813823, -0.6240686879328258, -0.8272857688914741, -0.49306549421356427, 1.0210231002496506, -1.4828530946586378, 0.02059737899225505, -1.6229479044456465, -0.13429404092606811, -0.1979279474708799, 0.1979737332090343, -0.9880150659768626, 0.1292560160137026, -0.44633647467882476, -0.8444181057227949, 0.922291518315769, -1.2339746819121384, -1.0421211685733967, -0.05863704059085685, 0.17639049512879262},
    {0.6581352610565432, -0.3466460120189084, -0.6008820796857127, -0.2322231403123472, 1.5309137559010453, -0.28699161681932533, -0.06518121848135511, 1.0732059682881059, 0.056264126490824885, 0.32216913737639574, 0.34248692221267407, 0.9574973777377522, -0.2830680940794713, -0.09957399726257574, 0.2359969128867, 0.31239699397036363, 0.36135668763135576, -0.4953007647942192, -0.3298764180161141, 0.487304249045649, -0.8787856351399369, 1.0067189434937673, 1.0882253509164481, 0.8372488528906985, 0.7590843866769484, -1.680762565433023, -0.5824551885258121, -1.6361865432956324, -0.7359981555306372, 0.39682204137994825, -1.1767048937638123, -0.15971435752820382, 0.42762552981332597, -0.342908859150267, -1.7022857663531321, -0.599875760470267, 0.7974978555201261, 1.0085480216807634, -1.1912752110429576, -0.8186730909939456, 0.8389707316111092, -0.028121168292469845, -1.56252160067703, -0.4393728256282571, -0.31157472400089986, -1.3229648495929494, -1.4786515193786507, -0.00977971219718977, 0.0033713213082303558, -1.1964678898740402, -0.8681723219555759, -0.9708414786754048, -0.885393931835222, -0.7565175329938301, -0.92272897257207, -0.9796321816485806, -0.1761542312853098, -0.4338915638951192, 0.9494772436887633, -0.8144017763998221, -1.1494747040387938, -1.8850965448406753, 0.8404962093374398, -0.12431457814311919},
    {1.160058494050209, 1.230295380554327, 0.41411501778955107, -1.1563092874545196, 1.7476428684579899, -1.5270797943682672, -0.26875533862971274, 0.6815695606850509, 0.47558366458279494, -1.404727640516473, -0.4309533605665218, -0.3396065194825571, 0.1334913064486944, 1.0318750905992429, -0.868120517313487, 0.9154346842142167, 0.3220177070616972, -0.259880875454731, 0.12397280827841986, -0.5524974199489946, 0.40409762230730784, 1.1183613217083521, 0.05356708397298389, 1.2026437880194027, 0.7444507978681114, -1.0658143889284755, -0.3438638507013513, -1.5619891495777969, -1.0115859912171234, -0.6320122557412159, 0.2600887099454181, -0.8318444793199982, -0.14832717606034226, 0.0748057628407767, -0.9244733413463004, -0.8230276249510181, 0.18090556216439257, -0.5567247832331274, 0.05337512619617351, -0.44475475501437506, -0.6989648921165694, -0.412894922032692, -0.6975583062782694, -0.35225519150208845, 0.017114234756313934, -0.771985114500689, -1.6038097857161009, -0.7733235327066342, 1.1589902155962957, -1.1260774632203514, -0.5259543032834589, 0.09907542284643947, -1.5102953958104184, -0.49546207447660795, -0.21099864191350912, -1.6650657591414317, -0.7994192466584383, -0.5280924699380419, 0.33272781375322746, -0.9217774212585819, -0.45773050943995713, -1.3916924439547442, 0.26527683880035396, -1.182709132451552}
};

static const float b1[64] = {1.5421317489162902, 1.3542357547770318, 1.275573000823587, 1.3028983220040722, 1.3529209568731566, 1.5645642567788784, 1.4718515207492207, 1.3936590597827252, 1.1351913132939548, 1.3294157983742032, 1.4447979300422462, 1.1157136513526043, 1.3817130995484608, 1.232318208692293, 1.5081127727523367, 1.0617211275379517, 1.2676121527849584, 1.2291635091350008, 1.3947378321980355, 0.05361929164208567, 1.4492293767513345, 1.5586720703726311, 1.3955717575297548, 1.521868734750693, 1.1464040096462629, 1.1149939054140587, 1.3359317077362407, 1.4757873401157566, 1.22996007536879, 1.4669485664106094, 1.3980076761846991, 1.1650802940251215, 1.4482586946748475, 1.3571557244954768, 1.3009683130320577, 1.5027951190252486, 1.5150649567106562, 1.1020802335495117, 1.1543812886057736, 1.1342286858480612, 1.2673906516738296, 1.568409229241719, 1.3811045591501012, 1.263839205937612, 1.3308739411389598, 1.3228985141418808, 1.466667304216914, 1.1368191805189387, 1.4480494945970437, 1.3178071860753842, 0.9838612346750331, 1.219928155684915, 1.5345531309171694, 0.9236523101386845, 1.512786409938491, 1.4719013586031542, 1.0776640624564262, 1.350503559514582, 1.3349704716173765, 1.4673615856399096, 1.459523256157082, 1.5254389934876618, 1.5099354203018553, 1.001836792992199};

static const float w2[64][32] = {
    {-1.0446983583001175, 2.206920749246827, -0.7605000570396654, 0.9647412699994945, 0.49498213501308264, 0.09348310755394364, -0.16531644653138486, -0.8663199825779323, 0.7581721370387409, 1.1567031345806056, -0.6888115191253635, 2.2076711578504993, 2.110782896148308, 0.9231979190349581, 2.087156833431354, 0.9525708273154071, 0.12916513945415814, -0.3751609441361133, 1.7094544600183832, 0.8386930430299107, 0.5367988174605636, 0.4028043729010235, 1.0765299467438156, 0.3248191719937471, -0.2398160510310409, 0.17882139133861577, 1.1564011478396459, 1.023937314570429, 1.7176963072247478, 2.0338935452920515, 1.1905941979043717, -0.5277650604312323},
    {-0.8437868701124939, 1.1982705631740964, -0.21244315328890245, 0.9988707838291284, 1.4340629075824882, 0.6711677691173938, -0.12606993324101595, -0.20335061358532486, 0.36012866067851074, 1.9594836684684411, -0.5649158707279716, 1.5820181840279877, 1.846190464392333, 1.1324699144153654, 1.5051113983327218, 1.9423175059294546, 1.5504829687346942, 0.5185403709571524, 0.16000886907699666, 0.654787744797055, 0.41013018891073455, 0.6877819241310251, 1.675622076308107, 1.019369537554217, -0.7863843680283565, -0.714042706739373, 0.0883810271595388, 1.0501652213051667, 1.1651464067105455, 0.2178601122351598, 0.7120622998931819, 0.650624564117166},
    {0.03309384080705141, 1.0007536104249963, -0.3685016906100908, 1.0279635266824882, 1.1497000234060453, 1.06184681990231, -0.4392729448369015, 0.8879381166090347, 1.8541702761178718, 0.4925866783658856, -0.6889659165729474, 1.4917217286123368, 1.888720795022961, 2.043160733935194, 1.5786767497241272, 2.057030571490889, 1.3213280103802116, 0.14807012343395282, 1.2633591104637505, 0.5235414605229142, 1.8017382929132684, 0.3006860201541758, 1.4710082570532823, 1.2487199538872207, -0.5635214503074433, -1.1135139973613783, 0.3415082365753623, 1.121111956086571, 0.5867386694928682, 1.8567211113678836, -0.07170116427477505, 0.09392043222748006},
    {-0.23712127200055874, 1.9655975892832407, 0.15170931506679847, 0.5363749502674803, 1.697352080541746, 0.7588201152445119, -0.423932898926076, -0.19096505245047923, 1.161241191832801, 0.8744984143689482, -0.9955060665076403, 1.8585966654655734, 1.5755238996324183, 0.854374596057007, 0.5272036801209606, 1.4087554829082534, 1.2767039783209264, 0.7773194220878309, 0.5087878564465927, 1.471782371063136, 1.033183964712374, -0.5920807643812104, 1.7426043966064932, 0.7338034533721268, 1.0318119385621747, 0.3401430583713462, 0.1551681658041846, 0.44081153112932764, 1.5202958497422177, 1.0155617189793245, 0.5095110030033525, -0.49584915810784824},
    {-0.5123259354515981, 1.9612297469903306, 0.06275005975265555, 0.5551794117246575, 1.4139766622646683, 1.731693376828951, 0.13221211663524332, -0.23112759744208286, 1.59387617952947, 1.5284106616152138, -0.06889482498011607, 2.1473885244105184, 0.5476727442741774, 1.7987947277068856, 1.6834682552376043, 1.3315829199882072, 0.803844489575909, 0.733050209859354, 1.686590052381855, 1.4084976901923565, 1.136508103907781, 0.3024144957805724, 1.0336029256556911, 0.5835975653022376, -0.7102890543124165, -0.08269707162079395, 0.05044914155042932, 0.7217560828825553, 1.091922953311275, 2.075294730851978, 0.9292680982711041, -0.7544018568530586},
    {0.047815507931041216, 2.167406603503941, 0.37340087530978183, 0.27471505017119047, 1.19061210773909, 0.9964060211359661, 0.6139636554052921, 0.8300299454846491, 2.005981306143866, 1.2751367290426352, -0.020474673229223705, 0.2539972370948956, 1.5979983079100726, 1.3036218524456933, 1.7322611721396552, 1.8690227488654858, 0.3827859046052004, -0.1182031949958427, 0.500155720359068, 0.20411623717334487, 1.7188516084135104, -0.5387038894355094, 0.47822640151763685, 0.4319045677208944, 0.06821984453875894, 0.5420754899772592, 0.3042757737413683, 0.16795837656855178, 1.9150157306318523, 0.6311050878978397, 0.7856898560023654, -1.0681622018752728},
    {0.04876823394710685, 2.2598993301746675, 0.38515271639896087, 1.046455196479872, 0.752579906501839, 0.9940152625371315, -0.031113922365562686, 0.4930686270244394, 0.43871749366279655, 1.252855081454005, -1.0245021724732941, 1.817227817437812, 0.3568719023860658, 1.2850273393735179, 0.5807939495226286, 1.7249603373799876, 0.938634917513168, 0.09674120645527724, 0.7537773099956656, 1.3138379842073051, 0.7936558726846413, -1.084502638723408, 1.4054489774381356, 0.18590435599751853, -0.6742189682181282, 0.603047089051739, 1.9917089227110243, 0.9097035871186997, 0.4105519629764159, 0.16716216207205256, 0.9924961291301017, 0.20120836564205272},
    {-0.25126608644696724, 1.3687041594529727, 0.2895805987169773, 0.6500314534626577, 1.7120877509532622, 0.48966068530019635, -1.101939648208555, 0.03709297931575315, 0.7685988395133704, 2.191894506026175, -0.8265990467014092, 1.1893631644295772, 0.9129894597445207, 1.6950431143693019, 0.5188768084320179, 1.0877362063231253, 1.875477272724757, -0.3866313686506976, 1.2975912704675197, 0.7117682431276865, 1.4175126659624437, 0.01895557187557997, 0.890903724756967, 1.090761037761882, 0.24642391446052803, 0.03087142669413792, 0.4942512346582697, 1.0743029864443083, 0.817202303265249, 0.8432042205821739, -0.13593405704616096, -0.48805387240674575},
    {-0.6314391803629006, 0.2990576459807637, -1.0221532214034554, 0.8253257852476222, 1.25683064324864, 0.0815694850998042, -0.1997620010551844, -0.9772673132550196, 0.9050448702581352, 1.0380196108163737, 0.4717782170371751, 1.1135189052917915, 1.2887366181382998, 0.5381244084235202, 2.1322476832958874, 0.7922737831962742, 1.5890116124875677, -0.5735542141719714, 1.8396144626279731, 1.019901552146994, 0.018074274695929943, 0.78403636298049, 0.8624974333878095, 0.23733525786745102, -0.402825490795376, -0.7164338536824814, 0.2081489002449408, 1.1678702138410098, 1.2817400431707577, 0.16655358163534598, 0.272382613928239, 0.7395389719552499},
    {0.3267079505370803, 1.3590601704186314, 0.5236471408854252, 1.2977935523182023, 0.601280401838026, 0.9340867634428903, 0.4287394738376653, -0.641468171187357, 1.0586301407640077, 1.5958731626374525, 0.05964077343331793, 0.37227915835166364, 1.5885297714507791, 0.2210732225085346, 2.0234929704144435, 1.5902228908149574, 1.078505367013475, 0.27225077602247005, 1.5999729692058966, 1.088564895703158, 0.8514954541406758, 0.7211881931094044, 1.0153205730404984, 1.3320464707619037, 0.4332082442277276, 0.05684760553762781, 1.516575801874686, 1.5895658670731427, 2.0226835793041307, 0.39476033386795556, 1.3057301992072172, 0.051461138510523835},
    {-0.013189322405784455, 1.8232391818829357, -0.6463574749226912, 0.38871117886375595, 1.876653654732689, 1.0195574921431247, -0.3969652902465352, -0.171908345222546, 0.6164709454812326, 2.3023992568141116, 0.41504898379869976, 0.9223727594550569, 0.725258625848497, 2.0651074447298186, 0.962964610639285, 2.1441695285717137, 1.4662004856877042, -0.5659133984124357, 0.6656328327019435, 0.9515264816945422, 1.7703383910770418, -0.19720092998483152, 0.9893552376636281, 1.1889790071430828, -0.39530803742764303, 0.479922137228999, 1.0859558953621335, 1.2488296926388187, 0.5480885417752064, 1.2437465676102297, 0.06955523892692816, -0.31456049240202977},
    {0.6124573245847247, 1.2749236707425269, 0.16060691777852387, 0.37662014634838376, 1.7575602143328886, 1.7067960576908674, -0.8070642034884915, -0.9562131173508618, 1.6903824582162945, 0.6076840705259277, -0.0646458273996124, 0.6362733890528826, 1.4915490735485821, 2.0475672623892334, 1.2150988015895434, 0.8112308031113089, 1.2170634202935686, -0.08290653232722936, 0.2218979675556972, 1.36828054411715, 0.715251144042885, -0.38271262901794406, 1.0392731951044312, 1.4670766398237787, 0.052363321687700276, -0.22193563127536958, 1.0527599355502608, 1.6992574626724062, 0.9572542340622694, 0.26767189641265327, 1.7423615159170394, -0.4244841097088143},
    {0.4776441518906634, 1.2717912825532214, -0.4547982548094118, 1.3477387805745609, 0.24708925229000522, 0.12595393966563997, -0.7862931986357621, -0.7211221969919822, 1.0243714128098391, 2.084301261572899, -0.08356578215594929, 0.5190376171967749, 0.22387605656786824, 0.4537737648937045, 2.091562203501959, 1.0551795754908055, 0.1899581679154831, -0.11040322557826647, 0.40439810698671835, 1.5784563880494273, 0.8236846260060513, -1.1042186502221465, 0.6429011915027429, 0.047800443596341655, -0.4251061551700995, 0.1212339968190974, 0.2461475458154453, 2.163087848764946, 1.4935002359774707, 1.8738493147408404, 1.740498967980322, 0.8651674484622764},
    {0.22560773245146432, 1.798162055991362, -0.8749895018013272, 0.05193420365406847, 0.5737806387902312, 1.5689854415820046, 0.5246927360319256, -0.9247955333639483, 0.40170405957617566, 1.1927309123592647, -0.9149138337825038, 2.0346916013622742, 1.0485527455730939, 0.7951049092347354, 0.8763703972291983, 0.9278718558513511, 0.2235049731504543, 0.41502667658565456, 0.39739462826370203, -0.2971510151762049, 0.9941631762184555, 0.6350491542376491, 0.6215596136601976, -0.14325525832392236, 0.22316593100454632, -0.6948282348228999, 0.8669169023231477, 1.6528522614000536, 0.8299073837408718, 1.7691675720872355, -0.028736455258339597, -0.6218408091152662},
    {0.6850087052601614, 1.719453978824875, -1.015775028870024, 0.8375149136926924, 1.2701598602199267, 1.2749985053227193, -0.2769410814081614, 0.2288654558674123, 0.8991292481894796, 0.7909107998039747, 0.4783537790112309, 0.5496472110898714, 0.16151464703035034, 1.7218710487017477, 0.5933373088275218, 2.032503926418705, 0.28139424432491195, -0.10028560900097087, 1.095171741255458, -0.2764884716373662, 0.2330349249038049, -0.8975719600651152, 1.8396407862496238, 0.11535784658380993, -0.153095293343981, -0.22961976698096814, 1.6326078613790502, 0.9903670273718684, 0.7675151023262046, 0.3575313750721139, 1.2979183000343106, 0.4986841255592595},
    {-0.8564349324722583, 0.8351125112974422, -0.14261196532578171, 0.5454623780639568, 1.2366521215550943, 1.1888169615298598, 0.5594377972593274, 0.5358655878779574, 0.40420145488242615, 0.6395434899293847, -0.9729991071028814, 1.010088994786103, 0.8340388267583386, 1.3581241805109674, 0.4400728265928345, 1.1674950767747037, 0.5083676081722943, 0.6358649550790859, 1.2398007225402619, 1.3617914241221187, 1.7069256918395392, -0.6840423626237686, 0.7374237437584511, 1.5793596506405296, 0.20150790895906104, -0.933815831444965, 1.049293726178768, 0.8625156005970083, 0.23611976305860777, 0.36459212291757653, 1.1648020515996953, 0.2472474494172262},
    {-0.13127525980955554, 2.238102412071705, -0.9188399346439319, 0.9731583510947337, 2.0303666634982074, 1.5263032997143673, -0.06882918485326459, -0.8086271325718097, 1.4430862510371698, 1.7152986439249485, -0.8591336899389784, 1.4858554349015756, 1.4175668790207794, 1.8922003966831602, 0.3690177494025808, 0.5060686355996283, 1.0489848364039285, 0.1079976033919578, 1.836208181004309, 1.028191764853705, 1.6118638810547037, -0.5370012138414529, 0.9734678173911439, 0.6329979960137463, 1.0878642453811158, 0.1431204109671552, 1.0338090429662943, 1.8572368184232573, 0.5716583998695649, 0.29963216482311, 0.5240162941422233, 0.3251922628334315},
    {0.43240112361399724, 1.0581246200030283, -0.3622897521147747, 1.1086601165275625, 1.5366073003484773, 1.3605799242607872, 0.45334354490406714, -0.037970669988584005, 1.3575079784793271, 2.0247905255611385, 0.2342629224653404, 1.485354765750559, 1.7348789452400266, 1.3791416560439178, 1.0796327991906278, 1.1211810927782477, 1.6280574241986825, 0.6720403067742918, 1.060732016767161, 1.12607172414953, 0.3898953531514805, -0.22025675357956492, 0.319577044887828, 1.082383223656615, -0.2801001486117755, 0.11088644386666134, 0.9448044522559936, 1.244375506007431, 0.57735140340139, 1.2873111810357183, 1.4415603613306227, -0.5456142724709696},
    {0.6497955192290944, 1.3851185490329923, -0.21034258409727716, 1.3761865578780736, 1.5614520783537642, 0.0787896113197281, 0.13211494706193344, -0.8530943456540572, 1.4323440831284213, 1.6885652363379573, -0.6892948115508173, 0.42336865045930966, 1.0155889096718405, 1.610576410134705, 0.8300573328382302, 1.1637274617690887, 1.7146149490853875, -0.9108920362147329, 1.3465178380134215, 0.5660875950510041, 1.6783918063344454, -0.30447393079902263, 0.566680061248952, 1.5941097438535534, 0.9305191931822374, -1.0853257947188835, 1.5977374282516141, 1.9348150247589113, 1.3242648474428131, 0.6531605073589007, 0.43206548448829396, -0.9296026905948973},
    {0.2347445938011614, 0.08522839651808628, 0.7242104795956088, -0.19018752453148066, 1.0089517038939684, 1.1434191177816477, 0.5385738879591413, -0.9005799174990575, 1.3618042790547804, 0.5716796635010615, 0.13455199170698326, 0.26698473014744617, 0.6131763502221629, 0.6424225477807631, 0.20902347017603295, 0.6161605361200283, 1.6314122804404323, -0.11692062828589, 0.7552153007333027, 0.5283761013778071, 1.2017841102175684, -0.5243456356214955, 0.9367230502729433, 1.2968747401472582, -0.2222286013083195, -0.07005893032620461, 0.5027949791633977, 0.31574118302035764, 0.4124282570964708, 0.23420946470476223, -0.1553343647038433, -0.03950503233949954},
    {0.18284504156771927, 0.5161742201291412, -0.1973507624417347, 1.212377707601646, 1.2387311954132363, 1.5803776565585839, 0.21597242354485913, -0.3969416220814628, 0.8786880031091572, 1.9922883381263357, -0.3606867991406412, 0.29486144068922937, 0.6696089139768969, 1.4982762580087658, 1.2164203422709472, 2.112693661968813, -0.0001992874830934641, 0.6483681898535185, 0.05030675014380231, -0.19832705911711884, 0.04761631604756794, -0.8806557659770626, 0.015317157127332177, 0.1649101627916542, -0.6750179327027758, 0.4939897437657793, 1.44851556320438, 0.18169744550764916, 1.1453964630507478, 0.9450288548255995, 1.4833619465023888, 0.6285366897579743},
    {0.40671672595168107, 1.201214370984351, -0.1572880719698329, 0.7835391633061238, 1.0466529805852374, 1.3800700706196294, -0.4869784925298228, -0.3699195308733184, 1.8075180680992575, 1.9483883876129873, -0.9804659097839525, 0.9020421984147166, 1.278988747320745, 1.9489288555566182, 1.0838962039432047, 1.9540580039787956, 1.9935036103940609, -0.7880616354370564, 0.27602054911974033, 0.2740901046699228, -0.07878425972108107, 0.674515271098101, 1.7096197597862466, 1.7676912860806777, -0.6455384376090813, -0.358479462734511, 0.274161277643146, 1.8152049957709744, 1.3589974330232395, 0.8617722372627105, 0.8907322096743135, -0.11207557490909179},
    {-0.39830506046867564, 1.7647627815086866, -0.7946504370726499, 0.48760156944763905, 1.351935012431756, 0.7123453314234137, -0.8038855675463503, -1.0037492207723877, 0.07466755021444796, 1.1179357118418676, -0.9225475625543379, 1.6197537657050611, -0.03465805505195038, 1.3188786392290976, 0.399428114693348, 1.4479983912606582, 1.4916598840250432, -0.5507743581076716, 0.09496077774609647, 0.2290269084373045, 1.1107389734381141, -0.36367379974194614, 0.4271169935273909, 0.9926869761689012, -0.413356054326897, 0.23687974147170549, -0.020542093590821802, 0.3137644604341038, 0.7327235234570402, -0.031172947928548307, 1.7111622205097923, -0.28517610381478653},
    {-0.23146207229754553, 2.2252845826982095, 0.6390077979434607, 1.5411369803946462, 1.3321142138950854, 0.897898988490887, -0.6937597956403482, -0.9276806015105772, 1.5205024696421663, 1.8265589881192932, 0.6209632290588162, 0.523288887837779, 1.5303090637880732, 1.0541450861358603, 1.691199653487685, 1.5309817987467056, 1.9809015567397423, 0.0070372744297435095, 0.18291989239920864, 1.3779711724149317, 0.2879602584590186, 0.028335289339288004, 0.996081372577597, 1.2715228529872318, -0.13021641133927891, -0.21970824398192507, 0.7768580517609175, 1.494999075288602, 1.9329480647086585, 1.804141286954368, 1.1459123703895542, -0.8709855688506802},
    {-0.3364257012021612, 0.9732861498837085, -0.13179429642457516, 0.3277178359443955, 1.9069341654281589, 1.4275806539025004, 0.38328742347287204, -0.12447454691627494, 0.9809904676076272, 0.3347021472581759, 0.5687094479846881, 0.3078464465322222, 1.8866131906461896, 1.0974445902635244, 1.9057055544704018, 1.6458359613862417, 1.2367755652659866, 0.7985248650638136, 0.4853583403476671, 1.221938913978379, 1.3439501418076585, -0.9099134714032903, 1.1102890006133497, 0.45198394410358567, -0.6428187058919287, 0.25306444023690217, 0.15848910957192802, 1.106379727094602, 0.4307670043644764, 0.8146828745800687, 0.755370617960124, -0.629082440963792},
    {0.09270311639279608, 0.742054962360815, -0.045725467452804605, 0.660119868792112, 0.6363228050276869, 0.433438260530172, 0.6763057594726942, -0.7113621078758944, 1.5529698652480943, 1.5700528117776318, 0.6571471480400233, 0.6623169003353835, 0.19227533067709662, 0.3118921774800678, 1.6714770907419467, 0.6989258528035346, 0.6254825170368179, -0.8165739508366479, 1.364941596087383, -0.3061567313958598, 1.7234438464728825, 0.3288663650152125, 0.9722844011050095, 0.2033176581064677, -0.3071172859320983, 0.6984231026723299, 1.211883746149985, 1.397048856806724, 1.651854704180754, 1.1416569904925544, -0.028815538385490613, 0.7903569250133453},
    {0.35446074645499137, 1.1062833702930563, -0.8223984505851262, 0.3119136797524824, 0.6415719877754493, 0.6618688886991303, 0.4422755376362385, 0.8878454855469129, 1.1916023393077833, 1.8582287792543464, -0.07442161764856113, 1.2077403401154547, 0.24712144839023023, 1.4729081182751773, 0.6673061483313869, 0.5212056241668863, 0.9600933387239101, -0.7195463142255275, 0.21477259721684147, 0.19408271394561635, 0.9112828828847124, -1.045665141052115, 0.9838768883042384, 1.315252316224834, -0.49400972373225105, -0.8164638588469287, 0.021588425410005267, 0.9750772200976722, 1.9256415021462407, 1.611086344550136, 0.38026662180386717, -0.46088991383075434},
    {0.7093829680888883, 1.2707338701583706, -0.31497721956266733, 0.7039063441781183, 0.6898840149010864, 1.0103939003614268, -0.041559674929382444, -0.05673875399943227, 0.25112550077351015, 2.2264428659185476, -0.7124800881634251, 0.8838408065745165, 2.090466519976313, 1.2914224192263692, 1.3830763161995654, 1.76144816275603, 0.650512369965937, -0.8994621537486808, 1.3844624643890744, 1.0659762476534091, 0.9227690643342163, -0.6425397600008732, 1.0450964016082676, 0.23933020012055753, 0.9472510278600424, 0.22022742674049348, 0.5705709925126828, 1.4670859131650045, 1.8399505290300955, 2.013813752309678, 1.269522768673286, 0.440141578673379},
    {-1.102316695214758, 1.1032121210325234, 0.5228291794242622, 1.3668941685153746, 0.5746420029048418, 1.437273991807248, -0.20272886113976676, -0.5524224496711821, 0.8246062478791603, 2.119566969951301, -0.9024870060445674, 1.6699585671488286, 1.235529119718203, 0.15638280520209802, 1.0124279721414775, 0.6668255469055427, 2.0496990836310585, 0.22078513125747987, 0.8419598651607239, 0.9846787938298169, 1.8392526552537276, 0.057634348110908, 1.5454469894002762, 1.1974152043787494, 0.4134970402139514, 0.21739746365015428, 1.414263367296804, 1.217293102078354, 0.6527546465612238, 0.08892261475888201, 1.0868801755238289, -0.018945077258899705},
    {-0.5844920095335173, 0.617279366697998, -0.7855273190105869, -0.31720327457936803, 1.1739313289305064, 0.2501259880717752, -1.1067083147275802, -0.7947444059295701, 1.171383679621239, 1.576451215478366, 0.4994376944218089, 0.5869049008616262, 1.8112649086206234, 0.47906924188413397, 0.8042092219335222, 1.5029193115401103, 1.021414468077687, -0.6789653075648107, 0.6381860030083664, -0.10879785592550374, 1.0389308127428403, -0.9866768758475393, 1.0862956890786537, 1.5228399533180914, -0.7788361337376831, 0.09680357732008907, 1.0655867013600584, 0.17356003087385063, 0.30262829973647504, 0.9473360359428156, 0.09971879931239104, -0.7529168084515181},
    {0.43856781451981836, 2.0887554656994536, -0.921600915388934, 0.41301609771752185, 0.8806076480174677, 0.5014122729988267, -0.11115643017969636, -0.7780965733249909, 1.272721302595081, 0.8103016618190476, 0.49991647244736515, 2.110515658053314, 0.42937372859674866, 2.083558413046404, 1.365962729707916, 0.8335036056081979, 1.6011011912114939, -0.24975935701713994, 1.3073624121163423, 0.33381493620749536, 0.39669953827690935, -0.8926573585964488, 1.6192114356041858, 0.4524687484131666, -0.5070550796129978, -0.7139166652938755, 0.5150716004490251, 1.098663330557011, 1.5547983242226964, 1.9170129049463758, 1.2094894414001285, 0.3956183183774658},
    {-1.0977711543879778, 0.8873561012818255, 0.11206638062274941, -0.10065792978060208, 1.6352269226878529, 0.25528548692165914, -0.620761237998939, -0.8009645244842419, 1.3335447182188795, 0.6112755332316164, -0.5335891029072088, 1.0787463453487784, 1.3257962897410693, 0.2762615494402874, 1.1546962705133998, 1.1083198620418695, 1.4238892869040527, 0.2122936089663051, 0.08248761011115166, 1.34454927911341, 0.40269966293497655, 0.46715999181257717, 0.3656148171971039, 1.204575504817963, 0.011818111771295275, -0.644076307421576, 1.878766598801651, 0.13940669221135119, 1.6157636242458018, 0.7284617711807434, 1.5795233570940546, 0.27731955018371407},
    {0.25420117628889394, 0.2665346885849359, -0.9348531191158801, 0.6917374739480526, 0.6775170265725087, 0.25880734211746187, -0.6909961837801063, -0.40006553314742904, 1.3520624573852338, 0.6615315457370616, 0.5851453792377408, 1.029671481908784, 0.9944071773650567, 0.6805427056735867, 1.8254101299572714, 2.186645845975227, 0.9385713441886181, -0.5647855020840208, 0.33119681840881465, -0.1987841120636831, 0.19603838972153687, 0.7841089680680134, 0.8125315115333072, 0.8951132794955617, -0.7519137060225399, 0.222557213735198, 0.3419799285565466, 1.0339556951066433, 1.635738497021907, 2.0009897628959536, 0.047287532011105124, -0.4215966276777143},
    {-0.6367653328133368, 1.8959514311945314, -0.02427913697956925, 0.8755914250496006, 1.2606821744768928, 0.8696851341918939, 0.36885922118687503, -0.7735137772217622, 1.8571101143137536, 1.3738482961934146, -0.7120200603195986, 0.6782502893141515, 1.1876873136279773, 0.7506835216520155, 1.3022505504379687, 1.2175896612380726, 0.003367282727569292, -0.3422337763403839, 1.8834988928730965, 0.9408781477031035, 0.5967415964360606, -0.6548603889466545, 0.7927160208395545, 0.8999622241862332, 0.1895504227876613, 0.7494447219770057, -0.06263096489671854, 1.5771364281389677, 1.2485218242460934, 1.27904668130842, 0.9235615649782812, -0.6111950836550321},
    {-0.8632247386361221, 0.5253198471381516, -0.1841482130485472, 0.07762814780996052, 1.9231895025010077, 0.5569911962820406, -0.64962506360348, 0.7373634084119975, 1.5558555572581014, 2.0794579881770434, -0.9600410546381952, 0.32681017590198186, 1.1951247066810584, 0.8016359485403629, 1.0858151256155066, 0.7098179019498431, 0.8153760714109569, 0.5084090649474048, 0.5440907108275512, 0.9302167019358069, 0.2152517089053579, -0.891473462663069, 0.14606260465809015, -0.061141310942339495, 0.47977419433128976, -0.6763970516155512, 1.0774528132068708, 2.0112302139293003, 1.938983102971207, 0.2838867492330103, 1.6532227412798164, 0.6419701830871333},
    {-0.3272078395291722, 1.823153338378964, 0.06775683241026759, 0.4194653318344267, 1.3738022701290429, 0.4399964183833707, -0.4203441223749512, -0.3322144043617227, 1.321693326513226, 2.2363512790785633, -0.21759498903552674, 1.849954579778318, 0.6881120623571643, 1.623347125892826, 1.7880659071913685, 2.1216184983644766, 0.9948311620955675, 0.1986411995408428, 1.1073354444839862, -0.009702451148748827, 0.05772902494768207, -0.3335894139927761, 1.675508695297915, 1.3574879568218643, -0.8274145531793968, -0.941588229878344, 1.6797885856976993, 1.551911789775253, 0.7292697809094257, 1.8850366891318575, 0.7527261051591664, -1.0082965940324748},
    {0.37247495631289385, 1.6546484586688133, -0.49678565881436254, 0.36199135909163027, 1.5584290596371877, 0.7095071014643436, 0.5868624354236381, -0.5736547264145235, 0.09638301790589235, 0.9063418481730053, -0.5803593247667501, 1.589940416499986, 0.8524081349663363, 0.5818408126827487, 1.6806154181828856, 1.9013288985172376, 0.6201960371314645, -0.03990323589329724, 0.9017021538180569, 1.240043219767933, 1.363514104844876, -0.4811037741166989, 0.6740353767314317, 0.22827560596236393, -0.3068277945976054, -1.0896553836018137, 1.097790705769443, 0.4923055320846355, 1.8655151500173643, 0.857863271978202, 1.7192269806655698, 0.6266172737235527},
    {0.45564953110819073, 1.6238003415831155, -0.511654925734109, 0.9686814812391513, 1.193504105312908, 0.9236747685288224, 0.31001358083435376, 0.015646941636501936, 0.0004127656067341605, 0.14726174751350318, 0.495230070951428, 0.1326985437400886, 0.6116385323158233, 0.23950278023859825, 1.5747038158589521, 1.2311119902169028, 0.40550397782143777, -0.8544788928912935, 1.5393072987588394, 0.8668047948459032, 0.34414684866986506, 0.6282976946224519, 0.14860017720179927, -0.22243156765509495, -0.8150571832816517, -1.0425964827823657, -0.028338767284354152, 0.7668019286609216, 1.1081161406633904, 0.7791617779189028, 0.8232614104408088, -0.5775407222978448},
    {0.7955804977525663, 1.1781509820559137, -0.5627737831396543, -0.14414669956471116, 1.8977725181694511, 0.006384125061055987, 0.1804761434728437, 0.17087348135489547, 1.1471073146420263, 0.6687187849094678, -0.6747698354265469, 0.4013420255016598, 1.8273270749369404, 0.9884265435244031, 0.32813382352324605, 1.3946182900398247, 1.086934445324464, -0.18203137200026806, 1.7674006725998734, 0.2823887772791957, -0.0036279840301278927, -0.29295791816899663, 1.805112354222188, 0.4159232422112998, 0.9604027069019768, -0.8069519579082148, 1.892464655773312, 0.2734990356639017, 1.2148160972650612, 0.27601943345631086, 1.669831568547373, 0.08400786849127322},
    {0.2626940938625857, 1.8695636906966637, 0.5664153198465282, 0.7854942645946017, 1.5434557410965255, 0.8983275697921839, 0.13575968396319363, -0.823907429293271, 1.4837236915204357, 1.368140776278817, 0.8341891304198701, 1.177949952889811, 1.6757538533153773, 0.8813249113015513, 0.39900689514019516, 0.5641165000984196, 1.076641885923065, 0.4932744335223338, 0.8724145617238878, 1.5071102218943297, 1.6614035022352251, -0.6911749278598271, 0.13606519024694977, 1.4050302464876328, 0.5471990520111591, -1.0431426203807288, 0.39735818331499784, 0.9667241954376871, 0.4233543353644229, 1.5836546336792072, 1.665256108263396, -0.6988738476503668},
    {0.2279058449586434, 2.0558869962459294, 0.08043797968002322, 0.9756519929742922, 1.72800672770492, 0.816780405110937, 0.4213431766788279, -0.5068349665968476, 1.7575055955547523, 0.5804124598442101, -0.05992873271850274, 1.9385056407080652, 0.2714026615292916, 0.4154785868183062, 1.8413271196071919, 0.8426389438117705, 0.4468111022428605, -0.84571978467656, 0.953645955224587, 0.2463037426307508, 1.3528926343310808, -0.09809367328717337, 0.8032020341218039, -0.19850443388857952, 0.596985829671085, 0.35185670137969566, 1.3050005321771165, 0.2846860212258106, 0.5356176968844779, 1.174846175284379, 0.16164092334139857, 0.014986867042591463},
    {0.36049552949663527, 1.0166622592046404, 0.08340108594842703, 1.3611477152824663, 1.5250126294268804, 1.5640335704643036, 0.04868107976978123, 0.0539543355341542, 1.368096341619952, 1.8807352047515902, 0.7385787911620311, 1.3522043311335508, 1.3695061698892275, 1.0534567268953985, 2.07318058352941, 2.1818488546535213, 1.2490732932115405, 0.34121080976213813, 1.467435634134563, 0.34139900152115793, 0.8079307767215814, -0.4203455575031249, 0.3030713761062637, -0.023742180047848, 0.46551930359798527, 0.6861811291515912, 0.7426984604369997, 0.16104012241210203, 0.437658720881151, 0.3657575227010233, 1.7212823174855605, -0.9557882710985788},
    {-1.0762651511301475, 0.8017430113087531, -0.9028486991739365, -0.20045047389897705, 1.5125271630032142, 0.8405446281158157, 0.05606307486271988, 0.6930935163809641, 0.42040322221680043, 2.0780407664946865, -0.20577614264546992, 0.5233058189014971, 1.327002264076455, 0.34583449608768446, 0.6170952125831058, 1.6857359587239966, 0.747770206829386, -0.09275749001912761, 0.047550386425382146, 1.352394508779222, 0.4051607814986564, -1.076052459755869, 1.0080317552995157, 1.3868692040913817, 1.1280881229387238, -0.9199663479207338, 1.2242930822492015, 1.260852148520874, 0.9462853364747866, 1.7539149716976894, 1.2190874038714656, 0.30739063952352097},
    {0.8120331099318798, 0.7816867483990072, 0.11787815291447899, 0.27081121784406414, 1.1508317012144853, 0.5037330627361494, -0.6131322245045943, 0.15048802923095195, 1.291194310497172, 1.4978825184936695, 0.06575454207750503, 1.2873856680255582, -0.020211992343081544, 0.026573167661765467, 1.6532858060885067, 1.6003166637452122, 0.007250619368369396, -0.3787153172513553, 1.5483442056526895, 1.0364536360953869, 0.37725439338278516, 0.3493597915612801, 0.7614530204967414, -0.057740172114675005, 0.22016521880954504, 0.7177837938709463, -0.030552121707111374, -0.0013480613698889506, 0.8523335096967389, -0.10948389950673698, -0.03048444747910797, 0.014726874950547211},
    {-0.6819644702452164, 1.1144262129810256, 0.39411276674242324, 1.4232901127195456, 0.15583827268728584, 1.7652045305224857, 0.1579972715096193, -0.3409489317926585, 1.3929582299588066, 1.5090995658490567, -0.8547956936103334, 1.4103999410719579, 0.8887271017574058, 0.33772806766542673, 1.467529642484071, 0.7778743713641195, 1.13913593900749, -0.8465501188179679, 1.5380914863361788, -0.3406066573401178, 0.11140323829537395, 0.6228987685206304, 1.0377099276892754, 0.1423036114382009, -0.14183334360985841, 0.5451641167301796, 0.0024970049869205754, 1.3862616263383458, 1.611100120789757, 0.029827952834276607, 0.9750757983997641, 0.7191333484786643},
    {-0.49575583536274465, 0.560883825606296, -0.007613415570752633, 0.007453339127960821, 1.4800978223983627, 0.04605493516104277, 0.4005248831352471, -0.6828919371692358, 0.1548479364894909, 2.2017966547070853, -0.8007138696736266, 1.633798090432194, 1.7246893617546306, 1.0313654758110333, 0.8348758913035436, 0.9275485786921683, 0.4941372484314746, -0.6998043525516855, 0.3643201716818286, 0.13365449620551664, 0.4105929647000085, -0.010691264955223906, 1.846623098540104, 1.096068462558069, -0.4177033733649494, -0.6142533586453736, 0.5349052711911071, 0.5589833487627973, 0.7655939903400911, 0.29883389930380305, 0.23427980624843153, 0.2786812932933867},
    {0.22559765044187569, 1.9595815577228188, 0.030930419228829175, 1.3080629252080593, 1.735757188680044, 0.4115591065659272, -0.5122677000480722, -0.3190314085487776, 1.9509197104461686, 1.9802409516332509, -0.8268450388567044, 1.7486028611671778, 0.2704494339575106, 0.5569114242153174, 1.0745347460622312, 2.2900645331395304, 0.8279260072380366, 0.3120685410502952, 1.0330962031391555, 1.0322757542996615, 0.394078485063701, 0.5092119224250639, 2.0146568692799276, 0.5642772227625926, -0.13247813150432347, -0.9650771036554018, 0.15794564816599682, 1.8810685825815885, 1.4527578676775603, 1.940184296350101, 0.8800568253554382, -0.06732477078629774},
    {0.8307452826613972, 0.580548930899258, 0.5942961169426967, 0.7866386151781458, 0.8771686272779895, 0.7347239551206434, -0.8640704940152726, 0.9038132879354933, 1.8094642290028882, 0.6076200426749078, 0.9070684504515562, 1.8888617318792118, 0.763360141398415, 0.43946947205943876, 0.5460991801760666, 1.4277906826969013, 1.7644697773205176, 0.15304327187177674, 0.8363781111645799, 0.10742308819207802, 0.014951750272068094, -0.9015050025793861, 1.6728284800549749, 0.8263806317667362, 0.3354795399952713, -0.5055378581463535, 0.9345429728268403, 0.7578849583039579, 1.4782843405148138, 1.1845808973016778, -0.1559841069764861, -0.047432592889347105},
    {-0.6599242355840728, 0.34624621797255545, -0.9387119109810602, 1.428041331131184, 0.6963345323788691, 1.0921916097991136, -0.24964704780931457, 0.1608622620522993, 0.31339856817915074, 0.962397533217619, -0.5040868844371305, 2.0397861595680307, 0.3527387186373089, 0.36524999443992123, 1.5246755123764397, 1.3991247345483118, 0.46193564913072666, -0.36486802064980034, 0.3501525360581488, 0.35453562148141166, 0.08255609228204923, -1.018493232754407, 0.3742944172016427, -0.20060730128804138, -0.8213730923456676, 0.6016263067265555, 1.619553009924953, 1.371468915886682, 0.37898755910977383, 0.20404211199249223, 0.9318235164767126, -0.6833513680864393},
    {-1.0776578718452827, 1.3052414727259156, -0.07468242127959378, 0.2898437235718287, 1.7986938254424363, 0.8149251486034141, 0.15285646269889555, -0.22422450699451954, 1.2128761493185858, 2.1489500926587706, -0.6470333879593394, 1.168942952589482, 1.0626030810309308, 1.8841888012216579, 0.6955578654105924, 1.4505589327637565, 0.1852632825923707, -0.653438943900226, 2.0174446576822933, 1.1344909807518486, 0.8602686468561759, 0.6452487950364554, 1.8488272117944162, 1.3659324182191173, 1.0958252857612971, -0.35567876423456285, 1.1393626147075069, 1.1994195412192306, 1.07211947715933, 1.1874943068258799, 0.40841838255059415, -0.2431392910688833},
    {0.27052481237178416, 1.923930992619987, -0.12692049897309368, 0.707174484235459, 1.497925871394764, 1.082306101546055, 0.34427010672322583, 0.6211731170129421, 0.8023127826008822, 0.5413419212779546, 0.703206873760248, 0.47994752657220363, 0.3356125290995318, 1.1949979826957406, 2.054704050874808, 0.32862082161838563, 0.24180230255963786, -0.7866132465510777, 0.6219368416055001, -0.3058657138683689, 1.026036497968916, 0.4491524143777687, 0.2470397294349632, 0.834938253316472, 1.1528526323636685, 0.19842236933057344, 1.8066982233543203, 0.8435543860033548, 0.4960777018180543, 1.361185016201878, 0.7637969819652873, -0.16425591947758172},
    {-0.8231673278820996, 1.664948982784904, -0.9986656247536975, 0.20553523240110247, 1.2453310906359307, 1.7638449543822072, -1.0704342852606183, -0.15523048541984688, 0.3851077906317133, 0.2696511203314028, 0.8403871065631718, 0.4447573879619542, 1.6702329701256915, 2.0596226142669796, 0.614329104777346, 0.9023409541640576, 1.9122339920819793, 0.7745051674875032, 1.6951923199383212, 0.814327338296963, 0.9481341690424584, -0.38852364829952574, 0.28319647040907686, 0.10911605920929628, 0.7258824646893967, 0.6595728176123212, 1.4529075276123151, 1.40977564013173, 2.0989084459231044, 0.7192711758650436, 1.2567412411706622, -0.024350569781964256},
    {-0.06869301859084352, 2.1291231310142607, -0.6092489313932368, 1.1510064098214938, 0.2057042150961003, 0.8836159463750646, 0.6993441600891988, 0.0940146187221243, 0.721884558345097, 1.3245992586040425, 0.05547180902713677, 1.2845188171427644, 0.9194973742757931, 1.3977707437401263, 0.9551847673118737, 1.6691843077802122, 1.8014149887778066, -0.16602859655368726, 0.02584940719803008, -0.26803834665912385, -0.0729987878774119, -0.5153434195660559, 1.9312587297328465, 1.291191430036608, 0.9461277322909173, -0.09466109101057156, 0.3275996845622565, 1.9644407060809617, 2.259841590658528, 0.9410276091018579, 1.3158676947680954, -0.06601397830005952},
    {0.6437581085189487, 0.9104957512173426, 0.5470073830001125, 0.2391579301104817, 0.21962255587206875, 0.1449802577724037, -0.3971299216912515, 0.3307401408682251, 1.23428351001121, 1.0516064775056817, -0.12665141733245103, 0.7545000440774831, 0.4307965709907091, 1.2091878267522442, 1.3612991003352695, 0.7416713933783523, 1.4421729552726514, 0.45816468442200614, 0.10213608433111662, 1.0133103128544454, 1.6658918962721456, 0.8183178194110898, 0.20473233807029528, 0.0886817015065012, 0.933494909389178, -1.0943977460206187, 0.31636128954549164, 0.30506924555029546, 0.769088832780703, 1.6973386761088505, 1.3894447056337258, -0.5168472903372076},
    {-1.002173659160311, 1.167216821653776, -0.4045412758222985, 1.4958713641732453, 1.7191098110876937, 1.195834888050292, 0.10006777925759704, 0.19177141438956424, 1.5900222247691813, 1.5238361272585481, 0.2971078988442763, 1.1095514737165335, 1.0666578539028337, 0.7537050641750791, 2.033166810907714, 1.275075747720177, 0.3295267953375568, -1.0921817415854296, 1.7315091027659515, 0.848550631185694, 0.5758516764790316, 0.3744245072172002, 0.253899368333806, 1.00615975179577, 0.25245920702899416, -0.7273324118204226, 1.1033136952613776, 0.8846340195814303, 0.8718962309281677, 1.0702887634642493, 0.5492186184312541, -0.3772960804506115},
    {-0.7317029675375719, 2.0455175088071886, 0.20827192388638735, 1.4522408554439987, 0.6718390911757032, 0.8096135851598608, -0.41564956650557877, 0.019616260447851572, 1.1909394469856602, 0.8875379640588487, -0.9449536676426115, 1.228510236059526, 1.784771186845729, 0.5960193997499436, 0.7979491104318555, 1.8175511523797474, 1.8077449896711333, -0.49594519635210743, 0.542285134101867, 1.129953742638903, 0.4330743204717677, 0.43567962876892213, 1.7603257422787457, 1.5480534514708784, -0.35341474470136913, -0.4751960860148507, 0.678674334114452, 0.28794017021150625, 1.2893511554478045, 0.2088049913149064, 0.05483088475022802, -0.5052222458183259},
    {0.7813029178480942, 0.34383502498548807, 0.6126023968580487, 0.8436492572592266, 1.6385248895617461, 0.611065401583175, -0.7321088870915551, 0.2376970441894505, 0.0887069720428529, 0.26071109852127833, 0.4824574204441648, 0.26691998403810335, 1.7179857436369574, 1.1923404944742764, 2.0488453193191796, 1.5936907777642304, 0.47680572197535875, -0.5092232667805416, 1.502934307155574, 1.0351912733203612, 0.9698057791057054, 0.247580081172429, 1.7460871096338488, 1.381822200241154, 1.1228487991848277, 0.2754211926204845, 0.6184907008093297, 1.2621311705026177, 1.7067107976229945, 0.3236464275720953, 0.46503917254907223, 0.8321031799007019},
    {-0.7020037358154241, 1.5050152445985, 0.5833093531281746, 1.2796144706840569, 0.6342618453463135, 0.23276149461392565, -0.773433701381669, -1.095758686055398, 0.9946671040509479, 0.4818576547947891, -0.3165248523197878, 0.44608479111454, 0.9970526152493866, 1.8959735146771326, 1.58198316227296, 2.0087645822481393, 1.0818750533101535, -0.8507222215038226, 0.2401936386349649, 0.9551520777678704, 0.2197870041522251, 0.6484931313631019, 0.5267358288269908, 1.1093668712460896, -0.4163426084938096, 0.4805159794878898, 0.46908667409067256, 0.645400731647779, 1.3010117019068221, 1.0769174715118437, 0.9371867555862067, -0.8401080598499511},
    {-0.5705627212560438, 1.274332958553966, 0.8069257446601021, -0.15194016741377547, 0.08264338672602503, 0.7124543651137393, 0.306289086419457, 0.8501942322063334, 0.5413715776080394, 1.0537666312584788, -0.22475461538054334, 0.18863616921244783, 1.677258445539697, 1.7047483625223496, 0.43491997875680954, 1.4739403129882647, 1.1434248814280348, -0.7761916213089293, 0.8937518870826852, -0.26588191797372596, 0.3597899560455177, -0.842504430521385, 1.1347069437054687, 1.2738029741272963, 0.8562911737592765, 0.5126614679259608, 0.8708539959707982, 0.7818143966477418, 0.7355485937621903, 0.11159187565405453, 0.36726924041951314, -0.35680960868578415},
    {-1.0404590396617477, 0.8156517116645521, 0.07329425712117532, 0.9288123274140936, 1.542350590193284, 1.063214768691191, -0.38901017569283863, 0.029877872972420328, 0.5020558158242656, 1.9969390414721568, -0.9943306454457034, 2.1044822354738693, 0.9481809790541527, 2.114632860224011, 1.271295585762268, 1.9285946725959824, 0.2259477305178605, -0.9940141211790908, 1.8341826280753335, -0.36183952538628217, 0.07086383657422589, 0.6463713103482788, 0.4821978532702751, 1.500357712294665, -0.5307600067921039, -0.11148097885173998, 1.7135594863280355, 1.6354522770756303, 2.249645488866978, 1.879036527777478, 0.9303726612929173, -0.8566608871133377},
    {-0.16624009144382798, 1.7942296504859097, 0.7792396913899933, -0.1605892668686821, 1.6845129675136323, 1.2484293196674026, 0.05222396898368928, 0.7371468908912899, 1.2526721240984293, 1.7739442612990628, 0.11851190816274203, 1.9230949890977758, 0.8465095333685059, 0.44557320010402784, 2.0735213199646365, 1.235757552349092, 0.9604803099024076, -0.9379626675774468, 0.38935481245905484, 1.0811433746534376, 0.7397178133089989, -0.15581985659816222, 0.7072989753845343, 1.2321238616043722, -0.1252056708994504, -0.4773196114637037, 1.0451379611707396, 0.5859089269374851, 1.1516257956471059, 0.18332484757333775, -0.003676106674026804, -0.9747252031403909},
    {-0.6224652861562103, 1.3585617151758016, -0.8541130748642526, 0.32677690872850323, 1.2869099681098528, 1.8762458924387508, -0.19080454968484342, 0.006696989245610237, 1.2793406235497042, 0.5765519798537176, -0.6263045670760189, 0.9817258231283521, 0.8650795926077501, 1.2704016996418392, 0.8761165172334944, 1.671248562871236, 1.24282579882357, -0.22594035684992309, 1.5225533779622529, 0.24113409846579928, 0.9695408186012368, -0.4456981210675974, 1.5646119901910143, 1.4019260063909686, 0.12652621418125992, 0.4538026969784902, 0.7427158958109825, 0.27338232444894833, 1.9024902538343158, 0.6244206310464431, 1.2600871846191302, -1.0369263663791815},
    {0.013621586289221744, 2.1185699603161963, 0.03995266897481132, -0.03721274099223426, 0.7820253126950433, 0.598825808194849, 0.34124467445453277, -0.6731339878354354, 1.2520519849615988, 2.284570678534509, -0.2385971193865346, 2.0153281179361007, 0.30954678237574507, 0.4320568907114244, 1.2207220479995224, 0.6834349873272791, 1.9003370438692182, 0.09213010457796293, 0.3272541667068057, 0.912528062550288, 0.6830602308438102, 0.7417969610437576, 1.5086017790860642, 1.3758208968816976, -0.6357352557095645, 0.04703365249014917, 1.2090148876976696, 1.2799157444201898, 1.91647876564368, 1.3241886873154691, 1.132782051686976, -0.5330833692425254},
    {-0.3232173027687775, 1.9136584039070115, -0.30239337543745665, 0.8664487680706077, 0.8208097309493871, 1.6402601898620923, -0.4167784746777276, -0.23872289241316275, 1.113745199610824, 0.9240989107882, 0.5130879173776899, 0.981101026414515, 0.7563979111978295, 1.1090749769411083, 1.217574064981333, 0.5770021371593131, 0.11649143078621545, 0.8344909438452861, 0.8784357893541352, 0.9118552339051476, 0.5974738271366019, 0.6608184157194675, 1.2548749450788035, 1.5660841352323023, -0.6459258072644974, -0.2505056111030482, 1.542697087677257, 1.5378422704045227, 0.6531648516676128, 0.9586331699688337, 0.736767370159603, 0.6007357138409942}
};

static const float b2[32] = {-0.27852495747750255, 1.2780548233606894, -0.150479492397857, 0.7666987906299352, 1.0658711187094523, 1.024776340175898, -0.2861374791023281, -0.05786454233188437, 1.1246190703525467, 1.4111336103649956, -0.10131388418345728, 1.2119618191815997, 1.2003614830222307, 1.1777439204458582, 1.4239828623170416, 1.4861096917356558, 1.1469177407446236, -0.2520939149719389, 1.1406402456977134, 0.6531502680189696, 1.066946820102574, -0.2536858299679395, 1.099303712760571, 0.7466106421300958, 0.15511326148247975, -0.28161659014903623, 1.1072990405649636, 1.142889598881043, 1.4307163054508025, 1.1631217656906114, 0.9543977389758102, -0.153374727541158};

static const float w3[32][16] = {
    {0.29019726744723606, 0.3636334985760138, -0.8240237278387087, -0.8396663099354303, -0.19689667932842808, -0.6148220750701422, 0.3924747161237667, -0.28367399219643163, 0.1250061450162784, 0.7657540642585713, 0.1126399979359953, -0.07197877987400657, 0.7431210861717245, -0.7370010210647979, -0.6150268812796525, 0.2757978708815682},
    {-0.291095013002507, 1.2945083314086396, -0.7770704562233152, 2.1756203203734126, -0.6075478420349888, 1.9535593128733282, -0.5753854430499418, -0.2725113004380739, 0.2235305887072659, 0.16830881241243706, 0.7931289257354702, 1.4030764773904068, 0.2747678746800295, -0.44381713961835756, -0.5981238856761211, -0.19089411893116168},
    {0.4562527392247783, -0.36592647233335895, -0.3349828992514492, -0.594844415132915, -0.7831643720934551, 0.23267084128719534, -0.71633331600245, 0.6685195430358559, -0.13278239929511734, 0.6864632277957137, -0.8787598134763644, -0.7743422219880508, -0.17437544851851838, 0.684068266446753, -0.3707525804591787, -0.16550050672657168},
    {-0.7820900732725532, 1.262416178066883, -0.6106156168697893, 0.48080879741552535, -0.5552662639207474, 2.005103933068151, 0.5232659027189633, 0.13915918219927734, -0.5135313950320186, -0.45083043939672807, 0.3318674954694523, 1.7286308423507988, 0.1348624949703648, 0.45823151796856393, -1.0478447351806368, -0.3498801389615872},
    {0.4561999481823151, 1.2661012637542803, 0.46228580478735415, 1.5836387338084037, -0.8780058405822787, 2.014697997409198, -0.14208026977282928, -0.5108864159144526, -1.0426463557002006, -0.4723080663633632, 0.618450315774947, 1.6703779564712304, -1.0547989079167914, 0.6804949068986864, -0.21169302204031853, 0.22989823871191475},
    {0.6851917137097177, 1.4194683050631822, 0.126338297598246, 0.9157630578436261, 0.41985221414730534, 1.9970747801218416, 0.8172253494777917, -0.6677962224761661, 0.7306666488780716, -0.01079376111417829, -1.019030221348471, 0.1737297992170019, -0.993207364552308, -0.9569226709081669, 0.195134012637819, 0.20616211371305765},
    {-0.6800179059852142, -0.5891133986615349, -0.4009880149544628, 0.12969247464300995, -0.6801057201818543, -0.6727867251280687, -0.5021148554527326, -0.20347759413169847, 0.23965282237721203, -0.7661321781867396, -0.21925838616190765, 0.4591954316309496, -0.31112715345433667, 0.03389057157968018, -0.7413528094971388, 0.41468083627652325},
    {-0.3299895396774998, -0.5280359180909829, -0.5991897681459609, 0.959231155956262, -0.8546540544937105, -0.5673398362342096, 0.33813226262391666, -0.70112180153009, 0.7871592564879665, -0.06915717307233489, -0.7671208676185455, -0.5371099009943788, 0.5310437195746044, 0.04094706646442605, -0.7071150184126912, 0.0032837851765902264},
    {0.06552622886316592, 1.3892602987234322, 0.2600998908343213, 1.5422610516951212, 0.6457141316239832, 0.8169363016595238, -0.6400214909710356, -0.5953968745402959, 0.16377124259916556, -0.01243893525086854, -1.1208072294678164, -0.18831687209929543, -0.9305680926629124, 0.010783613980504737, 0.3351768688345658, -0.5744474323960052},
    {-0.5213206293483896, 1.404161692732875, -0.24441277261569944, 2.025204853164539, 0.37178557615783625, 2.2624726310665513, 0.7349506058465692, 0.296442783116252, -1.0998539967381424, -0.4403137385487206, -0.40848794131518373, 0.47292460304928813, -0.38383799230360877, -0.8931520446257128, 0.3970824188421093, 0.13860011968853175},
    {0.5830361247090523, 0.4319551874434001, 0.6757228305570123, -0.3224000854497203, -0.07796553852558065, -0.040818942635850716, 0.40063156028648794, 0.11042186525164703, 0.25871754864155466, 0.19613058912211537, 0.021010017922771417, -1.0165177978387687, -0.506724615167695, -0.6378115278378963, -0.5649351506375813, 0.7132292109214844},
    {0.42607578284949693, 2.2715951993148584, -0.17999804652216966, 1.3397863380394075, -0.22296649835355312, 2.20222818853714, -0.42969705568610783, 0.07952864755798084, -0.8113168425637698, -0.29446061276639923, -0.9000722427877692, 0.22105431871816056, -0.26088771247689885, 0.5651531693844536, 0.4648287158123206, -0.25265194713576},
    {0.32455715438408117, 1.5200852168780887, 0.03408406353282405, 2.1675391260982044, -0.8945853078486096, 1.9117746782019431, -0.015409524039761662, 0.8154901328267846, -0.08587843016375421, -0.14317029539692605, 0.07511550574456304, 1.6383314516425769, 0.3929391350367316, -0.7937523497919456, 0.3563754580228562, 0.63341367528197},
    {-0.6427429122344754, 1.483724389383761, -0.7696401883978043, 2.4486232834949915, -0.6723609502752385, 2.104009274121286, -0.1809490501105947, -0.4693999838087202, 0.6733095771354441, -0.8305734323428484, -0.870806673604896, 1.186903381797163, -0.3372396064257926, 0.6095021562885814, -0.29589759714262587, 0.029120860760304186},
    {-0.2102324683516069, 0.7378687044783766, -0.6243402425670284, 2.3509099667563507, -0.37826956990790633, 1.547663530742526, 0.5312190649358601, -0.12021149718421299, -0.19139551995419773, -0.8681309519330435, -0.26747595854253864, 0.8625630709437658, 0.2827416148385059, -1.0472107561326147, -0.704567664615156, -0.031431621425439704},
    {-1.0972324327273575, 1.681538017563323, -0.5618063474360904, 2.3531496680211292, -0.37971145122687766, 2.4428848434160244, -0.8683642178209371, 0.22120502511704015, -1.0340401991605628, -0.42594125699077406, 0.23459701478398276, 0.3796986809608609, 0.17155831167895816, 0.010669268099031475, -0.02657014467460579, -0.9580433089245229},
    {-0.09758940975061506, 2.0122062167969927, -0.9024092654998845, 1.8381773065693339, -0.17593334904696856, 0.8368684119539505, -0.1653937740777702, 0.44177131157203137, -0.9985330043642632, -0.32626876497584695, -0.1987996458631006, 1.6003132174232317, -0.021500766121316288, 0.3518470263364939, -1.0321051365940799, -1.0392897981093046},
    {-1.0236650628287223, -0.2840376742926768, 0.7989012164035876, 0.03728517197456822, 0.44340374354787887, -0.4130451919595077, -0.7294731867337063, 0.3939288121783981, 0.34462954635059173, -0.9682691097333518, -0.5963682989705799, 0.40621614398846106, 0.6725696291401577, 0.7354790834144834, -0.07276757218542264, 0.332910553048832},
    {0.6923166582154566, 0.35651526350524815, -0.897843461112342, 2.0176210497547444, 0.3513168683640182, 1.8626925292865737, 0.10774275244387806, -0.3673805778425013, 0.43481866279772763, -0.7766376001683993, -0.6734391919551209, 0.15247133692708695, 0.6647000450561185, -0.04510523208702171, 0.22745002745174292, 0.1309672031855896},
    {0.7778053245301488, 1.7122536928135217, 0.6756066582282795, 0.994470004996247, -0.42629710315770114, 0.8750532468873988, -0.32260946107997857, -0.6815990521458631, 0.9231456183088351, -0.45789382225682856, -0.4618369578642321, 1.5074794833460194, 0.27534644756924676, 0.8654399994283813, 0.2509680572593026, -0.6037833744061579},
    {0.7419545187909156, 0.8461031346996051, -0.14266113027529143, 1.705240941607801, -0.13398039894626934, 1.6672670096374198, 0.3598073372277018, -0.24234159502682484, 0.6993579313065496, 0.6955458227859274, -0.1536206801434464, 0.4227735659064941, 0.5057052095906027, -0.6966690598895405, 0.5481316231418183, 0.08616291177081799},
    {0.23740777584137016, 0.7289248519704721, 0.5360250655539426, -0.6743305845822813, 0.8352006191018473, -0.03004035272967722, -0.22670668359134574, -0.6232779121467755, -0.25995334323236835, 0.1693820007852126, 0.7614645197981786, 0.593505878063901, 0.8030243223855753, -0.4848572526467137, -0.7180281284116683, -0.8314154575715477},
    {-0.4232692015702997, 1.5121864055250263, 0.1888356734679461, 1.6132636404306027, -0.8747655020757606, 1.207602019392856, -0.3521817640945216, -0.6172262451967453, -0.7525726365946493, -0.8792456476682196, -0.893563427922134, 1.4269542173374234, -0.43854842974888286, 0.7493705643054729, 0.2239043004568375, -0.29974171264327154},
    {-0.07414293024044008, 0.37768334278769866, -0.23272379553563705, 0.7803307703736913, -0.7100405851065165, 2.0861631351894174, 0.5953221107377614, -0.7447055764096355, -0.3248488308204253, 0.11238702561438806, 0.3213997637594186, 0.749187227743607, 0.182316895860796, 0.19889395791690526, -0.3364002879134879, -0.013958058826700454},
    {0.5577918756163549, 0.964091313912032, 0.34816610715594093, -0.28019993506552304, 0.3119763863619386, 1.1219956867746854, -0.9127601695225641, -0.7774035056730355, -0.7959861748785787, 0.019093099554887957, 0.9212117098945573, 0.11090504620852694, -0.27192793820294653, 0.3607344559933941, -0.733201085216266, 0.42273938423703367},
    {-0.8721850239288489, 0.7790607538264475, 0.41444787604368355, -0.6317840176506985, 0.010631623452145637, -0.38087251092158153, -0.11885892248944033, -0.8598784131399526, 0.7670745054931215, 0.5010116214095729, 0.10576722700760617, -0.8225200867753788, 0.45873634604267416, -0.4658367399341765, 0.4831719624052873, 0.17613489896733406},
    {-0.4181530259186557, 1.5842039592837116, 0.1344809978316413, 1.0544841928270725, -0.18382019028787247, 1.1614241963894105, 0.5946054980696727, -0.04583565949277192, -0.6594111775921474, -0.9678084825284924, -0.9255109535901392, 1.4446706464964707, -0.34219601305206887, -0.7895086388773603, -0.6090430457154609, -0.8022904309644044},
    {0.710287768832114, 1.762562816577153, -0.3139472562304658, 1.9825296705334552, -0.2439140757702189, 2.41708705677319, 0.10400301781453497, -0.2239554183100974, 0.43921419758894803, 0.06959798454859077, -0.5111574919762124, 1.61538815881161, 0.3476189006403928, 0.06365287214997968, 0.5005925586045462, 0.5681729483365711},
    {-0.4303919627516195, 1.6458811099772466, -0.44775185102997866, 1.4172440648409563, -0.6364004449593293, 2.426637481782351, -0.5669798897538982, -0.16277542539916254, 0.12818906575372094, -0.8080069340417608, 0.24165102240299963, 1.3042623178619646, 0.1292244181931959, -0.9837636918701486, -0.27446203443790096, -0.20958857516541882},
    {0.26848942406385257, 1.516526797814694, 0.1298947107493742, 1.7548235430462196, 0.629647988256232, 2.0540146949206908, 0.09720956733926103, 0.48070732195148985, 0.8426299299591775, 0.1034599248723499, 0.38322442195009165, 1.5426363541212522, 0.40403413821236267, 0.6621182594915289, 0.2130794366151293, -0.9727482885629585},
    {-0.3963097052493136, 1.4340368913220556, 0.7433154009529676, 1.1293481986524967, 0.19627161044988314, 0.9590644278006037, -0.8462727215185365, -1.1949328747159975, -0.7584964258213094, -0.05936696509600947, -0.6343030130852194, 0.716317394340004, -0.15232450307541226, -0.19033299156112113, 0.06445430457497558, -0.38927077741350524},
    {0.7575604391303722, -0.8180727788168888, 0.246242715728754, 0.25731812920099195, 0.21856098407486999, 0.23093622514631157, -0.13810186886601813, 0.33860119628586893, 0.5098343775857536, -0.30096677866337995, 0.30515703115322623, 0.16740143706824775, 0.4862588960977332, -0.16936059814464263, 0.8899606337874397, 0.8335428236080914}
};

static const float b3[16] = {-0.14709869305645265, 0.7823435695607989, -0.07981498554825994, 0.9293481179982325, -0.2310895745958785, 1.0468153864170275, -0.17503987110659572, -0.2802547918156931, -0.2037763101814496, -0.11151246477486125, -0.21779405318089265, 0.49238126927645953, -0.18019923730160955, -0.24923347900260426, -0.2306867847827737, -0.23354957270359025};

static const float w4[16][12] = {
    {0.5396754813965614, 0.9067471842404887, 0.8472897020798953, 0.7376608840608788, -1.0642082593104032, 0.5391967600568925, -0.22858051234671062, -0.5760131226248486, 0.4542286162974673, -0.7803311232767967, -1.0113527352454588, -1.0197991956584087},
    {-0.38920800843014314, -1.459253231485588, -1.5735687898178545, -0.9843566507393643, -1.637962780620563, -1.225679516436404, -1.151005172307159, -1.239700212076884, -1.007136368871227, -1.3174180791818961, -0.15749208669161882, -1.154553181707699},
    {-0.8286760864312858, 0.4925756272006885, -0.8231447832244748, 0.3896452600745702, -0.5869952627350521, -0.438328929915222, 0.5527970524908324, 0.36594986066062896, -1.0080195900391546, -0.803113053085681, -1.0274166623609113, 0.47122918089361093},
    {-1.685339149618518, -0.9701813876076877, -1.0746951888893266, -1.1179517336395368, -1.258502870443638, -2.4522683614948, -1.246621091225287, -0.9564899917022585, -1.550555377424415, -1.1265206481886114, -1.2815701438383467, -1.582995629703736},
    {0.6092290278720318, 0.5872362996633169, 0.27839145075334365, 0.5091049220061165, 0.7126213740701142, 0.7389713693705464, -0.08002317531202705, 0.753428169102624, 0.8178186763367291, 0.8002210969784007, 0.7599848931670652, 0.7655338573145567},
    {-1.760118129161029, -1.3713096780958325, -1.4215371069831009, -1.3771198560889293, -0.7429719799903882, -0.523851224026176, -1.5248747937575495, -1.4236586297652951, -1.4649798532027025, -1.6718198746825579, -1.670015848898211, -0.762614423797381},
    {-0.9900335322328425, -0.18478598530736698, -0.8403084027464849, -0.8074826895615477, -0.7434102575693113, 0.6168322623357173, 0.6442380191102367, 0.18239834835707205, -0.6491491915192635, 0.5479175451510797, -0.5803602604758041, 0.5118513633412701},
    {0.7026148717642189, 0.37389927838814024, 0.3929985519588486, 0.4681159989569484, 0.14899972472406156, 0.7870530301003313, 0.1436404146128516, -0.3832815967842598, 0.10800957586633383, -0.3247915791511912, 0.5753737311990912, 0.3108739540201486},
    {-0.16093146530988706, 0.7344084742133256, 0.6888896518947041, -0.6720793541328052, 0.0024446217878783295, 0.772113440220689, -0.8831243398720762, 0.6087080472047173, -0.6943389191648698, -0.9726584303920822, -0.14842547056558525, 0.015124824335867693},
    {0.8744405894459472, -0.7419387650770771, -0.5085015703097036, -0.9568033869125244, 0.22238980747013423, 0.8233934646221746, 0.2570561677492012, 0.1232256036004818, -0.16533028395377142, -0.3254835566730872, 0.4300263130378501, 0.836214959041578},
    {0.8024065705306795, 0.42805073996249193, -0.17527559423275013, -0.1876460360603917, -0.3281694743345425, 0.19926918970982657, -0.9341320410832222, -0.6945548937757973, 0.07804481317433766, -0.09191064928343394, 0.4302241397073428, -0.8901035052005482},
    {-0.7505788725020244, -1.0114300067794062, -0.7914150229103526, -1.5487653407747832, -1.5738946357241623, -0.4668355941583579, -0.7914318376995007, -1.371967590870576, -0.6133845525989231, -0.5218976791101306, -1.8892437252280947, -1.6471722753232723},
    {0.6202387114355724, 0.2980658879013384, 0.2917935420620715, 0.05633118080562351, -0.9495728805494169, -0.6691457068512032, -0.9217304663081506, -0.860035518298448, -0.9089819319787491, 0.7479966589547528, -0.6949982499216792, 0.22903318006295428},
    {-0.3203182171920764, -0.2642389381329162, 0.1522581556024632, -0.014604279677898634, 0.17625447323080257, -0.5602205738446979, 0.6353227002153654, -0.12817374006796065, 0.09401344446054903, 0.780213378032971, 0.07578973008928445, -0.07763113164294178},
    {0.2852235271113592, 0.349774145626528, 0.36383803789399244, 0.6659866950479951, 0.45685046558841863, -0.11037388178571321, -0.22322881902130282, -0.8530968693402041, -0.6783381400042684, 0.23086355837379188, 0.33582012760245206, -0.6279364805603889},
    {-0.11731355133755558, 0.06260127628051317, 0.8079713615319375, 0.30732231450428393, -0.14640935993741713, 0.7017784124204208, 0.09214690854885166, -0.48205057849569655, -1.1132456918460873, -0.20202729837632344, 0.3577966629265743, -0.13585529942666758}
};

static const float b4[12] = {-0.7858753179104423, -0.7459119114895892, -0.7904382039461888, -0.6148760020836616, -0.6261738963643778, -0.7464881824159341, -0.8159148922790334, -0.5978394922436902, -0.5885176342242847, -0.6510448877878859, -0.6102532489847682, -0.6865776111619482};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
