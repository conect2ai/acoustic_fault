#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-5.766952684406304, -5.903866429046636, -5.4154446881546265, -5.973607276463594, -5.578753990894803, -5.658294867976804, -5.602795474029996, -6.038117490820806, 5.791425869581012, -5.905179592687323, -6.170589514587178, -6.224887785502603, 7.507372358394397, -6.5490302177477675, -4.612837702144694, -5.604771993962382},
    {-7.238943872941974, -7.509743040659705, -7.484827382889754, -6.911668079876302, -7.36735345154441, -6.95951839184194, -7.1135635901006244, -7.241657893038611, 5.162127456415645, -7.208026296417917, -7.250046477534187, -7.658040009864333, 5.5163610601935185, -7.517073927582591, -6.935107437602365, -7.438455339595132},
    {-7.871632113842593, -8.173593115063964, -7.91435052231146, -7.88852217893685, -7.9802149761238725, -7.4686665623862964, -7.5284270501700234, -7.921378983924023, 7.01232777023973, -7.4458465034104195, -8.239827217666747, -8.285219057526888, 7.5999739317390835, -7.909339912585141, -8.019177966716896, -8.005448459695469},
    {-8.151959454415154, -8.00593032414574, -8.02082430318571, -7.483935255325778, -8.178492469968443, -7.725323704854172, -8.156920626108537, -7.98642624003231, 7.854056322860744, -7.6383109162719585, -8.091114755476253, -7.98984853258681, 7.913174964992448, -7.880964844559571, -7.848719433762675, -8.123863831084332},
    {-8.08352031303347, -8.304482051676912, -8.321112043978967, -7.468651381891252, -8.529380079232912, -7.7425455468020035, -8.232422652088148, -8.009353239130126, 7.98915903790484, -7.426134472232363, -8.172596257788568, -7.782659184215826, 7.561396218986539, -8.233824859290985, -7.838472584239957, -8.136474908956451},
    {-7.825003192967458, -8.085115603830934, -8.064335815818914, -7.291662048820535, -7.828046991443195, -7.27460945866834, -8.162332468543793, -7.66008641032289, 7.4324928767984435, -7.575060771081587, -7.821415820838275, -7.957747013658121, 6.956662708640814, -7.969568883874598, -7.768123920897492, -7.894704456088816},
    {-7.7821270166750995, -7.93568943901802, -8.057998575849771, -7.479698893752514, -8.130444496771126, -7.084059519588742, -7.889849670125958, -7.752758077234596, 7.429107838283985, -8.089228992420312, -7.718044099687586, -8.329914242343655, 6.561928419862951, -7.839083531911232, -7.777133945356325, -7.891538958479919},
    {-7.140357182904153, -7.797883701507934, -7.991751122660179, -6.822231375535029, -7.751196949594935, -7.179000388971965, -7.531591054560032, -7.486332707507543, 7.426275396305959, -7.656871293515307, -7.315639560272434, -7.631476908994079, 7.133970061545629, -7.689374876359498, -7.302412257268533, -7.6765063922244945},
    {-7.266791005716567, -7.933446315066497, -7.856598055833451, -7.245889015244431, -7.487061218864473, -7.493435077133595, -7.789984389206253, -7.613784126487655, 7.492295942571088, -7.502321871325852, -7.680322252329095, -7.57028932319097, 7.482267733243148, -7.780628285934252, -7.633700177398283, -7.902664131544187},
    {-7.7106143835838825, -7.778618866298956, -7.86320725885069, -7.4919082062611215, -7.896571049392813, -7.5247368205155984, -7.940676413037334, -7.567657910295492, 7.274796327344429, -7.641391455179382, -7.894485291849024, -7.860032603002362, 7.645740555522974, -7.917288976397544, -7.747496414118653, -7.635410873403839},
    {-7.57191786957986, -7.655265836881753, -7.556756780441431, -6.900481684272222, -7.590057558527967, -7.266429223523305, -7.4900267972651795, -7.608132489340445, 6.343010216610243, -7.253597685783271, -7.56903820942666, -7.746444105946173, 6.258827407361915, -7.773538993709224, -7.4461060776126375, -7.5123344566545285},
    {-7.573310906287611, -7.576729336200354, -7.650338237022251, -6.830858709142266, -7.898820673902256, -7.551984973015699, -7.7232281572185055, -7.47494504420522, 6.64662829944903, -7.380160538917083, -7.688980106086826, -7.527337154097815, 6.284048339909187, -7.753206671357164, -7.68725805105662, -7.4959394359554965},
    {-7.934454220020799, -7.884436674106931, -7.790311096745984, -7.4317206609011, -8.018623325598218, -8.047122250793217, -7.890924208551211, -7.66524714213153, 6.485835559347491, -7.816245003784899, -7.90312832272551, -7.853978432934588, 6.466030699261765, -7.939738254064344, -8.053330084520802, -7.639862687320516},
    {-7.87109448525487, -7.859180720673721, -7.977328889321933, -7.448625604810542, -7.9317913515655984, -7.7414991781781834, -8.200309943824726, -7.674741889746397, 6.3465274128816445, -7.983383875073506, -8.229198807573615, -7.777056097280763, 6.383058892579405, -7.79777173562067, -8.027195890167523, -7.910218366099988},
    {-7.81895235180666, -7.757824641739494, -7.953848623465409, -7.6743102720278085, -7.73387770068589, -7.669169498372359, -7.786561544621, -7.675994395397837, 6.136909589492577, -8.094462677328139, -7.972990208769676, -8.030205967207294, 6.595889748827839, -8.18247902918824, -7.904015257096782, -7.832761475178269},
    {-7.6674052219882025, -8.342259477297597, -8.191296772563783, -7.555176593673629, -7.9617516550681335, -7.948741085058845, -7.965899705092686, -7.875352329480117, 7.375723447352501, -7.867799080178365, -7.89577518834164, -7.873333513325477, 7.603736650181663, -8.182415234436016, -8.031637506388543, -8.11885206020322},
    {-7.962584841153703, -7.893467662094681, -7.9205998285633505, -7.328667142956902, -8.311344922928509, -7.744885453538481, -8.170261488251022, -7.881844175481518, 7.335452161198581, -8.011534675479872, -8.260359882998303, -7.858420123005663, 8.008708784865917, -8.066105251654937, -8.070170974302089, -8.159599839313096},
    {-8.248105941740326, -7.832224199210626, -7.95593954196806, -7.630319844373642, -7.916673588513636, -7.656137310101023, -8.127603618088296, -7.79718997116518, 7.310567001884631, -7.893829555886723, -8.144067387845404, -7.889208103307144, 8.08140146516351, -7.839880835251723, -8.160633251344159, -8.037952186271243},
    {-7.941019233469928, -7.745535042662013, -7.972943470993848, -7.798467509616205, -7.9786149088765566, -7.569128021483122, -7.812805095100811, -7.786478852777802, 7.578122541698272, -7.77356938092992, -7.999533920897309, -7.820695269226564, 8.108276086784382, -8.168201382077232, -7.929422541844045, -7.896544881776232},
    {-8.018974286458736, -7.86072517811732, -7.754720051645576, -7.327683598051714, -8.044080183346527, -7.550868361214676, -7.488337906493463, -7.78597208701884, 7.599680174474871, -7.635789156185627, -7.917646555410008, -7.993675339010718, 8.061110427158894, -8.022243881537662, -7.970691493612813, -7.7889384976558915},
    {-7.930396606303035, -7.943033711943086, -7.711194598641633, -7.211315781146879, -8.01396112625224, -7.761280589943758, -7.99933256829168, -7.644509628794098, 7.822967961335753, -7.629459628970582, -8.0512650827942, -7.780485608114729, 8.14801562304829, -7.915837269664184, -8.003815418363466, -7.924552071968206},
    {-7.708632902216187, -7.813350910109752, -7.7596824667281235, -7.111071706628345, -7.966396824459101, -7.340605702185958, -7.610847110157345, -7.6956617070961935, 8.056232549456231, -7.845566938989101, -7.6279908299043, -8.089087342537557, 8.433498768585283, -7.896682443221431, -7.795803391615624, -7.730888758458539},
    {-7.860898445478241, -7.4341646501279435, -7.767827395400143, -7.206304369610057, -7.914329298461858, -7.298021255904031, -7.419885253960623, -7.347600658706204, 7.590473692492393, -7.458814555763104, -7.931581485241108, -7.638258865165034, 8.216181838675553, -7.622881509559893, -7.553846689940985, -7.877839681803057},
    {-7.525255284963925, -7.769446702492305, -7.631758139459473, -7.117798174111179, -7.711950099659106, -7.473907094407871, -7.407599912520197, -7.309537824322723, 7.7120281842153195, -7.66632936551564, -7.962694413253643, -7.82896928770236, 8.253874887142896, -7.478360371504621, -7.562519236488502, -7.6686437198571875},
    {-7.498345196170269, -7.7127761233440335, -7.481905600427786, -7.152316195340838, -7.825845253189279, -7.748711685653527, -7.348625784247743, -7.223939225388019, 7.509106196649323, -7.37184328427457, -7.727267987318586, -7.7709812612144775, 7.609239114957972, -7.784269214519591, -7.959333892564837, -7.677652625528334},
    {-7.747995663859517, -7.623707448305523, -7.61067832009352, -6.921827588081718, -7.890560931134998, -7.76998125823173, -7.517103829257401, -7.548706787052212, 7.617905845960514, -7.4445896494822135, -7.810307088091968, -7.747740172727706, 7.698616958473214, -7.662417633916423, -7.782707789105312, -7.726491004596907},
    {-7.852243955077175, -7.972351747048276, -8.056466308533073, -7.538100490543143, -8.18059763607997, -7.6422825950631506, -7.740282313249098, -7.661800473872077, 7.723660661353724, -7.576332788259874, -7.996789268503306, -7.933786717827672, 8.094437898261823, -8.062619742959999, -7.716971412746196, -7.795044429193703},
    {-7.858181900349843, -7.9085263118838, -8.07577961312145, -7.46435765107114, -8.100828662542408, -7.79043591273417, -7.910855447202279, -7.817709534487964, 7.3564884053959485, -7.660895631335229, -8.003216575617142, -7.998087545669813, 7.966862459832997, -8.058091549322928, -7.874342491047106, -8.108809299364644},
    {-7.827050914564391, -7.7429581178421945, -7.7575226675271525, -7.4744774395328095, -7.904205648505601, -7.787569660805269, -7.662663865763805, -7.7202352562038, 7.097036277477466, -7.951446951653696, -8.017135481792126, -8.010677941256333, 7.761444519167012, -8.05521076003492, -7.885551402628338, -8.083238067648919},
    {-7.770436412201767, -7.964693073542633, -7.774833477956617, -7.421760427321225, -8.118023033693811, -7.839288780688557, -7.84558036685236, -7.757663229422464, 7.176649776411888, -7.708302095097598, -8.333833711925323, -7.9949528519543245, 7.59989194063455, -7.903420109144707, -7.921827430102804, -8.132756400041895},
    {-4.3992525162256175, -4.101685407044362, -3.4246304814043738, -4.034540460242383, -3.9225462267953346, -3.8364697205192115, -2.600948144472315, -4.29790477487629, -0.7040682019751172, -3.03558832167826, -3.7481867039148034, -4.39242135992897, -1.1871372212517564, -3.3591636036711767, -4.065622828553037, -2.962072070267917},
    {-3.7777421729335816, -4.746974592503931, -4.416079540903884, -4.008890728397298, -3.458513658107343, -3.9162833287170207, -4.112788838925244, -3.483480884189114, 0.8587547966799091, -3.703744999487361, -4.449247356720593, -4.432840089461225, 2.028477888330438, -4.467065205177387, -2.2412960585217427, -3.6711745385397125},
    {-1.206482983517458, -1.1849204058379676, -1.5885329055250546, -1.4274118990651057, -0.823442913803297, 0.3461737842590231, -0.9177376282086291, -0.6439948344132, 1.501771391920122, 0.4885550436777965, -2.193225179096713, -0.6742091830412539, 1.2420252129172125, -1.623301136661017, -1.493004325972062, -1.1594591473438252},
    {-0.29812919149800954, 0.33451313139824396, 0.051219318294814645, 0.025393979602032896, 0.010059661035684264, 0.18099393463096602, -0.08576592048694757, -0.2100779889911054, 0.6943934855040083, 0.4977087946426924, -0.6582701448667092, -0.05156058622703383, 0.8251739348126954, -0.5352723197742842, -0.13176906758987036, -0.2856996121996296},
    {-6.41367669393594, -5.7990572478720255, -6.1362402982727655, -5.915861203233584, -6.0805886818777894, -5.4904870850730365, -6.10378385485388, -6.0685101793730505, 2.656090961541553, -4.7431946129971365, -6.131711206714522, -6.1078059485580365, 2.565549020945386, -5.954966964826446, -5.826475317457119, -6.1488487981456466},
    {-4.598779474382388, -4.290573760263846, -4.163717954017044, -4.643409880135705, -3.6809555319171223, -3.6316406284507075, -4.610799087593916, -4.20494133191768, 2.022015253891572, -3.8676661304578723, -4.317889136888757, -4.35785083673156, 2.5138876052441015, -4.477820262644233, -3.944032406680877, -4.316906359317615},
    {-5.4898616895782295, -5.380716615920579, -5.364023900358317, -5.407710209022086, -5.479647986047795, -5.118097976812252, -5.534530166103788, -5.625036976811843, 2.9074732087725486, -4.9290587268067245, -5.323053897575722, -5.516287057794814, 2.7925444933158508, -5.533647939243359, -5.189437251981158, -5.5059242172099925},
    {-3.4912820591761884, -2.9654687148645826, -3.2138405771535044, -3.033325662164603, -2.8594016045020165, -2.378624414700366, -2.895150302626741, -3.296254816312251, 1.300497475247364, -2.108288896759912, -3.43771136304732, -2.755643169376304, 1.9356087981136212, -2.916487884316963, -2.984415790037956, -3.041195305115469},
    {-4.884237179116749, -4.619307809182826, -4.9626193654015465, -4.717088386424059, -4.2107535956936815, -3.6932608494951187, -4.675038804688907, -4.753320946545138, 2.8423292919267977, -3.3922185349953926, -5.06011469772452, -4.4698109517060205, 3.0918005868061766, -5.271418477413028, -4.217464686003452, -5.001761993843632},
    {-6.616005083848371, -6.470735761818507, -6.913308153938112, -6.596304688933802, -6.528013838523652, -5.676485439950218, -6.513279011749369, -6.854703146100364, 3.330790591346498, -5.466625630348653, -6.844359281871202, -6.592705607473713, 3.633409015656726, -6.901929451832759, -6.576324252522457, -6.761762748697361},
    {-4.969532257053441, -4.793898320679797, -4.721274527367498, -4.53167252672587, -4.966299446193449, -3.9007914415263607, -4.595402726430722, -4.819508533827118, 1.3382861336567764, -3.178755839975586, -5.0086778811332335, -4.841604966491813, 1.273002576824707, -4.827314986839409, -4.827050600022149, -4.70703885506076},
    {-5.129344995864971, -4.898225801869602, -4.948243433104066, -4.861667755552187, -4.7080180858524, -3.664080203576509, -4.623338537288986, -4.855135010237688, 1.765720974658798, -3.681040955508564, -4.975233205897728, -4.654653929545475, 2.207016755545207, -5.114445205924358, -4.7117791686740365, -4.994797142744798},
    {-6.5856957086632235, -5.9345076058492365, -6.179867108207015, -6.147854684653343, -6.28783853821498, -4.932949938656627, -5.974984857311425, -6.312207033661893, 2.3472749926608696, -4.520535002796878, -6.445513363050305, -6.183484739900026, 2.29021318630322, -6.21780605546731, -6.146121230213432, -6.20868323999534},
    {-5.6491744126012815, -5.657099166027568, -5.572714094762291, -5.77493130141569, -5.2641187012335315, -4.348207712780138, -5.461854736997288, -5.090391003419581, 2.3625981285919653, -3.9838567542916037, -5.9375379348124975, -5.6746437034077335, 2.6611677778317167, -5.866061430950179, -5.282832225994062, -5.7778858810053215},
    {-6.769034126836019, -6.618735618908579, -6.410175903555323, -6.641374218585009, -6.475516178857634, -5.442289826403347, -6.17260722713729, -6.535242881560825, 2.451365875115006, -5.392031713494667, -6.5360016720864715, -6.223496766604704, 2.536427295948089, -6.598090861195707, -6.472422668416423, -6.470976689043838},
    {-6.298017198868753, -6.257016465968456, -6.253509645958678, -6.422366485507063, -5.772000214637832, -5.09882804841012, -6.1505674780360176, -6.111295368666913, 1.7430447101259732, -5.289271536213252, -6.529169493797321, -6.112132065700614, 1.967588929913316, -6.49195843190847, -5.924515987306378, -6.289191606247298},
    {-6.673728113376463, -6.319430721550445, -6.359445602971707, -6.580321746525739, -5.843643500237578, -5.299364522327482, -6.291871991022496, -6.3630792270671455, 0.8641549514834441, -5.235032405065617, -6.648098930803653, -6.418796723087287, 1.9312081670005554, -6.630274370776529, -6.336381725980877, -6.438735505752482},
    {-7.255290747526281, -6.659374755119745, -6.58433601973925, -6.908123344703779, -6.652993848249888, -5.914547112889951, -6.702621056546589, -6.857496050912329, 1.561640925596022, -5.948970768070098, -7.095594790171723, -6.7321544877175725, 2.3863391570882446, -6.567330827770523, -6.752400424285417, -6.900933823976331},
    {-6.877629925150326, -6.38102416612462, -6.634381916274303, -7.073794423087929, -6.272859630721937, -5.576109912253072, -6.637687997166996, -6.397335159263457, 1.4103163129252332, -5.4991132434665175, -6.9696547036477945, -6.452228152190546, 1.8247514837160534, -6.731160238835047, -6.477751466736533, -6.523101204837618},
    {-6.393771222733919, -6.382108070587339, -6.3186539425721495, -6.655970593354694, -5.767561412432168, -4.831129389859593, -6.161464756642653, -6.121442566778981, 1.7018484568896628, -4.875677148902407, -6.552555803304461, -6.276361958712775, 2.151860841418279, -6.4139988602809845, -5.570577070378805, -6.652001257571041},
    {-7.636313905586746, -7.244902285653557, -7.49597850122749, -7.322794038450958, -7.094821626687202, -6.295269071903774, -7.6300520892495935, -7.187365975101695, 2.6145952017168446, -6.367367460286547, -7.558611885334419, -7.619894535785651, 2.2523958668617454, -7.427001709188706, -7.1380872244072995, -7.406201942313597},
    {-7.80296975898457, -7.628873102448462, -7.740669580223984, -7.599807118425582, -7.596552852253884, -6.889348058247783, -7.5227091354485065, -7.852016970168637, 4.772974145751656, -7.071952964314817, -7.536918121056182, -7.810858164636923, 4.828766000965107, -7.917817772361562, -7.323110729236052, -7.521284631855439},
    {-7.840244822497338, -7.513515417658311, -7.894973379728606, -7.816416003260501, -7.492486118951679, -6.385211065616392, -7.584252368140576, -7.7152155039814545, 4.078912142014274, -6.711584565788012, -7.675854077448365, -7.804995134087005, 4.332883230464814, -8.217191256370773, -7.520472227438137, -7.479830871531655},
    {-7.501174337814837, -7.0713605946244185, -7.375348917070425, -7.5819368833057394, -7.194071872934198, -5.9687352924532595, -7.439099075942241, -7.385843561535602, 2.9104789996017937, -6.0777356748335745, -7.515362612833819, -7.231458669530499, 3.0879693221621896, -7.607569887648062, -7.355084484506194, -7.191659961777524},
    {-7.295653982234545, -7.519875134029892, -7.66762462812975, -7.579425197263404, -7.107525058041074, -6.502902237681655, -7.2876754652793245, -7.581709910868183, 1.4371166490890395, -6.31883388130046, -7.4226506922868785, -7.3877583908156845, 2.0354907563086355, -7.348203036150575, -7.248031251049681, -7.484078505567291},
    {-7.691607848943636, -7.090224249234064, -7.223894881910044, -7.451182922475112, -6.917588700000764, -6.226554285385843, -7.336265530667187, -7.343957189417092, 3.0797384051821854, -5.969198718164666, -7.562708478097078, -7.283389999173668, 3.0540893372452436, -7.274351295470301, -7.105350125468494, -7.105067109155471},
    {-7.672931279091804, -7.6424164617117265, -8.006576670595834, -7.973071406304382, -7.373651044617695, -6.6300195428462825, -7.410417469933957, -7.74519596031138, 2.154166764759011, -6.792469379154888, -7.91638879242836, -7.706607980875562, 2.3838751699820624, -7.665822061950506, -7.780516149728236, -7.903717239753057},
    {-7.919491902603526, -7.56241548072165, -7.621089533307751, -7.707482997733915, -7.297526147623497, -6.110860360705505, -7.002488343440048, -7.746060935675915, 2.39198360052923, -5.997199767159119, -7.704452517502293, -7.340495653796711, 2.8207589866652465, -7.487824051177684, -7.458677140912576, -7.5279282124326015},
    {-7.823651257588245, -7.3342208211873, -7.616156751977524, -7.913954909412, -7.28469168787155, -6.429992908780967, -7.54732442603294, -7.648076941411678, 1.9436086234960706, -6.968976716734918, -7.8196146524531995, -7.4853056156517015, 2.4764063143362667, -7.604076149462714, -7.445276188669003, -7.384534580002401},
    {-7.475014046220883, -7.231374540516143, -7.322118996250358, -7.688583714726212, -6.864798893363942, -6.773019752055172, -7.396801952445831, -7.7260354880480415, 2.392237999860086, -6.880137193005056, -7.5586873449491145, -7.452010513936494, 3.0645349991531208, -7.519420170181627, -7.454060948527681, -7.018821675519552},
    {1.7836664029790972, 0.37678512099377737, 0.7323161889230166, -0.36514506318607015, 2.0306355914313916, -2.035045382526782, -1.332783787679018, 1.5129907073051865, -1.5594662940325286, -2.1089596450574692, -0.049369052551304554, -1.1866669158247325, -1.8444680863542309, 0.11204014758104547, 1.558595846567116, 1.0306519218041743},
    {1.3552040151560212, 0.017132525033909596, -0.03694393825735053, -0.7980024913676482, 1.4701898913659799, -1.802609238070889, -1.4309341751423763, 1.2803019705436145, -0.8374578196570884, -1.8916398388066364, -0.5275951041831726, -0.9882785276372529, -0.7460220550939247, -0.4468478984746528, 1.411553337079474, 0.662099437179468},
    {2.6705320379426554, 1.1922768279175995, 1.3045091414405536, 0.6017925062598964, 3.1110043710350728, -1.19477161395492, -0.39328672289852373, 2.696714946783401, -0.19570891958864425, -1.1871360518755611, 0.896850107388341, 0.07530629003074524, -0.38912272728910136, 0.8795390831774741, 2.832763725780225, 2.0741871585877045},
    {2.3345596127374235, 1.161762574986977, 1.3772346235931379, 0.3044073662885172, 2.9961394373125616, -1.485015811831306, -0.5219345721376684, 2.2712705568538367, -1.0214967677491857, -1.7217821810266063, 0.7064609547745405, 0.09116793841325468, -0.8787365040209271, 0.8234600833781526, 2.524762319661106, 1.636317961730656},
    {2.159032098885521, 0.7003928305248401, 0.9545879418918132, 0.26166893818849857, 2.385596776160691, -2.244516526551663, -1.193943802626606, 1.8068226183922043, -0.3913361326294075, -2.4407896450509434, 0.45171297002203187, -0.7016796518965186, -0.5954474537474621, 0.6078850735378645, 2.137135992218859, 1.5224355945431018},
    {3.4445994723538775, 1.6765452351039376, 2.2140133462638594, 1.1095602953713573, 3.622309199057147, -1.3121363207784407, -0.3681052243841259, 3.352954431817705, -0.29447704363035004, -1.6798808740341895, 1.7742904166784261, 0.5846292422428736, -0.46561934354960044, 1.9015401802036822, 3.239097257488358, 2.8859933155399813},
    {3.731025378202766, 1.8419345914773362, 2.4518997453434754, 1.6182917822916294, 4.157862219457987, -1.2742965205804995, 0.19131532076115848, 3.6370432463241986, -1.0780174392757902, -1.5528107253470769, 1.8629271737789888, 0.7159650361556495, -1.4146046892131718, 2.069654942628368, 3.785186863721206, 3.3121690596045203},
    {3.8041315622019343, 1.9346494821574518, 2.3807751006824525, 1.2870471843328486, 4.004126884560067, -1.7060121123756862, -0.20342005530120322, 3.614410362164517, -2.2250666110681405, -2.0998758306268384, 1.8549969072375476, 0.680363128948799, -2.3850550687182484, 1.8750038470523702, 3.5894256660264023, 3.0967140026908284},
    {3.9432951872144866, 2.2697672537015476, 2.8460084814260944, 1.694148265681235, 4.46015528461054, -1.3506454193800588, -0.03619578277975195, 3.5365944910131377, -2.0262738015231103, -1.711469155672697, 2.0547161480572256, 0.7371053393596256, -1.9662201910442942, 2.392853328553109, 4.00903954930215, 3.572849789393421},
    {2.842718000174954, 0.7525646786831293, 1.4232696327808367, 0.12894403877324018, 3.3054249804402143, -1.9772791946814765, -0.9636452392380438, 2.585466585478573, -1.7178546993592274, -2.0841591156613952, 0.4513000387879447, -0.4193179955110493, -2.106411726921515, 0.882262541475014, 2.8692198863674783, 2.196348698489429},
    {2.8050158270760654, 1.229696383268166, 1.4378024365315882, 0.29901932698550654, 3.2372012117300804, -1.76403343045276, -0.8391967059264855, 2.7958186059812418, -1.168292429741439, -2.14397017062479, 0.6263155577477388, -0.3448524740979083, -1.3263761511860699, 1.168999720240407, 3.2619418264359865, 1.983311587294864},
    {2.8576382223533963, 0.7947189255440874, 1.4371940396198084, -0.07358686636494424, 3.4508378219367963, -1.8595390684773268, -1.1231069548113914, 2.8434445187427393, -0.15499199461709068, -1.9759897217017828, 0.6192670427801894, -0.7805620539654433, -0.3650319820043684, 1.0002062363575195, 2.9098149382019565, 2.357244943607243},
    {3.1497227805424397, 0.7719865556214107, 1.236183446628059, 0.28786302549379383, 3.6126426571082044, -2.238269118333262, -0.9092843002396783, 2.8963503891522677, -1.827323937400698, -2.503100080324451, 0.4900965831501644, -0.5464214984640049, -1.7408286409609806, 0.843732460080619, 3.0379422514605254, 2.3809545712873974},
    {2.7748560811349283, 0.9768115935411822, 1.7423412335329136, 0.2637144330537414, 3.12440210428754, -2.2069312725044825, -1.1276429020344496, 2.6503866876488447, -2.618666018758069, -2.4859774938281864, 0.6201250914525379, -0.5218287623952224, -2.507381736289033, 1.1245610382253863, 3.157619757276634, 2.231045292555737},
    {2.929849685854134, 1.1861229529881478, 1.4883664643868513, 0.14188480528831837, 3.1736293009833685, -2.4213481192356157, -1.1274363828687346, 2.65084459696359, -2.36966394791702, -2.73113097767193, 0.79203983523336, -0.47787231818889914, -2.398115014109034, 0.9831637003045105, 2.835637141394767, 2.152785080593836},
    {3.042976307639852, 0.8849197087594329, 1.214052589134236, 0.024525359259745392, 3.595062169753725, -2.93951826896939, -1.6144814379619823, 2.835074635934792, -1.7930138180931965, -2.8668484407033596, 0.284573306227073, -0.8733818330104877, -2.125829949411557, 0.672910958011125, 3.3411053197628786, 2.040034345546074},
    {2.9962415837016008, 1.0698370228034737, 1.4254325350801313, 0.20636258425258505, 3.7450168140217883, -3.02695544375291, -1.4792688809636192, 2.983982059977922, -1.2222265589754215, -3.397344601874312, 0.7142475256919188, -0.6657224908346797, -1.0748385453810858, 0.8274380538418462, 3.225936115255655, 2.4064387300102488},
    {3.1485411499247555, 0.7050579087399313, 1.0570195984846609, -0.4016979558503583, 3.5991587938932312, -3.477893302803698, -1.71719357448998, 2.786693325740093, -1.6923584218457943, -3.7511988773684837, 0.22720479773888572, -1.3544973995396647, -1.7955927889143104, 0.45896996264104706, 3.017879530217188, 1.9095484297878114},
    {3.0904913335168605, 1.0699419662708718, 1.5581877002598974, 0.06499476619577826, 3.5678294561677126, -2.5618767718807582, -1.586166848862975, 3.1213556143330274, -1.937408670645947, -2.8457102885868544, 0.5815845077387893, -0.5786588393201411, -1.8915745531516848, 0.9885911775534891, 3.221877419479693, 2.2315571880938183},
    {3.9111585856864086, 2.221424535319515, 2.7654390579362795, 1.3801283804119975, 4.470441374824653, -1.3902704739061331, 0.09302756136222992, 3.9356202615323332, -1.6893981022024365, -1.832303264198108, 2.118256444457398, 0.72549485298452, -1.6694696662055264, 2.474831147370779, 4.0631513742955345, 3.363693820974252},
    {3.7442163391148093, 2.083582039261135, 2.420807717958095, 1.1128671491368822, 4.246502708226585, -2.119919482402368, -0.439467607017416, 3.61275596567353, -2.468173198489641, -2.4222829236080585, 1.755514629694373, 0.4424912819359287, -2.5903976404613376, 1.8713478659762128, 3.9466035184962616, 3.1498989784012426},
    {4.454666207187614, 2.5259232560896927, 2.828678334653107, 1.8501641813663956, 4.640604547258341, -1.7041701214145495, 0.34598710710471425, 4.236784157983682, -2.373540690074722, -1.9283506240685584, 2.3060440641215, 0.817989610405967, -2.573283681287197, 2.5584171358042016, 4.483535803342466, 3.634482028414061},
    {4.089689649735722, 3.0436472204871796, 3.3346218292121605, 1.7728542336683215, 4.849559115763223, -1.6967971264735002, 0.16272320278516753, 3.9094028642943637, -2.792550170915651, -1.7635040209085717, 2.6005378920093687, 0.9921880224678103, -2.7268318970876266, 2.6686354042864355, 4.458313563695113, 3.742450802806221},
    {4.4998342254866985, 3.3062191106359142, 3.4096883280339596, 2.1524641856272533, 4.909155824112745, -1.7344746858949265, 0.35855994294618976, 4.084319320708245, -2.396856347147886, -1.9580042515754619, 2.4497587086872965, 1.2265627841001783, -2.4801447348159242, 2.883394407801786, 4.636927580979902, 3.866047578225813},
    {3.6656971030747, 1.7084997940274134, 2.0342579974661907, 0.7301464089005996, 3.7879453726510537, -2.548994081153165, -1.0844249707471851, 3.355019914771931, -1.5488741808229742, -2.6422022547265764, 1.2609078215924892, 0.0029725711424370394, -1.3851101522666396, 1.2436246326113907, 3.5550857294385536, 2.825259302083172},
    {3.7347659116881946, 1.7982004786531476, 2.2554978421455205, 0.3583157743054411, 4.523139567435, -2.7616137158744998, -1.4029028934046703, 3.669969879071551, -2.766700174348689, -3.1083441098556532, 1.260927215269793, -0.12511669333240952, -2.5549588709028757, 1.5836602037466532, 4.166606246009512, 2.9637980679939675},
    {4.651055665373284, 3.239293729934188, 3.461468650110499, 1.9222035643773006, 5.123118493174516, -2.020519302302183, 0.10431022027702017, 4.394056276684645, -2.351773696462873, -2.3461331033904913, 2.5322044597125237, 1.0215088967450547, -2.3580253033659626, 2.5044015180109933, 4.873063413101814, 4.086233570745737},
    {4.020851042377789, 2.0445606632146656, 2.21280816428285, 0.8269350208836747, 4.294763689497855, -1.971652340801932, -0.5038607044088588, 3.7395849446338985, -1.9148736711373524, -2.159349688777562, 1.387643180502458, 0.08983885426976924, -2.071007718158397, 1.5485917379937697, 4.096902818894566, 2.817275119115113},
    {3.865785316970595, 1.856323952091088, 2.1266200884791293, 0.6994139262252393, 4.60763942884026, -2.587749371751517, -0.5682752926204538, 3.6959892992956354, -1.541926415010446, -2.605195270958045, 1.2821766000005892, 0.22479134397145736, -1.64144314802898, 1.499834465144278, 4.093428764765402, 3.1373399215002533},
    {4.515418207767239, 2.6066577938923006, 3.082723476171838, 1.396998521268942, 4.718479914312388, -2.3551578964960194, -0.5321342175575257, 4.176241618262184, -2.3995066503240636, -2.5164855972363704, 2.0364218539813144, 0.33985129446978807, -2.4131290271256387, 2.273084032335694, 4.614544487107422, 3.6469860070946036},
    {-0.13699888013762024, -0.7278311475531717, 0.015303604180210267, -0.4730960687833946, -0.5394191212314434, -0.3085529424886362, 0.25958976894779673, -1.046625698025045, 0.9129588378073039, 0.0827134066354928, -0.6401174904325886, 0.14166857089299648, 0.05176987766593895, 0.1925213884150642, -0.13073012592298006, 0.39259066156616196},
    {-1.7953613819623044, -1.388002556878317, -2.6840664564187366, -2.3641914409064806, -1.29459729201448, -0.06592959874559903, -2.1463606521555807, -0.6473757085331976, 0.9766376813639757, -0.5787081975048447, -1.9882293134414264, -1.685515661128846, 1.2600309841217552, -1.4481545049816829, -1.68967948364225, -1.288458701187162},
    {-2.563908127737379, -2.840933731491761, -2.363838054646166, -2.6569808572823406, -2.475671884916126, -1.2221337489601596, -2.106138316512652, -2.6959727304837378, 1.802478825832591, -0.6855029796842191, -2.535161119818974, -2.212158592107749, 1.7295644226939888, -3.173530457316835, -2.621308197821254, -2.2389508439092363},
    {2.200697973602693, 2.102823580090784, 2.229945760254997, 2.2569453291023724, 2.6758056309936666, 2.7019962048722874, 2.536789372882649, 2.0918425759557424, 1.1875564334465443, 2.773608985061898, 1.920801851612193, 2.8325833345740157, 1.330864878114845, 1.662575881527285, 2.1727413017979744, 2.283817307264345},
    {-5.049794652072683, -5.357497156926686, -5.116413494120735, -5.283273264952942, -5.040319878837048, -4.345913474150616, -5.215997454061978, -5.175971027953198, 3.2626473534204226, -4.170528913649203, -5.494448801693995, -5.210885789833702, 3.306595632464565, -5.276673804599799, -4.900605524926594, -5.353189195606478},
    {-3.4616292015393384, -3.31688072265861, -3.294422235099447, -3.6973586341890146, -2.8916055003134553, -3.003373441850438, -3.5932082364363995, -3.4066181513551492, 2.263134290783778, -2.9770151530593716, -3.680586228526824, -3.6192196769647387, 2.610438967253584, -3.356594406189325, -3.2622861832882992, -3.445988810929129},
    {-4.627394193887356, -4.302165338550869, -4.230525236442278, -4.497430587794057, -4.507557631908135, -3.987385014855095, -4.5725267929668725, -4.803538221424601, 2.614034067554334, -3.7109720695729487, -4.463799987513513, -4.661009910588751, 2.4293564880914125, -4.4436700817621935, -4.355900632612098, -4.275691836617976},
    {-3.534273081487916, -3.3941308584382197, -3.2101278648449045, -3.128789557777464, -3.1034636425522844, -2.3234141022853896, -3.1068439847807157, -3.290162545493334, 1.3029075882038066, -2.0577663038596126, -3.4159842266273874, -2.948063074741722, 1.5618006971900724, -3.357106422850555, -3.4422302647227645, -3.1575101888973536},
    {-4.4064530803827395, -4.339518155133286, -4.59692547574663, -4.470056215304149, -3.874598947319075, -2.830870309285103, -3.919330038859051, -4.19105572690082, 2.7222203389161694, -2.483587369338248, -4.713074455972951, -4.447302108087409, 2.677820357157552, -4.806675237146011, -3.8781372744304066, -4.542287662928786},
    {-5.78126707825061, -5.718551070259173, -5.7620672265585, -5.736270404006783, -5.407849223083304, -4.531944727373605, -5.293095583670309, -5.6661376591577355, 3.470999613076872, -4.212798590901928, -5.956568314628469, -5.604866702704362, 3.6024762589962487, -6.179970564172414, -5.571285640987887, -5.732540774738955},
    {-2.4258816358127637, -2.773045990095071, -2.6749253746938506, -2.376214734310828, -1.8598887074537187, -1.5268032711955848, -2.478874654354687, -2.4569577040786217, 0.5968334045204647, -1.312785856577535, -2.6997513193176714, -2.703047741945751, 0.6809400627633994, -2.6684416755116334, -1.9080194906199033, -1.911745984264014},
    {-4.115178625029302, -4.074268917708821, -3.8646457788417337, -3.594851773546291, -3.2082381858531543, -2.6318822836142908, -3.5414391242856254, -3.8821885060460404, 1.4721900171981541, -2.5362087181103266, -4.052066909412524, -3.9243138096821237, 1.5900116399591075, -3.94226229897542, -3.5469107427279614, -3.723190646875109},
    {-4.694300431399184, -5.215801913909194, -4.97052149597807, -4.669619814610744, -4.5651580715391304, -3.761681340745532, -4.567747356944322, -4.9738931027275965, 2.2009579820805594, -3.475185164363272, -4.988288634553145, -4.8860171544224995, 2.278013383974992, -4.990467098012162, -5.015781446571604, -4.588713399694768},
    {-4.406815771721086, -4.2604382507907825, -4.247856612025599, -4.652664603457148, -3.5173137749633248, -2.254824837418852, -4.254292795670794, -4.044561742213085, 2.427776262604075, -1.8798522448322057, -4.610596796883236, -4.576370022819748, 2.517895478656668, -4.6818537729057175, -3.7896877636389625, -4.131262477202921},
    {-5.691116781789303, -5.471655071895744, -5.437869980440331, -5.750017895548453, -5.36244771739023, -3.6495480857229405, -5.252384613508464, -5.709462787058535, 2.9983766675213306, -3.6909686309004157, -6.015980700438883, -5.487708469252453, 2.7709182267878103, -5.59439224101097, -5.422014441680915, -5.4887223051917156},
    {-4.782843190170844, -5.1255435467464645, -4.8701213642617045, -5.364571211504256, -4.451150727563859, -3.6374648722770293, -5.113511544669137, -4.850498004349813, 2.465428620975877, -3.611050984539945, -5.229179607312595, -5.052876216469609, 2.3894977217073015, -5.323013755927807, -4.757239697966304, -4.7153716694229395},
    {-5.822946740028437, -5.6457411010318514, -5.71867655227513, -6.071281731105808, -5.386317539537875, -4.2932438172422795, -6.133591725708568, -6.318693940068901, 1.954795165111639, -4.58635699542766, -5.789718098632214, -6.003694158762902, 1.8327534329251869, -5.862359531642989, -5.730400553684803, -6.071892166138092},
    {-6.9143723106281705, -6.437093530470761, -6.56644475789914, -6.881011484857402, -6.199992826579888, -5.36804935472757, -6.778159181813548, -6.655776031816172, 3.1535038226263286, -5.508741078039172, -6.637849767020492, -6.3447288932690435, 3.2969074902399154, -6.627776610691053, -6.476587223348401, -6.309361502232041},
    {-5.964522350177886, -5.552924301626644, -5.957022359327665, -6.024603753349895, -5.274113931884445, -4.517512633239821, -5.795519604360473, -5.790183985440389, 2.2999780553211684, -4.339209758694394, -5.94591194957548, -5.477895950984571, 2.3552863285978023, -6.0653278278432845, -5.582035978168154, -5.5330133077825145},
    {-5.665523645433548, -5.591920336024241, -5.729215182433427, -5.827203661361792, -4.466767204839427, -3.884233274082578, -5.4497837508293365, -5.581359337177651, 2.013581132448609, -3.6826819026425794, -5.517062712296116, -5.253085809579405, 2.06099954646561, -5.813044238093757, -4.8900220929419405, -5.196292533688793},
    {-6.557175797956829, -6.7095497321493305, -6.572653044263713, -6.568101234995861, -5.819815261332448, -5.047712904547486, -6.501998741302532, -6.558201870065198, 3.253577651409804, -5.085444065775178, -6.514031978741246, -6.348488326557046, 3.0331807980129057, -6.622737358292834, -6.360765209791284, -6.504316784718212},
    {-7.14204820962244, -7.204174184112611, -7.190845946337581, -7.419413411186123, -6.1530806265702145, -5.311627421574376, -7.01413816288702, -7.121317798159083, 4.110758699973826, -5.471429166491902, -7.290342440006578, -6.718630498864829, 3.6349396425471023, -7.429649893029842, -6.7507418175008045, -6.604288457810743},
    {-6.891377732177312, -6.576869279297014, -6.658005204407382, -7.322807731327746, -6.287582150299881, -4.5557592344132605, -6.512338655086891, -7.089603126170289, 4.240307936322785, -4.7433004407504145, -6.730719979879905, -6.217901188551234, 3.4668598554842167, -7.104347377967316, -6.406008952032469, -6.091381866059723},
    {-6.970172245910937, -6.946523418382181, -6.736312262176023, -7.254133337788092, -6.3892137597589596, -4.608837335852454, -6.571524511615036, -6.90317336003943, 3.3761968596644927, -4.829232517579057, -6.81510784379032, -6.153383085811284, 2.714283568681676, -6.940187066259663, -6.900109269649608, -6.420133216346025},
    {-6.755900222729686, -6.676534042591486, -6.614016699072226, -6.894623525073024, -6.111889822888553, -5.251146060576484, -6.637540651064252, -6.494866057358552, 2.8684602007402265, -5.158125172439043, -6.908142858003475, -6.392826207430699, 2.7797524958296953, -6.944462624156672, -6.37446622550338, -6.340811633258234},
    {-6.312543614979233, -5.978144747814091, -6.183663916111584, -6.864055700698959, -5.642890949752773, -5.116131243416526, -6.368717831780943, -6.219895553202405, 3.93387816746794, -5.108322662420545, -6.4268381448062435, -6.1855679675356905, 3.2741906959679703, -6.524829988728305, -6.135837018668624, -5.568056306543838},
    {-7.564738201898666, -7.307813155879099, -7.278725541439276, -7.701251601827931, -6.72947386049906, -5.536367253121954, -6.941057367421222, -7.308858510127441, 3.270958007112033, -5.977642905185328, -7.383200806981239, -7.128716172210612, 2.5507213136908824, -7.643907872845015, -7.124615786293785, -6.887828591695139},
    {-7.469797774244732, -7.31391436766313, -7.319110874767003, -7.634980972463509, -6.743446697752606, -5.226894150507782, -6.638909439230878, -7.562042843290349, 3.334698124589827, -5.011201460663549, -7.604845973532602, -7.06748465261153, 2.8183675979683374, -7.50146625378718, -7.227796798113196, -6.7999545685824065},
    {-7.5322742649623144, -7.302327634783155, -7.374514143761532, -7.650485920985212, -6.55303969698127, -5.373287002079177, -7.166462036015624, -7.3077345613156375, 3.314366954527734, -5.901103403796023, -7.402874161099408, -7.149224488769716, 2.5139154150523764, -7.53809424753983, -6.996001174187324, -6.8198067180019875},
    {-6.720842579610111, -7.139597403624091, -6.902687521289638, -7.559092366189341, -6.06378730893138, -5.28386807399359, -6.7806513263313475, -7.270591725551977, 3.536671629824391, -5.935663220969585, -7.207208720685623, -7.062165779598866, 2.7599069800471474, -7.483536312012599, -6.786703750018353, -6.706885858265757}
};

static const float b1[16] = {8.640029082332228, 8.559623099912612, 8.607684257680653, 8.640184551781013, 8.586522567918333, 8.69307189412778, 8.86880597445592, 8.629590277158615, 8.86736138707307, 8.498128317659114, 8.644170186478654, 8.813253064534145, 9.055255242750427, 8.656974906273987, 8.711574678375062, 8.598368560920296};

static const float w2[16][12] = {
    {-6.293873942686017, -6.819004569346935, -6.130315982498847, -5.895550630165299, -5.793036184654848, -5.528856997384338, -6.08579149799994, -5.862337725796024, -5.330146664929612, -6.121536839714848, -6.049827150927343, -6.209768313417876},
    {-6.38573190760881, -5.5814473415509385, -5.623681399093029, -6.018819173822169, -6.763413100384076, -6.265090079591771, -6.639037420001629, -6.407796059670571, -6.389294945262673, -6.1910831962333965, -6.0738389751339374, -6.1674878363577665},
    {-6.323761669975134, -6.483592245870709, -6.305701646095331, -6.33620948423999, -6.155415792121603, -6.009334940882933, -5.391151974725641, -5.895777544577969, -6.647807441548284, -5.487358568369901, -6.314218290615241, -6.8792138371090745},
    {-6.2652144122722015, -6.369010732172172, -6.202118289802897, -6.339589508166387, -6.555831797697343, -6.558694158900527, -6.127283687310484, -5.337449455572355, -6.29728983026086, -5.593249130512838, -6.425130847685548, -5.923377119834983},
    {-5.596948262190584, -6.026152673189186, -5.919295300707825, -5.857283884957317, -6.053974736915621, -5.6597691643134675, -5.927851470673682, -6.306247067447709, -5.623713269693835, -6.230578200029641, -5.586713031755249, -6.294945431157346},
    {-6.444773286124839, -5.527018075471959, -6.143993207763863, -6.006049846573743, -7.116276041483136, -5.551465927303325, -6.038315539254122, -6.2089915750932905, -6.067325833031864, -6.682990812510192, -6.119513557824331, -5.721681773586685},
    {-6.075600754449477, -6.240865842718422, -6.377553429159526, -6.280686561052132, -5.996235032763003, -5.950133030545723, -5.717860353324661, -6.778588910205471, -5.9071169873233815, -5.98436582366565, -5.4969665375875625, -5.949193082935873},
    {-5.912504588926658, -5.847580227750911, -5.670113645016661, -5.771586408633794, -6.533727624285485, -6.7450981860547925, -6.107065550667626, -5.640357751750086, -6.178762169076699, -5.8905143006653455, -6.840603212565276, -6.239333257137594},
    {-5.504870965059926, -5.216753172326375, -5.725645483183006, -4.979257931815792, -5.418077266104436, -5.230681390801164, -6.1050202345300155, -4.82810708336551, -4.568649582837538, -5.288637985628292, -4.4853894583244225, -5.641724731489375},
    {-5.9292442757036214, -6.574460039218956, -6.02762927462919, -6.009774623544242, -5.244819920980907, -6.503722295208409, -6.317980917099882, -5.997474088711604, -6.2967193159782635, -5.524413183285086, -6.327197576623094, -6.3796200678630175},
    {-5.839262052079563, -6.303309570740164, -6.809551453361995, -5.409091685044753, -5.776998942074599, -5.7932251008384075, -6.147971250535749, -6.190105205767144, -6.443232646698001, -6.3941868729842355, -6.597988341703581, -5.597417061926248},
    {-5.758018491328083, -5.762082448205041, -6.089893631749759, -6.480933532711254, -5.736149739447065, -6.191823887456328, -6.2887708673396165, -5.652084766281689, -5.196405848666032, -6.561507870690754, -6.169874429833351, -6.729330299668515},
    {-5.184758230523836, -5.318474273344491, -4.924919988263973, -5.779026247440161, -5.232859578292135, -5.395349582164064, -4.495908893892146, -5.698798586107036, -5.974358557002793, -5.303601649781983, -6.134845813263784, -4.922225904042242},
    {-6.017428599506285, -6.787383163608084, -5.24632527310271, -5.987042735885773, -5.7890161723689655, -6.316940353021393, -6.336796656708207, -6.555389052024896, -6.419241152496337, -6.483003838354605, -5.887594812772902, -6.14130179645113},
    {-6.3059861593950375, -5.919434225108159, -6.69080794630653, -6.452165277849252, -5.5379890347831715, -6.176715232609987, -5.968377148280886, -6.295298313888296, -6.360205260221924, -5.981859968097206, -6.40010808556032, -5.466207952140129},
    {-6.298251335055889, -5.195740607225576, -6.220444602478104, -6.604935685728127, -6.411718544482748, -6.191500888123794, -6.393522212500275, -6.375713731594847, -6.318012759460329, -6.298199330458251, -5.200198730325235, -5.73382031397493}
};

static const float b2[12] = {-4.637065164675253, -6.706207654765852, -2.6713393379861152, -4.636803629436878, -4.818532713127137, -4.044949367863169, -4.505700536925866, -5.744464976880101, -4.721869218356938, -4.412934371361849, -4.425073311385363, -4.926561818267059};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
