#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.15751828402768533, -0.3836969483488545, 0.04722472597154318, 0.3488515135388117, 0.7472302113670074, -0.29587493567323275, 0.7909973001567794, -0.43027767639589726, -0.4248203786717939, -0.450165102949717, -0.3347615737512667, -0.7118750453626669, 0.23761910771065423, -0.5920707838002515, 0.5588279211293167, -0.4470352971629462, -0.28054787865619407, 0.03528676068691499, 0.14042578124123914, -0.1032942227116493, 0.26939210363149635, 0.3510786134589006, -0.43312802346631574, -0.6140665732039432, 0.03925838551676336, -0.16651084448903042, 0.5668061450072357, 0.3222713791348274, -0.09025453141927212, 0.20805980755791312, -0.30022960625519735, -0.17912878289906192, -0.4967412066502906, -0.07353045229717271, 0.19632062909914616, -0.45504250801833646, 0.7187807046566902, 0.33861747460707337, 0.032532757967823775, 0.02536977443725952, 0.48678065526026065, 0.3907978654605411, -0.13051890827167642, -0.006895108256256311, 0.020578300327616025, 0.45409268870034847, -0.4561897457431297, 0.40894487067546004, 0.13512539181353495, 0.5697019244976756, -0.6602677451233937, 0.3540799637603008, 0.033789959793579724, -0.3337060264531812, -0.17550598919018, 0.18781932014508712, -0.30351543887078714, -0.23957156055190976, -0.5511026859984224, 0.28345807844673204, -0.43464245825461406, -0.6287019680449082, -0.28292762063987886, -0.1270938180214464},
    {0.7634000147172231, 0.3364503095333511, -0.36736582661444833, 0.498309513623841, 0.6621283911665068, 0.0979753823871366, 0.4559604659424192, -0.7044543666252282, -0.45383842021111115, 0.3102607385817571, -0.7284667913134831, -0.5676933499967077, 0.5695005758947671, -0.4149883810746412, 0.6469469593375801, -0.20984266749897582, -0.4839153896331563, 0.4704763290925314, 0.6201698416159869, 0.09986027857921181, 0.6066095454005884, 0.6478959612891066, -0.5679008546978831, -0.31252810858373103, 0.2781040696203107, -0.3015383627534843, 0.7501890461008337, 0.6893246473426413, 0.021840809186845337, 0.3342770388114733, 0.08514567818102742, 0.09324084534355387, -0.6912462461511455, 0.10536620405520421, 0.5005907649104854, -0.8139672564099462, 0.503090578845684, 0.6165846076329133, 0.213037178567084, 0.4640980454235598, 0.4373079962880704, 0.21503046774650267, -0.22645776094670897, 0.14899978528930166, 0.5925481410988009, 0.5982000417329525, -0.5614998186105246, 0.48411660618119007, 0.6996720292198729, 0.6284630312961788, -0.5593699615893108, 0.4336851658752584, 0.4471950841387606, -0.3012696675228328, -0.16382233545406225, 0.6827791576414501, -0.41756182215567383, 0.15552319038178458, -0.6902614436759905, 0.29038312701789726, -0.1874526766870921, -0.5795720797434752, 0.24667578862147702, 0.20697716418343332},
    {0.561687174889212, 0.07497834883524236, -0.40567901192110334, 0.8880014478195724, 0.9101064907945314, 0.2024677405984797, 0.43618269005366644, -0.714055316426498, 0.09958685773003027, 0.4091200529321209, -0.2990954009609393, -0.7672522950383736, 0.587048008379357, -0.5247343711733671, 0.7404327822375341, -0.2765217099970796, -0.27165787348331205, 0.5529763241033806, 0.7076543858910569, -0.1832247622611946, 0.6852275781660774, 0.584854151659264, -0.6388652387280777, -0.7247382351297397, 0.7680461510122816, -0.011714973744152644, 0.7694859076332469, 0.8677048254266791, -0.038918289521701684, 0.7702523338870872, -0.1997551309281828, -0.0952990793926508, -0.5224800974112573, -0.19404657291009875, 0.6443216971583288, -0.6508774132654118, 0.8113259430071339, 0.5860259166201294, 0.20048082579123713, 0.7132834998098166, 0.09557122699209396, 0.559801405562132, -0.01510253342894276, 0.07952381250355166, 0.5371953364921442, 0.48331047382935516, -0.5798773727609712, 0.8378118304550317, 0.5792971307561587, 0.7270230146857976, -0.42160441617238675, 0.727034705155613, 0.38588496976148373, -0.0615860403748809, -0.12719543494277888, 0.5609470670229574, -0.40598188253867995, 0.0868672400400762, -0.6325980125568141, 0.42583455171429535, -0.38512223516961064, -0.6860039544859732, -0.14156586823230502, 0.16311528252292465},
    {0.6011916138383964, -0.47521660833752377, -0.44569008573853003, 0.5952392006065634, 0.8364455594424834, -0.6662850023427878, 0.6567014150950784, -0.8525519901600671, -0.4034919683815265, -0.07345338613648308, -0.7084876682068275, -0.7553734799699208, 0.5456786890323083, -0.6552239120209287, 0.8665486494018765, -0.6509230756947638, -0.9008769354095806, 0.2924844814013671, 0.2842727548505726, -0.6417893465770238, 0.4724527215937371, 0.5001778617566037, -0.7363388559949349, -0.6793459919797051, 0.3938395258765104, -0.6366236088261683, 0.6818543086962972, 0.4218579304753136, -0.717048333471182, 0.4609266682342675, -0.5755171262511027, -0.5848028396512847, -0.725851089931644, -0.5626757948402944, 0.29072833874515563, -0.6187556180556791, 0.8249789854496097, 0.4627341021924275, -0.5426567951314586, 0.24170144216007952, -0.49983575523285395, 0.2876343566660089, -0.5074456635786052, -0.04344903774707062, 0.43261532229220645, 0.6979601919216537, -0.5824621775430239, 0.5913715894200973, 0.49938317144860045, 0.5773968620968366, -0.6329465660975807, 0.6873971369113349, -0.31502287419481456, -0.5215921337223018, -0.6370014004772077, 0.5562428243434255, -0.7794865013759653, -0.2243075818517542, -0.531511050659763, 0.5663333939131295, -0.6716015227955424, -0.8468103355242559, -0.5119784954723905, -0.29685747328004153},
    {0.6377095781746412, -0.5781410811335166, -0.5802448055502908, 0.6580401734720726, 0.6996385791416587, -0.4385579325189426, 0.332963387109864, -0.9155226413780501, -0.47858124980327255, -0.21319818392007592, -0.6355616538541597, -0.8088893819922913, 0.36395988294203285, -0.7059387806747751, 0.8524868551208777, -0.670992002484106, -0.8350040383947189, -0.1262490317868023, 0.413622368736411, -0.7921811686641776, 0.4269853484006619, 0.5851018629935649, -0.7228909335351226, -0.5653256172685546, 0.47787542013871503, -0.3841567723341334, 0.8123065765152726, 0.498495514782164, -0.5915100122750188, 0.3960633135640513, -0.6273227883135403, -0.5704850911492383, -0.7508056342919841, -0.7431456465592752, 0.44649070584301587, -0.733448834458788, 0.7962958740887993, 0.24901271011064563, -0.2699444132064459, 0.4005776057797549, -0.5772413470429947, 0.5710993241640067, -0.7154916785195984, -0.44862391815098146, 0.6918562678889953, 0.49676618295793834, -0.5381695979611908, 0.6116422844763582, 0.41424959162871516, 0.7841693142480896, -0.5336731020990519, 0.4578279499995628, -0.5896888962911225, -0.5784382074556246, -0.4480347095513793, 0.5272469661923195, -0.858116550380505, -0.19679093029545552, -0.819803282469942, 0.2529298620409474, -0.5050484525023831, -0.9289547504478887, -0.8564693851804334, -0.14023738808353173},
    {0.5036636279878038, -0.5117930355269812, -0.4859893498029186, 0.628108916487912, 0.5348281933797799, -0.6425440592189855, 0.5675877717153486, -0.8336338121545547, -0.22866055005678915, -0.23687595940368258, -0.38503115092135043, -0.8852127608538887, 0.2502802951019474, -0.598969463683483, 0.7494936232466114, -0.7804564375095265, -0.7369347439923757, -0.1657180375526396, 0.5093451916783567, -0.4435715555546951, 0.34883911122932293, 0.5317558138851375, -0.8960434842567442, -0.8544165223256778, 0.1604621283263176, -0.3851027075789037, 0.6908677490012685, 0.49940768997048424, -0.8140947618103126, 0.5534468194107265, -0.6478925780118056, -0.6525902831556719, -0.794516571771471, -0.806890346247888, 0.6488365657237124, -0.8324863124798262, 0.7282169192403634, 0.2808638928932679, -0.026824382123660926, 0.29272794819733117, -0.7753799469656505, 0.4469772867890751, -0.5078979746658708, -0.18665771976403225, 0.49687624749138415, 0.6274470319553493, -0.7875391717734602, 0.6025288493805494, 0.5278241730638319, 0.7453629322292323, -0.7941774022856085, 0.47642659723547226, -0.7471473241620277, -0.5972714665126632, -0.6332199471376603, 0.4605429209068282, -0.8405635871062473, -0.1511738730066202, -0.5649532465691527, 0.5709644030659107, -0.8247748460597344, -0.9078069761092905, -0.7734977967115916, -0.30470398536433463},
    {0.4043837260814034, -0.36481714648812297, -0.4713189164141666, 0.38829792393961227, 0.5213739226547964, -0.552709211707885, 0.26874752828237386, -0.7216196795816374, -0.2220982177963273, 0.07733501208977082, -0.3700972327052825, -0.5495623337616172, 0.365576676545256, -0.7526023765056566, 0.6273909738707004, -0.6287657363144595, -0.639587928633305, -0.1510540116943616, 0.4224524910914446, -0.5563108696514123, 0.42263467876011424, 0.5915749338084944, -0.7151690834845017, -0.6273940872236405, 0.37949993944261784, -0.26270347604700867, 0.5654034644268966, 0.6369682262048151, -0.5018461299040159, 0.2808167119318937, -0.6161797656913759, -0.5474902274662944, -0.8054948858395877, -0.681568121588349, 0.6916175983514209, -0.8502490398958286, 0.41053608526351, -0.020847413116566484, -0.03749945494654033, 0.3582035247063891, -0.7425538501203426, 0.4856066899773013, -0.6675274558517882, -0.4286642254611385, 0.6768244054560716, 0.33767358819044657, -0.6114648338174404, 0.5970807228623485, 0.2850213955017242, 0.4874000012173883, -0.6280545433119625, 0.5957896946662351, -0.6713434650171796, -0.3001338069647535, -0.38616366910461086, 0.35314779726891754, -0.7887196970523841, -0.14406622277267606, -0.6608384303348548, 0.5319388493510259, -0.5617795928471055, -0.8329867695166587, -0.5662312683429508, -0.3132858352582002},
    {0.4151771789497114, -0.40544771475405866, -0.3364950330720775, 0.49086933067611427, 0.34778233985650503, -0.7093261004458912, 0.25860540160142786, -0.6778630792992751, -0.3655214750957857, 0.037243885067604066, -0.6122125210796238, -0.6430794725624673, 0.3362332321162585, -0.6107041354641313, 0.4616012180720752, -0.5512121831459073, -0.660920276087916, -0.12472949948747468, 0.11536621489418533, -0.6270426634794309, 0.27196690367280857, 0.3579798654990687, -0.8381792382733126, -0.9044215334903307, 0.04386190595879936, -0.38874399813306904, 0.5725283007491974, 0.3558726490274609, -0.8894200763052452, 0.4284171604195953, -0.46740949259550885, -0.5886322257535191, -0.7753150385789308, -0.8955243369633491, 0.5437277275339093, -0.6275197902650603, 0.4360430234581347, 0.04077861355932507, -0.39223563165706804, 0.3621846658271147, -0.49455492373613935, 0.2734763295360486, -0.7701190285957626, -0.36497448061689614, 0.3684402498611433, 0.5434513931689329, -0.8507405200285006, 0.6429299214886601, 0.5275906561111218, 0.5331319045078697, -0.8529320813480497, 0.3012958455091687, -0.7291119471082, -0.7243862967822099, -0.6766708980239575, 0.4512821319270747, -0.649292365804747, -0.08867610683151328, -0.8999119733377839, 0.4749121645293322, -0.8179219925943138, -0.793670475575073, -0.5722351924075009, -0.3983964574538394},
    {0.5365419380288124, -0.38956888821327434, -0.4941467037737326, 0.35682066793584627, 0.4578953244061852, -0.6570451553036832, 0.49857832747803, -0.6163975774586425, -0.504576808270343, -0.27615595319504155, -0.45304394349604, -0.5782771499168229, 0.1511327644413182, -0.6213357364073931, 0.5422287269376851, -0.8501365559784757, -0.6640898497962088, -0.04130760088959917, 0.10972846776744993, -0.5313014240336255, 0.32280327709313195, 0.7117596363903326, -0.9605513101000765, -0.8081811596928747, 0.0828218997177821, -0.5211513168746067, 0.6414937948946922, 0.5480590394809837, -0.7549715399611291, 0.1874231766280684, -0.659960119359898, -0.6637365065018365, -0.7497556535227872, -0.7880715632376623, 0.3492123700180276, -0.6284961998636863, 0.5120150119728314, 0.031751020812431884, -0.49861556161359183, 0.05805659044188128, -0.7363718144026982, 0.3019974464351633, -0.5095124777895632, -0.4334833646891721, 0.3911463530613105, 0.3884330018920156, -0.8218230173972927, 0.6157031949888054, 0.4336409012773372, 0.6491456236772909, -0.8065791733398999, 0.6459629842036679, -0.6807688861485182, -0.4587557663014388, -0.843992557563335, 0.30250389740467726, -0.5774351187339841, -0.2259107645845605, -0.7054831636016877, 0.5165881413233371, -0.7996997917749903, -0.8705411210559943, -0.7552541892995577, -0.5542208499970174},
    {0.708949031943692, -0.21197154520562753, -0.4361189028870546, 0.41826701191531734, 0.7058844428498255, -0.4415184456810991, 0.35137113017340155, -0.9558827578117286, -0.49856609990558426, 0.05729499196658846, -0.6256997224942836, -0.8694698273923871, 0.4607505656399051, -0.682618576677751, 0.6357828486153682, -0.6603740296524729, -0.6885791972296426, 0.3080248671352375, 0.2986926795127088, -0.5067762371914792, 0.24789979826289765, 0.5300082175707704, -0.7705489863768226, -0.6503917140034708, 0.12205482020381572, -0.5491119542930659, 0.6275204972858327, 0.5896644591966387, -0.7609567111701595, 0.5442579475701006, -0.4135492604664704, -0.6253574286074515, -0.9075851632150634, -0.5924528892310273, 0.3618554514628352, -0.7903464062008628, 0.48990067807780374, 0.08388422929341187, -0.6884372207473607, 0.46325161208191784, -0.6150027321481566, 0.5496135151028922, -0.6162538008403868, -0.16685536442707516, 0.40292912481367205, 0.564310043728008, -0.6438288404031137, 0.7678624269412841, 0.42331605884214935, 0.7611425600237708, -0.8863773383878155, 0.6270824407048682, -0.4159702116182251, -0.4776751314013052, -0.5359616868836136, 0.38590904198632403, -0.8666576736269475, -0.2140715283213114, -0.6984022830419993, 0.5044832316273952, -0.6720777780448719, -0.9517266869227793, -0.7446064853012343, -0.4316546944056108},
    {0.4442810380391788, -0.2932565077617192, -0.4209339890544258, 0.5168825438712251, 0.4867324838850379, -0.49384146642854665, 0.1509069417420626, -0.9001488284739425, -0.7613512226330716, -0.26837564594465935, -0.5526254690925315, -0.762392509199546, 0.3664373229440558, -0.6875511371830293, 0.537158509546897, -0.7544230209707324, -0.8640801501012407, 0.0934546292837227, 0.24718114923211817, -0.5141365781963549, 0.29558248549847255, 0.334245992910308, -0.9159547159575315, -0.7372437362920596, 0.036107404657752314, -0.5677288355945751, 0.6102477087299486, 0.547069516368752, -0.5777286481302077, 0.08605218144527958, -0.473992424777124, -0.6368429497853739, -0.7591720926486079, -0.8147408452267552, 0.06991322757043121, -0.9470146592206673, 0.616807653126144, 0.04007419201569737, -0.5129852162061109, 0.14921349164240222, -0.4342889105690739, 0.029043923271446653, -0.8620496505754106, -0.20828027835409993, 0.423728426222772, 0.5084681416012621, -0.7075221559859205, 0.5909518227709709, 0.4441070137024745, 0.6607642356476426, -0.5367506054265724, 0.2644677855450394, -0.4610003626531802, -0.46340190210626586, -0.5618766977790928, 0.5226071232585016, -0.8717318002602779, -0.18784081882067363, -0.8122972397760376, 0.2178369165472359, -0.8301941867711398, -0.7586617906799988, -0.7612158709801653, -0.24834158578257115},
    {0.2708753743164647, -0.42378885418949586, -0.6966727016948735, 0.3708364303773838, 0.31800756852085027, -0.6023604485711691, -0.12994984229002401, -0.8628643458520757, -0.5133557131985503, -0.3052709262261765, -0.5270932340723496, -0.6576853148205, 0.13408518063920388, -0.7787674166067976, 0.17549467305675445, -0.7341843425790152, -0.727337136171166, -0.11351816467901989, 0.13994075499292885, -0.6085554065625365, -0.06506912898430212, 0.32379536306224665, -0.7612415612260702, -0.5510009889713302, 0.009711021005383237, -0.7529547997195364, 0.5476005742182675, 0.46455276684935654, -0.8069692645655079, 0.12248717815688549, -0.434140279002805, -0.444032755797241, -0.5979058315118845, -0.646246801043008, 0.0768395223321281, -0.6214866997261917, 0.44432857714098717, -0.01915115471873625, -0.7520266148773219, 0.21135797253857777, -0.5522761838165771, 0.11117381429239195, -0.7970601105060281, -0.1891085010106728, 0.08918668777857389, 0.32579369545913245, -0.840676328934691, 0.3353854266362978, 0.11040862566701576, 0.33943276970028946, -0.526374368774489, 0.13670767587916988, -0.549593497182096, -0.7617431003711127, -0.7991395183010044, 0.23723224229263115, -0.7026452235810225, -0.021130173597312948, -0.8307353175825756, 0.2527182644891037, -0.5770841540650337, -0.758220078023298, -0.678312059588094, -0.27882885809132507},
    {0.42696902714409796, -0.2719783590530428, -0.7097952195295114, 0.368812512700819, 0.5778073326303215, -0.6032627583497274, 0.013663280732342286, -0.8550375886524377, -0.7526341224570385, 0.0003538999783746943, -0.7066040285793036, -0.6675466960161064, 0.37673600110239397, -0.6683943813744803, 0.26435642064391646, -0.5229659655773592, -0.7854196651762007, 0.09754348836432487, 0.26922576791558267, -0.4891833677498927, 0.0642554928303819, 0.44640957047909796, -0.8148778729050923, -0.7808489511483242, -0.05359953057508802, -0.463506811226487, 0.61854423837543, 0.3258476231497093, -0.8330681099826891, 0.5413447978457937, -0.22397677503561592, -0.5790755111411557, -0.7410275548441488, -0.4636949230249912, 0.1418462324887093, -0.840889056144637, 0.5641380833263401, 0.04298581512453821, -0.6252009997175052, 0.41658168908732407, -0.6877316564405039, 0.20705975246281533, -0.7380235123308555, -0.09790052061841192, 0.41128335310602127, 0.6272969378886758, -0.8656848949774952, 0.4751795188014108, 0.4826017579176781, 0.7057526677054542, -0.532025324756089, 0.41416919479989284, -0.5506041778665023, -0.6459534095861079, -0.401066242851831, 0.46775597947423414, -0.6237296120100823, 0.13789426933151322, -0.7541332836501309, 0.376177932153871, -0.7816240296263419, -0.837307957024418, -0.6255147613885697, -0.33439624205197555},
    {0.3399424894226945, -0.1973533164560546, -0.42573781853201464, 0.4906083153648719, 0.4130260790292902, -0.48541869631481144, 0.19773860228678328, -0.6751840446046421, -0.6424915465606187, 0.17819222501712897, -0.5891383176950121, -0.7883680375256356, 0.27901914088389007, -0.7849925137489105, 0.5002121966461407, -0.7147053929304272, -0.9147413321567572, 0.2892118213802961, 0.5201097390414406, -0.6363578210126052, 0.3466434016798219, 0.3994428013186349, -0.7072583895074251, -0.5384719539144317, 0.0848639102460665, -0.680559402385654, 0.7472476533734004, 0.32756974953426904, -0.6848981603048335, 0.5226599515453679, -0.1940575112766784, -0.5838830626365757, -0.7976421067215053, -0.7248042992581696, 0.1725968301644807, -0.9068954516561181, 0.5319152734403073, 0.2552149949520676, -0.6443390910067858, 0.2242295933345603, -0.5698676058915867, 0.4233948896842816, -0.8118028424092683, -0.2441596839137884, 0.4527018352811093, 0.5387834065929038, -0.6402709247878302, 0.5361139687933035, 0.3928063470526523, 0.3753408419048051, -0.7153968374099293, 0.25628433760414604, -0.545463472023925, -0.6332923311801216, -0.6988310452859128, 0.5758526471287426, -0.8063976926687068, -0.21301799361913146, -0.6535108608849839, 0.17843889809952046, -0.4258339371400658, -0.8490662088086209, -0.5761642473337265, -0.2868348019502162},
    {0.6135950009317372, -0.2713230817764102, -0.6214842938586407, 0.6175023368915686, 0.7807962520788492, -0.5191042047347897, 0.3132712913716853, -0.8633039397450128, -0.7475383492910298, 0.14922490730936513, -0.7875016448328103, -0.5934030691190536, 0.6548746403841946, -0.561294292761549, 0.7164870913121855, -0.5443290798919742, -0.7692653454681386, 0.3211503391594848, 0.5006898799732795, -0.7585713891937617, 0.5312835018139095, 0.722215347675594, -0.7352605069204999, -0.6892067638303652, 0.4442414803452422, -0.6458708560176021, 0.7223289839955764, 0.3799875424611919, -0.5977363881937975, 0.7114221329366732, -0.10477595060733555, -0.43152747851133044, -0.6609298345299103, -0.7675673860281024, 0.3804747483266099, -0.8595275732310995, 0.6865631301259675, 0.2887148445392725, -0.35368562044477475, 0.2828064283991967, -0.5564263583887182, 0.35443490217472184, -0.5491075789824832, -0.045540169128357455, 0.3205775637379316, 0.36526290396177674, -0.7234459297051229, 0.7963606005754224, 0.33931643172723847, 0.6109050910289836, -0.6567351457492041, 0.6596616698531476, -0.4127123825221047, -0.6028309371216398, -0.41955405348575414, 0.5778649768569342, -0.6084707260058654, 0.3146279769608244, -0.6989095137658767, 0.596591218251021, -0.6973420315151072, -0.6762199817277647, -0.4777767602034667, -0.11019575635353233},
    {0.4822698417456603, 0.0769411563258484, -0.7103835885423851, 0.7861295588978542, 0.5270905583491559, -0.2599672009597558, 0.2492770886318172, -0.8433757312235738, -0.6383392839028571, 0.16429374167245264, -0.4952928411233596, -0.8414666208578434, 0.3909299026486992, -0.5742166357450169, 0.8133121237718789, -0.605500558313822, -0.8835001711362873, 0.3164509826313375, 0.6297111217376181, -0.7915371083707284, 0.3622629290898281, 0.5503979702018109, -0.9173538211749853, -0.9057842018232175, 0.5371479960184283, -0.5325084065333686, 0.5240084407076319, 0.7629151021821644, -0.6142500195677494, 0.3779054637919745, -0.026931734376940266, -0.361868305630995, -0.6434695144862581, -0.6780078093283519, 0.6199570034308836, -0.6824182474364264, 0.791883556610473, 0.32848269568269706, -0.5242607306000726, 0.42785463746959623, -0.6879364823832373, 0.5229798119597112, -0.7426726189529349, -0.011777210369460858, 0.4555157038223533, 0.42962171145412714, -0.8355586173663059, 0.491288870594028, 0.5038639581737815, 0.5561151831353822, -0.620086875404123, 0.7086109114289185, -0.5175125096694135, -0.38559113176834336, -0.46647683319952377, 0.6085159504050996, -0.5350701114462965, 0.29992994858390937, -0.7225549846043019, 0.6479535024449282, -0.45164155887924357, -0.7705323980457914, -0.6624821718526598, -0.08582553202633614},
    {0.69087870992789, -0.2077259651983723, -0.42703098880366996, 0.8981041021847199, 0.595633900747501, -0.14924293423820884, 0.4560095169356393, -0.6377337355971419, -0.5420861995903301, 0.40478178216023863, -0.5028326320602985, -0.6384823676363143, 0.6580489600408447, -0.616476181039622, 0.6284964576098265, -0.7015047454147691, -0.9355263687282062, 0.4634236810311659, 0.6394998495483429, -0.6790544542995682, 0.5423135898794479, 0.7723425479949894, -0.6662466251815984, -0.8369906052990557, 0.40534410381636954, -0.5737231949517559, 0.7994177232390305, 0.46081940435672164, -0.7227753840256167, 0.43842857194108986, -0.26123506834249216, -0.4982142498702613, -0.8108272863748361, -0.7079118375253078, 0.472114194091056, -0.7007996646213137, 0.80010957819408, 0.5258343701736228, -0.2982548355271724, 0.43351817642219176, -0.566102761745019, 0.5858978889501305, -0.7422259725102072, 0.13751444522940104, 0.5796110842637929, 0.6286071018631995, -0.6694990006299141, 0.5578870826986061, 0.48620120291807223, 0.601487434880583, -0.7108986801902109, 0.7927809652859961, -0.34424561522285974, -0.40379327895667866, -0.6669045236860642, 0.372939512051787, -0.6963893850725509, 0.2505819143569178, -0.8126062671061643, 0.42390340040434404, -0.6946776173833146, -0.7726138819092336, -0.544843593982644, 0.005306298631211719},
    {0.5286452008439213, 0.025010110762224244, -0.3057412373402809, 0.8966172757936272, 0.797826296685138, -0.3128698654032507, 0.7926727160429596, -0.6643565809825284, -0.4068487595669245, 0.21544051666312483, -0.7650048133356508, -0.6288219439912245, 0.6096762949622425, -0.6312463697463307, 0.9040140611756907, -0.3712423997758782, -0.8221963733161334, 0.3707143795301789, 0.7955689961772144, -0.6523456035074277, 0.38281115866386256, 0.6718336213554893, -0.6633438626608785, -0.8279216014174144, 0.7022271739203437, -0.5921395889075003, 0.6201768377984862, 0.8304004321888576, -0.6457812991465749, 0.782388663187118, -0.2658951986860786, -0.18461773779551893, -0.362338016697897, -0.6637720643361626, 0.3885602337664855, -0.47123715878814776, 0.814575086823889, 0.6738425132301009, -0.22847110091502637, 0.7139222096290043, -0.15137458665058026, 0.7900200283996406, -0.3948376419471421, 0.06054060663894779, 0.7156311399106019, 0.6425826507976552, -0.7438805953980002, 0.853573390370128, 0.5822631907483002, 0.7424294227008487, -0.430809406548374, 0.7631684002082288, -0.3173148309120157, -0.32928724717879215, -0.5408724871028519, 0.6171557678995946, -0.7546074906012339, 0.1915296951438991, -0.5784918178245555, 0.6286270073740337, -0.3156001471885988, -0.8558077967286969, -0.4569206511523893, 0.03224659259298984},
    {0.4922006645275059, 0.0037343118468817207, -0.3619907934493279, 0.6928221423257231, 0.8420769769297136, -0.07471671521258363, 0.7472764735036178, -0.6914279948837949, -0.49396806587583986, 0.3350277789926051, -0.7210097020042192, -0.5229237112651324, 0.5277878908318822, -0.3818959369572112, 0.8444653211927995, -0.5049188465679858, -0.6811911647921275, 0.32439580659564055, 0.7314792359986705, -0.5459072466322634, 0.42608130795918353, 0.6085992849594951, -0.5333803798324418, -0.8198433368931014, 0.41187875732050533, -0.5550292138706916, 0.6717030346102189, 0.7620488050994522, -0.6279476186041019, 0.7385446557243843, -0.416659106112514, -0.21921308341215634, -0.45650653214684433, -0.6050808497000019, 0.29119289820445265, -0.4654042284657582, 0.776131997660527, 0.3361367629665824, -0.08067044098988478, 0.3591997902707154, -0.41547192737856337, 0.5300597567117564, -0.4341630425375926, -0.07136668954636448, 0.5719032280617383, 0.7579098937626563, -0.6751842782376275, 0.7924915017145941, 0.61640861746367, 0.6043886043122288, -0.6078680877339128, 0.6031793495382193, -0.33572765907599705, -0.46946819229670184, -0.6051884043331923, 0.6335552724919118, -0.6932797741786687, 0.1119594017446541, -0.7050681764912944, 0.5540254076927772, -0.3897619085191685, -0.7645439598986155, -0.6854781921489475, -0.20642285512041375},
    {0.6020356880229216, -0.2749586673962678, -0.5040798976933368, 0.8072008663950908, 0.8701681055817865, -0.6113886418833411, 0.6895911317683855, -0.8692713989679206, -0.693314122901772, 0.16665134499568213, -0.43619439276002564, -0.6952973010207535, 0.493387023173731, -0.5040416574846727, 0.5971045182245251, -0.7819432307563972, -0.5658698643332929, 0.12114751518334478, 0.36292050177018187, -0.503082606686264, 0.33949296903485265, 0.42298114436731454, -0.794328299236769, -0.7870517727487809, 0.3831210142762188, -0.36307447509693724, 0.8953888003913096, 0.6472919316433715, -0.5559694994032751, 0.4261721288417014, -0.3469788265419204, -0.6683298107976668, -0.7896519518826502, -0.6901333711561125, 0.24171778646760428, -0.6078385850167967, 0.7747162606614314, 0.4403704465106539, -0.2501183566279173, 0.5203498440076022, -0.3915870917847237, 0.5914636359202482, -0.7486360692462561, 0.058937789359271145, 0.38204272783527193, 0.7528390897137992, -0.5503007099177085, 0.6839288436294568, 0.6940076651665542, 0.6014215590540012, -0.6721160352252942, 0.5165479632824216, -0.40296544323210953, -0.38697013737408514, -0.5742830474670324, 0.3228205621788985, -0.6059565513018635, -0.15683082154393568, -0.6365253440372386, 0.3260557199939975, -0.44431633390208425, -0.722735290504406, -0.5940716765915235, -0.19537503533968745},
    {0.6366865759160725, -0.16949351851223485, -0.7331806949253282, 0.6280307907533853, 0.8043528954279686, -0.4514611307276735, 0.4215901494073144, -0.5773782523884367, -0.6052020724700732, 0.24268340222454768, -0.5397024050134595, -0.8576706489225331, 0.6660549020903582, -0.5536631956312877, 0.742420898258479, -0.6159675995069812, -0.7938828051785177, 0.2226491463485705, 0.6216946230981328, -0.6714882158604102, 0.37674997755795503, 0.5934769583888438, -0.8578767675175966, -0.8394335025738182, 0.4852138281285003, -0.45619831667239635, 0.6241853301164259, 0.7003976780169054, -0.7675869155684248, 0.6410303067301404, -0.31710038900400156, -0.44865723073746033, -0.9143793673331029, -0.5283640689126841, 0.31188853938900196, -0.6272114656956393, 0.8611863439001174, 0.3994750149943049, -0.2984608593722253, 0.3763953406923748, -0.3372812460489282, 0.5740786359260385, -0.5208639172828461, -0.1455054904517686, 0.4565197992570432, 0.7629956420023798, -0.818901882908702, 0.5581068301103329, 0.38569524257285853, 0.5568556372387112, -0.5789678315266821, 0.5344439125781281, -0.32488725301408683, -0.577732802162547, -0.5203275032035548, 0.5406135802930736, -0.7780748853373525, 0.009288940706029633, -0.8029526207130858, 0.25755929258349075, -0.3910557949169133, -0.6386768542862266, -0.5094937962376311, -0.06622891990494982},
    {0.4996563858009457, -0.1380370404496095, -0.6534735680957937, 0.68177186809887, 0.6745874643179639, -0.27158959734215193, 0.8003360669736418, -0.8001521389546119, -0.36295486111656683, 0.24592154289792523, -0.7656915485386359, -0.6404856759103245, 0.5951065235670533, -0.6308898061026368, 0.6387617492604099, -0.3635688832711222, -0.6526409506713756, 0.40749803823574166, 0.6086711151041349, -0.5130640404877479, 0.5188206907272614, 0.49484929035253955, -0.8669190155815137, -0.526921180809662, 0.6526982279643485, -0.4315407347959679, 0.7575213518232645, 0.6097738434895303, -0.6269763927130284, 0.6589229916310615, 0.06246404117375553, -0.4532411479394589, -0.6550326036529033, -0.3856539174384551, 0.5330906818774762, -0.7552532001137763, 0.7371341929191337, 0.40236194210257964, -0.26882476979038106, 0.6764128932217552, -0.312443051663871, 0.5041778459757252, -0.6421407890512639, 0.061370039147599066, 0.6503934919483167, 0.576373298908646, -0.6795028371228033, 0.8089102856271715, 0.47910533746666834, 0.7664711124787625, -0.6822812532114568, 0.8630335652004987, -0.06206529519536506, -0.5002633812944084, -0.5437355274175901, 0.49079879089517403, -0.7912951581157889, 0.289693115680033, -0.49577001520629044, 0.5461595273191645, -0.28043595898976104, -0.7773359661872927, -0.5540907910257631, 0.02066237198900048},
    {0.4710860250597255, -0.11451866488240144, -0.3805602376526627, 0.8150474488354106, 0.6941546002622832, -0.34503615737831717, 0.7406076885360338, -0.516846715406367, -0.35284451529579886, 0.1707684802363244, -0.5103325044456554, -0.7551213955647178, 0.767996286501747, -0.29468723715871026, 0.6670076343327007, -0.2774222034559046, -0.3861069791358749, 0.48578815507422585, 0.6116946045854251, -0.27858783510335483, 0.6365788077731344, 0.504508739352052, -0.7038425154526887, -0.6593255172396822, 0.6425147601815829, -0.5987786574517685, 0.7027138123922508, 0.7111205534722244, -0.540445801535809, 0.463215177524693, -0.0656604548105883, -0.3154195888911662, -0.47998904570933176, -0.4009266303950226, 0.460102056907498, -0.4631113332689686, 0.8809093832919016, 0.4505646086531307, -0.22377952580257596, 0.6382176093262923, -0.091598845984228, 0.4380372273457049, -0.4561234806941893, 0.1816228227936977, 0.657041452351062, 0.5818006538470907, -0.5584353661709489, 0.7432263096670335, 0.5497418698197674, 0.848277593961615, -0.7014793617654841, 0.8583874690073159, -0.04668387229890528, -0.6403246033493833, -0.4167436665416296, 0.6449342381345767, -0.5168082020653573, 0.30360073241337454, -0.48935459600790127, 0.45437059650806383, -0.37095706360356845, -0.7684101830372384, -0.2036651601608426, 0.055452388473489364},
    {0.7519092595089358, 0.10811453706414045, -0.5366914816791997, 0.7843880781379986, 0.9195190387141912, -0.3018225499356866, 0.6307997938805272, -0.6522450251269785, -0.6809592283731296, 0.07068558265049563, -0.476569893957325, -0.7136663403725326, 0.7553289890266076, -0.3787212283634733, 0.667394864201724, -0.5051887855532249, -0.7077487207894662, 0.44741984410586844, 0.4945908538042818, -0.3830181190177881, 0.5813737952335418, 0.7019532256718566, -0.6086429700614008, -0.7614888550893114, 0.3151812629678282, -0.7272136181369847, 0.8327888493626738, 0.7809097383991022, -0.6033563648908813, 0.5497997850753549, 0.01269868950072034, -0.30933294381460874, -0.5076204423535383, -0.5645786462490714, 0.28322940322038204, -0.6942636908948998, 0.7681550067073184, 0.39423773498750075, -0.3697381545070789, 0.6474012200550628, -0.27308482367570924, 0.7086255311253198, -0.3734211424489984, 0.028553062897506146, 0.47829704576556953, 0.5869015275053074, -0.7522029749695774, 0.6186810065801698, 0.4488439437004425, 0.6494414584706444, -0.448600696557843, 0.7795922596709721, -0.21727376816708774, -0.596064315403262, -0.5819305447295563, 0.5087449237635876, -0.444925630985058, 0.18831911699771858, -0.8423248307800724, 0.6301155390242696, -0.4067592686609003, -0.8126920041493181, -0.5787018971679229, -0.11179468557211468},
    {0.6117146161466304, 0.10549320283794988, -0.6753908738484433, 0.6858609911216517, 0.7183988778795194, -0.12647511030058348, 0.3368782712150052, -0.6976730168349953, -0.7603308634705271, 0.2060364392133934, -0.781930836433885, -0.6795601894775322, 0.6951454108085163, -0.7364129967182291, 0.6661748082497989, -0.5310286116890661, -0.6691578622067523, 0.5856002074893368, 0.40668115162125634, -0.6268269139187597, 0.5025799855965153, 0.41830846140706857, -0.7339340402928234, -0.6068688316828211, 0.3382091285324865, -0.6408385284537861, 0.826324630140339, 0.7359880603250455, -0.713672045499676, 0.6071172997383314, -0.06022670109568999, -0.4236665456769844, -0.6820698532093733, -0.7138539970772921, 0.41519810435050764, -0.6849545944111521, 0.8777169108488252, 0.5774745464090246, -0.5059756157281936, 0.5098885825780288, -0.38040591592080114, 0.33292655533625615, -0.47697329105382036, 0.21437588076265993, 0.4590965573983804, 0.6209217376304217, -0.6555351316369807, 0.8119825403899851, 0.7359195524029123, 0.7461239999745469, -0.5135247418178762, 0.45294344305139095, -0.43612903622030613, -0.680729033235107, -0.4154822231725861, 0.6919600414691235, -0.5979100991312637, 0.29566140928209317, -0.7665128695712321, 0.49904392966164574, -0.5229672597529166, -0.606181659326464, -0.4997372011989052, -0.059762223352211395},
    {0.42829274391734856, -0.06160242868800692, -0.6282049689784144, 0.6444223602474299, 0.8292022529835495, -0.20591155414293963, 0.5924263784260929, -0.7609337516518908, -0.4676881505709452, 0.09878039421370309, -0.6083142578035572, -0.55368775928455, 0.5630112572470084, -0.4315042103209321, 0.5311115976002355, -0.6244050850897556, -0.6665488111901278, 0.4542643474335713, 0.5021720725760228, -0.6850049230327641, 0.474897294765213, 0.581558317194162, -0.5461208994829191, -0.5092347731088641, 0.2515215252144177, -0.5309556312807451, 0.779768809400941, 0.5977630546656625, -0.6651625432346652, 0.7550795152246196, -0.14049273190137218, -0.5024833820062575, -0.7896643853715308, -0.4495274914000405, 0.5627639915098058, -0.5598541770615216, 0.8559903563966142, 0.5224184168171848, -0.5060558755747232, 0.6278857567151057, -0.2956018427134503, 0.5121957367359984, -0.3384566977228034, -0.12352744656626215, 0.76184330328833, 0.4827075682960745, -0.813314415618545, 0.7250852819319764, 0.7052132668564316, 0.8625776887449391, -0.5017423818052659, 0.5732635347274874, -0.10783981362914098, -0.7077190630076914, -0.26052590847549073, 0.39868740416975906, -0.5011436208900241, 0.08622046575556526, -0.4548389583218545, 0.575746251893409, -0.36087873940057963, -0.8830790684835794, -0.4958856059887455, 0.1534806556032618},
    {0.5348727146146717, -0.06686935490075162, -0.391255510318452, 0.8456876736642759, 0.882808536603029, 0.004928905298123203, 0.468453794484227, -0.8303723406099925, -0.43719219258160585, 0.4020224561286332, -0.7935144755615768, -0.6283143173988555, 0.43969821154993194, -0.697915493496886, 0.6939172432689061, -0.5905024795593525, -0.6811434220257836, 0.5791164988395089, 0.6500564258784637, -0.45059409718048105, 0.6509777974443781, 0.6416225355486219, -0.6916587288083674, -0.6795938913257643, 0.38556347916590683, -0.3387532047010105, 0.8180931776914686, 0.7926278690956102, -0.5476961674656027, 0.523413374829348, -0.04388611362529327, -0.11531343497083636, -0.7666682052266934, -0.59469793613075, 0.6292978582609703, -0.8158531099249466, 0.62802890819677, 0.45876338587572757, -0.32143382216508726, 0.5406644080570654, -0.19268509683902652, 0.48520316297257543, -0.6713452056619051, 0.2179032679859824, 0.8185428943607972, 0.8143067200852832, -0.6232969490571358, 0.7942329190339217, 0.5394753242743914, 0.6588399552593388, -0.5608435798351634, 0.5864054082740124, -0.26319452075304145, -0.5979900656356332, -0.3882267076792067, 0.5718014023357151, -0.49358970770962657, 0.08307833261213916, -0.5576380033861967, 0.5842370044896387, -0.4437146817601313, -0.8163552510141292, -0.4408731884795576, 0.17849962502311603},
    {0.58220630856551, -0.15620394844671, -0.7136219351393127, 0.9301721720750917, 0.7729764349304632, -0.4828039901383706, 0.6812130610375424, -0.8355906213034332, -0.4548080838737795, 0.02912108542028029, -0.6244345743896725, -0.6785145756043183, 0.5784906001270169, -0.7417784788170044, 0.8906433507387028, -0.500895258523725, -0.6322423357891155, 0.41237567162526784, 0.6445619168542192, -0.38914357895928187, 0.31428827195162884, 0.7755610484595526, -0.8472460235000651, -0.6930652077734895, 0.614603445550415, -0.5348563448946538, 0.8573974981713878, 0.7875091732172961, -0.5739940088189014, 0.6602731069094842, -0.1543581342856244, -0.47942252836209426, -0.584755038968511, -0.40861380582668066, 0.5270153418347001, -0.6250742332655853, 0.6778559148460741, 0.46008901954897957, -0.16375907285454086, 0.6451422306962099, -0.35846695356247665, 0.40602149859211134, -0.412408907651665, 0.13027155071645388, 0.7928447149801796, 0.6828373820145799, -0.8274369907736038, 0.8192066029353613, 0.6900338528114429, 0.6326112917933886, -0.4589599394256265, 0.8324267442061645, -0.15751402645026066, -0.5220290468390505, -0.39154271778237437, 0.7086815476635583, -0.7429006994974865, 0.17066383561996004, -0.5696585461652329, 0.30032204934258205, -0.3989085238659401, -0.8687831609342667, -0.6571223969190402, 0.11155447923714633},
    {0.5069028602367734, -0.1446067955600045, -0.6993594811267722, 0.6523394134669536, 0.8262261101082686, -0.38368847757108726, 0.4222010148959008, -0.6508602125323787, -0.7245477256077011, 0.39141847614581265, -0.5194864380522012, -0.6613440526211127, 0.5246925803222373, -0.4440613492418099, 0.805636239334815, -0.4789940257565773, -0.6363146833242423, 0.6410074629091386, 0.7229679965708661, -0.4321228624284149, 0.6104790843140315, 0.5842150177491048, -0.7279661526499991, -0.6135214512098127, 0.41756942108894696, -0.5534341614185421, 0.771799104861105, 0.8131648325423857, -0.533508773583573, 0.6675964031380315, -0.012009130514215304, -0.3602287769887797, -0.6385917335264137, -0.3173130388597452, 0.5520257729078002, -0.6805199477247251, 0.6067616671960112, 0.5230597109996887, -0.23050409598556845, 0.7545535481448099, -0.05556037495091203, 0.3174085972576391, -0.5809922812864201, -0.04909905066309716, 0.506880336328177, 0.7025249361709625, -0.8075201756990086, 0.7333588209806402, 0.8006537153051024, 0.9247297684750584, -0.5821635393519496, 0.7982812020379908, -0.28638377473395965, -0.7116866300094571, -0.33538965751224403, 0.6420776138830381, -0.719433881596127, 0.23090287722362807, -0.8159793442889641, 0.29819649399326215, -0.26205133245069984, -0.8647450189170814, -0.4191482327715828, 0.23152552888745062},
    {0.7973722173747091, -0.04322370724306781, -0.746819435165305, 0.8945341344135702, 0.8310342404587091, -0.21752086780862848, 0.4408721470723436, -0.7976639640002816, -0.5952343660734497, 0.3157216883491578, -0.8437762172291094, -0.581745516082595, 0.7229646138235503, -0.5019727568855352, 0.7069348482634353, -0.6793504471157289, -0.8676979639025074, 0.5462621048374623, 0.41443247688505014, -0.5043642872925936, 0.6705740188629036, 0.7583890455921888, -0.790839937934128, -0.6978335743567802, 0.6473776111350636, -0.5838954820736505, 0.8494670145525752, 0.7018274267854301, -0.6306717396049011, 0.7430646802340631, 0.014165772378232605, -0.44769715497887796, -0.8047782241736509, -0.4691948188092448, 0.47752711878957843, -0.7403024598667611, 0.8873613005438904, 0.6660816923795168, -0.4747920448251372, 0.6781697630928232, -0.14578888110789615, 0.5851344730271317, -0.4025499783637753, 0.3256825191750538, 0.7749989593256026, 0.8167520552441702, -0.7913365371358433, 0.5213635203330732, 0.45844247624380674, 0.9104891073640271, -0.7747832759692808, 0.8183118061539915, -0.1463586384455045, -0.7192527217408917, -0.42058804429464836, 0.4920170353170664, -0.7082737233932331, 0.38322052238059895, -0.6330233596029051, 0.2992905584248572, -0.294548163775107, -0.6101596870187462, -0.506566232410555, 0.18396153941856142},
    {-0.3149024393544998, -0.07758727681955933, 0.1844015476138075, -0.21985528834338672, -0.7322669425023506, 0.2286928815082313, -0.4172516890336703, 0.37728922396616593, 0.597565431610396, 0.12184375992426916, 0.5772505810345512, 0.4741774393570262, -0.46952748281924866, 0.19610149322922799, -0.1614151687121778, 0.18119046454092122, 0.6712728804607385, -0.6109354440971918, -0.07283789591077214, 0.2165768642004488, -0.2099603735758696, -0.5164564674464511, 0.5705815833480138, 0.5308468862815134, 0.04351434705834822, 0.3731256067014567, -0.37506727900150766, -0.6165503391924022, 0.17617609704909673, -0.40586398682115127, -0.08671835250514068, 0.5306119938113076, 0.3404433029272337, 0.29406864271900873, 0.028882693945728084, 0.4998662734587572, -0.5464396287095973, -0.6565278908950717, 0.20609699308930315, 0.12533033925826506, -0.3551989079427502, -0.19154752273365142, 0.5062519758435743, -0.16381979277356717, 0.011528876823707616, -0.21873939245294283, 0.6486059486174458, -0.662734881856639, 0.0056780169726829526, -0.6564742319365229, 0.2965172887780554, -0.6254433194555992, 0.3993095587174771, 0.46184412850208395, 0.3578450361898442, -0.6205373381839168, 0.6152699220346576, -0.16613106245691697, 0.2658481480418198, -0.3243040174135867, 0.49438207778928284, 0.41549273321399255, -0.0651072320034883, 0.2400116683411743},
    {0.16814201809797222, -0.4921244953988932, -0.35884968967209047, 0.07883769323367354, 0.4683643163562052, -0.6235792647858852, 0.339839666636798, -0.46031715103027754, -0.16761620057827303, -0.41417098455924706, -0.7341089889620961, -0.37830236308794, -0.0017886719157847672, -0.206419352567809, 0.37767760741167256, -0.3602027076199238, -0.4978786729328719, 0.021877401786933065, 0.2343493602474515, -0.068461193291322, -0.1368094691352431, 0.4935821514419126, -0.6004386182081564, -0.6053934586377546, 0.034951334595074074, -0.22504784760767546, 0.1611125997981567, 0.20195628320524694, -0.1536245753497827, -0.23179755823920872, -0.31912393373832076, -0.19241363386012172, -0.43616754192396245, -0.5883237032295011, 0.1367844057497754, -0.3638567391787519, 0.13373593595661876, 0.05552824207578685, -0.22228455827231705, -0.05266754910465142, 0.060765459396153854, 0.1742586499743255, -0.5503190614887851, -0.2499074160227163, -0.11932346389459504, 0.1191045751725371, -0.7125443486907106, 0.3888001264783403, -0.17378343988502815, 0.46666397354651507, -0.5128723345112925, 0.18384241801599, -0.19685118956594688, -0.560295905078369, -0.5623808674286574, 0.3679938875548777, -0.5855471312689555, -0.18141436270118605, -0.5859808659212435, -0.17185889331781512, -0.6470817939595193, -0.7318615199690393, -0.4437963167444047, -0.384022943686442},
    {-0.5312310511193085, -0.6578293435276032, 0.17491139272522135, -0.30266790633996027, -0.27575231729787586, -0.4146823607328581, -0.3330329377934256, -0.16840197826310505, 0.08931094532252, -0.5092341674352696, -0.15693553896063317, -0.3107312266504938, -0.6290048237916055, -0.37877856277229394, -0.4467159184120791, -0.46060905233258836, -0.31184814605734784, -0.6583740634701728, -0.5611162638270139, -0.6146170321236948, -0.5675026411856723, -0.024715368514087566, -0.11881789055087766, -0.2863424597168906, -0.45698092580824967, -0.14577282972681987, -0.5062778741729388, -0.7363877175339101, -0.3952801484369257, -0.2862144172745968, -0.38942165303494536, -0.4875609360463229, -0.10411736476890168, -0.6316628764256231, -0.33015867770363033, -0.2151433720556961, -0.5280398872871845, -0.6954676881375178, -0.49433588233686643, -0.6640964401933224, -0.5447923457299897, -0.28289842910585017, -0.5137154686870744, -0.2878510842433828, -0.22886264382191454, -0.47604437397052984, -0.1296831649461244, -0.1051114282581702, -0.5157160272866803, -0.5256258640130874, 0.026174372857303254, -0.29969872952136906, -0.44603628530635814, -0.0030967506478412066, -0.4669194490732667, -0.5557707907551765, -0.5519789946236113, -0.5971131997396449, -0.3248880326786321, -0.6147701350577283, -0.6599350769918105, -0.397751477468111, -0.4375142549042854, -0.39552185243708765},
    {-0.7773854690548452, -0.6651256792130559, -0.12347962007178775, -0.6569262357051948, -0.4392178804659736, -0.5699428809060435, -0.4166138105624976, -0.44451513425734135, -0.6328946849687863, -0.4581117792236247, -0.49146801568839343, -0.3660142897500544, -0.657319045249461, -0.3856505976105436, -0.4382076571519922, -0.6571033119251789, -0.4195056063048426, -0.33902055007580645, -0.4822609258371659, -0.6832080660486536, -0.4006635094772415, -0.15618373045913658, -0.3453145356399232, -0.4576447353513809, -0.6553635315214124, -0.33057286640197625, -0.6935172708742713, -0.5610395809959069, -0.4229901962840564, -0.4590446411788115, -0.4035571036119856, -0.3900883722229889, -0.45858968475706186, -0.6976431298028509, -0.5355708909953364, -0.3748150379814271, -0.3908479850018372, -0.4533814845606808, -0.68621780582338, -0.6232872510624766, -0.3486381024136654, -0.10004227908642477, -0.5603174849421625, -0.3710806197701812, -0.47422211447821455, -0.4685958272084451, -0.6792324503896445, -0.3462138669385218, -0.5726290789990178, -0.5063776168936764, -0.39929571952111825, -0.2964255644311529, -0.5081184229930349, -0.47416725412518385, -0.8088661924930917, -0.4954963946868627, -0.4908846554910089, -0.3626997694080423, -0.4435252303933835, -0.60918844461347, -0.7410382669215853, -0.29945744073743474, -0.5615356520190585, -0.7318733559330911},
    {-0.3854349155109754, -0.4483519624135113, -0.41635672881070185, 0.0249222601118059, -0.20389639277326982, -0.6667513537391978, 0.19809998688084224, -0.7110765875696574, -0.4305996392844948, -0.4428028624875315, -0.5933678107456488, -0.6344702093063832, -0.43296290316989894, -0.4001846083749101, 0.14409294524672203, -0.25796179954359094, -0.3832381135423401, -0.6714220193331717, -0.24603285124778146, -0.3369335425208714, -0.17329261658173042, 0.24572737475069598, -0.39541049069526696, -0.43554316904770385, -0.6266945818892689, -0.5089622585772766, -0.03380297433943207, -0.14739334853881728, -0.5053005750114989, -0.08070801825582408, -0.6881979932117698, -0.38306768624049575, -0.5045055805061758, -0.7099722140624063, -0.4334368955936261, -0.45720957087005143, -0.1817413006862926, -0.41266486001133157, -0.5637698014740465, -0.19232320167606062, -0.25159794122619294, 0.17674811849614486, -0.642210610288184, -0.4717160300011201, -0.045510443014728896, 0.022566323057172537, -0.6520275107435388, -0.15378727251281574, -0.32908160424161054, -0.15505688761451053, -0.5032912578983446, -0.33100254824304803, -0.5984407935572739, -0.43694605558714567, -0.7065810449787037, -0.06315675869763336, -0.3939545316420002, -0.35339370435438006, -0.3764774345288322, -0.28761074893223754, -0.7457997804242186, -0.752249132882745, -0.6631309012692046, -0.34228396098923014},
    {-0.39825500183665635, -0.38150678193106224, 0.12379934372351534, -0.10854372035054193, -0.07807456285232904, -0.6957897662620688, 0.00854271073887855, -0.6694816364361418, -0.07540502631023127, -0.7321281747122582, -0.3809850250438412, -0.31025637377572846, -0.5661898359851176, -0.7004160980499762, -0.23710704491020165, -0.21092201876503147, -0.6185414976756699, -0.5647149673817222, -0.4228847648358849, -0.48204251183173913, -0.5864661135936191, -0.023444008808618584, -0.3312902625815399, -0.69775928245043, -0.5616742162566127, -0.20466062477016497, -0.11095067814384971, -0.37361060200681784, -0.5120113509618065, -0.4147437101217237, -0.7347173374440367, -0.5773066360368755, -0.6748221277696986, -0.5935846918171765, -0.26581609848202237, -0.737104379596886, 0.06279824464341281, -0.5286169069594358, -0.2868509897137417, -0.5313706991942383, -0.39009439400513934, -0.1591497643603636, -0.24466284051688728, -0.6499293940869737, -0.4838582600265806, -0.43464876427871274, -0.41852838733811987, 0.0781288988667088, -0.1413206937618307, -0.1000865776397735, -0.4857199290430785, -0.33055642823294884, -0.70069303816873, -0.49176112290942037, -0.46795640300835706, -0.07010673448851028, -0.5713151669341661, -0.46349341105526665, -0.4628663408166282, -0.5706727256468752, -0.4650641149097679, -0.4151058097472752, -0.5275089269571659, -0.464471823023588},
    {-0.4568830224569348, -0.38510803847785524, -0.13360475441955197, -0.3236640863197078, -0.31777689275817883, -0.6645897624224251, 0.12241890864226225, -0.4471201578337541, -0.30152504931528745, -0.6997704201713297, -0.3617284370529804, -0.3496016527327006, -0.6345780564603389, -0.5669296664434224, 0.09039440459595946, -0.35091757142643965, -0.5982937525187935, -0.35565919406241236, -0.25943796794099333, -0.19275031435666387, -0.30369232258499357, 0.15818737663484117, -0.6453956409841252, -0.4707573766424273, -0.2774576685564518, -0.09697357213720809, -0.1297829399246627, -0.33860122681116844, -0.32625991679326904, -0.18546769036249047, -0.5156849380453147, -0.5591196676107482, -0.618301270375962, -0.5929160223708039, -0.3423676329912576, -0.6817629988714892, -0.008445573257497481, -0.5069349674064004, -0.31210415931129937, -0.4655756256759321, -0.3243776641204283, 0.1580842066437508, -0.34845934087974323, -0.31123241341616353, -0.3974253744144611, -0.18115767274564207, -0.23262663232984238, -0.39097784801972585, -0.4031589978509883, -0.31096097805415684, -0.43413315190821966, -0.18646583580283202, -0.7067262968536544, -0.16050506789372465, -0.7230684513979414, -0.4018110949975667, -0.5950065454577385, -0.43898774964544135, -0.5809980096341375, -0.4797691681995402, -0.7860330013544278, -0.6803410440353741, -0.5916677391752952, -0.5204948360995029},
    {-0.3973291812518836, -0.29772596193387624, -0.33614843970055774, -0.14544180804792814, -0.1357369022881733, -0.6505285556359648, -0.22566756525329942, -0.27171292328621366, -0.434481619506874, -0.5570065943839435, -0.3698032750481262, -0.4940784438963725, -0.5844265076186008, -0.44002765549355893, -0.08432285278225084, -0.37651654581092026, -0.5509890537491317, -0.658577145365857, -0.2670489755466361, -0.515173929038121, -0.28051460587421406, 0.13599546230657814, -0.5879294535848544, -0.6119873447650298, -0.30540867425552015, -0.0463169243692923, -0.0350536814304547, -0.20051482405219218, -0.5238140545468151, -0.11013721805159586, -0.6515289104118721, -0.3122616289000689, -0.3826317619151126, -0.6303229932722922, -0.5303151247968585, -0.6611368465758264, -0.20276355686022457, -0.3811987567446011, -0.5353988056672057, -0.434931632462743, -0.5605880194611969, 0.01194556668467562, -0.6550325146357293, -0.39691426114510114, -0.29336726134779934, -0.297446670324278, -0.39619182011311893, -0.27497573381868584, -0.5071311710297962, -0.09263083866457188, -0.36257986336021314, -0.14292948325714522, -0.6962059898016468, -0.39250604751282375, -0.39793946089307236, -0.29583647946228775, -0.6752899271975874, -0.32827700161386153, -0.7194627497491602, -0.7128804463405752, -0.7252698537884054, -0.4084224813514029, -0.6331473914577085, -0.7081563787808889},
    {-0.4733381325999332, -0.5396956323389314, -0.3249089968399681, -0.27514001677782646, -0.34511491945084954, -0.661711225328185, -0.13748252742488767, -0.6525246379989738, -0.18591738636119517, -0.6298898992792684, -0.29784734307943994, -0.3492390154228484, -0.3073168228953292, -0.43081559321783525, -0.0075489081840927055, -0.2643775457549988, -0.40021575741602733, -0.5320138486966477, -0.33880295792387316, -0.40056945243100306, -0.4854421640199812, 0.025061701311762715, -0.5470896237860392, -0.4993028525387442, -0.5956974104050129, -0.3973575688927928, -0.28027795699947683, -0.4635301132268227, -0.6288424519452664, -0.2585369280788426, -0.622262620144408, -0.3279077601190562, -0.4150732136011191, -0.6051076317618277, -0.46279655815342435, -0.762745259295318, -0.271677254976537, -0.4509153357497014, -0.5550115567851687, -0.46214094709868336, -0.5211587366045757, 0.15401002298683317, -0.5554796284123096, -0.35481317184798267, -0.17599168592977313, -0.32660711251225255, -0.5199195166065579, -0.17736936249850827, -0.36340101669402486, -0.36599645526069524, -0.3197590266303089, -0.2402140124835964, -0.674519960776902, -0.5743150987667536, -0.7382400384897987, -0.14116705531349785, -0.6251535178596499, -0.36075433839921034, -0.6853119339640189, -0.5654254528777113, -0.7268740241433137, -0.7371420105532653, -0.7571027755699652, -0.7067658241146383},
    {-0.24997047455932556, -0.5546179729234368, -0.22138933693169163, 0.12826424102192308, -0.08778057103645974, -0.7006837340943828, 0.25295609983550726, -0.6295289787852509, -0.09853306902502731, -0.27833519154855346, -0.07543437364482686, -0.2631931196436607, -0.6216377941369038, -0.36843124226007257, 0.04788381683775578, -0.3020824322664882, -0.6867060377792321, -0.5986883532320264, -0.2416417218485631, -0.5046727081184511, -0.6233811341288069, 0.21190448237333195, -0.633976019415656, -0.3744424620181493, -0.38364528325891284, 0.15128802603909225, -0.3428431738702063, -0.1920262502476766, -0.5372773764693799, -0.16031752240051872, -0.5043087644690537, -0.5725355793760196, -0.2997894423219708, -0.5840137943132659, -0.22163940139844857, -0.38714645059266517, -0.2891653694215995, -0.6745070677746358, -0.5541892545156155, -0.14483108418847115, -0.3662839157074085, -0.09373718683471818, -0.474928268142575, -0.5679217857001508, -0.16644293304420482, -0.42905569315344955, -0.26455432973083165, 0.041769864733189395, -0.2729130387171224, -0.08497846314288963, -0.40523047506836035, -0.07158840812274894, -0.7060558375639608, -0.14420344222179246, -0.4657657323824208, -0.34432174739408145, -0.4741041102831039, -0.49845263177798216, -0.6181873973535128, -0.38170684543087036, -0.7235017138679635, -0.4344428456233789, -0.5667933798921645, -0.2925301698777106},
    {-0.42016544500268915, -0.5742618760864115, -0.05021080824179342, -0.33699935511350637, -0.5667872367856615, -0.601455808331059, -0.18401427274857857, -0.562875274579659, -0.08784849476333123, -0.3221638499784644, -0.16953142007217623, -0.401128245406956, -0.6012590522866994, -0.6492819109026849, -0.43926705197291815, -0.5043905393949257, -0.5981024497542546, -0.5668362703943244, -0.6009171651162202, -0.6172100680900976, -0.45910625032344776, -0.11471202630150604, -0.6635296171711388, -0.25994407228575767, -0.6489407428848875, -0.10891240268107279, -0.3853916056823921, -0.48778651355042324, -0.6221465051593097, -0.5919888626401351, -0.3158372258488132, -0.3397049065726517, -0.6736701753941692, -0.4985371630405573, -0.46754917219151143, -0.31897578425626816, -0.353162519069117, -0.7142965912480017, -0.5836898972761524, -0.6178578055952125, -0.44419017835900276, 0.002855229945294846, -0.49628345600552454, -0.6321419955976194, -0.6054559093914845, -0.5267103089758214, -0.2808350690396598, -0.0783808191242247, -0.4507347764919158, -0.3697598219904772, -0.2754528028240507, -0.3932193011023845, -0.5323824951536743, -0.3567866461758875, -0.4983572168134114, -0.33357708186201707, -0.6019337509116534, -0.3003897880001868, -0.3129471298083581, -0.3199076400862931, -0.740171706694234, -0.6636747022697247, -0.6210640083791644, -0.6524747774184357},
    {-0.5664392598103087, -0.3993311034844286, -0.07664086314448453, -0.05100687808409514, -0.26391786921012905, -0.7024079115415495, -0.1323048504896905, -0.6530189227550482, -0.048875194299167826, -0.388714385055275, -0.12202258855983592, -0.637748672445377, -0.6362368528725436, -0.7377010377494279, -0.0210156463615617, -0.3577835523523809, -0.6041156532849437, -0.7481767929914567, -0.3033935281713976, -0.5251289156260074, -0.290921025517439, -0.11860612386020339, -0.663918407780698, -0.4465821734958429, -0.7219501534331807, 0.2358837745545179, -0.3130989322824202, -0.5704041371529813, -0.6791016465141841, -0.32718799529007214, -0.4791613657526792, -0.22676228718501193, -0.7314844659588956, -0.3704110781051282, -0.3595977965446049, -0.6014807171135236, -0.20896257835646556, -0.6615927876015765, -0.3048425854424034, -0.5737621757535833, -0.6717987443180713, 0.0740263291144115, -0.5701479044818077, -0.5752576500259338, -0.24733879446502904, -0.1452083394084538, -0.6588731282862064, -0.27653921765800477, -0.4186546796842468, -0.22708876220771168, -0.508804020530471, -0.48977006354618285, -0.6179510330478731, -0.4577763012638751, -0.38235242926639074, -0.2577911603078643, -0.7720911590804479, -0.3653607163008251, -0.5047107734596619, -0.30618450130601543, -0.5579006191886827, -0.4139343803526253, -0.5647006920357692, -0.7704237513445273},
    {-0.2276898032650286, -0.5112675470625427, 0.019932390305406136, -0.16360614336435322, -0.2715585959721349, -0.3879127884630475, -0.0394131519952292, -0.5607996514013358, -0.07627618735978636, -0.570761653306678, -0.4063154072144732, -0.7236234368904908, -0.6742087605055287, -0.419478226915841, -0.3265436037773565, -0.6166355281606778, -0.4898865173663012, -0.7236858794422769, -0.4162841718274243, -0.32510133465067625, -0.5067296922413648, -0.09123031218632421, -0.7808998359663949, -0.618229116394687, -0.6987796942554079, 0.2596372955248837, -0.4919789404680809, -0.39890141747330893, -0.6987825528990186, -0.4251070959389135, -0.6667190925939337, -0.31965870710968985, -0.6797961426551163, -0.7569890806600785, -0.2012118994491053, -0.748870350183342, -0.11343513152208615, -0.6556543247071496, -0.22428721632821463, -0.23987391501122526, -0.4445727966479261, 0.045422203048443875, -0.4099800838443507, -0.33060971646166964, -0.37326786361504144, -0.43411380791880777, -0.6338747603162721, 0.05149970201152541, -0.3727784260798252, -0.331826799607107, -0.6822085919554567, -0.38803775389076545, -0.6606276759875962, -0.5445140119494035, -0.6531917712543388, -0.47229519381071305, -0.5062438962351942, -0.2784493684000955, -0.39349066220638934, -0.5540817440637131, -0.6864250844748894, -0.7386181876773436, -0.8193536155422609, -0.409056875299835},
    {-0.49726549799875824, -0.4625858459677052, -0.09976701592388207, -0.2864917875877299, -0.5210046677441247, -0.6744791773018282, -0.2733497075249328, -0.7722662548042701, -0.18040821421403708, -0.619033843260696, -0.29146066904145645, -0.3109372949518684, -0.644657175236592, -0.5201149930361401, -0.3825026126501165, -0.18672805480925828, -0.5835163986595451, -0.7403057410499916, -0.3947381864382261, -0.4252364133329136, -0.503861640242874, 0.038843656712728686, -0.4950259999635296, -0.6149599952273445, -0.7658906586191934, -0.049241151434308045, -0.2841283680914659, -0.6392767448614654, -0.782362047277133, -0.19138917880528694, -0.561406152035148, -0.3950452260105986, -0.5820416957939523, -0.6768239016175452, -0.4989069318396091, -0.6835675438809138, -0.4944031479519511, -0.48904803138315767, -0.14634049345880046, -0.4935966634055673, -0.4670721250130416, -0.12907259399109355, -0.6392330682369453, -0.5246860739360395, -0.5549589213380142, -0.31949792319148645, -0.2583017964567535, -0.09442748693182665, -0.4498877675582872, -0.5544563282207686, -0.6311861709192716, -0.5119011189900295, -0.4364358404834021, -0.5610943460326598, -0.6898937716275205, -0.4996841172706915, -0.6806511561662035, -0.4132764731332028, -0.30959012097611455, -0.48686120794798565, -0.7388687276748266, -0.5985681297433922, -0.677972402290102, -0.44448257408158626},
    {-0.45407668207821367, -0.4749310005493846, -0.15695138321396201, -0.26546884916766916, -0.40708927896200053, -0.4683969879267495, 0.2644168895214245, -0.7001812313540928, -0.0031120993048987015, -0.4044705853498571, -0.23121864853336355, -0.32280288381264893, -0.562759673910764, -0.7018205169278295, -0.18699775858519627, -0.43689640657909756, -0.5263254767480023, -0.569342154318354, -0.5173737817166937, -0.4488411264306451, -0.27514421908145203, 0.136824120212986, -0.6256720666420066, -0.5056680396208045, -0.678938798183856, 0.37002367774446643, -0.3361133475611518, -0.2861059490635835, -0.7124047595832312, -0.2665356465869739, -0.6046767942571333, -0.43897916404558707, -0.5280235681176387, -0.7501200246632133, -0.36811435603590076, -0.303314668827736, 0.011276685959260955, -0.7754769641103599, -0.26363545538493677, -0.5603962344885498, -0.7158412285437095, 0.013059772524621954, -0.25282970605589844, -0.5553972434093726, -0.18237826948992503, -0.21693393016704074, -0.28222336909430884, -0.3320775864604752, -0.3163346617253742, -0.45439103106768614, -0.6177086220245739, -0.4527361325704184, -0.6976381860279754, -0.42391083402363716, -0.37803252671676363, -0.28022418707063124, -0.6119569889865709, -0.2936810154986403, -0.2977148601236138, -0.41846454216251383, -0.6754060859909037, -0.7491241727470433, -0.580780751731492, -0.6774286383538844},
    {-0.7327885847685865, -0.6286481081427204, -0.02300657138174528, -0.1880379545086409, -0.6312947402137961, -0.6973674060737876, -0.021395631285120273, -0.3891252494588776, -0.02238144925520737, -0.707382146817589, -0.04893808683125996, -0.33306203051689265, -0.6632650051154066, -0.6528970640436655, -0.050425661251086815, -0.5160361860819114, -0.6109748779510094, -0.8013352990184754, -0.40805319785648203, -0.6593790505136208, -0.3984808859830907, -0.07819220309222999, -0.5744292117941285, -0.7256262612709915, -0.5482502826489374, 0.34963893447854894, -0.5434343159468321, -0.5857032426797704, -0.7430010848717894, -0.3113306001004398, -0.6635415122152234, -0.2452288335777483, -0.506468291611336, -0.4135728228978296, -0.4384482722429925, -0.31142355701096464, -0.4663481720397993, -0.7832466253427722, -0.34165757411815195, -0.4913484009214124, -0.7396500665369106, -0.08710016359000568, -0.5079113366051717, -0.7189224625545177, -0.5483724823633548, -0.43607808453371366, -0.2298468660989766, -0.48239513796201117, -0.43103478592808164, -0.6346191074232956, -0.48227776730582556, -0.5226818661772268, -0.5062472069584476, -0.08770155034910203, -0.6019662712732056, -0.3900626835783085, -0.6669389356173421, -0.4529887236485531, -0.31535214261370276, -0.2583749297288481, -0.4811892451624725, -0.4143806548591785, -0.5609806750859921, -0.5634085077633731},
    {-0.5992844950980646, -0.5114440253166459, -0.14804350158265928, -0.36248895005979453, -0.24465290828814, -0.5727111137868727, 0.03050603376095202, -0.5475460158760159, -0.41733373025595505, -0.7216964828169682, -0.21118604272789174, -0.43094009107640113, -0.49624533700999734, -0.5791872737812691, -0.226489121609397, -0.4814293634384619, -0.429289008591607, -0.38411174315565527, -0.4371276133115441, -0.62930443074446, -0.6891450036229934, -0.17778730883565888, -0.48402885522196654, -0.40874298696141365, -0.5659753557848695, -0.16536189441021293, -0.17644146034642783, -0.5743206063445115, -0.5074138886446323, -0.22293807146451755, -0.6169384252632348, -0.4784288296889406, -0.4794661345969647, -0.6334624921651694, -0.5810246237010865, -0.64633248619883, -0.005388750787214678, -0.6801945903096664, -0.5527061053343421, -0.3130429809017873, -0.362529962691833, 0.054299404328622514, -0.21892556440480368, -0.4852734774158138, -0.5341895940296806, -0.5906288152060648, -0.31299022406814314, -0.28975361094642443, -0.6074412871362229, -0.5090263204165025, -0.3068138651506059, -0.4185888497206076, -0.3596999302140161, -0.40795573442784655, -0.6216432747755435, -0.5281211090592233, -0.432259536077452, -0.2520773591270814, -0.24982290409456426, -0.3630849237553957, -0.743785136769884, -0.5737490407075204, -0.7750892619159485, -0.6144958797384736},
    {-0.3061733178034526, -0.23606393217196736, 0.06221164799913469, 0.1708082479776815, 0.0200163674283538, -0.5984815556255089, 0.22528120652158304, -0.36964266935282714, 0.011831925387966248, -0.5259096998650781, -0.2104566789347515, -0.3199825346786263, -0.3813456771238908, -0.4164897641218253, 0.10787925421798653, -0.11033495706373574, -0.2781081364642133, -0.4111137731431028, -0.37529468617410605, -0.15806387160513824, -0.23100941712719222, 0.03255367191803807, -0.4747638736386084, -0.5306567871734895, -0.3076303670671717, 0.018332109772029394, -0.20000074439513044, -0.21370026423514019, -0.6401028460239189, -0.1460187408211711, -0.5287236939141561, -0.32697892364493536, -0.13243699718864, -0.34375569394336575, -0.42333595517839745, -0.31828568697057874, -0.11982953017743675, -0.2561031833743735, -0.22015950795183398, -0.48530915272851066, -0.3920084107391887, 0.17590689451193367, -0.4084649120207019, -0.35568241116474525, -0.3284108617525361, -0.43819536182035074, -0.4586598204391788, 0.22703250380923556, -0.3774058864870285, -0.19914638879688107, -0.24693849582063684, -0.061771279435788064, -0.6006212766715608, -0.24269747278112463, -0.4611131893136198, -0.43028816699674777, -0.5819055709483358, -0.4710424124192416, -0.2800571923819547, -0.3332283556693216, -0.4059615260329729, -0.2829387683800717, -0.4530373703763957, -0.6502371221120059},
    {-0.7207404640861448, -0.5593680065627021, -0.1274583701147587, -0.21916341548739787, -0.42359883409799065, -0.35854904054526576, -0.1048434102578771, -0.5064979852245697, 0.006519021452134279, -0.4363804385708105, 0.02740021137774706, -0.29135667362462014, -0.596152290922816, -0.5777541544923495, -0.41233525738919863, -0.5296931541090395, -0.580248621851397, -0.6324157253835258, -0.2951233647481209, -0.35486131089462364, -0.5823150427997055, -0.07052880017674348, -0.31006742679288596, -0.30775219065379217, -0.6729335369845043, 0.10754147646495746, -0.5042282400992386, -0.5362685244885244, -0.5674188788628894, -0.410608475313267, -0.7622932997523145, -0.20963432198999668, -0.3192212748233652, -0.501198754039399, -0.319347563020669, -0.3900287940084532, -0.5511085925898449, -0.6362628727884313, -0.31529579682295433, -0.3854320633481137, -0.4986040887025246, -0.04719866962056046, -0.4811939747683618, -0.5147198013854086, -0.437578668568574, -0.5469756675235982, -0.4920056604364505, -0.3301574886952715, -0.5442223835419752, -0.4599525748035811, -0.4310201076379315, -0.503772115750478, -0.7041891579671528, -0.18906231052571096, -0.6788467121997788, -0.5590510706658479, -0.5890114903391234, -0.6017719729737143, -0.24200576342130034, -0.5429845813427938, -0.7681524775131683, -0.7228392038553201, -0.774915993610281, -0.4964194983723887},
    {-0.7102721465724442, -0.5221183874332195, -0.10091948037425702, -0.46261064174425687, -0.4697894576022729, -0.5678535731369527, -0.06595071671009106, -0.42182417336550204, -0.0003853019394985478, -0.46543125005297675, 0.03558013645995133, -0.3487127395198198, -0.47276052530744117, -0.6121238877943528, -0.08305367299112552, -0.3510131815688371, -0.40867874644513813, -0.6625407889304902, -0.37904200569517615, -0.5804496842758764, -0.6440022492000005, -0.2786302981675206, -0.6212287211342116, -0.6776810625404415, -0.8005236895769642, 0.1591120832228456, -0.6184561456477605, -0.7191891194111312, -0.608041579775904, -0.44355653163248215, -0.7011187849138595, -0.4755490955391408, -0.6140546967694831, -0.8046839669915552, -0.4767783233483357, -0.5244224885645368, -0.5595500425102301, -0.5551095518053045, -0.39673114896018274, -0.6455843308492041, -0.48854316804465864, -0.14418514971851792, -0.40448169646920434, -0.6599935081748477, -0.6627399000169538, -0.552412526217097, -0.4175792820530894, -0.20670246577173354, -0.4516112823123658, -0.418964619379962, -0.32212995823796836, -0.3457809103853162, -0.7092223583518076, -0.3402187317753399, -0.6314801897009357, -0.41088249296968893, -0.6187619854709846, -0.4126866030356999, -0.5077766127448992, -0.7119569126991233, -0.7610760424316968, -0.4685328416744514, -0.4704032290349577, -0.702602779831019},
    {-0.44011214184771413, -0.7406874993270278, -0.33565014662039144, -0.395594128516313, -0.33626165683307835, -0.8713909803058686, -0.047880672311287065, -0.6516555591679513, -0.46802961156036893, -0.5590155856857351, -0.16563302686692866, -0.6626716916795348, -0.5605602974247154, -0.7160498551085885, -0.2839048237883437, -0.42710391078525733, -0.411590413547743, -0.5129531228662544, -0.5379326316168903, -0.4999264830912521, -0.6955147816174246, 0.014987784998423449, -0.722697260684967, -0.7898811352391133, -0.5675439753453493, -0.02973999047413117, -0.21847719977189892, -0.37368495847561684, -0.5050475582928841, -0.31925885111237834, -0.676790743877736, -0.6654278856448416, -0.6742196426043204, -0.5955509338301391, -0.4070428505179814, -0.7270771170814528, -0.23874141988586792, -0.8155199674584392, -0.5633099566404399, -0.30402578365973293, -0.4920164469927864, 0.07620427480876704, -0.6483741523430634, -0.4773782207052835, -0.2729081236125379, -0.4230800713939172, -0.6025928804886822, -0.06026859669879955, -0.5528716969682907, -0.13353002950665968, -0.5971418216528419, -0.3418001525912005, -0.720943865295883, -0.2952184247432499, -0.5685907261128499, -0.5890838896478251, -0.7841913792996487, -0.2768267622929552, -0.3778049245216165, -0.47123505094941587, -0.8026366858301782, -0.5826076458416087, -0.5413800857047354, -0.4996868839214174},
    {-0.3557466310872346, -0.7450445403254051, 0.11923861624930947, 0.40406900234694787, -0.1447430743817707, -0.6775433951491684, 0.6761362773025595, -0.4056495562192602, 0.1830739680339815, -0.4583088040016538, -0.0044702818874981735, -0.533585171644802, -0.3573248911062355, -0.6103019935511139, 0.30548621314669994, -0.25031285548661114, -0.5327519731039718, -0.6363585748698115, -0.2383872374002712, -0.3547151300449113, -0.6093019776468357, 0.2954078980819444, -0.37339229788820394, -0.464463943273363, -0.4214869450706547, 0.21449063464168833, -0.12187635522738087, -0.1490486185900763, -0.7236852423858783, -0.3480713048529116, -0.6065284219106799, -0.1446343730522553, -0.24683487401718893, -0.7038790317843819, 0.052153897204384556, -0.2680436935636965, 0.4896115343007268, -0.6112501726160525, -0.021791477150863412, -0.3110073374429594, -0.4519436551589454, 0.054705350055409496, -0.4202053505355906, -0.5749058744090769, -0.021393459289653333, 0.008844427574476395, -0.16051160317139362, 0.20527488641067568, -0.3846251650064823, 0.25058572677916713, -0.27703652591932704, -0.02868832031205066, -0.5543567632844646, -0.07819328520328829, -0.5390421018351956, -0.23282360851790268, -0.4987246918783975, -0.5632235357074807, -0.09762511195119752, -0.19103711960535447, -0.8146645649790107, -0.6659509042013534, -0.8008514514472802, -0.5876978050829966},
    {-0.4712636860403634, -0.4098922272031864, 0.619886203447285, 0.08721304274025975, -0.4595132426932243, -0.48146883166644794, 0.39507036138177787, 0.012086631350559198, 0.3905957515069757, -0.5183742165375159, 0.5426625298302771, -0.2689695024019964, -0.756230198247126, -0.5063183011732104, 0.4290459358878396, -0.03368302778665213, -0.1338349685910044, -0.8633617970690748, -0.5595484575595098, -0.07856187355857362, -0.37825071495497475, -0.010594478554827631, 0.2679775994373363, -0.39863065359926764, -0.2888610874884703, 0.4656453265180439, -0.4050031357536158, -0.4700350070217611, -0.3660660602786055, -0.08063931333175116, -0.6401251812579419, 0.042157949521110016, 0.21044941182585655, -0.448614462838859, 0.10446520187999694, 0.32966837468522775, 0.2699460186191266, -0.5474082193578599, 0.37685897657837375, -0.27120513287437803, -0.41599595660474137, -0.09064534748531258, 0.1582273136005311, -0.4452150973747094, -0.03529372142011787, -0.31368082784700935, 0.36301061555121356, 0.20541619836877495, -0.4472959154165471, -0.24518411687589223, 0.24816511927828713, -0.2047013213981955, -0.2730805310893693, 0.40348601406454293, -0.1052099369951345, -0.5506756124788893, -0.23366062158912884, -0.3611863500065402, 0.39890664871912823, 0.10178675851844296, -0.5430951549778535, -0.4535748694705113, -0.5022560844566806, -0.25608234795281615},
    {-0.7074749870764359, -0.529848477959524, 0.5654720455789216, -0.036614476717908365, -0.5705222975986645, -0.4102008682719108, 0.07362324925705058, -0.4150004657363251, 0.27890986869712625, -0.6765534248815042, 0.16053532223954503, -0.36109573433211767, -0.5749764455878502, -0.5816596062061006, 0.1863052746851748, -0.32314434999703134, -0.1432489436466165, -0.8061827467955006, -0.34654404764332436, -0.4392801236104777, -0.4804958423785088, -0.12272035671366793, -0.05215528480427548, -0.29205271408252187, -0.5966295461908769, 0.45879200807058357, -0.30842085623056065, -0.6042696599114856, -0.6468422284422594, -0.31702316532447394, -0.5996655826805908, -0.3747411256361658, -0.1377588951901715, -0.5771375572215309, -0.23342564544083735, -0.15883764177147625, -0.3992089000479966, -0.47352815703382095, -0.051660007493900845, -0.6807003882746158, -0.5691318543059581, -0.295356023435561, 0.020242090803429612, -0.48184251673177936, -0.45209057681407894, -0.49955163127747354, 0.10506777554087703, -0.05249626848395834, -0.5666388159801621, -0.6444605013679704, 0.27348455866418625, -0.4664422089099703, -0.5180492195068178, 0.12608276683644998, -0.5670484816775777, -0.7568245556672744, -0.22370039936852823, -0.5442637197389146, -0.05018678644800478, -0.3059615572141823, -0.7172776633331999, -0.4198569945880937, -0.8355034352033791, -0.4536020533059434},
    {-0.4306308777100063, -0.43940625206448236, -0.13132277791079663, -0.33345562594937156, -0.5846696082921446, -0.6201482035141402, 0.20440005138261844, -0.6255126623288224, -0.12529799104380232, -0.6184520062847201, -0.2596050508690991, -0.6588774442247778, -0.5064470662633381, -0.5482495260886399, -0.00276164956478188, -0.4916664408591831, -0.4038157614698797, -0.8022201229601409, -0.4415195793668681, -0.6605650808174472, -0.7209567590020574, 0.01619593272480864, -0.43976177877857614, -0.5239558477810918, -0.6034982716351666, 0.20244488978577507, -0.4356097182317268, -0.5544221935770465, -0.5791528010055985, -0.4016755947313073, -0.4936280362303969, -0.48034028056173506, -0.5796957683875359, -0.7904612297848145, -0.4894871045506421, -0.5610501357765842, -0.39639551225560404, -0.4438502199259582, -0.30775863663346614, -0.48502584529171855, -0.6936523545809, -0.22614212474267376, -0.3410870240721961, -0.5359816125477214, -0.4526171576267305, -0.6188606763539913, -0.20902162210957267, -0.28372375294411517, -0.42544378940509275, -0.5262844256811826, -0.3717443469129579, -0.4244848112112111, -0.42917307231659424, -0.27404894256353424, -0.6080588076755867, -0.5952302940646882, -0.34896082619860574, -0.4242665086720596, -0.2927681421566849, -0.6565535792539933, -0.5372651918263807, -0.6641959911996551, -0.5815307737406087, -0.4275362648267514},
    {-0.6919596458643597, -0.7511652977062114, 0.23367193267401873, -0.29351138479154815, -0.42831317932520696, -0.3324518066758738, -0.010797584990048162, -0.29394537986371444, 0.314720290925288, -0.5918788526773211, 0.28633424634705296, -0.4572665362762903, -0.7669599851246998, -0.35737278555653634, -0.1327436433973594, -0.6170012424637761, -0.3141044353649496, -0.543480900602511, -0.47226244784594384, -0.4483188496238735, -0.645218828658727, -0.26323245312291044, -0.2318218260659677, -0.5912542504120302, -0.548720873954212, 0.3804818420915307, -0.686380943454437, -0.48090758222182056, -0.5157196455599478, -0.24512829124331942, -0.8256547228850166, -0.3031306170391163, -0.052373401577235676, -0.39678956875607174, -0.25782613908051566, 0.20160763175045993, -0.4334120438457577, -0.49755293353131463, -0.001043804559709814, -0.3758771576058017, -0.433475457058692, -0.36294791444776936, -0.06800460363924168, -0.566635741062746, -0.3972891631080648, -0.543501803471384, 0.18456752723903252, -0.47804847491715247, -0.5473761276541478, -0.5531230581333063, 0.15764156024687073, -0.45427042071740326, -0.49701606373670326, 0.18216174331471896, -0.6041729282213232, -0.7144758626487083, -0.31356552725271847, -0.27619161522364316, 0.2327823036579791, -0.4508305116660838, -0.396782038595162, -0.6354462431432042, -0.7291098169705366, -0.5851671044564656},
    {-0.6034134344472678, -0.38629997441138775, 0.5257813981743814, -0.029006340766172974, -0.4965840266222151, -0.31742337000558607, 0.17935928820736843, -0.09922360029543573, 0.2918551135856361, -0.6960517285198449, 0.11837951948933464, -0.4266094270888849, -0.7471648481710012, -0.5207230820220761, -0.11446204250079815, -0.34395120204645124, 0.07089056922697051, -0.8531128024273859, -0.5475895131656373, -0.342405917033887, -0.7013071030052197, -0.061246076214376714, -0.3382848513825989, -0.1665281341512565, -0.542804663852788, 0.34949187162418366, -0.32713577438073366, -0.38504931977424217, -0.4581216973864921, -0.24411934911921124, -0.6866329828854653, -0.040929295739768244, 0.05116792002467311, -0.3075788848026979, -0.1718126595753566, 0.14479883340707375, -0.06528309884701677, -0.6721772558549357, 0.1791623073421419, -0.22715495894485882, -0.4137239011883009, -0.017368850666421607, -0.1538318013061987, -0.6902397779200847, -0.13909227107420197, -0.21293285250349106, 0.06191289951111326, 0.11817591771761032, -0.25014225574510346, -0.2525689140015114, 0.14960751541051553, -0.40703956047431816, -0.25834841491706095, 0.12048057328317271, -0.3369574423292534, -0.5148494642585731, -0.03402380467715497, -0.3315618922756388, 0.12706478800976148, -0.24685492984875956, -0.5700037396413995, -0.4983463584161031, -0.61944324296541, -0.25826122382069466},
    {-0.7627258559532352, -0.49987974155651366, 0.12701062302516994, -0.039501366195119646, -0.5996913564267281, -0.5057406968442197, 0.23410425278147648, -0.6317714834691729, -0.0885627309434715, -0.5697674778069673, -0.0447082774013624, -0.5227838208286234, -0.6858484941323291, -0.6595492059560287, 0.17145435916773105, -0.33116441166630833, -0.39849664441895444, -0.755958207238901, -0.48477413066728914, -0.38132336394517485, -0.6791068176977464, -0.21438963169743952, -0.33956242871476566, -0.5059546706845719, -0.7515935562612527, 0.47075724038522326, -0.3042411078851572, -0.46535974496852234, -0.7846316294257287, -0.41087604176004366, -0.6663166186232737, -0.40339028709560426, -0.24425905047703336, -0.614660143696844, -0.37437738362076983, -0.3181809707578556, -0.07481540451382152, -0.7624828432325591, -0.1754074127126107, -0.33277014032957297, -0.47282038306391533, -0.3934950821942586, -0.050001481621194124, -0.4185173521914699, -0.5179011851245218, -0.32080750242608713, -0.3089684381317171, 0.0016489969520129153, -0.3469636749332678, -0.41457193629002026, -0.14502821417213593, -0.37187890042891647, -0.4376099891114548, 0.01334843087791264, -0.4299537845936286, -0.5078012735533356, -0.5126862179573913, -0.46476403432290586, 0.028927210827712414, -0.5591361709982763, -0.6793880555586443, -0.809698539926489, -0.7961024467760399, -0.4000642534012298},
    {-0.6939766766401886, -0.6333909921627365, 0.3779291114065973, -0.002433721516182949, -0.5654824907982122, -0.4794429882110211, 0.1631426366180098, -0.325777980160253, 0.3677624881837776, -0.6589677460536275, 0.2064602762716186, -0.43219858866586086, -0.5629293074066755, -0.6572098022863551, 0.09469335541940477, -0.46624917511394254, -0.3339761614206086, -0.6074168316966261, -0.5661758180479992, -0.28171903695878264, -0.44730043903706224, -0.08697859121847239, -0.26945786050711484, -0.5888648707720027, -0.5158456085023098, 0.4251483624231641, -0.6414496055238132, -0.601355842083126, -0.5010643954555326, -0.41035557329717, -0.6064611304025169, -0.01787452938851977, 0.04790783487476648, -0.4087083958192245, -0.4757083722470647, 0.10305381824467785, -0.21953562562637008, -0.5912019823158705, 0.12407463801987668, -0.5349949018653344, -0.6356039017027219, -0.2848078886375847, 0.14850499601772027, -0.5031776758268051, -0.31184318120017585, -0.5527042460124226, 0.027899413809392596, -0.2086682642595879, -0.3366697623969405, -0.4300442666405657, 0.16394101351448898, -0.30483368834281377, -0.3782816055066705, 0.0073195282623720135, -0.5135876142393632, -0.5412028184854223, -0.4027172136509705, -0.3796961516453501, 0.03033484214258335, -0.4775744908636814, -0.5708933803385527, -0.7697472332155484, -0.7502674129873593, -0.4478275139775033},
    {-0.6436609612546897, -0.6270359845633482, 0.4003270633108994, 0.07254327874636828, -0.6716964892327573, -0.6458320974166547, 0.5810362187248369, -0.2849119367815061, 0.01853446571221575, -0.7158541912293034, 0.458454307476431, -0.3808195161381352, -0.6984258810825598, -0.4281752024470448, 0.1906259626294037, -0.3689134387249337, -0.030772096500551113, -0.5133734094799786, -0.5019186389929468, -0.5221103003204383, -0.4565068214287695, -0.04783326048102306, 0.061737144783410816, -0.3184900592782751, -0.6369025150591745, 0.46220762262207266, -0.42393587920477555, -0.6384658085265299, -0.6688323304853441, -0.3311330235175198, -0.789949063594356, 0.15669618377232997, 0.17867268290676172, -0.6057216164115614, -0.14333679684649325, 0.3251124348693607, 0.027517442457590014, -0.7468255703981213, 0.16915400516280127, -0.4815492218832208, -0.429880708691523, -0.22912452819395773, 0.2794955802475455, -0.5545141070094437, -0.3522709027756334, -0.21696399094858373, 0.38238864353548285, -0.15706499711795724, -0.3016628932491363, -0.478503508016997, 0.3385300454845355, -0.30968806556865075, -0.45627072143892944, 0.23182153646434533, -0.4233397937940846, -0.4735236318579376, -0.1779969936139358, -0.36902353550266603, 0.27055462033381605, -0.30717231762933334, -0.2289588770100915, -0.6431816063064091, -0.6529906209398599, -0.4365461169594593},
    {-0.5134340439498919, -0.3431301344540035, 0.3920362756631614, 0.1200658537799574, 0.21480154977965818, -0.05555292938352455, 0.12884816676203148, -0.016171850743219033, -0.5428810147078657, -0.22738051322546868, -0.15306702695103708, 0.06578737209698625, 0.1435900636083118, 0.04374725885927046, -0.34778849632563996, -0.2342898613458469, 0.2381639429880641, 0.03710908625602417, 0.26551348102323186, 0.5363233246583007, 0.451107992881032, 0.11021917643756672, 0.2716783678790042, 0.011479624121989655, 0.2630219233239991, -0.4131779595493112, -0.3854813289412248, -0.04975719847299605, -0.27842663013767616, -0.5996832806586042, 0.2542655507809791, 0.30724626650164993, 0.08287618012286598, -0.3489287547057398, 0.3866204323436403, 0.19200027438371448, -0.3805264604333805, -0.6033504006648528, -0.22507087436225554, 0.11284989640952402, 0.27617160207747543, -0.7295702739524198, 0.3796419362350929, 0.4845466255806228, -0.3986012481106263, 0.21316606191138548, 0.21762599910979114, 0.1487494053229218, 0.1460887812287201, -0.21505383944217404, 0.048608552306426016, 0.5514318853363079, -0.3082858909774761, 0.4614598493510131, -0.4851426869280323, 0.18974347299636904, -0.023686006052201853, 0.5356375528726937, -0.03449122760339644, 0.4109970197030494, 0.3547873971652548, -0.09852592791535487, -0.17181587107159602, 0.5119722124211875},
    {-0.20792734785558548, -0.45162947972933776, 0.2246830154381969, -0.07079528690069739, 0.21592916062077813, -0.08757637132697489, 0.4068229942454898, 0.1400399656857398, -0.24652766980831797, -0.03428015595235549, 0.3388970045422347, 0.1888589285645091, 0.4118292358039961, -0.15024093042540468, -0.293411093486935, -0.307455013073168, 0.3364669050684142, 0.05101666560048211, 0.5359920838914636, 0.04932753532392654, 0.5208365518100752, 0.25279850777263213, 0.4122252482689384, -0.03449542276789922, 0.42273587419840136, -0.479378327052664, -0.2129893021665047, -0.17512384025981947, -0.13985908879012451, -0.1722086703963287, 0.3515568503484216, 0.5267312242736802, 0.08921126388173052, -0.02822957690073136, 0.5923595223474932, 0.149188291003518, -0.14358203077213805, -0.3520189732417468, -0.4022054243746587, 0.2946087063789629, 0.12587393116735762, -0.4860494527795192, 0.4230134780727422, 0.61654629006133, -0.6441375588778194, 0.0719263605282619, 0.08516279485174494, -0.025547269739411432, 0.5971196514611298, 0.34573649739762985, -0.02649820549051554, 0.5457992840206725, -0.4565061117971669, 0.6175657420242774, -0.181037049152121, 0.19676894786759444, 0.39905761837651044, 0.5442693074733957, 0.3183125492890471, 0.4741294131788706, 0.010966167942607892, 0.0019085635854892635, 0.04490425319652191, 0.6240579753473093},
    {-0.5250269542081313, -0.3689856784191294, 0.2990508254428845, -0.2811298445656029, 0.3531759688087162, -0.3060284026156073, 0.44313477241075083, -0.24142246130730927, -0.3529979221060479, -0.05107263689674524, 0.3350812278153134, -0.028007760746901613, 0.27538946405602477, 0.10789602675312615, -0.316199307203926, -0.2805152098216503, 0.2417564443141002, 0.23102927228867867, 0.5140780493763368, 0.07925286172069773, 0.469575321441295, 0.006288611469727397, 0.15375519175155558, -0.22750888465473837, 0.3647834160680278, -0.27317456666204737, -0.10693010171831008, -0.26641186439948134, -0.11708656449786468, -0.45705037135779447, 0.45282503494966525, 0.637109942246709, 0.356035630582734, -0.5209617550816472, 0.6874047430027376, 0.03970450927118385, 0.010799855723293192, -0.5451330328246753, -0.533076551772595, 0.3399131507918101, 0.1007557185878716, -0.6646154751182511, 0.35546234540923183, 0.6377996125482269, -0.6815597903597971, 0.028306115749935475, 0.04225192171084233, -0.05272363305514361, 0.61751369754202, 0.19550220624156334, 0.2534232472533918, 0.5809461652287722, -0.5082188770229937, 0.45678534756428374, -0.47421230245233303, -0.1435565762697266, 0.21997227647556516, 0.5815942227083307, 0.42296230086692055, 0.4869241408006443, 0.4698973766319977, 0.20013466299899257, -0.05541167136065543, 0.5881239016956327},
    {-0.5745988197680937, -0.658335487817105, 0.5595063981485503, -0.2578148026039397, 0.3258750181806056, -0.5812145303307296, 0.49375758271858133, -0.3455613635858572, -0.5661203844293208, -0.32732638606188885, -0.11558150205552561, -0.07318931552826693, 0.4573639918846107, 0.3112083030812343, -0.14312611926999885, -0.4620028819868216, 0.5573568653782317, 0.06461029460770851, 0.3011720938957732, 0.3200791122772783, 0.2983142280326128, 0.11036534370610453, 0.38112244133773504, -0.2718638582647773, 0.2962221521904596, -0.22464909751946432, -6.505624419672887e-05, -0.07996177595265601, -0.3703874576080504, -0.3748183067108026, 0.2611859758703406, 0.6880584181265862, 0.4676498180863497, -0.40353864262761485, 0.5234901286488729, 0.37410140181375795, -0.04805000855785629, -0.5388286099072704, -0.5042956925617742, 0.562507700135755, 0.0539394129651581, -0.682830703090798, 0.6293037025044916, 0.5732262492615762, -0.5872507218031602, 0.12282714631638601, 0.19457614665346623, 0.002518944570850834, 0.6193421942492645, 0.23666462212984976, 0.05086936433193508, 0.4839389611432115, -0.5943454023606924, 0.36779341400614207, -0.45903189459393173, -0.04553710054756384, 0.26128373783194603, 0.5067517160580298, 0.20186565851103552, 0.5636011310831025, 0.29460799942606664, -0.08903262617590742, -0.06418293566827565, 0.5280792305001735},
    {-0.2331265084556597, -0.458412072666813, 0.5710562328172645, 0.0746150804508966, 0.34238561385925487, -0.6272050111853974, 0.46643455486181123, -0.2875639408220344, -0.31401375112792157, -0.2978940766202, 0.10885206348556001, 0.3500507257958553, 0.26061047415483807, -0.01870960904657588, -0.28271329645555043, -0.6014565102166954, 0.48331695640689815, 0.2112128934845024, 0.1400493600370104, 0.10125581052539143, 0.39129584873808376, 0.10425027183319358, 0.34860304402144743, 0.1271743506514658, 0.349402369094238, -0.3473126493514888, 0.340518449328445, -0.1108085839118505, -0.18227260904230283, -0.4476608555499324, 0.15004850684916013, 0.37188641339008005, 0.4395255084080122, -0.41599235704037435, 0.6701721169365156, -0.07621492663678432, -0.14379188806003104, -0.4823565656205338, -0.7535883636485752, 0.5005113378349733, 0.31849640797650464, -0.5535610170505582, 0.35723149470898463, 0.3317678475675071, -0.2818761957836116, 0.29921293541561744, 0.2310346623770952, 0.14992396246524853, 0.48500298851499485, 0.360370809099141, 0.1344756941278679, 0.6425334111669626, -0.5946047756236748, 0.5826723921137159, -0.2678495846527583, 0.24169580934700402, 0.1592718377130204, 0.7317251713905958, 0.18426402446991497, 0.38426633512989083, 0.037894850425461646, 0.12418434102557627, 0.04086178211199074, 0.44660520777729124},
    {-0.23883429610705315, -0.4509977804515998, 0.369598686688482, -0.19316117252954376, 0.2698644877464505, -0.46904249834421335, 0.5865673381236766, -0.30579604055725046, -0.5501513228791111, 0.015408410314144801, 0.133404128148041, 0.24120357930556746, 0.3574772506977504, 0.00880908692181597, -0.4510761494654566, -0.6724604890465304, 0.3621376709437679, 0.34953498329062355, 0.3873908704315564, 0.1751779429933754, 0.13864781024187572, 0.3531956532277567, 0.30884212625779184, 0.2342731325462006, 0.6206490504126986, -0.07831056823930418, -0.14917953137825427, 0.03217028380087253, -0.28447603776698543, -0.5095448349938885, 0.1187570066790394, 0.2523969682290942, 0.5344671794421264, -0.44196809317855973, 0.3610617174460788, -0.06598249228434638, -0.2092244513642387, -0.5913923265470953, -0.6066794806005811, 0.5097413930525235, 0.40781272994657736, -0.5325226717834144, 0.4427233518778771, 0.7312912115140278, -0.5506734078729617, 0.1536176549380492, 0.21745584059995088, 0.39306709873849727, 0.45242492908470205, 0.3475316728981763, 0.21768813835909098, 0.6174465451395604, -0.5822237898542787, 0.6220790578427533, -0.18619133099417218, -0.07762217732477364, 0.1305821844957282, 0.6971499656723238, 0.1112734696437552, 0.2874743360704516, 0.24970943563701312, 0.24398152211065013, -0.07271526108983858, 0.7655878531247761},
    {-0.3191635039198307, -0.6087620711648365, 0.4092416574842829, -0.40105249527704667, -0.04842854485378381, -0.5379406867395251, 0.36316700854082956, -0.285624101084282, -0.6348181524401848, -0.1558862311572219, 0.03936337675367341, 0.014579967748330985, 0.05017622157053767, -0.03912108786108743, -0.2697052252235131, -0.6352921016839909, 0.5615359720013452, 0.22496173632918104, 0.5447639359023623, 0.08685280147316952, 0.1393859524930619, 0.21802987794566436, 0.4914788726005219, 0.13248080186127653, 0.6190686062294747, -0.41077425617125246, 0.06070251543913171, -0.022092267469709763, -0.20931905239606244, -0.6701534141799472, 0.1696042036591913, 0.3344008917459813, 0.38245505174548433, -0.40366869454154997, 0.3466530346202306, 0.18845896205154414, 0.024188783232910138, -0.4733988108953134, -0.6396388494357375, 0.4791344439020961, 0.18039856619761066, -0.7491328730439737, 0.4189131484640704, 0.6717235693979088, -0.5752798573379948, -0.012098292917188034, 0.4329867869294288, 0.17428414938168468, 0.6629190514686906, 0.1577183173010166, 0.24048542311117682, 0.5683591753604936, -0.33504442045162003, 0.1526839919172198, -0.22631656715474333, -0.1335234487234985, 0.13240171059535713, 0.674653031516477, 0.42445316518387854, 0.37559058497556985, 0.20267496079486777, -0.027415275487006587, -0.11282490760199233, 0.47952068252351226},
    {-0.3835043812454434, -0.47767246289743026, 0.4747228467471866, -0.08788152605631691, 0.26140681015065453, -0.6277509346294041, 0.4808672424343357, -0.3720127939648689, -0.6044853458971545, -0.17862588677684957, -0.16114967596697954, 0.4145774107692826, 0.09529007206349027, 0.35111325392897696, -0.32508292248670684, -0.6000942116509087, 0.6446930391057121, 0.1798787407637235, 0.42423848912683376, 0.5792499501835746, 0.49808182907375187, 0.259999718888254, 0.2669679323847381, -0.17723609835050105, 0.6710249715678887, -0.38960555199227825, -0.2786845591634381, -0.37711556939003427, -0.35399989547312083, -0.7381727389632616, 0.15138075373626844, 0.6501206553722121, 0.5771669789616622, -0.403417713417164, 0.5129704143105808, 0.4039267479831517, 0.05855505974222511, -0.594607624734363, -0.6189835247292713, 0.3861235011393286, 0.19455039744949298, -0.4145341366731179, 0.34441988778912824, 0.6698722887229942, -0.4832210566758255, -0.014856644138825972, 0.1485221206402178, 0.2771714785061485, 0.6968810924621568, -0.13587325892706822, 0.22408217986276271, 0.3697866189163507, -0.3879626065463291, 0.16800234409679718, -0.5251834196185466, 0.14430662303589523, 0.4517513221445958, 0.5941597695444502, 0.36563341998720067, 0.503340205296571, 0.4250308126368263, -0.1251796878281395, 0.13829986008041506, 0.6825887535972921},
    {-0.5319164809276922, -0.5607494625505817, 0.3359554182198047, 0.22766257348872537, 0.42633649768924675, -0.5079992450877344, 0.5332142962744179, -0.24166636339133493, -0.6380673057205102, -0.374457898254639, 0.08411800261144829, 0.31263278892447727, 0.46692869018652694, 0.06418519654550511, -0.25862522416945666, -0.7065782590223432, 0.67614600494351, 0.23233088834706977, 0.5368899597336129, 0.5333780390409666, 0.43654143633931675, 0.28021795724646564, 0.3305039761916769, -0.268767315645538, 0.43268761739359274, -0.604864170208327, -0.09117536794666457, -0.20390893506087238, -0.5156192987609389, -0.549701149608368, 0.14335851903828115, 0.3393222704190526, 0.3114234617941286, -0.42208078558796, 0.7274671470133158, 0.40214091307798416, 0.1704887851661261, -0.36841930014576557, -0.6435322374176604, 0.4737481339353919, 0.39944803134680684, -0.47641426132249115, 0.5796167856037886, 0.6954188019091948, -0.6622449508911404, -0.0746425716534759, 0.42970580456482116, 0.13849825465193683, 0.6572867677615188, 0.2938785934066723, -0.06143826470599604, 0.5809368250981481, -0.43743546044097736, 0.49446093256279616, -0.7109260820224984, 0.25910861202414776, 0.5806837453198092, 0.78486778164151, 0.3403428110493351, 0.4325216582134579, 0.44265571478637944, -0.11392564772072533, -0.07222311580013466, 0.7161834672045194},
    {-0.6651484009773591, -0.6594289592924948, 0.3531546462627128, 0.16262148640415056, 0.2695450726573111, -0.6364371073765912, 0.644505766483028, 0.04302115138742145, -0.48288557163389234, -0.27074319092263316, 0.3434701528387714, 0.5123804691368768, 0.2083960864172462, 0.2090310790694994, -0.4540074295521815, -0.578002862163481, 0.6838953449316544, 0.29575070382593205, 0.4845182721102573, 0.3178628406418858, 0.45947939601950716, 0.3068433340134485, 0.3513235460524002, -0.06406732292954946, 0.7222812756960443, -0.2221146105249347, 0.09587411888400964, -0.1721374799188852, -0.13787596433465085, -0.5966915593665132, 0.07831036620614121, 0.43676153722861505, 0.4559925623184939, -0.5851925941593186, 0.6423850091596791, 0.22341416480787488, 0.026729849985617504, -0.4373323069339003, -0.6751937278465099, 0.4468768848198512, 0.03120824640643847, -0.539801808672992, 0.44532998213346514, 0.6852780836698334, -0.7131404954735787, -0.11481555428784285, 0.15960378382435478, 0.4512014904014665, 0.5782651830948743, 0.1260557797134346, -0.13276393605086106, 0.6403217812437251, -0.3549131693171952, 0.6079194839749563, -0.5565156164689601, 0.25507315678576475, 0.21684329432871458, 0.8083005170679821, 0.47050474123089614, 0.3912422387914672, 0.5502655173555356, -0.08679992492882381, -0.1761190245908074, 0.6714849599782311},
    {-0.45892719773332513, -0.5245441826532445, 0.640789976405947, 0.24788003008580958, 0.1904762967375535, -0.37235914994377234, 0.6184686490804099, 0.04027270407682553, -0.1724953896134291, -0.5756519916144253, 0.17699435846627826, 0.4849889498466248, 0.210564859774516, 0.26423109069403594, -0.47941636625870787, -0.7089890494481846, 0.6717580114506588, 0.12575996145583268, 0.4924615082420996, 0.5717694971966072, 0.4614227679804145, 0.49302035995571886, 0.19264795210921917, 0.13302771390608512, 0.5581779700195384, -0.4749362280354531, 0.17369569718195624, 0.013776465750751477, -0.134810777589036, -0.622389324217917, 0.33514167931457894, 0.6534939620386262, 0.59823696099702, -0.4009999096981901, 0.7455589445735016, 0.12642616982888924, 0.15308628663446774, -0.5878990677322992, -0.8100878705491494, 0.41795810180706955, 0.06284968572178293, -0.6843190857851452, 0.45927477528211097, 0.6207357649195077, -0.4087328135542426, 0.032691173564141925, 0.37905737144043455, 0.04673208183303662, 0.5087940300914618, 0.2634068112060964, -0.20203088464227292, 0.3857845765009129, -0.23786238080222938, 0.4043472664421984, -0.44588758282862556, 0.006705604600233532, 0.14745285927278148, 0.6290150728450271, 0.39692983615641025, 0.4661275657706007, 0.2934759141989441, 0.0468913546978977, 0.007284257706369428, 0.5828127684180489},
    {-0.29788777854534737, -0.4777053194721817, 0.5355291874731376, -0.012689840270193856, 0.15505266662290315, -0.587081006241053, 0.706125119720459, -0.23595219991009603, -0.18537718341944392, -0.6011477947867189, 0.3000483429241062, 0.4363921099939379, 0.11571091390363875, -0.0788302349629823, -0.6721608705333247, -0.4783195525940673, 0.72371863354116, 0.07825406188694828, 0.5946700569882934, 0.22296319826743183, 0.2776101587917307, 0.45990774884688496, 0.20218784877567555, -0.19248642793888046, 0.7114442524721467, -0.47537133264183623, -0.15524204126542068, -0.1453015442213192, -0.19274453600523211, -0.4465099830508217, 0.1303048468120726, 0.6201138133244373, 0.32444249177448314, -0.3550965572006976, 0.6385032568452645, 0.060379179603327726, 0.2675875220034455, -0.6912863152105923, -0.7025928851726508, 0.39075809570234554, 0.24875918974139125, -0.47268527922961323, 0.6669909375900975, 0.4057107341029174, -0.6919597086439395, 0.021444321897197246, 0.44004771265963244, 0.1472005095637367, 0.676789825415228, 0.25674513104201774, 0.030972478723749263, 0.6740656993547662, -0.5894111442967424, 0.39562495845602896, -0.4586652473163474, -0.023198147656073347, 0.5677260046805717, 0.5916404007345674, 0.4697662964292457, 0.7119553301630825, 0.4621472184488393, -0.006055989019649263, 0.21091733605342228, 0.5772579575540309},
    {-0.6032363646480436, -0.5138516279692334, 0.4553914873706408, -0.20090929329232105, 0.12615282044102627, -0.6941473225242786, 0.643828018177243, 0.01180023101700443, -0.2548516884222676, -0.6042856715100313, -0.10367667564865883, 0.3133043984540533, 0.4158008141974558, -0.08424274209683115, -0.37521795074950914, -0.45589478634240105, 0.43745872052572754, 0.2247785558356815, 0.37899122180634537, 0.21761572258893433, 0.31478735739102204, 0.4723527941549849, 0.23034782423060463, -0.08272253407998238, 0.6535635290847301, -0.14717097887616726, -0.2075401757457976, -0.10785461947376741, -0.6059033081282615, -0.7094503030700559, 0.2188622889251473, 0.4837161960322922, 0.5928964993394599, -0.5597438052980144, 0.4438723334506303, 0.25032012656680175, 0.16885644827202323, -0.45117832751595377, -0.4651745017966854, 0.46726068353190725, 0.24968291737242812, -0.7644824230141267, 0.46542053507446746, 0.5446607431387788, -0.7906254715970396, 0.19082986773963784, 0.45210663668447143, 0.31760011111316416, 0.3390159972304816, -0.0009399938732570955, -0.03099860096466447, 0.47570330145002865, -0.39242978678581897, 0.27829061720878123, -0.5726333695143775, 0.3211125933165161, 0.5343185667633396, 0.5738830016000774, 0.17132820598183793, 0.573090214777619, 0.3744162444527947, 0.07839622034778031, 0.20775213669363554, 0.7490600941770518},
    {-0.614483127334136, -0.5953336468632072, 0.1673286784300231, -0.2380789258858486, 0.38368357614137677, -0.5647383190435953, 0.3148683983207031, 0.08427979440257097, -0.4195504336450559, -0.36860422233295026, -0.17157262235745244, 0.18026444767891914, 0.12107164903885875, 0.11949329280065506, -0.28764455283770124, -0.5644084550694551, 0.5745171027532494, 0.2509684899413353, 0.43866694393360794, 0.27581039903375765, 0.1299253076369843, 0.3084146996154913, 0.347815008794914, -0.027690264227396347, 0.629234330661469, -0.1479264964422377, -0.42877859869290735, -0.37540602408818385, -0.3213932875108889, -0.5303867371280858, 0.26502561503742594, 0.562636769314702, 0.5126238243190739, -0.4590206119142569, 0.7109480476536386, 0.05781894796106721, 0.17942832009654866, -0.22119506872303105, -0.800154831888618, 0.4970604219468124, 0.33029542311797844, -0.6897121260986852, 0.518155293854716, 0.4274325240997462, -0.6479833224274448, 0.14745621488234487, 0.19025818621868473, 0.31741780010439896, 0.3855534916476197, 0.08297745156240467, 0.1192420153407005, 0.6840836872829049, -0.401293410529932, 0.46206623860447327, -0.6042435772863272, 0.0918946491650483, 0.2716871965307658, 0.430381508559573, 0.12463437858259112, 0.45334019243942186, 0.43577413625835654, -0.013358175022402824, 0.05958928770371073, 0.5112512778233071},
    {-0.5736715891779717, -0.7433853445202566, 0.19482892133890423, -0.0590672277361553, 0.18805201555264323, -0.5380735739253681, 0.2798119013847876, -0.17430304929495105, -0.1442560420679668, -0.4805706674935399, -0.05385831444411231, 0.3185770601568937, 0.0056806673586231125, 0.4602222569852784, -0.7473264670759856, -0.384839000453868, 0.6334188249471976, 0.16274720204303406, 0.21658907184902088, 0.4654344837231154, 0.2614521099947281, 0.302361833558245, 0.4727709316513886, 0.15512746715708522, 0.40158340594250885, -0.15967580596553083, -0.4841203504732403, -0.26344764126338654, -0.13564334258287283, -0.38901732504891373, 0.22824738174639422, 0.6629684518663244, 0.5711846380713784, -0.15236413551528907, 0.5247325848606246, 0.3291060962105656, 0.012828194361645657, -0.5514655622379545, -0.6520622228417746, 0.3255935711291291, 0.34611780641019557, -0.37782082910754694, 0.31947676908617717, 0.6561109745430845, -0.6594904942580446, -0.11522285537273184, 0.3658496553021934, 0.34714944670495507, 0.519180882313867, -0.3724231711160453, 0.2921230130579515, 0.40806875146810373, -0.3927839634378526, 0.45179003424085634, -0.3447416882424012, 0.011409331239241382, 0.6208189047266559, 0.533486138988303, 0.3112480079169022, 0.5059849569055023, 0.08459151413992201, 0.09154218159080249, -0.14314703317118135, 0.6975497761344779},
    {-0.528013658166078, -0.5918307923972548, 0.23494663277863015, 0.1487540648900421, 0.2528319394046544, -0.5618390290388219, 0.1619216179495418, -0.06772014883163704, -0.4389971877757806, -0.1765015090160363, -0.2098252163933821, 0.2997584934746976, 0.22434664406579996, 0.4331628483020428, -0.7007156046417203, -0.5836185930878336, 0.6280270082627424, 0.2558036800060817, 0.27694131203886047, 0.21433433888993111, 0.3221573802942455, 0.5276561062601167, 0.4290645781940092, 0.09432498735404415, 0.6277515530520008, -0.41350636174316646, -0.2742552638444407, -0.5025888382276571, -0.4204006748457509, -0.5434618427885501, 0.3636704427847013, 0.47534825426536276, 0.42439949934254995, -0.364725026363603, 0.6421166106843271, 0.11511115476064089, -0.16140430291357802, -0.4066269375890117, -0.583613754408337, 0.16374126482302298, 0.2290014491290976, -0.5794671360961967, 0.6006936107134541, 0.26255840610488357, -0.4503093959833172, -0.007613782224846901, 0.27445417335507344, 0.45442248309050925, 0.43758532232435904, -0.08338452015085096, -0.08844297715831494, 0.6272357982410213, -0.29076975122496007, 0.2849173508016812, -0.4902232964134347, -0.14169603232248137, 0.5725786579648503, 0.5642771029070988, 0.04091596635587141, 0.5619705915332358, 0.101493744196602, 0.13076876018834493, -0.08781408764299076, 0.6642404825030528},
    {-0.23392727529771135, -0.6273064851549309, 0.45315035545852755, 0.09105139656782978, 0.3507213827944841, -0.41777652018500533, 0.39339485055604906, -0.30596229637117234, -0.6825069094955311, -0.2875756927792425, -0.007948802706867385, 0.1997763457267807, 0.1533884999677497, 0.46161223403035595, -0.263869845075637, -0.6877557623076556, 0.30666178764118324, 0.2877257954817606, 0.1906031622605757, 0.21390398274374053, 0.48147258849185204, 0.29420584920363624, 0.5085965036340038, -0.10343504514397453, 0.47383016347411333, -0.3509646572509359, 0.03831710783468825, -0.23477022849432932, -0.4758113016490548, -0.4831779544804244, 0.5275127255783516, 0.3664361189376002, 0.4168583421608937, -0.4340577346813861, 0.4918876997863025, -0.05012344345679688, 0.4454936028215623, -0.5227008182341485, -0.7198796457007101, 0.3581805886109719, 0.24559403808085992, -0.3202084751837052, 0.6036135994801556, 0.32194534208109293, -0.6464010796916522, 0.435640527853626, 0.33880400982888004, 0.5875321093401714, 0.5472980575315053, -0.09282233826492171, 0.13216116908343545, 0.533939284383154, -0.40513906826031515, 0.361789826453021, -0.46911121530596306, 0.23721096635151445, 0.4306285077308837, 0.4048061223681109, -0.10548590464486489, 0.5905803396114289, 0.4295761086741403, 0.15590410863239168, 0.20972061647695123, 0.44113829311530656},
    {-0.6209688080615559, -0.6460148382914996, 0.5155596773594888, 0.030450816689529415, 0.1251686364300943, -0.28148348450107297, 0.38994267843259234, -0.10925250584542291, -0.6364882827618014, -0.2963273632955846, 0.2646375376854286, 0.08686252662933215, 0.20924651545025938, 0.22509424095632566, -0.6119862419698842, -0.5790286215425493, 0.5437892589067431, 0.2457744236160581, 0.5798931415988304, 0.6279076827362337, 0.18685683916436924, 0.4381371249604014, 0.2956553045554187, -0.21367817614250317, 0.5180065102434709, -0.3390734380754083, -0.03353836645847819, -0.37030264884825603, -0.5064367896473361, -0.40521200835630283, 0.5681458420370191, 0.46038953931010707, 0.5251760397414306, -0.5682326828319941, 0.6840359394979807, 0.42930699250289267, 0.30132539037518047, -0.6636268329394188, -0.7496591429440715, 0.5400353172358683, 0.3145066521849339, -0.6237428750785213, 0.3663007740129948, 0.6188291388388585, -0.42216183146837005, 0.09887286568717364, 0.055178624107696944, 0.1478867085223862, 0.5848943361493117, -0.09221516751510198, -0.10417500214667279, 0.7424826644451182, -0.22407718290292214, 0.5970029963337214, -0.4196779963792758, 0.013513303683177541, 0.4083756475374899, 0.654656552999378, 0.21816723161478094, 0.6345995002838188, 0.38207792023404946, 0.18592878298775956, 0.10956750151123103, 0.5643621370712936},
    {-0.5058816612807568, -0.4011126809232034, 0.5422077841084103, 0.02873960262370373, 0.17714165343895577, -0.3973889916007725, 0.6146624854531091, -0.24118538885622362, -0.49321812785110225, -0.223183820682509, -0.07895372437880696, 0.13943002401170626, 0.35929211285101115, 0.4175277413977883, -0.5452913304368242, -0.6697334995071973, 0.569723238237962, 0.2968135009039446, 0.448510587708579, 0.5840826571275687, 0.22987899971993345, 0.501172558287391, 0.27748180141067497, 0.16646184182608667, 0.7223237805202812, -0.1939894519970686, 0.12588433775195368, -0.11451544525254281, -0.48020763610432327, -0.4723028497364861, 0.33277749316667676, 0.40651469995038586, 0.5215170560495674, -0.4354893252106119, 0.6289371713448192, 0.36022362073724207, 0.05576160976852768, -0.47544441781496, -0.7593555510275326, 0.5987612787115721, 0.46499643748004393, -0.420654195420656, 0.2286204951227124, 0.4929859506834963, -0.777035299666137, 0.06474589401780909, -0.026345485659344876, 0.045802888975040465, 0.5095210149436249, 0.010165790921462633, -0.0589148409783506, 0.6646669794555108, -0.4982768983966762, 0.3466735314627355, -0.6661361986335951, 0.04493298893734642, 0.5252222802847756, 0.7790335256677603, 0.2952415025162839, 0.28789237696985615, 0.3822350295498759, 0.23387371491487913, 0.21030379510189537, 0.7362382653399573},
    {-0.6274511364373625, -0.36402109323419496, 0.5276250644382359, -0.30711634988311526, 0.3155414110647006, -0.6176699717428186, 0.32458073108093227, -0.16568195640800784, -0.5106377973414122, -0.4419237995145375, 0.2610514312832679, 0.27457220580524083, 0.23743056326914003, 0.13355224649798142, -0.65519005429525, -0.5471891237699894, 0.3979406127931296, 0.4310971602429317, 0.5966186505842107, 0.2690009362839536, 0.32101865151006276, 0.2578254190730647, 0.3275540725884684, -0.10512031663063644, 0.7043179914865016, -0.35169254987427667, -0.08824460132796852, -0.18161493826197106, -0.13818005477529363, -0.5363889762909085, 0.2040973112871223, 0.4169782832796061, 0.6604467047861643, -0.6127274926858616, 0.5870303062916086, 0.2133824103468954, -0.1190974889056805, -0.3971269197491532, -0.5875883336646128, 0.5301253764585236, 0.5688759121542, -0.4905840700630742, 0.48246162268981563, 0.4616832353295673, -0.6883908347342071, 0.37438151248671503, 0.08683278528915576, 0.26497398747106243, 0.6597881581499581, -0.026920925650758695, -0.07777607516063298, 0.6517837021271039, -0.5599700858123, 0.5971889044917758, -0.46794504417890886, 0.16073025470972607, 0.4684326353382815, 0.580839204526877, 0.007158542623229516, 0.5373929237240958, 0.38455511013138305, 0.33421710184085823, -0.008205638773511447, 0.6004488727537448},
    {-0.4787125913395161, -0.3920239056003291, 0.6007605892493225, -0.040877432353612714, 0.07384895970441946, -0.425595597960996, 0.3919203575388943, -0.3112581928751212, -0.2789016539812703, -0.18658951178346556, 0.1884963146463752, 0.09434119243022483, 0.5671920475558063, 0.2995232279804188, -0.6416096331563453, -0.6119195872748804, 0.2937329692205774, 0.12524336297793082, 0.2358388938372409, 0.4583001266479635, 0.2967934248716217, 0.3153127508610178, 0.552030422905431, 0.06602430976499525, 0.5206542387875259, -0.2511435286076938, -0.13688188155043718, -0.4420843363911713, -0.39407243038112394, -0.41588506907527467, 0.5333099683852959, 0.7121183068579657, 0.471802167234687, -0.5287277830159054, 0.700388723078015, 0.19471121401802816, -0.00557440337058338, -0.3479878125432917, -0.8304236772847526, 0.22165217038018217, 0.5254104919275375, -0.5564380787728123, 0.22773520371479156, 0.7549612860996316, -0.692529034214343, 0.34207467871276237, 0.1546473912060379, 0.4354868673305744, 0.6228222825509276, 0.044740097527001296, 0.22000438776061065, 0.42888058494902237, -0.32806495342629494, 0.49510000055738657, -0.5880690706990296, 0.1687339424127274, 0.6080608598728959, 0.45721976821003457, 0.1697375301209414, 0.3063505126596159, 0.43406523313726414, 0.08243215545210998, 0.03546995990861289, 0.6257482637660355},
    {-0.6853337344365247, -0.6224150230578813, 0.4603533133026895, 0.05905334858342283, 0.33587754846849033, -0.6760088147698321, 0.5804315107355351, -0.33911774458378713, -0.5200852525434856, -0.4042123878968356, 0.03786328227098792, 0.43640830692689064, 0.5913144685986911, 0.42086466892807034, -0.7227095074153534, -0.5647717486735148, 0.42919773321175403, 0.13838077168931345, 0.31771885479470313, 0.5917407615156434, 0.5935825252787731, 0.2367229585260986, 0.6235802885261128, -0.034953732523354465, 0.7233279964574069, -0.10498125051471686, -0.14743729205144315, -0.1578261720948831, -0.528041164265872, -0.5882722684250509, 0.27815143043639456, 0.5598528543136023, 0.3755007190705522, -0.6449765029728597, 0.5388352792286922, 0.42413784783312214, 0.24264096830358675, -0.2944122665949304, -0.5295973886629597, 0.4610513053203282, 0.37656783312842723, -0.5858142658513923, 0.30540273374787064, 0.8458038105752658, -0.65635173012046, 0.4634809443147383, 0.17266059262220507, 0.48874478239888064, 0.7702009394290148, -0.23031389494537574, 0.07746899964720334, 0.7121075740235765, -0.28175045585500014, 0.631685936394367, -0.6922196495256348, 0.40807951080586596, 0.3306721593665461, 0.6064102983615528, 0.10648389423758049, 0.37720878103504346, 0.5317383528014241, 0.24403315267787076, -0.0851177060772208, 0.4308348883001734},
    {-0.677334680711146, -0.5717687433793082, 0.6513714010216581, -0.34036755214162395, 0.2760823473111227, -0.6300423303210473, 0.34326573552977696, -0.08020431605742774, -0.40933400653354934, -0.6701009358433649, 0.20896950060578337, 0.3616528606580846, 0.46250421060916863, 0.23033104626447515, -0.672790495225609, -0.46294597543045096, 0.6829270075866205, 0.29691220384681566, 0.42966893543136364, 0.30681624683358316, 0.46875397424244913, 0.36548654698902255, 0.4493237116181168, -0.13495248468119755, 0.7199914211674714, -0.2111031831644201, -0.5528873770010596, -0.23746304206579713, -0.6941177222181513, -0.5700141011701555, 0.3822142451616349, 0.6969621569563191, 0.36008206883497496, -0.4588410839113026, 0.49455891640193284, 0.4639537081982417, 0.1497817906652458, -0.7063657867919405, -0.688422754629564, 0.529864100387354, 0.4194017256467125, -0.7042269510253892, 0.4437616320891794, 0.5468002042480601, -0.6218366868802121, 0.44592141540967084, 0.16787798160657832, 0.16809466601575782, 0.5863660065403269, -0.24691066536467374, 0.1548365320837251, 0.7010992063571959, -0.5351149010554309, 0.6447768893651064, -0.5475454198740297, 0.21133016444189512, 0.6434622888159433, 0.6489600847936947, 0.32253734500500836, 0.5876916264688817, 0.5926684941572253, 0.2691904132871648, 0.17728917754160914, 0.577809705619706},
    {-0.6104572331309056, -0.4993150606041401, 0.6350599552235701, -0.110817254040356, 0.353204920170703, -0.6193770647054795, 0.21150503140960245, -0.18138374770009325, -0.45843548805374335, -0.615975275482483, 0.0029184365068423692, 0.2213277782505684, 0.4644636969724165, 0.10995520961285364, -0.7451605601396478, -0.6157597198888054, 0.39089697459152745, 0.23289378412425263, 0.4871386382331844, 0.6712446037632867, 0.45766098404053807, 0.49405984759931, 0.3229014601824316, 0.10576802566377423, 0.4514913924314485, -0.3118970808046165, -0.4887073945738932, -0.507391579042953, -0.5871338828403323, -0.610062615630328, 0.3838639614614013, 0.7880089694262377, 0.5779394406284142, -0.6738767017391583, 0.7095626821926156, 0.37628722653080476, -0.008738492551676653, -0.5675457210273641, -0.8617123144914824, 0.40771413599990475, 0.6770277738861891, -0.6388959134809002, 0.6011382029654313, 0.5809954395172592, -0.49877752096348577, 0.23682484174743376, 0.3003057373844264, 0.47689369100520485, 0.5041914256919113, -0.24931073521969502, 0.0599284819775165, 0.5622110912657097, -0.5473098025051675, 0.39533928119241685, -0.440789294786444, -0.10746626177633031, 0.49072966101342724, 0.8044289564627619, 0.29404176453910247, 0.5713809277971993, 0.44766479837774026, 0.025560796106173157, 0.3034990384255447, 0.6312081859167028},
    {-0.5597471415904732, -0.6141330399538845, 0.3518490072897101, -0.2688261957053092, 0.4648492666181696, -0.5389983405358536, 0.5411547140038548, -0.1522987530525823, -0.6382522669292169, -0.35620206425803974, -0.16873423003364268, 0.1268267494345897, 0.2947748703149155, 0.4214124449770004, -0.48299738912612566, -0.7905151516632782, 0.43423464635975395, 0.021317881804027612, 0.30847366668284365, 0.605114457231418, 0.5158192695063876, 0.251337196886103, 0.26386190061368686, 0.015168432983629118, 0.49975661543666966, -0.4034312462537795, -0.46704670853829394, -0.4950594979536464, -0.35305786485067764, -0.571589155007003, 0.40561152368732456, 0.507843382064969, 0.2964557010114385, -0.394442668522594, 0.5319482974506134, 0.17642045939088247, -0.1263128404009627, -0.45177876513862775, -0.7031917219919773, 0.3179021054882138, 0.7045527361294281, -0.4522426798006204, 0.5624981567377799, 0.7932267087069707, -0.7719113048772971, 0.2874678420084204, -0.05120023053813835, 0.44212874431262017, 0.5051176804307955, -0.04007180824635397, 0.0246969019877263, 0.8011022155983145, -0.29130553949600885, 0.2658999297209502, -0.7299702534219457, 0.05245618056648467, 0.3131141988123876, 0.6099407932611315, 0.16453049410798135, 0.48026177861063546, 0.32267417089408174, -0.09657648249191228, 0.24519191399806847, 0.6852293531838658},
    {-0.6101873999144181, -0.44336673303509233, 0.47198237276457594, -0.21533800067719422, 0.38195994108970593, -0.3138560207932124, 0.34008610924950955, -0.17627550934650846, -0.3289527873924, -0.5278961998939475, 0.0739648103482402, 0.08694690157393277, 0.43793957131828093, 0.23865938090905364, -0.4473475179609987, -0.8077258651735431, 0.6064132470839424, 0.20309701450157974, 0.12089884345915, 0.2761689442100616, 0.5170878194711145, 0.2390221691493688, 0.4788493727977277, -0.17313880136971024, 0.6919490094518768, -0.3672866258338837, -0.32843901274424014, -0.33643970441505877, -0.6022122749380159, -0.5657974648122226, 0.15543290521187017, 0.6189834594009452, 0.38295515895872206, -0.4462885990877432, 0.6260321469551006, 0.08870100863225623, 0.10239652609477992, -0.5504367600703561, -0.84563258556883, 0.45233887777696624, 0.7190631184962651, -0.84759306668617, 0.6065977307127511, 0.6553139038183243, -0.8331167638998053, 0.5006968511539651, 0.1911437876132498, 0.42639268167372363, 0.7629626883206401, -0.32880146443944425, 0.09653298064843593, 0.7288337464180135, -0.4037786978707549, 0.6343937754055592, -0.7737946678483202, 1.1536329597279907e-05, 0.43345134421980086, 0.7494082478807742, 0.21302547440353317, 0.6112048810105721, 0.25942605405679603, 0.033381256102704655, -0.010851017989513694, 0.6246401346407479},
    {-0.529687835893745, -0.7892744238129555, 0.4368619407923383, -0.014111822911928036, 0.2895508341100172, -0.3400855962748626, 0.45605215899171203, -0.20484989066101306, -0.5393681358356092, -0.4402269916244232, 0.05955712041886973, 0.2074218816685116, 0.5658397959595872, 0.03392367507689857, -0.6852049738283412, -0.7954435272322368, 0.5448872580498838, 0.07993343013590688, 0.13648746650401553, 0.5679242495422285, 0.617851977380833, 0.42426795707565435, 0.5326694565366831, -0.16996079085678714, 0.7767523583188334, -0.5350786773370834, -0.5324247332286762, -0.4190219406427701, -0.669061148169763, -0.619057003242632, 0.2879782037535818, 0.6975564311905929, 0.5375259125072744, -0.4764430236916185, 0.7084244258458772, 0.24909483186617318, -0.16537726824289728, -0.532017769423959, -0.46519646841852574, 0.34192903833996646, 0.6276349256190107, -0.7632006549191818, 0.5482260551531593, 0.7302028219837183, -0.5232928253360118, 0.3653567407616081, 0.3375581796058083, 0.5911686835637023, 0.49461616278930715, 0.0021214123003971174, -0.10773785510756646, 0.6894835647350853, -0.27403465419526396, 0.24072323087886166, -0.6571334114807933, 0.0822928886577061, 0.6231365957787968, 0.7315142163340499, 0.015890022444689615, 0.395525013993743, 0.3447826677512843, 0.06938288614024368, 0.010520534229800088, 0.5054163004470106},
    {-0.4787408260281488, -0.5979890812405781, 0.5811703934276086, -0.06091792388733018, 0.029463004008055935, -0.5044783537208035, 0.6162127967682479, -0.08607842710099822, -0.3960417704781213, -0.6285371736216478, 0.06394120189264497, 0.3761732592862404, 0.5369719273881702, -0.008954261254923733, -0.6022389975815754, -0.4548891546812156, 0.35070966803817744, -0.04635476710454168, 0.12916124391942524, 0.24720854018485242, 0.4022438343481738, 0.26769719068475245, 0.2938277062918409, -0.09152251146554014, 0.7506269651285571, -0.4255220755297541, -0.3987816360826258, -0.35617366019133384, -0.6519358854037204, -0.48539692938554097, 0.14532689224106454, 0.5212322833657276, 0.5762939142757282, -0.5815922189328039, 0.7215299753153688, 0.1699646283694902, -0.253078837666258, -0.5589322451720036, -0.6749831814410951, 0.26479083183469054, 0.4106780321832992, -0.7404651952289746, 0.46637211058986006, 0.4881902900228801, -0.46198822891974817, 0.35080459295306865, -0.01233553314812997, 0.5458102174237983, 0.7087827894279422, -0.2730520689229894, -0.1641299016896345, 0.4817818366268321, -0.6030398332340129, 0.2509153379268613, -0.49934259799409153, -0.02727152952933695, 0.34639856443870837, 0.7544772190595201, -0.10586220384814694, 0.43845020045710054, 0.45419500126969087, 0.12754524592316588, 0.0370754268798764, 0.5906802015223901},
    {-0.45810615514873765, -0.5589529805188224, 0.5855144379077265, -0.02809864929112691, 0.1333105004918456, -0.35951748692034224, 0.3415344948729174, -0.2486187056596746, -0.5524086774639761, -0.6541205367283905, -0.05300715822868374, 0.3482993013358022, 0.432116659557275, 0.27075484552730816, -0.6017076085960155, -0.536405959567082, 0.45303752203352193, -0.033484412042426845, 0.28249626424748936, 0.291581492358045, 0.4954422413995573, 0.4990885557723737, 0.28564643349625646, -0.2691435704448729, 0.5706264730002467, -0.3687831910837822, -0.46199403121094695, -0.24937587365047462, -0.6392438047805663, -0.41444196489249546, 0.46751965422468056, 0.5894986290965666, 0.37252746086787414, -0.6709462143788025, 0.7003006623210507, 0.1216359290143009, 0.010192834502126949, -0.5750550421477745, -0.7111893369800178, 0.17290824625417708, 0.6601661183025292, -0.6731696122355718, 0.2920000775971317, 0.48197149902544806, -0.8235165184727934, 0.5327792852794994, 0.14766585358981, 0.3657565317917135, 0.45677867494230034, -0.2948882020478139, -0.11126754739122495, 0.5501122732116512, -0.5927964101304295, 0.36429825518015313, -0.6153786535902008, 0.02967984170646784, 0.2549406781269248, 0.6504154155576707, -0.022647116283854733, 0.43746464843720656, 0.1578986363848527, 0.08249494344171632, -0.2698675429754362, 0.7021836485772589},
    {-0.5845902591091785, -0.7307839738194831, 0.5205846905547542, -0.11107111585421107, 0.3408482629096007, -0.4728869853281111, 0.19613694005888488, -0.1123230358721506, -0.6577309656623367, -0.5460665705658848, -0.07360819103298744, 0.08326512552477586, 0.5302146300374933, 0.16167442239339344, -0.615847010831543, -0.4500263607978743, 0.45855030127256563, -0.13909175269400118, 0.3688432899510874, 0.24579103191830495, 0.28793134196238046, 0.4788611568796868, 0.25840925875041665, -0.30330632469775815, 0.7667710277214882, -0.18007265298069328, -0.5347929740859725, -0.3794989283070567, -0.6379437668718632, -0.6639342546868381, 0.18327743340748326, 0.6908723419282798, 0.17081497668085383, -0.5465894529749257, 0.571658856476513, 0.3095632390899896, 0.05504958189359965, -0.43639625381146957, -0.6185982258945175, 0.158672398472701, 0.6548184729011494, -0.5802692489208537, 0.5710341415686385, 0.7303023892331606, -0.8320497604326724, 0.414973035170464, 0.3138213756308999, 0.49779141313346587, 0.49736513481706685, -0.280933573226131, -0.15197270421430306, 0.7662233073397283, -0.41529266732603665, 0.4772442587067479, -0.4476809808613063, 0.11948976766805094, 0.4166917740549798, 0.5814025684640128, 0.009284787689019325, 0.5766777329882561, 0.4531402871328947, 0.04516946720593499, -0.036746225533708085, 0.7130661277927866},
    {-0.5673104478913081, -0.015607909539490556, 0.33809948909291143, -0.4027408267013173, -0.6892844240884174, 0.0797894498885749, -0.06539052457268815, 0.3984296781709106, 0.4283855584296697, 0.0584624819199123, 0.6383883678457729, 0.5982454718197935, -0.6593313654580268, 0.40510497032617077, -0.0485642464037367, -0.058875531744764335, 0.5179609160262736, -0.5580762151089341, -0.3485569827654465, 0.07555140682918683, -0.521182030405057, -0.5028336534512414, 0.48646773759541273, 0.48428953250865747, -0.09830363066783739, 0.34500893625559237, -0.7401509333008957, -0.5725113684213888, 0.13467675760825923, -0.2858545728447131, -0.4572194783406615, 0.3263359594469145, 0.2776651531722846, -0.0578818054049677, 0.1445166328426991, 0.5444311059917012, -0.766109709644306, -0.7242625447800245, 0.3839825883146873, -0.1429716266290703, -0.48246230892103553, 0.02057820466361537, 0.5498754624339682, -0.15904844726620843, 0.07052511934738366, -0.42696938668332457, 0.660935467845664, -0.7103305875799891, -0.2736474146443455, -0.5560289049198842, 0.5230417436565726, -0.6048544709998019, 0.3412025111060034, 0.4147222798197654, 0.17101556271171237, -0.7495032203051831, 0.659598990492771, -0.04091969371460466, 0.6867161045874483, -0.27682069371774076, 0.2710128698635375, 0.4597974470623014, 0.0014596479009621438, 0.11138055231489749},
    {-0.23530967118672905, -0.2289506208112736, -0.04608376931159066, -0.3068832807281068, 0.1505116828990308, -0.370025502871042, 0.026571843296427627, 0.012924915302668944, 0.21475040926155148, -0.3469971195086501, -0.2007745341662096, -0.3281917781475863, -0.3497247988546812, -0.365686909085393, -0.30892715145915756, 0.02506659892910596, 0.01177337019214021, -0.3128616514673785, 0.13360980790780952, -0.12186998171074537, -0.05818532144862923, 0.027512806997419082, 0.22765502314566421, -0.0521692732770489, 0.10624888718290011, -0.43432104480715794, -0.3067298172802914, -0.3655170306201336, -0.3291411305303743, -0.08359855287393612, -0.23242935562886635, -0.4377309439840319, 0.040888205593649224, -0.3815737883307071, -0.14397085897676615, 0.04814242650766089, 0.013459308929644056, -0.2971068849829606, -0.16969651786281212, -0.31900180059087974, -0.1319861491915607, -0.017728218948840156, -0.1142165559278235, -0.20256797520106015, -0.2576666553050155, -0.4320757857615801, -0.4472879275044054, 0.049705925941905225, -0.5007895187445783, -0.22420269325088688, 0.013966397046777221, 0.00035285954993511895, -0.011387638005018472, -0.2827933856786654, -0.1387099837009095, -0.004687450396512358, -0.36449968184947795, -0.2716192957901926, -0.3910205521229629, -0.32078531108365116, -0.25025756639450575, -0.3777091511194411, -0.43427420793885796, -0.15585258079544023},
    {-0.5560378423558661, -0.5483972510791119, 0.3396225115886867, -0.5337389064927202, -0.6435403959064784, -0.38702715568864454, -0.35671339178612876, -0.4784210028195317, -0.1386715336778076, -0.5772445553430493, -0.0829429418110566, -0.19412783622478522, -0.722602172530168, -0.6105566502630697, -0.152314418909257, -0.4755498528236383, -0.4220712612502407, -0.40621018753820576, -0.6574059604299874, -0.46882109274655864, -0.3267490932301813, -0.214073369834617, -0.048542496493548255, -0.19188962874536314, -0.3524613825275902, -0.19248438452123917, -0.48616662801342175, -0.7508801219006243, -0.4771565334052713, -0.4366453705724293, -0.5565492784072358, -0.5458003833169441, -0.07741366742267532, -0.21189847876245055, -0.4630905718582083, -0.09100899160503519, -0.5111509412469218, -0.34543382816402507, -0.16055865650420942, -0.4418233582645436, -0.644395171903818, 0.02751365208391815, -0.3527478208127625, -0.40603798032265787, -0.2933372572885004, -0.5522415625662387, -0.023477088386584914, -0.14516145401285724, -0.6066269543153673, -0.5513720340314507, -0.08628384611267288, -0.5525541996384565, -0.25465764943110314, 0.09965039587513044, -0.372976731617793, -0.5020183776801901, -0.26268825006478635, -0.5823228046304741, -0.41831944812530863, -0.3675534031500904, -0.29026845343209506, -0.5907276956635422, -0.55807134182803, -0.6580070033745447},
    {-0.7288089039911786, -0.33768478222717263, -0.0671811575365711, -0.4282091276261566, -0.403828277968247, -0.3126755805259612, -0.22644279592103064, -0.4272272392095863, -0.5060452643343863, -0.23444182815094286, -0.1662395180587506, -0.4647593543545383, -0.764483418544592, -0.3083322724766929, -0.16100639514203635, -0.3254387584842672, -0.1490115503790446, -0.385523820317676, -0.2664200389688864, -0.4075562678224851, -0.658094031847311, -0.31190272056474533, -0.058677242406753434, -0.26047496514394547, -0.6257158465983617, -0.45097676421032595, -0.3172072929907862, -0.5925484199317717, -0.3829737857629265, -0.2470564736413483, -0.27956258192434036, -0.5166265009854027, -0.12280148242826842, -0.49814203529364465, -0.49508092901819684, -0.3541315292714736, -0.3856403167623488, -0.3256609437913481, -0.4967499909552076, -0.2663594544811239, -0.41620738169571847, -0.18502601062295174, -0.5130697584347903, -0.608384599094893, -0.18136817088123786, -0.38631849662134105, -0.11549176682897601, -0.2966934758232711, -0.39532157894370684, -0.45030361034488264, -0.4087678790366288, -0.30124942387684306, -0.6151896027899674, -0.24826227287495514, -0.47311371024741694, -0.5482544084220525, -0.5805035140460745, -0.1552599530676543, -0.17585246546528366, -0.3824614244465106, -0.318398523171161, -0.3318401951715594, -0.48849354583420773, -0.5227216277818006},
    {-0.43275284709566086, -0.5500743104735673, 0.06117973962284764, 0.08106326181364583, -0.1764280212651845, -0.4608380494822195, 0.21107459763337272, -0.5229766440730053, -0.2688773136284522, -0.3342610527034521, 0.08971101313524563, -0.3369072243316071, -0.22505825179599173, -0.5142330750717307, 0.22733969829223244, -0.1688505644726099, -0.5014866678955825, -0.5153181179992634, -0.3644811002385965, -0.21600252563356717, -0.2669461089337343, 0.35136639828475513, -0.18474886352180397, -0.4316314693047232, -0.2268189879618941, -0.3025134075729633, -0.05255499488696856, -0.14740321170280302, -0.30765281862954896, -0.22959157044285475, -0.2991369461116062, -0.1908118430803975, -0.47483618067955174, -0.3766456133712164, -0.27999570087589987, -0.1001801661219821, -0.08084530962875158, -0.4146400307018063, -0.1736577999893228, -0.03568529265223298, -0.017512604544872867, 0.12101774286257191, -0.3446285921287337, -0.6002521885186975, -0.1148647971157946, 0.05573115179692267, -0.10747863722556382, 0.14103067032712643, 0.010880166857382436, 0.23042466672145798, -0.1384008118551339, -0.23897325321179566, -0.6872918537731529, -0.2641514661923502, -0.591661974614357, -0.13048266045776274, -0.39187440341118956, -0.3008308608988875, -0.45772439224279227, -0.0381313312103371, -0.4602744363941101, -0.5260112002796232, -0.36056404360460415, -0.3528306112618105},
    {-0.08102835355627967, -0.1956598581221685, 0.13942953773896147, 0.1570052465429901, -0.270406351277704, -0.5792092911324164, 0.2882062798532059, -0.5137665141477803, -0.3415560830631144, -0.48777071623001717, -0.4032422467687844, -0.4682660385043611, -0.3195803826244582, -0.5631985406723804, -0.2790773559339863, -0.2483316759680436, -0.23337266941388807, -0.2600388686464928, -0.37413669191190446, -0.21715795353890238, -0.3376517658687133, 0.007735238566839533, -0.18784688696356003, -0.4683856358697783, -0.3566351439312903, -0.3472139178615308, 0.00836679834157384, -0.316988977177913, -0.40451542726825956, 0.011163919932158447, -0.40225352797777, -0.5493379054230342, -0.5170862116661171, -0.4983036119516862, -0.15401024832781735, -0.5549870847262629, 0.14020811192065036, -0.44900752423890933, -0.44585001261432217, -0.5690648658915896, -0.20028958946425854, 0.07852870732575692, -0.09945276827987556, -0.5396279461434178, -0.00016625336993628917, -0.4117958290480004, -0.3424066803119643, -0.07872104018684865, -0.192168920876863, -0.04335797596747242, -0.5270756292734702, -0.361507013345025, -0.27158953956146303, -0.39676966957867194, -0.2668274662991423, -0.030145089695899168, -0.4507684293481255, -0.20743862017693712, -0.5055317745815052, -0.2847412747453433, -0.7025908988082408, -0.5617000534623615, -0.41697355118586144, -0.5760796474713101},
    {-0.24270040855644323, -0.441892195003268, -0.025355385396794675, -0.1891701858619781, -0.1858569828536517, -0.5250904442135931, 0.11802800148664364, -0.4185666304572044, 0.07467967145827299, -0.4412832582482711, 0.16981423968138964, -0.06977101568278408, -0.650983590988065, -0.34136767946284985, -0.033559557412276245, -0.2389701682950449, -0.29585918515590803, -0.4861319070252074, -0.220590528216049, -0.08761698248773762, -0.45287738901982455, 0.08253699483809208, -0.1604536617842817, -0.27126847179011604, -0.33704487564321794, 0.29820569160725346, -0.1926171714835268, -0.4329120362589884, -0.42487544809368466, -0.4462060035733425, -0.6685496534458576, -0.15478564884872553, -0.2512687329417494, -0.5895282415976095, -0.2690350448510856, -0.32237349634005324, -0.38407060307670426, -0.5018749975204293, -0.015626356235105544, -0.5383615976202951, -0.14141975368153714, 0.19973223724162276, -0.01794568220645864, -0.26912805151177155, -0.05691086406423481, -0.11542576001338613, -0.024836004397579513, -0.4138653143611974, -0.08779073331966487, -0.10807815155723541, -0.31716842073210627, -0.14045031560332139, -0.534744642909591, -0.09810346902745007, -0.43653720669115686, -0.14470555055563666, -0.1313013799474059, -0.3562149292025258, -0.3641734739441657, -0.6186491238693754, -0.6777886238680148, -0.50859408738305, -0.3289155643645436, -0.36698466186957085},
    {-0.43936544779638126, -0.287019938602076, -0.020099744101638006, -0.34039665472461084, -0.12813169557574847, -0.47598323554442057, 0.0821958001455347, -0.17539313780158086, -0.0023095262104166426, -0.506835649478399, -0.053085931214714076, -0.4672548971862116, -0.6128028024565095, -0.16082083150831317, -0.13882061771527673, -0.31477114596486, -0.5705879520326212, -0.4326338460916505, -0.07373504374569588, -0.4022294188955426, -0.47772334647685694, 0.17204745467213922, -0.08221409865656608, -0.19975323650986657, -0.15951937846654055, 0.18380067621117765, -0.40057171292231114, -0.1622768146387576, -0.1906733140824286, -0.3683041337494907, -0.6887130378541817, -0.14868332160919637, -0.4231343665757416, -0.2651687640986932, -0.28697039410893405, -0.4232256185243902, 0.04204823871000289, -0.19526719686162386, -0.17674100194639913, -0.461532902243403, -0.43298527954734517, 0.13477526086976324, -0.46234966640254466, -0.5467390163053284, -0.2757934382912309, -0.35595279904796967, -0.45663848081246783, -0.01365214864609208, -0.3713281134013866, -0.3713076934204874, -0.2841401816390944, -0.4052217249979339, -0.6005091200318177, -0.4208083657364287, -0.5703514733425666, -0.06991545134794136, -0.5200923446706195, -0.26837933296102473, -0.478079526549868, -0.5951642525150281, -0.5063520009659183, -0.11322802539306863, -0.5403605755940465, -0.5646124410572664},
    {-0.10246688011169404, -0.6255834970574321, -0.1977788675762679, -0.20753200417350837, -0.32311726817370506, -0.3188497672917511, -0.2393015149429384, -0.4656268821157921, -0.10207480607389953, -0.6691447470204538, -0.012259189251581558, -0.5242290439090649, -0.1818960016811543, -0.22596933310133527, -0.17100766830499248, -0.110555769681698, -0.41165293914966183, -0.6045541817785245, -0.35319418673871134, -0.4926201106985044, -0.32165444311749647, -0.17424252954207547, -0.3077352813551973, -0.39608326363499063, -0.598526924380141, -0.11218764880086274, -0.18218364276445426, -0.19839409568303648, -0.45715769459761524, -0.16101613077998664, -0.602550174425386, -0.26751135471928733, -0.11403497424461782, -0.26890036710166254, -0.37394126876786793, -0.6476982679551382, 0.02261066209108152, -0.3983683686852032, -0.5770062513731905, -0.33963150949956056, -0.5533599472789869, 0.03283891947383481, -0.405222832771165, -0.6426363971581417, -0.23693386418071094, -0.12932308482351276, -0.5860993065711984, -0.38887167742709455, -0.24224659623187325, -0.13793259829771864, -0.12994052615912982, -0.4432978647170051, -0.36770124235036417, -0.16142905873472196, -0.6010564635093758, -0.3805517729796722, -0.6436766336049774, -0.17383860947292606, -0.2947246228060624, -0.16534176341736392, -0.4970138128363059, -0.3708864240624634, -0.46170139154842066, -0.45400727477110225},
    {-0.09242072268886552, -0.22266633845008274, 0.057435151803628764, -0.16492665712760765, -0.49221637977092764, -0.5600676481585688, 0.3903384485928077, -0.1935072521906298, 0.26819480772112525, -0.4279231790850075, 0.10055071821447248, -0.3433268426369893, -0.36299588337661415, -0.5458723660427831, -0.05408785156921009, -0.34363808614194036, -0.4371038419843696, -0.6416679304053033, -0.16756838383367062, -0.5077207705420125, -0.32643487623323464, -0.1947373102308237, -0.534786437324093, -0.47725939625716834, -0.29851726872758627, 0.31353329093846033, -0.4049703982723202, -0.4164784251313061, -0.27036249473815505, -0.3106035280634303, -0.3964170012485958, -0.305700090786563, 0.06677426650608617, -0.4242810577004174, 0.08920897368182279, -0.253075048772402, -0.2537436817909769, -0.50465430585024, -0.4045481353071931, -0.16194286986653103, -0.5881853550629516, -0.14646209097794383, -0.40539596140583556, -0.5036548268040734, -0.13115076085721752, -0.19627918265404345, -0.340772120014193, -0.06400624544372688, -0.23045357945970327, -0.2569647997896942, 0.05282939567984208, -0.05195911714277038, -0.2897980145424851, -0.21234707821404952, -0.5117772395624965, -0.26745408238790475, -0.2952980289740398, -0.33018708605241426, -0.19238596496416194, 0.04990938101239351, -0.45175463492709417, -0.5712452952167073, -0.44982827559769106, -0.31384159534659833},
    {-0.15417814832464563, -0.25469263345326326, 0.3435906909733589, -0.09650526011850609, -0.585047801403935, -0.5231348079058645, -0.03126160676728631, 0.07952184711172937, 0.2645751826456712, -0.4521076857227201, -0.07773794441660808, -0.39463183872323887, -0.29594817288685693, -0.1837059768035585, -0.0445525828834997, -0.049788295070459246, 0.012180543910471159, -0.668205294585306, -0.3439851811756987, -0.49259220846422835, -0.24133168179487274, -0.03223341809962702, -0.17853348945892983, -0.26940048211100215, -0.28369262267531675, 0.45653284260562405, -0.5875276073821568, -0.421676046324928, -0.5664778372305508, -0.4078083551765441, -0.30858363845565806, -0.15138508663750502, -0.3610953477036991, -0.4606741455903481, -0.405028671121416, -0.005598757381967044, -0.3412778373293108, -0.6998907828132973, -0.4053688975672358, -0.506140707973329, -0.336243145710827, 0.016752135182389036, -0.03753206445201042, -0.27306239460977216, -0.37364200138289533, -0.4300662323628135, -0.02929401198686349, 0.028595015687661623, -0.22147257483291394, -0.34243855608337104, -0.014849884848784531, -0.15228664285098584, -0.45281946919676563, -0.20392459766177454, -0.047448440366783445, -0.5267128109591825, -0.0487462997676209, -0.133719384458582, -0.3476674421616378, -0.5153306243402062, -0.25788768050660715, -0.47368299256031965, -0.48082594992899813, -0.308874386267632},
    {-0.3648823733125791, -0.4909861803660945, 0.34943626867186756, 0.01728336467622515, -0.3219035622327442, -0.5999279406645752, -0.0021921295546889962, -0.1942522041987128, 0.3024612984815485, -0.5430625272416028, 0.14322868444702064, -0.1662946586595721, -0.696615390646476, -0.2424950062867761, -0.1657712827257385, -0.4528664028886468, -0.28140487672792114, -0.6624882227991448, -0.24934368948538865, -0.25265715219474294, -0.17954933924401925, -0.1145635886551713, -0.22596637700791003, -0.5161557611403346, -0.6172850872055802, 0.4836011040005614, -0.31696224541603174, -0.4778699247693023, -0.6284861065318049, -0.3026533583466202, -0.4156987412874691, -0.18720205831782913, -0.1471220770139493, -0.5150480477644431, -0.19209649019897462, -0.2892291531954883, -0.4635019129319602, -0.633010333229811, 0.07264522095378903, -0.41884508808014065, -0.3448240577720513, 0.27313651194690125, -0.10463525469079468, -0.454573330943616, -0.08749306592113318, -0.16513357336808837, -0.27613452468758376, 0.10330305440797981, -0.27491809747748086, -0.3966858974009787, -0.1755937023680628, -0.3067712493161025, -0.6431597095533061, -0.2892951983895227, -0.26293324383887373, -0.42988183667177543, -0.5332846419633579, -0.19129914654233662, -0.18080579664702942, -0.3400901710606586, -0.4677906361067436, -0.25289364268706144, -0.6881163623555048, -0.523746651225877},
    {-0.19478442735145546, -0.27926416795825404, 0.344596343617681, -0.09603022081066105, -0.16200944442663162, -0.5102290009082862, -0.12777479242113185, -0.32658213994762153, 0.1351977105198966, -0.3244673871137245, 0.036633285103341066, -0.41058893073984265, -0.6572780623422441, -0.5068111746781888, 0.043621191602594304, -0.23479591716312015, 0.03525914236629532, -0.3433961914821892, -0.25157005132890786, -0.1776987394802505, -0.26678337674052754, -0.1215977541063, -0.2329850186466903, -0.11726294380846435, -0.523795736099975, 0.5305055656447253, -0.3514009654083882, -0.41989985929869655, -0.5475675378884821, -0.4035374179963261, -0.6598270700889277, 0.009765219041563477, -0.22104632843465033, -0.19597888166995892, -0.322641454638001, -0.4491676163756748, -0.38325188900074164, -0.43381136519769825, 0.026449770667689124, -0.30315281162129926, -0.1411657381651658, -0.09387429194334548, 0.10263004941125026, -0.15631448791480515, -0.28907670682563535, -0.3370697780856672, -0.04329748141214531, -0.00611735484572982, -0.2653728756363163, -0.5076335780151381, -0.018444279014248735, -0.45436196010178187, -0.5678604605199091, -0.02949560208876041, -0.2831133291042875, -0.37938905823379016, -0.32507351190503697, -0.43747891200555455, 0.15988667254049238, -0.1338862402447578, -0.15788249793951042, -0.20666559376748783, -0.6723969651547391, -0.33435566809870176},
    {-0.1658760673492323, -0.46155950830082115, 0.0577765603573668, -0.06170709562350748, -0.18983541184912214, -0.7143798913430619, 0.034227967739046995, -0.3867998967128331, 0.0578753465775541, -0.34130761620118716, 0.18121349950385937, -0.02261077072269116, -0.490701493497452, -0.5695480028482041, -0.029310286036346646, 0.03822041158796645, -0.2339200767420682, -0.4147983894497648, -0.29191546251781225, 0.02033164071535634, -0.34796934581747935, -0.08437275340504811, -0.21327261985905027, -0.34737797985144514, -0.3403480192995462, 0.6012901727163908, -0.40708687193486337, -0.6159835907512556, -0.5393795121100318, -0.07305928034962347, -0.5589443293966374, -0.12762300762634313, -0.18435541734747635, -0.26395718163255555, -0.12990145815728865, -0.3822213138637223, -0.2783136070013493, -0.44044911353325983, -0.07357257600353305, -0.46380411661507753, -0.4313178461648378, 0.0909656000870315, -0.04715006311694016, -0.4773812847064254, -0.3030042867179595, -0.1675762285335433, 0.19576501721854705, -0.31681543437685045, -0.38992521448766376, -0.4360682866319412, -0.2641184144881734, -0.23951197424887508, -0.4985520924803908, -0.3353176908659176, -0.6345328523423851, -0.27399756738558195, -0.3354372629567415, -0.22800475768488318, 0.07991835296899774, -0.5503025029346529, -0.3492641127005426, -0.2902549698381291, -0.5718628395002577, -0.38310397066826946},
    {-0.3286924519558037, -0.606273989940622, 0.20567598792717276, 0.05766035859117769, -0.4712076674313803, -0.42837609911238905, 0.44041224451369637, -0.34637731897983326, 0.3473819587562782, -0.6799623783305369, 0.4105982017869281, -0.06284003739425613, -0.461851621020818, -0.32724670435599745, -0.16004057787460868, -0.051277315646307886, -0.324815960864315, -0.5895242874531671, -0.5559482221790506, -0.11743446890300797, -0.26702263593266096, -0.21952785638872535, -0.20762847717144983, -0.4815088615491656, -0.24068234582162104, 0.7375310379186193, -0.21721875458985132, -0.45712460761499296, -0.46081703976588995, -0.13109886323080552, -0.4913434323639344, -0.016886796870016443, -0.32498295831824886, -0.37873172157164103, -0.12872485371450396, 0.16025032641498588, 0.06986089850316923, -0.3521153514119536, 0.05806446125495927, -0.26967082393524483, -0.5219187605899438, -0.041841425500031545, -0.24068529788613277, -0.5850880121836959, -0.025146841176824097, -0.1250178872905103, 0.1683035704105874, -0.21792966307044975, -0.5499909521385754, -0.2749202624363487, 0.024829305351979893, -0.18482448287410083, -0.3491635019427315, -0.12165713558555306, -0.3768445075848811, -0.4731678360459189, -0.49483119080147925, -0.18214021619928208, 0.2470382182442865, -0.39029395883292883, -0.6002736212028592, -0.2335492347995842, -0.6650993941431693, -0.5284670790241434},
    {-0.6214013828566332, -0.44340279154907253, 0.16665379377624645, -0.37712320472468314, -0.5884005668121284, -0.6625210261378994, 0.37390766130166697, -0.25688082935139256, 0.11839860513986936, -0.6976341179488033, 0.37844849419825977, -0.23927412594893663, -0.37352786825421574, -0.5110341007524081, 0.04522298776280275, -0.30382295118222613, 0.047393322216386646, -0.48944493854469895, -0.5717849204090161, -0.28016909767628895, -0.4015954799381138, -0.019156218490153254, -0.14113181830650706, -0.31816828724371277, -0.5347014285876359, 0.40587462227684323, -0.4685930240958686, -0.6854864422002706, -0.6283894889236411, -0.37736468685710034, -0.6188155581328211, -0.016983989779514923, -0.2837377669122253, -0.3886958054787697, -0.3959613341874921, 0.09087946953711395, -0.25350194776669394, -0.4224113665511347, 0.02348673830210451, -0.3754555714563354, -0.5552986550148094, -0.3365680260478773, -0.24323782913266032, -0.23842549413419092, -0.12616819127718826, -0.29290581865389437, -0.1290724540423644, -0.4462137343707787, -0.5920444905744257, -0.5704416293636454, -0.26855742621238765, -0.30045541857426844, -0.5767299611304257, 0.030041602261061163, -0.3865257319761979, -0.479772802510062, -0.37381201915610873, -0.42020660432763585, -0.12277956936106436, -0.2724350334821806, -0.23892042988102738, -0.4049538540880959, -0.3713615307849516, -0.5446762394701516},
    {-0.27948081002163633, -0.2528331601733468, 0.4918390374350273, -0.4919432168351987, -0.5232989655388958, -0.26558728668893067, 0.2886006929183325, -0.30482986629322834, 0.14045231329721627, -0.5190152819775404, 0.2535882475982511, -0.3601495942839167, -0.6767002110890702, -0.38346796817205314, -0.14500938976393912, -0.12901562691066798, -0.1766989917994785, -0.36775670361714335, -0.5000689358554413, -0.5276752727589689, -0.6277878578443665, -0.08380407537647719, 0.006050114889662112, -0.27559635595169696, -0.4690693387873493, 0.5452014759101772, -0.5096015761761671, -0.5171388330625353, -0.4287153189229839, -0.5355111102509592, -0.5042430471085836, -0.28551155784836246, 0.05345608691724825, -0.613890386325323, -0.45436072952212725, -0.14927683771658173, -0.1177375874842526, -0.47713692609761416, -0.03649661619785204, -0.5785477175477965, -0.33056253205573166, -0.03033819532534966, -0.058226364233685, -0.6594283637279634, -0.23865346061235962, -0.6516718473241652, 0.2014635804001474, -0.03202021016498037, -0.48689443196778964, -0.44805469247040286, 0.18447834095270738, -0.5634911913298423, -0.5330353162628259, -0.2558182445750244, -0.21593577308949924, -0.3245041411285692, -0.14532479898231349, -0.3932252855897576, -0.19178411737371817, -0.13414104937088028, -0.44243248312200684, -0.25520528077156424, -0.6940304186137054, -0.4915138059359619},
    {-0.4154259159443613, -0.6263190746285898, 0.3093023296654722, -0.10932564159688431, -0.6076128738542269, -0.4810210838442278, 0.5863271606050338, -0.2918557591510668, 0.28481965720275093, -0.37505119643975915, 0.49501772428362784, -0.3946710980682043, -0.5854873657550331, -0.19143977014631458, -0.008588540609696953, -0.25233371830533724, 0.08489712956438684, -0.4286166254165977, -0.6007001851708315, -0.09173777478184174, -0.26469884431043395, -0.21480901916875303, 0.27556709233726434, -0.2797448056418084, -0.48061987430431746, 0.26865704645942884, -0.6339428803621991, -0.6024903629474937, -0.34766608605444105, -0.2851551055897396, -0.449346868422445, -0.10784364499575166, 0.15280389057699395, -0.5075323806047867, -0.10458628638155248, 0.25185745693608097, -0.051953402639149944, -0.5013310545773191, -0.0462227915921996, -0.26812482285768124, -0.11548242657856497, -0.1683422045134426, -0.10822573336969417, -0.4037243225280045, -0.19086130743725102, -0.3949801137884076, 0.06188942133125136, 0.015664223152738806, -0.4365776652624737, -0.3067839955352373, 0.29884830890014885, -0.39110389110206795, -0.5971306351762016, 0.11785083821299645, -0.5116818496740138, -0.6675065997185196, -0.07346855635513197, -0.24534520499922186, 0.08767527787304587, -0.1028624506793855, -0.509114569560904, -0.1507008514404806, -0.716675238837978, -0.6015402506033067},
    {-0.6351637992779796, -0.23801801024264105, 0.38732226514889234, -0.18370216809620293, -0.6660060734176436, -0.2733558544407457, 0.40641819368316734, -0.34011051877698234, 0.4780001919041953, -0.2797010109199761, 0.18901434630681807, -0.3837620156796818, -0.5167848505746149, -0.5638130170472353, -0.2855373517615271, -0.3468327162650865, -0.3098777671719969, -0.6559527585893328, -0.31277874719834314, -0.12245690595867444, -0.322181704562457, -0.23612794465420306, 0.04538066688924195, -0.11030005314537646, -0.470116834436459, 0.3990735500152642, -0.6226719541281112, -0.6744714545225172, -0.3494157331902271, -0.326925519662208, -0.48861372355368615, -0.025282339982721832, -0.013926628952614829, -0.324667549988926, -0.5160574968788196, 0.03726849944285701, -0.49947156097085604, -0.6335316264100538, -0.2746775109106226, -0.43072109427210714, -0.4991735767232843, -0.23681214843772988, 0.09999403578956405, -0.6382629594791535, -0.24986117755286955, -0.6230530517031831, 0.06863255027310305, -0.13923039226041428, -0.5535940431063275, -0.639509351403309, -0.16274958557350735, -0.4456225346988301, -0.5601405892833042, 0.0028450160821594057, -0.39705787593097513, -0.427654982227868, -0.08652752498812052, -0.1559103639237027, -0.02575398192259404, -0.4585367019212604, -0.6101969917989564, -0.1972804893067905, -0.3823487317532083, -0.47823262163189434},
    {-0.6536538886752089, -0.38140488331398087, 0.3715986812744057, -0.4526157578335122, -0.4095280114562968, -0.6614152864049934, -0.20929517008246046, -0.3485215975299582, 0.2327717954673455, -0.5465392706825216, 0.2501794341319916, -0.21670268655814826, -0.5651852980095982, -0.5412971998063904, -0.12277796199591154, -0.39504185882119525, -0.14472956739208823, -0.673663180851414, -0.5124161432363921, -0.07712545835825005, -0.6081574307483034, -0.07124284342589157, 0.016571172990593158, -0.4693055360935923, -0.5739575353146381, 0.2357971470311348, -0.7025840060099892, -0.45504415283434885, -0.3568057043113535, -0.25849021080028606, -0.4525870400126663, -0.18333476680251093, -0.26347084777756785, -0.671802307781239, -0.36420018178778535, -0.0395254666624471, -0.45308513707440484, -0.8012600687620177, -0.18168559855567903, -0.4939159396878736, -0.4702211023908988, -0.007811484982102814, -0.051380804892634406, -0.3981480687013275, -0.35697581426983405, -0.6435001501396274, 0.07238817147912355, -0.1101748068866901, -0.57555010871558, -0.5003286527010602, -0.284261036853636, -0.35032554124977694, -0.38672126979257226, 0.08998468082608509, -0.39388772842176645, -0.4422319031074968, -0.29023363971046257, -0.3255720586740545, 0.17159888973068893, -0.2519852626641136, -0.4472670269111019, -0.3234155150691549, -0.4605651665774218, -0.6481434577766713},
    {-0.4612559157413178, -0.6513108691287989, 0.29973971162635693, -0.19909811669269145, -0.3674621920097154, -0.5403877808762763, -0.03068421005189885, 0.026554135751299102, 0.04500680599591925, -0.58805417495628, 0.5815816965564523, -0.09298895245640132, -0.6249671516953702, -0.23823782631653623, -0.20382491734514757, -0.30915747426860996, 0.11189581628837957, -0.5078271313310144, -0.4523169776822155, -0.20380979364565951, -0.6872704017960642, -0.023598809724239028, 0.2265836471120642, -0.17264196170123156, -0.3128289748273633, 0.5426638582767883, -0.6774088545939146, -0.5304526891106871, -0.5116330949980283, -0.47634307880944665, -0.5225159240457049, -0.4168919069840124, -0.11373569416137302, -0.460109578333058, -0.40358817715082546, -0.08402021029063153, -0.27706360064345215, -0.4344489526706601, 0.14224303307965214, -0.5174130105242334, -0.29990773994651343, 0.00032336541975394297, 0.186776731390942, -0.4562335737505451, -0.46664955343753056, -0.6356035320569845, 0.12652209312257398, -0.3230280316202252, -0.5754891604527667, -0.4150318694988094, 0.23065226505148229, -0.5221674762287439, -0.32661433430426207, 0.22013127280021152, -0.5462059162877809, -0.6905631826497375, -0.010160891474211306, -0.23175599322618595, 0.36151034818995, -0.40904050762516847, -0.6346798085466994, -0.13870539070934348, -0.6379649324644978, -0.44290487130051887},
    {-0.6651431199130413, -0.6962850575900066, 0.8148794996821508, -0.16231896774174784, -0.4517901798663743, -0.5585591573220827, 0.6790844577995299, 0.028124515191122388, 0.6551981631924666, -0.6850343875208086, 0.7510000654611855, 0.05490425490766035, -0.8096190938809756, -0.3048041137575728, 0.06572562159576477, -0.32668621064664344, 0.2944395409759991, -0.7882582631531535, -0.6038289454947323, -0.29285959936106654, -0.7672403508282484, -0.1643719701216364, 0.5989619009688032, -0.09477249838851665, -0.4321220466104312, 0.7944956861399823, -0.33005472545747827, -0.44902501606578993, -0.5738769124234099, -0.40024711130203083, -0.7931294639501809, -0.11156232929708708, 0.4490242722677659, -0.5204783393411543, -0.22240060558912586, 0.4815091100612201, 0.04494711226087349, -0.5128198085944387, 0.2995367463780762, -0.6912826889982371, -0.4637725195904922, 0.01609537459953331, 0.11871990606274074, -0.5928914819879012, -0.39939331426960784, -0.6640414372300124, 0.42575027371178004, 0.07038120968287948, -0.6039444462646756, -0.6275279281292457, 0.2904615786683422, -0.26084485525053813, -0.37201594194355886, 0.6748526950426367, -0.3327617966943126, -0.7692539232102735, 0.23279357622055624, -0.39359120636312855, 0.37587111339836904, -0.18421631616563625, -0.6130845316159096, -0.44602882743756356, -0.849490264145751, -0.5724781682438086},
    {-0.4847714415007212, -0.5099823100991421, 0.9295672069096734, -0.10871945148080121, -0.7860999040484269, -0.32091990593622205, 0.4990252814931161, 0.4213785003226278, 0.6624297107545701, -0.6662994497082301, 0.8329457612055738, 0.2415283672758224, -0.7617962701361188, -0.052537703921902344, 0.16646973617559505, -0.06265080763130708, 0.4735968313583266, -0.6868054458697365, -0.40871294716214196, 0.0395385482219702, -0.7421637705346584, -0.2914724620297317, 0.5896096256295181, 0.16744623494590152, -0.3678495149235443, 0.8546152494386764, -0.4720492816651869, -0.8305435319551403, -0.4657098602917192, -0.5401959433239967, -0.7883713339807035, 0.02081263908586041, 0.8176145154823841, -0.14943894680038658, 0.11994013653044044, 0.5634745731561903, -0.1686322635674133, -0.6974050865546527, 0.6829365211111074, -0.39794696274621616, -0.08898372421959846, -0.09545354077016589, 0.6131903170488625, -0.603947329424034, -0.34226015984378916, -0.7148119714656341, 0.7058743782985978, -0.1385430108281692, -0.7011121992381524, -0.5906536574231883, 0.539344204912434, -0.41263623835538926, -0.19700930650663664, 0.5562480092281817, 0.09026440479151396, -0.7985878215350379, 0.39498847126195147, -0.33234297302118887, 0.5267854022337333, -0.008150001827965577, -0.2427546785194501, 0.05560312335101686, -0.5973350011712076, -0.40705453399850533},
    {-0.4982002014353369, -0.4287905368138124, 0.6876560769367368, -0.09110454535663542, -0.4850171493574713, -0.3524904823907977, 0.22872892857294708, 0.3122871393086015, 0.3906521909470859, -0.4478245025952368, 0.6141288305537643, -0.07545492036660109, -0.8596502740210568, -0.2681126640525222, 0.06244948019075455, -0.3858784591830431, 0.20689482534763312, -0.9062062354564129, -0.46133886745861585, -0.45885219785337267, -0.5175413663228545, -0.08947360731927169, 0.37541748325145546, -0.15901722567175952, -0.45719974048188156, 0.8546314470429678, -0.5639579496076631, -0.710525165345522, -0.49053134153454286, -0.5709048801896913, -0.8176247449992609, -0.2232517101381793, 0.4768102398825463, -0.49549875604921195, -0.2675504086208956, 0.34071055437799536, -0.20501093961766523, -0.7465833799049436, 0.5258605901551608, -0.6791013004808266, -0.31562836691406343, -0.0501694032109679, 0.4810289982181263, -0.5692743777421299, -0.45048896313617254, -0.44124954513837866, 0.6555592101410967, -0.1146240821036684, -0.6046836217981021, -0.5198222671634058, 0.5968819987999029, -0.5947731692710314, -0.2204394047498248, 0.4767820589934394, -0.2975641524774354, -0.7877472220156372, 0.1335735225704917, -0.40398883038855943, 0.6277020998751465, -0.3215541445434302, -0.17157767234633678, -0.26609064888439643, -0.6248522936122722, -0.5908216008873313},
    {-0.6307979895123026, -0.7207508228594032, 0.6283061834043103, -0.29523811850776827, -0.4376109136153831, -0.5140700682738671, 0.2800624480376147, -0.13426510258706226, 0.28559645831909075, -0.44548689616455184, 0.37721916964065805, -0.31301545386270613, -0.5113654889165274, -0.6283964240487548, -0.15859803060434888, -0.5309898139489949, 0.019241934876343323, -0.6044533508778157, -0.4686614204936653, -0.4609176175414729, -0.5968901244570982, -0.17375823406381252, 0.18426917571050902, -0.3020177955137202, -0.4967909540443103, 0.5576781874200424, -0.4127790839667543, -0.7404683030564713, -0.5611085268508818, -0.42814200339378594, -0.8392621895186014, -0.2340475261158938, 0.2766623807180104, -0.6877182493238181, -0.3011963207678888, -0.0015507643969415745, -0.4214975268900459, -0.7324510753410265, 0.04294015153550201, -0.4461204747436324, -0.4150675015370659, -0.020043386235360467, 0.05497269769503675, -0.5785502662838675, -0.2138960749205519, -0.6830093670090616, 0.4197979413045614, -0.12065537950006101, -0.44482231381885823, -0.40563246810610115, 0.004755670151924614, -0.45573622411659925, -0.6670114616195012, 0.3417674311738434, -0.35316703061591415, -0.6369223139533716, -0.025033577356803463, -0.20683694626135712, 0.24054298977788782, -0.5015710565486251, -0.34322679727680167, -0.2930808844423139, -0.5848107675451099, -0.3155932535069027},
    {-0.8089276352464646, -0.6466244776147172, 0.6960455820955195, -0.5218734787441612, -0.49163214517455933, -0.23096377339553864, 0.3629465596748042, -0.11087549936828904, 0.49365073060928927, -0.7854276018791153, 0.5676000645538941, 0.06868625891840022, -0.6273623938520798, -0.35843360045529143, -0.08644894310184506, -0.3618274857709757, 0.243674151884038, -0.7771698080797398, -0.42425252755315335, -0.4230528817444368, -0.5173069805659428, -0.3516897570076862, 0.402711355204576, -0.08565576189539056, -0.3992518897460862, 0.7903731527877951, -0.6658058988581521, -0.7159816605918038, -0.6525777810281954, -0.5999852489612444, -0.751662427983374, 0.13234153804274063, 0.3907695202943068, -0.1836183313125895, -0.08644380444934169, 0.5313159617079336, -0.4249160693839793, -0.8540168689073738, 0.3528229775417182, -0.39692219468498374, -0.3582751475212245, 0.05073490208846232, 0.14355729101981599, -0.3889613112539971, -0.46033013934588, -0.7745182632580219, 0.4582798414664408, -0.3895259581816417, -0.6981814710200052, -0.6833153808623342, 0.35092630755799886, -0.5002765544817314, -0.48458825277781037, 0.31664686811065906, -0.29170322432444684, -0.7731011712993566, 0.19072884721342506, -0.14741048298160955, 0.6168009773223696, -0.18478681219459644, -0.17705348536940851, -0.4515018935038673, -0.6286974456033336, -0.4514234658805638},
    {-0.4486355018193948, -0.3600877857954566, 0.5861075859957924, -0.33284374656295884, -0.7712837091107136, -0.4071157259084925, 0.36273061886875124, 0.3392377018992855, 0.6878775346682178, -0.5229287078585664, 0.4841914494049305, 0.10651201952115621, -0.7882692350306255, -0.15587959090055004, -0.11256734263473675, -0.07224212334012228, 0.2418937592370736, -0.9401188554354846, -0.7036748170418483, -0.18861097377270608, -0.6155016576148653, -0.47112698173204304, 0.33531673803343803, 0.0533521184337914, -0.5192680205598147, 0.7994827626213722, -0.8101464489979253, -0.5001787913497373, -0.428630721946596, -0.232391979194673, -0.6742111726099542, 0.18772578657723202, 0.740488497355653, -0.029796644376500023, -0.16915318950553634, 0.7362126756865436, -0.3028393263205821, -0.6514494664246514, 0.48421836111439165, -0.3835537296094964, -0.5103441728208788, -0.12252541622900016, 0.4307240304414878, -0.4146567058443666, -0.09483572650704766, -0.5476815530013882, 0.6304507515233888, -0.3572929634760477, -0.5766232982165909, -0.6096769812578565, 0.4157262448056514, -0.5600631902970382, -0.18429917838806592, 0.4090946587633568, -0.012122675959903899, -0.5539926518171503, 0.20655191683327243, -0.2812270718957301, 0.5200431539718163, -0.15297072935343825, -0.055953017266066406, 0.002641457206932128, -0.4412765793744587, -0.4389307922849566},
    {-0.7905700060174422, -0.40445628013840695, 0.5512829119677031, -0.5141159822896502, -0.7684465159521214, -0.37971726282557094, 0.2598158686706111, 0.08734761898469018, 0.6287328534857267, -0.6043609807775202, 0.43476322855739613, 0.11553511139211481, -0.8912049306284963, -0.5276747066488905, 0.008385071487646122, -0.24258741215872434, 0.42892944719942466, -0.8691726245829253, -0.7403011502920975, -0.23487163926456955, -0.8074250917121019, -0.4445540194408046, 0.4951893169015135, 0.09937373261740368, -0.5286818817251907, 0.7935861853482904, -0.7517891586850274, -0.7810543289869546, -0.640953473246187, -0.5484609430610295, -0.6588772569049345, -0.185197800813107, 0.535806731331867, -0.2010359643090467, -0.36578958601771694, 0.4773888119760417, -0.3907613067932114, -0.6999657431783571, 0.45510956716637524, -0.4201507358316173, -0.4373963112845507, -0.07823961296837091, 0.46508225156720906, -0.7028190464681093, -0.2872438992706891, -0.5187649208128764, 0.530695880949841, -0.18411570583643483, -0.6501115491137869, -0.4474361835267947, 0.6250755026834476, -0.4125956582508753, -0.32718878038804927, 0.530526193015867, -0.3056818073211371, -0.596513602581163, 0.14878962488953992, -0.5113308848520861, 0.3839926699161605, -0.48335771702781194, -0.09468004331806, -0.41119639233984867, -0.7351239471298925, -0.5194305418552886},
    {-0.5978238816637043, -0.3736763003987051, 0.5218691649797182, -0.22219749389416502, -0.5400327438623168, -0.21964290919573734, 0.3692534640696227, 0.00677147469930697, 0.6788908694748775, -0.7176683665719398, 0.759691442395202, 0.2672295532474931, -0.8747157890259889, -0.24830793392169817, 0.1724077275649569, -0.17441613920244325, 0.5527746652397465, -0.8291906811745, -0.5997371983444953, -0.1146343812063038, -0.7892919776311192, -0.2643625169492429, 0.5419817318540516, 0.025871224612179156, -0.7140829770845262, 0.764380972880448, -0.5453340516606962, -0.5778916549874336, -0.32853605949703796, -0.41989240011396545, -0.7774975571835179, 0.18197100890666973, 0.7400445935870483, -0.43856126615877256, -0.07908357478709588, 0.6867399776899724, -0.6285661888076368, -0.49383964673649516, 0.4410966390898095, -0.6588316380844127, -0.5367012060814883, 0.08198827711084207, 0.4483599906556749, -0.4574147006067279, -0.12619968071010124, -0.6929499581859025, 0.6944953845789895, -0.4077407312491196, -0.6166948430444302, -0.511204434263137, 0.5283237395713766, -0.4017752790291142, -0.40804767714156576, 0.5473859546354756, -0.39191757950684003, -0.6697797799590098, 0.20863193346938771, -0.14422386022523984, 0.6804087507022989, -0.1042279528675907, -0.43388210681129274, -0.0528646996385122, -0.6690304213309245, -0.5163661625432627},
    {-0.7274949277886049, -0.5558268661438043, 0.6996180626154929, -0.19144846114812725, -0.8026899965183568, -0.35000772437489, 0.5896551675999594, 0.13778669830087864, 0.3624894899309775, -0.712310716873919, 0.4893838952194622, 0.2511724436597639, -0.589916605896789, 0.18382638365377887, 0.23520985328717894, -0.06885908459621977, 0.6077831494493025, -0.6317654700364401, -0.748849692609909, -0.20422164993639855, -0.6062801192748478, -0.23925747602244046, 0.501325134795541, 0.09064301545431624, -0.6614164835686672, 0.6834084995553129, -0.44301532938558874, -0.7159624301038803, -0.4651705443432167, -0.5767432850614199, -0.8346037901793284, 0.18694676260402773, 0.6902219601196184, -0.3754978143771256, -0.07407232562923037, 0.5932361581636216, -0.3524848326817378, -0.5986595523439304, 0.43373947382898526, -0.4757302804925774, -0.2598120540146695, -0.0905183061531263, 0.6790097653301356, -0.5124606036149616, -0.21834473806164675, -0.5370937998888108, 0.6445531944317395, -0.3309898165056986, -0.5571790172310858, -0.7257859761389283, 0.6473833642385577, -0.3075985491253617, -0.33932349737402673, 0.4236708584317188, -0.009001627797112352, -0.7393304886607146, 0.4948146635579969, -0.13582035474483511, 0.7731177722322028, -0.36491033176328486, 0.11232329464529342, -0.09228334604846075, -0.6109023742714422, -0.3772881303951757}
};

static const float b1[64] = {0.8724702234958244, 0.81011026858646, 0.7221394320759014, 0.7774873809707397, 0.8606797964820305, 0.8566294916265953, 0.8350863444644596, 0.8061904910866905, 0.8123397369090996, 0.7871311430284617, 0.7718352901033684, 0.7651677969891235, 0.8353675674258422, 0.7567747711393422, 0.904422594641131, 0.8941861881109762, 0.8873492272608817, 0.8263457310642289, 0.757840316546469, 0.7000980502577301, 0.7717836628460857, 0.5364603915900248, 0.8730868990091901, 0.784331671068492, 0.8699400942545589, 0.9001558975930548, 0.8658685635140589, 0.8331067065020474, 0.8340854234047854, 0.8289526016904646, 0.804768675425038, 0.7353901551257453, 0.8682440185648241, 0.8507564946075197, 0.7517030232644555, 0.8728145019195341, 0.8417774779649666, 0.9078034267784474, 0.8899414246661761, 0.7204576231695657, 0.7678037078747746, 0.8316369678976014, 0.7414737452131647, 0.8709822250225596, 0.9087169819521919, 0.8258303709849055, 0.7517761716228728, 0.8094795744868698, 0.7993525932860458, 0.7659364257234479, 0.6977388308956549, 0.870245703731248, 0.7838829029749295, 0.6867539163012193, 0.8750344179215547, 0.6893102338592024, 0.8397586859073424, 0.8377430620150624, 0.8020363050251336, 0.7781394731536108, 0.8449306915085012, 0.8770296592635121, 0.8138865447139128, 0.7906347873753774};

static const float w2[64][32] = {
    {0.7961770913371767, 0.7030736766830934, 0.06198744269383335, -0.14842892733010865, 0.4124509541825682, 0.14386150023532682, 0.8438259422101974, 0.8713055746530011, 0.863772943028819, 0.7437469074378864, 0.7442179515289431, 0.7274052294981143, 0.4808410966371787, 0.7846379591904593, -0.1379725624587222, 0.8841255540921934, 0.7633556120217446, 0.7252440415169988, 0.4180676430444838, 0.8384671251534108, 0.9340919212281095, 0.040286860783386835, 0.653195817620697, 0.6813551929653157, 0.7910962509446241, 0.6161589314763601, 0.9197035898362637, 1.033480055402707, 0.005923657392400676, -0.056808696996469774, 0.6319418417761898, 0.8718172526113013},
    {0.7267235532353518, 0.6886626996497439, 0.005858171103842857, -0.21332132740980084, 0.3199076153974237, 0.02019745175635147, 0.8807739296005946, 0.8204980225489449, 0.7776152368281376, 0.7232060541507206, 0.6236887163827778, 0.34819952003170335, 0.711013309427246, 1.0414331262574017, 0.004719749815416945, 0.8290141882360352, 0.5066879839689566, 0.6589780789088807, 0.7612892368336625, 0.8472359840754833, 0.8777677150819131, -0.1467474307662786, 0.9890574014417999, 0.8710500482170411, 0.7438663483320197, 0.7445485204668104, 0.669833283665022, 0.5726591412371006, 0.04626409481601847, 0.16078132841177786, 0.786755773805377, 1.074399334048707},
    {0.6031739562414686, 0.5321644548805318, -0.2458566794938819, -0.06481784107535009, 0.4855043318290817, -0.23162983358633074, 0.7073017872800699, 0.44961069118273644, 0.6706773237116808, 0.7260355027686796, 0.6372570491145069, 0.4980534790450936, 0.6410886659702145, 0.7309831721051122, -0.04817297643456766, 1.008511314829013, 0.6233698137447291, 0.9194318121497563, 0.8003716351522493, 0.6653384268364242, 0.6600222211404652, -0.07181316296583418, 0.77241559888906, 0.8639059291844239, 0.6315627864751663, 0.7571281230685197, 0.6012246821668371, 0.9658995943302123, -0.20331759911178063, -0.09426411704791864, 0.9579207108915506, 0.5996651258870119},
    {0.7430609706860033, 0.7299359617944624, -0.2416019178240661, 0.09802243759201698, 0.6569597228175883, 0.1394304662382484, 0.9163701818502437, 0.7937461958503781, 0.6905876524241249, 0.6133281317464992, 0.6040901336943593, 0.6254023307956219, 0.720242012090151, 0.8407712465916528, 0.26293636440199897, 0.8318409496633634, 0.5805695730976759, 0.7160139696389308, 0.7043264877060269, 0.7319175593197299, 0.9776755964544656, -0.05356529980762357, 0.8482392096549741, 0.6549964499722294, 0.8452485568612277, 0.8918629462491963, 0.6523024021119153, 0.8474050284678749, 0.059728111331323275, -0.10995102995209304, 0.621508284371598, 0.95289968208663},
    {0.7847473749777376, 0.7276581900087049, -0.16690462631643935, 0.04699446951600992, 0.4950962546735615, -0.2155851271100949, 0.6411198585176114, 0.4947570457333983, 1.0157707946787158, 0.7531443008651633, 0.7293891990238252, 0.5842956898440358, 0.8658589841494838, 0.6278661111221161, 0.132657774573568, 0.625441513038808, 0.8333671047130653, 0.8995358751316209, 0.6390053118045128, 0.6299552132064874, 0.8364122281365739, -0.2625850870800999, 0.9637563726936199, 0.5672262256703406, 0.8180392222488807, 0.6554080230433548, 0.5811576261941125, 0.792258154207965, 0.07157087095903975, 0.11342967349622776, 0.9268708769636529, 0.6527424450019561},
    {0.8241216837671816, 0.6610769441795006, 0.04866123937668608, -0.01652471009662532, 0.525593350818196, 0.11225102421970086, 0.6437712820722513, 0.49722240605588475, 0.6428211423634151, 0.5193074160227211, 1.0205504780627648, 0.6156174353940957, 0.49012700024885525, 0.9671767371383034, 0.2267637702519958, 1.017473413727283, 0.6067364857622359, 0.7859143409913315, 0.7120996792230196, 0.9069374525450651, 0.9743989891316064, 0.036297074473601226, 0.6593335178498138, 0.5397170905285841, 0.5098450784183011, 0.7363125504770451, 0.6731598605912557, 0.9505167991993374, -0.1091391917961466, -0.02327353704799801, 0.6171656596798097, 0.8589834985709083},
    {0.9508506274613306, 0.6282932352453017, 0.049079330779035236, -0.16450223821326737, 0.5167021612451373, -0.031364522312832654, 0.6590173579634042, 0.7366500299130407, 0.6607750865505968, 0.7617403308356533, 0.9227070437886603, 0.6119584720753417, 0.6667808244718557, 0.6049094182731636, 0.20284812865365842, 0.9648106417951133, 0.5966411175438, 0.8453360606484025, 0.6298297848533279, 0.938612991940131, 0.8678309575803733, -0.015418409107057145, 0.9759643783585675, 0.9040667116733766, 0.965822558095419, 0.6797105031685062, 0.7403643045343555, 0.9947411047359923, 0.0887333934977521, 0.043507447363943776, 0.9873344785386483, 0.6228001118609311},
    {0.9862874345099213, 0.8556616457020982, -0.15677654080204165, 0.02335021902616764, 0.7488444958716619, 0.15189663959928093, 0.7216805009539882, 0.6933053452760565, 0.9417972675925202, 0.8931322553406683, 0.5731373866105475, 0.5914980665683911, 0.5656312871870629, 0.8474435299689554, 0.23187837111293186, 0.9951883142548321, 0.6504555974209638, 0.7798334496588174, 0.8133911878883477, 0.8686446988922037, 0.6463890464182783, 0.0848649258596429, 0.7537574341036667, 0.9133612212624738, 0.7014141778535335, 0.8775999769022661, 0.829859112280525, 0.7385017078924657, -0.2744699241230392, -0.17377138007342396, 0.6721722603809446, 0.9265924035139811},
    {0.8138768051542428, 0.6437797329995926, -0.06618564720960973, -0.3406371261056901, 0.750744819557832, 0.1554519406757558, 0.8372734108341353, 0.624171639518497, 0.8397920043193837, 0.7507782169497527, 0.7783753325468906, 0.7980909994398483, 0.6884753793952508, 0.686725079282837, 0.12358892878436527, 0.8808272340421267, 0.8855022831847977, 0.6727329139739427, 0.5348361893239149, 0.6953729291681854, 0.679623459006116, -0.2977116579852617, 0.5715769999282038, 0.5257332466812885, 0.6512372712478727, 0.822878027093197, 0.5556477972510151, 0.9354220855458024, -0.22536568699179246, 0.16130378464462572, 0.7012197865980871, 0.6200425130378716},
    {0.6314130119863006, 0.5066443374877279, 0.006638490802615242, -0.19717967407513118, 0.5249739064222161, -0.1342902148129218, 1.02818860705409, 0.44643454506414537, 0.9193215710846472, 0.8231088259077999, 0.8574330254961824, 0.6814837788406636, 0.7182149628811196, 0.6223562575350212, 0.21211237552433662, 0.6106285469763602, 0.655395746155845, 0.9892479978239124, 0.7087888674221895, 0.6336381713952137, 0.7982657527322831, 0.002377351414074117, 0.6628743887103051, 0.5519774991701899, 0.8499028416929637, 0.8523087513644177, 0.7873298907735259, 0.7853590486670792, -0.25811679962995077, -0.09450584682143387, 0.7195865007645329, 0.8033632801654208},
    {0.5839963896235502, 0.6514252533352095, -0.03997317367616724, 0.055933188666338576, 0.6732545727970075, -0.24742442288881605, 1.0192566185293521, 0.6096664891658916, 0.7445085266001618, 0.9331760190294562, 0.7754936999275768, 0.6168224785320733, 0.3985253388750205, 0.9845729603731926, 0.0001838128591871352, 0.9124987959741773, 0.5944342677588995, 0.608862998210526, 0.801803889180374, 0.783948303445963, 0.5985710129986944, -0.07760092489951917, 0.9657478318743247, 0.9432707833653903, 0.5944150623802669, 0.8321098053277388, 0.5382563062732634, 0.706097833632721, 0.19485355676527266, -0.16918907023255692, 0.6374592779792858, 0.7834653841021124},
    {0.8840123302954801, 0.7210979771700683, 0.08696252217175396, -0.09575324196456099, 0.5168613878131557, -0.15590334870248063, 0.8660135244909726, 0.4129484431351976, 0.6335992979895818, 0.9457155369966079, 0.9120450934941363, 0.7390294554390215, 0.748807169145176, 0.9664651516870432, -0.030360069646221968, 0.789982025053808, 0.8562092312201047, 0.5647089410244215, 0.6219645690373031, 0.8379962271307438, 0.5778391657944113, 0.14430641390610927, 0.56736519001856, 0.6607587262525784, 0.8562051034066943, 0.9201006017257484, 0.5966797998318576, 0.7769389042251749, -0.014478282254156141, -0.26080394101706883, 0.540241088513393, 0.6868493787676836},
    {0.9579451158824941, 0.7186659795169257, -0.040763441676304746, -0.2533321627525229, 0.31549549808595834, 0.15564405335419007, 1.0482581970419766, 0.6418857073590323, 0.8300323252189717, 0.6887046493061391, 1.0153540809332215, 0.6106668379004659, 0.772292305588931, 0.5443777345660922, 0.06250932350472378, 0.8122542806434022, 0.5996963944583275, 0.6566702410434514, 0.3752351502827943, 1.0298874353773848, 0.620347395622261, 0.03358122718507394, 0.6696952417667543, 0.5951500176604538, 0.6440037419299217, 0.7869642891115455, 0.5656878230301069, 0.9702277382537471, 0.10375592970838715, -0.009485305266589842, 0.8903442769463609, 0.658924305959684},
    {0.800260078976681, 0.8620527228779425, 0.05152337280132204, 0.18520805541514773, 0.46970612615805357, -0.2138736731087962, 0.9473834465652022, 0.5156097425134827, 0.5571096278931683, 0.914863246660483, 0.8786975044479475, 0.7043136703349029, 0.8301145212810618, 0.9068284890186752, -0.01990560315091132, 0.7140110246919474, 0.864874480650927, 0.5647630186133488, 0.7243799802648658, 0.7012105461868204, 0.7217211855619079, -0.21650931807370138, 0.8332523982831888, 0.6028119134773463, 0.9296613165896116, 0.6659940071792235, 0.7352993840954276, 0.6882630333919604, -0.2514533462205986, 0.12419511852070735, 0.44608971585754886, 1.008807663460234},
    {1.0102611619444897, 0.8442893818174173, -0.08516252910890415, -0.26772222194099526, 0.46530667402854253, 0.018973188436549864, 0.7271470562673428, 0.8004411069242958, 1.0296854686850476, 0.5931304588373801, 0.9987469061726352, 0.5366602082344697, 0.6506784978969895, 0.7469362033814572, 0.2883737859854084, 0.8981900532979985, 0.7280768260896495, 0.6880126046414603, 0.8882581162002068, 0.5847215839587551, 1.0051417570136387, -0.1180486027392283, 0.7101532827478503, 0.7747997099016791, 0.7568179485912765, 0.7289812443533843, 0.7758879197307326, 0.9283131018851772, 0.24540395858531897, -0.2429297376907409, 0.5467685484538548, 0.6466363666729585},
    {0.8323551937198334, 0.5164238472985312, -0.11124499972927332, 0.12956010267612875, 0.30932438490704073, -0.05169774324846488, 0.9436783218021304, 0.43961216311597323, 0.664840912782309, 0.786839310798818, 0.7535737837222715, 0.3364171311959216, 0.708038573169123, 0.8947465271916799, 0.016781295997602606, 0.7686923597732103, 0.554823352430972, 0.5500012486405361, 0.8659518937005195, 0.9816118593384127, 0.6904081120140163, -0.023778919005807104, 0.7434677209408497, 0.8261127238957188, 0.9739887958978215, 1.0012856081385324, 0.617060847745371, 0.8673496018455192, -0.13749080579580758, -0.1415307199687705, 0.7136690578950876, 0.9767229617195957},
    {0.7675780236998365, 0.6966489501016269, 0.11189702688040025, -0.050521945633221044, 0.5739393120739726, -0.11217841335627893, 0.8694009892193406, 0.40926478897183627, 0.9453932871965872, 0.8479271293584184, 0.9426101845421805, 0.4097091228657932, 0.5153817565000804, 0.6928648332002003, -0.10853966258892789, 0.663756972117646, 0.6839991878184006, 0.8643601944342539, 0.8152901389209325, 0.837406718808581, 0.9879927170961529, -0.2701742419629896, 0.692373972715125, 0.6572137295865814, 0.5391322533741096, 1.0425297762661316, 0.7511874704600784, 1.0185101395969158, 0.12468570805916733, -0.0010742560320332948, 0.4832425489737528, 0.7780879256208163},
    {0.8197854161544529, 0.8178535743488509, 0.06724461572564511, -0.11272262487531731, 0.3150049286016361, -0.17607953954503228, 1.0520727168024233, 0.6150247449554962, 0.6609758139872846, 0.6470957866117576, 0.9468564613257722, 0.7504831248513292, 0.5026311124167107, 0.9158017769230229, -0.017968394490525556, 0.9088326149334808, 1.041004229493921, 0.7496871393267456, 0.7990489123239334, 0.7694452180416393, 0.9515500699069144, -0.248338340770256, 0.5277138013713089, 0.5058486687210526, 0.7651089332255542, 0.9572212213610141, 0.786493884838824, 0.7864485849019177, -0.24275813103551455, -0.059018977694868795, 0.839045477247711, 0.7554899208835961},
    {0.7263300255437856, 0.7581301529815334, 0.20914692060812237, -0.26167978114611434, 0.37036736222276784, 0.036970448593015515, 0.9704712884792772, 0.7550183510601364, 0.7667541575423094, 0.4785134185267384, 0.655563117639479, 0.683486722412028, 0.4275470446101152, 0.8996677755876886, -0.036925095161022846, 0.6121222315133298, 0.6934731490843953, 0.9669961041731595, 0.4502035857726228, 0.9546760744293447, 0.9880199103747428, 0.17934071540217889, 0.5911825213103181, 0.6007470104251891, 0.9683378678863376, 0.6866478442887899, 0.7202609841039705, 0.5598115378719062, -0.19447991374773813, 0.16088337999175026, 0.9286078578993422, 0.7849357803743654},
    {0.9529893628128943, 0.732971131652986, -0.04700791738080802, -0.21234331939211087, 0.6210139402233695, -0.008042110938493777, 0.5372346723314173, 0.4207888646382201, 0.6721594021514872, 0.6840751057488821, 0.7978430543726507, 0.4419634768183549, 0.7477575795543802, 0.9072368109347964, -0.06413703460022797, 0.6092126473815734, 0.9747343570326809, 0.9240656638917162, 0.8398737426073164, 0.5646627784565365, 0.5859197025576034, -0.2494967911486083, 0.9170333026290541, 0.6775137289957006, 0.6874164712318409, 0.8574827643980568, 0.750450265315439, 0.5596876659294127, 0.014995288023926934, 0.1744810186610514, 0.6817487060255067, 0.7986711165941576},
    {0.7687923608351124, 0.7411863287415892, 0.04671344479183101, 0.16749144552922923, 0.6300679193041374, -0.110729908378807, 0.7119174863662486, 0.7834700359939699, 0.6705107967974299, 0.7616724106761465, 0.6716300139743173, 0.43545318666774885, 0.828623085381734, 0.8789432517165906, 0.24886371742099228, 0.7275540901066242, 0.6682454810801712, 0.7423383918879041, 0.6027150092110675, 0.9601177244009407, 0.7254661729455777, -0.11226382253861139, 0.5163347013475341, 0.7952718525367231, 0.6548766626814886, 0.891562787619322, 0.7671352790763202, 0.7201053961093833, -0.06494065255668051, -0.06542492364991871, 0.9324292787197594, 1.0067818148317922},
    {0.8606503117464435, 0.7767972603583706, 0.11910451897361535, -0.0060612048145423335, 0.3820783226452807, 0.08928159007315996, 0.5148029663979579, 0.5172682556227844, 0.5733705628823634, 0.6593254381417225, 0.6949567156014099, 0.5622249187794217, 0.6226151090006857, 0.5812877483277592, 0.1390457765026793, 0.6980377458171693, 0.6457535039928188, 0.5824556165132989, 0.7875979765469695, 0.8276584964361015, 0.8071749174887053, -0.21461941647249075, 0.7004831579582043, 0.5464835498526859, 0.6852384997349704, 0.68961851522373, 0.40784186309287646, 0.7573706500240421, 0.1288320422584705, 0.11264132554673156, 0.6636892621604927, 0.6310653650326071},
    {0.9494389795180873, 0.9120124639192693, -0.30124179709416876, 0.11181844091177842, 0.7177002424088039, 0.04472331204596964, 0.9470316763566807, 0.8250257467349451, 0.9921891159005009, 0.6871556676479068, 0.9629613674949828, 0.4744582312544092, 0.558423280164578, 0.5638208148132425, -0.07874479543911077, 0.9478948910859585, 0.7979425132956555, 0.8733735342558601, 0.5124881207044458, 0.970482613153169, 0.6088475679345277, 0.1224152088844719, 0.7029885833972382, 0.9654032220646821, 0.7203068662841786, 0.8103360272390565, 0.6086765565599744, 0.6267908611454973, -0.2869020987610359, -0.2569281653819321, 0.8341913960896747, 0.9774707821453613},
    {0.6995600669499001, 0.5479013474635883, -0.12058762211586531, 0.06263996102913788, 0.7744481726976019, -0.23766432559150388, 0.8022855737179239, 0.6718332857454183, 0.646807706503952, 0.787882631044977, 0.6292106866831306, 0.4621054469264771, 0.5136995565128624, 0.7127158123186558, -0.10728472562506083, 0.7581748751538671, 0.8657586949012718, 0.517911568377724, 0.6438796302257462, 0.7515875522573388, 0.8399632345842685, 0.08698731272140676, 0.7991299456822053, 0.8401280686592474, 0.7917214153122198, 0.8947807846784398, 0.8937741560145526, 1.0156174189573022, 0.14906317448327153, -0.04865027554920216, 0.5257927247419848, 0.9964809663778886},
    {0.7616363526430995, 0.5617747899466041, -0.14441922511257338, -0.013286410326012087, 0.5900835385427006, 0.18025488070549728, 1.038086430166159, 0.6286426110678349, 0.770039948853764, 0.4749121548803549, 0.7594627943833998, 0.4241614860963951, 0.8784893820966436, 0.5502593558246661, 0.039945673485771695, 0.9019402348322675, 0.9982968307347804, 0.7817435220062097, 0.7264948488694507, 1.0203466346768257, 0.8178980396143098, 0.0016539333217554084, 0.857561353396721, 0.5660654657425251, 0.601807293968354, 0.6601340216643141, 0.8531130453306346, 0.7254002854486101, 0.02223803826204332, 0.10791366559553099, 0.8093968527794855, 0.9565686869543422},
    {0.8586244479202176, 0.6025330332267512, -0.1012176129583885, 0.09127209358795825, 0.7932547516546798, -0.09929962961907517, 0.7051423209692601, 0.455045337266209, 0.9774785578145044, 0.5618164797846947, 0.6092870816910125, 0.38451615349116036, 0.5856588678855468, 0.6241797664411874, -0.1253108447681555, 0.906764719820185, 0.8820147228242905, 0.7099081695167445, 0.6751338749411985, 0.8981991973872926, 1.018171554816978, 0.06962157184865067, 0.8776392177767054, 0.9118729117724731, 0.8594917851259782, 0.9655618809145021, 0.7002610338498049, 0.7425116522436197, -0.1265882567898682, -0.13586680588350222, 0.7277701197186213, 1.0812431784793157},
    {0.5471366866284051, 0.5085923501022153, -0.2610088208782701, -0.11906635994343344, 0.7093383381388523, -0.1099243058197323, 0.9395538694661721, 0.8216104279542193, 1.0553212036568511, 0.6315339549690246, 0.748978387072518, 0.7456302566307627, 0.5439340018148019, 0.7587929369247557, 0.08074252867691199, 0.6083457133493525, 0.7553131949617977, 0.9472806503049974, 0.8385627951030846, 0.8834458013136745, 0.7965815198199072, -0.25590051088332316, 0.941784466188819, 0.6533946392676494, 0.9214757387707048, 0.5780449866747898, 0.5599373965099658, 0.7076502980002671, -0.012522395897944185, 0.08659107387959282, 0.7866152872168563, 0.7638632086442205},
    {0.5815008401829929, 0.7980409394914273, -0.17354178315586477, 0.1850648831759284, 0.6761638812203853, -0.22138519349649283, 0.7830037303960081, 0.6379141803601375, 0.7461923211669834, 0.7511831345578384, 0.959346871190734, 0.3642129870645647, 0.6602650395731419, 0.9569583756649948, -0.14798264562869062, 0.6077275856650798, 0.8506012510613106, 0.5718184376426719, 0.6173621058170418, 0.6395539591416374, 0.9522918602449202, -0.11598612474688386, 0.7774320628585532, 0.8343684801722805, 0.607883962874036, 0.9437809433604982, 0.7540604975502688, 0.6217964402323936, -0.17134837867337946, -0.2664101899944788, 0.46461393243904353, 1.0056331814283497},
    {0.5674121528694738, 0.5501469346074896, 0.04360881036590213, 0.0802794279686876, 0.3797695248497149, -0.15944055927918638, 1.0170051020610906, 0.7835912092762356, 0.7219164839598438, 0.6560717507137781, 0.751396141421075, 0.3482071501061142, 0.5229972591151739, 0.8268941340556192, 0.2347929679305981, 1.0072116155970021, 0.6817434225921555, 0.5704166931474307, 0.37492345653386466, 0.8556201513122857, 0.6559959481419462, -0.18822125506543638, 0.6876084550256721, 0.5222596501435448, 0.4813516189412107, 0.8646437041580431, 0.4799508136583439, 0.8706935373835164, 0.20690328520673612, -0.255468059201273, 0.6628322898789369, 0.9605534947359836},
    {0.8501428458839143, 0.9248485697789426, 0.0834260365421728, -0.17601671276642317, 0.6525047447431839, -0.09012276059667655, 0.5767038743268207, 0.5565347905890026, 0.7901067521440175, 0.5055269684490762, 0.8486615383878304, 0.661373962640587, 0.822961449548013, 0.6720980700001326, 0.3074863793192009, 0.7020176260578997, 0.8723457679157993, 0.8799262018519278, 0.395773295304998, 0.6976375096781436, 0.7449325226595975, -0.13961797690840644, 0.6039286413119934, 0.7299792560522506, 0.7232144573207182, 0.6135964592702221, 0.684062935687706, 1.012175089423289, 0.14304883841671856, -0.06594844060553902, 0.5877979355690928, 0.8322558768017194},
    {0.8926292221784058, 0.6997841238396636, -0.058486708654508016, -0.1901142486217546, 0.5541427307337562, 0.04362029514739257, 1.0494803715317034, 0.6770225417218823, 0.6411030566948819, 0.7261554379386576, 0.7137600784897639, 0.4956658823294823, 0.5693234676645843, 0.8752747686834386, -0.11486679157006809, 0.8257982945507891, 0.7240761063694576, 0.9647165577906984, 0.7132937232675164, 0.7687540372362223, 0.886899176656107, -0.1889557725763011, 0.7717057411182541, 0.48773472289280073, 0.5972607707333194, 0.8476781293418826, 0.8197603228510857, 0.6288486445624443, -0.12261055496667041, -0.12110118804648652, 0.6972800284726339, 0.8247322079655752},
    {0.7670803138344461, 0.9403730267956061, 0.0940952874298014, 0.09617314086043158, 0.38353107825561655, -0.2632647024791874, 0.9345773408218689, 0.49614660915504716, 0.9030602267307315, 0.8850432240800552, 0.5975648123989896, 0.6282710322639804, 0.8230077881774696, 0.5506689038175028, 0.18209141615360486, 0.6015656938730977, 0.9589042201658559, 0.8200245166746947, 0.7254728674516158, 0.7339178337467607, 0.8632020161780487, -0.06354153715992045, 0.5861168268987555, 0.8241808202016927, 0.6840916280215139, 0.618027596520067, 0.6558334313157177, 0.7066246318658299, -0.0831696823140694, -0.031653227297403996, 0.8987070008072255, 0.6798622472184543},
    {0.7909360809579112, 0.58571530753298, 0.13106645756414714, -0.22485127112282008, 0.5853512806408238, -0.012804555759662094, 0.6159203462728674, 0.7653250856735638, 0.9311436563908629, 0.7040391957507084, 0.9179503956525876, 0.38264330047900413, 0.6932540828117478, 0.9347658245163918, 0.06003909206879795, 1.0440684501095425, 0.9293796294120125, 0.9657687363970309, 0.5534487725165889, 0.8864003645731353, 0.926681177468844, -0.10605444773794781, 0.6596351541683043, 0.8864590383475294, 0.6925056921052284, 0.7457632262067545, 0.6868660539956868, 0.8705952329410823, -0.12151939795055831, -0.03832543383375672, 0.5501687822664002, 0.5891248870281391},
    {0.9858388601966804, 0.6687674492643115, -0.26912244675822594, -0.03879824809048243, 0.33620331246067336, -0.2357542862774482, 0.8002609708113445, 0.3813434866632461, 0.8673807954947542, 0.7918420132935939, 0.8297738892107791, 0.7830575952448773, 0.5951583568956778, 0.8811942748709208, 0.13309547967396979, 1.0395599125945203, 0.5786231850024736, 0.6287890853300289, 0.7189824116655901, 0.9592098254336802, 0.5953275605266405, 0.20165331433049266, 0.9847968519541446, 0.569787119892778, 0.9077600858692019, 0.9839753320365001, 0.7108674954010222, 0.7312796048098629, -0.03899009511701464, 0.15406456171266963, 0.9173278838689359, 0.7241413705407248},
    {0.7471116085366982, 0.6194896280535769, -0.2514417460753768, -0.23309608133006754, 0.4986848170796196, 0.1493768738953438, 0.6077148555522953, 0.507125859168405, 0.6502739078738419, 0.5860885953063051, 0.9043760966542728, 0.6149309517661855, 0.7390814603600913, 0.5708607588551343, 0.2568413648433871, 0.5729485571966785, 0.9711033084818, 0.8924125518817823, 0.7235463837161142, 0.7881616482037554, 0.6350855238054218, 0.08300701585623596, 0.8818393421944416, 0.797765162022876, 0.8574152225252047, 0.9123584142751823, 0.651006905241478, 0.8473386644400295, -0.1403651071049759, -0.024948371091240342, 0.6346264258721155, 0.739755871579073},
    {0.9306503487208236, 0.8276747054018867, 0.14861415674917985, 0.11539777293178974, 0.42408870503102, 0.007908666932030642, 0.8432109355346308, 0.5316941740613299, 1.0331136733830293, 0.6795346328401357, 0.8719724798522305, 0.5048543349462663, 0.45371767554713444, 0.6001726265163342, 0.16277558451627314, 0.9725676273017392, 0.5661607123451585, 1.0219485987263808, 0.5631198004364124, 0.5786105872014293, 0.5555607819859122, -0.26131074484519123, 0.8054182014836254, 0.6419116048170533, 0.8131910505560429, 0.7460730204651709, 0.6570302773295955, 0.9681711235506159, -0.23109327237635804, -0.08417357802322295, 0.9248229559577947, 0.8405593023567406},
    {0.8639096029203776, 0.8075361453929851, 0.1269506200851099, -0.07910199178285449, 0.41702983056003107, 0.0528236948174903, 0.8293175428861287, 0.5125857761776371, 0.801694046529305, 0.6604030368422346, 0.8918362350094479, 0.8241004131437164, 0.42656921376776863, 0.9513624897715505, -0.10366117348031731, 0.5650939346806658, 0.9007506158850166, 0.9327800724293497, 0.5859622595160147, 0.7909556906920174, 0.728620072189835, 0.042751382049829256, 0.9298702648803961, 0.5430684654355408, 0.9147822062759642, 0.7181083238979992, 0.7472359108042507, 1.0225629660273001, -0.048471356396617, 0.1508683489936875, 0.6250946304433075, 0.6839405985256075},
    {0.8077894422976012, 0.7930901323833204, -0.15597038953218292, 0.1523445458466964, 0.7339057659272078, -0.16157941469369394, 0.9125958561786869, 0.6324913141403166, 0.62762550976911, 0.6740999896204607, 1.0571841709889296, 0.558697025538546, 0.4604762066249792, 0.7309495200522921, -0.06348256533702164, 0.8237257016907509, 0.8504958232069282, 0.6365293795395199, 0.7437310973116832, 1.0176472945648676, 0.9091777339022082, -0.14244512341095697, 0.5838607003226004, 0.7156115318948522, 0.5565464558890131, 0.9818355380453515, 0.7434244695786214, 0.8108516928003351, -0.11851645716240101, 0.19523945402292192, 0.9111301084856087, 1.041005259743527},
    {0.9261687400295199, 0.8923840190586058, -0.02655360665821658, -0.1936069223382765, 0.42009474368949606, -0.0619934833591871, 0.9206034251311258, 0.8709526770364302, 1.0259695311563493, 0.4466138606046217, 0.9959400772560701, 0.6263744265188675, 0.5214881182770417, 0.6648889664173366, -0.18165055668174512, 1.0397480289025276, 0.8514628757987807, 0.7887252699758459, 0.5786124376358753, 0.6196720336163901, 0.8964166172313256, -0.03722696946504965, 0.72334838566793, 0.6814975475358221, 0.5641050816363864, 0.865698300455568, 0.7930785049415736, 0.6459594008306278, 0.12102190696890446, -0.2633341508621962, 0.6226978661478276, 0.7641192571938724},
    {0.648446589883099, 0.7336861128400098, -0.27829089642214466, 0.10744153511950194, 0.47681686582259397, -0.15149972220027247, 0.8344876075715708, 0.46495938130763703, 0.5622843561561923, 0.7224027020540861, 0.6262381304109135, 0.702233847311631, 0.763743882378392, 0.9180249637504957, -0.006859346695810599, 0.792072742674676, 0.6531294125390835, 1.0075084081610879, 0.42654607594711225, 0.9641438909844439, 0.9268451975512493, -0.1381749198410085, 0.9710496395309562, 0.9321380381072903, 0.652946595393196, 0.6707761011566271, 0.9027404469154597, 0.6759720524498578, 0.1846933980056236, -0.18094575723375525, 0.9030824017190542, 0.6009669134953438},
    {0.6638313086859915, 0.864724561200117, 0.18292154988611892, 0.029135515870804995, 0.4334455865101163, 0.009686107695455788, 0.6393950906537582, 0.5050805090788802, 0.7662967631049921, 0.8152272742206254, 0.8492405800186174, 0.6782169652825041, 0.8365978517496053, 0.9210639952275058, 0.24738892813887345, 0.831998046670119, 0.6033677937481684, 0.5762820028124773, 0.8134660132701843, 1.0271661619449335, 0.8471292901520281, -0.12108248474754582, 0.7082564449947645, 0.9167720133114655, 0.863170019679621, 0.9858770509561633, 0.6492629151249372, 0.8927587664322516, 0.0910854847705213, 0.17652518367823938, 0.7053654427716932, 0.8866352538758555},
    {0.7547225616252797, 0.7450544367375254, -0.15392427614044146, -0.2863005848780912, 0.32710419070705027, -0.011221899628857397, 0.7283825691602358, 0.6005741225102698, 0.8930223719429609, 0.634129182175284, 1.0120020728977228, 0.3935376566826792, 0.45714964914776224, 0.9730349663858334, 0.07695097640419801, 0.850879789228984, 0.8737125392196999, 0.8235153432821515, 0.6689979344857574, 0.5903867995369272, 0.8197953769821871, 0.12695133421543767, 0.7909496494752258, 0.6838996911658061, 0.5991718813054845, 0.5269890518228229, 0.7338312448383564, 0.8014011556834328, -0.035011300556571076, -0.20501770504178185, 0.6619786630163427, 0.5973506229075085},
    {0.6746996061814872, 0.6584268760436619, -0.0023337932006727855, -0.012149949533097426, 0.6137717038249147, 0.17141692385396154, 0.8750124158488484, 0.8216826069850055, 0.6395473250022033, 0.8495496492657119, 0.6457991412707895, 0.7829487594091018, 0.7509689512346905, 0.8123673100158845, 0.14010819921610299, 0.8049469217099404, 0.8670484354687291, 0.9022117851088945, 0.6570388864894728, 0.9847669767293276, 0.9502761718633141, -0.04414863077292641, 0.6972511677519344, 0.9310310765604155, 0.9747473027610873, 0.892298074557602, 0.4943054004676577, 0.8095234394564208, -0.1513033828806656, -0.21674884769874336, 0.6271856203055265, 0.6579897780335369},
    {0.9451257949350841, 0.8763213482548902, -0.16197009724747477, -0.08838375135411544, 0.6941555276341801, -0.2579863217600751, 0.866861197683796, 0.7092789085724889, 0.7646337627877327, 0.8564870883008788, 0.8094129324306745, 0.37084700274592414, 0.6644494767262206, 0.6334277244549239, -0.12806792591828964, 0.6718145015451302, 0.9926177235461918, 0.6191192751477455, 0.6347609582267864, 0.9110132573910109, 0.7820535261422379, -0.1543422792478755, 0.5964387041793207, 0.8060956298171696, 0.9698647025586774, 0.6398580883869193, 0.7811688018404104, 0.8240182333498018, -0.20140954836572356, -0.02501235317057758, 0.7572029541695495, 0.8376497647130999},
    {0.6202731683139233, 0.50804264835319, -0.10587558564982968, -0.09469632400412961, 0.534922267839337, -0.0590280652667416, 0.7136466799103662, 0.6916425768688137, 0.7854738114860271, 0.7646311311666517, 0.9708761630492498, 0.3489318333185294, 0.5990235352904676, 0.7002093070293901, 0.11296726501535664, 0.6328428622273915, 0.9672882091612557, 0.7516610447704134, 0.5630180715804001, 0.7500819740775877, 0.957055357978883, -0.13187601053590534, 0.9274309272639767, 0.7367578574065169, 0.8971292563586316, 0.8001277589218124, 0.7113665571539877, 0.9204191082070016, -0.23978627563541524, 0.13424520647150295, 0.8026081085319486, 0.8303430082972436},
    {0.6631423159248095, 0.8658600739339348, -0.23849123661672436, -0.14834988448179465, 0.5675412932777322, 0.19406015371984045, 1.0498335408869526, 0.7244566462630063, 0.5834291390484884, 0.6673510281192158, 0.8916396926545612, 0.7512804431073004, 0.6146171886146231, 0.7156567426847669, 0.16616528509509992, 0.7704335232945227, 0.9414186848546221, 0.5938092639443479, 0.36814582096058546, 0.8027455312670538, 0.8452707293334636, -0.11164139010652945, 0.7631921685302769, 0.7229773534364774, 0.5090243280104026, 0.9299150419493283, 0.5976945986331864, 0.5970227104457028, -0.05252215747572333, -0.16658131181338479, 0.7635563358319714, 0.6704436632974572},
    {0.9557186653461103, 0.6157720084868389, -0.0005054344414255548, 0.052080920055161836, 0.6987401252499246, 0.14672780050896853, 0.6506172104654379, 0.40782065187279287, 0.9715100157059264, 0.8792766339744525, 0.7785383885833164, 0.7839405832287821, 0.7646234568095904, 0.6073645517378345, -0.08043358379615534, 0.6784488075504849, 0.8318074166443226, 0.7747761866278511, 0.4601114247966529, 0.6481550451228575, 0.7014025318497664, -0.16857063586400148, 0.8367615625055219, 0.7990239043135865, 0.513799622957333, 0.7795709272467589, 0.6333005009185003, 0.5733503902278841, -0.05063251900937313, 0.18030582641773235, 0.6963661802849623, 0.9068473500344993},
    {0.7903558883700612, 0.8787265195206527, 0.09091421165754704, -0.26445910746988704, 0.4266846017557699, -0.2872908510205245, 0.7187519143057854, 0.5515165823334405, 0.5776437166035873, 0.7220744277060939, 0.6079642669727716, 0.6477232080069351, 0.6865021845021603, 0.5696601090295594, 0.26295285766074505, 0.8791927216570308, 0.8556367709307164, 0.9601148694143907, 0.6151511297012132, 0.7352237902378457, 0.6398466236244854, -0.3109931273684714, 0.8811854175418159, 0.469503838056416, 0.8480897114055548, 0.7632190028003091, 0.46578349725322116, 0.983484132643436, 0.1398985443588079, -0.18942265803224947, 0.678604841263351, 1.0229044546564505},
    {0.8327225542126849, 0.7314231099321249, 0.18727256385711494, 0.011835174526495825, 0.7875989078431963, -0.2703178369502097, 0.6945357623735393, 0.5664382935596324, 0.9450843941399111, 0.45232762721236275, 0.8060449310316047, 0.5034356551997442, 0.5561022375897705, 0.8340887096172103, 0.1904953557683443, 0.6294912684610505, 0.8374429043142247, 0.6234062681499476, 0.6402244395988819, 0.5833239174711979, 1.0157523069542904, 0.1547797912966686, 0.8531628131154049, 0.7022411265292146, 0.7676535899607781, 0.6386805033679444, 0.8675035573198748, 0.7256054874173014, -0.15755689198286044, -0.18169233398923718, 0.7214253503915651, 0.9689245140035162},
    {0.7988079741876997, 0.7383889071035031, -0.011390352339645807, 0.12277148421436779, 0.5096195808251357, -0.2399581332640456, 0.7811902314079984, 0.48971621634506945, 0.7606478241141991, 0.6662882326208259, 0.6095421037481819, 0.40799874285130977, 0.7230141924510639, 0.9475639786749047, -0.04150618548810649, 0.6768306015491307, 0.8750824553536031, 0.8017374014003454, 0.4686474985432692, 0.9487914093831992, 0.9486861891709126, 0.18445300718135454, 0.9267774928643598, 0.7947142934575042, 0.869817893547194, 0.5807439174833182, 0.7759311877037168, 0.627485165744488, -0.02688298838335256, -0.036378181790595494, 0.75029256072037, 0.7614827947766937},
    {0.9894853861085188, 0.811751583488612, -0.18161666038914523, -0.07275033356123063, 0.7969581080621913, -0.1305759291056391, 0.5375847420136094, 0.4683406603692251, 0.9803532062963692, 0.6375491773314572, 0.6204618505244744, 0.6447969947724641, 0.6053239385783349, 0.7288745277062849, 0.09801766962809427, 0.7916927660488416, 0.6289010366130963, 0.722773689568573, 0.7891633639522674, 0.7722834171726852, 0.5632683267747423, 0.1040345275617934, 0.5698623913223654, 0.5947221444094193, 0.7610496574303452, 0.838184028264544, 0.7064148364583992, 0.5750185854851491, 0.12888449420940304, 0.19072281949603279, 0.6512466942524493, 0.900213589115292},
    {0.7077326341777398, 0.8224527779698844, -0.19012568328257373, -0.13434488993095692, 0.5189071317275519, -0.015284045912427512, 0.6974399556029763, 0.5814329949183744, 1.021112707962461, 0.4514436259906129, 1.050674045120246, 0.6156053726270481, 0.8498152692035628, 0.6690310386455346, -0.07075062687405383, 0.6128806598514205, 0.7398669299071796, 1.0045251475869559, 0.5862598133582458, 0.5500691757473392, 0.6454376942370579, 0.16803830708132902, 0.9460009805161388, 0.5235338624166938, 0.7756996003738206, 0.7895844518112994, 0.9112738911182479, 1.0109229176656358, -0.01653333017974992, -0.25841131154028596, 0.8798404370428452, 0.8513160110732922},
    {0.5929173509862096, 0.9509695055640398, 0.16337972600431716, -0.0349059255677212, 0.6448468030815382, -0.18489151191822395, 0.7414566333253101, 0.7256304692412189, 0.8807047252710961, 0.5809485577163431, 0.5833029982485815, 0.8081653365880581, 0.5398326951308916, 0.9983492687957416, 0.1250045636529094, 0.7426844824423783, 0.7169221598280636, 0.8345098869747968, 0.7546798709864057, 0.6530486605553069, 1.0339032325688182, -0.017322098364321272, 0.6347995978935761, 0.9434135417189106, 0.6301444426669899, 0.8148976555011082, 0.4361498787483095, 0.9387273030037254, -0.24519957613320537, -0.2865356202990018, 0.5046767975639354, 0.9037781508493047},
    {0.6878026658603489, 0.6898711562924214, -0.08994479418381186, 0.16747602856589097, 0.385527541108504, 0.052229660182214276, 0.7952181244031362, 0.6937512438926391, 0.788324653807939, 0.8446516132858061, 0.7025629153980166, 0.780487417611475, 0.8766588296002576, 0.8403803381259265, -0.16032359162676676, 0.8629766638288042, 0.6133736282982556, 0.9924746249917531, 0.8607698098746934, 0.8837566828856077, 0.5677442146086034, 0.03843661074325628, 1.0174412792984961, 0.4916260400741404, 0.7813183586885207, 0.684227240887297, 0.5077148496835433, 0.6569959359141366, 0.08298699897282591, 0.13007301012497918, 0.7441022642737407, 0.7196688588465594},
    {0.9867391938956319, 0.6721759471394626, 0.15124725228547822, 0.1827535623405305, 0.5053434848330319, -0.23739983248484783, 0.7940341666373625, 0.6972068961675929, 0.9844519319200443, 0.7007777695723233, 0.8373791423510588, 0.34520464243617177, 0.5933361367810058, 0.639959142455128, 0.11767524764961747, 0.6469608615956906, 0.6358367914314286, 0.8075877291520934, 0.6432677497193809, 0.7056018972548941, 0.6449340664732413, 0.18358380335662822, 0.8474614129375426, 0.9735254551610271, 0.6753003019330703, 0.7165274503021432, 0.6237245081079527, 0.6931383964113922, -0.07628983751990662, -0.16208877555466045, 0.7100608559710437, 0.7433960477454334},
    {0.5735400335352955, 0.5235157066591394, 0.1652297623941326, 0.07737118061126337, 0.7116156747092195, -0.24620826309199478, 1.0298461332361353, 0.876591184086048, 0.5901339066939195, 0.614220892184087, 0.7089333126287757, 0.5914695359005057, 0.524313687937626, 0.6387111965195479, -0.006871487765204961, 0.6485984004574181, 0.6080706223529372, 0.9884318719353079, 0.8039496331502396, 0.7195090720938955, 0.8870264993467468, -0.13978413206451143, 0.5047171040719376, 0.8106407541291591, 0.701574160581243, 0.668935580395844, 0.7469892500463924, 0.8569236297779409, -0.26248941494176414, 0.019426817914221507, 0.6549713303571897, 0.8347121085175196},
    {0.6822161570693778, 0.7889020053471798, -0.14301676119016873, -0.1648845344799751, 0.5182640358272861, -0.24894209701565992, 0.8570826725927625, 0.3830412431854568, 0.7897898605630328, 0.8861059489875374, 0.9034050465766178, 0.3793924992930965, 0.7138579624749826, 0.5505955928475545, -0.17377390775916737, 0.6024853443109325, 0.8494608945736356, 0.6615554390967237, 0.41929527074995393, 0.7739077357799574, 0.8722207681373468, -0.19865400530764135, 0.518253811636909, 0.6614833656937898, 0.9341494107695691, 0.6376082010188859, 0.8611917890723061, 0.7423229572889682, 0.014580681071027978, -0.008979177486768975, 0.5406436351813128, 0.7917469239622527},
    {0.7338929025824938, 0.9077715979433728, 0.05746639215009849, 0.04674554082022785, 0.7882621295943979, -0.016487321202218606, 0.9675311201984998, 0.863306245678683, 0.8487207247938685, 0.62143864325981, 0.8061834590132191, 0.7457237196893707, 0.3882541259830414, 0.6728103082154768, -0.03434093038763302, 0.9701134507382991, 0.5950232989626644, 0.6328255523418531, 0.46700391982619366, 0.7916002819134379, 0.6533443949154915, -0.21766933685661327, 0.6482285958957107, 0.5869713545288676, 0.953124109847284, 0.5938793270421602, 0.765028298443778, 1.0107190392848475, 0.1515129306646412, 0.17444449680104895, 0.5674558976087877, 0.6787855646583936},
    {0.7473340551454775, 0.8198685054750977, 0.07173331948279763, -0.25207544287982836, 0.7251605299377639, 0.02028437968352939, 0.8187363675407191, 0.8913492554314802, 0.8024535081543452, 0.4832926404084153, 0.6563866348770916, 0.6087541208606179, 0.6280960601289591, 0.7839546641459447, -0.06583814588053219, 0.9591559227784716, 0.8887935663437669, 0.8212233736881336, 0.4424893396312422, 0.9998673049257006, 0.8834141861479504, -0.2550351093365665, 0.7714429580288386, 0.9117361795746001, 0.9583726721959552, 0.9664279386965455, 0.8332436783757975, 0.5874408628789223, 0.2162085826867976, 0.13655719394869442, 0.5610648450701811, 0.917547173076294},
    {0.71068091508646, 0.5746990957765088, 0.19395933992997663, -0.0459557439008119, 0.773399698138588, -0.1145779687456158, 0.582201099034039, 0.83892606621557, 0.7900183073288984, 0.7025165084119339, 1.0432051319929274, 0.8462284369661703, 0.6094480712893793, 0.7781476250842309, 0.27490671781940534, 0.9477817526605632, 0.9937435781477642, 0.6084206960797176, 0.7518817078067084, 1.0490857467749108, 0.778906486269215, 0.16292561189708032, 0.6600536119686382, 0.7565336420044113, 0.6861751770394793, 0.8916013167406616, 0.7102077262793851, 0.9065948070135087, -0.19696325527351394, -0.24514663015345226, 0.9132162869308118, 0.7739181785230046},
    {0.9229399515816223, 0.6667519989489129, -0.06949458176198396, -0.01785172004280271, 0.7758745700933452, -0.24103835587070777, 0.7450121678139495, 0.6201908441520403, 0.7017848170094304, 0.9179919849650267, 0.8575284380961458, 0.5226404885629534, 0.3801581319395611, 0.9483109792139006, -0.10717821517253823, 0.6287448874256787, 0.8404710503040805, 0.8016970169371276, 0.7562810672434015, 0.6818720156955009, 0.7074239465709192, 0.2125926630396838, 0.8312497211803843, 0.8230541851703961, 0.7467341127901703, 0.9725935347584169, 0.456135201515725, 0.936740638528194, -0.08499771245967615, 0.18663864251378984, 0.6600126194620171, 1.0083427220403938},
    {0.9402264513960471, 0.5842431078369871, 0.14020809880841037, -0.13666222002635472, 0.6464108146086237, 0.14463365825434554, 1.0148973631741305, 0.5962343605744038, 0.9438761334542192, 0.7372494243404972, 0.8912440637675875, 0.6561774285852897, 0.4695987950016535, 0.8494209151074674, -0.18741838769390043, 0.6270011841604244, 0.792059252905704, 0.5585869552797865, 0.5197068066991758, 0.6578730736777281, 0.6429545084577585, -0.03866442554806577, 0.5578756728956933, 0.48048567524151364, 0.6918874577865045, 0.9993538317080591, 0.6588012879020745, 0.923518923373284, 0.13093579029245792, -0.10702147630550596, 0.5262421178333142, 0.8627849825216067},
    {0.8776149401797424, 0.5066299460668047, -0.1768935381931338, -0.19532631223078556, 0.48126804411119306, 0.15194894520774277, 0.8697108880606502, 0.381996665132204, 0.9090313253455887, 0.8629731894578797, 0.712978695771398, 0.6160826194228474, 0.6321242990446978, 0.7755040898706929, -0.013429469041494441, 0.7065598346245944, 0.5946572276959496, 0.5487745182072475, 0.5697325789905167, 0.5171226184129049, 0.654652756553061, -0.27012905654879776, 0.7492654213228658, 0.6644919406386719, 0.7734566370913646, 0.7997761840044779, 0.7467593168595295, 0.667067017522431, -0.04364576703025135, -0.018880762306771832, 0.6220814286430447, 0.8935793095220369},
    {0.707117227074794, 0.5015525939984176, 0.1500081068574856, 0.1736428950492461, 0.5891205281135846, -0.07818468343441815, 1.0115249804248712, 0.718359753962902, 1.0164628605374946, 0.8269028548446885, 1.0517568450962669, 0.7065624246798026, 0.5678348098392118, 0.8309258305885057, 0.06575691934170742, 0.712319304257945, 0.9271095494360593, 1.003782514859286, 0.8719185625152739, 0.8952089779876692, 0.8190758120093554, 0.07656623870384952, 0.642451034660351, 0.6760877482448253, 0.8407548599991811, 0.9959513589194099, 0.8856603523735632, 0.5598857182689817, -0.00681573794092297, 0.08882018257482699, 0.8497669896271236, 0.6070159443298263}
};

static const float b2[32] = {0.7702727655672834, 0.6969562413662217, -0.02932595174951759, -0.060114054631520746, 0.5359177887600797, -0.07217680096650252, 0.7911535992962206, 0.6149867192403812, 0.7552600949023662, 0.6430480512010549, 0.7520603487302343, 0.5369195230996916, 0.5684173971498825, 0.7391011418037352, 0.0900030568404805, 0.803142511267482, 0.789101714818583, 0.760241193239569, 0.5898070557073752, 0.7350399466918387, 0.7659163502907066, -0.054866591741196444, 0.7175594537321608, 0.6863398843059993, 0.6928052257537057, 0.7903748666752836, 0.5972589489098161, 0.728056445576908, -0.07368063779575289, -0.06394949988018497, 0.6809373804426692, 0.7812471556339826};

static const float w3[32][16] = {
    {-0.1833905913927437, 1.1453253527416845, 0.25472028209783865, -0.31230812124103124, 0.29779007357137677, 0.00022622720799864447, 0.8515519349882239, -0.1887071496025593, 0.6038683900202119, -0.2823821110906026, 1.0412124525401298, -0.12564416142696544, 1.0341734041293653, -0.08131381721399278, 0.014276295063701, 0.8135274101628753},
    {-0.21654508398812183, 0.856718354297259, -0.2655068140925205, 0.2669471575941267, 0.029737213490707872, -0.2626325269389018, 1.1014389292220663, 0.21063611579413102, 0.9756097373140725, -0.04182579628004411, 0.5710395748898787, -0.272240018563582, 0.7185992168199365, 0.1719811604766545, -0.038836799798533446, 0.8082526399047527},
    {-0.0012607704473541826, 0.08848851962616694, -0.0007276740009059947, -0.30640052775161897, 0.3208208522570676, 0.01119032770115087, 0.05885174876232111, 0.20633105012915742, -0.07757345775460099, -0.05138062721261571, -0.2406648112589373, 0.2428856242237277, 0.29325794305910724, 0.2517996647708812, -0.28763803495864837, 0.31029503640956646},
    {-0.32698463693045493, -0.1426716407865617, 0.02412445285236993, 0.16961426623809714, 0.12975461937426683, 0.2722598978087619, -0.20910097183684878, -0.32414350424427874, -0.07734437933491559, -0.010052395308951464, 0.032530812203999275, -0.33770790300975445, 0.36348310184329613, 0.2294542375947382, -0.03450652046587111, 0.06967206739467659},
    {0.11370398992479257, 0.5320004678148013, -0.2513597002987208, -0.14280390771704576, -0.09303335055916177, 0.1350349981850487, 0.5224878118378358, 0.22525186100880942, 0.9269465033218377, -0.11603002321388609, 0.6353487953934833, 0.19422355183230391, 0.4139146328660889, -0.10196335218738116, -0.28987400897868965, 0.7008277838359177},
    {-0.1958900004523916, -0.1956552353927506, -0.2561832886860524, 0.11813086835695709, -0.2642084623138623, 0.2918414111052479, 0.09713091884542518, 0.2101243446117238, -0.24190845799126262, -0.27482366490569643, -0.17507232690215918, -0.09870025741446489, -0.3362943627657199, -0.12857929818361244, -0.10722512776916295, -0.24867722447088042},
    {0.1317882327584968, 1.2503519028906882, -0.36926726010844885, -0.06568879258618261, 0.133498003972156, -0.05282468317022542, 0.7571188613776798, -0.285802251985586, 0.574187717368561, 0.04300168323246006, 1.1551089281517175, 0.019449597138165787, 0.7891549301129963, 0.14485202567256902, 0.10868948923552324, 0.47278454074459314},
    {-0.3115643072894056, 0.9169641065705223, -0.2235530020817036, 0.23346831085272382, -0.21936016084989937, 0.04430032876921542, 0.5004158077889875, -0.1549137538038779, 0.881051926935131, -0.18128223217350148, 0.579755513477092, 0.11169585769826927, 0.6883182583652316, -0.2478747690787719, -0.007920280305927525, 0.8431005002977455},
    {-0.12985910823229585, 0.9406406588455607, -0.23499766473435454, -0.23482694218402259, -0.13677634564360958, -0.3648144547508524, 1.0233588250490564, -0.19653121170111443, 1.0641825921141939, -0.2883171769567767, 0.9995351172919026, -0.20139030476568065, 0.9751133906391594, -0.2748978093890911, -0.08849971334159076, 0.6040471884874145},
    {-0.18678179886381752, 0.726789685964106, 0.19564596923911384, 0.10327146049535385, -0.34398373199416077, -0.15528467294319162, 0.4030981369525382, 0.041939916882181086, 0.9242005905996306, 0.24699333502836365, 1.169868438231985, -0.281127880257852, 0.9086014975679362, -0.033157937468904816, -0.33540226606241547, 0.6764242289240243},
    {-0.21732951835328362, 1.1835375009976161, -0.002659477220529666, -0.3416616016566511, -0.2796546504259804, -0.18345952265834387, 1.120506973861534, -0.09290313464909716, 0.9196914541597402, -0.029441496442953463, 0.8626171546621313, 0.25559415855741807, 0.5378153534909901, -0.34537133753851296, -0.23886178819826645, 0.4956407242719568},
    {-0.038508620734149734, 0.7574206328850791, -0.20689536179233473, 0.2528372085191813, 0.195768771719404, -0.20345174532824867, 0.41940051811024537, 0.3004305440331141, 0.9616930554552041, -0.25556800657899176, 0.9290679091572361, 0.1650045150132176, 0.40731454377776877, 0.15364391541849834, 0.005734793355634345, 0.8116253612686956},
    {0.29771459731550426, 0.5536524394603437, 0.2684250891854954, 0.01319520775223534, 0.30383644282951633, -0.09303491966696949, 0.5615736422933408, -0.20826905896176665, 1.0091447387873227, -0.066595726648224, 0.9604887815148562, 0.030470123781180015, 0.4987844933840419, -0.2569857334565219, 0.034037682380768264, 0.8516301828688616},
    {0.2868216696051136, 1.0104906504826077, -0.3320566081816744, -0.2553559876553487, 0.23350773843959524, 0.0728547952421799, 0.9331454060906, -0.11808096949351574, 0.680940660948791, -0.1761185287215883, 0.9702602455780373, 0.22804448694102059, 1.0859015283835487, 0.07980372246948962, -0.1379579309368574, 0.5520401981580249},
    {-0.313817254025877, 0.08015688542061314, -0.3508454786365003, -0.270302735179355, -0.16707392404639454, -0.32234878129951383, 0.09758997616386422, 0.24834985901821025, 0.5900627664410381, 0.3082476917731446, 0.04898290895197429, -0.0459833232375688, -0.05771073449137616, 0.12332969153212522, -0.03421486868229813, 0.23590071330539905},
    {0.25068954443316205, 1.2382569620965092, -0.18181058682611148, 0.05940279304303296, 0.1510973062261984, 0.2619292275140474, 1.0953688779041788, -0.13904032989535672, 0.6861694865382244, 0.23523004421053853, 0.8100287820003307, -0.031323674946581365, 0.6805931244203156, 0.15952707648334033, 0.08842361269733316, 0.4503465216803257},
    {-0.12550801139827913, 1.1821818282107612, 0.15116595531809282, -0.245533383301688, -0.09160519566189293, 0.05924389428783115, 0.7538150132798109, 0.24109274467161387, 0.8049559036762186, -0.13801656290319841, 0.8099977005391671, -0.39318414404063295, 0.9841951275258947, -0.12140791051431224, -0.23713982689040577, 0.7619475054935895},
    {-0.30641629800213943, 0.688353441941847, -0.04720258232218895, -0.17432443495009914, 0.2512177678493721, -0.3202337606443865, 0.8706767393462144, 0.014198691478362602, 1.2062884459387706, 0.33697355580188193, 0.9329735196634528, -0.05716990976849805, 0.9532360203660208, -0.1077248921550745, -0.12944695796102146, 0.7582823838426636},
    {-0.17726462370889035, 0.9668453090057507, -0.22341736836668233, -0.34091920158158723, -0.24632152913751892, -0.13617040775280856, 0.42737314866274545, 0.016471005491966124, 0.6913245643311176, 0.04910801272566451, 0.7374927825023897, 0.28777907737859787, 0.7899594148541634, 0.21217684446926438, 0.13730433984212628, 0.6304874248856598},
    {-0.2628879065010065, 1.1464516705077266, 0.2869229265025518, -0.34864313424336446, -0.11198104604826177, -0.027585434779383765, 1.0823299695532678, -0.031719958855248656, 0.8077180162466173, -0.24952494574108408, 0.586496260999009, 0.22524883707295443, 0.6758670808297116, -0.0579563283768126, 0.3065795523990191, 0.5050941887635813},
    {-0.0694538263506372, 1.1499637815809922, 0.06315489557993144, 0.27113163212693825, 0.2481095667709502, 0.2697962469239343, 0.9000805338800961, -0.24337531037267526, 0.8919293344789161, -0.10796812751719584, 1.0839877303093826, -0.2558052827272252, 0.9905125131283106, 0.15152338723626846, -0.3612099459207012, 0.7605019121208647},
    {0.30790880078968563, -0.22513801990444213, -0.0976915107206029, 0.3301693747700696, 0.22126641922079857, -0.20777293857724471, -0.24421270496037265, 0.21592289569731324, 0.13449403257695025, -0.02502711419699536, 0.026757040770159345, 0.18792140698074677, -0.06525850840806745, -0.31956243842405035, -0.260889499143555, -0.2857566351921994},
    {-0.012874645526995406, 0.965870337576714, 0.00499962765492001, 0.13677859815784082, -0.3297476902704025, -0.24068298152829964, 1.0272344475164976, 0.251635691817785, 0.9391870145941402, 0.23655583774919997, 1.189273450699668, 0.0655552803483089, 0.9154369816408554, 0.09865895887877063, -0.28829797452123856, 0.8212155517689494},
    {-0.32524896484521426, 1.0950792011928048, -0.04218714508822171, -0.2991292963090721, -0.23398975197319755, 0.1857550873198229, 1.0804484122948215, 0.24687696670842307, 0.7833015535621897, 0.24525166660208308, 0.6915304974923703, 0.02022369423096432, 1.0180049022313022, 0.21420703497514224, 0.0304918968822335, 0.8570075874969704},
    {0.13520991324273296, 0.972614867947262, 0.08143099011381301, 0.14371174471806286, -0.08455838353022825, -0.17305700086120765, 0.7890497441350796, 0.008879473830021908, 0.8918275056574694, 0.00438459955376451, 0.9710685081828875, 0.30429877029124225, 0.5931272714979046, -0.3542856120410354, -0.2925333812450265, 0.6275399307202952},
    {-0.15511337498058586, 1.2487003422466756, -0.05050929210723959, -0.3640469816624376, -0.3584347389067671, 0.05086408023216215, 0.6876514948807549, 0.17119335078927014, 0.6110319987209821, -0.07929042358089759, 0.8628324807084807, -0.1475738844589891, 0.7349088610794016, 0.08027943227796829, 0.002244459447249324, 0.5432832051531709},
    {0.022060655018714792, 0.8212445907133393, 0.29041350488684975, 0.07826599244245117, -0.35045898344486726, -0.12182163404270774, 0.5740978429416743, -0.1744473227480934, 0.6337413607009483, 0.09354123540245537, 1.1436389380177483, 0.10583959967554896, 1.0442606577030944, 0.3161960202030018, 0.16229609247040103, 0.7976272038284379},
    {0.28716366593392756, 0.7584989272752193, 0.05400096967470092, 0.11190380534962915, -0.24721182970360883, -0.15091652512850978, 1.0250012959972261, 0.11894223102768825, 1.067542266112063, 0.04336057718875192, 0.8595819180997796, -0.38548193425129695, 0.8535043953574394, -0.3176891490659042, -0.3188411711121145, 0.4382012575370014},
    {-0.2776868535322208, 0.12130902487997333, -0.08909331365238977, 0.23996631645050495, -0.01718942608435192, 0.16970645935160444, -0.002334803176182558, -0.10944069708079707, 0.16777947853738875, 0.16430172376464863, 0.22673703159473266, -0.37603890021058484, -0.03631481403493442, -0.16264757609156452, 0.13754634291458084, -0.370757088050203},
    {0.27099243010573854, -0.005732484963144458, -0.15702784607460943, 0.12427777340635808, 0.08226035009613311, -0.3179620656923056, -0.15443501277462615, 0.17980118628624914, -0.08772392667932274, 0.210470240209819, -0.055906999420647606, -0.01561372570790914, 0.24126403633904112, -0.2352373951063217, 0.26082333770981725, -0.2188781964673305},
    {-0.1419726309074858, 0.893582000221288, -0.23551380982494619, 0.1546689132790034, 0.0495874763881869, -0.22089697022771415, 1.1508797723996873, -0.09453981593239914, 0.6974705692446984, -0.12833728502650618, 0.5277585932333758, -0.08605236453630224, 0.8828808460960659, 0.28066351284871055, -0.32278837031956664, 0.519081108674144},
    {-0.0808218041746038, 1.2273186702175622, 0.05838997567081798, 0.14943110389449782, -0.30516543207325664, -0.09446775343296011, 0.750887741346009, -0.20346152198898376, 0.979758324246235, 0.05425940199448479, 1.1703243175678673, 0.10360756809513376, 0.5971233032349315, -0.16135591377495484, -0.05052835249571924, 0.6376554998864493}
};

static const float b3[16] = {-0.052440474642654576, 0.655076569415764, -0.041461217879034035, -0.044049175053099236, -0.03354514230880938, -0.015485640953621612, 0.5545515211633633, -0.03522737254793848, 0.6499444480783099, -0.02166189442678678, 0.6195731069573234, -0.040872354892878965, 0.6344204496917272, -0.020747122938462682, -0.03485239300622145, 0.34647675817243495};

static const float w4[16][12] = {
    {0.15953251520866948, -0.24711231564438996, 0.22887413905478934, -0.10273047072020915, 0.2541149103834534, 0.3682363565078459, -0.09219491071035987, -0.09602501024353802, 0.1660829199847677, 0.3491990603421285, -0.3743489111512384, -0.20647952517004647},
    {-0.6594963342948723, -0.7037650831449006, -0.7735892031277282, -0.9166654747278922, -0.33623989653949504, -0.5428943638650255, -0.7962138940592186, -0.8917046074012093, -0.7376510835443824, -0.7882286763383777, -0.6635127424207983, -0.5830860435345053},
    {0.35125572029728114, -0.04334202941102379, -0.2027148805451131, 0.38912557091283306, -0.1531165063361596, 0.13035944141135028, -0.44095428108216356, -0.04722324622483139, -0.16782148199516608, 0.3480106694502974, 0.3043148013568684, 0.20474660971508257},
    {-0.04899839431614086, 0.41395942660185486, 0.04692777368167126, 0.1308443419746343, -0.45069569416682925, -0.4159071863804378, 0.38804748969885433, 0.1878273067797845, 0.15043065655511897, 0.029413624037434544, 0.048588274004300894, 0.025927785628326882},
    {0.42655020375134406, 0.2629698854144945, 0.07059107657912053, 0.16176651088959884, 0.3352138333222887, 0.3652156570815994, 0.048561318147684704, 0.1326568294096532, 0.021209541431910516, 0.059142782745791336, 0.3998681970530801, 0.17746436741038868},
    {-0.4047451284162198, -0.1690069579459847, -0.3129374047333859, 0.3506724074811343, 0.3960683953935801, -0.15077454233566503, 0.37432998525488864, 0.37503287539716385, -0.3762104431091629, 0.03676939213510118, 0.2046660762399862, 0.4110373340659628},
    {-0.7864107844231392, -0.3268472288604558, -0.8790045561192824, -0.7640861928886361, -1.013985766892918, -0.9380536219659259, -1.0694861772453437, -0.8000435798175185, -0.6794010715861405, -0.4140686323770438, -1.0321106290763453, -0.889312620778206},
    {0.09345429821497289, 0.33128668538917905, 0.2356326508497729, -0.0624629604071463, -0.23123456543170084, 0.17960301891217487, 0.281079558286021, 0.04479782821177998, 0.35072342710704146, -0.4174216353518361, 0.14054620076910906, -0.43379264639058884},
    {-0.9574294257020256, -0.5571584603444294, -0.666914268459147, -0.8777575314848822, -0.8649045557196988, -0.45361339753552243, -0.8979343652525832, -0.6680245728623081, -0.6109219843169911, -1.2185689531214734, -0.48878425507248047, -0.44651537375800965},
    {0.17769166679419307, -0.26126674135966177, 0.059003218143776175, -0.20042250011322116, 0.027235227587346866, -0.15426912279062233, 0.22357156448593352, -0.012931120027802896, -0.20935448632854886, -0.1943018760284508, -0.434590087904919, 0.137418591079497},
    {-0.48003769453337936, -0.8718426708230994, -0.9916806580753498, -0.5205849663895764, -0.7357851162081087, -0.599174189770689, -0.3545024416264783, -0.1621433339958281, -0.6472131451910998, -0.9380241315379695, -0.7938460874406089, -0.7149903898193647},
    {-0.10826213063092265, 0.2899618340162466, 0.275103749685944, 0.3207403766952428, -0.24823487194034294, -0.06582291642106916, 0.22620287955527146, 0.03616810166248384, 0.24917656952335182, -0.3381750983363744, -0.28063356296092795, 0.20852530153867224},
    {-0.8238346576087399, -0.5296788956680576, -0.36774157785451533, -0.7387218121135875, -0.7465131528892612, -1.0013465845803609, -0.5613101163451729, -0.8242015271729676, -0.7531660706181691, -0.29384878636458767, -0.7016574375407697, -0.6524883397482071},
    {0.34420999874202146, 0.280274340117456, 0.04400895027560004, -0.2187460205706242, -0.4170846364591626, -0.18977910653361585, 0.4270762712906091, -0.48049103655635755, 0.05510981924709972, 0.40396972342088416, -0.22389688114036155, -0.09060235445992594},
    {0.3823950863767893, 0.15521729594791128, -0.12861452439468893, -0.14087852409992987, 0.2269637433592273, 0.04571831120514654, -0.07325070090591279, -0.10006608589837467, -0.13938199609772056, -0.21492723215781973, -0.45605487494086927, 0.34495216482131685},
    {-0.23858558747571895, -1.1029010227044553, -0.19567261983169879, -0.06335411905183498, -0.34472171589911155, -0.4527147957838307, -0.2422014595184523, -0.7401891817079433, -0.6144630876281489, -0.2134717708639704, -0.29830408054760094, -0.7678433405332478}
};

static const float b4[12] = {-0.3318890571524031, -0.3208272112335842, -0.3271467612406585, -0.18759007440807676, -0.21689070404347255, -0.23081403979298254, -0.2637059502270231, -0.12449744670411021, -0.2318084143538759, -0.3693122136555356, -0.21537452867581877, -0.20151703728626827};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
