#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-2.9240697658305854, -2.5569407333192133, 2.721127175721092, -5.020762059643753, 0.1562564969552347, -4.060443256958768, -4.733393493320752, -1.3275005494790997, -4.808239398085337, -3.147566669277796, -3.3199902606440443, -4.4900153174609585, -5.36851353566282, -4.897611422483586, -1.462823967765565, -5.624043971526993, -5.067448697250976, -3.5427324595303302, -2.3272977984648198, -5.099582892147707, -4.347239805939508, -2.5840049204315614, -1.5947694221622002, -2.7309773418383685, -1.3112267690288926, -4.839413409436536, -4.0234259741691645, -4.420456536325757, -2.6262856951971094, -4.634887825228138, -4.394596491640305, 0.4115257607075072},
    {2.1482980663561544, 1.8355064041165858, -3.4374298974202655, 2.6360634877006603, 4.217840727333994, 3.3589547255213477, 2.033913639874844, 1.111994730470232, 3.301532510475335, 3.5681549083123643, 4.025395697425003, 2.7280353929914303, 1.7787479552532341, 1.2024984582777998, -1.4359648039960868, 3.7858170953834653, 3.1416818778047366, -0.9180785412564092, -1.1568676912038447, 3.058464308385412, 3.53756985525739, 1.6583260246348883, -0.35870820862073494, 1.2536044964107869, 2.702641525704118, 2.345068886084738, 0.22887074131852844, 0.9913352985059409, 0.744283278946947, 2.1322353401491982, 2.0188062450171764, 0.87414640846887},
    {1.1009825916518892, -1.5392193308315965, -2.544856139461197, 2.3834149330003545, -1.5411452856522696, 0.6715990580723822, 0.9324377525662694, 1.8698545500624284, 0.9164004952504881, 0.8251815407632503, -0.5951820589722109, -2.1341169159571964, -1.6000781972824727, 2.319904432366053, -0.5012758193567841, 1.1550582910063367, -0.19843982636857202, 0.3756072893827253, 2.330826238470883, 2.000686696247698, 0.15005430492555105, 1.8647656446862368, -2.0078906371728262, 2.3653812578566518, 3.354531315896814, 3.7364685758344445, 1.066748600816004, 2.6196308037098306, 0.23180545428419175, 2.149913911094317, -1.5845354049833447, -2.181021708889974},
    {-2.1142472291129115, -3.238566197512657, -0.9906354961892289, 0.45460568933903145, -3.654205425594118, 1.4248278992627141, 2.617102711587913, 0.47671462446667273, -3.1205172286730694, 0.7731483395183908, -3.513894399555241, -1.1307880186844554, -0.09187082955281202, 0.7365902530261869, 1.050675775352758, -0.8538664500911202, 0.4442300696054391, 2.7469462090101695, 1.4548233276027456, -0.7011340315624887, -1.4136965835593962, -0.42042714194884845, -1.104849910583269, -0.36736170352368974, -0.8180547691866917, 2.616386999229941, 3.4377659825605567, -0.6795889287108182, -1.644248437348669, 0.2221703064492665, -1.5003240512193288, -3.3729867220344967},
    {2.4412589469238735, -1.1093256502459854, 0.666507904264146, 3.1734667359666173, -2.529380188844683, 3.89970800089154, 1.8274963276746148, 4.213874776732098, 1.5855023515441586, 3.174690760719732, 1.332372437541739, 3.2166856188491044, 3.25407129935285, 2.9105556645902597, 1.7148526583590566, 2.766323092941764, 2.0402919274131035, 3.6860482802258177, 2.014857131982893, 3.0318884230546157, 0.8112142008627757, 1.2086706848312685, 1.9567441968024752, 2.5718624620095785, 1.2898092168637616, 3.954377734585241, 2.988975201895692, 3.051184686224469, 1.6445024835687831, 1.8879550799826452, 4.779842140062583, 0.9022980141982729},
    {3.1539243140111832, -0.3219412000161063, -2.015893493986904, 5.783990976301222, -2.913724564506946, 2.927701110388677, 4.782179625324145, 0.5779644953478128, 1.7668601762000486, 1.8763158260797508, 0.09463537728169413, 5.924967698582211, 6.14903984397715, 4.135563428631728, 4.805671854317055, 5.714022921272434, 4.581249384152793, 4.173031421300887, 5.139306198859182, 5.210794618397904, 2.689898979934897, 2.894909728330342, 1.2354746328222288, 2.117633136933897, 4.49573665123252, 4.6755459852488075, 3.3081904977914136, 3.413710371170214, 1.8460147871745984, 5.849696765252295, 5.324755299712371, -0.16285373094765795},
    {3.590870432858041, -1.020633654710497, -1.4420701934453546, 4.9590344585053545, -2.2315070112336812, 4.570354802631491, 5.755328351064902, 0.4280764328352391, 2.431330705163549, 1.0077588547568388, 1.7614110698000962, 4.366903372955212, 4.994760694977996, 3.5723668986712447, 2.6841814718009127, 4.5848795607783295, 3.5005498539319655, 3.2856960861989637, 5.542725728499152, 5.656714203619314, 2.1044662524696514, 2.3914885270741433, 0.7860229836611102, 0.20765322243618148, 4.247285829422906, 2.2813984924428192, 3.4922971117228387, 2.62051001699976, 0.40297797566226284, 5.925394885475263, 4.690940451390846, -0.5452483168768419},
    {1.1161320107328754, -1.464593651034716, -2.1922726644831156, 1.7963488194834298, 1.672047418114958, 1.694355553591208, 1.052365959401712, 2.085861817452004, 2.6574886425056294, 0.0641385779787569, 0.36984105176014065, 0.9644752073844406, 2.0988030059042755, 2.146916752104854, -1.9232469243226014, 2.121392017132626, 2.0898184885577704, 1.229193707321007, -0.3201727537438811, 2.3450399367839774, 1.8122773287614562, 0.7812453200391973, -0.24793625795112503, 0.5471364702062997, 1.204610185191464, 2.066120708378617, 0.9265974791889973, 1.6755609781384508, -1.7555415857585905, 1.3553106296483797, 3.367620802512564, 0.2624874201453768},
    {-0.60816393239425, 1.173567954432233, -1.5700313430327126, 2.491286318001604, 2.1351962060820773, 1.150776479337962, 2.206833188226404, 1.8011008372445048, 1.4515108975937818, 2.312174077640362, 2.4971034231392277, 0.8211059077025312, 0.803974615580679, 0.34285786940555285, -2.5571190609350647, 2.4263916118531745, 2.1390371803678625, 0.05948830846774116, 1.1379396796443082, 3.5312863126759644, 2.3558705143251064, 1.8680329092536372, 0.375917504850849, 1.274392518991456, 2.434595144658802, 1.1435245033465653, 2.2622712964332155, 2.7360690105440457, -0.4793083746300493, 3.615075060836417, 2.3013235366905738, -0.21307548035802068},
    {0.8855037735652956, 3.413433992056409, -0.8920166138559237, 0.5633525798145103, 2.3913153287252054, 2.4418726697031667, 1.2369407466465072, -1.1522799590068655, 3.0430085421646225, 0.45402099414522445, 3.127966380372492, 2.271275619395664, 2.217334004950456, 0.1631560050214176, -0.05474259485813294, 3.3084850258644467, 3.09046805116306, 2.461074854600405, 2.02598768685547, 2.4014921863470575, 2.6519746365934997, -0.23168446003915566, -0.21542438909216513, 1.2116062186714134, 1.0525703761505951, 0.8152852398427537, 1.010882038668698, -0.09427908037875149, -0.5290599655767425, 2.5715837229988496, 1.4446897069894866, 2.090810194784562},
    {1.460067035862823, 0.3697625073874496, -1.5891108595720134, 2.1119071860918277, -1.2338336462756376, -0.4919759991103534, 2.732314041525656, -1.4634629779693413, 0.7315761713457394, 0.9975879639075568, -1.008438363264221, 2.401214978490983, 4.056303769783908, 0.39208933135126156, 2.0361480690031684, 0.2900474580651962, 1.1904963764915542, 1.0500009346614447, 1.5912485095260651, 0.5951458253755976, 1.977667879345528, 0.2235248032129233, -2.2585470287820333, -0.8741562744672571, -0.1595626943226846, -0.15842799128658366, -0.041183116468354805, -1.4809126093879752, -0.5381937874609046, 2.6656442536972222, 2.6687344239617072, 0.09952278483729632},
    {0.18306219053351425, 0.21674275924188566, 2.2038261308846785, -0.9495730774065996, 2.3903786529156252, 0.9053389389338018, 0.03018615596978892, -0.8898773264330807, -1.50428318076823, -0.061958055082272805, -0.29813807377250956, -1.8851997852975073, -0.330606984838266, 2.0032855355943653, -0.032579661944180556, 2.3253409054225966, -1.0700232671560472, -0.9615844660369397, 1.3218124149292754, 0.8110700062852113, -0.8219556020090862, 0.7815253659939635, -1.3834996111997548, 1.8592135241921495, 1.9436384589027071, -0.9625452867994073, 0.6877289957508665, -0.635294936322418, 1.9297574353827363, -1.278905679672182, -2.1666748990399474, -0.3987976074476911},
    {2.9573373473908173, 1.6044803261797205, -4.129109859160316, 3.2279606968387795, 2.4423776965230104, 0.44864419840258213, 1.8416437462641913, -1.8166548456831442, 2.190761808766491, 0.6371377799664316, 3.159111120122803, -0.532305270038796, 1.2001973105679187, -0.9541804259881769, -2.1799271978626775, 0.8489652395071449, 1.7405356378894445, -2.579808611204726, -2.0164728996277894, 0.8085106892263936, 2.818388998146648, 0.5337842348178194, 0.3992759496100978, 2.432247851878306, 0.804326505630659, -1.2743707389423597, -1.8081034360018706, 2.566103892506298, 1.1923256944612326, 2.8994099906982767, 1.4438652542126045, 0.47616667551072395},
    {3.0042036888895836, -1.241244513898018, -2.1336275218538905, 0.30686705619078636, -3.5435017711841454, -0.8685333469094499, 3.1852074767083605, -3.2522419600861747, -2.069105753090265, -0.6894572166033075, -1.7861683156329606, 2.6079367050101836, 2.7640881155263, 0.6518573514845344, 1.7232016152763825, 1.805868517872544, 2.0660368647337037, 0.5374515960115395, 2.6982448114144155, 1.2192351509565174, -0.38622698854378823, 1.01933061579172, -2.81162449601966, -1.50295168729476, -0.041234501174293677, -1.6303362685550997, 4.492299262956761, 0.4096512708724914, -1.8616633749490963, 2.9866348027078202, -1.027097077671027, -1.3670725870374703},
    {-0.2553599505590512, -0.9238487350583693, -1.4743595716124007, 0.21428022538498642, -3.8316826790889316, -2.867130842867624, 0.777945203579326, -2.7274573189110414, -3.462476331537845, -1.1598126606469685, -2.416806503370404, -0.4988686592977222, 1.8967694416718817, -2.409421725703503, 2.103223572876293, -0.7917296953896428, -0.5890038330420835, 1.6031555992852529, -0.7066113548740669, -2.69679384402876, -2.2273984061224628, -0.14504794476602517, -1.594153605362959, -2.2480662899436457, -0.8342511388849005, -4.373194803974636, 1.8103491581959499, -0.5468474084742139, -0.9534976706081144, 1.8467966362969424, -2.1269198899597708, -2.877215791712377},
    {2.4023184156256634, 1.7195303358446756, -1.9092869534708397, 2.767695705088739, -0.5769223655518955, -3.0881279918847087, -1.2797746690648562, -2.8382169745899137, -0.7982775008848056, 0.9929572092420569, 2.5697532199009796, -1.2152534224512284, 2.7307235097362237, -3.14379416520561, -0.17478442651516218, 1.2658141023243958, 0.6031607274666674, -0.5174885700565893, -2.1659825512146216, -0.4386654022040682, 0.8580431516258428, 0.6219150344785528, -0.3421279609202037, -1.6736740741909513, -0.5213351669665426, -1.80212489424475, 0.877157888778788, -0.1708404722881776, 1.3129974958941557, 3.1335563998202263, 0.00855120562397986, -0.9218324861772357},
    {1.741972915637157, -0.9896834412219153, -1.4982026669582416, 1.6248864846958457, -3.7027699248279813, 0.9060274757278973, 4.191210047875482, -2.318674077351056, -0.5099556420269352, 1.0568482585646537, -0.053767153419033986, 3.9118036504087987, 3.220131997725051, 0.6893349000504145, 3.338019300555307, 1.5128676601517783, 1.5363455335935492, 3.822717813969388, 3.6863037280198543, 2.325926608659725, -0.8264973516109422, -0.8962732413305227, 0.02568581717124314, -2.284015610699918, -1.0095618251484868, -0.9988833332610579, 5.058480176835863, -0.8870855367291707, -1.885002764577897, 2.698706432201302, 0.1284907134236951, -1.7021370413616306},
    {2.2638751958676715, 1.6895529193427947, -1.081208928807085, 1.412412974958171, -2.3284833459318985, -0.24361441857735833, 3.0772037901751204, -0.751419772635353, -0.9471528809709973, 1.0177023358432784, 0.17263805788208383, 2.9144997265980317, 1.4603932241167712, 1.1895089805273407, 3.5209189160389913, 2.4157027609859614, 3.1311853818375996, 2.3746436339133727, 3.28644818495884, 1.996820053645395, -0.34893072654143387, 0.6560107433688812, -0.9144204444826208, -0.6599476050588545, 0.08180647224412381, -2.155865053350854, 2.0546106383396046, -0.5788734267745932, 0.4165404779787438, 3.687876884229002, -0.11537068481020357, -1.5493901974211877},
    {-0.8990403848259104, 0.8524489838806972, 0.02403129238307054, 1.2431531988516742, -1.6893904640558266, 1.1232586256931194, 2.5462536080786644, -1.7056640957376628, -1.8502593304813357, -1.6295069020869413, 1.2097471380209106, 0.7779209279961823, -0.22181589406115773, -0.11135275083431381, -0.4504564773713993, 1.8494447372904843, -0.06879636559103607, -0.6592139697504719, 0.1859526093416741, 1.3685967561896275, 0.42123537069310063, -1.3039339990757208, 0.9072869615806267, -1.492116271160596, -1.232186781507866, -2.247427349550499, 2.475855580114928, 0.3889578034061901, 1.0419671905059507, -1.0252249700065559, -1.191623637701105, -2.3322134246468806},
    {-0.5397721168602515, -2.839038643882278, -0.6097450928745844, -1.0139905345068536, -1.116517931290796, -1.563057934049832, -1.0163747003969759, -0.7456025659876306, -0.31399965689836384, -1.6808938745758177, -2.9873695129438866, -1.2339388535422813, 0.2493311714661001, -1.5198447896162233, 2.4061372047788345, -0.7567750463233474, -2.522949947038034, -1.7563443530070513, 0.5941831335378148, 0.6159866441743964, -0.55114303604801, -0.2634127901641851, -0.674406856420062, -1.589870814771985, -2.354704779980447, -1.939754719746171, -0.15488816631175695, -0.6351477219938119, -3.1372380985531505, -2.5400247584522053, -0.027467697766948376, -0.847436205482725},
    {-2.912187968221383, -2.5562771711338907, 1.9861164271028902, -1.6651277612581394, -1.017437637902871, -1.8833740251572868, 0.6835958009496423, -0.9415410145810753, -4.204414835748367, -1.052594751475128, -3.3269609960645687, -2.590668513589454, -0.7001964278139006, -1.8109763506352505, 2.4030938976236427, -1.9001721936301508, -1.4439962088656948, -0.8495861068005182, 0.3264705716570324, -1.2139628584270417, -0.7349498960101957, -2.04631798755781, -2.2171180028676614, -3.456650137083323, -3.6436044473051377, -1.7326209017793024, 0.03493528169833673, -2.2936094645252885, -0.1279772776301804, -2.764940958384145, -1.2824975848934799, -2.260938320016614},
    {1.1165191133836891, -2.8145926033174997, 1.5635653090397204, -1.5496947648041286, -4.206737463088257, -1.496379462809899, -1.2488499257775203, -3.010180520645188, -2.575702260639514, -1.4478301109377048, -2.8867441515910666, 1.7684744502534824, 0.4919310190128216, 1.4015445223879306, 3.2637582262075924, -0.1649233260031282, -1.6557288503001384, 1.7727438814758798, 0.1622204038178286, -2.5145953197418405, -1.6645804970170068, -2.4291044433403783, -0.5739495160655694, -2.6388580453770563, -3.255221575520095, -0.9879214949108868, 1.7737255733611357, -1.0956621663656907, -2.0107901167758215, -1.9744922269930982, 0.057281283150086765, -1.740742677036927},
    {-0.4600805654394315, -3.320785650461278, 0.7987785693254876, -2.2956820733489627, -2.5281911921387916, -1.8965671309900198, -1.059580581054494, -1.0065971728505472, -3.088907453529082, 0.009863998579531422, -3.492077105095741, -3.003308013827518, -3.6116143598633372, 0.06963883836353466, 1.8790577175240388, -2.357784493652566, -3.196044229003732, -1.9056098533761079, -1.3681100190476407, -2.819911854519734, -2.980850418152559, -0.5204218869477463, 0.3451679927661229, -2.1377443977249353, -3.4745216794294365, -0.46434255896875265, -0.6287044991731311, -1.1796760723886062, -0.0888310337399044, -1.3635269694195504, -2.4723451140383945, -3.3995489548983553},
    {0.0716507791509977, -3.4153710710540355, 1.6497370362244121, -2.4329544801210847, 0.011707766803217499, 0.061573925668950084, -1.1877911080136307, -1.643337603099504, -0.6462656581135116, -0.04225899665926221, -1.8159004246522716, -0.2960453033580896, -2.571516711662151, 1.9417982832142309, 0.05861419439511174, -0.8028244501139428, 0.5879064566810109, 0.05697119155218282, 0.648120768374066, -0.10773281201484308, -0.5099711668774147, -0.04540571222412128, 0.3182991503395175, 0.48645545877446894, -3.7234076863937307, 1.871475253480517, -2.106133514039312, -0.28169432279125095, -1.4412352465461846, -3.070295251116493, 1.0321533317231442, -0.3952871075323247},
    {-1.5258000568310945, -2.728407492258618, 2.0994922781561476, -0.4213386480326206, -0.8887629991566185, 0.40246755412859947, 1.7997297569051305, 1.118564792444267, -1.7691005662736243, -1.824832069828479, -2.2712549186183204, -0.2494802007228798, -1.504952850028766, 2.98943326848188, 2.636046580216851, -0.9830833366300663, -1.727567468584595, 2.879103103875539, 3.041537809815597, -0.3054272864757842, -2.5985215986035177, -0.5422864574675071, -1.851809885259982, 0.7271884988623343, 0.3768802456594709, 0.9785075344980892, 1.6594902980469997, -0.5666638548191417, -2.9184254463955943, -2.007435577571116, 0.6255830220476941, 0.6841588845082374},
    {-1.4828345108785443, -1.6625275466790983, 4.738937604423735, -4.151046935326006, 0.9948935123790819, -0.30558024210262186, -1.2490125670130336, 1.211160776999507, -2.579470516723812, -1.3309806331446126, -2.3968079395793063, -0.4073585217378379, -4.238635313106315, 1.9736444904756008, 0.6558911220883614, -2.6480329539916476, -3.2385807347506383, -0.12089498733666888, 0.13172503137833244, -0.6629008562909589, -1.1917098440474856, -1.9699181694323982, -0.4240089738584855, -0.4296401277033708, -2.0241886557308364, 1.7392031956093617, -1.231177095561327, -2.0192075843884996, -2.3975334409101063, -4.8911995160358375, -0.9261483740905241, 1.0972742499937345},
    {-4.1464703411091275, -1.348018751340301, 3.4182484935861, -4.5317985579465345, -1.1410478526169714, -1.3125095465299292, -2.39426022125757, -1.0825575283523896, -4.665423603957783, -4.0229741338411715, -3.666817173414749, -0.6346766555459727, -2.718867410825681, -0.8059885704042118, 1.8384374681394784, -2.53438500943092, -3.2951426703399083, -0.8822618906925023, -0.9275918856798322, -3.455211358167391, -4.2975287028370195, -2.1751362353207337, -0.09956784490467326, -2.563417916059012, -3.6368851106404043, -1.4914304588550629, -1.0587106272930509, -4.011170817515718, -1.7056971951648576, -4.555642071683947, -1.4830668015056034, 0.8134309802773652},
    {-0.5835812686161888, -2.342556204746633, 0.9518276607011935, -1.168468822244545, 0.09048602613548078, -1.518190320098401, 0.12770181371205658, 0.5257885317819422, 0.027730178188297885, -1.396708089866116, -2.4919041212442528, -0.38870692605006424, -0.07288081314334074, 0.7327530629576157, -0.6934797725459767, -2.351273577390069, -2.689866303894559, -0.153323800167747, 0.8825738677689273, -1.65013329102684, -0.6548593598495169, -1.5581037818822092, 1.533715749177729, -0.4191048731960131, 0.704375246849941, 1.0655866191035803, -1.2331469032181785, 0.9485996557072905, -2.026993529486468, -1.977284184202709, 0.8667436384860084, 0.5299851995490126},
    {0.9832224235242194, -3.180200732703833, 2.7582049103553072, -1.7652712212488482, -1.9852983435886682, 0.6302074187500967, 0.12344769853984369, -0.7404676574202371, -3.614477242585254, -1.671610228995067, -4.342854648807208, 0.8320537604625874, -0.6879445421007097, 1.3352064206025978, 4.547747806413132, 0.7981577368463942, 0.19761108454021564, 2.6897282390133945, 3.135831097385661, 0.3409412209271105, -1.8352970962347002, -2.5382789051000136, -0.8802181169502616, -1.1284848868611208, -2.716174042210788, 1.3753939106881328, 2.5378290771106222, -2.547136264096064, -3.0680709274534435, -1.265661223194646, -0.5150991753499125, -1.226403540997207},
    {1.2866744402007606, -0.9161139725700032, 0.48938240281273654, 0.31884622600891377, -2.9746773890724976, 0.4961483524892597, 0.004350543402593197, 0.2702909169806424, -3.0784164839060106, -1.2584744547108184, -2.242151514575347, 1.6261949595964869, 1.7769668126287184, 1.7481486551511634, 3.1106398341224333, 0.34068025041748595, 0.42405349750837923, 3.335573726616974, 2.2046821450113265, -0.8645899134931949, -2.1707839384915704, 0.3702653935749817, 1.0649875906573407, -1.8046439908349297, -1.0001886936722255, -0.5795958355523532, 3.2417280597655727, 1.3279017707135528, -0.21414138372321476, -0.8091096606310838, -0.04622637942732615, -0.9520172278785463},
    {-1.7742946034279745, -0.9874133510959567, 1.853901370533916, -5.799082107458497, -1.0086100746936033, -5.575742503366463, -0.9469586166338039, -1.2648800007669945, -3.4131025811914837, -5.40183574174093, -3.6062264017753503, -2.081719275239895, -5.3377058883798885, -4.254789008172678, 1.0547439460478303, -6.059480686461593, -5.908472064799311, -0.2691789961760808, 0.504590697189465, -3.01300441943071, -4.836574311584449, -6.003073951375086, -4.330023521989743, -4.867367201428899, -0.7190826710749778, -2.9069416588416344, -3.869583190982572, -6.314953272057517, -6.94015164447011, -5.513112666025761, -4.086557481953495, 0.9156376823012593},
    {-2.2082592913348074, -1.3163287912429729, 2.0191027049227332, -4.423059375780994, -1.828305433081956, -2.5517190765990363, -0.9592662146260078, -3.6573510905045192, -3.582706049430164, -4.79085061588975, -4.079402531589925, -3.4031847071171843, -3.7449340755467393, -2.832781420632506, 1.2281913581163295, -2.2543362971528267, -4.157092576454103, 1.0957230761627657, 1.120932683299011, -2.4139653827797756, -4.54399087282407, -5.9845550542799435, -4.980202926742786, -3.333784141466671, 0.006900015834903003, -3.36925756066884, -2.324466686320057, -3.787953054784441, -5.577522255932594, -3.1295534733559767, -5.276979306449806, -0.9815745181919949},
    {-0.18528745354886414, 0.04680164943482059, 1.2770828653356738, -3.4216500379998593, 0.8408743645593488, -2.076645048538772, -1.1790379394424093, -1.3448517226507501, -1.2055249195998026, -4.022467476495429, -1.4352800313605778, -2.060750927471645, -1.2342711637105874, -3.006309962861274, 1.5372898865932016, -1.3034606703455727, -1.1593637033476174, 0.5367346513061605, 0.8949499658501823, -1.1021032321307966, -2.0717707772901077, -3.6424584823728434, -2.1599398632332587, -1.5898858905446882, 1.0360115735913353, -2.126117248612752, -1.218000900627252, -2.911195624652568, -1.335565876174492, -3.0476987330220795, -3.3085660419900873, -2.586888833521013},
    {-0.2551775193478971, 1.398259448835191, 2.557684069901876, -4.082794722589223, -0.058347156111841096, -2.793447295323401, -1.193272753553877, 1.4609411072610554, -1.40899961646532, -3.6391439852524945, -0.7760948302043525, -3.2526905984565357, -2.096481955121123, -1.2823221233293534, 0.7724441930436835, -1.8105404674579342, -4.165909099323496, 1.426760617437877, -0.20816422739300103, -2.345316650857396, -2.7667680069320015, -1.5543778176562746, -1.7824662079503544, -3.21447339037552, -0.7165836876758059, -3.0155424746301414, -0.3916259209610431, -0.9771565534214487, -1.0195281526719178, -3.4481966133916, -3.1594633686093934, 1.50179328977622},
    {0.30696937379468303, -0.3626289209476417, 2.2335579200996425, -0.9130277708541226, 1.2836496184271735, -1.7478807134314969, 0.6589780797261872, -1.2087194754295953, 0.771016532494053, -2.1800055751716942, -3.136600059551752, -2.0253990041498646, -2.214908380735607, -1.476158697734368, 1.4219513961490549, -3.0895929517717815, -2.9926091010791893, -0.14411762711172835, -0.2743470476142125, -2.2454880378460027, -2.4331363110254163, -3.143627643573753, -0.511513916971897, -0.34839407023316965, -0.8012685568245879, -3.0305579458638117, 0.01990281545170572, -3.2809068297112343, 0.017542710519000696, -2.6129738468940515, -1.679420999347052, 1.4166263547220146},
    {-1.237088676627224, 1.2983609546146058, 2.4563666275902816, -2.790327878479095, 0.08770662903027199, -0.995182728870212, -0.6895600771008839, -0.3636155089286888, 0.7789323155728007, -1.8205251428463287, -3.5420845020217255, -1.2866173827064815, -0.6489897412123553, 0.18254225941948915, 0.7847165334112922, 0.17804539820906573, 0.31983745181494694, 0.486477972748056, 1.9577764132219728, -0.396815034526152, -2.4032105465535496, -1.5000067820124658, -2.5991654783119262, 1.2809516700526469, -0.513229402392602, 0.19945979199365718, -0.21675823380489245, -3.25329983759093, -0.09068844486293606, -2.7911449890394393, -2.3105467000793545, 1.3627569834223552},
    {-1.066697892879288, 0.8975907092429058, 2.0828534596540296, -1.79952549564996, 0.4061746673756602, 0.49226650011138834, -0.7571069413960978, 0.29614848988588083, -1.637066234189999, -2.0622800194173556, 0.2191145922476186, -2.9864234125779405, -2.5824806958789472, -1.1724013590449867, 0.6553747399138312, -2.3129999331922524, 0.41349956572756186, -1.0461442959991356, 1.2218948830672602, -0.6480144825039998, -2.303370033339656, -3.823421800019678, -0.5638394145116311, -2.056262127768737, 0.48095081000947304, -0.6586498709505144, -2.2684147622196686, -2.5258078446916197, 1.684578987768846, -0.7914906229578378, -3.014925653108101, 0.9086186358993569},
    {-0.34327512726614184, -1.486864170648216, -0.39936755890657816, -1.7839130275929918, -0.31773119748646694, 0.6602030949146778, -2.6117639660464156, 0.7052140580167797, -2.910182232777732, -1.892628513125504, -2.3628469722541703, -2.0956686046562654, -1.2322096029493173, -0.43469735528061737, 0.45597428734622614, -1.997248495715887, -0.36139767683521323, -0.258976313383237, 0.46097308914607477, -2.3007086120734503, -2.1533123351955976, -2.3996649456984382, -0.22510434920183817, 1.0085914040488297, -1.1553677416377182, -0.6164152491818777, 0.041019038597721616, -1.1956012713983968, 1.475614941378344, -1.667684376502868, -0.5356937541237826, 0.22246665473382646},
    {0.8548264725428693, -1.022082910028601, -0.2759407243711068, -1.2902966028303542, -0.36212915661113493, 0.49486934474035427, -0.413870320546763, 1.1128275384867543, 0.5091536534624154, -0.3701434656339203, -3.074268539923513, 0.0895531891527802, -1.0677617212383526, 0.19286628269608486, 0.6015291899087774, -0.7618574842996212, -3.1515070864353008, -0.6048266293457703, 0.42716130974842387, -1.434190863863351, -2.345884269964544, -3.8138408809492192, -1.3081098649316831, 0.3204233071356147, -0.21139238683786288, 0.2444210998718307, -0.9800844631538422, 0.6166616793905222, -1.7907700190610856, -2.556945526471235, -0.9581708052811375, -0.7956129782803588},
    {-2.3770937904752243, 0.11150941732137945, -0.1478456988088133, -0.6585418726296186, 1.2952355691034616, 1.365484949119386, -0.21567383678406174, 1.0157196654863911, 1.6770575402385894, -1.784492476524118, 0.7238272997448565, -0.6106593993858207, 0.32081186931840333, 0.16394441479421024, -0.7069149451066155, 0.6009724467806149, 0.30312149572910907, 1.50136695459214, 1.2215754060280477, -0.7686727660239222, -0.6003524644446478, 0.6454125775445297, -1.7294428317432677, -2.3833182541674813, 0.4793599779016641, -0.766030330540189, 0.9488846971925026, -0.9649946861374993, -0.6671964019685324, 0.13637624456757394, -0.15780708347786518, -1.4487509079619891},
    {-2.910510986641852, 1.795049297435772, 0.23941910953152223, 0.28759914405873943, 0.6516785015716346, -1.174398107748639, -2.870045071802084, -0.5900125012593583, -1.5388689724014821, 1.9344468758267224, 0.4830236906990121, -0.757530441095279, -2.0251758710682246, -0.663246303151801, -0.32447516545137683, -0.8994730298814351, 0.2343711264190435, 0.3321225236836207, -1.5961022291829934, -2.2005079575826687, -0.3776074706949255, -1.7603879460174674, -0.5887452314849442, 2.1086968199995875, -0.5658605665309046, 0.19825412553694133, 1.841462801715006, -1.6618470888588395, -0.9008874419395988, -0.620009226736464, 0.38897643172454127, 0.3663072859452715},
    {0.7036504751731776, -1.6954416929066227, -0.29564946558366123, -1.820953105256847, -1.5372623180473084, 0.9882846853822693, -2.288831362155263, -0.8670794618624786, 0.6775583448531649, 0.9407913207564893, 0.8943581722237867, -0.3688681541650907, -0.5095620046309365, -0.5255385992191627, -0.5954856222248626, -2.264223437658692, 0.48653241376838313, -0.3913318021424219, 1.5747952246039405, -0.2141948815290018, -1.4175671265991352, 1.3733342776711464, 0.21306075110295633, 0.6802943709143082, -0.546836260482592, -0.6764708761285162, -1.273454696012336, -2.171865438253887, -0.8403484655270715, -0.06559788262240317, -1.3949458277404716, 1.5371717541482774},
    {0.4978829648511386, -1.457826225694033, 1.3397986541007585, 1.2543875416619292, -0.8891860938572514, 0.6419124942943464, -1.2018887169152914, 1.0533522865304774, -0.6108477671179788, 0.8462878944246882, -2.6017761236538024, 1.5716103974134292, -0.2701994110536667, -1.2213089916625697, 1.81603371229571, 1.3030844920094835, 1.4855027764552156, 1.0681064826709967, 0.39730392529060726, -1.7380059981014788, 0.38423676997498835, 0.7836631326608896, -0.2701107336181269, -1.5492345065787638, 0.216270169953127, 0.39275888916579443, 0.09942126258271447, 1.4605339370408026, -1.0259899324233888, -0.2618893211764391, 0.4885363605078905, -0.45470437455946255},
    {-1.383459080664158, 1.548701651024415, -0.19290655457416478, -2.4847246714593805, 2.9825702877542746, -2.200722836462007, -1.7113095306025128, 0.5473254539940865, -0.41747160196719785, -1.1724369601988285, 1.3790784698783367, -0.012111089696449001, 0.15344765447459752, -0.777547152477451, -1.5226299075925154, -2.5017862461671423, -1.317037755404264, 1.8152882529364047, 0.25002735943716015, -0.32821601948005247, -0.9972944040439112, -0.4023017410559935, 1.55278564395236, 0.5062884534181811, -1.6792773662457212, -0.371147674844623, 0.6322971551760236, -1.1780312805506759, 0.6193332726870536, -0.023931256185422793, -1.783890633962445, -2.4251403199186456},
    {-0.5623057830874844, 0.32437549440059077, 0.420303675663392, -1.5754654448925098, 2.579151127045502, 0.7027314339180211, 0.997783040376103, -0.6464364444588614, -0.14242899214700705, -0.2979588212717543, 1.875264320169232, 0.5381443288002572, -1.1992060917434675, -0.3259760481227943, 2.0533792383896228, 0.8343125498721705, 0.2691045816598104, 0.42802606367902557, 2.5216345252151475, 1.4507240186607087, 2.106090683271154, 0.682600203417597, -1.2765405844865307, -0.36575749096352583, 2.9442975975523367, -0.7041183070493812, -0.22174828161703122, 2.1441504761242354, 0.31162108601314126, -0.6413511585497137, 1.0735505489685055, 0.7730187926849079},
    {0.41646987167692034, -1.6831961898701482, 0.911223095494201, -1.6289024887441017, 0.7602971830058591, -0.9324280036571402, -0.9356586937111417, 0.15673422029848216, -0.20180760957934027, 0.24532717446765484, -0.04956729955172651, -1.3628685631570754, 0.6045117213820895, 1.218812412521783, 0.3039170327238825, 0.28400508357589177, -1.0914103557055181, -0.7581334394111771, 0.20282800602146817, 1.7930256368921467, -1.4211534040536276, -1.9399837263345585, -0.5395792137452993, 0.21109667310379504, 1.5765486098433863, 1.213832593504249, 0.8613712224050147, -2.0920757265643704, -1.06235472881376, 0.8094872413879168, -0.8271225998126218, -1.098673515273362},
    {-0.37688506736991423, 0.1926899360829347, -1.305773177376792, -1.4376823088793247, 1.6729743317476735, 1.1509751501667866, 1.1069093078267511, 0.5372881476300982, 1.0482800542930497, 0.04276434430227561, 2.176722102191819, -0.6015975103810338, -0.7237678954305656, -0.46488346428345684, 1.3764215152098265, 1.8238446896542335, -1.8701237970423492, -1.9875537852210263, 0.9332943047725198, 1.0455605748064412, 0.16542924029439157, -0.8900184233226827, -2.0113152928082827, 0.018281812285553773, 0.4586904838618158, 1.2683908017033247, -0.6393438228585447, 0.6519107315338561, -0.11898392215024299, -1.0076256155431662, -0.6496378881229754, -2.2459392535475233},
    {0.11972695383672353, 1.6953890503135498, 0.44985958977067186, -1.845520659394588, -0.5051260515951749, -1.059797426937554, 1.8276796658912677, 0.5184378077876667, 0.11084668142586315, -1.3243494422234585, -0.8960866131634928, -0.4754366036799504, 0.20988321663990864, 0.6086696150038055, -1.8324222019758731, 1.993883111005622, -0.08481088919681587, -1.6027518208734328, -0.6822476942368634, -0.6060806438877938, -0.39293530787476943, -0.10415965796366418, -2.162944772092064, 1.883802406941474, 0.35482712629285235, 1.6754162463454756, -1.6258430793017127, -0.9751895924752674, 0.26996375906007086, -1.3607045635212935, -1.514263708514743, 1.2324476258360573},
    {-0.5595609239380789, 2.8028337329635815, -0.06111818775705398, -0.3950563655106082, 2.932934998929801, 0.2326820668812515, 1.8840424051939666, 1.0395061980130664, 2.240740750540391, 1.683596555055457, 1.7244112180443303, -0.6282586333307737, -1.686058009141142, 0.37688512478574465, 1.2560875222038235, 0.4809254280521084, 0.3206220866102051, 1.7223821898766363, -0.8519821194151133, 2.3283563543063184, 0.1328731469089856, 1.6520792264019917, 1.3078495724598622, -1.030857466714667, 1.5051951145541849, 0.47158257281999283, -0.3603911005084325, -0.1879903911892898, 1.9521559600207756, -0.030607009043342456, -1.9637517631968344, -1.9898254936863142},
    {-1.0249992327656194, 0.4027803912393983, -1.110670164562805, -0.38012828354775885, 1.6446470354077416, 2.340854432293308, -0.26002602814091397, 2.3617947243821207, 0.9151398934513507, -0.46210819294273914, -0.8304950511583314, -2.994299860649591, -0.9110880048524873, 0.9742176257086819, -1.809358663892308, 2.2029480183702908, -1.7422039469810067, -1.8308220838376805, 0.15396206047653396, 0.043362465678802746, -2.2486872874960016, -0.38576236703050343, -1.7724914879054838, -0.5520917271862553, 1.9382339152052193, -0.3059489827039669, -2.533742601326107, 0.7805397492488001, 1.3279010867114183, 0.5526847447000992, -2.3310527599092374, -0.1380881506214801},
    {0.27152428868879286, -0.15016628371844873, -1.5708201403282602, -0.21045572509668037, 2.0152310295065234, 0.6911316088361313, 1.280401849874422, 1.970156064263003, 1.8536121627353521, -0.23522017733880735, 0.22250032637818276, -0.1994705390651924, -1.2313911232517687, -0.1548678653606314, 0.6394010507775777, 0.06361560517245266, 1.698641245488199, -0.8971652618146688, -0.14793114641221042, 0.349856083000378, 1.4847001106928106, 0.07348674605017812, -1.2631163694902747, -0.7266461934089472, -0.9521895507333291, 1.33092881157714, 1.3145304994374527, 0.1621003844054394, 1.7947148743233365, 0.6103572076816756, -0.43887299805177704, -1.24810068638841},
    {-0.9797758463420105, 0.6403237838398714, 0.24335622631772214, -0.7128693070330476, 1.0027749914010582, 2.579413426412342, 0.28005650658647213, 1.5065026159775725, 2.1749453084649333, -1.5915479708680451, 1.5765423236341816, -0.29499197971002283, -1.1877052909151897, -1.4943025556253096, -0.20101545209084484, 2.42589338388409, 1.9457138269376462, -0.2458984400604454, 1.3938807536184574, -0.31947840916562764, 1.7447364177517999, 0.2989160564014428, -0.5447488427486258, 1.3790473873345457, 0.7739075681745593, -0.2885059107679012, -1.2954114008365816, 1.5003688044892804, 0.3367449148591141, -1.0441937489477136, 0.91466882794199, -1.9510840003581345},
    {1.5350566375976085, 1.4503251074673962, -1.2021061993298374, -0.006228381576302339, 0.6362541645780941, -0.9136757425078689, -0.20912794136328322, 0.6993719769183326, -0.9801160183894122, -1.414732577187594, 1.2920304570928431, -0.8956618991153187, -0.9843534028818746, 0.4284650006106975, -1.0459511199107547, 0.5061547144289996, -0.5038097412769109, -1.0645848290469504, 1.2017560577648911, 1.7707361711016627, 0.6992688843289185, 0.6680960935274685, -0.8947512662993589, 0.33814155403457596, -0.21448849427055527, -1.5812839387813724, -0.6047614763030853, -1.242107530398448, -0.46413994960556737, 1.0830625892692771, -0.9436567468076025, -1.5796722681387814},
    {1.1410131492785625, -0.9025234147500519, -1.199763925060709, 0.5045094625133798, -0.6985320117568522, -0.5498127823582806, 0.018303333831291433, 0.12036093043364265, -0.19078919758495785, -0.6693553701850038, 0.015021770583607222, -0.1666331424270961, -0.35244845657944357, 1.4939470836568705, 0.7917642181071441, -0.6638605938967846, 1.77543521049722, -0.3277369966940698, 1.298856530237106, -0.5427010031597468, -0.03336300555066907, -0.8072724000418734, -0.9825923792132926, 1.3395800861937925, -0.0850924081668392, -1.3457266026975825, 0.5645201842646635, -0.02228878615731917, -2.11506246894523, 1.1498503521081516, 0.9812067473503283, -1.4384839041597353},
    {0.2975405924623658, 1.8804916635838536, -0.9842448313338844, 0.5788859023064581, -2.2313973634515434, 0.02729691559730652, 0.754667255135794, -0.854793626680034, 0.0911382839036925, 1.4051975345105967, 0.6317786357599209, -1.2189158734355698, 1.7880078697601351, 0.2569750889353169, 0.6151205899228763, -0.42254946159002227, -1.185538889040369, 0.9155732073512833, 0.5791543516473389, -1.486578945283258, 0.6358538639430459, -1.5419179038638435, -2.31248445002655, -0.37032320564604343, -1.6758046148921018, 1.1011177872642857, -0.2667918878130373, -1.2483607453623686, -1.1986399907670218, 1.9620435045856721, 0.27350039624587275, -2.401970206113002},
    {2.3799704149471266, 0.9795825887075501, 0.26908469381459094, 0.43111445861961134, -0.07784603332376383, -0.8853723209851013, -0.9744344091401825, 2.446263995425998, -1.937462129692819, -0.600349750408142, 0.916257133009196, -0.7239210857176533, 0.2999244695356335, 1.8280176211734394, -1.1627069814525557, -1.9890719023885104, -1.5466258640498438, 1.1809124176824277, 1.280650999239597, 1.1050434690190485, -2.017651626308083, -0.10043277873371281, -2.1813664825064887, -0.738905034765439, -0.8796407399562627, 0.2727532091716992, 1.21728217975612, -0.5197938708110678, -1.9089576531816452, 0.07467637196044233, 0.818402804949578, 0.3601656674460045},
    {-0.7307160764570053, 1.282211416578284, -0.8472060387313939, -0.3752739389014957, 0.99594402650973, -2.613773801628784, 1.6730592120525356, -1.635151108890405, -0.22072602088132548, -1.7712766091647283, 0.8260860369053938, 0.08351432221754404, -1.2165270417881633, -1.5313818080117387, 2.1447834963087145, -1.10100181875617, -0.25046492481355886, -1.3935962859261386, -0.354166622985685, -1.3512300133064898, 0.17937284862728553, -0.8373439043871063, -0.35073070877021995, 0.7452058797609735, 0.5597177721786201, -1.4932635186447096, 0.16646812200205224, -0.4433215588284995, 0.1618539150139091, -0.12488579329864387, -1.0476961200222668, 0.8732385516054486},
    {-2.1785478526274873, -1.20934142065444, 2.2347924801533736, -1.5525547023900408, 0.502735685151226, -2.1022551299057586, -1.502986202049971, 0.599543259238385, -1.1012840369049715, -0.5454254019427002, 0.14803921800068548, 0.8946291308854217, 0.19993525206121493, 0.05839484462310307, -1.2309125903275715, -2.2985098726973394, -2.7662710813226075, 1.7636548364954996, -0.9961974656170144, 1.3392893030521862, -1.1506711802170242, 0.4022446187629037, -1.1595698593395805, -2.3043859148015455, 1.122995468652146, 1.477759865934013, 1.8909538275964368, -1.364267467157271, -1.2344247768126884, -0.318533107678961, 0.615084683788072, 1.8832253003099406},
    {-0.05062555859430872, 0.43057356213826437, 1.0345184155793263, -1.555492815150377, 1.5244986904474138, 0.749527907665533, 2.8307203034705637, 0.45578498559734154, -1.1325281460801802, -2.1513018598847706, 1.382223841953623, 1.8534007202988194, 1.4156537311507158, 0.5960015210472849, 1.5150400270654787, 1.184861495181749, 0.19466368333884673, -0.19434989583921913, 2.1348386942567084, 1.3218296466438637, -1.2887409101468867, -0.46308092346046215, -2.3752850902997493, 2.6157976865108723, 0.2541453003431894, 0.8199425550951549, 1.784904363512979, -2.0702173583865995, -2.219102211287335, -1.3963358694158694, 0.6414496434404794, 1.4570748093724681},
    {-0.39802538376677216, 1.2131942274931797, 2.056414755967043, -1.5026240728477103, -2.2456063653381317, 1.055905441032022, 1.3520247064246456, 0.9747094160826982, -1.455486609545018, 0.9332739686003085, -1.7875932249192186, 0.5335817275221143, -0.8815718864151153, -0.26484181047838234, -0.21519624448369154, 0.9994613477945964, 1.7185516971684778, 0.8251115921001996, 1.9411511334572935, 0.5837984556974476, -0.9952727593839648, -2.4785442309988226, 0.792290022833023, 1.6168815428434657, 2.6830112079923283, -0.2596305485548651, -1.6492279779395984, 0.4812111727902618, -0.2020197664140506, 1.3275495029374496, 1.0547570638936459, 1.4102484243852473},
    {2.188614704253345, -1.1618120905559006, -1.0386218450948017, 1.2268727758020024, -1.0568008360780712, 0.8491630409494628, 0.5306894967050962, -1.9496019734079821, -0.009486334712055927, 1.431305593964757, -0.8070950619782751, -1.1693349282164647, -0.16226918423136855, 1.6011693344591527, 0.46216566877401294, 0.5330132995110777, 0.6275620723340115, -1.1262042375947725, -0.6011636322573022, 0.19322141282946823, -0.3663659892286346, -0.5717827661977168, 1.4947520575941204, 1.2216810348230376, 0.32921281385021967, -0.8244223244130057, -1.768130706377896, 0.681870103380835, 0.8228733688792323, -0.9564776939237174, -0.021849503402379886, -1.0855507806593692},
    {0.41423311209248304, 0.5110884891680806, -1.6731927647603122, 1.2348009811286411, -0.06588146384122374, 1.3365177333330813, -0.18164487972385818, -1.4129421544385312, 0.4970014767100751, 1.2962276102653354, -1.4305947197607134, -0.8403515570905186, -1.573006627041356, 2.457770545886411, -0.5711900108880738, 1.1103852788179183, -0.6945153508594296, -1.1518536933609629, -0.5072988058036473, -0.11319172694800926, 0.4131076549506688, 1.607037565744353, 0.810055061710551, 1.9717682316022662, -1.778668656333963, -0.10225116606626039, 1.449280615448601, -0.47887405396871024, 1.179356677981058, -1.0951476497661818, 0.2924749390875976, -1.0750440974888402},
    {-0.4108210205877026, -0.05437673139913088, -1.253559461715982, -0.3758707931080704, 0.733801414947433, 0.9428691348573228, 0.15756568694741174, 0.8970618916048224, 1.308037616216438, 0.22529854238218122, 1.7675752386245591, 0.9619479592610116, -1.4638524285385748, 0.47300265576364153, -1.007885907606777, -0.4071376266774226, -0.24750968123386083, -1.6177577835666654, -1.4993350811067505, -1.2428638059331925, 1.4891474517998111, 1.120637127102035, -0.5256604801201786, 0.4226172402662718, -2.030836860302981, 0.8687629634484315, 0.15215826020071566, 0.4595509189618823, 1.0726491648234415, 1.1023490856839917, 0.5550127701405559, 1.4619269719858514},
    {-1.3284072873044654, -0.5494632876940401, 1.4056220323693527, 0.508474165415012, 0.10280323807121981, -1.130462973427791, -2.035021336107361, 0.11585377031580198, 1.1278770354445993, -0.5297228540336704, -1.3644075739551116, -1.4737432182955903, -1.5698576122644605, 0.13322722958609634, -0.18328969292574898, 0.5528120621690664, 0.6784646597976709, -2.0565838870054463, -1.3216843853949187, 0.9078485177422807, -1.9230665447307909, -1.473701214624327, -2.1458076259681653, 0.7151982866023675, 1.2059195993996774, -0.00966424621318846, -1.1538639425445518, 1.6526902217438562, -0.12375424405229185, -1.5491893234697418, -0.8530210845424027, 1.572167342099822},
    {-0.3991548197388048, -0.8394595528658908, -0.9368970536753322, -0.7796935042233539, -0.8481454241667873, -1.2842008713615218, -0.6675751317285106, 0.29684820055469274, 0.8862634367699141, 0.29470484519919493, 0.9533570908442501, -0.8482461053638883, 0.5602986508492149, -2.5268920462584, -2.2289741111261856, 1.494098376051733, -1.6268849408724406, -1.7587317994114042, 1.0603350810562957, -1.645751823724465, -0.2455561390651057, -1.3502025424243929, 0.47438500212236706, -0.4531469984051589, 0.2390390530857101, -0.07692063442873291, -2.32978021769544, 0.9163869646560734, -0.26709585137914565, -0.8840623537746494, -1.7764423980567607, -0.6876500873230615},
    {-0.4026312557007995, 1.7270264980458492, -0.692079708423027, 0.64333996718641, 1.2381960897899948, 1.2887709110549947, -0.2633627314900179, -0.027201197180123548, -0.8348470276155512, 0.8143300784287963, 0.4432956762519879, -0.370340095785949, 1.6704388414113853, -0.8106452670834867, -0.579332258266731, 0.6919398882623069, 1.0810067999922006, 1.185043709153164, 1.7969957766505895, -0.0708747647310636, 1.0315202032111923, 0.9504543005946753, -1.070980357563259, -1.896174228154013, 0.7282697361713373, 1.2174101067426413, 0.45367104571369804, 0.27898959340905843, -0.9947064814525372, 1.325118598400012, -0.0775278800007727, 2.031438225754343},
    {1.4110235553803094, 1.3852515943437729, 1.9928413609921127, 0.5428853828714946, -1.176446264297613, -0.8303530929035073, 1.816164367143315, 0.2506521763122353, -1.2724245852824003, -0.5447082643770242, 0.00971615312123086, 1.2614213946283594, -0.5509320596236302, -0.7589083410486759, 0.60371024851881, -0.1203573513437395, -1.0264678021098381, 2.0467428316370992, -1.0076257813384022, 1.4981769257091853, 0.1714294437316761, -0.2857278936920127, -1.302830286845302, -1.4459546577547766, 1.7291066688095411, -0.049228391514617865, 1.2013873982739876, 0.6568253230975272, -0.4265340077292173, 0.1492376040403497, 0.4839664995391037, 1.2376145252329256},
    {-1.4341442265777007, 0.01557499189628185, 1.3902716849150596, -1.06074620243754, 0.05905840364747775, -1.0018487052232672, 1.679926580138927, -0.3624754049627071, 0.5791130609251814, 0.635132280500393, 0.059998734307682614, 0.76533103182854, 0.0891406209308264, -2.393523972202968, -0.40596107766628975, -2.1418537098778274, -0.8251922094135743, 0.42488456242948214, -2.01802938215163, 0.29376509870969164, -1.9150054489094979, 0.006034619683260823, -0.05382792317581541, -0.6757885471789958, 0.6994089936379636, -1.5365717179707252, 0.9891885494997646, -0.6146282429301205, -2.7478411844024566, -0.5050223687698853, -1.3158579149904495, 0.49241302979669976},
    {-0.26450500598656507, -1.3933590799747635, 1.496772935094899, -2.0959372093542776, -0.7082639355628468, -0.356920294598958, 1.7621024233088285, 0.4795154256916239, 1.6795329458884656, -1.2166499895499099, 1.0726345635132917, -0.2843984966186848, 0.741947877360968, -2.1498898135022713, 2.070988620618232, -1.8353786909170695, -0.04743391389658259, 1.9813731677937994, 1.1208535786764424, -0.7612945593042229, -1.733844106065997, -0.26109570969550894, -1.5793925793916548, -0.3854012531646933, -1.5967408504082048, -0.2613683070250985, 0.3291504074217522, 0.7613696433538645, -2.512288749431188, -1.0679918372856951, 0.9049924307726408, -0.2526762469545509},
    {-0.2469786337417493, 1.5059497679603218, -1.6514415192497596, -0.7919066079516025, 2.325192207541516, -0.44081122614904056, -0.0357553351099305, 2.77208322645458, 0.006862119132288812, -2.512285754349577, 0.9007624319098964, -1.0074421602443584, -1.0282405066579594, -1.5596547491516655, 0.35776798875923943, -0.903544846024188, 0.03817565592085822, 1.831205106530649, 0.988259937632819, 1.0648305488373755, 0.6248945228623767, 1.509176265055727, 0.7343941107716867, -1.4539007037039107, -0.6429769964972711, 0.3394893074050299, 0.9343558984936632, 1.8642713751504922, -0.5977329349215379, -0.1437853403567027, 1.0050440346019665, 1.2419364082752224},
    {-2.188311507980803, 0.23043725687462036, 0.4602201325954079, 0.9609586324868727, 1.0157892259112768, 1.0006336966029883, -1.9408523081668754, 0.44912821580881923, -0.5197604790300853, -1.8641124960908755, 0.704069074781594, 1.2761387882554147, 1.2673685655738964, 2.136234023197214, -1.9835352323353803, -0.1406816366525262, -0.27939659266502204, -1.1573092822327697, 0.8535944122979761, -1.6109010718632761, 1.5864556027576926, 0.5554967452774306, 1.5429291277678339, -1.6265821221602528, 1.0205421883985872, 1.1371415866460781, 1.6809869281447352, 0.6243856285419034, 1.6157017134901153, 1.3931107674884464, -0.9746322590221671, -1.0396572402181112},
    {-0.36599639252009286, 0.7842289633863209, 0.9555813926433059, 0.6063922980021926, -1.4498031556640307, -0.6693408879738714, 1.0778901685254623, -1.087168087458446, -0.3291111936540749, 0.2551440043147189, 0.6877454268488844, 0.3607508042147629, 1.7660853232056737, 1.8010305484607005, -1.4209168060689639, -0.17879810959832826, -0.5191787022676156, -1.5313429217903698, -0.22886620945873745, -0.0861473305940207, 0.15291474590196738, -0.2664806231578246, -0.9192634537116168, -0.6584460085364819, -0.6975751178558574, 0.6752216674618107, -1.1649272132512714, -0.9731816302315748, 0.8393660619393976, 0.6681890889979495, 1.5836237630973178, 0.49740469486332745},
    {-0.5557372178320675, 1.0901489391021366, 0.9545371915190375, -0.014463703044819032, 0.9711898224940112, 0.5332006811676739, -1.0884664268711295, -0.761770030343551, 0.6098170000377654, 0.9042165783727971, -1.200894091138807, 0.017133797039197093, 0.5051031471259778, 0.9652773684242069, -0.12627815068994108, 1.065950795550142, -1.084421624275122, -2.32139747411364, -0.41123325247515224, 0.48483752117782825, 0.571939573093599, -1.0397039686067004, -1.8048147311692122, -1.097513844282533, -1.631626335314966, -1.9719444523335516, -1.7053312292775906, -0.32773144324574993, 0.6907134467418123, -1.949690330955613, -0.998299020001328, 0.9219702602197584},
    {-0.034772057584886065, 1.2834331078362837, 2.1132827286560625, -1.8586529091928992, 1.7783430240887206, -1.285395792474459, -0.5311671174521768, 1.3275873711899555, -0.1029076540848856, -1.363878454600375, -1.5583268241626573, 0.7565942161065111, -1.1755520551458047, -1.7585019697237523, -0.24574772093316283, -0.31420158842722506, -0.622922678859806, 1.8105476045316073, 1.1868454044709544, 0.1772957259596395, 1.0083645688424367, 0.13269415828875772, 0.7897461485253255, 0.33707350442504236, -1.3968344399831951, -1.3598657900281204, -1.841950425398774, 0.037124207878196765, 0.8064572618810562, -0.8505716980493455, 0.9782264174629395, 1.076252038392089},
    {-1.298861823911866, -0.3918946546772752, 1.0236780588048, -1.2070607393653072, -1.2950889878492944, 1.877868307179369, 2.098691015982117, 1.18973242206508, 0.9585493744851574, 2.617825968549779, -1.3383846052337818, 1.2369901517550572, -1.9197970687216845, -0.6411780398537065, 0.6442906438125519, 0.47027949879324743, 1.4040363696477145, -1.573414261236639, -1.4897712299498143, 0.2625419603510545, -1.2056689660127904, -1.1123040778225421, 1.0531426379831303, 1.4725244476395707, 0.8391136261574059, -0.6414790370010318, -1.2895094069158777, -0.7022348976844797, 1.5386999493659637, 0.35032730541911233, -0.47812610094333263, 0.029142128132591667},
    {2.012710353662476, 0.4371478034398189, -1.9950244468904494, -0.4530674211806635, -0.2960790648896389, -0.09531004514712177, -0.9582804744485136, -0.26766060974200157, -0.02014948575236202, 1.6507310055296398, -0.6496268933917958, -0.5317492704264121, -0.8283545892580351, 0.41004412330958573, -1.0603980028044908, -0.3993957443026538, 1.9624871871477751, -0.7249301365836527, 0.23644338975346632, 0.43717250830489685, 1.70253989688788, 1.8927449630941173, -1.2066866250392, 1.5974036563450564, -0.4415570589106599, 0.7850905261252039, -0.4252614809209388, -1.011611615872707, -0.5841801400434892, 0.9113187597194875, 0.5931655819746376, -0.4268926535087973},
    {0.9843119117551917, -0.5112222195808379, -0.35408616052399505, 1.218628982006381, -1.5960947898078548, 0.6219551043273869, -0.2944707303819118, -1.1144803288307288, 1.830412564564429, -0.0012280120808953474, -0.01845629046645686, 0.4470736979247852, 1.4623847436842445, -0.9151666200177804, 0.5116068741657787, -0.5777050471488125, 1.3691574408948197, -1.1705760576982431, 1.628549112769077, -0.7693870216295153, -0.9693928133960092, -1.4707903591748663, -1.5584669501364736, -0.9205066462740015, 0.6696889832237746, -1.4767368669564784, 0.6080375986486336, 1.266548560062981, 1.4664334130314116, 1.0894249052153717, 1.5596187604553469, 2.1377067215439465},
    {-0.5356099768999529, -0.8581673723535019, 1.0593615010688393, -0.2975679835304734, -1.0434002365987045, 0.20656476460796513, 1.284236052145671, 0.7586869501517765, -0.9670890472326986, -0.23229102488820602, -1.1558447689328482, 0.9113486142563, 1.5360489739945045, -1.5603723096329478, 0.18242981776770936, -1.0303333818318297, -2.0393314969117133, 1.463146145562922, -0.9193929821598672, -0.8779609119978348, 0.4086734672776175, 0.20945135815300783, -2.747098129103226, -0.9382737873774261, 1.0858721085435061, -0.10795408426461381, 1.0327916862512574, -1.1561286758475973, -0.6431025386184696, -1.1766547489978618, 0.8170524956163314, 1.05312051845467},
    {1.4525086228686241, 0.7032905320378502, -1.174048468165364, 1.7721146786730053, 1.2128723495621603, 0.6384192121391854, 0.8727434922246182, 0.1530151488345406, -1.292427111301646, -0.35787348290018783, -0.6195949195405865, -0.017735443879527177, 1.8486175296767673, -0.6399660837233336, -1.3487620345358315, 0.18544347643847928, -1.135217413897284, -0.30141785365737256, 1.3012401337690294, -0.4459090968154276, 2.2871666479708677, 0.3359220566400755, -0.9391532051615155, -0.5524840178805298, 1.9090312365005422, 0.11930270505545244, 0.5509142806011961, 0.045598675804457534, 1.0831974102487802, 2.138281646293939, 1.6428124944111377, 0.19844571116676996},
    {0.4818258249811054, 0.3439063618795079, 1.496463398710263, -0.4014095899513036, 1.2640664258877787, -0.2021370207089379, -1.5120797468121356, -0.13540555692014047, -1.8856360443649103, -0.10532858021893601, -0.2566720355170703, -1.8389136397736812, 0.20334539215469496, 0.9717607759589879, -0.5387479888922995, -0.02829630704785015, -0.4379233927912628, -1.9366344463909941, 1.1894900139837485, -0.9048564655094138, 0.542532327792122, 1.2744042800011783, 1.759974592282983, -1.8279656560191715, 1.5677554784972922, -1.868127059597178, 0.5072392274478131, 0.5653717225760291, 1.199924081534222, 0.3765176363130702, 1.226296034628471, 1.0576011931037856},
    {-0.008313058028442217, 0.7876027316616272, -0.8129482438708705, -1.0560624492888377, -1.0105462352899515, -1.235607062552262, -0.17002832590685873, 0.3443132726166475, -0.8268036496605082, -0.7219596308744913, -0.003526613379555686, 0.2950250333955146, 0.4195392137657941, -0.8777919689881116, -1.4131842040959175, 0.3833785562161458, 0.2523406747748114, -1.7741523370075525, -0.1518657327659542, -1.2058511201188113, -1.2026652124088872, 1.0080845724148941, 2.104316290857354, -1.3236857779269862, 0.7951524484543457, 0.13604252941700287, -1.6439701371305737, 0.026194488306016946, 1.7776807611886438, -0.07796957762415689, -1.1699509733318425, -0.5635821381214424},
    {0.6770465753199628, 0.41892970733200646, 0.019166072928939185, 0.7698308519712626, -0.2381109452530206, -2.094765819508454, -0.73391425858883, 0.40268924361399755, 1.6200814923968498, 1.724565344749828, 0.1307248680670949, 0.6820222601209093, 1.703024642904273, 0.4490617372579897, -2.089593182073695, -1.4227076981375832, 1.0482509930245687, -2.0198442361375304, -0.7339500770487045, -0.02655919638854789, 1.117639091023042, 1.3153351629871823, -1.3654887045372455, -1.7196459574817036, -1.5724716487921566, 1.2092639740728415, -0.9697704592438738, 1.0725901449798696, -0.21481461488331077, -0.9407388167690502, -0.7372751142819051, -0.7757977948019819},
    {-0.3821614774119525, -0.6253654404189739, 1.8692986329941064, -0.11426110484436361, 1.4090549252518063, -0.22803389640563818, -0.6145243576271736, -0.3631909377068809, -0.4240656610880804, -1.1267675347255617, -0.6491242337150467, 2.1085022184370157, -1.0905785544787043, 1.355271513023636, 0.6082821560619792, 0.9621032395262575, -0.8769755706070347, 1.910621985229826, -0.4225741111863262, 1.1957748190507043, 1.6523935701615544, -1.2491319432175512, 1.590635574505947, -0.20414106576015975, 1.2438313458479424, 1.54281634112624, 1.9250883379270485, -1.3870087939710187, -1.720734533293692, 0.38989545922449015, 1.9595198135705, 1.578913037901467},
    {0.8676090327581262, 1.1587298975811238, 1.2681484656145234, 1.4570120877574266, 1.7155913220849488, -0.6677902653914615, -0.9544037219867595, -0.501985342225882, 0.6791238693114947, 0.28330481938914276, -0.44639320432123447, -1.3218740872859798, -0.14527835029444386, -0.12226303125946733, 0.5157466862020647, 0.6902516308150037, 1.2745192660603855, 1.605012060811981, -1.4027524833342828, -1.1434223115751692, -1.364644429610413, -0.72490403053535, -0.5823595230965292, 1.4983527673330421, -0.2494870540577521, -1.706477124298056, 0.39600646357499003, -0.24601901322868092, 1.4913241093847318, 0.6843836720978559, 1.6839918811103582, -1.1143096802534749},
    {-0.36900285526833637, 0.08601024956071117, -0.0023982089703842107, -0.9474141414257041, 0.9211956690114139, 1.087457063906326, -0.6985202560922226, 1.7380237327905477, -0.5229188584997247, -1.035758313473519, -1.5222485807607458, -1.8765547459340652, -0.42504753097861764, 1.3411437008246891, -0.45634092714433794, -0.10498647568525038, -1.2722625333444237, -1.0449587140932075, -1.100294013745268, -0.7627637111612828, -1.11321525404876, -0.2331064150798046, -1.0428229424894424, -1.5266557521318855, 0.008269570889077925, 1.621163892637734, 1.3444579615690269, 1.8699562727492578, -0.49123456090499906, 0.29296201272018185, 0.34356540723410484, 1.2425481536155067},
    {-1.5978846086834104, 1.602239005867894, -1.1277038221175155, -1.5454331322996073, -0.7830006820163702, 1.0551615610541376, -1.3762154981824855, 0.5486709864956609, 0.35806926763593017, -1.3138116426374582, 1.121413419364103, -0.9388256395118465, 0.5073988128764503, -0.8866174137117401, 0.504727191955694, -1.4607938879638824, 0.8872621270781513, 1.6385199502478376, 1.6143985180520282, 0.30676229512974884, 0.29426079336164984, -0.07128080229904303, 0.11374290703199673, 0.9716062204332632, -1.7868965180954886, -0.7179936317024753, 1.0779035639291399, -2.457048565557904, 0.23878721564083774, 0.1388739184032672, -0.7819124880637792, 1.1248205151328987},
    {0.2822337873621098, 0.5692384111488, -0.5221735027595847, -0.46418081976549846, 0.13216101014355297, -2.2575991918437044, 0.005454361831879965, 0.5329259052043257, 0.7821846304863667, -1.132225035321813, -0.180076209734063, -0.04503458152833126, 0.6401598662648169, -1.5827553379793708, -1.3758355608486257, 0.21193306419970775, 0.7934593618585138, -1.0136393476108052, 0.8563182471434486, -0.9995559830210656, -0.7466312309488073, 0.21811526629378014, -2.164024387460535, -0.7714157779700904, -0.4663129428130289, -1.7635745470694209, -1.536854408139292, -1.867880494510029, 0.6221451278819541, 0.7423967106635001, -1.2641097619841453, 1.362174730465},
    {-1.0696621225583867, 0.4351034851503067, 1.2031413712539958, 0.507047784841729, -0.12091770537793958, -0.9625299290878154, -0.8593594792667447, -0.6365081991203291, -0.21149180447270421, -0.9026717409049126, -1.2679879769895732, 1.3771025857943116, -0.7372870344875175, -0.6458665030345564, -0.809157669705335, 0.6636275839320718, -0.5847404632934023, 1.4993430111258226, 0.8548747166296864, -0.08101860982446049, 1.4883468273582021, -0.2769129006168651, 0.4899853251198917, -1.0045724532461207, -0.9361190550932156, 0.7734180255746922, 1.9939344235488468, 0.8454692066327679, 1.8848234069256502, 0.20290661331308923, 0.24429534162741093, 1.1479061836730595},
    {-2.4984835132918004, 0.5491251584735429, -0.08242577736268848, -1.069823959375179, -1.5754548737974403, 0.1562456226983662, 0.1585157344691837, 0.7002026128949372, 1.805056782240038, 1.5891640095127118, 0.7902025629619961, -1.7019961440558573, 0.9935543702056326, -1.497345446820802, 1.428782759260442, -2.029399551353208, -2.0961155729466814, 1.5048086467046886, 0.9359184819032109, -0.9585006589917595, -1.2138191735526078, 1.1099535334873443, -1.3688457521014166, -1.6914468145008192, 0.22420627228502568, 0.49366221084072365, -1.400586149893077, -1.8519564439398646, -2.5432818231409997, 0.698069455472629, 0.11841333103871639, -2.056807853261091},
    {-1.8251772151320118, -1.1819657069202456, -0.5940014602691043, -1.485425325808111, -1.7091019149653497, 1.0488717873094877, -1.6460381644716127, 1.6561374544549488, -0.9419042409070285, 0.7510264628317221, 0.5174856943026706, 0.7557191374020659, 0.7078379066398195, -1.246591698862555, 0.11231032103213834, 0.4915988801610764, -1.1098971452045314, -1.3377035053994726, 1.6385273091086747, -1.2281644042386666, 0.4363606883821382, -1.8542110735503294, 0.7718528550937858, -0.5747249038461049, 0.29739009545029665, 1.4902503902716446, 1.500174026045145, -1.2051520259914363, -1.8888849612843752, 0.6397949065558501, -1.7904503020934892, 0.02849707762952782},
    {-2.9889610854637594, 0.5091499972087956, 2.1336119079033478, -3.856500330834653, -1.71216750177622, -2.807352860422049, -0.09354400841049511, -0.6798615564387264, -1.2802466713534137, -4.992255330043623, -3.5807814694123565, -1.9510226484605016, -1.9121362148238752, -2.010950923712091, 2.18064500332814, -3.8088341597820445, -2.4352833782340135, 2.211178716886889, 1.1963292047470917, -2.895241883618076, -4.750384087936021, -5.373315354092237, -4.742043751008184, -4.176617525617698, -0.9733182980450548, -1.736992031834362, -3.2293496846332443, -4.433651528188931, -6.051787117852879, -3.3482595631088525, -1.4750953939705216, 1.4855406000144251},
    {-1.4916861377028972, -1.1962056034248052, 1.5464352991504924, -2.932775610608181, -1.3075872484526694, -3.08417965599817, 0.4449714693301504, -2.9005278093540414, -2.3980239097976708, -2.733147283985302, -3.8826573633833443, -0.8900925151494699, -1.2757570481158758, -2.035840462405893, 2.4379611154664063, -1.485618555766188, -2.3826147847689976, 1.6893969300362874, 0.9430101259900829, -1.3433989167132487, -4.916111543481103, -5.684903564781929, -4.300685557794539, -3.8678625135011324, -0.8239521622053906, -3.8768764653403482, -1.477810395385355, -4.371430916881346, -6.127631093460624, -2.3859465182803743, -4.42472831799298, 0.02828514395152918},
    {-0.20930900685282255, -1.7861680006792657, 0.6695784826561029, -2.9447233956454806, 0.3609279341171814, -2.8402203655489338, -2.4254837823119417, -0.8755079051284054, -1.728820216135303, -3.5171753561676335, -2.48537227279533, -1.155097650546839, -1.9220959742452244, -3.6986287995549842, 1.279188489505613, 0.031821352943254284, -1.4614561968223738, 1.1587045449829678, 0.02185786716166948, -1.7044324320118158, -2.7178802623834786, -4.281944453514013, -2.648622792432015, -0.46290320240206145, 0.7673594343469821, -2.188456007796092, -2.1209023236769906, -1.7515295328077445, -1.9462685368615606, -2.740254473139465, -3.230582275721494, -2.139657263688434},
    {-1.1141642519966186, 0.24964211601431888, 2.339588431726613, -1.9506656253253818, 1.2386406893862032, -3.4285933412379013, -2.2629609469620986, 1.163539565650313, 0.9059318932511568, -3.1525169913880564, -0.24324602203702653, -3.4092079143859633, -2.9204507225116134, -0.02509768398101858, 0.3887762170577542, -2.5061676995825994, -2.564590928626109, 1.5363849280116728, -1.0522348647105961, -0.12067848587548423, -0.25163421010317266, -1.0668005927422826, -2.9148300251630244, -1.8117990958578065, 0.37966066018776395, -0.4352884349013735, 0.2896601184615574, -0.45597698057798525, -0.7829813070314977, -2.483108821580222, -0.3322711700326836, 0.47731275555066915},
    {-1.251497834900209, 0.0907510398183311, 0.8338529144554289, 0.3759795252696482, 0.15734110292633785, 0.20028119334536218, -0.432557572971606, -2.1154271527426407, 0.5034864242919036, -0.9611363666711806, -1.7429325333169914, -1.1394514511588558, 0.35345174991489486, 0.34009449023240534, 1.5191280210547737, -2.1221741936117025, -2.551952164865964, -0.7285420562230543, 0.10894467148082594, -0.6956319899965664, -1.857468248950791, -2.3924862903255986, 0.17802415010405165, -0.8049744128597147, 1.317086999189875, -2.1583248288823946, -0.6365464739797201, -3.682606156562911, 0.36944019968661285, -1.0878904519197312, 0.0696416113934789, 0.5819105116595098},
    {-0.7042837051903814, 0.4014546973413994, 0.295148695143216, -0.7449661603233166, -0.9992589193686546, 0.2651607757244956, -0.5913684504948148, -1.583485615041946, 0.8975561021631687, -2.457044060623668, -3.743620958298255, -1.682766859254375, -1.29598077145181, -1.6880369123730445, -0.2644544275638735, 0.2523974748056635, 0.19496336152417446, 1.2658439934562913, 1.429230428290068, -0.4939782624252158, -0.4815001929217476, -0.9753799751014256, -3.247646458076438, 1.102073700892509, 1.2225521857494102, 0.6495268605430836, 0.6035208054405361, -3.537338358154121, -2.304671531744894, -0.7820122686406057, -0.25897060264412974, 1.6109932920164836},
    {1.7802041465314087, -0.3021059539088776, 2.453993084588625, -0.7744948395651899, -0.059497284708547454, 0.43713098936604383, -0.5179109448128696, 0.0020491921988122926, -2.5811241911837315, -1.692420533683667, 0.8634839614378051, -1.0036529175024556, -0.45195818962925866, 0.5098506146669306, -0.39541892443095983, 0.3317441022587078, -0.4284437620936763, 0.7902867097311767, 0.24146383061994278, 1.4123537885693578, 0.02264538106229337, -3.409730697618126, -0.8145147646383739, -1.1687433501280007, 1.2857700692638454, 0.38938864562115316, -0.26056146802768226, -0.5935366521157758, 1.4722136448758107, -0.9395386033270513, -1.4015695677420767, -0.7244646446831859},
    {-0.5250350332336914, 0.9136372834989671, -0.6840044879166954, -1.242043472827676, -1.0654659557360509, -1.0899486665543632, 0.01418132172944701, 0.4574768443926689, -1.530155574496135, -0.013768729156939592, 0.08432914815684876, -1.0730187218884202, 0.5499136822958762, -1.3322645925718264, 1.640525026123873, -1.4760061375599045, -0.14661795447820525, -0.4577909957461413, 1.3502263953545226, -0.961973756595345, -0.40552517461713883, -0.8521357411236401, -2.4221824557716976, 0.7920998914274452, 0.8042645844695225, 0.9267120015957686, -1.5514558685114421, 0.3150403831224196, 1.8093656314657522, 0.10448440607693912, -0.3934700029225202, 0.685384639649243},
    {0.46776859827336814, -1.074813844493179, 0.440465199665676, -1.0783906298009167, -2.182734920095632, 0.32843621979092213, 1.202500418389139, 1.2908595219800407, 0.2458396370930572, -1.10569798457987, -3.0715153531610087, 0.08237001019762008, 1.262047116770026, 0.17185852509227303, 0.37911231912912197, -1.1805817777074143, -3.015964343010654, 1.5002710593639574, 1.1496572382786503, -0.005401597150610115, -1.4640160162040108, -3.9476271469313717, -3.5183696137357487, -1.8379958235712717, 1.708667387299712, -0.015175979796041905, 0.2810121821244776, 0.262138391761541, -2.3403789616443826, -0.18222713120984554, -0.462638544278775, -0.9082149909558265},
    {-2.6002437942672603, -0.2739510992115826, -1.4913399702217236, -1.1154145113219454, -0.6604951130268165, 0.11989524772779407, 0.6041723286704263, -0.2024042668885192, 0.11287223592939105, -0.9183463200995661, 1.5858196697452, -1.3195779650169661, 0.7525210059135615, 0.19256617134501824, 0.7581040300773638, 0.4090364689326806, -0.7352858554634134, 2.61491160758706, 0.13629491859151185, -0.7893591733017831, -1.311492455142036, -1.0153461479789085, -1.633222419384202, -2.0557818088748205, 1.6561451288696076, 0.3563003334110847, 0.18632173026559498, -0.6101399450181049, -1.7214167715717457, -0.23437208704121687, 0.3047737209955215, -2.189337900150486},
    {-2.362793736425279, 1.0920734320093248, -0.617011397392408, 1.0385524191730833, -0.6121606792462562, 0.9957539071199099, -2.675721087037734, 0.5941304187178783, -0.06799768245066146, 1.4959487370061437, -0.708469327524539, -0.40169748133838784, -1.3617877518303876, -0.02518575865560368, 0.53062991528421, -0.09056082123152402, -0.2104142637731339, 1.5277346384689185, -1.0985161612745644, -1.685309664183843, -0.05334044463265494, -1.5155227938721119, -1.9380910980919464, 0.6384273182769802, 1.214195537152391, -1.1650605289072404, 1.2439837158912737, 0.006234864183324014, -1.5633143610379623, 0.40119299275982556, -1.1968997946460687, 0.3208334390477554},
    {0.7671658838689184, -0.21046615621743917, 0.06300119312086007, -0.6760588217061791, -1.6924631112862814, -0.4329249926786446, -2.038511014378314, 0.9643460189369051, -0.37920326504913426, -1.0030844459318584, 0.7397388564988531, -0.38647384464951895, 1.0436977687657996, -0.3595930554206074, -1.572673363543451, -0.4341407712899158, 0.20703784325284874, -1.3979874402774464, 1.9321222987560862, -0.3177191670086383, -0.17658333322398365, 0.7982630141736279, -1.1224951895102975, 0.8333493615689891, 0.7429929468090054, -1.9216178814172142, -1.1601813670607874, -1.8233806122552363, 0.09837798867143893, 0.37226831473073024, -1.814632092740789, 2.3151016932925796},
    {-1.7896863321729062, -2.0299026246437983, 2.1037490802286714, 0.3049058795697719, 0.7278383073583128, 1.793328243982239, 0.3242665668072371, -0.4065195476369707, -2.0754570229098177, 0.20962925335081933, -2.6170381681915447, 1.255019807131843, -0.5997014623441674, -0.7541201521775164, 1.9708014058888057, 0.45322477163149366, 1.7111852442084965, 2.061392672314659, 1.1674471723886881, -1.9004905215713666, -0.25762348573157073, 0.2890202806311773, 0.4453393236921323, -1.1436521792755818, -0.7043014661740533, -1.5175678976292621, -0.8673895426945094, 0.4595922061406343, -1.8393506294884743, 1.255138898047637, 1.356052430398384, -1.6890960514687559},
    {-2.0049249963848093, 0.606625776736711, -0.47645214976938083, -2.078425634378946, 2.757222294920178, -2.6453772603698447, -2.4936074038545146, -0.7197768207608702, -1.895436290943234, 0.4471619202197806, 0.7234933753132545, -1.897389003875214, -1.0164630612313024, -2.011051372499532, 0.5540327983939768, -0.9321210296995086, -2.1122600930974156, 0.5985134760135444, -0.025273082130782058, -2.035953372288529, 0.45005624413395207, -1.26547738371147, 0.1840733140724404, -0.8369517367132209, -2.3789462736662257, -1.4021393283215007, 1.9004113147611355, -2.2059075155814725, 0.29822058181212485, 0.7301971812008915, -2.422191390748847, -0.6766675373114446},
    {-0.25214024722547973, 1.8210076005831368, 2.1999041228254512, -1.8493761930262171, 2.147022103168282, -0.6399574336742919, -0.47463569797892724, -1.7593715795105371, 1.1777109216992008, 1.2362110529852193, 0.2344245110578495, -1.4170905180676807, -0.8197482800785818, -0.735885250077679, -0.2814278572848086, 1.4730362663139587, -1.2230323107429333, -0.9459290765524322, -0.29825101414580174, 1.507677623610405, 1.8612808911086534, 0.14630385465440293, -1.1535658233870039, -1.14258278053604, 2.8163462545672164, -0.35022525989255054, -0.5431759113969062, -0.41632783773746207, 1.1039191382164633, 0.3672642975873905, 0.44412123387086355, 2.7751009255248986},
    {0.40905396553557866, -2.3454000632243663, -0.1416621657599969, 0.32952050550893436, 0.7716852816605966, 0.4269427801480268, -1.7822998758304391, 1.3972376916437323, 0.5874726473209324, -1.5910742531450286, -1.0364541494051667, -0.20152285738648973, 0.4809734199380325, 1.1643220267399366, -0.546609209492062, 0.7909937816413447, -1.211950377204443, 1.071958143096327, 1.6072877138706714, 1.720141750285427, -0.0490814065122976, -0.08688089423242976, 0.48572225032835586, -1.513416537344849, -0.17155991158929768, 1.5121225710563828, 0.7720570973424591, -1.1556000788049687, -2.0574239603703774, 0.9313613909788067, -0.3099400553597275, -1.3643633709225935},
    {-0.7667509583679465, 0.49916239947676166, 0.5433784104220605, -1.953803672868604, 1.5340170306454903, -0.9982978921527582, 0.16563365438311903, -0.5243577099538853, 1.5496554538425402, 0.8228754646481362, 1.4635218981153146, -1.8720710362220903, -0.3930911380908268, -1.2001954189687887, 0.9629891473605522, 0.5777540757829976, -1.9542093565497467, -1.7298489003023538, 0.7042944626614528, 1.8336875228613747, -0.2783060805878607, -0.6478544074766045, -2.512651196907427, 0.8192815628521872, -0.20338519252038312, 2.1824914958705643, 0.5272508550896574, -1.0849932931677921, 0.03177990556434329, -1.9061575295968969, -1.5333567844571718, -1.2284577157291328},
    {0.38576004130772634, -0.3492516148490734, 0.589162534469128, -1.309292032503326, -1.520061917151955, -1.7419426893725767, 1.2241273113073288, 1.0642747252029359, 0.8026755025055446, -0.006219767780489562, -1.5377084167913864, 0.26796896593221176, -0.7266377330173941, -0.4537449138747103, 0.3667843347148658, 1.6497671303204287, -0.8960954003722819, -1.7448460787724478, -1.2246932100063046, -0.04137971982166858, -0.7913715116816121, -1.5439180566778903, -2.5113369315766154, -0.4143335267524903, 0.5111883547747831, -0.16098685390612336, -0.12402259817595492, -0.09002416383369574, -0.8814717779206961, -2.062196896804817, -2.330790301129983, 1.352399463483882},
    {-0.761981792798186, 1.7584213970061315, 0.4718957018974613, -0.24036216048800127, 1.4756150086840674, 1.2911637875787167, 1.2534948719906545, 1.6050251097496782, -0.8561378427552436, -0.8732913028101014, -1.2809922995117045, 0.32865075118949, 0.11275121674504555, -1.445211600282626, 1.674763434990346, -0.07220487332700251, -1.4136726029484252, 1.1461560506690385, -2.1180767516712864, 0.8879440876232987, -1.4374077647304213, -1.4690214898837985, -0.2752463517535445, -0.5273602360797346, 0.43507764826379103, -0.19259192142305526, 0.39670082703103204, 0.5096632711101353, 0.4353162676284916, 0.17593091329154492, -2.163129929057808, -2.5943894057575405},
    {-2.5707101817473506, 0.5813664961344182, -0.8561277763339535, -0.1663996105450551, 0.8743097552590245, 2.161084715813479, -0.8959496715731998, 1.8576313674985614, 1.598648832308657, 1.298996726643093, -1.3386460650735545, -1.0875135788518429, -0.6422085590203607, -0.5327111791606802, 0.3466727070995513, 1.8832464982533705, -1.1243787842618642, -2.5779040902840435, -1.580128200525661, 1.420008324901632, -2.506831638127501, -0.22836695539538213, -1.1324732883484536, 0.1372135657895581, -0.42943723923547944, -0.2674234429944546, -1.0459452880325828, 0.7795707742477394, 1.167361893417483, 0.8728992043826181, -1.2222046226783594, -0.13241689955508953},
    {0.2030945583256011, 1.676609000034096, -1.235489521225908, -0.10335506132993898, 2.8068091480342283, 1.5821958081532974, -1.2137418463182452, 0.7852177340505847, 2.099145278768232, 0.5870588113778805, -1.2131830290001604, -0.36166548275060445, -0.5311833218485278, 0.21426369807769513, 1.3775974677011622, -1.1576801083564565, 0.8852631346316381, -1.800829687715232, 1.6349893683829444, 0.8169447339755279, 1.2275252878361598, 1.0171371218597565, 0.43639621579785776, 1.0905844578889774, -1.9210558031730398, -0.7884773479351577, -0.6160289342804675, -0.7516642965293642, -0.06752950808717928, -1.0607721763302969, -1.1930921932549994, -0.37357094470794744},
    {-0.015032180138253175, 0.7629723247607132, -0.039302975777786076, -0.7821189304260686, 1.158870725590701, 1.1456086762937354, -0.9549322873893443, 1.0933780697233608, 0.9639814562178335, -0.9099032962866634, 0.6433412970343501, 1.468015539092396, -1.006836284786241, -1.8497310153093924, 1.1013231565142962, 2.6130757338469865, 0.019419787089749264, 1.7146905718536984, 2.078117510390044, 0.8979397184850203, 1.3826131681825722, 0.2301997781337168, 0.040350031209983615, 1.9333639580111937, 0.3572960465711601, -0.5242231259481542, -0.014557096285061943, -1.0878823697676305, -0.39516472238397365, -1.4556837747105662, 0.7736436189782937, -1.4992092769446905},
    {-0.6693726005990173, 1.7226454430684115, -1.012465264794251, -1.5419986584771779, 1.8353607700201688, 0.05525390005068224, -0.916708429965828, -0.9432414759760921, 1.467325683235589, 0.8743085766442156, 1.605067280559397, -1.8223297832094236, -0.55556693563263, 0.15244680886274728, 0.45014493242128023, 1.0617881483212317, 0.6042813989728602, -0.3166877360012751, 2.002356445363614, 0.9460798096314749, 0.8779235713428822, 0.36771223032141526, -1.1583384852801464, 1.0039649910139097, 0.2849457567715907, -1.8878554546496003, -1.3109682785952417, -0.07269864169782426, 0.12331470550012322, 0.16354206005382027, -1.148434249599917, 0.8886490678886528},
    {0.45425069424613324, -0.48850524576878135, -2.5418966560290484, 1.3788832047443733, 0.40455320802380845, -0.7940427726664995, -0.4283935522061813, -0.19524528508251515, 1.2639292443471817, 0.42441710985246833, -0.8394637780847315, -0.3442035764422328, 0.8257515339302572, -0.3269967510488041, 0.20356771342255206, 0.04070908262255084, 1.1776528788163094, 0.5959575190368396, 0.8982123276030246, -0.47847592412271805, -0.06870656287523681, -0.44144374428868716, -1.0337970444937277, 2.075723258273472, 0.36117084083481715, -0.24535803930433658, -1.6248435678245514, 2.011674028277304, -2.118318521777596, -0.538467866889874, 1.5564343877416513, -0.10936126721785454},
    {-1.3376391446715317, 0.23052863813023167, 0.8082535104533041, 0.7241140199226608, -0.49968529075118895, -1.2692091279995532, -1.649613136530716, -0.7902556567925053, 0.05263678711248276, 0.18877744959051346, -0.8355396559790694, -0.9068029967905584, 0.6318034922593058, 0.03010116386155271, 1.9111708446167457, -1.6627951559435856, 0.2880712472897183, 0.1644178007910822, 0.38544514319013834, -0.602226876177917, 0.7913528621510044, -0.5507781293608924, -0.5032309246376886, 0.01847495756529105, -1.81471182037528, 0.9630957929979349, 0.41783225426498943, -0.2042957691093537, -1.7732419103643902, 0.33029344851396714, 0.14313378451312145, -0.9919717946875635},
    {1.6997008031466467, 0.5418548450971631, 0.22376787326081077, -1.1186458581283472, 0.7175071801064999, -2.068883676592336, 0.2478472219570226, 0.8121321858352472, -2.583712623915549, 0.0671565326539771, 0.0201753011050652, 1.0992330224306706, 1.4849705747313597, 1.8890751240506534, 0.1409970461855346, -2.438710940561678, -1.7839476626885349, -0.4077510166339174, 0.35265728847167244, 0.967448440981523, -1.1858786935978298, -0.8433978786013292, -2.116856444632318, 1.0889248988282643, -0.5592670243536966, -1.0592485041104736, -0.05494304150399743, -0.7582472494230065, -1.2051114397438658, -0.4134113977958627, 0.6797471520875169, 1.9808753327475301},
    {-0.8739257653506082, 1.0419273374417675, -1.7749893730246338, 0.19965955753568598, 1.1878422840728466, -2.232539305129072, -0.8748272086679444, -1.2736433569553682, 0.9189172754860924, -1.5211295185368483, 0.24213377699151106, -0.4064305546894998, 0.22746749045478387, -2.483492155863024, 1.5417460477931126, 0.07310201439762434, 0.6472238400581425, -0.9958048440840699, -2.2048571527408956, -1.073071537281361, -1.4012474762203537, -0.01424325261515259, -2.428342132276848, 1.5632734676623785, -1.2864565973706314, -1.947530261592041, -0.5844043492580998, -1.7897257577702905, -0.7346604936189655, -1.7326619626458193, -1.5803153577093587, -0.20492496775974042},
    {0.14954619917062623, 0.7850154677925988, 1.1909694518860898, -0.681648137888664, -0.35440492304183974, 0.4663080669394661, -1.1995510603633683, 1.038594567152147, -0.5910634270854, 1.184588031457649, -0.6938771169342458, 0.5970584139285646, 0.4098506907565233, 1.6140108692381714, -1.9771167656121096, -2.063362893845632, -1.2098331431901213, 0.09872017145263919, -0.9769294276998268, 1.5761299481215902, 0.29374333495889776, -2.111645864734304, -1.3095355341227204, -0.6246389945799622, 1.4652443945104903, 0.6720818672767046, 0.1127082356127353, -0.7144502803003896, -1.4881031602750237, -0.6822211479870977, -0.3854563402025303, 1.1019697517804334},
    {-0.29709806400208605, 1.5209943174383278, 0.8147849421599153, -1.2246295907211193, 0.09396090184117042, -0.8847372149023396, 2.5981781896724874, 1.2810947192332862, -0.1588731630518469, -2.544021052017452, -0.05291367511439222, -0.12572524901343235, -0.18920565075738624, 0.032856368413279394, -0.17822201581967995, 0.8213329974377443, 1.12044911337895, 0.5076607456425658, -0.9169878907981265, 0.5886311084882465, -0.6624730315061813, -1.3943232542252655, -2.508724875581837, 2.030649386095144, -1.6800005799277147, 0.503037219276406, 1.905602198013039, -2.402223949829199, -1.241220196569259, -0.3055157817027697, -1.2904979634135347, 0.3215842688493987},
    {-0.20698999812398, 1.704006371358269, 1.6556539942708448, -1.8367275437892479, 0.307833187579777, 1.2701053693425979, 1.7160129592900046, 1.077742092374779, -1.193901141559938, 1.0797656861659053, -1.2675438490884297, -1.3164587992330374, -1.558625988426789, 0.671398991878054, 1.433676414531823, 1.146879431574925, 1.699861883946245, 2.0323482658872125, 2.1846625693692316, -0.24278063521666557, -1.3586106120628803, -1.0580658759393031, 1.6123529097551517, 1.485224282491249, 2.398680981240083, 1.4386521119857703, -2.329236147020578, 1.5601523498190475, -0.6963891934185255, -0.26591275046758484, -0.3646324883605812, 1.092790696761416}
};

static const float b1[32] = {8.105350400307488, 7.051311636277019, 8.27340160085882, 8.168400445594703, 7.9126118398525005, 8.024622089997893, 8.348306670240667, 7.810171422274311, 7.823991205508034, 7.939774256485725, 7.974491693850371, 8.054386131461616, 7.575101585219948, 8.16811702581872, 7.790895482832282, 8.187375859468384, 8.029965252668076, 8.166810274510617, 8.37456162178318, 8.221299935323028, 7.6303482064431245, 8.226923026950749, 7.9878089300610835, 8.446040888776315, 7.969349379093667, 8.049403809803774, 8.293101428475413, 8.353976266070177, 8.478002776056124, 8.265116757964313, 7.973027201056676, 8.17878619630596};

static const float w2[32][16] = {
    {2.9729189522075266, 4.978952737877337, 6.198600631682089, 6.964797200277015, 5.596628056756498, 7.227798915502908, 7.117007412649155, 6.044549174748704, 6.407761086194028, 6.870377257815522, 6.100008680966685, 6.431039294980137, 5.883795213189893, 5.294001335906953, 6.130449854653472, 6.617506042300386},
    {4.394072021101253, 4.01131170252982, 6.423039757298704, 6.671828855313208, 6.403865442915448, 6.408428414354883, 6.011471792393114, 6.307204899059131, 5.875062763611726, 6.324611772581678, 6.274870003602667, 5.4232251350382885, 6.158543484569742, 5.269798517734899, 5.9482434516477785, 7.297930291560864},
    {2.77583449802757, 3.9323023530834114, 5.78724841151023, 5.311174637110363, 5.373489185135941, 6.474294482259192, 5.987893567759652, 7.088337770244374, 5.856241124927897, 6.410701532091842, 6.103049840353089, 4.938975920484214, 6.997222678643447, 5.34303652375644, 6.395430130935069, 6.854683675956723},
    {3.2074599750605115, 5.403004735735038, 5.827227915405986, 6.250639576247768, 5.441642194726658, 6.008008355022032, 7.687653358808487, 6.394153105850762, 5.842808151464258, 7.273881199515867, 5.5854838005959735, 6.577985128347785, 7.14271983875694, 6.86176575816407, 7.138836303758699, 6.34405846498389},
    {3.868280619804018, 5.399155866854231, 5.868363196302928, 7.279222700601858, 6.733588328039215, 5.8886467127252216, 6.626847883866275, 7.163955751315719, 6.655542372139003, 6.545147866888321, 6.462276970181893, 6.595187292905021, 5.55335160783227, 6.115948310676981, 7.048039863510385, 6.600901831204019},
    {3.337572303805544, 5.23880875398297, 7.286318722611382, 7.624845489055893, 5.678875941335749, 7.238988413507445, 7.259473944743093, 6.603262243518881, 6.97072534050484, 7.4600587184706475, 6.98470375178842, 6.691619203294846, 7.641339484819814, 6.090751161109587, 6.430004152188558, 6.0646762412155955},
    {3.38512518897146, 4.756016980385045, 6.25117295746216, 6.716059826070687, 6.44930535065989, 6.1442119510362785, 7.333938129778646, 7.588689428891676, 6.391028736917519, 7.557130086788279, 7.01415818831423, 5.68163941497612, 6.718416351260196, 5.368191654626606, 7.669926524719065, 5.806107286262616},
    {3.9539574104203083, 4.617539279914105, 6.584426613265345, 6.287202682492062, 5.750789482749269, 6.955635666620448, 5.781381045614769, 7.59830050413711, 7.132692786165505, 7.654126635130775, 6.179815772292477, 5.6118503839706975, 6.862836555775826, 5.488367089681929, 6.079713764554833, 6.1153929934993725},
    {2.441923807390733, 4.256284247677845, 6.213561660944449, 5.821460464097294, 6.537464623084634, 6.826224508475513, 6.159954581735357, 5.759222824394981, 6.169469755147036, 7.222700513037597, 6.280789832868027, 5.373991894913329, 6.0576165237194015, 6.4703412329633885, 6.707996831369604, 6.280415399314566},
    {2.4810228796488203, 4.505696640986076, 6.957886332709415, 6.465264385648561, 6.963365911825571, 5.952513953913603, 5.977136924527652, 7.685272989410652, 7.354132753253121, 6.141449766409333, 6.993172780666647, 6.530400185599984, 7.210141061364868, 5.704509165416251, 7.606147316831099, 7.37069196270858},
    {3.5566023551778843, 3.914781780814328, 6.695204870075774, 7.176919082656341, 6.691424176988347, 6.8685383372493565, 7.123227199732274, 6.308770756774559, 6.927849635977326, 7.1659143416889375, 6.638641380824075, 5.093431478843914, 5.763861345141236, 6.705211094706122, 7.25729803748972, 6.013743391317861},
    {3.234917327000651, 5.5807608022996265, 7.106094100386576, 7.4262086473826745, 6.5802844601974115, 7.3104728058973825, 7.06858378984637, 6.28214576375396, 7.518742057056228, 7.44452307573325, 6.957164856293172, 6.176683045973829, 6.46048498411094, 5.300262660785768, 6.595446483817527, 6.2805171165456075},
    {2.8175432424781817, 4.907949025257193, 6.9988948579975245, 7.4909147966222545, 6.187121868509125, 5.577698110726992, 5.716157450856521, 6.904414682107665, 7.537949593333388, 6.549092196126346, 5.798395844305543, 5.0737316289748025, 6.424802377018382, 6.937104863441397, 5.992191522993099, 7.319373276740325},
    {3.322558675201261, 4.411734356090383, 6.87152359432772, 7.680989518338211, 5.9701091446379575, 7.272398769037381, 6.332723059910883, 7.559703199890816, 7.593230223917547, 6.152853725655969, 6.648370796252602, 5.843832663062967, 6.2649830177570935, 6.737241073983493, 6.860616157122878, 6.282927592239996},
    {3.4161217045024284, 3.9984428008104533, 6.45932390641712, 7.102753334736321, 6.054267113177441, 7.269430774246839, 6.3472283565421606, 5.974812745602865, 5.716133544762565, 5.811730126308986, 5.903838167518612, 5.4717334182989, 6.13226950132017, 5.82017159392045, 6.634011092146919, 6.536708158063325},
    {3.3866576451667756, 3.7703193909774457, 7.115620466974956, 7.366557683704698, 5.665753337636489, 6.860979940603094, 6.777219367709359, 7.597755387533135, 7.20632996669287, 6.121960075556295, 5.817518167719398, 5.858776634929148, 5.7508071327176715, 6.660372865451223, 7.3420585605925925, 6.277907387054718},
    {3.9032665197057557, 4.780947528149161, 6.368134328886307, 6.68979658684814, 6.4252724578160905, 7.056322915806866, 6.568281026633439, 5.830566326745876, 6.2453482782425525, 5.868461665531432, 5.61066963526703, 5.494865524759869, 7.4714948105105785, 5.049322406439118, 6.442157305931257, 6.442862198307678},
    {3.632971788237461, 3.9697246151340773, 6.506502472131136, 5.983753757576913, 6.797315815307323, 5.868643730941149, 7.096339792331919, 6.056607848995301, 7.346338785281676, 6.7545766368332965, 5.874107361979724, 5.802440583631996, 5.852462245640263, 5.297682127997362, 7.2714484283971945, 7.1524458828409525},
    {2.391422798793838, 4.408102671611509, 6.368065208422087, 6.8090379895299655, 6.121013870959596, 5.654050401271924, 6.583798402203904, 7.254431653773494, 6.220058719199449, 6.732122360678029, 6.109808299965838, 6.558697002819112, 6.744110231005186, 6.266679402679538, 7.760239387609211, 6.279288135301133},
    {2.5054793371188104, 5.048784424742373, 6.170155471939706, 7.047478554864161, 7.035852063485686, 5.749591688559965, 7.702682777003917, 6.430297391033898, 6.060996700740375, 6.787700116717522, 5.684473570641333, 6.664224133619226, 7.562337739869816, 5.9657720803917975, 6.496426367157852, 6.7412705928217775},
    {3.0232435898349594, 3.9009182010319927, 6.910525244072667, 5.868979968284037, 5.135236051913227, 6.352056026393607, 5.732910738623735, 7.023011165182096, 7.442617352203716, 6.860592823744375, 5.300305446201981, 5.112597683591351, 6.360916493735391, 6.676641386332316, 5.727642043408028, 6.121154801303804},
    {4.071981504097218, 3.7944873130236805, 7.548631520683685, 6.576950306382014, 5.629535834992678, 7.412712560407851, 7.328960306153324, 7.2222295063553394, 6.577251831778473, 6.3376557365223425, 5.56190878367925, 5.2043911552149025, 6.671467876631088, 5.2265320448827195, 6.990743285671858, 6.5109459031339565},
    {3.7187962135884685, 4.798767711057474, 6.050813509772947, 7.2100306449553795, 5.516857745118511, 5.696348700622592, 7.048485685541978, 6.44284417729253, 6.305091464529987, 7.680638221493913, 5.779880202085825, 6.78429112494242, 6.717098217196513, 6.874786622480709, 6.856808857259348, 7.1976029397377115},
    {3.1284327424097267, 3.955551339119942, 6.9381851321950245, 5.825694127754614, 6.262720635268947, 6.401807037075682, 6.709481665424575, 6.859267351356355, 6.243344327989479, 7.221468083284249, 5.973563255271803, 5.574401482894103, 7.315545316142302, 5.660504184530027, 6.704799398750315, 5.770548045548913},
    {3.818558264719172, 4.037571027623828, 5.947564230500196, 7.115730673687368, 5.476078572079056, 6.972663021358134, 6.903945287801706, 6.114154508417648, 7.3250946347392825, 6.888329966263611, 5.449273020264903, 5.456629651987806, 5.975223623108675, 5.317973517026311, 5.890929957309222, 7.1248153704221755},
    {4.20808614398173, 5.620217570757045, 6.001930939414023, 7.7049076536073215, 7.024456029989837, 6.785017696766231, 7.61584998440606, 6.012311751617228, 6.257506433264738, 6.002475108792606, 6.416084989579161, 6.431885364237652, 6.218927030999601, 6.589133084219666, 6.669988974498608, 7.612553974333137},
    {2.644114857368683, 4.216815423272463, 7.007357272976149, 6.978768479827732, 6.8045732861065265, 6.387665028213614, 7.0687656629782145, 7.301704658541443, 6.617745542073093, 7.048227716642811, 6.670453220230017, 5.842962499586421, 7.357722296399141, 5.852829005091326, 6.855925855808446, 7.131708326292327},
    {2.823578864021157, 3.93916694061179, 7.135728198739809, 6.968456014639328, 5.874255501331143, 6.478170040150106, 7.700194403442634, 7.695466239571998, 7.544914194068095, 5.743662918339226, 6.151957993784134, 5.632218519133781, 6.8875637252167, 5.93521087253781, 6.521431375977724, 6.956892677859318},
    {3.085860272811107, 4.799651816487097, 7.454790345406288, 7.199281064992378, 6.47965481856941, 6.90110199532817, 6.5720930730826295, 6.145193687486474, 6.9627332572078755, 6.978300829769826, 5.925931447198377, 5.566154476671695, 7.01162757275436, 5.5619334072430755, 7.32491054116956, 6.191318297341943},
    {2.351566526788539, 3.7169533498975276, 6.472398383875218, 5.638687932465949, 5.449824875649045, 6.606948031239176, 7.297571858535814, 6.436940675853688, 5.7961281230850075, 5.820433009260593, 6.011162282652248, 6.306181050965473, 6.404446497965558, 5.37129800543358, 6.358846071709107, 6.212769850263047},
    {2.9136472466360113, 5.811089604006207, 6.517862316809937, 6.9505574028095225, 6.171561028943228, 7.1239269936389125, 6.502886243780849, 7.503768634133511, 7.309029467196082, 6.1605964724337925, 6.97213927385503, 6.067028314500778, 6.06588786059245, 6.264769624064384, 6.027093172226478, 7.31743658042289},
    {3.8131726289551873, 4.461588699802817, 6.976830788779764, 5.672052993112301, 5.960377019155197, 6.3011999410317925, 7.305189825506177, 6.427563808179719, 6.682543324130218, 6.436569868277194, 6.363520472317957, 6.327789273940393, 6.214038036202529, 6.656918939626652, 7.174532012688759, 5.823886748635549}
};

static const float b2[16] = {3.8177315360860486, 5.447857596453475, 6.985075185130611, 7.138192801230085, 6.91940095850105, 6.803927849366532, 7.0603076543998355, 7.272288560161677, 7.074353138303974, 7.196102563613861, 6.642843244159058, 6.305354149091405, 7.147258687804175, 6.578289351482608, 7.16450680754001, 7.107911514365206};

static const float w3[16][12] = {
    {-2.162334969247372, -3.202973675928923, -2.5260657639541075, -2.626182282591223, -2.0360434721386937, -2.90192957446599, -3.4166817103133886, -1.9074003480313348, -2.6461510206415895, -2.4208293833317374, -1.6185718961803712, -2.14102890289896},
    {-2.5436302278997163, -2.861645315142613, -3.6243591183146453, -2.8150852611418795, -3.4800531541409554, -2.473539665691276, -2.702074074563749, -3.581701762564059, -3.9211059489818223, -3.2337998781849246, -3.774931045043443, -3.241096377630959},
    {-3.9901017273409183, -4.428155111430957, -4.488846670958063, -5.250013929665169, -4.138558800716405, -3.948735864498219, -4.203507260147846, -4.765547326581391, -5.538366355482952, -3.9992542267853644, -5.304748872901446, -4.743620255101672},
    {-4.509528712105501, -5.0027855397360135, -4.234619619549279, -4.591374977391716, -4.714330482221864, -4.520812142602508, -4.418844803186732, -5.747009593549505, -3.9825458805350133, -4.471506300403208, -4.029138655575008, -4.71894100588431},
    {-5.095380050437039, -3.696759643540209, -4.0878604026694685, -3.9112904348957644, -5.594894676791922, -3.8083158123583214, -3.9914635512363974, -5.128433766186103, -5.109453144943613, -3.9533619664047728, -4.486921371244506, -4.027417486792014},
    {-5.5147859086377045, -4.725997081852802, -3.8436623945959867, -5.1511888650927995, -4.321962569813068, -4.73045396949633, -5.676458132815733, -3.8989234010159453, -4.2823468465777035, -5.468215232617728, -3.6277467219484163, -5.226765456752933},
    {-3.6891210749659926, -5.213464985525768, -5.42332289557804, -4.482616679312524, -4.810773994561914, -4.052941794954019, -4.6660061741085, -5.735389611867156, -5.395993400802776, -4.152564624578449, -4.854543704818807, -4.882364772362362},
    {-5.105953505856692, -5.080161463034765, -4.438484479852812, -4.974471294583078, -5.410854060530532, -5.077792686056611, -4.304500017614941, -4.111261724528633, -3.4669787548307447, -4.640895084092236, -5.136593391940127, -4.936656190494478},
    {-4.181122780847772, -3.600761234646505, -4.7478514275131944, -4.200271505571933, -4.64058594519416, -4.738967213710745, -4.932829979312349, -4.33718755272012, -5.4017039222274885, -4.932994262527831, -4.654933809368574, -3.3812500548341258},
    {-4.31599420946982, -5.297760872053255, -4.823226800217218, -5.7237359044417335, -5.0570657192146005, -5.21064367259391, -4.851852816118588, -3.7963397515960393, -4.7913348923837615, -4.355424850338508, -4.859910062784267, -4.397276738132931},
    {-4.17853798425859, -5.106456851152025, -3.8349578049707316, -3.669586784365365, -3.7350718164227295, -4.522867070968168, -5.255470442081443, -4.746680520942263, -4.08416867039699, -5.444185238307993, -4.369596709348373, -4.6902334759648845},
    {-3.9761019078232236, -4.751119002882387, -4.264459064315568, -3.482872261234447, -3.435479433001985, -4.641975161343754, -4.182586741415324, -3.536530014019805, -4.599218518513122, -5.170711171215735, -4.1111841799507935, -4.4991882216989465},
    {-5.397449720308633, -5.017546878776422, -4.3867877854919675, -4.5106943824826775, -5.806494012795198, -4.879829693632068, -3.769821302746143, -4.463730308811738, -4.953280242616236, -4.188241036158544, -4.691658930437673, -4.685840852323974},
    {-4.291725536663081, -3.423854120225977, -5.385464703665823, -4.1658029475484675, -3.371958882488282, -4.1949925837030895, -4.516281247033218, -4.012868310548314, -4.123180924081236, -3.969748077713971, -4.503057643882869, -4.921105119699965},
    {-5.429448916131807, -3.594377309776903, -5.676807171227605, -4.9481582345730475, -4.122295946156589, -5.352215172885389, -5.1373630436605096, -4.647552491699691, -4.055231171294724, -4.612004451430607, -5.733030162252596, -4.289872439117377},
    {-5.052604773061836, -4.9575519963041454, -4.127914629475458, -5.0047260745325115, -4.796524012024129, -4.628578909969626, -4.1370330295671005, -5.090883594530936, -3.842352520147964, -4.932605814459562, -3.7191533362307716, -4.8807023606049444}
};

static const float b3[12] = {-2.9628489236482127, -3.0193620468087623, -3.1952936164398165, -3.2634579568475113, -2.932963006147969, -3.4293343239398344, -3.0912955651492533, -3.285277369381043, -2.417408351357766, -2.6365970478986043, -2.988410391295762, -3.347175740555463};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
