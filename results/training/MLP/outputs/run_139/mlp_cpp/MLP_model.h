#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.5840014375390141, -2.9457201692804595, -3.295586153098366, 0.4243877828165853, 0.6415214002545493, 0.7818697615707898, -3.948148696381878, -2.1303862924728576, 0.006620517686596059, -2.3945746788009044, -2.2748048133944425, -2.1100752004426693, -1.7328959851081447, -0.5803589131274333, 0.961128694454801, -1.1284970003113064, 0.5066572754993847, -2.0037341379699116, -3.3619115939886877, -1.941151003690562, -3.9825564089600753, -3.000655068337628, -1.231952379044996, -0.4948694979946946, -2.5818882848010025, -2.3790341247477245, -4.332308919060376, -0.8579043102119533, -1.4629511252994756, -0.7123961555367783, -2.3472386580467317, -0.3459961169672094},
    {3.189634541540104, 1.9172297366898605, 2.031567323401995, 0.3096254622738601, -0.25798872458470035, -2.2947374295450986, 0.43251601599858286, 4.939299547900391, -0.43438548168624175, 1.5345985769857688, 2.652093082099292, 1.0153159961920768, 2.6568884928857965, 1.623353203869508, -0.05752397245428473, 1.138007224294508, -0.7782637403117367, 1.682756875468475, 1.5814035216154867, -1.3786718521884034, 4.519146511917106, 2.152033131644229, 2.9692770881037487, 2.358383874355893, 0.19112109671790548, 2.8576587713821113, 3.4260481956543742, 2.381307582547494, 0.02975837841961182, -1.078623444462823, -0.5732752788429112, -1.0014491535630077},
    {-0.4217626943646093, 1.4257621613098779, -0.38448489944264236, 1.1443498680738133, -0.6637959394492966, -1.0071291622297063, -0.8214645796155958, 1.7631185734232233, 0.08154768147568359, 2.3370179970543705, -1.3933198599477632, 0.11322374845006883, -0.15173351346926695, -0.09181799371671867, -1.4738429971483213, -1.8620779228877342, 1.5862440764159202, 1.780499479469144, 2.0707091835705373, -0.23602515535681226, -1.1677251402051223, 0.1380366711284948, 0.7850015727829911, 1.1332608462211156, -0.8227403291879538, 0.7787070134079104, 1.3544194487521202, -2.0708777556389215, 0.4354375748174726, 1.466333150206204, -0.17847538731655085, -1.1274549443964492},
    {-0.8156411955967177, 0.6976699564127039, -1.0727315304686917, -2.592794054673036, 1.5646550245667288, -2.341796645915582, -3.0823309262870224, -0.8203842978811676, -0.7668828893072593, 0.2875237757043504, -2.5067325363587774, -1.6830442118050426, -0.8222055371607618, -4.110778511034305, -0.11516327789384481, -0.9473304533491531, -2.0612541016241104, 1.5990402748958081, 2.2081371494615727, 2.1907803174835343, -4.036650873307441, -0.18532958085424936, -0.16653016813420002, -0.7674363166304348, 2.1485441832913494, -1.5231543225356337, -1.372592104410227, -0.46245116056191515, -0.16333475987707904, 3.5221256280650617, 0.09490148670032404, -2.033442893576431},
    {1.226772666158994, 2.326416699174731, 1.18007699196449, 0.13686408329706864, -0.3915855775139924, -1.7472051359052234, 1.9728290298590958, 1.231699794880164, 3.21914212056891, 1.8647694088651594, 1.073064221194476, 2.0576086044101056, -0.3285152317192086, -1.6867745585866383, -1.754913696806598, -1.2792412431335904, 2.647561097179566, 1.721778531849214, 1.7202943622685773, 2.5793550524087836, 1.575315061400315, -0.28808242238467613, 1.4232124359370253, -0.5634252697758839, 0.7814909898950745, 1.0949473330352393, 0.9036152017571681, 0.7687891134898681, 2.5219920773131723, 1.0374038394177725, 2.0799853727096673, 1.1507250709915942},
    {1.445701980625763, 3.0521753754821574, 0.3880290898617167, -1.3050140616135861, 0.10423605876410644, 0.3464617268636747, 3.5407081983396846, 3.022389980516463, 2.90615715494157, 1.1610916542118903, 2.2025892936367133, 0.6976810144201696, 2.242574451658449, 0.8341964127731306, 1.7788552772875026, -1.029436598834218, 3.300426356492867, 1.523701075225834, 2.4032389531278926, 0.20241967754923423, 0.2893107224212591, -0.8751619492450478, 0.8824251570667124, -0.5851791609224287, 0.6210953129706862, 3.4188508263482604, 3.278818467126971, 1.7462838264828155, 2.0294698467279404, 0.46480117069495874, 1.798385097877514, 0.9362242087715326},
    {0.024582086277757924, 3.5141701131296554, 1.6278160954117185, -2.2053101822146295, 0.853856636056841, 1.890726200196944, 4.256086541341312, 2.9377684971759153, 1.1541199915542775, -0.3761340272893742, 2.115165924459314, -0.3805785899347709, 1.2591014633078719, 0.89165497915098, 1.5702408777857126, -0.6304404647028463, 2.424789806707438, 3.565193355968537, 1.2160873375144092, 1.07598732448257, 0.5663526977244325, 1.5180073952691104, 1.4306689018863583, -2.2437812092697182, 1.3237365271635972, 3.7336694742606977, 0.6592682334993243, 2.124778262376619, 1.0055932641685734, 2.7942468942782943, 3.073172089238394, 1.1499902184832216},
    {-0.6014006802290842, 2.25930167876495, 2.8268735181094153, 0.020201920737273917, 1.7074972092620375, 2.7646327404428974, 2.223085766509861, 1.6907441288346399, 0.10518837685652165, -0.4504724626791342, 1.4068188396980534, -0.08822959266385015, 0.5158271132188034, 2.4547024256268704, -0.17487138405766675, 0.14122806675414476, 1.1426336318417674, 1.2270542540690024, 2.969733409206925, -2.533823232902285, 0.40656548658261044, 0.9719149403351446, 0.7721363350745893, -0.32123701454721765, 0.0885775571946246, 1.5192440167178793, 0.5267928702614478, 1.0800395878885665, 0.7773847494912833, 0.30060828900977465, 0.7013262819699799, 1.5182760082285431},
    {-2.4749228623680617, 1.3787911287754417, 0.41075473787003025, 1.409326670842126, -1.4092445874889703, -1.6234733422327723, 0.30387682016637113, 0.9333307239002441, 1.7302900503834011, -1.4392187432169188, 0.972192170335288, -0.12125435715348173, -1.4530539757917902, -0.7065499459137443, 1.3321370365621852, -0.325441519339702, -0.17121773165437712, 3.936884079213009, 0.6807992134380585, 2.4297549554883737, -0.09385135198894502, 0.5652432607583427, 0.6402077164082234, 2.503371047225678, 1.4723599105274698, 0.4238198930211875, 0.26441279535623163, 2.9588812739040122, -2.516145830308648, -1.0951100626420807, 1.8044510351365408, 0.47925152447490427},
    {1.1021856902889382, 0.9355393348869395, -1.0639631459235772, 0.2197202642178451, 1.7930660121964017, 0.07896789903763382, 0.7307586080174044, 2.8082263607421387, -1.2608727945238491, 0.9951484150698177, -0.2926745247906361, 1.2025486901569817, -2.056698232032825, 2.0651068163859803, 0.4292888976985054, 0.9374929180545507, 1.2725427504607842, -0.8452074232066871, 2.113034786221754, -0.09507129075702768, 2.3588375687883354, 1.6145784782549621, 1.7072537965867862, 2.449521963806816, -0.7423193458892653, 0.754482168290833, 3.7798688835823184, 1.7351048056016796, 1.918010293849312, -2.01152489741101, 2.564115874190368, 1.9466526918760199},
    {-0.2097960031356672, 0.1121311066242408, 1.4231261644995152, -0.7360220974714096, -0.3714036647072535, 1.0193638552838171, 0.24110606140516008, 0.732269015456702, 2.967480500835718, 0.03615421082869349, -2.5588622735588626, 2.1721297701685494, -0.2240169236071717, 0.9214929408041264, -1.9784355991161315, -0.8421754937044413, -0.0007806639451509009, -1.079840451894339, -3.468110027270546, -1.8581286139493103, 2.566652337261313, -1.226806892100391, -0.03392291270871334, 2.493617618240697, 1.1173004714830927, 3.4982777246519023, 0.23404566582895148, 1.5277314941888418, 1.084222367968634, -1.929438422563809, 0.2840112886429214, 1.0346535771911702},
    {-1.402197710625495, -0.9142801949160407, 0.901228770761443, 0.2069426541906572, 1.0777877395117506, 0.19132103312433885, -3.115290496468937, -0.7662300773181375, -2.746403049969949, 1.5200380412353491, -0.20768530286524606, -1.1385109017316908, -0.4948213889929758, -0.4768003873667546, 1.4010974058012422, -0.10669657308619947, -2.0477628445036937, 1.0102079619734108, -2.0287930047455562, 1.563623937405386, -0.2515446001694373, -0.21347897257036874, 0.1113950054888851, -1.9313180735553392, 0.5952066861444485, -1.392741748410609, 1.944465703505481, 1.563719573691723, 1.0913594256598498, 1.0230063281246946, 0.9157491608753229, 0.1093042283897896},
    {1.8040021328730071, -0.18903943065489975, 2.1689043503124203, 0.8429172038806613, -0.9823362240464114, 2.3274542031890606, -0.46867489397594253, 2.2338438874364943, 1.0832689797357193, -1.3612208697545576, 2.584744345150131, 0.9493824875622745, 0.7232232839537367, 0.6962801286274067, -0.8438903304016665, 1.0257270461013719, 2.454813137748325, 0.7475029748863445, -0.4687141897952812, -1.31148613575468, 1.7414617785945425, 2.805185168487357, 1.606283846929452, 2.970442168703378, -1.252965153305057, 0.8809534016320056, -1.0934118328408915, 0.6324034572746168, 0.39975422698114244, -2.7146376372795253, 0.5693468132491804, 2.135893612350617},
    {0.485059272155629, 1.4613860677028143, 0.09648018331664443, 0.6196934557697075, 0.9965300209105094, 1.0484236755622782, 1.406078773174103, 1.0894804573964003, -0.1427598778172663, -0.7734243875104541, -1.02182821447779, 3.181285430908751, 0.8957699492916774, 0.04047764800625522, 2.004067910950147, 1.8041149616896146, -0.7092275618115591, 1.8538662478259111, 3.309102503605976, 1.2814449651445328, -1.7747346698133506, 2.2352619968717438, -1.5473112310322075, 1.4075222594965326, -0.4566332877008822, -0.8221958115244976, -1.2585436445381737, 1.3579294354443172, 1.1633298967279082, 3.4253609965164946, 0.17428215261007005, 1.7221124113865334},
    {-2.8549712052135905, 1.6729168813955626, -0.1545425395341625, 1.3745844435097718, -0.7262773810305165, 0.47989182525149165, 1.142417097381436, -2.145703702386456, 2.2829880750618816, -2.209240253654409, -1.9680737237024377, 0.36132014935863904, 0.7940118563354291, -1.2954973113045811, 3.458227661262406, 0.8644065914798806, -1.2016345137021855, 3.7225478560611784, -0.5182273018041704, -2.515209711875419, -3.06231947248733, -0.4113558211232699, -4.627211865594742, -2.07612728378258, -1.683982486927464, -0.48214122059725695, -1.1389255468526256, -0.7955297777883868, -0.3739091377497804, 4.7019204688961445, 0.8446886541493797, -2.5544756964578625},
    {-0.1647989414911201, -0.4640524013055181, 2.3224113549903396, 2.4775773470793903, -3.1873172290830407, 0.38872195733846754, 1.6043064485037675, 1.8844794841328054, 0.6085862453859204, 1.4688102232874327, 2.5560332409173947, 1.7064602041617212, 0.510132907504199, -0.9848487205851967, 1.0129137155031571, 3.0493466238472284, -3.317720105384527, 1.792575892117771, -3.6072630297086934, 0.3420071573531795, 2.365170145953514, 0.8762959997888322, 0.390153960130618, -0.9207757601999914, 0.5088443726795066, 4.466555439950963, -0.7916990094276811, -0.2000981717227736, 0.6179726871614568, 0.4276986782998623, -1.5108030608662024, 2.211046267924465},
    {-1.7132837834005052, 1.6278715569387996, 0.4931031990729363, 2.4181196003329997, -3.0617549419724215, 0.8156010271496436, 1.1507405802739354, 0.47369204748709726, 1.9019828649851267, -0.3596436188419841, -1.1868119089601443, 3.743743359311023, 2.881712410987242, -2.343500502649896, 5.271352809316248, 0.95275118117565, 1.8580468679751538, -0.7844432679517236, 1.0504883631871977, -0.44164989487394163, -0.16379023782422103, 0.3118347564922777, -0.8730572033797941, -2.0383081747781207, 0.3076131170207182, 1.8097554201629908, 1.3438981696351466, 0.25012493393940965, 1.1887398248971277, 3.7554932391587954, 2.13616010571683, 1.4659337347687003},
    {-1.4625848223064104, 1.3773687373648684, 0.6652788836461428, 1.5822492134214154, -2.561661203714639, 1.3886523684416798, 0.9579903605965814, 0.9384501468621718, 0.9306401872596137, -2.9996041297185254, -1.5262713658143, 0.9675187964117758, 0.9551642905209354, 0.17619058055659712, 3.834153166546428, -0.5777148653054719, 0.02474320967507089, 1.2151177991504543, 0.6012663790428042, 0.9374071706941669, -1.9679653781739859, 2.506586359289114, -3.537504745394512, 0.24564753102647613, 1.1032468196929903, 0.6101956827305607, 0.7639421648014684, 2.226521946454441, 0.9916742783944078, 3.5350189814674633, 0.5153210709833792, -1.0033781596185132},
    {-2.131803796032295, 1.502517863573824, -0.8146985741183929, 2.5138687976943266, 1.7803916180462254, 0.6488209056194537, 2.696942895055288, -0.7139344367525945, 0.3207948228772013, 1.4266830328323605, -2.3567642362688015, -1.3183753273230816, 1.4546284688603603, -2.8447431018914022, 2.551830269156977, -1.0644043842611837, 0.2162490844940051, 1.429098982659208, 0.021563752784006976, 1.7051033646066684, 0.9044547456230907, 1.2415004922892041, -0.8646278811045502, -1.256628967948418, 0.16506568500467728, -0.38344254337000555, 1.778441939683271, 2.741609689236618, 1.9747607162270435, 1.6308058878436045, -0.6575136034526807, -1.9672927251002557},
    {0.615879871374745, 2.565543862231787, -0.20707690177445748, 1.6243980994288685, 0.44446668952777607, 0.09717121772621305, -1.2380571250818244, -1.3969390618076891, 0.46193155389688323, 1.0774334521547264, -3.2719893449437727, -0.4769695353432929, 2.611022817275884, 0.17477596451894378, 1.0347954892774769, 1.6869249433568376, 1.964895189134864, 0.1646587623144851, -3.7991641245881227, -0.5880251678651546, 0.8991226850509089, -0.19360916376591625, 0.1985652896547861, -1.9242625149212669, -0.5919234066931955, 1.8605053707094137, 0.5923169548529357, 1.7724904794802536, 0.15959262228269933, 1.1391298866335813, -2.006724969225447, 2.4459981439995966},
    {-0.7435388130806316, -0.045653673038826025, -1.13841426869024, 0.43844443456896626, -0.6132351692849073, -0.09827118233963097, -0.46527876592877365, -1.1001971780840252, 0.9659850304308384, -1.3341790945575975, -2.795091671906559, -0.5389656607896463, 0.788767938514144, -1.7819474150425727, -0.2693041835938126, -0.08671473655763323, -0.271858378902622, -1.5498746179317506, 0.3718733976067551, 1.0707453642464546, -1.4638053013895362, -1.7234357502984776, -2.02817591533805, -1.198564172982242, -0.27678711963262786, -1.7087584615299258, -1.4158053046999317, -0.543455342632114, 0.32949140651275255, 3.296529778664491, -1.2793557183699251, -2.516109185647766},
    {-0.6576116336354412, 1.1374479157186377, -0.0353179553885744, -0.9027318077063564, 0.758641037362785, 2.2449844416523965, -1.5278511851511445, -0.18548719725880278, -0.8762586975527666, -0.5466333827864088, -1.3700596905296099, -0.1500357381937347, 1.129637172029156, 0.025267009969369307, 1.1984104063001872, 1.0739009676532294, -2.0685549057913906, 2.1831877551507413, 1.732689706046865, 1.1545948175857244, -1.2232204319516786, 0.28685269206384684, 1.4335455516755844, -0.2823803351373452, -0.06526778250196973, 0.006251988217182248, -2.7592376527493228, -1.3860149919197566, 0.5846629281078054, 0.4236922355854982, -1.9051464879079683, 3.8981828609395297},
    {0.12424548258154113, -1.0861208936203728, -0.21376802669701758, -0.6355993752420301, -1.3770803206284687, 1.9655478067029208, -0.712793874219292, -0.39453308892407774, -0.9406211890720658, -0.17034635735483228, -0.7077919579944306, 1.2593094051488634, 3.2737500994920734, 0.9864348381410576, -1.0673756074163057, -0.029102070202199785, 0.18039657482319027, 1.1606518364699177, 0.39720121651495877, 0.9698260910890762, -1.9997854268836417, 2.1432209554592108, -2.1213018822245955, -2.6274693572474823, -2.669854146256514, 0.03447179089418368, -1.8614034812182394, 1.632736673847917, -0.12594369699458602, 2.1249599499155742, -3.5047960032261307, -1.1373915101124645},
    {0.13798153954761155, -1.3476144606449811, -0.9363176100647391, -0.4583901443944876, 1.7639746706580441, 3.5757485575292565, 0.77844746057693, -1.3538718945169523, 0.9188087913637003, 0.6195237151894996, 1.142338324097313, 0.05453885768907413, 0.7334531074704055, 1.7737439009483282, -0.49993833592406295, 0.9312403936835489, 1.4693999015322947, -0.8093237234292827, 0.375899840045153, 3.5335385222766185, 2.2211396441691336, 0.8676771671993645, 1.0208578698804611, 0.6315019065879612, -1.4255985314247945, 1.002549757762394, -1.3635985583287824, -0.35238548089359417, 2.448694222094421, 1.5441481547310563, -0.2447988914941673, 1.339297650667456},
    {0.28977651474748345, 0.28399524558550004, -2.0555521517671345, 0.30456447609408327, 3.046081677300265, 3.2860007300259326, -1.67960697488133, -0.150555453593261, 0.009641543495974429, 3.0006556066435524, -1.8032957704759631, 1.6239386369290427, 1.0959754376661581, 0.19697648471728102, 3.7745870842244202, 1.2253804642532418, -0.9199731013411535, -0.6612532854876813, 0.3456386302512591, 2.8568275078737733, -1.8949540588568214, -0.41253400897419434, -0.6332091089336267, -0.3019815549865711, 1.8954331816175851, -1.126285632292514, 2.358148217127814, -1.7183882768677166, 0.45744961945022117, 3.3392857141688763, -1.2355073109698733, -0.9858939805417122},
    {-1.0043757396608806, 0.06955099023295483, -1.359624813837625, -0.023953737781476712, 2.5023141413813996, 1.5746050313030868, -1.8866132858320206, -1.9287275129435284, -3.2310543963090597, 0.23934660811261177, -3.5723748752107403, -0.2640633952080128, 0.1879812844211766, 0.3341091321650966, 0.5947370002541651, -1.506857713382067, -0.6760933974357767, -1.1915241312041127, 0.8214684361762531, 2.3045608855162905, -1.616864091793857, -0.5400797263391445, 2.1302790556414797, 0.2165934143409783, 0.9917987666580786, -2.9920139828776997, 1.6660850336460282, -0.4917986974595855, 2.0245322593055004, -0.5904614140145307, -1.0503543881549755, -0.10198742632516755},
    {-0.2400085441796404, -1.5634030451215952, -3.84215119813767, -0.7370225524518126, -0.8379436822980508, 1.6593566639307227, -1.658614556013304, -4.598858251462239, -3.303271515417345, 0.24667835243478878, -2.176938318986714, -0.3611962366620434, 0.41377901304639464, 0.38727948844672905, 1.047751778918483, -1.5621860128113578, -1.6091403792789456, -3.653940593485704, 0.5935504469497347, 0.6474919149117012, -1.95277855769303, -1.3735331787044043, -1.7961861089093683, -3.7653425557052627, -1.3638627826559901, -3.001619770379546, -0.018251835737328075, -0.4877755393285912, -1.7521192254000792, -0.0204041368770971, 1.9909490305309785, -2.104450041618391},
    {-1.2095745642817444, -0.9173869491823395, 1.7675780940745371, 1.1792888476543328, 2.3140989819361573, 2.3635246493312785, 1.0037052701985092, 0.05321295321119935, -2.3191406483615853, 1.293985206030798, 0.37637360096492095, 1.6790186000891787, 2.5218626877439587, -0.725560302606144, -1.3323175356659747, 1.4614055299553548, 0.9107524993474249, 1.0372443072188553, -0.7591310500667933, 1.0237674984895662, 2.434292858528856, 1.1841421203560616, -0.6891276664554067, 0.588962389426928, -1.1716296765864194, -1.9014978547720036, -0.40805760970152083, -0.8112206743563555, 0.302499064087142, 0.3712845714976528, -2.1858928043976564, -0.9886040738662702},
    {0.0711863511212654, 1.6080733733876744, -2.402381938123874, 0.18091776127605547, 3.6764448140419677, 0.7403703649678118, -0.06266457989414612, 0.8528426544247074, -1.3153054914952627, -0.7540496764293892, -2.0502101359599965, 1.6665155915454584, 2.3837654097644703, -1.6509435245417965, 4.24083220453722, -1.947076550936605, 1.1144000079927763, -0.9531024190996658, 1.7623087601110985, 2.8979279502622877, -2.374415585820043, 0.7460159217137465, 1.192373866580166, -0.2664379970062936, -0.6483883864731282, -2.6144482432836234, 1.6110321769450606, 0.33994913602183807, -0.5104600468850993, 3.4742719763536662, 0.5164456020553876, 0.7268159022506891},
    {-3.1794307394171826, 1.1614883326389573, -1.063567083501644, 2.1704047710946814, 0.9198458186136556, 3.073214217545129, 3.7585453281027306, -2.005626391697086, -2.2549683492636596, 2.5831659114704353, -0.38265576948611335, 3.18755650376205, -1.378019595239524, -0.39584021697061944, 1.3994282123883646, -1.8096298633806698, -0.46069071889521046, -0.4549179917925817, 0.35530329069339334, 2.4002144711728928, -0.7740987632272274, 1.1767961186658475, 2.6999781399786995, 0.17044975294927855, 2.2102991280826143, -2.625957266716578, 0.13644258002555618, 1.9559830087305519, 2.2753177248995557, 2.1099584267245652, 1.5104728185495193, 2.297981173258114},
    {-1.8372839428484729, -2.6356783597479296, -3.1840632302594494, -0.05880406807350128, 1.2642574856533335, -0.6548817482298873, -1.456114285739919, -2.043230445107956, -0.38102201526267865, -3.7047001638752017, -3.703083017438796, 0.4831781307525038, 0.2775638327670449, -1.056672367866098, 1.2780816104583417, 1.2379262488128566, -0.1365536164866398, -2.8178840557858607, 0.2667418238436532, 0.9314381746659947, -4.021530569364063, 0.29910687160490407, -0.2317091731452009, -1.1063599421782597, -0.44261964793377306, -3.030030878152889, -3.5264661955530223, -0.8237901928844985, -2.506952235343015, -1.570439923255462, 0.7165792062760069, 1.0574864986890538},
    {-4.491134274166423, -2.0825504802322428, 1.7063905676258122, -0.5419920578010764, 3.0621641750442126, 2.52216612604397, -1.909482548000043, -1.2101112496249506, -1.770467557391521, -0.3350241760011545, -5.724965606639195, 1.2782305790088802, 1.6058672547397848, 0.760687570619471, 2.4872419338154343, 0.10808290717379054, -3.206114666850889, 0.37530905731164343, -0.06588805501024135, 1.1775218198676198, -3.922880995013072, -0.6390381832993453, -0.011406739028530734, -1.094629114333625, -3.7177264871151148, -0.9314021215809873, -1.4143517877462062, -1.9538210420374507, -2.474884644629342, 0.7754713250031346, 0.22323931483950157, 0.6849508436391911},
    {-1.5345113245920796, -0.6528606497141108, -1.4639653091707612, -1.3875706778637498, -0.4989407022591189, 2.2944659691602474, 1.2837643681844944, -1.4873858553733217, 0.585007966019478, -3.0285231185836525, -1.9707395484775196, -2.5194884768661403, 1.30680245442369, -1.3674360678426798, 0.3023612353724017, 0.5517225839111354, 0.5932959328930764, -0.17689256716112656, -1.4122569211389457, -0.7114948143142871, -5.383315879820845, 0.44778049986721624, -1.3550187337505366, 1.5204751196646833, -0.015107087157546183, -2.116376349454998, -1.994760876896105, -3.825924887479083, -0.6707844325676103, -3.887659166464856, -0.8199937140383885, 0.8074792862408142},
    {-1.0628685446584294, -1.1603609491500946, -0.5796451069606106, -0.9546510804897941, 1.1464192284179904, 1.272566716719435, 0.8233832673279862, -0.7869833220978858, 0.5573432377545072, -0.34131296401142763, 0.028456084939340463, -1.15800823109184, -1.3491627107041404, 3.078864882319683, 1.4254224995519564, 0.7699974295758102, -0.49751139935423244, -0.5611855930209317, -0.4297483583657372, -2.281591161368145, -3.742335899028428, -0.33951449637062997, -0.09175929572426672, -0.4856934809759902, 0.01951703206954082, 0.39459742194492337, -1.559111462386112, -0.3835050433504924, -0.5691584998318754, -1.5992652082417766, 0.8847249555546552, 0.6273884010401247},
    {-2.0289733564161634, -0.11667645641233607, 0.8590729312955446, 2.0969965023379067, 1.6601674489103224, 1.4939437570789418, -0.26623713474523963, -1.308207389947173, 0.1316297473393301, 0.7152337992596955, 0.3853013189428034, 1.0240055590548978, 1.4602816417993094, 0.4203169857986952, 1.8624357386041686, -0.27603181327290655, -0.8180345972717056, -1.4348613456794153, -1.1693204289045576, 0.6112818575244906, -2.944656139191726, -0.9125449278641867, -1.7048047611093768, 1.1949125383045505, 0.4516396981487392, -1.162712242112002, -0.906920016279972, -0.8132355283184847, -0.06927727112865237, -1.3257950645245875, 0.5255338841133909, -0.6632492540596538},
    {-1.1170109184754202, 2.1603319995219854, -1.090719077825258, 1.861857753568233, 1.8429834001697447, 1.9189065278267041, -0.20540169192663488, -2.3397200141483965, -0.8532314334171188, 0.26398432038499586, -4.605869717285524, -0.6768011509827531, -0.13187157831148977, 0.43361590011941553, 0.8866505613002714, -1.800327341112506, -0.11601956654486616, -1.6168389345664278, -0.18085690603250015, 2.045475418541985, -1.8692089878179146, 2.272781644839958, -3.222873816275036, -0.9770915069311642, -2.645899695363716, -0.7455601368204825, 1.2798864614768704, -1.022979081041297, -1.813131608312031, -0.5072770485196948, 1.3787900715027726, 2.222468184786467},
    {-1.577743188236715, -0.30765973849464656, -1.2303355973364636, -2.9302382990458433, -1.1091247377354538, -0.6934039986329558, -0.8306717791378544, -2.568361933545163, -0.08800714223659299, -0.13660336429656142, -0.9701279850941574, 0.7643180942435163, 0.26054764669948105, -1.3516003317517933, 0.3294524747607246, 0.06802960644292093, -1.9480901433708457, -1.0850340902294981, -0.8512331510156853, 0.6230369912621424, -3.0811953158113945, 0.8314159785203722, -0.6499674878741256, -0.7265415504332375, 0.9323864130494535, -0.18332388822594986, -1.7514274466226698, -1.0599493264402515, 0.2618710320131979, -1.4511646127970093, -2.750063913163671, -0.29487730464847006},
    {-1.9361617457807965, -1.244750505303088, 1.5000956592116652, -0.5531534519747621, 0.7866710999850084, -0.9470941559806624, 2.675076645349538, -0.24318746770954502, 0.9339646920791027, -1.092640682347802, -0.9945855830480608, 1.6162746385914912, -0.8067150984213567, 0.8954648397611902, -0.33610028905181605, 1.1972008633865454, 0.18680289830745528, 1.5100405738914724, -1.6755538724159849, 0.6911725284200316, -0.3657408319323744, 2.5415467802050515, -0.943295311169936, -0.46012336245018254, 0.4832956756633689, -0.6128274827002914, 0.4228263259087482, -0.871703404363015, -0.6859978183756836, -0.17436766963779077, 2.1971031434228694, -1.0282648174624118},
    {0.20157574395420635, -3.029269584546487, -2.85278949752531, -1.9103226859530336, 3.3981300354484767, 2.1116848557587384, -1.3708480915176546, 0.5272793704713369, -0.4977764849802699, -1.8737989458713658, -1.3457371069762463, -1.7668069594936828, 0.7108691471981153, 0.7027822604850513, -1.7345403835299993, -1.4327233421123775, -1.8497698873645847, -0.36593819537639183, 1.25121720926095, 1.3530927659547909, -2.854390646403978, -0.24366010421051468, 1.648602509399263, -0.829143879848064, -2.562727238828155, -1.1495956795024802, -0.7435266793859057, 2.5749852020726607, -1.3669154076564967, 0.37380482097165596, -1.64859519270151, -0.8913891538288897},
    {-3.1065631558942566, 0.20051606123113694, -0.9982323449025743, -2.677511504325123, -2.327889997205409, 0.14848933213682317, 1.567143928548753, 0.7512191937770875, 0.9314091116997042, -1.2263031860543803, -2.8369494311658343, 0.002273374329624988, 0.5919086581990444, -0.9402126906229523, -2.0407257826284697, -0.4440134509208161, -2.2595042705858983, -1.9356201109106335, -0.2335605886211862, -0.23034703486811348, -3.4532981115171775, 0.5675438069503563, -1.716094998791752, -0.5657059456370971, 1.147651445097996, -0.3821594477146319, -0.4979936329983453, -1.404771493213429, -0.4698280438671564, -2.4457877139908737, 0.7756118186175164, 0.6106016881953304},
    {0.6356273025011808, 0.4332834314446999, 0.4439424511701793, -1.746574640763349, -1.2301054286077153, -2.519238110622627, -1.7608855785593056, 1.9514926957765848, -1.4331554120711179, -1.7676096880729424, -0.9620419950526194, -1.8278425431434029, 0.6546189759634485, -2.2332325834216284, -2.1492467978436887, 1.0339512101391601, -2.2928084542416722, -0.24949320285293727, 0.966352099106028, -0.2720810162522645, -2.215019023422389, 1.2215176148599245, -0.25251997681619304, -3.551753956831426, -0.6250339032853929, -1.4782907200174278, 0.8550049383418766, -3.090090824519605, 0.04044688137839389, -1.9560656295557974, 1.2066590862659001, -0.9454464267496127},
    {0.986949276004915, -0.1111383921727072, -0.07534841801853018, -1.3698835437618109, 1.124604328038572, 0.3899310981478208, 3.3223524004096174, 0.40572586539765876, -1.1111062906073892, 0.10115377455201364, 0.7045252056025627, 0.26279508300168686, 1.1834958318483355, -0.3202515599800475, 2.0822501729945952, -0.9137669886476478, -0.5060035724530648, -1.8159603324326934, -3.6775279316385197, -1.6808227400033193, -0.4947149666374066, 0.47241116814722584, -0.7125745839506292, 1.0225162569040638, -0.3312018019702102, 0.3322160019319637, 1.735080248736537, 0.920261150537907, 1.111593766127904, -1.1041658178718623, 0.49663871371094626, 1.1398752593513988},
    {-0.6780367585680472, 0.6335329423144412, -2.5112235507253127, 2.176794398859959, 1.0916032887545657, -0.25356351037380137, 0.6125987500519986, -2.2195564642506485, -0.3135991912318471, 1.1138778474479016, 1.0780374745893762, 1.528797347925784, 0.8777182472465754, 0.848831133499999, 1.4771476147466283, -3.6055349926077667, -0.3061508139406082, 1.4350186665478066, -1.57591641798221, -0.24258745806318602, -1.1620903533197295, 0.8700381133224354, -0.07000994360643958, -1.3863504206451096, 0.8939409300078072, -0.7324236477868726, -1.0343794447481391, -0.27075799465925027, -1.9885361401967028, 2.2102696568357327, 2.4575478734332665, -1.7325079220525343},
    {0.7059478750474474, -0.42050649964631664, -1.5823721693591446, 0.0008185185536190643, -2.607078809850971, 1.8069977311238397, -0.9208084118778377, -1.7732966640101429, 1.0700235773817475, -2.4814367231820964, -1.3089701914856504, 0.7411995733199692, -1.5536938089092747, 1.9807193227958908, 1.3047425873180385, -0.8039054085790992, -1.190971689913327, -0.6607440109422219, 2.017852128708694, -1.0580056073297586, -2.666523898471449, 1.3574602753956013, -0.4843219080895539, 0.1203231391432194, -0.9667610947866688, 0.23097359545547164, 2.5617696806533874, -0.38965016333104546, -0.08463095402674214, -1.84515930815133, 1.1778239770146348, -0.3769679850827122},
    {-0.32347547801672, 2.171368131001207, 1.9187690211263482, -1.1382014655848027, 0.7389413776356364, 2.28839989644682, 1.0787412946366488, -0.4671902352730628, 1.6899588556472596, 2.2422237004106145, 1.2529841625350893, -0.4998053351333405, -0.7148286986327611, -1.1653436137495794, 0.09604947029136056, 1.7923949106418817, -0.043496224975165663, -1.916527918784996, -0.6662942024334861, -1.0493627304633593, 0.6537265854431856, -1.6576159496690528, 2.664657907440712, 1.1616278873055619, 1.0403436433891196, -0.015389088588180602, 0.8134930888216919, 0.712201755765815, 1.5992862300740158, -0.3964115147582787, 0.28515867552403873, -0.4564234731061012},
    {0.16313853542495876, 1.1368626217999904, -0.21510561260798527, 0.707276434526973, 1.7174116855676818, -0.5563547469897197, -0.6978408262989677, -0.8303229228787206, -1.9162797780800072, 0.8113029385993061, -0.45428463323969304, -3.2310707819454287, 0.2373732047625624, -1.0221697319004834, -2.8277337524457193, 2.0644229285915703, -1.0073188511262525, 1.150228762123264, -1.480476691105638, -0.16087143862485082, 0.5094449341451154, -1.0031012943472952, 0.8102054815626296, -0.373188541186993, 1.0559977269976757, 1.2231877246497618, -0.3454554086484852, 0.42478783402682774, 0.5755102779876001, -0.044387756751737784, -1.1655234081579757, 0.5329757275503231},
    {1.596047666734093, -2.792630933165681, 2.0538116939115465, -2.0116852990483265, -1.9673790505387632, -1.0105258302146212, 0.43928537087289743, 1.100020329445079, -0.07108383157507164, -1.2260508678278363, 0.7230208546384944, -1.230697049844947, -1.7872488423022372, -1.6409580563033515, -0.809223514059056, 1.8184974329379557, -0.4841764002148965, 2.6340552765288456, -2.3109016088631025, -0.9723523395939012, 0.1229396682312202, 0.39124122591553384, -0.20743805839286514, 4.130922787069526, -0.689278061114656, -1.4059766175518496, -2.263184404614474, -2.3603817178935187, 2.9254287908077243, 2.1147071501899077, 1.221532532686017, 0.0490147198622252},
    {2.8618719980532124, 1.2099911371229242, -0.1939401724815494, 0.42302477708616165, 2.608394554408434, -3.3380393069124374, 2.065932510513418, -1.780248508559167, 0.914763885348213, -2.0240543501172374, -0.5963745192296701, -0.19768945088826878, -0.1684220465943255, 0.3513933567360502, -2.83104309524228, 0.735052739209134, -0.782459420328284, -0.9484452920802587, -2.383766126721064, 0.726047117446191, -0.038158011031382486, -1.1914763328228688, -0.6891841391405744, 2.471356643358632, 0.004478907806543384, 1.8438289762195985, 0.979490225827171, -1.3286582091359154, -1.2068764044600546, 0.19630441496576462, -1.6950327209891896, -0.39982567276680436},
    {0.3897820619968471, 2.256353847198543, 0.7416581017101268, -1.5650214280932189, -1.559519135626388, 0.6570251650448548, 0.2185799337593822, 1.683240472423727, -1.7794253853581161, 2.007379140188472, -1.0497557066418, -1.5105067798042253, -0.8238296751040708, -0.5084675624446753, -0.7458299738017133, 2.3753858180671736, 0.18477717280087727, -1.254119213382799, 0.022922776480950143, 0.3192906104925042, -1.3271022310983684, 0.3010155285128133, 0.5189413714322828, -0.35223166865883343, 0.8264062899283234, 2.9971221757620623, 1.0087507965345273, 0.0926117033065667, -0.5907549329736571, -2.402412177217767, -1.851251347156543, 1.3626856916226997},
    {-2.3516256483985196, 2.430766376432436, 1.6561313380813965, -2.3944831763401084, -2.310973551823714, -0.23195727065107855, 0.08875501261529226, 0.9832070412830918, -0.11540730006193321, -1.3550203741606193, -0.6474664341337042, 1.1701878542672608, 0.823682453838119, 2.0391924484395165, -2.089582108709916, -0.19808498286947546, 2.235794952094814, 0.3780877349560012, 0.740217749537601, 0.17709164744009362, 1.3378965843015385, 0.5814009562018931, -2.4741791897118506, 0.23482080417930098, 1.3943010556592725, 0.20411003076035894, -1.3762888090544885, -1.6078806303876563, -1.1330191731683834, -2.2227705830340265, -1.5230912046374474, 0.9383094655503185},
    {-0.4275517439457278, 1.2828780049559818, 0.524922797217692, 0.9704489828135224, -0.1438590598789054, 0.5397143239935784, -1.7476596064550087, 2.631039465363172, 0.6085967197960085, 0.3242422174750674, 1.03885966467388, -1.7349001652188907, -0.6915957340727619, -1.134995690043348, -0.5773099120275463, -0.14571675663038283, -1.8256286731546696, 1.0820256616619435, -0.5724021878490735, -1.4600932916514002, 1.735933159698173, -0.48456830302808895, 0.06514900818011467, 2.041038837061564, -1.859096809192336, 0.8719763176179643, -0.8725545159074405, 0.21050714027749876, 1.6827289834159762, -0.29068670794788337, -1.3323501362903434, 0.9804152847145362},
    {2.0898593228302738, -0.6995445543644734, 2.1935881273166835, 0.5662591258656051, 0.23356574475577752, -5.154095874700845, -1.847287069713038, -0.6667699492842425, -0.2586634599049849, 3.105981010004238, -2.3543668091650214, -0.21302166790798044, -0.26823408048332437, 0.3155854606514505, 0.6540378471635515, -0.28554808476867904, -1.368598821796286, 0.23697020084235904, 0.5855241848276029, -0.17279912233244618, 1.3383910324889374, -3.3873286334389956, 1.0229355638992026, 0.7428817141899785, -0.1495696883557883, 1.612688667914128, -1.1567147145827454, 1.716912091868439, -0.956560043644982, 0.8648840702720877, 0.8280352119028115, 0.09745661999252161},
    {0.5713706905355198, 2.7290473045111754, -0.784830947039581, -2.499335937681647, -2.215712406797078, 1.5659230044851726, -2.5481637060052957, -0.5022450189149471, 0.3851264586355258, 0.8954680261817078, -0.14347192650309348, -0.9269998692935337, 0.4147817275457771, 1.9345490612067773, 0.22595494710265704, -0.7330204560408643, -0.4866728863214473, -3.11903285927485, -0.3052616230039195, -0.6934202518623431, -2.4161955473870584, -0.2681106568450281, -1.3846061457240784, 1.0345152447930783, 3.1683006444397046, 3.361806584495604, -1.8360458979988747, -0.9932944400889556, 0.7941642771328095, -0.568265402508531, 1.0270395149855989, -0.71077528112419},
    {1.2293611183640116, -2.074859687893711, 2.42531376608208, 1.3375087367837981, 1.5466372013204752, -3.437063794992536, -0.5479841203938794, -1.2248078180037574, 1.617313980094247, 1.0341600367927375, -3.1192660332995947, 2.458063249240008, 0.04057509268107245, -2.107339269984479, 0.1896434246741429, 0.07193774042405741, 2.0653204191334242, 1.2103695019317835, 0.4178614668272051, 1.2074198826576314, 2.762423905001639, -0.20637365114873818, 0.20641539605317352, -0.9872399015511767, 4.395623225612463, 0.4475548964237288, 1.266899365954206, 0.21450109165089204, -2.266783478598085, 0.4799551687148942, 0.677796653547323, 0.7731637140838121},
    {-1.6105769872270574, -0.3251179938911236, 2.2272495743677396, -0.8549246846948285, -1.9091652926473344, -0.40333710661951383, -0.4114890237515341, -1.7146300283414364, 2.0980430889035313, -0.4492357935642432, -0.22094337305429973, -0.694321157759344, -2.4052981006073417, -0.9779818420138293, 0.5486181606726093, -0.7485496001738332, -1.167350324621755, 3.6410192072378766, -0.07888197128582311, -1.3800602904001815, -0.11267062122205117, 1.761686212712713, -1.1675967831410483, 0.27455062540333053, 1.9168693528801404, 0.12375487281065203, -0.015575659469581452, -0.2632883176146725, 0.5137558918726483, 2.018921457899924, -0.8423790964421024, -0.8485618726465879},
    {-0.45737410675329726, -0.6835911099746628, -0.6584824247157764, -0.5596614701115714, 0.8059320067724653, -0.8231878813655735, -0.9291166005274094, 1.1545150664908042, 0.27900008607372345, -1.3217263068919713, 0.7729965351023759, 1.7213955605239244, -0.5003041749003961, 2.406396821337656, 0.5293435178466263, -1.8301671184689345, 2.5092653483663674, 0.4558400183920149, -0.24808098628559322, 1.1884699430456889, 1.4251742993219698, 0.25614832839672025, 1.8068263439787449, -0.09874000864802344, 0.9281163916004967, -0.8766152419493907, -0.32017339718698373, -2.1114425942300796, -0.7263255058904747, -0.7329501119722636, 2.40211166798139, 0.9377017097512774},
    {-1.4637670170937698, -3.081935069614325, 1.2646398401365584, 2.1090155416960004, -0.5825698286887171, -0.8430901715126407, 0.17707638343846877, -0.559341887146242, -1.2420470986608365, 0.8571003910592426, -0.7991429743849918, -2.2125989651256965, 0.045137188829898034, 1.8146691010381006, -1.227754570748886, -0.623429241323542, 1.2397857996706454, 0.6238999376658401, -0.6767557497072836, -0.7744227567370293, 1.0244377275892251, 2.022472984454671, -0.43316242332739757, 0.9942040276747037, 0.47633239043209874, 0.6847548924172538, -1.707706084639535, -1.8540948197625182, 0.21606135254953837, 0.6514369136236566, -0.8817779175934347, 1.3774961014999274},
    {1.0130948682834195, 1.579107073099075, -2.5061551999955927, -1.0305185262863574, -1.0160928714300894, -1.592098280896236, -0.7612404719313763, 0.3859046337064478, 1.1938756170893254, 1.8438879094524752, -2.026567883572067, -0.23923410028103093, -1.904235258811496, -1.168839131186586, -0.9817883557665077, -1.8188098315125307, 1.1682032963752602, -1.287616836368169, -1.0197361260706763, 0.23749754907802686, -2.6713549021421032, -1.22256993738764, 0.40659910223727164, -1.1191064845795486, 0.8037206033962703, -0.1944615976698787, 0.5787366866698166, -1.3127780233410533, 0.5245728724146161, 1.8259870278039483, 0.8638609020592412, -3.3150182845816603},
    {1.109861115027357, -2.0031790437096535, -3.780719118753886, -1.4625263804167317, 0.9848476586841933, -0.2030853042730622, 0.6371910770256412, 0.42640587044543793, 2.2209289515628123, -0.9781718187407831, -0.8995070629791726, 1.065502275642434, -2.6719305465878933, -0.5194752686889389, 3.071904706374059, 1.7599086819732255, 2.1117463807358674, 0.7632402832743973, 0.6617507809863339, 0.43483908965255014, -0.005737919802263586, -0.7334482318827144, 0.07619747392365019, -0.7238888742272558, 0.6344357347454155, -0.3275913527375654, 3.9559462790152193, -0.33988341795408217, 0.04333214559591429, 4.203158801069213, -0.04127023755794738, 0.32448589614688733},
    {-0.5099303400638515, 0.7128086140448082, -1.0475522658506995, -0.24799731922769583, 1.216871256088864, -1.4015250794771272, -0.19239209026563067, 0.7687687700846513, -1.8827874852824225, -1.830401336985975, 1.2718190931258475, 0.5501807626452987, 0.29941088564660984, 1.0238330845750334, 1.1494888265386989, 0.36456444174866764, 0.10861624910387653, 1.105151068930089, -2.0583306009276274, 0.4266820839093638, 0.4087385677517478, 3.4368660213912037, -0.022454671929744582, -0.4898976832223416, 0.39404512873353076, 2.6092349094568994, 0.6852828955103949, -0.44768416866452204, -0.2277404670625112, 0.06943760672575124, -1.3594228397962749, -0.7076795790319097},
    {0.5160359561050688, 0.5268387742015044, -1.725919402411242, 1.4638663260960345, 1.1209665531058453, -1.1862671605101582, -0.10434850946817248, -0.3534947040564845, -0.6330865193843901, -1.4708612930289175, -1.2571626495814028, -0.24674615158594618, 0.5872457220023661, -0.4813386736234481, -0.014484375519859052, 1.4788631473330744, -3.0379520695943607, -0.005243585593873594, -2.2199714305869325, -1.637120286577341, 0.7051359236069925, -0.4681299427699237, -0.840539835566704, -1.6934125352910976, -0.9463609804258912, -2.106988119506199, -2.9683423959336537, 0.9985670763208724, 1.104596708451403, 1.4697445292781148, -1.4076084797759991, -2.7757424496415584},
    {1.603548814775169, -1.6651070702638557, -1.899575442909958, -1.174019347326023, 0.4230384073591005, -1.119113516634221, -2.0848618405084625, -0.634108626842769, 0.4287603842852953, 1.6438852551700422, 0.11255585130116008, 0.01575620533247867, -2.889445707809677, -1.6934890095014383, -0.3486947645603414, 2.1437004229006944, -1.205703239389211, 0.7833998340111002, 2.1126478304088705, -0.20559796684324744, 2.1386383787932983, -0.5631142982768507, 0.6771288849856094, 0.9214628753410412, -1.2709026200325222, 0.7213765334167007, -3.204734123278427, 2.6621951169818767, 1.5469132851518614, 0.5064600330226668, -2.5988946533899404, 1.0184542708128472},
    {2.204915802355232, -1.1651185268295254, 0.33361758211743725, -0.4797819696415899, -0.7420686285201963, -1.306360813631259, 0.16690772929660716, 0.600173265156534, 0.8857825979272518, 1.2880848571537407, 0.4137315557498307, 2.4315912218048563, 0.8085988913922986, -0.9503601278803138, 1.9890389287755361, -0.5789472651000966, 1.6861888015556021, -1.230208471483071, -0.4361335159732417, -0.74324861613834, 1.6024980185727093, 0.17656852117018557, -0.6305771546632527, 1.89484187581209, -2.7951748739841595, 0.3610607050175156, -0.0067949131161875505, 0.6135174920771788, 0.600721460378484, 1.0283999600477685, 2.4881734640824766, -0.7635085462224188},
    {-1.670551163707679, -0.41175424330274396, 0.07013532033771055, 1.3494384078612183, -2.016661481476667, 1.7749607397464833, 2.649434175929746, -0.7177145902317011, 1.0673709007850847, -0.06985637678343957, 1.7755449674046, 0.9155575871647654, 0.4892690131516567, -0.19734759561942622, 0.5284539478188678, -0.4540987733745866, 2.2431379442031747, 0.16358490199978695, 1.3608861224945072, -0.838151788203605, 1.810059626707835, 0.44733266015219475, 0.32178330691967943, -1.516857151822186, -0.13932512384161924, -1.2628873387303827, 1.7285163364831104, 0.3504950945050301, -1.324559918928176, -0.6931255944874617, 1.6253749880663373, 0.2993836665086531},
    {-0.2401590622699297, -0.08765633906239374, 1.1034161586151456, -0.34928688097398225, -2.656788647737963, -0.09667053047922061, 0.2316122303914395, -0.5285938452542803, -0.6075730278365317, 0.46697964710122597, 0.2441982604692959, -1.2691440005192067, 2.4400312736019885, 2.5862384764848727, 0.37776456753690124, -1.1590977493792498, -0.1137242397886458, -0.21636289831995087, 0.10686475846055925, 2.187442834693542, 2.8412836974530102, 0.13308233997776583, 1.1549825698726441, 0.26061089156280753, 0.8794585131202824, -0.5122836887228747, 0.18350116631670071, -1.9434854797922083, -0.6342188442468704, 0.11603545724071365, 0.9948377316021174, -0.6904224845688286},
    {-0.4731592460396038, -1.1647789020557966, -0.03639083326615223, -0.899183806521263, -2.185717511465842, -0.4977484827519539, 0.5559752557719393, -0.6168442334097616, 2.4010160901878685, 0.5100114547956155, -0.8068761715671864, 2.128051540981596, 0.4076808177007741, 0.5155093974698295, 0.4601903258592481, -1.448704252935695, -0.753141900488136, 0.5627722917721616, 1.3123338061754544, 1.2167475314176621, 1.068383665432712, -0.1116818470185636, -0.24799821947689685, -1.15568372547299, 1.738579721103462, 1.5407948020237925, 1.9971466172435879, 1.5898709370323298, 1.2304650311045904, 0.24485410999016663, -0.35591250931169066, -1.4986794987835128},
    {-0.32988771515902193, 2.9257477510790397, 2.657424319837213, 1.806288626030493, 0.1896879885130223, 1.0938447377768332, -1.2360239565676014, 0.35209016959956496, 1.7216021489435245, -0.8043535629268239, -1.2394566719078906, -0.8688025672003694, -2.219558937881913, 3.577588905464161, -1.1494987395652128, -1.524595112611137, 0.4960916843766011, 0.12781010695723663, 0.6740728860815683, -0.7163670044497659, 0.39654647808953086, -1.5413385129996167, 0.43095942850816815, 1.5784726543972636, 2.8109374086171384, -0.782959080089392, 1.139130917684544, 3.8318315996633974, -0.7237818977513546, -0.8727089507478455, -1.4479776158155417, 1.4767056054276597},
    {-0.25910696352691986, -1.7560975984365397, -2.1943228517676716, -1.8746448053598432, 1.5484652132567724, -0.6201728215777011, -3.0703166859345834, -1.8733897519415732, -1.3898029928587365, -1.1955391924813141, 0.4161345561290629, -1.2561953594661859, -2.7295898967285708, -1.8320711781853656, -1.629831712687379, -1.286948914272076, -0.9897282877077812, -1.5002743395742144, -0.5619367409618634, 2.777854471249625, -1.2705431257840722, -1.1948099818510083, 3.101178135643318, -0.341562738963408, 2.581406335255146, 1.0782014286797739, -0.8358527596498433, -1.9635610543511441, 2.79536223262757, -0.9596976343801754, 0.6256195903483422, 1.040347366034204},
    {-1.9443425453689442, -0.07309889648659255, 0.6076712583057341, -1.2002990027933254, -2.9286719770913514, -0.6472483084586317, -0.7875449707838873, -0.8077914298467399, -2.7146794515775965, 0.0729998568817321, -0.7790911809659397, -0.3444218501871931, 1.0983698863176465, 0.08857860683860154, -2.0842731994988855, -0.1657953253201071, -1.4397586868442012, -1.2611675540559417, -1.2227015955865654, 1.2066151906533051, 0.1676475133405233, 0.8516866440032739, 0.02826445118393436, -1.302633173467364, 0.668004845745437, -1.0322095113982381, -3.6630391696477815, -0.7214707110805885, -0.6574615530448948, -0.923304874425229, -0.16397215914350466, -1.0998206949718503},
    {-1.3905064703242789, -0.05191120750458035, 1.149422384686654, 1.6598952127973843, -0.6893320165086165, 2.980287658522148, 0.589870727702863, 1.669643094497458, 0.16127424566391835, -0.9775773492879524, 0.9911742794964642, 0.030310825226629298, 3.138342974072932, 0.7526128175741164, 0.7655442454846616, 1.8730657541786566, 0.0910542544002101, -2.065806232172087, 1.2403883172154913, -3.634447520701295, -0.3806162198168927, -0.664255217230774, 0.0016282227633451546, -4.326284222418178, 1.3415302106165319, -0.2065035906225421, -0.45516291921603835, -1.0707695454870092, -1.9298012395224902, 0.8532005947389196, 1.604624141027711, 0.9767698067464208},
    {-3.003504802984406, -0.742798305151139, 0.37454106850438185, 1.7205947480600725, 1.39809360546049, 2.6179886315279983, 3.1636064240802564, 0.2714640298353256, 1.6567160612563336, 1.8815926162026764, -0.4386793569677023, 0.008766627184809686, 0.04119678400942556, -1.8711762793762863, -0.28700132916207327, -0.5826025194585769, -1.8737681819363696, 0.9021088179536417, 1.138021660558706, 0.9362028644434479, 1.2197394713424816, -1.8920886821760032, -2.4849170562884515, -0.5919713486050928, 1.7668692663584435, -0.2587649422934868, -4.976944180539536, 0.32336520140706715, -0.5222530436399708, -2.1905530155800492, -1.2201539885425199, 0.09086021660280827},
    {1.5608094508373107, -0.6171436402079019, -0.8940163367121353, -1.267923735188101, 0.817298197352157, 0.11901995190587558, -0.6591797902030863, -0.928804471526557, 0.6493801993193761, 0.7455309872916248, -0.5423150796518673, -0.5272875332232445, -1.0706821225791372, -1.2549599924862533, -2.62230496547524, -0.22175294376301724, 0.400514424926514, 1.5185326010779023, 1.5262337599798028, -0.7253637820061883, 1.1228445035423966, 1.414413703803908, -1.135855800182811, 1.1550059505390282, 1.2714374049059023, 0.6535391457624957, -1.744049042449687, -0.9042012494238835, 0.11954171820701974, 0.39213298264256147, -0.37670285278299154, 1.653068570420654},
    {-1.245149646713871, 2.150969310760413, 0.2914355379448287, -2.5791844314725356, -0.8983365063286868, 0.8232575314735353, -2.3688732696995705, -1.3741441820960032, -1.2753124551105688, 0.7668506910663467, -0.4725283802966216, -1.0465767209809593, -1.5264318372100678, 0.5519726621828686, -0.6335256023522705, -0.7681749494972677, -0.03789587947174735, 0.887880225486891, 2.5331470130907934, 1.3280896603689512, -3.7687911105577956, 1.1581300502057998, 0.48441995933340326, 1.0935488741254518, -1.364157268610884, 0.6715619192323249, -1.9278251114354752, 0.30706334258069473, -1.320746229219334, 0.2247631107626999, 0.26456267355729013, -1.4380307508432053},
    {0.9329109555758632, -1.3042170322687383, 1.7594874321529634, -0.7810106516069754, -0.9853486372377313, -0.33547746634704007, -1.0327088131032311, -1.0083941370701222, 0.21028316617253134, -0.5412316342897776, -0.7124283454956727, 1.18665089155144, -2.9142058073539725, 0.39702275574911, 3.0188676679819126, 1.2920569962398862, 3.499346608456474, -0.9518242407808497, -1.7426270993707726, 1.42590086542615, 0.9252934891131881, -1.6722017062753471, 1.2039647898299273, -2.1540970720252552, -1.1369191948663624, 2.6031973105968125, 1.0994772829884103, -1.9476064551542767, -1.093612337197005, 1.7163501865377182, 2.4971182148075717, -0.7258904928018386},
    {-1.593335992585561, -0.1186980431917784, 0.8420413977610215, 0.1657100419105061, -2.0026807888504705, -0.9025103204115136, -0.8368308910467775, -0.01371937853382992, -0.12358680294956058, 1.8734753459644007, -0.6112756459680825, -0.4572386840987289, 1.5630396056984381, 0.5188663607857157, 0.32836312739917317, 0.3938446465666984, -2.670357821240833, 2.6946059495798256, 0.13530454141705578, 1.3361995533103954, 1.3215564390706795, -0.3282206130927802, -0.44047877850900674, 0.29138502553245793, -1.1376468767403582, 0.8773902430141368, 1.8982746595639979, -1.0441112877732615, -0.09991193559546876, 1.0798404640617432, -0.597792641781727, 2.232640896287199},
    {1.3493736640150895, 1.3635823481734488, -0.12228917165835138, 0.9393905012448055, -2.3533635941520656, -1.3916901341949308, -1.044470839153278, -0.8093213769047145, -1.8137380846345272, 1.5657548493007347, -0.6665062506688009, -0.06557737430424242, -0.3966979828578748, -0.6424673134872547, -1.4213506065651766, -1.4193750002765526, 0.5450437838098932, -0.27335700488814957, -0.8268361044039526, 1.153818318991189, 1.9759337790748481, -0.4794365690751709, 0.16773838605781566, 0.7257035877200636, -1.5129990118676309, 2.48441654524856, 0.7050789250980727, -1.7015066221093722, 0.6977091560199855, -0.2769348404000778, -3.252539005384608, -0.22435043654116388},
    {1.0879912769902744, 0.5029702635763372, 1.9197904838957802, 0.09234255724034926, 0.17371313907779573, -0.5311794835619473, -3.0237109989605675, -0.0448036546188203, -1.6534963113868626, 0.7468566101139635, 3.2313339174245934, 0.5878833098716488, -0.6510249221766856, 1.5047117186965948, -1.5286220825775423, 0.1849087770805176, 2.0333421368007496, -0.9182349443421847, -1.2326162361474133, 1.1574914000302048, 0.363186304077042, -0.010384526235168381, 1.0653956944710472, 1.4874581596361636, -0.824576786599115, 1.423498175802827, -3.93216105308295, 0.7216991877941639, -0.7808506840754779, -1.897666069494566, -1.4953202034790325, 1.653772053597932},
    {-0.48934827349820165, -0.13507301793629287, -0.0788733073681297, -0.5621394261771838, -0.2516893214047062, -2.339963908025443, -0.4708975782073776, 0.8751304324412575, 0.22280023479460329, -3.704741576389096, -1.2853516244865677, 2.4403024921404914, 0.5070566591044616, -2.5312163236221807, 1.8789802278675984, -1.9987815363230341, -0.36427704472229977, 1.3475979258956783, 1.378238299613702, 0.7060048981955718, 0.1161884155370002, -0.09694372475610559, -0.7126045734137711, -0.3049869456869038, 0.4468319383744942, -1.766484008869565, 0.749303897135435, -0.7389797293423013, -0.20782215556649397, 1.6901147523437277, -2.7097889532259796, 1.1034073345557445},
    {0.9167444627748634, 0.38880307377383616, -0.5970844629577157, 0.8989450198457586, 0.11509124432584153, 0.10161510874721881, 3.6439069043502696, 1.4137181395062635, 3.8261120996425078, 1.0898153323266648, -0.4796754450148908, 0.698717710969349, -1.8575474076343184, 0.9127048640065689, 0.0764944304797813, -0.38479408470156645, -0.5587393885021537, 0.23923276921362682, -1.3432446404429164, -0.8734339686361465, -1.4040993083963935, 1.8036088891837279, 0.7004121018582221, -0.37515112406341106, -1.1014522719220925, -0.038285628799634236, 1.8869851861613296, 1.0418505723266036, 3.2379090825119397, -1.0537133850171436, 0.04526553359864243, -0.7337059625726936},
    {0.6371588079044993, -0.02546648050943811, -0.3518178022270612, 1.9101297533475012, -1.166343914291596, 0.7176118743662462, -0.17853043770064786, 2.020443340588883, -1.0652422041786422, 0.8271852829047946, -1.2652278865369844, -0.4851143629410492, -0.3007981239178507, -0.2626677159333621, 1.5095901232183735, -1.1781897427641417, 0.2709045964406898, 3.8405338161958125, -1.5856197899504945, -2.54081890599365, 1.595271275526159, -0.4704492931229814, 2.4858675653417928, -0.728431499608852, -0.7219981090470101, 2.820803104993064, -0.3039520352817711, -0.0006260766764451704, -2.0134156808695405, -1.2177334403171463, 1.531943014405909, -1.9564356199158186},
    {0.9836147407546519, -0.453899371028418, -0.30802446821771856, 0.6133123098932167, -1.9148775376281113, -1.7283421577509142, 0.33177665557423963, -0.2025834451539884, -1.5702643478726594, -2.579994277964636, -0.10125982532224578, -0.26024233237263783, -0.16580823921305046, 2.516299465750003, 0.11719717472457818, 0.7899964966300838, 0.8399794808139004, 1.4347772222576367, -0.09009010363697956, -1.4078589596779423, 0.5728098075227548, 0.16331029451891038, 0.4528228711147167, 0.8265402367572046, -0.025901758564614435, 1.8673887659206845, 1.4910974338842313, -0.4919032711565398, -1.4329301101674925, -2.330425961324204, 0.16373930172895565, -0.7457863662487478},
    {0.20351455938757473, -0.6365020408701276, -0.6854347953873144, 2.138215172929301, -0.40958856828517803, -1.1546682521632694, 0.3471002580803074, 1.5531231921701483, -0.37339033739396205, 1.1050551124498988, -1.591833954565657, -0.5151996619599468, 2.260128005837101, -0.5255355722683843, -0.26721816610518917, 0.011739486798917322, -0.24391979650078002, -1.9461303801930772, 0.43215435845880373, 0.19899174366638508, 0.35260071263849185, -2.198051164065239, -1.934945680524341, -1.0365626966994088, 0.9480044120126605, -0.7882517051589791, 1.2286318569643508, 0.11777542706720899, 2.794289292062627, -0.4749225117252224, 2.758234659381545, 1.4712117601054955},
    {-2.8728430783727026, -1.3474784090096052, 1.0384007296390576, -0.21990280595227882, 0.6241163159002313, -1.031917683283713, -0.789804984863826, -2.097586181319891, -1.6150907290107284, -0.2262999907976119, -1.244967297997056, 0.820821509745456, -0.23314125138070363, -0.8967592217152414, -0.11073045860925657, -0.7355032899897047, -2.3423316954488227, -1.0737760022964842, 1.7673956842393939, -0.5377692489745014, -1.3057655268252173, -0.6732620975279018, 0.2023773274106594, -0.5900924180265221, 2.477599629053519, 0.0196220544353593, -0.02802790251570469, 2.1336010400638625, 0.09850365362212565, -0.6138010688048179, 0.7831761492337583, 0.03016584114882605},
    {0.24320469827133281, -1.4609478671849094, 0.5510920418478471, 1.2181101141445336, 1.2666243470166074, -0.3210560978968043, -1.0290244730481832, 1.7495369538826944, -1.4396414832787334, -1.025420831830162, 1.3569649037124945, 0.2665830501667741, -0.3143132814570468, 1.5242776669303688, -0.1574718979739186, -2.4914911906500072, -0.17640514155894543, -0.9958217842873931, -0.48603348767816623, -2.655344442796454, -1.430565789103189, 1.0273856710527658, -1.1589467672752733, -0.9674798954965359, -1.0612682074289141, -1.1000025472820256, -2.8578918875280617, -1.8235996966541588, -0.6010675607579145, 0.8455584880986353, -1.0340459232979022, -0.44308847236256493},
    {-1.0324753542887977, -1.4974494264933187, 1.558890322378718, 1.2723447484451758, 1.0451701463971468, -2.9353045254964525, 0.822761438897322, 0.39216381696899993, 1.5599386647203466, -0.38548582495883976, -2.206321544519816, 2.423576734144215, 0.3484002601435213, -0.3836232631397955, 1.2237384779804241, -1.610835016386429, -2.0673261881721716, 1.5223833094166186, 1.0404803779951124, -0.410319118203826, -2.3115963194626996, -0.5020971663763889, -2.5627250008621987, -0.2687024765550584, 1.1231134042016493, 0.07559805652790935, 3.164867142322052, -0.09715122106344566, -1.0394797488513687, -2.0585031907929148, -1.9649561153743593, 3.7677611862318057},
    {-1.8242083340683208, 0.48104262873494313, 0.18603836563749318, -0.5244663306782676, 1.2319502815936259, 3.8940363697131413, 1.595374631121364, -0.24814106886656562, -1.094914663136437, 0.677245198639279, -0.15829019643156025, 1.2275319983323592, 1.3491389612523537, -4.144700000345035, 0.2058706401978071, -0.63335156667917, -3.0143599801681176, -0.10937564435561156, 0.21789918502763297, -2.070057320384525, -3.299325308462113, -0.5017532773339914, -0.13747622126267955, -0.6642756515432303, -2.861005204058955, 1.3367489459174233, 0.30367283816814505, -3.725834050094645, -2.2027232724785692, -2.039511749681406, 1.5213926838635603, 1.0095347758986961},
    {0.39281548125178345, -1.5800824025014522, 2.575656329362855, -0.08533969983459884, 0.30545080396778396, 1.2916764976850175, -1.3972876458214158, 0.6498522023628137, -0.30949034702501305, 0.6540545956334836, -0.3848022671924238, 1.7324750092516255, 0.7170039394743074, 1.9902641478355894, 0.5110084184184048, 0.7301217160960841, -0.9341258203501044, -0.24597540209488072, 0.1607821181476703, -1.147680822963305, -0.8849776725708124, -1.1798858019033378, -0.8950109671048971, -0.46992065133719046, -1.6397754463195728, 0.07908242365244092, 0.7034600421988461, -1.3686268154335661, 0.5901206624705565, 0.3087289135458955, 0.23109881255316142, -1.3314465702159202},
    {0.1596481492266407, -0.9760184964930557, 1.8338318762262356, 1.4701393661040907, 2.4549520988006903, 0.626170167900534, 2.0519601941458774, -0.4961562378668966, 0.8583358779169123, -1.0602719112097327, -0.7773279601436985, 2.382395670604396, 1.482973581208046, -1.9408798474535964, 0.5064304935948448, 1.5347193128695942, 1.3729689156521858, 0.03343598361367389, -1.2150930944713854, -1.3006743522668653, 1.5974560301935017, 0.4291247697395337, -1.4872194049912992, -0.08984197920374616, -1.5018969118638879, 1.489796090964141, -2.0050212582593354, -2.235567268689538, 2.4160365768105967, -1.9950314647489744, 1.7755508612537498, -0.45793021433716685},
    {1.2119799448679045, -0.9935726478794468, -1.2230151165966394, -2.3672847068719434, -0.9423977608445733, 2.2408409629873303, -2.0135031190060713, 0.2813944206441388, -1.0365876976782362, -1.6651473093759348, 1.7961595128417907, 0.9624074221269175, 0.9101126173484159, -0.23047336852636724, -1.6493352599234485, -1.9162570492807551, -2.469090543189584, -1.4048136937037001, -0.42441167816129843, -0.36414347677884307, -0.34561745708173847, -1.3282511066691307, 0.7531665627979389, -0.5052667063509121, 0.677516406726762, 0.5657022352175077, -2.4610943956953877, -0.1999272448470316, -1.1076295687884306, -4.301862991680586, -2.271656072679597, -0.6959383776042404},
    {-0.5089410397507023, -1.0836800968953861, 0.6848785149862576, -1.4680854799829974, -0.09377659823291565, -1.0686611898364746, -2.0121410596024814, -0.5646938357503989, -0.08320950447642972, -1.8541253528262323, 1.2634524529254252, -0.7693321593791478, -1.2115998209623742, 1.4676337897503904, -0.1102002424518964, -2.2583655314658646, 1.646068380843427, 0.22790885846546446, 0.2672251730096938, -0.42463175359040367, -1.585366258534667, 1.0458452179284894, 0.23522304951829973, -1.6477835341161942, -1.4191692418647868, -0.5970090766633439, 1.664116598449483, 1.8914085367757165, -0.5123273367604245, 0.26448916083530516, -0.8221876713603052, -2.171275372540286},
    {-4.1875256859625285, -4.609691735054376, -2.037772587404757, -1.2010983621441294, 2.2533295912660805, 2.2038456763798133, -0.7253592402760543, 0.7561686364982265, -0.35858545859675706, -2.5259788445073816, -2.847201767971539, -1.5813301984877104, -1.1899751224447463, 2.126936363528236, 2.6508294202876668, 0.5282618141088653, -0.46669591152930223, -0.2780351212055566, -2.0147918077379807, 0.15255875335977573, -4.318981079851097, -0.8300022347700033, 0.8273965830208952, 1.2065243343705676, -0.4537277485068946, -3.2253822594758925, -1.3064204932972998, 0.41191464631897035, -2.784972674992717, -0.835823739854293, 0.5687446023754748, 0.5436079273246945},
    {-2.0488202545201633, -2.4705868000750524, 1.106212568226107, 0.27949366153762933, 1.658941655741748, 0.45335527794459424, -2.4105157130489845, -2.2663275347009852, -1.7893246486440568, -0.8062682234873199, -4.366829876476548, -0.4830770833355872, -1.0690496453710223, 0.8479408289211613, 2.0590953010481092, 1.1548163884243041, -3.3364726473338346, 0.40032033245978177, -0.7890179902667168, 0.06675144743640155, -1.1920657137196107, -2.156576563100492, 0.9733178777326678, -1.575607597612078, -2.2260292777653445, -1.6618652320886844, -1.9794511115703035, -1.678602156503652, -5.271247435340323, 1.585446182859535, 0.6359551701251708, 1.5333591383237728},
    {-1.5509665783548967, -0.4971647116865397, -1.075159511146503, -0.911749244023285, -1.052107341195383, 2.104497161409475, 0.12303249094508462, -1.4037248199227093, -0.09058502085693382, -0.8072818370729077, -2.1323104684845737, -4.319396519476551, 2.9458045431204054, -0.017258620676215967, 1.9195469541433396, 2.050030387019663, 0.08675726366449912, -2.5148783111185953, -1.4932874575375528, 1.282423220302516, -2.1535719840847394, -0.7896587420716061, -0.4696887193460585, 0.11875576529389711, 0.9620135365650839, -2.7170650159224663, -3.0055916324535663, -0.5968701384148276, -0.1122393971149111, -2.8954604355355573, -1.037414189023093, 2.8547643812149808},
    {0.5114794465908943, -0.020825019608856358, -1.0665616363767045, -1.9905392745419597, 1.3171997055121636, 1.220580601358895, -0.25559102899798497, 0.6012693972890031, 0.7940710696440648, 0.21359260877877106, -1.7915026277630288, -3.376314814285638, -0.5704021851269127, 0.6417514534632469, -0.8276389540678862, 1.1266910281284226, 0.37045393706827906, -3.396380211415003, 0.14701178608558876, -0.5786832557980428, -2.4684644443514365, 1.8388415155258753, 1.764161153515991, 1.750882022715493, -0.48309841800832437, -1.0914610252269363, -0.5706290074171658, -3.2372367431172613, -0.8095014337193241, -1.6696138381778434, -2.2366948408348173, 1.020299638146377},
    {-0.898656162961472, -0.9813720567400843, 0.8684183404812573, -0.3973370558829115, 1.0440570800549707, -0.3973171273033787, 0.7328645494124192, -0.9410394342535255, 0.16558388388752543, 0.7014228365160428, -0.605522027367503, 0.438227512934914, 1.7512491433189958, 0.7020341660445979, 1.1000058191726712, -0.4838979766490813, 2.3603891517115376, -1.6297263546192065, 0.771222057119151, 1.5851816227995157, -2.2797753121809246, -0.3074254552790166, 1.2952830400858335, 0.6387826245810074, -0.009737147358651938, -0.6623949811876764, 0.028316620284680353, 1.5356252684901566, -0.1505552405288564, -1.1687680645347103, -1.0947217164016925, 1.28599246676875},
    {-0.9741574887540437, -0.5050941329888351, -2.276254261234765, -0.580968889701791, 2.069346470092368, -0.04306128899301784, 0.6013593341107433, -0.09100330118901108, -2.6537568077812534, -2.630456623214821, -0.7934656940338382, 1.8520812909226634, -2.26311626713063, 0.7883066601632378, -0.8367182812891281, -2.8572288730014197, -0.7200182951635447, -1.6494717995419403, 0.40785617907528754, -0.15159840459720736, -0.8222612773295187, -1.4217759873870843, -2.0491843630629685, -0.10898894051233465, -0.13190866732705334, 0.22962442523220253, 0.25626664076761696, -0.6043313712823815, -4.081339121658721, 1.1026924196235124, 1.452643367504374, 0.902862191360322},
    {-2.71502524997943, 0.13412447139872058, -0.7091333796873528, -0.6119127275279667, 0.28184605204111685, -0.3763081067585089, -0.4609294536306536, -0.24344080576736973, 0.17775395750753648, -1.4313975497529496, 0.09180184012631305, 0.6067743392748276, 0.43470959126779807, -0.7833438392357028, 0.6227181964583804, -2.0723716961162606, -2.7915411027576766, -0.20783908227076234, -1.3279218703446374, 2.0787677649881715, -1.9418915088179358, 0.9182839787811647, -0.691190624103317, 1.0112416492893352, -0.6465517891163832, -0.41899310932649797, -0.002209499254380702, -1.023312703317575, -0.7312427858023824, -1.2766978788809353, -1.8643522521634937, -1.746213529317012},
    {0.17679084635123488, 0.5530335972540344, -0.3314556185462716, -0.5631529033076416, 0.49670807838170744, 0.34530032023246443, 2.6078053296630266, 0.9167266954140535, 0.5292622337649595, 0.5079628365341319, 0.2609416820790681, 0.835738207237867, -0.030429590167746257, 0.3046052134190756, -1.0545962525744585, -0.5136220071002555, 0.10475229282976402, -1.6564274951562061, 0.1778934035149759, 2.1325778389812036, -2.818037032058674, 0.6707459480275554, -1.7311544698629537, -0.9875295211021897, -0.2055678631473026, -2.7409446361807412, 2.0966695915771942, -0.3197494327562756, -2.5715535371373317, 0.16326709982946647, 1.0263506971516652, -0.597064786008037},
    {-2.224454801888524, -3.9952100568945332, -1.8815287888003238, -0.7178952445729033, 1.2367039428017659, 0.8471771949010244, -2.023109326612155, 1.466258367834959, 0.38528420559039755, -1.5498123451617554, -2.025817475974787, -0.1594267806835414, 1.2498258596733434, 1.157420846123268, -0.4153280454379289, 1.2845221788065613, 0.21816555599020793, -1.3702802683149315, 1.5908662597355467, 0.6023348457008149, -3.761096745246391, -1.63014418551546, 0.6393893605916219, 0.39447228291384856, 0.05943262045505431, -0.3738227191858245, -0.2683643234149604, 0.5650778027914858, -1.5752416895421542, 0.8037508542112591, -0.5179676520326055, 0.7694213465383107},
    {-5.102652541739323, -0.7078153992129742, -0.787602707458596, 0.5892761819442466, -2.262312476325507, -0.07584314294612303, -0.012752799710753928, -0.5402342974515814, -1.2381035985780922, -1.1851896689656345, -0.5512041715787944, 0.9414786008697218, -0.2055861013471874, -1.458385683569139, 0.5411415309549542, -0.4663907625060802, -0.39601068673881573, -0.5724850609023417, 0.3146789171441747, -1.7762517637927844, -2.439893226190078, -1.4052160356925958, -0.7541437770139182, 0.6929885299852959, -1.9763966992793995, -0.08980116608315233, -1.6315341158815149, 1.4207261403977218, 1.4683676744685976, -1.5363083146610461, 1.899485126269507, -0.15278274852549126},
    {1.1319071602096769, 1.9867982667629682, 0.4117750432806046, 1.523996488207131, 0.2474827508368642, -1.0361489378639153, -1.2330944474426728, -0.9842375247116945, -3.3404798411919763, -0.24569835712695223, -2.582003595905247, -1.9811383821962054, 2.297582638164449, -1.3432601413313379, 1.3365243961647928, -0.9309646017948583, 0.041442317526161405, -0.5468672806330639, -0.06051767801959518, -2.670447187514374, 0.24852213916723384, 1.2350914687367718, -0.27736790072439427, -2.21039606169477, 0.6699023668985676, 1.2686544856628268, -1.1649929549624733, -3.2936966039604414, -2.9396457453576237, -1.8983090320069809, -1.0182302766677078, -2.455554209997422},
    {0.5051351378012573, -0.45743223686293943, -2.7373017648368685, -0.41428596631990455, 0.7699544543872395, -2.1889466088186325, 1.148014628426273, 0.5591156991072632, 2.5745862043235372, -0.8384060572253224, -2.7766145029991374, -2.9739697797519633, 0.8762740304965151, 3.653668057943971, 3.2291922415501175, -0.5638504544360083, -0.7071606575145656, -2.044921964944887, -1.6214800633692519, 0.18283079047068745, -0.0777906461607751, 1.9886015635170653, -2.18192762726131, -0.29651852539363616, 2.8102290616324734, 0.7582725483021632, 1.5222471328577203, 1.3512545278986738, -0.06871929693966501, -0.4573521071171282, 1.4586484741536137, -1.399097075273923},
    {2.3404193945134386, 2.696786209722169, -3.0141865256737392, 2.1088348974557523, -0.0097392526712132, -0.4755231883379646, -0.8886548298978508, 0.597501424152171, -2.4578423373860714, 2.523746484903465, -0.5604718721327514, 2.238464764956953, 1.587918520790203, 1.451218001145557, 1.0261134380811674, -1.6260687181953277, -0.9243698960732127, 1.5666494741779426, 0.20641554616279012, 2.3047269445594782, -0.23045851385452196, -2.360911888450648, 0.7878766083043912, -1.503664900646404, 1.6371001478588163, 1.0384970488247554, -0.12010810258777783, -1.2603838437015644, -1.011542388999851, 0.19953867513017154, 0.2655991264896479, -2.259641559358845},
    {-0.6345544913441739, -1.6341466337635988, -0.22461049398357102, -0.6604568734292746, 0.37731072206586413, 1.020135429462873, 0.2825197777777145, 0.894181049270242, -0.31397864801110026, -0.4035557073174439, -0.8799180924826966, -1.5153914666088246, -1.8634372911793882, 1.3012350814384201, 0.08537134770200841, 0.05770133512704298, -1.0149454416080217, 1.1648817253331831, 0.8500487759465466, 1.2747700613639794, -0.9139581505822949, 0.2711203925515903, -1.8551532270669817, 0.9074607995095507, -1.2082584810328725, 0.7851648549365177, 0.6220503066641073, -0.9522115778923623, 0.050395468788691875, 1.70258603467505, 0.1331831389919533, 1.0648075198774523},
    {1.7994891168931753, 0.08395115704256746, 3.0967940994335286, 2.0116402052896967, 1.4361706215512369, 0.749299776163248, -1.6963666754997178, -1.9465086614661427, -1.8433798998704616, -0.7159743196597756, -2.2807502201497605, 1.1032060085807558, -1.069138068000604, 1.739009675668154, 0.9641613348086197, 2.365070929303988, 0.9921089289166937, -0.7000820483339946, -2.5757257130245073, 2.0607636260277875, 1.4873537212617005, -2.3639275410319662, 0.2522445121024082, 0.1487720825018789, -0.5910561088733777, 0.24333582428009837, -0.46925636375334306, -0.1706455645480939, -1.4680062731831607, 2.645496030313251, -1.7289226836995546, 0.8076871105676869},
    {-1.4911225077603496, 1.9270951811291746, 1.3115002763263965, -0.6418810892893488, 1.8642983826754225, 0.22964351663981195, -0.3611293028174472, -0.9140276672863873, 0.9707049661127624, -1.7421415860713247, 0.22196566275838886, -1.4599144185746715, 0.04116149066777539, -0.10049225800475825, 1.3785485390844636, 0.10039343586887174, -0.4921602024269821, -0.15951451670802377, 1.1732745209460649, -0.2633289874628961, 0.13843113096932383, 0.9475672636500054, -1.7757146196670555, -1.1383684995726717, -1.6528446017274718, 0.6658151775810748, 2.0396807600393103, 1.5077539747362696, 0.4749174770761314, -0.15386129701229712, 0.9943403102899393, 0.2527342252256216},
    {-2.7214904594211555, -1.4992788993778017, 3.4381869980953543, -0.9800354598793891, -1.4107447614330402, -0.33410964737922083, -1.020013406371367, -0.43361949206371314, -3.128317049317658, 2.5234111960836336, 0.0442654328065992, -2.050832813386579, -4.37794737220028, 0.9966995622909127, -0.6798633365957594, 0.19542667708598194, -1.3039330578750326, 0.039011684048925445, 2.1508908745113042, -1.2923106583386403, 1.8586216460074607, 0.5375805906116219, -0.5998314315045866, -0.6359757105634257, -1.2380475226256864, -0.9934241894409934, 1.2589092496434604, 0.017119706586325185, 1.8254478193984311, -1.5355770960925705, 1.3797121183098522, -0.5228385136091824},
    {-0.21987082801243313, -1.5632978688640915, -0.1835842159397628, -1.2721595995314263, 0.2691874415464214, -1.96488414249599, -0.6759938710310719, -0.4312163924076986, 0.0908246434680892, 0.4429666644886696, -0.5680569919424459, 1.0036432765418213, -0.8828098284857968, -0.3368089733522947, -1.818748254027502, 1.844315765504593, -0.9360130582969219, -0.9624179371478088, -0.14652502965428854, -0.2961377632750543, -1.3494057775054238, -2.2559028144142905, -0.3295891755225528, 2.1547551324171, 0.2955824728881636, -0.3634154217515307, -0.5659719707013526, -0.70102375490773, -0.5025235129098269, -0.8129858229295451, -1.082589725874835, -0.18309982634587815},
    {1.4603930085014034, 0.018303747566286985, -1.4583772543402442, -2.9954207170166662, 0.5669910283988154, -1.3025266964708198, 0.3456738158258795, 2.551123611364788, 1.4486750040859915, -1.7645877165179171, -3.138445252441404, 0.33512197831814766, -2.2453026858324683, 0.6408875369380312, -0.6718061104100111, -0.36707490253663283, -1.1287453215711911, -0.5655213558786569, 0.16409500306275013, -0.3139574925551597, -0.8931611749045086, 1.1124929140302489, 1.3071894149814454, 1.8610514424474407, 0.15941147540807316, 2.6876235870130305, 2.0533543708431674, -0.09309733863577094, 0.1219111250246399, -1.6741265280715703, -3.8199899760598863, 0.4919619201091226},
    {-0.1667526404359072, 0.35195951232030326, 0.5272393059735963, 0.2386536147263629, -1.3853100906179199, -0.40785297061412623, -0.5121688679755437, -0.5638982489769055, 0.3182693779980282, -2.5521114079132454, 0.7621389561753037, -1.1877920806326272, 1.780169733095948, 1.7492394843359016, -0.6711218745086843, -1.5777977538883905, 1.2389020591635194, -0.5820671169522827, -0.03580471865344192, -2.430839843462857, 0.8601957988119123, -0.17510727469400791, -1.4616771636289863, 2.2177074536120185, 2.595537483926035, 2.3534100128526054, 1.4158953478616856, -3.093776515128501, -1.8584775135146656, -2.8676242204768654, 0.3512270522899058, -0.8578339368181632},
    {3.2130991863702034, 0.8103186357163298, 1.1242971329628675, -0.13672009489406176, 1.091740092171686, -2.5489144949860187, -3.1595600235220163, -1.0818028290372097, 0.006655415518847348, 0.28960005460853827, 1.6213003263957093, -1.2400426272896161, -2.159234069726306, -2.936215184243453, -0.24435260057990735, 0.7848207571942385, 1.615582108178576, -0.6317391266653164, -1.8547427651104218, -0.9847267786724667, 0.5180016827938354, -1.0948593555299395, 1.8733770362351887, 0.3039701451106456, 0.5483552216562442, 2.3110483200159084, 0.36453058235417357, -0.15623566793729185, 0.09716168477891231, -0.6450929615548041, -0.16783156302852953, 0.8100652318949065},
    {2.1200308015564757, -0.7594262832591294, 0.9370448264257174, 2.640956145099789, 0.7063597497113601, -1.182518131954249, -2.632843961453271, 0.32555089143025684, 1.0978505129187577, 1.0282585782106546, -2.17182848793289, -1.2514160273097044, 1.9678480045982887, 0.5318688040036653, -0.37875121867616196, -0.06662254770042227, 0.2505522616773829, 0.7429850959104166, -0.24279321897956813, -2.49495026832334, 1.1709138384186608, -2.0511687141554007, -0.3755203823402993, 1.2781344668019048, 0.7513418440913137, 2.120044904674118, -0.16323690853402403, 0.7757615196416963, 0.41127675636967087, -0.8484247870372478, 1.4466670362956529, -0.02242783670401608},
    {0.6519449567319171, -1.6779364477024077, 2.7618166926140257, 1.5818159986381406, 0.13554283792506205, 1.1975884467433904, -1.245194215352989, -0.4571827004416896, 2.0010903786136622, 1.0327865542054886, 0.03574187852985513, -0.6343332139967398, 0.37898934838388276, 1.9365929431381264, -2.2092321803277626, 2.39824094004107, -0.6780251315655471, -1.1878390938283516, 1.4280304715098047, 0.1677642406020795, -0.0325055650202339, -3.2587193563245203, 0.18655404980607085, 1.7052174388096022, 1.8239996948783879, -0.47659569953581193, -0.4931443754018868, -0.1587019679828297, 0.39762935175614045, -1.20361112238829, 1.0612332493327397, -0.5106234572372075},
    {1.7980747816751719, 0.2374562871687582, 2.1507488161126935, -0.6111166077587089, -0.6513080058800961, -0.3257013981831651, -2.3602968890905593, 1.060513185973037, -1.1232722693084614, -0.6138995087459225, -0.29580569928585376, -0.6714138826786903, 1.410476229141704, 1.7000084580432826, -1.5077532022432816, -1.9128858572308787, 0.02292588455844574, 1.7597871567028374, 0.5636624515945886, 2.3403100090843343, 1.5782430219730865, -0.6307748500710795, -3.4631777758614235, -0.4063765573745196, -2.487622964631662, 1.9701757926983898, 0.7329293631844015, -2.4944062173610413, -0.9498414912797088, -0.34869247160319344, 0.24038098539629002, 1.3378160223594058},
    {-0.5226694036307772, 2.3580408209704586, -1.2600569431723194, -2.396081299083925, -2.5935490217316546, 0.15518455780849347, 0.9392286976374813, -1.5060709089445932, 1.5941931228529693, -0.022109738509180698, 1.6926814778932824, -0.8416666601510695, -2.95671317005926, -0.4201999780802174, -0.49939727253112987, -1.0425164560543188, -0.9345290104371488, -0.360985116833699, 0.2427139988283507, -1.3766538166418951, 0.48949445597021224, 0.16375330932514007, -2.4565034208953085, -2.309507368545746, 2.2023445333159284, -0.041049029424629506, -1.4997268866042583, 1.2563159651331368, -1.6166715513035812, -0.39261357910729916, -1.5663406292452546, -0.9710840987678682},
    {0.294251128470501, 1.2078955627638588, 2.4065967503735193, -0.4648670595645291, 0.48286216205207205, 0.639327757000533, -1.0907429420922752, 1.3574638568339374, 0.29731414456453953, 1.629919540535399, 1.2447409032499663, 1.7587271434003984, 1.0081479203353672, -0.2304238815428851, 2.2005396604461556, 1.7571334286535205, -2.1242408590989794, -0.5668229527644102, 1.1649944627626423, 0.5437898142593839, 1.092372227391265, 0.8840098267604032, 0.5955356078950192, -0.9726234394434038, -1.148969897439105, 0.36802139095267283, 2.387285870046318, -1.1620811311440131, -0.23892003107151896, 0.3315098209732377, 1.5244995651967272, 2.2028560775669175},
    {0.043210866486836336, -1.1074270123667238, 0.1711343994230466, -1.8987005191623219, 1.847868804835619, -0.2501837220581371, 0.47082111743845456, -0.6871750584542985, 0.260304796865759, 0.005216958696505097, 0.14755490297880625, -1.1359341291069638, -0.3377558825510571, 1.9197789032018349, 0.3566418363392258, -0.06798043822826881, 2.296192453307481, -0.3522303273134933, -1.774468602848568, -0.012727914019172046, -1.5898278467682834, -1.5249211640430618, -2.0602994981164735, -0.8630782553859144, 0.6643691590691939, 0.24109767305318786, 0.31486964558612823, -2.138433953110131, -0.47342923727490555, -1.0034981421806637, -0.1480308959090617, -1.2711481503807693},
    {-1.8577513342179173, -2.3737596974011863, -1.6261339386155425, 0.7668219252522847, 0.04517943026967272, 2.757045685962769, 0.4656546295521655, 0.09802725527603666, 0.664727640444478, -0.3438743608721102, -1.4820183269747775, 2.0229040472457758, -1.1510107769274187, -1.197564798077146, 0.5644057605185785, 1.6471661619681581, -0.016601831871838217, -3.3514671590769467, 0.6572177933886176, -1.224700172398123, -0.2923038976890205, -0.7541686022230668, 0.9484473401667721, 0.30981604361048093, 0.5756876189601297, -1.7372649744872468, -0.26730132719541405, -1.2771625339414223, -0.5713621242959105, -0.5297813199629556, -1.1620256632042931, -1.1737035104006237},
    {-2.799732699296428, 0.7905569194790648, 0.9671149051027742, 0.9024065327964997, 0.6422896671025827, 0.532987738518426, 2.0963035523683, -0.3437287556508975, 2.9761270542084484, 3.848921096134387, -0.1254493267713479, -0.24414030478544366, -0.49495704727262396, -0.7849266083861459, 3.161919893834298, -0.22651701452054543, -1.3199356604358998, 0.4291706908788404, -0.7167672391113665, 1.1801356270766579, -0.9499302047795269, -0.4458127343913085, 0.8920314683356564, 1.0162998039067708, -0.14588375279330235, 0.22724663986323143, 1.4832365278294193, -0.04641824370017917, 0.9166077093598164, 0.6022326057840967, -0.32579139894641723, -0.0040527624649088975},
    {2.9113240737215706, 1.5487105631953197, -0.8332717258415975, -2.1621389841832035, -0.9441022458437485, 0.758100779367401, -1.2908322445969869, 0.7063704071042054, -1.8195939945143045, -0.9115962849118664, -1.1565803800420307, -0.012913991364244213, -0.012373231906469533, -0.07023521438691797, -0.7723069491702608, -1.3174112970263414, -1.6321701040143166, -0.05585565534317539, 1.0569197911107666, 0.3388554873832241, 0.1977085698303764, 2.0094520116972716, 0.6756332641425522, -1.4661254039038794, -0.7413002925985719, 3.4798883532419462, 0.8608571060080035, -1.1508539809935963, 1.4999785875832472, -0.08126228871636589, 0.19239297920214762, 0.13661805907190294}
};

static const float b1[32] = {6.188423673671361, 5.38177277636342, 5.634926029020402, 5.043556585968501, 5.938431220555721, 5.96380225788142, 6.477903256588698, 4.210117012027772, 6.238566693633051, 6.026366795195548, 6.119021005184837, 6.219399372402024, 6.152750870014023, 5.945586695369262, 5.968750303124237, 5.0647259169408185, 6.338442301124392, 6.2747234542250325, 6.102805083655478, 5.75841586220436, 6.498919140608711, 4.847005107921209, 5.7222518283488, 4.9802250416893, 5.627343839633158, 6.2201489485095385, 6.590230556573934, 6.200299920394787, 5.553776523565502, 6.365225540874873, 6.061704806225219, 6.012114140906102};

static const float w2[32][16] = {
    {3.477072492817259, -0.11211424229754202, 2.9089371001539606, 3.459379277623271, 3.1149319036671463, 5.060904988704815, 3.696686027289386, -1.0409998605102189, -1.8368477553989548, 4.127924679558124, 0.07332470001246609, 4.050084499255574, 5.980518730948986, 3.7427270214913086, 2.2932938987981717, 0.07443874395040165},
    {3.478234419359737, 1.0129101975474024, 3.7179609963456417, 3.9396244077236684, 2.9538290990969895, 2.77604391471139, 5.354795363681324, -1.3511012258570707, -2.3937692572160367, 4.3392572240275475, 1.151511914491707, 5.885186176745326, 3.279709346778315, 3.550134207010415, 1.3739597725352486, 1.927457121667228},
    {3.4818844826106354, 0.7649224684089285, 3.9869816526152353, 5.939957385051409, 2.3913948627184114, 4.977322525201549, 3.962644780674116, -1.4765849459222726, -0.7180339520816669, 5.2732755404546925, 1.3299478235990942, 3.403214154027073, 4.636529142179657, 3.397620620563505, 2.365971057004937, -0.1652030462232539},
    {1.6811588793785708, -0.9980941326559841, 2.0710929865392846, 4.920131666679781, 1.3747864355557087, 3.775083634317778, 3.8390905821629118, 1.0144941725735004, -1.5057134649770645, 3.4146444620018426, 1.0341955322155096, 4.140189059852358, 3.89322859914933, 6.05540976220257, 2.9033272367472898, -0.47832583864446804},
    {1.3494132991689771, -0.78705797781103, 3.661958894985245, 2.9404888252913377, 2.0036030845766715, 3.639954837735667, 4.322334696660806, -0.04666121982610566, -0.7574150286470411, 5.327755596182908, 1.6519209111870072, 3.492540316178278, 4.5286456840944185, 4.335757890323206, 2.217494588676446, -0.2479238629033161},
    {2.829593191401865, -0.7174800546097543, 1.9991753311838836, 3.116558576677081, 2.8457851044077986, 4.027862079725017, 4.248411957607176, -0.25753522715310806, -1.4476734161414109, 4.956645539645587, 1.0871671054125005, 3.3333417888769272, 4.601923828920259, 4.02798321809384, 2.9259705916387406, 0.36498284860191615},
    {2.4928145001377207, 0.009007464808221299, 3.512247253242086, 3.8953289506283157, 1.975585010956906, 5.208265798981935, 4.155270710274523, -1.2566153653465122, -2.0810837012674095, 5.517780643329913, 1.0156605411678796, 6.085422752870122, 4.991291080644519, 4.945015997975829, 1.640628704339239, 0.13896219238613633},
    {3.4641175179338988, 1.8214444373837966, 5.559173424891969, 1.8106178529640022, 3.4290050851979195, 4.281857661327032, 4.2228208909702225, 1.089728698895853, 0.4735614707097161, 4.2309601164150505, 2.0274624525298197, 5.407004936976553, 1.8500603871175445, 4.2177203651597335, 1.2016891555820175, 1.5916816329019077},
    {3.3114373565014525, -0.8227590374491314, 4.021021411237607, 4.260317376137393, 3.2105080025138286, 4.251419822366003, 6.101411543029403, 0.21335834354111488, 1.2107290372662454, 4.381079889103344, 0.6460215282749223, 3.7969734606697227, 6.157467418300191, 5.309631463659892, 1.8637821880129632, 0.6924183405357125},
    {2.5386030820671825, 0.4878250833912574, 3.4794272620887314, 4.134505855202495, 3.64693378434051, 5.406917604294207, 4.447394205424722, 0.7197518923599556, 0.2970467582066244, 6.40301101858357, -0.850580568111786, 3.222393725417944, 5.329548787814496, 2.9165602729637277, 3.892891812344177, -0.05078769021508662},
    {3.9514506236412448, -1.3312475759539204, 2.839845975756512, 4.210843985877566, 2.0925017818657645, 4.105669921408015, 4.074220981107854, 0.2009738985096015, -1.4179154774306204, 4.708504049439209, -0.1887352307805559, 3.9671672710122077, 6.043237749047936, 6.066662960326661, 3.480665482642789, -0.5331096983350244},
    {1.7127858373282456, -1.156877781547423, 5.376658200451774, 4.353714174821651, 2.6201637801809414, 4.339676646005469, 4.35029232362127, -0.3156314998427832, -1.3677939001213264, 5.385903463073262, 0.19674138423446746, 3.865221438218684, 4.870722147616339, 4.754932475089306, 2.416149840176977, 1.1573980837779816},
    {3.3832647272312952, -0.9952547471240447, 4.069739293783962, 3.2301943587023287, 2.6951478769587793, 3.5622567315916025, 3.699516923496869, 1.3354503975397265, -2.0730781732198373, 5.690503900351405, -0.2554937826043853, 3.4357246269599604, 5.85227445727033, 4.364573096275546, 2.2679785016282836, 1.5980245141077196},
    {3.6369391497504897, 0.003241775144002433, 2.7278795512244747, 2.190552158440476, 4.356092848647112, 3.231099604742592, 4.909979629381737, 0.6745197489230769, -0.13586258097593126, 3.725913678957756, 0.143796746952379, 5.133745598919116, 5.8068636176884185, 4.698962493151281, 1.6404460629153523, 2.0487793395768894},
    {2.2492176882667207, 0.1851807526017856, 3.1835254266450748, 4.025896759301156, 3.826914297639852, 5.548945151992814, 2.9015378514720407, -0.8411100964021977, -1.3176888350497802, 5.041117280152347, 1.179546768992474, 4.314598984363606, 5.685306397650079, 3.3082835143994727, 1.8982841835194484, -0.7483072715661891},
    {4.122540146770403, -0.8063253234812662, 2.0164748940507295, 4.130944353724416, 2.5789068163793885, 3.6115532923114606, 4.762068190756356, -1.321063195742015, -1.1348059018097787, 4.1458225066461205, 0.1373918341656703, 4.018416746513327, 3.911529343418252, 2.991740339391282, 0.9924062677786782, 3.0090455559384703},
    {3.731617665220153, 0.6455355621748861, 4.737403137188605, 3.336905528537142, 4.237977344848151, 4.458378550106659, 4.552431036373157, 0.08161618499951143, -0.017338257219956247, 4.946209395065719, 0.689152201565499, 6.29096831701942, 4.642301379918908, 3.0927383004996356, 2.2174777469895317, 0.6521537260373511},
    {2.4454136299819917, 1.2159420615337273, 4.7408969879587275, 3.3354991596045345, 2.0073011337986273, 4.435665303030877, 5.506733091029131, -1.309807585695028, 0.8087784244848909, 6.564917505498249, 1.556459275210643, 5.574318734215687, 5.6291171788540515, 6.0119231545203835, 2.437918450325017, 2.391782557746789},
    {4.655596422263213, 2.4582668825057326, 1.831737540413982, 3.1610362511144374, 2.950385596168523, 2.850235126344322, 5.60120685935595, 0.4031521282770785, -0.39031992810221394, 5.727238705413726, 0.4048857785604373, 7.835491667880179, 6.355936113559678, 3.3259283151446786, 2.1208051952080473, 1.4969697018878634},
    {2.6657161244963143, 0.11151589415738922, 4.706286911366551, 4.004073357219695, 2.7472645443139343, 5.063360110628871, 3.146904085674835, 0.7816534558420433, 1.4389579053611283, 4.042824976633561, 0.47831204407224653, 5.562367267902411, 4.200982210612382, 4.895843592191776, 1.4348158873282228, 0.8274418291261773},
    {1.3209300078013366, 0.030491107066036586, 4.01955639987011, 3.7445645350640167, 4.736624484860969, 5.92997916882922, 4.930991571187391, 0.10407014177512346, 0.10196416890365802, 6.245239060053184, -0.3590016216508505, 6.2229654715058516, 5.407898261609386, 5.155408570320915, 0.38408309891910625, -0.3335117802191054},
    {3.915780143600782, -2.0845948294963335, 3.6425572872284957, 4.740813001660831, 4.197961253695345, 3.4628146513191074, 2.3258830764877874, -1.8640649243332545, -0.08476812101293497, 3.415516910662383, -0.06329687751000877, 3.743563141768082, 4.2626114149162975, 4.702923673056579, 1.6532749328910727, 0.2202214189917669},
    {2.8615101471491142, -0.6119975042370611, 2.9094225800597484, 4.827966966602076, 4.240668400786658, 2.9036408097818094, 5.138368985269498, -0.10703802055326507, -0.0035522045444441185, 4.533760189471262, -0.6613399640525298, 5.421967469037357, 4.931210981879359, 4.776322500513634, 4.349422143013677, 1.1046586897929405},
    {3.621266831216674, -0.31542141166461507, 2.4668869560126194, 3.1258219468734065, 4.815672345876222, 3.94754667835008, 3.17352006392949, 0.7956676971411727, 1.3136163811613866, 4.798398159277296, 1.4028044737632586, 5.045194180740915, 2.291886428534648, 5.087083537828707, 1.6829177482731914, 1.6526784579457476},
    {3.4774471750733635, 0.5890069892763022, 3.5233952410555274, 3.2013457140797112, 3.5049650066078946, 4.093404529120163, 5.858662581940605, -0.8996847686600071, 1.0088492863578, 4.592955399241687, 2.5637843812244903, 2.262203877597643, 5.315216044095949, 5.332431178951703, 2.515439472052991, 0.39225417940176577},
    {2.8597184885542513, -1.50080512038185, 4.586064745564439, 3.252309901522624, 1.623072999052119, 4.7533500673347815, 3.445809034893526, 0.6058790107581853, -0.8161634606613518, 4.6559364080938925, 0.5190739503313877, 4.368364641488002, 5.025350637178518, 3.6817293447636517, 1.8956396313994908, 0.5444609498280135},
    {2.4317164604770896, -2.0662026345219613, 3.9462384902016154, 4.0783285557175875, 2.5296544494958884, 4.766448890351248, 5.222336963694355, -0.30540033403076017, -0.15317787361245339, 6.823020107214953, 0.40418497534002273, 5.077727236661398, 4.767283003104727, 5.006203349751894, 2.643903391507804, -1.6290576599364648},
    {4.312268630146121, -0.6573107521347713, 3.5144543026070223, 4.274593285162374, 2.504696095059149, 5.5488260336766615, 2.7500652518841093, -0.6871469109118349, -1.2303912369786285, 5.243539051536606, -0.9622266359907156, 4.009807001812759, 4.288779217017659, 4.439308481378228, 1.3373956009877537, 1.2543673797574155},
    {3.008923907089381, -0.4452342444171565, 4.237550625552798, 4.011161409043034, 2.8765853778678165, 2.9532611108159865, 2.138171289269972, 0.5749912886753883, -0.1452913569246512, 3.8608849621762893, 0.7802054978806366, 6.1465096885797, 5.38295285923149, 5.424223744358722, 2.014833473359942, -0.08653524359171859},
    {3.432568849414832, 1.2134363822778405, 4.280027810331461, 4.16712357986586, 4.731572510020343, 3.841697803136955, 4.419055581635424, -1.4305846610089041, -0.7113674979719283, 5.422523157489557, 1.1815948104870593, 4.763125889909883, 6.496777941944026, 4.608123321885888, 1.8466282678578547, 1.0644111310159226},
    {3.1294751553597413, 0.7392449224156277, 4.647710124026723, 3.0369474719594787, 3.7986345635050753, 4.3592652669956715, 5.205964446987188, 0.3720041857004849, 0.6163109757741911, 4.33739470093653, 1.0769697493942825, 5.624253299120819, 4.733495670517134, 4.719671786235104, 3.0713083557666887, 1.81046521757357},
    {3.500110175009095, -0.3023901758222051, 2.299334302718461, 3.3918984262674647, 0.42422687206062526, 4.290746456977279, 4.926154998786422, 0.24985448253131345, -0.7166045954868056, 4.637139813372063, 0.8619087162989267, 3.474601683940593, 5.608903678567006, 4.001875959000612, 3.7943641054863906, 2.62470027517595}
};

static const float b2[16] = {4.103273395964351, -0.2030532783331551, 4.781393144067113, 4.529543472091302, 4.304629890446807, 5.031144136423551, 5.683242138934005, -0.016635354774011783, -0.4423855518085281, 5.857697287410686, 0.6563181132453144, 5.548019165593606, 6.220547467696661, 5.4764557291855835, 2.906547263056975, 1.1181300505413494};

static const float w3[16][12] = {
    {-4.345045412770383, -1.8406388764985195, -4.544275920832262, -4.08628929572273, -3.0906063404177457, -2.0774886543337714, -2.926836898011109, -3.4615239932807733, -4.245223631647871, -1.2872989253812608, -2.39977257095189, -2.322312146332579},
    {-0.22440180035729715, -1.96631976452604, 0.8616854356575795, -0.6982684685081612, -0.8360854266217714, 0.797434417829428, 0.9347394055756724, 0.26256903668307846, -1.4169654152310114, -0.5068117033749435, -0.30040954810848824, -0.2636031342227326},
    {-4.590705947088504, -3.521756864070092, -3.8055179030998634, -2.214885245592706, -3.0986377722110907, -2.5783659935948995, -3.525716526711731, -4.6693983775883, -3.5004672625646047, -0.9994656922622243, -3.478368242791168, -2.7952302121498898},
    {-2.063895331664276, -2.8128419158314313, -2.3595235914949653, -2.8381401996104842, -3.3718358843353533, -3.62430591496596, -1.759938804927915, -2.4035739949735175, -2.520769785599423, -2.65692534370978, -4.214474147088435, -4.386610904848497},
    {-3.277216281670784, -2.3929304924857324, -1.71002551513268, -2.975112373424025, -2.325898675505145, -3.0286073462227434, -4.075737218519247, -2.8082484841242454, -1.9150980826858983, -3.09762445652831, -1.9071443128277803, -1.3617314102958642},
    {-2.1481737286029765, -3.0461946490351126, -3.5494837959903713, -3.1025938207847874, -4.310864533172215, -2.3198695552211808, -5.077050054071317, -2.398545145911268, -4.823520397154155, -3.770552014891643, -2.500233959782864, -3.505739836310198},
    {-2.8966326764381694, -4.017740223930742, -3.4614088314970095, -4.086272101131035, -2.463095904029706, -2.8335771156948235, -2.8345393743974134, -3.1550829794694915, -4.11380582728358, -3.7714029623564667, -3.641739093586935, -3.0137734663920215},
    {-0.3866238592187816, -0.642327582970621, 0.3326470761321508, -0.6517235702767186, 0.0893788670228692, -2.5377956647637716, -0.2706588005175472, 0.2282408172854041, -0.5263693705731619, 2.1333286661186226, 1.1922917791890058, -2.2881272468181617},
    {1.1464494050330567, -0.6572005026391488, 0.8029058190740951, -0.453461155906155, -1.127405207017109, -0.2005120234918638, 0.27381958307414744, -0.5417947489001288, 1.076682014774355, 1.4889683533074614, -1.006871060906544, -0.8490774929258725},
    {-5.081080493740054, -3.245282017730983, -4.2544701652298285, -5.654991888282151, -2.834647054331214, -3.8770838453352274, -4.067583848097398, -5.246997644477076, -2.3235285510959107, -4.002761863603881, -3.265977177147654, -2.1817784789108394},
    {-1.078326182610683, 1.0167623002304267, -0.4899623480229909, -0.4212730614890447, -2.0204684930758843, -2.458983701707469, -0.7830253297490767, -1.4164781107255886, -0.8683575856114104, -1.9063943463367858, -0.8441535554030717, -1.1182573649388416},
    {-2.5099220070339285, -3.41770327738153, -3.026044116099777, -2.125838106446298, -3.476958541297468, -4.282226029593492, -2.1912534466733584, -3.229973857018832, -4.2918611074491295, -4.790784658937951, -3.6122085418273424, -5.163150922704118},
    {-2.9083221562260007, -3.7244149123432164, -2.6019379592112912, -3.2059980543678797, -3.402211856957558, -4.690461015695633, -4.134338686343477, -3.3064189699287683, -2.244950824603982, -3.1652437941376985, -4.1082594312563145, -4.628243823852921},
    {-3.5755612087570325, -4.857451354682946, -3.806073684332304, -3.0062955608182875, -4.195052792252084, -3.2260310240104415, -2.4657728569550423, -2.4645553490903667, -3.3693989631896635, -3.733428338104405, -4.220580186912881, -2.868369658054055},
    {-2.4071936859552814, -1.295408602107055, -2.045941369835685, -1.7930752562488195, -2.234436425900949, -1.8998327784317717, -2.847385174373651, -1.741786142010742, -2.394332245580145, -2.624686195057486, -0.3522143689480806, -2.0775833979109275},
    {-0.5811476516514262, -2.18268371879494, -1.9379942727727082, -1.113495321759916, -1.9573502940391214, 0.37105759665149135, -0.15445092879519606, -1.3001392291638183, -0.011828552432703868, -3.016638410671326, -2.0101805505886294, -1.7162114829863895}
};

static const float b3[12] = {-2.54851040840138, -2.882635608513569, -2.91144809678979, -2.466288223681964, -2.57736531998056, -2.971624182161659, -2.858513587847832, -2.4634744290527113, -2.600497449963649, -2.7323661312985585, -2.736549214166677, -2.670563961567739};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
