#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.5975518607076253, 1.5882969360925916, -4.145535611445352, -0.07892670111939325, -5.216930200729436, 1.8805674214846, 2.4451253443567245, -3.2816063650651817, -5.113450064353677, 0.28919104710893423, -0.037433344836959016, -0.5387325416436218, -0.9728244183980708, -2.792077885938063, 2.2411004104789125, -2.9448901148061273, 2.8794799902117334, 2.1422716737893452, 0.5036376857040187, 0.13036927823774266, 1.3248393352405132, -4.850670684095323, 0.4240438137694813, 2.690267060986341, 0.2726432207187245, -3.7625770372021283, 0.7171264965590434, -0.9376742879657489, 2.5758364033592387, -4.31731109511037, 1.3209869037222255, -4.294044722376472},
    {-2.155426278214753, -1.8729686747887724, 0.045609457489652554, -3.187641209812606, -0.48978761841878254, -3.4843308111754583, -3.124190457621828, -1.2418743542230677, -0.2622927537125266, -0.5773284386491018, -1.9846077055596307, -2.5868193496190126, -0.879689595315847, -0.9504309801813204, -4.4087996524777395, -1.9074248246909953, -3.373533666371646, -0.4485426904901558, -2.8043461333571207, -4.665840775589469, 1.3092870338228135, -2.597536450419338, -4.371001311698186, -1.3768635114147645, -0.6143711273069487, -0.3501071243519753, -5.07548279803937, -1.0881840739266322, -3.086880123065582, -1.8545093391383134, -3.9791933981376135, -2.2735778614177944},
    {1.174191874259475, -1.7399697971251151, 4.2203965774268175, 1.006180498253057, 1.6827783530608476, -5.193923525317559, -2.4037837736691907, 2.7112237356847864, 2.629361171877549, -0.28315296354688557, -0.19333896990084892, -0.29080639426429267, -1.8405008301250043, 3.702949731422763, -1.7876007524106454, 3.3339485166794494, -4.2257948847898135, -1.9125293415458315, -2.3314762359283234, -0.7453455075306602, -3.8048880334048065, 3.6133232172748557, -2.406672704351117, -2.6828100820196914, 0.5739979654343309, 3.0270267409418836, -0.9037058866903955, 0.7127720963644175, -2.159862643537558, 1.6613773313835325, -0.5198012779028099, 3.4172550885591653},
    {0.06501222586104814, -3.4124464319605816, 2.2512316825334526, 1.6676996301428737, 0.9667021870159598, -1.2740780564259804, -4.256062794575229, 1.8787281330721028, 2.422477027142959, -2.6165015193162984, -2.094105184590846, -0.8582741622709861, -2.8318192175385044, 0.6310333538189121, -0.6992377340073078, 2.50547518022875, -4.818528233787495, -3.905552136067459, -2.234426757146619, 2.783404283759412, -5.611398388865449, 5.208865958027407, 2.807180867387222, -4.7934588695763845, -1.822681154848107, 0.014744136363157665, 3.9401492152658513, -1.6167040874378258, -2.3357351648122378, 2.813836400922474, -0.059738578007202704, 4.206023769555972},
    {2.9541824953630456, -0.4146660736395231, 5.422243701848635, 4.583942231840354, 5.885421380672369, -1.8836999005538668, -0.8838029128023713, 4.856528927154202, 4.571925782927804, -0.22239668351680916, 3.034331258629572, 1.7440798235446846, 0.3066157758422828, 4.456313027826748, 1.555446486843906, 5.274815597841393, -4.074257425680389, -2.6056374136482345, 0.8138393498331139, 3.418756408321896, -3.5485747479811063, 5.7657127053385, 2.8157702107215794, -2.8329575879194233, -0.01119617097119576, 4.276894771388197, 3.3615033159632213, 1.891191509886772, -0.22132772915865476, 5.5436531483273175, 3.4613772932191886, 5.012348649948663},
    {3.0960431699564115, -0.7251913750116803, 6.332534500214363, 6.4044343289130365, 6.786773135030478, -2.1788249732897613, -0.9561911594543511, 6.379799919687788, 6.537319356981579, 0.4691032707141404, 4.980552165087963, 1.7914984406961345, 1.241271965449052, 5.199572217433395, 1.747368651106437, 6.462940271282135, -2.38983104978414, -1.133113903040338, 3.6877583817835475, 5.260639950522521, -2.14779964694959, 7.244597171087333, 4.1890670059515225, -1.7796174405932117, 0.36200427279599867, 5.8977972715761116, 4.558401643835804, 1.901363337372797, 0.3799662485798185, 6.939982812996262, 4.494257764775052, 7.265233714229656},
    {3.0789649474300695, -1.4255818720425506, 6.081866789901861, 6.265411497875963, 6.6451891235618765, -2.4091940406124768, -1.4032193133016044, 5.7948625414241475, 6.307300655894503, -0.4932352729091583, 3.8987752150034467, 1.4170066895738007, 0.061544577904397414, 4.634915825972302, 0.6847891890604674, 6.085144220722788, -2.681287373380908, -1.8619700509547683, 3.192138732221909, 5.461442356770567, -3.049115236215516, 7.064496721800932, 4.86565978597771, -2.5685822398152403, -0.05880711417993895, 5.719446018403132, 4.9825095598233, 1.551187377229445, -0.3833741914511037, 6.713378765184352, 3.8230690668057266, 7.099630688675049},
    {0.7090086795144523, -1.9677192488496102, 3.416179061248556, 2.093048845301984, 2.6128158543924322, -3.2178757597529564, -3.154925407203107, 2.5612139803300082, 2.6876517698399685, -1.2362547290289074, 1.5006202221696254, -0.8190699038585181, -1.0931411334363041, 2.4592952393114236, -1.5870626568504196, 2.9700763815767997, -3.584116090679879, -1.7829041224194069, -0.40158930533885456, -0.7800192182831938, -2.7374648638808066, 2.412569891603856, 0.008816452682821333, -2.328804023217947, -0.9806443189039361, 2.45234824417331, -0.9004568730502555, -0.6437785295822003, -2.632365067701649, 2.480602925881618, 0.513682488382009, 2.3509769931294455},
    {2.5699731015101195, -1.790704261106257, 3.2527693312104455, 1.6294404385599344, 1.8579021360673789, -2.1513548923663266, -2.783869628071965, 2.9817310307894025, 2.9535220620231617, 1.168597402177668, -0.06028079823603295, 1.9258687479316299, 1.4477452589588897, 2.6559382389071295, 0.5145305685260164, 3.149263300142802, -4.403614862077351, -0.5182784259607919, -0.25469421927793157, -2.6942069071055514, -2.2672935211371015, 2.645337457541706, -2.2750704279632963, -2.445801443747497, 1.203235070113735, 2.342050477016095, -2.084685460064807, 1.8393039169616798, -1.2469868870186251, 1.9168115717998788, 1.093291032971577, 2.8133893070920326},
    {-3.203383808295034, -2.7151958923530626, -2.915491273464061, 0.40438447790393306, -0.5140229974214672, 2.645694010451607, -2.8419112433557814, -3.002011331066892, 2.5414615706979204, -2.5348596095731724, 0.30022986624930054, -3.5645835676435427, -2.0252147971540464, -2.5173564698490565, -3.552403322595088, -2.8569000714385364, -1.2847408423416629, -2.1963697604430554, -2.6759402915281645, -2.0529574056181534, 3.221551516285578, -2.5336582997801123, -0.7602920618142269, 0.47740748734379607, -3.2009990957514516, -2.3785589045675803, -1.5460021230599303, -3.2823019971310483, -4.301281813340097, -1.7309727137038373, -2.9835191350087604, -2.3270112893902914},
    {-1.7419350077007778, -3.346303986669328, 0.2928329597093445, 3.2110599944892346, 2.6246913721812004, 0.47744825996746726, -2.094399960754807, 0.9032767114815076, 3.5188479525062744, -3.4291172107386987, 0.978112642104009, -2.1647802033317354, -1.4434838603974867, -0.7946222851568143, -1.8484490019015238, 0.3835873093639994, -1.0903212134312967, -3.224560353159346, 0.09574158427967785, 2.2617028777388426, -0.6226112573969206, 1.8438954899729894, 2.83380386112792, -2.7928360607996643, -3.5534734350519996, 0.6445287803399498, 2.905489014966048, -3.17533701644196, -2.781145592357388, 1.2339422819763384, -0.8137201443253812, 1.2100133602595875},
    {-0.37467930752587214, -1.382851857603825, -1.6286362212750682, -2.8988497966397384, -2.1300484164124827, 2.7930024299704255, -0.588278009652237, -1.2464500831515524, 2.3737556056334292, 0.4363267831080525, -3.179578677649638, 1.4936074563471047, 1.0161633715535663, -1.3369004705444003, 0.4093290633223202, -1.8464054934013718, 0.1930910493652231, -0.5062953697169855, -0.8673020165436784, -1.9261465068902979, -0.2972709042338087, 0.6972293907854933, -1.547386369386928, 0.008578293171590094, 0.6676718738749594, -1.520975954443753, -1.0382020925165818, 0.5600059300066142, -0.10366926239882783, -1.3030176660183126, -1.089102872760522, -1.1714396247690522},
    {2.205136554929044, 3.0761704534830225, 2.431646938181593, 0.6573360281603354, 0.32129499029189246, -3.699578349935704, 3.590214829112287, 1.9195982164785894, -0.3281128953954453, 3.1608261066439605, 2.4913772750185057, 1.6315621215289469, 2.725348625131644, 2.2252802817594657, -0.09342997957477363, 1.7776553203887044, 3.2472023661528153, 3.814211870581371, 2.1444579948182505, -1.5120638566534645, 3.9705313746453976, -1.8351871026263478, -3.149102981882239, 3.5052160916311954, 3.131857541629879, 3.2319496802622614, -3.230020865446769, 2.809907677911115, 1.630138221503714, 0.2067787709065579, 0.5752861951539706, 0.028335010349743},
    {-1.2119752519221527, -4.401712105922777, -1.315193408330652, -1.683260065085618, -1.237770933067782, 0.6090608322749351, -4.107852491589031, 1.014542717171133, 1.334159442488496, -2.9646539256640856, -3.5795037389244357, -1.099771073916828, -0.7118784578956354, -2.0544244381346, -1.7328296123912197, 0.27110847299368374, -2.6837982184771083, -2.9797857686953297, 1.8216358417994356, 2.094196613805919, -4.890043186629448, 3.51646944662269, 1.5736096648228695, -5.223732606498411, -2.1823809350175014, -0.3275375493656359, 1.4547005377855582, -2.1531273521455234, -1.2797291666182722, -0.12886378498574108, -1.1599777079577074, 3.4269914614211765},
    {4.580518915635426, -0.2270112627406986, 3.1043993500196545, 2.5357855433638337, 1.480388029950025, 2.2540605844660857, 1.2334910206597969, 4.919306220192276, 0.8432665298678372, 2.155672981988225, 0.1607616355568009, 4.912823186499578, 4.333426068695247, 3.1431791963823175, 5.280162863521183, 5.03103122718287, 3.0414880636521833, 1.5481500022487729, 6.54196033202964, 3.835538130971782, -3.798800737735812, 5.264257990034251, 2.8522912437964516, -2.6904621297713183, 3.1419287869895216, 3.5283409914016883, 3.1913204851613783, 2.982331487579551, 4.741251959892561, 4.136135768062487, 5.276102440164937, 5.616859557742094},
    {4.343949725869494, 1.8216625805846167, 2.442610682950184, -0.5384381530320803, -0.6818821226931827, -0.8623519624123188, 3.388434379445948, 3.641077389165117, -2.51239338397017, 4.493806137543001, 0.12443723256218032, 4.635566651541034, 4.894288278454095, 2.9465861517921943, 3.994593665899145, 3.5482241761752076, 3.7954990635559933, 4.699159156479737, 6.130182012785127, -1.644190124455999, 0.3972538429482233, 0.2606994684237424, -3.173520575887099, 0.2896596321723222, 4.167153327256784, 3.9258136805343575, -3.6152486380505655, 3.955312005144072, 5.02018166065362, 1.4213041270650333, 3.813875387913087, 2.5798944251178795},
    {0.8314560314321751, -3.876941203498144, 1.5601958297225218, 1.6849719791110023, 2.6827759559537467, 3.787921687068507, -3.6184885194553718, 3.4370558478757904, 4.0335357837723995, -2.141312240394013, -1.152892249599029, 1.0386259168653516, 0.41768289015085275, 0.5082138743811393, 1.4318472256213144, 3.4268016925082985, -1.547886112174374, -2.3308106597928773, 4.024680374528256, 5.444723275171084, -3.989173396664428, 5.569215169122636, 4.992777772851829, -4.678002975091417, -1.1527269226886787, 2.03266598564797, 4.909871157073329, -0.9172707144887575, -0.31150108645536567, 3.524556897472323, 2.3278880306433, 5.210011960064326},
    {1.690404226456368, -2.2963568263663636, 0.5041223189988073, 0.7240799217414742, 2.2408085575325254, 2.7297011017891735, -0.9325312635663612, 2.881527104917472, 2.8740636162487436, -0.46987538956795394, -1.291746697355661, 2.0356862335890007, 1.9708656757218217, -0.048480697103804905, 2.5929597472805845, 1.847641345731506, 0.9759937991037837, -2.1988445060311643, 3.9742458537189553, 3.627871551334301, -2.3890381811953607, 4.3932579127260984, 2.8416189950063875, -3.0155577603440538, 0.07050538850867598, 1.776439225089915, 3.1623864392028334, 0.2714182609809535, 2.018594965954683, 2.900104258178153, 1.9150887295502754, 4.37094793766656},
    {2.247700740547706, -0.8397171814673151, 0.607892853209503, -2.4445399741654485, 0.07357494592694817, 0.9305113203054519, -0.6437113624374261, 0.8178444001769158, -0.9265372520488432, 0.42157563667936804, -2.369568949549609, 2.787035698605056, 0.30291640671391873, 1.527417956056117, 1.4854573491578955, 0.8734428341626377, 1.4108339208058023, 0.5268910413177892, 1.9339200106931018, 1.4766187605027323, -3.289598664815281, 2.3380350393023184, 0.42085765927389784, -1.6279494597311075, 1.4556995545332394, 1.030069780815913, 0.09346483577116206, 1.7342152630807093, 1.8368171406334965, 0.6635659462693592, 1.4811923091645653, 2.384421578996667},
    {-3.205307031173977, -2.7264105037496673, -2.342753700679346, -0.7836182571252439, -0.24960792523067066, 1.5201451758155289, -2.6339076347943444, -1.253206559232852, 0.4462901053191766, -2.45799612560771, -2.037699352922247, -2.7899334253017196, -2.785846530740809, -2.4780730482384756, -3.313397066996396, -2.2389059200943215, -1.2323639711403898, -3.103476616547983, -0.6913505975487436, 3.1746974286083782, -2.4687095207721006, -0.15813347458158897, 3.5716482827372946, -2.9032420585096386, -2.7987128718673002, -1.9120987677461412, 3.5297680571978445, -3.3399558310208337, -2.343375006078314, -0.6077004967471867, -2.5155691499595414, 0.23459391169564903},
    {0.1920556081566992, -1.1257118211121466, -1.6356806729005733, -1.4401979493377128, -1.034509727139959, 3.792763925735479, -0.6546839656102231, -0.32649898178145287, -1.2223078270638166, -0.7937140968053736, -2.6410377472872955, 0.9595092642565356, -0.7256711104725654, -1.54081249658421, 0.8167360346864679, -0.6668901958689385, 1.4478379123156093, -1.2556032166331916, 1.387913943598981, 4.3365321450792695, -2.9127126120947513, 1.6811899018341099, 4.469411402373734, -3.195485760173916, -0.4420230924667332, -0.9529692103990031, 3.8464331659720217, -0.6549910640722928, 0.4524430137435, 0.35330023709238634, -1.1129894375445741, 1.935024972865055},
    {-2.9508003203933657, -4.645089811230907, -3.0405641321677104, -1.9554703321847076, -1.0844561344377277, 4.15284485679943, -3.827665276360593, -1.2270005122778698, -0.42742607122065296, -4.346936793068008, -3.484291937303966, -1.8196908565192524, -1.9790262608403242, -3.759978690230662, -1.9447584984936572, -2.1164388946388537, -1.4570331140878536, -4.0362335112454275, 0.7741368447553566, 4.195635968660216, -4.660484613692923, 1.8677979021894209, 4.668409948387281, -5.268826945097455, -4.041821594737941, -2.3931935833717164, 4.354807791707167, -3.7721232468170176, -2.357570968733426, -0.25757984698912934, -1.8525597957347264, 0.9099343823352583},
    {-2.103016463079611, -1.323738946182225, -3.1909274044927884, -4.874172741658661, -3.0528082079962338, 1.200755474410099, -1.80620568077801, -2.2832948002003626, -2.9554521004212124, -1.4069663283933866, -4.957396890201846, -1.134685970611992, -1.4790433298801242, -2.623669312832917, -2.273864087073042, -2.7544639526529946, 0.8821920426011508, -1.3605958682941692, -0.6279262640165484, 1.896393847057452, -3.5874876279335957, -0.30578504909291404, 2.4591549004069524, -3.197427870158397, -0.7874793840606811, -2.1908939296139858, 1.7096295402174695, -1.6729736132892519, -1.1748860776987697, -1.482580416010947, -2.790194245956289, -1.1542322595365622},
    {-4.63482221607928, -3.3223934739365246, -4.352914320229347, -4.236345133936368, -1.636453872618947, 3.655322780423454, -3.328641223082659, -3.945105253853911, -2.168031617703625, -4.31016950531855, -3.7178180674792762, -4.398337640509306, -4.244920939322672, -4.277197788271068, -4.264162725154732, -4.468614593370373, -1.373425472984863, -3.106485798435898, -4.474828617461577, 1.6584188160264157, -2.820217156461283, -2.121597830517819, 3.611432472713416, -3.1119515061141425, -4.121281734566361, -4.111884594924479, 2.215680846532418, -4.743815742563625, -4.460525371489353, -2.1490707658348294, -4.648716693824263, -3.2283287118326234},
    {-4.02130843253348, -3.7376833012060526, -3.21655331974462, -1.6329750847242175, -0.60755465344272, 5.428054541918134, -4.015224914854264, -2.216313780147194, 2.1004658466678996, -4.365407613298244, -2.691848835355769, -3.71622989353375, -3.7336736537635256, -3.3014725574598653, -2.7309936443177585, -2.793776139017794, -2.8285194198596892, -4.042811021760534, -2.362864029901406, 5.391991546843956, -3.412814825530031, 1.850065040859392, 6.274843244275568, -3.463275257089452, -4.12556597015014, -3.221544318551522, 5.960554481025092, -3.590839355581099, -3.984364761803546, -0.656971238266218, -3.047577485046954, -0.15080731483748994},
    {-4.7198105853289976, -1.9227466470599528, -4.609708245600136, -2.4417031523409625, -2.5287669552326277, 4.511838737465113, -2.8730529921354186, -4.901998842969395, -1.3264471590075215, -4.301904814592417, -2.860325080892484, -4.479482889696036, -4.933501178642387, -4.278569400366182, -3.368820856886645, -4.892830099308681, -1.21003599168566, -4.298569781461006, -5.075076140116164, 1.8703545791558918, -1.407234323079117, -2.651407670067007, 4.370380270947675, -0.9777579181159124, -4.137669516324597, -4.8222218091558045, 3.9864504853409612, -4.447515616402821, -4.294717109239262, -2.993128760200467, -4.295801391227634, -4.293851502037227},
    {-4.550228836248175, -1.4494156636612614, -5.776179196453215, -3.0536164711054443, -2.9561591103827176, 6.014357662915251, -1.4074474741131302, -4.640102129998328, -1.7172865670829203, -3.999690023353741, -3.121251857510337, -3.4037062712505644, -2.998267803483236, -5.526388728368212, -2.196484528496007, -5.192987926034334, 2.485387549524796, -2.423844357782328, -2.9865928346126864, 3.0078361314426325, -0.5636041464674528, -2.754440470644676, 4.821167307938504, -1.2497296638263804, -3.9217578700657074, -5.1231531987758165, 4.665829674118197, -4.111902586006701, -2.1699882862096582, -3.1547901768416162, -3.1710577126223822, -4.3386537382525665},
    {-2.0334476768483385, 0.13015888643516388, -1.5381603009472578, -1.8274472784959204, 0.7958952763765119, 0.39266162593229803, -0.4834502598175777, -2.1877329731851174, -0.05275354757120811, -2.2258990305284088, -1.2088018309766924, -2.800455831642805, -3.0217794124213087, -1.0860949279323913, -2.819605971765246, -2.1773847535407884, -0.31968849109685293, -2.5777482545812513, -2.283601191412946, 2.9769182544401156, -2.1942643032813103, -0.6690725212634617, 3.6801950142838598, -1.6213687422512593, -2.8408685997863525, -1.2006787389336098, 3.5121885437216513, -2.1990164412409765, -2.4432823299244144, 0.10129389704747759, -2.8762235592873187, -1.8954924911328768},
    {-4.165026372489178, -4.938024736413511, -3.289652113670768, -1.0977061542969007, 0.20403286842581986, 4.53086867941964, -4.65419356459312, -2.5376976808846963, 2.0443342788845524, -5.174211802747156, -2.902025262728433, -3.7053242286416217, -4.373371219870773, -3.564059182754968, -3.3480483722035355, -2.5634908900055127, -2.78777697109494, -5.771554856233318, -2.697713668535934, 5.065055842018242, -4.4342687786663415, 2.6986154245022633, 5.789896479517841, -4.195255787285734, -4.879880008873326, -3.4529244010649607, 5.69235622084153, -4.525318182067233, -4.44322357051368, 0.9593236796136367, -2.7018152256068753, 0.1754065234476701},
    {-0.4649766890931242, -2.9775129730301324, -0.13306192297834613, -0.4399040290540945, 1.1697257206013432, 3.8173873340642017, -2.0562749697029097, 0.19894614019737397, 2.810172022790163, -2.4854647362795435, -2.2992929690838237, -0.4599332534592329, -0.8141983691562535, -0.8398471775461482, 0.1941550783894065, 0.12978893906025069, -1.0275125180366036, -2.7444359971571366, 0.41662463802723154, 3.3861589742296814, -4.485339000366564, 3.160775941234909, 3.800572384683853, -3.834171649416514, -2.430564182698414, -0.20588485884102084, 3.2607890815072085, -1.9068386548384364, -1.5259924172769528, 1.3567429139107137, -0.8432179350519093, 1.394281143052001},
    {-6.364285003923164, -3.747645463077259, -5.904362992184094, 1.4938432703774942, -5.314998538219354, 2.39633018245979, -0.09748276524313773, -5.546175743988254, -2.1992073676204122, -6.213461816142649, 0.990676915293021, -6.549845133671354, -6.910418505352938, -5.959611237459562, 0.6132599500884979, -3.993436151936978, 0.5204706727580416, -1.011223456242218, 0.26565912542189785, 2.4842828348537913, -0.8089129720137485, -4.099302442344776, 2.3823314551353665, 0.025964615886332646, -6.614493133123847, -6.030957790514434, 2.6715562145823357, -6.464354590133935, -2.511216566469744, -5.07457851274418, 0.8697630262265555, -4.752660735697726},
    {-5.437599018332871, -4.92364811680194, -4.627943833837387, 0.5654516095959229, -5.593938146103372, 2.642900807400891, -2.020578773563033, -5.032039050753539, -0.5159423094862469, -5.651762792546128, -0.506267300002959, -5.1642298690669675, -5.904172171574804, -4.777261057815048, 0.5996533103383146, -3.2521694918599517, -0.17584430240089496, -1.8865648081401845, -1.2317180560933483, 1.6774143909597248, -2.2984695632298497, -2.7315423479290235, 2.4175963295047977, -0.9344133697231151, -5.732338980013999, -5.226686760494604, 2.925451394190849, -5.470050768391034, -3.488128389437707, -5.004557571104788, -0.05920436246802654, -4.047305737825429},
    {-3.6200739334548384, -1.3520742527888592, -2.744708681292118, 1.019650062292183, -3.942153144116966, 1.3768035743096865, 1.743153190279477, -2.406926758768887, -0.8006358972373322, -3.3378615709168136, 1.6202216465706034, -4.000343902522013, -3.842756167700478, -2.1530901331936896, 0.30628284083878915, -0.5854195147553254, 1.5421395072237647, 0.8245126767265193, 0.6290784580078816, 1.2427704160893591, -0.21244789165132447, -2.134861663888944, 0.8225454531276112, 2.149539448770934, -3.2100040251248467, -2.563555528422153, 1.0285919522247113, -2.9021730895359763, -2.1522000840728674, -2.987062344401871, 1.450924697374391, -2.6627925020321634},
    {-2.745533568875599, -1.01708202031605, -2.30076043714363, 0.5228639278037891, -3.5095935831665805, 1.8759010877029816, 2.1969800828152954, -2.6204729523574177, -0.8652745512304066, -1.8308526996322914, 1.118693947945006, -2.4898879530921527, -1.686955551082866, -1.4111216917551137, 1.6125004533368752, -1.0452177418688344, 1.9920879255226074, 1.0709617421842885, 0.8562594562600332, 0.4078225203918554, 0.43881846887165876, -2.837292708894283, -0.11944290579976456, 2.557022419722924, -2.023462239210811, -2.7592680348504834, 0.5619961335184874, -2.4636644666714935, 0.1624588640159982, -3.831503417164309, 0.9733410446266686, -3.0090818147667546},
    {-1.8811783863541636, -0.1703749957798645, -1.8411842619116423, 2.3252677237625146, -0.792091092670838, 2.9650245435495957, 1.6771913232577593, -1.4476685755613636, 1.638879920823473, -2.4825027406450517, 2.1362697387538563, -1.9038789631678161, -2.336897894739934, -1.7678156875029911, 0.6951625400881074, -1.1391748641074764, 1.5938957075595461, 0.6644855644468723, 0.4512593167762894, 2.749375876961851, -0.9610740650084227, -0.8669151000222356, 2.654335607500204, 2.0082332428467162, -2.6616095410779654, -1.31445014751375, 3.2921653665984367, -2.7381950924863365, -1.0642410872589598, -1.7186387633105578, 2.121112967730114, -1.7647505650030817},
    {-2.6373354946478953, -2.2796253525163537, -1.7885633700203238, 2.432254246921062, -0.24365274918091015, 2.4673426431735175, -1.2150165773126418, -1.3686040308345815, 1.4286702289533315, -3.0135590296239645, 2.4622969571562545, -2.6015293754521314, -1.2271601385558042, -1.2515156712151367, 1.097732555774261, -0.15751088197379337, 1.267469899208164, -1.1523416111347216, -0.4916684853511914, 2.4521504438389417, 0.7895709846619314, -0.5965825096655399, 2.7473147888628118, 1.1034034217115185, -2.506199443549966, -2.2732376299303696, 2.57086301212186, -1.8658703186235392, -2.827739324920337, -0.6439641695313565, 1.7726772827175368, -1.584697755078666},
    {-0.7121659102804515, -0.5873260586406349, -2.1026823531546754, -0.39365335321137096, -2.2861975437950672, 0.5604975150692518, 1.1678418842042644, -1.9207379439314087, -0.5126201508544176, -2.051696019656028, 1.1294377308902583, -1.2640801936110408, -1.7064274477314327, -1.0284270554403854, 0.3850515573659818, -0.3686121902655491, 2.1136696332005696, 0.00882455781100766, 0.09446105160167304, 1.0454743616620894, -1.2192613026981824, -0.72793895385559, 0.7573527499476326, 1.7306497017331501, -1.4667361543670085, -1.345434041347745, 0.2748993686472775, -1.6463989423092513, -1.8207233715738596, -0.7825737992492101, 0.32702612391141633, -1.7736138004038278},
    {-0.17743324919708445, -2.1687420550024705, -0.4148876716867524, -0.8125040981058644, -0.3982738496444028, 2.1236925346889572, -0.4286833560088624, 0.013092500178146184, 0.6294391486137533, -1.3529786869385456, 0.8539836865584703, 0.30031144907129864, -0.5152909558365999, -0.6538068317718235, 0.32364442153806067, 0.3907328457972427, 0.6107317743615042, -1.5094132422881434, 0.7835928722446539, 1.208369143623548, -1.8803284069584898, 0.5152490420982424, 1.3252279092231425, -1.4509181674579934, -1.6949625621647926, -1.1071287056838401, 0.30544221824491086, -1.46727431621682, 0.9322200088264498, -0.19998315406545364, 1.1436917941304816, 0.008536108938045177},
    {-1.4206793987213042, -3.316021814799972, -0.5438987526271951, -0.23904459494737854, -0.8256265573073612, 1.0112439536425752, -1.8274168834455855, -0.2764033305756657, 0.9747519041398053, -3.1200191044961425, 1.4308246602457706, -1.300839241842332, -1.3304055876363674, -1.5895753216413135, -0.04605018771204969, -0.6231271891908521, -0.6988614462781683, -0.9198670389916437, -0.1458813758404826, 0.21784697362106137, -2.0436120780720723, 0.6655144469362128, 2.1926077176290883, -1.1455647471369128, -3.120856994290975, -1.7945088598973773, 1.3058267435937398, -1.9830316013446916, -2.3221666365371325, -1.100216495227843, 0.4838606172126602, -0.4885857415076673},
    {0.11661035055731657, -1.903015487941899, -0.43090418511952155, 0.41879621655853067, -0.5593442329704137, -0.3332928477679054, -1.251468543526069, -0.49262139434552116, 1.0493289424696584, -2.374283867762334, 1.13661525699423, -1.2379112393508631, -1.0270772004530122, -0.16246927962329738, -0.8687076926789241, -0.9519904058313302, -1.3220992413130506, 0.2610939813013239, -0.5002275699971761, -0.6618491383486246, -1.5317551981130337, 0.6669097654748951, 0.19109757548861672, -0.08238769495093966, -2.155184755200841, -0.6864827080441163, -0.20491425897728593, -2.2287299554735887, -2.491116444025924, -0.012677589273778628, -0.49816146592950106, -0.04312474979898246},
    {-0.1814144962648248, 0.24857607648474095, -1.831928739015318, -1.1094511875195285, -0.7044930077956663, 1.363367982857888, 2.619980017979117, -0.5806762742596789, 0.6281790099535649, -0.24015103443978664, -0.12981290302626713, 0.15291614022889205, 0.9433746427764517, -0.9203840391531044, 0.30834353886271215, -0.06896335466158458, 0.30160408138533823, 0.5811292248191984, -0.49594311909272804, 0.04289795674789656, 0.9737941994644281, -0.3094047244808493, 1.1818690955662134, 2.2672201281830304, 0.16704142643773287, -1.5068845119597176, 0.4044386961055483, -0.43855145665960144, 1.3670765382961765, -0.5866340364960109, 0.574679684327925, -0.8555962727894614},
    {-1.109930349374055, -2.0847481835347534, -1.3065365803590758, -1.0246591386247383, -0.64196952644476, 1.251671135729175, 0.8959344920223205, -1.2922047689655405, 0.946260857963705, -1.1153923702051858, 1.0250777011035332, -0.19724717465870856, 0.38868640124180415, -0.42668256495053786, -0.3381938822363397, -1.5890527114164807, 2.1188420233923337, -0.17200751440076806, -0.4886338603365121, 0.9433790804236267, -0.0867573756710035, -0.907125443572559, 0.9777014138022767, 0.7712873564114249, -0.9642434292975984, -0.1422964066082458, 1.0814298488518024, -0.6506670766761784, -0.5941690623100059, 0.4497920244369211, -2.2775176531438324, -1.3319597072165503},
    {-0.7253764987651065, -3.1894161626063133, -0.6659244015879039, -1.0984570210875753, -0.23339011675764704, 1.451691523793099, -2.3862914533655446, 0.1749557047110329, 2.2845706011072786, -1.91005915695528, -0.588068513694637, 0.10597663313926564, -1.4032073405963834, -0.6979683147629483, -0.4194320222450421, -0.01755777834720238, -1.894232685538833, -0.7700280699695782, 0.04713328731959077, 0.6650491096278827, -1.3211776075880903, 1.4320985499817132, 1.4862330750438757, -1.994451226963709, -1.7003306152543969, -1.2108221492229174, 0.018477431933571573, -1.777769384591733, -0.5960618048178042, -0.3569677122171422, 0.8754898079280005, 1.2317324617667096},
    {-1.1063274153953966, 0.5161322578947511, -0.878386777066404, -1.9111131466553213, -1.6873850784019526, 0.5743718739603414, 0.5156012608052354, -0.21053785416901505, -1.3707780492737618, 0.5571071455622773, -0.5590178795447791, 0.525114805948616, 0.2274661769438762, -1.2316253110866868, 0.1816152411024358, -1.018745960999157, 1.6771056892006526, -0.3313637743222439, 0.07775528618259706, -0.36998274512332946, -1.2099155392393466, 0.054485591971597074, -0.042368829036850394, -0.8749579707508435, 0.19317224676699316, -1.2019995887591526, -0.907069549640535, 0.05625559424089876, 1.575423373432355, 0.3343000135668279, 1.1117539952700928, -0.44358292319488707},
    {-0.17355767465924496, 0.6212048975591832, -0.23187563866452196, -1.3650125133079845, -0.20388292237501038, 1.2939973780077183, 0.0751618637610794, -0.24169882649998164, 0.9711982848120746, 0.9627270698190974, 0.5405348086946925, -1.0903751210919428, 0.03792762643568357, -0.38913695992214736, -0.5493270837140106, 0.11958539744719643, -1.2631479948419948, -0.8967217375144831, -0.7888203675000692, 0.37132032513531027, 1.9261854369752736, -0.08895822636730043, 1.3430358917708145, 1.2090279226504494, 0.6907679644723643, 0.3083581924474219, 0.1452741583610152, -0.07750357979594967, -1.3217199364513574, 1.1693847763496532, -1.0995525292973996, -0.18118955994904928},
    {-1.6721664048379004, -2.9538428683902325, -0.5573170081618921, -1.5847351020228762, 0.20025868628676927, 1.07601112697175, -2.431966930480346, -1.2193626276521488, 0.5894887235828036, -2.8517876495986734, -0.7215958252293952, -1.8330324214320193, -1.9015883627326122, -1.150521809900572, -1.0362443445726124, -1.8271085967319585, -2.9501910099650748, -2.078671115928772, -0.6883989466902433, -0.4483033467248617, -2.1012704439578234, 0.3396495316266015, 1.48513430178617, -1.919771265382106, -2.5429619470701916, -2.1124722046487303, 0.6945780976882174, -2.922344472799865, -2.946001011717234, 0.6135886355777201, 0.05964050242303579, -0.20248415855516125},
    {-0.837212802348154, 0.5075546790751314, -0.04982211459928773, -0.383035376714261, -1.2725067519715414, -1.3055403475449452, -0.4592891342832923, -0.024135172320468315, -0.4202790244205635, -0.5839512931078342, -2.8627231609557566, -0.9501421981028754, -0.7928227476710417, -1.842803345072194, -1.9509573288247428, -1.1712150767402527, -2.6753239824854087, -0.8337065353069543, -1.3519653683081116, -3.0639581088048997, -0.8346055520173481, 0.04511561557123648, -0.5293995652507639, -0.9639696703119771, -0.03837123251430349, -1.3457683005282943, -1.495995030617422, -1.0452363190268312, 0.7361990010993181, -1.3832507574708794, -1.257498654974237, -0.17466739446527474},
    {0.3804275509972877, 1.1624886515429904, -0.7891725726378016, -0.8318805123554448, -0.8717962923979725, -1.2288826980100291, -0.8450574167817606, 0.7110849317971627, 0.8497508390997647, 0.8746962099865225, -0.04140028605948417, -0.2753616408310436, -0.5054023102665663, 0.5397459757119062, -1.7180198591011022, 0.12551821569695365, -1.8106089927699565, 0.32345815714410353, -0.3098264991321149, -1.780551532922281, -0.4883676864911694, -0.5148592153293349, -1.2981849355408603, -0.030689148125154882, 0.03974419960043693, 0.11866147801181547, -0.5963958124887696, -0.18684006372265388, -0.30224748673500273, -0.7401973749997405, -1.9185703363107625, -0.36044724083665225},
    {-0.05428502646001245, -1.0607531505898753, 0.3465602240509392, 0.45641697709197276, -1.9062934050079827, -2.0572441568920126, 0.581828575228712, 0.40099630449423806, -0.09828750170212418, 0.5903235509162376, 0.8225551098703486, -1.1459557297527245, 1.6065960768383125, 1.1979382390681836, -1.9915626934095874, -0.5360808023677605, -1.1185067909087931, 2.813637300530683, -1.0710759146122986, -1.1468433855512898, 0.626763589587888, -0.2756248013905707, -1.5549086669395813, 1.9769120607703865, 1.6151948338943842, 0.14052466763033833, -1.674916871595898, 0.025397328365143152, -0.4349839644250057, -0.5846932125639294, 0.42224442890936414, -0.1845810613140675},
    {0.4457368562129016, -0.24885019890227258, 0.5941781302118706, -1.5252299259198527, 0.22249072641575096, -1.459673951867007, -0.709157097826768, 0.6062347467625803, -0.11122106390184869, 0.12984406856403238, -0.01753527989876161, -0.9357708147706804, -0.8376297524258324, 0.638642870009574, -3.0112763802707825, 0.2813985683430711, 1.3121276408483833, 0.7760835874592422, -0.46623003581607714, -0.446825796180531, -0.4420586652169177, -0.1753454389578983, -0.853078738307757, 0.9598799602702162, 1.1982023853288777, 0.5976121049206127, -1.2528931147043358, 0.26171228011908615, -1.4377621538483016, -0.7628431522345581, -0.3465962364939, 0.05307144674393365},
    {0.33010199874451907, -0.6879667468090362, -0.3825508766927631, -1.3199256091997096, -0.0732252938338702, -1.0165725205945082, -0.4566394032923709, 0.6979668537824266, 0.41107507425788165, 0.019871415246969972, -1.1206114225343624, -0.6625071186065339, -0.7175087023651223, 0.26345136810787867, -1.0252560382149165, 0.5259610070059986, 0.21257109013542527, -0.4021395353059745, 0.15190632714495364, -1.142898034721048, -1.0072273846550646, 0.4915481639927817, -1.1069286574309893, -0.19671849388930643, 0.7950099059412636, 0.1262753214096849, -1.4454750157710734, 0.6979579936870572, -1.157250233974446, -0.7146585376740487, -1.536198480939153, 0.10893210217556099},
    {-0.7222351637063614, -1.6325261610371302, 0.4558034779658746, 0.1662481351557747, 1.1721812674014473, 1.2225865681810915, -1.0310139992287084, -0.2845916250709268, 3.1056857312589736, -0.4120688554721449, 1.9186469313344896, -0.23382792790156862, -0.5081653268959517, 1.7435407087462016, 1.9553601306507276, 1.0389305466826864, 0.20815587532281488, 0.5631504865910858, 0.5213450388984657, 0.9160713982591924, 1.74753618113831, 1.195450747975804, 0.4987484354253036, 1.007526558226824, -0.771478349086245, 0.43709481802912664, -0.8833832338104373, -0.34497790597194494, -1.1332917179307942, 0.38133763385921315, -1.6051855092807896, 0.4589182524369614},
    {-0.47908614249357195, -0.1578903016853404, 0.22838999048092426, 1.6806418439877555, -0.7697763707917168, 0.23529035702172893, 1.6256460060211593, 1.109202868246115, 1.9029408952692102, -0.11018060339362973, 0.38272631945911706, 0.6947424393756749, -0.06921823163368508, 1.5867764801919144, 0.16256624748216758, -0.11992450441088112, -1.3161657517600598, 0.07911174373800844, 1.2316770305390226, 0.02443453874364998, 1.1030316072978528, 0.15417439467780458, 0.3299027780318161, 0.8914948071386438, 0.28574713440597393, 1.2321582050899524, 0.42169687522770516, -1.1696209531180655, -0.5606075801869895, -0.4436239617486193, -0.29961441153391744, -0.2047332356175902},
    {-0.3578545862010153, -1.129071824160204, -0.8577199336055806, -0.5020074647238395, 0.44098632703814833, 0.8150032334519621, -1.782406939594519, -0.9117525797820752, 0.8503517586374939, -0.18335327794214462, -1.4144640401697046, -1.0969451284478555, -0.516783023591897, -0.6078233423921391, -0.8911992520342938, -0.10624970045138926, 0.5838334532109934, -0.6480769411453128, -0.14281630910462106, -0.5556648017150856, -0.07622266904448234, -0.09221191484197189, -0.8310612258208216, -0.947881310481474, -0.7275309223713294, -0.018751801984940974, -0.7141886775161191, -1.271679940728424, -1.2989201791197817, 0.5381279695778384, -1.3472081632334498, -1.1258177541658294},
    {0.5915014984820486, -1.4301487109135314, -0.32781248780397587, -0.6031702458772753, -0.6347831856187046, -0.6132779554929944, -1.277697851805211, 1.357735850573928, 0.1928878313070583, -0.33764068815981396, -2.9569859392903477, -0.05590950093387603, 0.035142112223518415, 1.2087426726687034, 0.9157967467417779, 1.168445625793672, 1.8536743538948972, 0.7328470594372017, 1.7060556694535411, -0.5870163923890661, -2.396401392171635, 1.3252885735749076, -0.9309146658896917, -1.593796320779705, -0.24130579677785785, 1.2120325182981702, -1.0053562877983608, 0.3309386178293607, -0.26374527781697227, -0.8305538534528473, 0.6663372853000805, 1.0939517310156666},
    {-0.08634994543446084, 0.28390457439706246, 0.7717984960753274, 0.35516196211113393, 0.27311740591310346, 1.9243874964434993, -2.340206277803842, 0.4662630958399125, 0.9919632005200646, -0.47802457686993477, 0.4935397564902279, -0.8743610335023888, 0.3092519360634473, -0.6739903047412888, -1.2079485607912777, -0.18342735112649505, -2.045952080570299, -3.244721970102546, -1.9641705747672884, 0.33032992672034633, 1.3292160336208942, -0.22268585883160097, 1.322131327239542, -0.3341753634946063, -0.6789007692778624, 0.7660588822216107, 1.2200632476899587, -0.9767338655636052, -1.1467139862233076, 0.13291381068715316, -1.9796075052054252, -0.17047683233152283},
    {-0.40387390114360805, -0.8108069932364462, -1.7525947147628707, -1.5429188089187595, -1.5881092205236993, 2.9516986389080966, -1.6072045718530896, -1.6795214162096286, -0.6366024904883149, 0.2953053612708428, -1.73922937788469, -1.021649857070958, 0.05190636361949358, -1.4522602182932567, -0.8645971946653072, -1.1269692922090027, -0.0020604302287931526, -0.2631692058156383, -1.148399159523036, -1.0543591069305873, 1.4460233376330491, 0.1281413258140222, 0.20056688275816936, 0.7900676213883021, -1.0078878319600417, -2.4621858908839975, 0.30936657785557486, -0.3809121593374139, -1.2882165955912204, 0.20945130226170752, -0.5832906753226264, -0.6685470077498202},
    {-0.09148131587574504, 1.7470340845242258, -0.22867980783680467, -0.391942611642308, 0.06047293765496663, 2.0806002382486475, -0.3923774582035412, -1.242368631222644, 1.3109188495318058, -0.2712735544571014, -0.2554169020307483, 0.8473794449291916, 1.2353933524836436, -0.6960803205963333, -0.10982199536631697, -1.101631490249889, 0.12450242068688948, -0.8257284988386661, -1.002702443439304, 0.4618414201220728, -0.401645863584079, 1.4608528914689687, 1.6377642760818538, -0.7002570853506261, -0.7020864313741003, -0.35928341062825864, 1.91622297529921, -0.480667128222073, 0.7499541953942672, 0.572836588678936, -1.933059115763796, 0.5551637351303805},
    {-0.4620836651932485, -1.8124687476238086, -0.49409109565027676, -0.2958145509546309, 0.5671142066461624, 3.485044917086968, -1.7566147726366692, 1.287943379060076, 3.3588664626073057, -0.4389045848713036, 0.9673312092110827, 1.0064693184381968, 0.6025799906663556, -0.10139378030440627, 1.877783161736926, 0.028267698201371823, -2.774759567758129, -1.8131286862750067, 1.256994841599554, 0.6825357659367255, -0.6548539274539958, 1.7923995152122891, 1.6222973347897263, -0.6692474588951614, -1.128384679495907, 0.19363044075182095, 1.6606089560013941, -0.7027166699104404, -0.7051377727308283, 1.747577444216907, -0.38795969041437217, 1.1511074454073387},
    {0.575993902745764, -2.478703199272634, 0.37405179712264053, 0.3447708812480589, 0.02673673393354708, 1.0638162441069157, -2.56083301613002, 0.22527869994888527, 2.223278612575136, -0.6105536893622621, 0.4435055507976051, 0.2271508023498387, -0.7122962543585385, -0.8236804061198233, 0.14483115601312416, 1.2600871940426308, -2.220856008350704, 0.08323838065688231, -0.8170331269433881, 0.6201954182852466, -0.6466977919495119, 1.4990183348460997, 1.6998950406969218, -1.136665918490131, -0.4549146325036469, -0.765593610047164, 0.4369476447530567, 0.2215536015472073, -1.735855152021698, 0.15653613848139325, 0.47709536807445263, 1.2361023284481936},
    {0.14172972292235178, -0.9112020755324993, 0.9302448871273808, 0.07619118255483615, 1.5224530935947571, -0.27656569217368315, -1.0618290270415103, 0.931541941796463, 0.47314848983726254, 0.3103872258639587, 0.42794127971552565, 1.296264871699772, 0.45654283750760033, 0.7876592349025052, 0.050464123151372206, -0.17425180122849654, -0.4951642339469273, -0.46033520403134165, 0.5956248327454852, 0.06167466000755536, -0.7169295844730934, 0.9958446944930265, 0.2854871712676126, -0.7504851674011983, 0.14785202866651234, 1.430267900143578, -0.2827160770534034, 1.22345233633923, 0.5579820397009104, 0.860492228690804, -0.28992408511031925, 0.5863895746235313},
    {1.4338266996230074, 1.3087843940317525, 0.7320322072411828, -0.47605420492109435, -1.5496972871949957, -0.5137578063458775, 0.9225397594695106, 0.3489998432051606, -1.7830656404098195, -0.2548072463988282, 0.8480366038902577, -0.7537750762495992, 1.3851468873931112, -0.47575368965271236, -0.5174617580933033, 0.05710337328185907, -0.3609845488115033, 0.35806531396476676, -0.03242729635411397, 0.28681416124815146, -0.11100234361823166, -1.3724887056601147, 0.24357088779068956, 1.4967067148455286, 0.0832520169413202, -0.20486762977818246, -0.6154239192251878, 1.0805327696840805, 0.8904599554503992, -1.8345031546819732, -0.2235904049656848, -0.443275177446363},
    {-0.13554262794716962, 1.090228428463218, 0.4641932822475198, -0.33483734989239056, -0.04170161063006587, 0.0484126651992064, -0.02963102336649224, 0.12288217710363014, -0.9986200893455919, -0.5165745016308502, 0.0714870564301735, 0.9552704421044043, 0.06948579965151094, 0.04327085284624666, 0.2711191974352634, 0.4472075482846253, 0.28295942301268656, -1.0738444798676072, 0.3676177097158369, -0.1371689571299976, -0.7251104730997489, -0.8094312937061997, 0.03459515497219193, 0.4210472795389916, 0.036872737379633196, -0.7575001629652474, -0.017054786745580044, 0.018313846890423126, 0.4624367622918102, -0.5958789605182646, 0.6984649062511652, -0.7006003548501945},
    {0.14694247641345995, 0.21392351533073858, 0.28778357202783733, -0.47192096779157267, 1.0423328498120656, 0.7396904633187392, -0.5752461105387285, -0.5330646490139594, 0.14350680290725518, -0.3574384762747278, -0.19370560993065558, 0.7421445346832705, -0.9900951065968053, 0.8242767166953251, 1.036731007863224, -0.21420330659154685, -0.5221286359703885, -1.3681003899631201, 0.01909196194131679, 0.15280017663629603, 0.28749878542014784, -0.33604374299913237, 0.835233265221966, -0.6889640340270224, 0.0060236179264659346, 0.16291574684068083, 1.0780485374692308, -0.041259673426344394, -0.3206741184195764, 1.6746404316480545, 0.09161394053450254, 0.24694120683083387},
    {0.31086586614166045, -1.0290388096679528, -0.6205739157606365, -0.05796233232955018, 0.3498798015523331, -0.0881194788323112, -0.29320093994705676, 0.5547787529030287, 0.5119200238419137, -1.1207817184745255, -0.019565884669811084, -1.0924475060896208, -0.6646136108024916, 0.0580132440511165, 0.09228463449398262, 0.183088164900791, 0.04411287181618924, 0.2599397241779195, 0.14329957473067187, -0.3246225165854051, -0.47262743340946906, 0.10714042361579344, -0.5884880931387878, -0.8454626989102926, 0.22865485956776654, 0.6192230615995387, -0.5763786852102132, -0.9953700126314728, -1.137840222438349, 0.5603782703217989, -1.4250207600473301, 0.37430749745680536},
    {-0.870142454610176, -0.8825803102638632, -1.8749053189848979, 1.0341158679193962, 1.1275788057911915, 0.2167624544980275, -0.127311913373707, 0.49996222083855596, 1.3079055223058775, 0.204631650056494, -0.04218919682099091, -0.9600010429842221, 0.12574840247593788, 0.6938012386467406, 0.628793997301224, 0.4432057832359549, 0.2479167471915406, 0.16198314762031374, 0.10743692931930968, 2.105366068175475, 0.9025851105587932, 0.3431428865182844, 0.8918495373524022, -0.035308857729818136, -0.3875468287842612, 0.44505193710700774, 0.5093928150827436, -1.0178937671170918, -0.8473056803166454, 0.5961306119485971, 0.04983260509131298, 0.8214046168379907},
    {-0.3459328549167718, -0.3727611183145339, -0.7582864633638076, 0.538152269772054, 1.0506659380589878, 0.6358971371996759, 0.3099850811061647, -0.09971006668907707, 0.5933111650519728, 0.30680943892918844, -0.37523615033281565, -0.07066957663825259, 0.4164352271977056, 0.9987253867428504, 0.8891172581747134, 0.4483359507032281, -0.07152716663607034, 0.03426695025324963, -0.03433209773472798, 0.8599868842498881, 0.8832128170048125, -0.23790234841319866, 0.8512481544794491, -0.07925489172645409, 0.622214090190999, 0.42896701491318734, 0.3742834112930375, -0.45325026476230695, 0.7544037950019934, 0.8314594755396212, 1.182071288370377, 0.30969177714779456},
    {-0.32444267445625197, -0.4116051071651261, -0.4925438324055293, -0.7469355288960153, -1.005614581150778, -1.277901271577187, 1.4955233856401677, -0.9760393253581837, -0.4151300019262636, -0.564773745948503, -1.811212122111808, -0.685180782526507, -1.2091650533865104, -1.3436468033725082, -0.3397803436229334, -0.5911959920806963, -0.41604161016561625, 0.8169511263558309, -1.4246088821242218, -0.9023048175889984, -0.7835256227525284, -0.5904373999529392, -0.7518184906603114, -0.07997689107910823, -0.34224929052220404, -0.8991694239128971, -0.6959776043288056, -1.418254639473834, -0.5824858463432054, 0.16732597016220627, 0.22225004353433722, -0.7528462850029602},
    {-0.318628903270609, -0.10854578136293801, -0.734115974002384, 0.7966340793875717, -0.8737531733059981, -0.4903150006892644, 0.05578527159804574, -0.8188487952785014, 0.1842821553478513, -0.565388248866696, -1.0688140110569555, -0.03126401172491965, -1.2044132969079944, -1.659897062289627, -0.8566559432565423, -0.31105791580248204, -0.629439761035344, -0.15668592383927823, -1.1770232589584053, 0.5059283312562625, -0.3575701400853634, 0.4773550346832025, 0.4867581285992225, 0.027243032112547364, -1.0317483416757616, -0.6316069255373998, 0.30357872566628347, -1.7767336445503132, -0.3368617387227949, 1.0050572750477471, -0.2609106098930779, -0.6632374660548127},
    {-0.39280725778670494, 1.04781398055017, -0.32909317864449616, -0.35116310415138036, -0.7155135856634236, 0.6763446173298417, 0.32305554151634863, 0.700573192491588, -0.10692941751737838, 0.41390139601343207, 0.02544623154439255, 0.5515896488846119, 0.9730214823809042, -0.39370219605776463, -2.165889202413645, -0.1085199820699503, 0.746387586486143, 0.0582203692338148, -0.12425410680659695, 0.6681307686206838, 0.6131492812059802, -0.5735881193397059, -0.13368308505324686, 0.2220805840745096, 0.5921309991248558, 0.14214053196629006, 0.6485550633703918, -0.7389726337403595, 0.8594520444155258, 1.093088995460103, 0.9048824933899313, -0.8768900906453173},
    {-0.4635486773939053, -0.0997411164652929, 0.5043270755276059, -0.9784671136634276, -0.2955154024497868, 0.7536202917152753, 0.34669629674597857, -0.02225881429306733, 0.32538831285949166, -0.5200918043880446, 0.6122278546542751, -0.6713947777151519, -0.2201931127129228, 1.1168752046249704, -1.5120787641718119, 0.6560322136189499, 1.4737854326623883, 0.6644549535790806, 0.244870591708657, -0.6895875870070712, 0.8408932266658322, -0.5928356264430119, -1.4591390927064447, 0.347023580202731, -0.17072737911531125, 0.17649718993936125, -0.3369903531732706, -0.1941970387173311, 0.03539213658020336, 0.30692273496119143, 0.7775463981731697, -0.9088936502352718},
    {-0.4674103556996099, 0.37882373329748364, 0.06933126773006901, 0.3827576456799151, 0.5691761064089834, 0.8868217243932894, -0.7462278283809644, -0.42912191697650837, 0.8287941594747328, -0.16170390901628115, 1.2578712077984784, -0.5503573785409337, -1.901927169565375, 0.9580626052945926, -0.4471429535658246, -0.3258471523668482, 0.19004654923934208, 0.043773298104995105, -0.5665417984193624, 0.015728554095868232, 0.8544783426965586, 0.7982961846033739, -0.5122753052718777, -0.5709578031030125, -0.2785847434219326, 0.6128725645021597, 0.8025240871631055, -0.49697743258360066, -0.9656001650438282, -0.649295974873492, 0.045974151550910856, 0.3797585821245273},
    {0.4357854211579426, 0.28056057421014535, -0.16049917749840897, 0.12200399917204356, 0.7971269009389758, -0.44146049117945213, 0.08309336585516623, -0.9448029918070209, -0.4008448037353328, 0.4886063472821597, 0.7366933296125807, 0.3383985785378413, -0.21569417859652626, -0.4171168077752711, 0.8381176715990475, -0.6531328593541271, -0.5934471209226415, -0.587286302153683, -0.11293793507706158, -0.1320591221091024, 0.10702553269827313, 0.21804039492458913, 0.01228534789018659, -0.6364614907444457, -0.8275223528676412, 0.7579080548353461, 0.16173038499432835, -0.11317731456400401, 0.21933995075404186, -1.2925011617846376, -0.8555927925223316, -0.2284648995619821},
    {0.42447404675151673, 0.9975923488258557, 0.2724861995381112, 0.4878162018618787, -0.5916382574800374, 1.1164688006380412, 1.5250767755056431, -0.11951304442122018, -1.0159661167895913, -0.8699985547908969, 0.44569381986201717, 0.1143789432004619, 0.1252214616522045, -0.2377869573442721, 1.2657795118503126, 0.13106774464410711, 1.2121123555713054, 0.4671764918757624, 1.1226700824730242, 0.2735004340534779, 0.9815451279216474, -0.7287661203665371, 0.9919566244684395, 0.9821572543516061, -0.6907515121263796, -0.845973759341517, -0.300134839518468, -0.39556670783334424, 0.7779424592414761, -0.7522176644836324, -0.15349937259353397, -1.224189846497591},
    {1.6637159708480873, 0.19207922107817554, 1.243466660872675, 0.25953274411554245, -0.6751607943638546, -1.0283163778258115, 1.2934985225362643, 0.9454631644659472, -0.8035168399307329, 0.3209942481126753, -0.9849495309303831, 0.3808204871377626, 0.8088518888194475, 0.9248376838327507, 0.9683911163319474, 0.15147463687311932, 0.714767234400691, 2.2267290262276953, -0.36932334272069145, -0.8375182511478114, 0.16374274844708214, 0.13551091229333567, -0.04361517941013501, 1.1379551399597374, 1.1464957509384384, 0.08219280623279242, -1.4184235539037975, 0.23783917166339683, 1.3749661212257855, -0.14578957931785055, 0.41436153213045895, 1.0265297200388965},
    {0.7028072496935132, -0.1358138664615452, 0.9934822218972525, -0.04159646120703537, -0.1161192356616356, -0.9311662741868931, 0.8566229473809897, 0.7078694347248216, -0.03941090651555444, 1.1743113352756416, -0.7812332541023257, 0.8050511035603846, 1.0360638799580675, 0.6229752734022349, -0.3580419378574221, 1.072840257095792, 1.2451284274207177, 1.4488608829645406, 0.7324637536666522, -0.4278290540533551, 0.035502687549823636, -0.0968413521708432, -1.2082874432788793, 1.3225240237206437, 1.6743037091461472, 0.8836856715587867, -1.010928143789933, 1.627287853697824, 1.024931985752378, -0.42170039918799745, 0.6177038909377025, 0.7827612276972388},
    {-0.47893416158100965, 0.0037726891875704857, -0.32263850787332454, -0.15926839710570245, 1.5624846053407138, 0.8659606470568628, -1.1305898990415661, -0.32815876639162644, 1.103062733064069, 1.2089273855750131, -1.0221461719939464, 0.21659408493283788, -0.21790573771075394, 0.15671822352113068, -1.1612423019730123, 0.8423735121306095, 1.0843509172515589, -1.6909861301692843, -0.5439366336927344, 0.07354830341525764, 0.42536287830606667, 0.6257061993472565, -0.19433461539992428, -0.20438981307843454, 0.7412196370926891, 0.602580952951758, 0.03728632608136722, 1.1446905634190514, 0.08401392266980244, -0.05224847016249279, -0.48007148526829374, 0.567027413405517},
    {-0.6265967764621063, -0.18154438884998383, -1.304313045478676, 0.14870740757389225, 0.08655460082302398, -0.04833847442760691, -1.4964781673284706, -0.5838766999976871, 0.138794981834242, 0.5862891477275756, -0.3217856453408002, -0.6259605008840994, -0.772576834576055, -0.05574832463362454, 0.10586419314679694, -0.8018680020769693, -0.5393563384209044, -1.0047652845208639, -0.33872243175197875, 0.14384513171954094, 0.017894425928184684, -0.6100714967385737, -0.32364408098394165, -0.16760158536199934, -0.4108277407942815, -0.0826653103503445, 0.24022538600605603, 0.3285607692182785, -0.7942368103108729, -0.6766202912256604, -0.7740526286065003, -0.17201706186792626},
    {0.24119285403935503, -0.43634321782176716, 0.16579855891281844, -0.1968906075568318, 0.5841543080926344, -0.047210026210058674, -0.21929905641606662, -0.7313130921771309, -0.18521502476673163, 0.4679137552497541, 0.8493423384873358, 0.5197022729724923, -0.09026612603676473, 0.5985925749084849, 0.44564085680200016, -0.4213397963569699, 1.1080872681950804, -1.4753448659408666, 0.9908294616510098, -0.332524325552858, -0.6054620577178227, -0.006690235191716166, -0.5875527370715558, -0.6060766566908994, 0.6314070350246318, 0.25147668116668415, 0.47184009932424953, 0.8478806272567375, 0.4081287218033603, 0.6139187326520511, 0.44615649157045056, -0.2767762404672563},
    {-0.04095695370265018, -0.29037977181704117, -0.09199868043058423, -1.1756306379876655, 0.035205581722298186, 1.6712993862940624, 0.5361292099307846, -0.5792992437803897, 0.31765659836826204, -0.4636410552948967, 0.7358229423613737, 0.41837097397493284, 0.8027572531167825, -0.9849397924186297, 1.0712774853524798, -0.5329787686958894, 1.0543930845709006, -0.42695671413077696, 0.7246025072081784, -0.14247163882468622, -0.07980550314785702, -0.2642313859725494, 0.9736476220453916, 0.41699772248007627, -0.9627188944602371, -0.8657013480072753, 1.0661893144593522, -0.24392381203744049, 0.36895481570240674, 1.0723972171514446, 0.03870504848488272, -0.3880507944270217},
    {-0.19453563812209182, 1.0134513138784047, -0.5501012145224289, -0.9688235711190132, -0.9237381384928663, -0.5879212272451485, 0.7381436343922355, -0.5676053616651018, -0.25556172354128526, 0.09033376663369849, 0.9355833578180751, 0.24486929362586307, 0.8183322324655761, -1.3528693752418754, -0.5185980569460671, 0.41528400189090464, -0.5539852576777728, 0.47936235862942633, -1.4395915096056868, -0.7003992197344765, 0.5709527159848231, -0.050330804577624476, -0.15869020708339693, 0.07843834502450325, -0.30009725810192855, -1.0380725428423574, 0.4898357010822622, -0.44345933685119515, 0.40535014811205483, -0.47898091637166484, 0.411450733434849, -0.1569106663142948},
    {-0.6685416023088642, -0.3361409155565184, 0.21790753238449326, 1.060929245135082, 0.3353969931682798, -0.982988618851874, 0.2573594565444391, -0.3064732547519292, -0.07961090900004143, -1.0434520084520345, 0.595491408298563, -0.05541488615295514, -0.22707690249665902, -0.8498716829595668, -0.13137460585059266, 0.2892756051892472, 0.7025063205402814, 0.39831847505742085, -0.4048261258354086, 0.15105157895654037, -0.41648513580465474, 0.3026407692408968, 0.10745554596867082, -0.28643251663099484, -0.3788454790052267, -0.8490580309231525, 0.04703780727775282, -0.4402938647452456, 0.9160766227528107, -0.030101988989103653, 0.7719648203634768, -0.14339658006362943},
    {-0.8585684795239353, -0.7618838148100506, -0.4481450788592805, -0.11021830924652536, 0.04197806631304593, 0.42863267127969457, -2.331774795071383, 0.22170134915000303, 0.222413096137123, -1.4438064515802576, -0.7357152155251093, -0.7707463708567688, -0.6495270997151168, -1.002700907278256, -1.001259421616731, -1.5008629437209329, -0.5959903879582688, 0.5586675436479562, 0.2219120965650135, 0.160123229373651, -0.22471070847469546, -0.21315776684694127, -0.3988235287533061, -1.0243961315212888, -0.5782935750420466, -0.19205494660932512, -0.07334896195533318, -1.1106777854483176, -1.0305486114590945, -0.6736530534251705, -1.7543090097175802, -0.258427813420165},
    {0.08842480114429964, 0.8683352007761668, -0.359287977370068, 0.188871736824991, 0.43716056719366414, 0.49156862971275184, -1.4515160660247193, 0.7937702908264974, 1.4356480988500933, 0.44053239748656886, 0.952970899123734, -0.5160044811758576, -0.2066600039616923, -0.08258182118658039, 0.1473006577998477, 0.564011580041627, -0.5402333933219777, -0.8994558837214682, 0.1704700404450719, -0.12599789730696226, 0.787616154641214, 0.3659915971442697, 1.1185522172324103, -0.015225682013994782, 0.26570037426507603, 0.05017666244178556, -0.923935503268897, 0.5599726640525918, -0.013725283489080652, 0.537945601447497, -1.195076370840473, 0.9873541313852497},
    {-1.5032292550195956, -1.111462316224037, -0.5617478950230419, 0.4248610172067564, -0.25634059081320154, -0.5064947713703929, -0.3277823196663298, -0.3853028964214698, -0.23960354884856766, -0.7612553672511398, -0.19020018889408769, -1.6451215372892694, -0.08879077050049074, -0.023185159184619487, 0.0003147216377735544, 0.13462837140196904, -0.36011800918180037, -1.119292913357923, 0.04313676843040891, 0.10316664643346142, 0.20279373560060993, -0.4505709371112495, 0.09978893400451543, -0.20421874046303726, -1.1535325146950803, 0.06127425053179128, 0.31224436783146486, -0.4089988584868881, -0.9199821757921587, -0.469365303872148, 0.3572742200190582, -0.31021543627309345},
    {0.34323377341197164, -1.0222242889053375, 0.0025999751290945914, 0.5908584813087893, -0.18340398988955847, 0.055032646108062196, 0.7772020200920973, -0.6976323423277062, 0.44070233613512577, -0.10821459853672258, 0.6184817829183169, -0.30831194494584496, 0.33204793639032293, -0.18205095443669195, -0.7216050011890668, -0.07153120198420573, 0.03899984823113953, 0.08742242098700861, -0.8544396571354155, 0.6342702821021673, -0.1245099073371389, -0.6886785948567633, 0.43181294380971347, 0.4749679343592089, 0.13191106796459173, -0.08031370081919069, -0.026669582090547313, -0.809777903101254, -1.1604617533490316, 0.6004853003681254, -0.15796503781259433, -1.179656893878685},
    {-1.2643577916920172, -0.8262813630201122, -0.9658443570320153, -0.4546941026519328, -1.7544690214761247, -0.05521302897671827, 0.10528425714645921, -1.9177900479225027, -0.09376723574918847, -0.19997218387104912, 1.214947798624379, -0.03512801509399605, -0.8443591677526321, -1.1392556603050714, 0.41224333317726314, -0.6670578130788457, -0.24421437608799265, -0.3902080528497513, -1.2763400820582256, -0.27760209726126556, -0.6222663529767332, -0.1807747828399013, -0.03079999594364308, -0.6380107119951455, -0.10602419457049572, -1.3113124641637437, 0.20174695189235353, -0.3173186624265591, -0.2588785224195215, -0.0976687881965089, 1.1446488972582864, -0.7230351631813455},
    {-0.34199705052835566, 0.17167694188834584, -0.39620946971402843, -1.4222960475510094, -0.061803117300112155, -0.29543233295494326, 0.1500292238980691, -0.47105019780260315, -0.31718547428826654, 0.5502053494460232, -0.5310981634633081, 0.11782012195592367, 0.6174971462419475, -0.07859750487154457, 0.45161918491516506, -0.6648647745806135, 0.8688059721222935, -0.6397844068430347, 0.10591523660145989, -0.01807136019987226, -0.16371186976078447, -0.186267217559198, 0.025931129526485828, -0.47074346384999793, -0.3190237550583229, 0.36708493653845314, 0.22231708215665294, -0.06063067564671494, 0.59961813394566, -0.41665386158007794, 0.4868697563454297, 0.4411648695007825},
    {-0.4369806387164438, 0.6060453766265512, -1.1110305837158907, -0.6551865029544245, -1.2483626995539545, 0.08880061732108115, -0.39495307857648465, -0.6460048338075299, -0.25620891307906735, -1.0613538731609173, 0.11809379562410381, -1.1221026713571216, -0.9489185942323246, -1.5550843215187191, -1.5052620199282665, -1.389504628142984, -0.5834869302311783, -1.1091437966894098, -0.17636105842256458, -0.30513542019794476, 0.591471753925717, -0.8113579088435965, -0.35207952664017833, 0.3446276149864964, -0.4062572128439371, -1.1864413964142786, -0.5374172527175956, -1.4235304149944665, -0.8839688415218908, -0.9634063790301547, -0.6631331005998472, -0.49026951279729186},
    {0.627991154062738, 0.418879024051602, 0.2478327703478483, -0.9874372520857173, -0.38947058413563707, 0.42508851806136555, -0.5252738305547754, -0.32163141873290824, -0.20810835810395398, 0.051697495196343944, 1.060869009437995, 0.5514370765064281, -0.8346446117217954, 0.4705769023494754, -0.6757660728188323, -0.5141051969797383, -0.34112598512703945, -0.6412612376394803, 0.1754217333993574, -0.16951776682668782, 0.8666416416971867, 0.6545905464656037, 1.3408138528192957, -0.34910773450624305, -0.17132314581655228, 0.05191413770707241, 1.1102399825253457, 0.6767851852152384, 0.02670852508153564, 0.10205101859095493, -1.2392177922991285, 0.14724672888449414},
    {-6.1481625969441716, -4.074532152791599, -4.758243488674594, 2.2467499967976923, -2.6089547901178234, 3.893906442579852, -0.730317338446268, -4.565665252535428, 0.9922152723423985, -6.643134302784842, 1.3063767432187743, -5.8013352527499915, -5.991073321742071, -5.031848977738136, 0.657518894559543, -3.0255133163338535, 0.6502846050182438, -1.2115646172736103, 0.4664757758113496, 3.1712656668058883, -0.02362951448595195, -2.1372732328903257, 3.874304123370774, 0.2291706494003548, -6.955410436949468, -5.1995047482023224, 3.7456493773976827, -6.226921448418237, -3.092137684816771, -3.0524324170239217, 0.9438429101771859, -2.901145012940682},
    {-5.417822825188606, -5.425606801759431, -4.378174741713699, 0.6177691713740875, -3.7329905375648633, 4.465988205524683, -4.149122490639572, -4.421195680814739, 0.7456342552219412, -6.262913957899185, -0.17608994244552734, -5.21228159897655, -5.590674443763862, -4.852009321059832, -0.6683376001392173, -3.429380066519575, -0.4503961774792508, -2.458253768513631, -1.8446711348121754, 2.0525214333932507, -2.3955154739234246, -2.073325708135014, 2.7570961776032887, -2.5371073652966336, -6.123702969801663, -5.1281632999746565, 3.2825533399561855, -6.119352008429416, -5.3078558593925615, -4.232757641056627, -0.9053018546437609, -3.7653736136168345},
    {-3.8453227862468586, -1.5647982654933204, -3.3119452172768877, 0.6079958173890503, -2.8096562829920213, 1.6069968406921296, 1.4687440053800116, -2.397518953225457, -0.6330949890124296, -2.978207605909092, 0.1690634846464086, -3.3755791304819875, -3.429035852128209, -2.042455148296363, 0.07522467529402369, -0.49756659865874986, 1.1625460013987847, 0.9495888776296052, 0.40819349780484804, 1.2770208551760327, 0.44758815831571297, -2.215256342909891, 1.2078526140693024, 2.3432936202025254, -3.1300449746780403, -2.588822644676893, 1.4369977376381147, -2.2028919483774456, -2.406705528824989, -1.6492608629203973, 0.44561922370296164, -2.31357244417782},
    {-2.450761849818567, -0.6724101168038514, -1.8136218148727499, 0.6560959283749734, -2.101539772350351, 2.4198541764804995, 2.091505350658787, -2.3997064283529825, -1.0114255945774202, -1.9065040524163963, 1.562709292788641, -2.2756217431318637, -1.6747611234455888, -1.5382622102560344, 1.1489956053244077, -1.316125956512938, 2.0056670405523813, 0.6394152347670596, 0.7569730021311808, 0.3106124347467424, 0.8672949915500587, -2.0207805771210325, 0.419444405583786, 1.861525745874582, -1.8647944312673248, -2.638957459849975, 1.253164360731305, -1.8974630151686918, -0.5719965188956987, -2.6465334453084415, 1.2381591297718273, -2.3951746688923583},
    {-1.8365791487344867, -0.5590404211051598, -1.8854356132163794, 1.622462587314156, -1.488456042341622, 1.8414203819799668, 1.5765403038537777, -1.636029022892625, 0.00645256714618871, -1.884118267153138, 1.0452416431859035, -2.133382154025444, -1.6503227816074342, -2.043149405633715, 0.15821129193183184, -1.7796169255620589, 1.1454735754633512, 0.28671390232347804, 0.4351197024559694, 1.1043457821150984, -1.2538943427304126, -1.1657398846172984, 0.9631193527031231, 1.1993953946544327, -2.6661924093353737, -1.8979586627284692, 1.6949790503305677, -2.527633085234411, -0.6289853914472759, -2.4313215207950307, 1.3436505991672538, -1.7113003304626049},
    {-2.001798374417864, -2.954199536482967, -1.3304018575720544, 2.721408922673038, -0.4846674587797478, 2.6659065017898627, -1.6781352063794508, -1.6573876660160907, 1.634951879534301, -2.7144273732995146, 1.7950851517910256, -1.8647302219835502, -0.8938881537059682, -0.8077830660516357, 0.9650420577539714, 0.2515279808782823, 1.0819044786101097, -0.3314447757492418, -0.23488726448074732, 1.877325100636315, 0.8790765183275207, -0.5194419135234326, 2.102363475914479, 0.5560564968555257, -2.9937016608793163, -2.159268013637516, 2.1989639261844642, -1.8133602003362481, -2.729414717266689, -0.5652434403109222, 2.3608994491800903, -0.9000852181880394},
    {0.13271705649842125, -0.9326659065565374, -1.7768720953995045, -0.2187900071399786, -1.9886643621821571, 1.0643511198447129, -0.22320140650759004, -0.25022522333711666, 0.07643421954927075, -1.5081905631832593, 0.2776416760805016, -0.24931548455815547, -0.8465054433016349, -0.878757360624663, 0.6990415079705996, 0.3904407732350011, 0.8615377682239866, -0.46807250060387967, 0.8772678189193798, 0.7861448335676857, -2.024898077651681, 0.28865100137609007, 0.7745208617434952, 0.6050133471080361, -1.5023843136469528, -0.7403045475000596, 0.31626250283719787, -1.359123082189667, -1.5032439230812984, -0.5030232954359808, 1.2488432241182421, -0.22861389769905818},
    {-0.6009230024150443, -2.5029311040562843, -0.818746820476124, -0.5157903082883964, 0.3981520969747851, 1.3010496172382604, -2.1760351962882445, -0.3722164586863307, 0.6695450351851407, -1.4308769984464729, 0.4221815815848987, -0.08195812984433358, -0.6020635616402722, -0.5070269022743443, -0.31252390525572055, 0.41691336358184505, -0.6706815763195265, -1.6201765604718918, 0.44338179168369285, 0.7883231298933745, -2.2847950635107477, 0.7848773265796021, 1.3774977887825008, -1.8181250174995351, -1.7676328366343859, -0.8131764443712409, 0.35709719962437364, -2.318833187350664, -0.10415637798758859, -0.3346752781635478, 0.7618519805485119, 0.42636976785216424},
    {-1.5216066996110995, -4.126455400228558, 0.08752452375378511, 0.07999037382977821, -0.162014396382504, 1.8410807386518302, -3.4200881991429095, 0.3161436199124585, 1.9989330205935136, -3.116991562358692, 1.99036573473665, -0.588334277837719, -1.3095448277358555, -1.415913168588178, 0.21672616705849743, 0.4530562823154062, -0.9547478480932685, -1.0130030945015687, 0.15786483395344658, 0.3268849125417175, -2.1392437406894493, 1.2666780683900698, 2.303777442262314, -2.010774788322176, -3.570340316876172, -1.4205806824997322, 1.0916735875351862, -2.5985487584019, -2.6511174815919443, -0.4963829598870952, 0.3978295693396915, 0.3024676908977756},
    {0.2766582176596993, -2.4240023090228817, -0.47587153720737513, 0.7026357286872189, -0.472402605052608, 0.07786620228572318, -1.5464769958182767, 0.10089325573779885, 1.5580514492431379, -2.4348305030401285, 1.2938154456896622, -0.714866618798066, -0.8451693073433189, -0.38835355701552865, -0.5336808687087501, -0.6999383628768343, -1.9027125505337261, 0.5337454680025779, -0.2642237493734442, -0.7385623815438972, -1.4590426931108869, 0.5330925360181971, 0.1383029842560639, 0.20512941001104054, -1.6711283279601927, -0.8580146005675953, -0.008209966730131019, -1.7478063720034642, -2.674242882091886, -0.5145204016029956, -0.10470497848462187, -0.16260843253105903},
    {-0.5415714763356669, -0.5121049530396725, -1.3495897511940977, -0.08833533327453012, -0.045711147379088116, 1.492085401398703, 1.3700402529140523, -1.1841559060931057, 0.7585306052380738, -0.6129877798449075, 0.11657580227237634, -0.646419354299326, 0.5795327191252482, -1.0115808210202109, -0.14683203540249842, -0.17078955614298094, -0.33240599828005596, 0.03052848275545314, -0.698334247518532, 0.17700412836144913, 0.23446365414032366, 0.049846060268604137, 1.5790021378798056, 1.689189121065243, -0.9293357739912784, -1.8122834637691556, 0.9621831295095884, -1.2823918568849713, 0.8887811833558605, -0.4554789148746431, 0.4856598379853115, -0.4114715813061285},
    {-0.8612664393867356, -2.213229499950947, -0.8546635038099456, 0.2637715065786701, -0.019224640587926205, 1.3894881862892763, 1.184764362205507, -0.8253858218152912, 0.7207699398647445, -0.967123587512296, 1.9488580954357193, 0.40064779914385096, 0.5526973179975201, 0.7465406193390275, 0.039189051358246366, -1.0363739471857005, 2.209418303037985, 0.4828618689844007, -0.2605215006790924, 1.0879889573835473, 0.9081517473536225, -0.2837057818905638, 1.2312340733968496, 0.7746525800775579, -0.9665367753964287, -0.14386470400366014, 1.4395790145945826, -0.6114613395876188, -0.38174490103863135, 1.3738096109816957, -1.1861549302947516, -1.1843788692693453},
    {-0.8449022619369833, -2.883168974895878, -1.2847987782399901, -1.2079701386235522, -0.5095938106593769, 2.215530449404788, -1.7558940820355293, 0.11248909134262677, 2.1262473535981252, -2.456896293903508, 0.18910469021742626, 0.30776392618116005, -1.1324388448970535, -0.7771016855012534, 0.40747183978697393, -0.0986388160060279, -1.8171692392704486, -1.4648136833118248, 0.2748065685413656, 1.0677247741331997, -0.6544311115796589, 1.009020993330874, 2.0520727562508916, -1.027640456337615, -2.005558133078864, -1.3763062869404041, 0.7969855696631448, -1.8534102672632857, -1.2603823253924151, -0.13277694613171367, 1.1731956480430936, 0.8465878282616812},
    {-1.8826521932897908, 0.2994049688399614, -0.854670668209973, -2.597016301913439, -1.757518275229672, -0.053107864106435504, -0.4498124058347983, -0.8942891235322787, -1.175673821318704, -1.3529761504434368, -0.925672939814647, -0.14196826616352543, -0.9478873338944477, -1.9139832165279402, -0.4280661251714804, -1.086401015561149, 1.2770432656610664, -1.1640360200663593, -0.34224537522849297, -1.0374931841216342, -1.951590336039855, 0.05914629816975948, -0.04708510618606646, -1.860777038626587, -1.236050897813793, -1.6517415321440625, -0.8311154436738842, -0.5066538324644062, 0.6017601218437285, 0.03363759606922849, 0.2869387050053337, -0.84436204169541},
    {-0.7847405732805278, -0.14223539253888745, -1.120302481010401, -1.5996696574922145, -0.5070238322845092, 1.5654620233010486, -0.22465259304593718, -1.4437683838349404, 0.394350912684722, 0.4232677349865146, 0.3316520923066086, -1.6618783051148418, -0.1393998959240812, -1.4699427856138005, -0.5112003521498639, -0.3389574536504806, -1.6051570405960043, -0.8555022558979121, -0.4684622107300164, 0.17014607490443528, 1.9227618339823083, -0.577566882362114, 1.3368711602421768, 1.3163124099831993, -0.6883211739680923, -0.4880911206990995, -0.491202716349486, -0.7103311378527218, -1.8873971599309025, 0.13766701529758385, -1.3898844123479577, -0.4010104457004072},
    {-0.9269486529889266, -2.613133053068857, -0.001122445833695403, -0.7386517625752139, 0.8007915907067956, 1.8430848395825814, -2.169079012950812, -0.1778090992326514, 1.3932872780987884, -2.768236369338563, 0.14564838331063457, -0.8605806404603975, -0.49708412970562665, -0.9717973592781599, 0.32126413070959764, -1.2001078758399268, -2.2794500479596826, -0.8288439251193539, 1.1272981509377231, -0.03249219420715112, -2.0075934747120283, 1.2585740673486563, 1.5295040687691697, -1.8315958239996148, -2.1860349625564988, -1.3667997331231003, 1.234186107439381, -2.1285382698225552, -2.4553073855554195, 1.1136676120148576, 1.5736746021217354, 0.9443126104103625},
    {-2.2688396964651734, -0.4134412471455187, -0.7629797400307593, 0.6911456017446505, -1.0568159787576885, 0.48340253201844346, -1.1230449422791224, -0.47538101199919686, -0.13615052972523117, -1.4695271566956478, -1.9810152732909263, -2.489807711789651, -1.038886432989542, -2.5437669066271273, -3.00310862760896, -2.2946384004147284, -2.31011865830717, -0.5889140021142889, -1.2535912302780428, -2.6279296751939736, -0.35353811288736153, -0.1128666024535471, 0.544346617540267, -1.5841640477291008, -1.5333302806138913, -2.416995556428151, 0.15670183860448733, -2.327253977153332, -0.2883285184374504, -1.424926480994361, -1.060007839380975, -0.6363146893428604},
    {-0.9316717729539786, 1.061892114073862, -1.9173693341974827, -1.3777431932206543, -1.603280081466597, 0.38107987517477343, -1.2034985175790303, -1.0327370213604181, 0.5837528711439883, 0.07661943235216356, -0.3255933222066586, -1.128830153671137, -0.5214325489665772, -0.48659803251127726, -2.0748295388623688, -0.7599007809575211, -1.2099721541454473, 0.36767352465681613, -0.2901751037215663, -1.8659188477617459, 0.6363505472135765, -1.2827542886206933, -1.1901384895919411, 0.26087386122922984, -0.4821722766173843, -1.2244516903928888, -0.7238577791259934, -0.4268867230247063, -1.1858090304479392, -1.4261757789464613, -1.4941021210309882, -1.6888660805106779},
    {-0.7507679096813841, -1.6233993834367697, -0.3845693895007625, 1.3406489643992316, -1.418053137123243, -0.6267446022522374, 0.6810436068010158, -0.14854027574801498, 0.6101162007975186, -0.09558548313182817, 1.2683641186155163, -2.017248683933519, 0.8201611021205407, -0.11761304665302384, -1.4641791347720505, -0.7975105216820827, -1.4118842887754557, 2.4678355890818717, -1.2227553469654113, -0.6281941105886046, 0.6621118878371574, -0.3416915712380218, -1.027887718456737, 1.190224200217713, 0.3917607333077643, -0.9789343522044183, -1.2640681314706133, -1.0863590287021956, -1.5130985029823805, -0.8829725488483823, 0.30239892175144495, -0.35713881893866695},
    {-0.8698350149374181, -0.78860561240319, -0.06877103429846039, -0.7512747516209256, -0.5282577751937144, 0.6281713450806932, -0.3596554165747251, -0.6944660229347777, 1.0346904099293395, -2.049592189019536, -0.10355029415916499, -2.133305222447043, -1.3700964192430691, -0.11052847489741698, -3.3401849036949294, -0.03860082604084003, 0.5920420294057726, 0.3442922903272049, -1.002390143143566, 0.004836125780532277, 0.5383561066546402, -0.04677467279244952, 0.654367885381324, 1.2664653378755661, -0.37341512917096414, -0.7360735360217323, 0.42194684953266715, -1.0060593223929786, -2.3007520056806086, -1.7711525093952005, -0.26113867101313903, -0.3114787714970942},
    {-0.5105711587683671, -1.0302495608730902, -1.1854977709992478, -1.0789423561241798, -0.6055185430253238, 0.30113068866142095, -0.565147219756242, -0.10014842085781618, 0.43880553963313185, -0.5472359760678573, -0.6729317951891167, -0.4170496662800597, -1.6246348924287122, -0.0815079141796004, -0.94333310070695, -0.9607964351524756, 0.9445373165831059, -0.0038218073685562866, -0.8866031291569658, -0.8677574500897582, -0.43053838204447026, -0.2839734097531997, -0.4549030799502675, 0.3189349722720116, -0.1823799353824132, -0.8503670576999994, -0.8657910207340682, -0.10932895007460858, -1.8667747619688455, -1.4526091671755585, -2.006807999217531, -0.5005892760544461},
    {-0.9128091260701793, -0.5757785493670937, 0.051232498436135705, 0.3011477306629006, 0.7389113446155983, 1.766482322028597, -0.43124474611705915, -0.45099753650725644, 2.893545977648441, -0.188393631841331, 2.8970319435144805, -0.134799208453499, -0.5082376659235954, 0.7503211150618266, 1.9392629057527853, 0.034169037641504044, 1.1400037336589026, 1.0580174619368024, 0.01927032834729875, 0.7751624109536809, 2.543656035694637, 0.5337042072198579, 1.144858788187235, 1.8490739290001472, -0.19765964337576578, -0.5383691311798973, -0.02031791592246383, -0.8986759811592624, -1.6086053067882349, 0.7355171616606083, -1.7029115994722919, -0.04354423130615432},
    {-0.061588656360714214, 0.2808342559982792, 0.011188684477806821, 0.8827772871505727, -1.0801320125798701, 0.531582176888306, 1.8125772200913883, 0.7450509157510101, 1.2392486511484493, 0.7584866703802892, 0.30331935622576534, 0.32304863166009923, 0.5749373055377531, 0.33433650386754127, 0.5470405000131517, -0.8237822596819115, -0.5927198259258486, 1.1195814006354545, 0.41062552226801147, -0.38625973566783495, 1.904737714521484, 0.06726435963090668, 0.40063409741706046, 1.3827329678824867, 0.39225916962607854, 0.8785138142615728, 0.5683360276436489, -1.344467910554276, -0.48470403923832583, 0.15073808516624068, -1.264875167945904, -0.04626236416019921},
    {0.6998176156142071, -0.4676233014760713, -0.1516675227658811, -0.4675850442004842, 0.6695256522365466, 0.24824720417361845, -0.9324098639740318, -1.0178634166996825, 0.04919947146983524, -0.17786441079767257, -0.988959364662733, -0.7232644170634916, -0.6070388048720525, 0.16734274875153882, -0.9799373054771315, -0.4450000971659106, 0.43065651589711035, -0.609196352134219, -0.5375776790517212, -0.6872259593906049, 0.5538947307880846, -0.260329621464953, -0.41613273661828665, -0.8348279467610686, -0.18596971442475954, -0.1864992799268997, -0.312586699471737, -0.5552062408834881, -0.9156870052532476, 0.3848703934470513, -1.2471845331749136, -0.4811754604489788},
    {-1.415255942086674, -1.662233393311655, -1.2638099235225244, -1.1126942895120455, -1.173356068596296, -0.07740397528984953, -1.513811627031352, 0.101744437018921, -0.2974225962109224, -0.6574007203486452, -2.691230860215411, -0.9415284784862855, -0.924280822842734, 0.4047280860396566, 0.028612334188232308, -0.6393804498735168, 1.0671517995566937, 0.2713922043862202, 0.6039582891637472, -1.414581939164886, -1.9348859256949724, 0.4233510036418194, -0.23138623632973299, -1.613915914137595, -1.536699454145362, -0.20135993023634366, -0.898923005584533, -0.6335201651341371, -1.2391476213472532, -1.4142665508395478, 0.23407909828153833, -0.36999840053718686},
    {-0.4540079368900771, 0.7424333255760449, -0.7882328859892465, 1.0431266565791975, 0.011386660585517992, 1.8649377223265635, -1.9099203689219202, 0.4680454958597404, 0.7464163705367499, -0.07232060229296704, -0.27031643383868714, -0.5358333356118435, 0.22406122037353743, -0.8559231989659675, -0.6443097888156459, -0.3540109492467996, -2.0431716785024836, -3.0304251445437123, -1.400233520586589, 0.3657440364937755, 1.801464872500326, -0.5003392891611516, 1.0764877223264613, 0.23823558441310494, -0.5004623116728214, 0.3439388919488751, 1.2205447445386783, -0.43164016571777497, -0.6652926622543287, -0.39201463603392656, -1.9475451620785573, -0.5152354486204057},
    {-1.5101390442406073, -0.39796899763699517, -2.1319044395037605, -1.7654008710717688, -1.29675655637603, 2.9500387678685724, -1.4000196437644983, -1.878176404141523, -0.40662108503259525, 0.07335678775277993, -0.8101776229200612, -1.158781742884299, 0.21415538312014165, -2.065336546941607, -0.561397508652821, -1.4148495135097232, 0.881110591712292, -0.659247572360785, -1.2088288773985891, -1.3588318997094173, 1.875793672856406, -0.810424245726767, 0.06994645990106829, 0.8077784868524215, -1.1245220287870616, -2.3819628978844873, 0.3862232489955841, -0.5841621297243107, -0.8075794048106621, 0.0964684717350033, -0.5883274043966153, -1.2659111091517006},
    {-0.439881424064481, 1.4006047400459174, -0.72806087291602, -1.4598934798245944, -0.7585572493931129, 0.9295944843956286, -0.7138731292235588, -2.084486324669208, 0.10973555602765024, -0.7459698225483787, -0.10373838712241512, -0.7795966298770798, -0.09369440107024245, -1.2925506495412264, -1.2316754243424404, -2.64686037266225, -0.8897365854362289, -1.2759120845750132, -2.232027314098395, -0.8643116839780058, 0.8566752014281577, -0.14483917130141724, 0.9153023046110811, 0.1027340486115405, -0.7592398400344823, -1.17132940488462, 0.7047350632840411, -1.2038833299916856, -0.8627034098051004, -0.8296069395115971, -2.790260306693562, -1.581007123437084},
    {-0.6753373728002675, -0.8605590944903702, -0.7444360018868157, -0.06118819082056396, 0.0008966423131068759, 2.0758720569625453, -0.894868549427582, 0.6536787857468112, 2.007466121634777, -0.29184094956150836, 1.0218810480168212, 0.8274675324432554, 1.2134107767121964, -0.2652810341570147, 1.2519094843914016, -0.5535781416990407, -1.932274105544224, -0.7702861794483344, 1.1900707572897495, 0.33813218850158705, -0.7009795273887588, 0.7672816924169482, 1.0854797037244859, -0.6229233028101858, -0.829106854562609, -0.4541641975608611, 0.41516041932049347, -0.7257992917674138, -0.3410622604250313, 1.4776419549657336, 0.2734233239718217, 0.8622299978181129},
    {-0.3009029209580956, -2.2933757700716155, -0.6211705667337154, -0.649266642815712, -0.8534017546236639, -0.23981760415806944, -2.5068511714296466, -0.18977909778050325, 0.9363032906441162, -0.7991738306909582, 0.06688508918249983, -0.20821394004309343, -0.8297496688626244, -1.3059680573038448, -0.33409333500495536, 0.4714688476042038, -2.2721547535429574, 0.13893470181189527, -0.8871140384480934, -0.3545015873555356, -0.5911542032160922, 0.2231894559377455, 0.5501972904747123, -0.6824764455449492, -1.0364823126572742, -1.0201693908533864, -0.14573938990722582, 0.09293665720227656, -2.111286855401765, -0.6786137104159194, -0.11927764266209656, -0.3310313250312738}
};

static const float b1[32] = {8.26599769259222, 8.35792289301722, 8.417946315278876, 8.472355769117627, 8.63709828955792, 8.55616655180432, 8.238971828029632, 8.225187979520971, 8.465140481591023, 8.184402120695994, 8.434608339516988, 8.259979011503226, 8.27923819034385, 8.178069090766947, 8.233288696462667, 8.275435149738048, 8.153226757450993, 8.049253444177415, 8.312126679906127, 8.684853744934257, 8.347060450893167, 8.4069724972302, 8.647479082622617, 8.283097286165221, 8.148871990582352, 8.278630982585739, 8.435245489365984, 8.296922953940385, 8.138601458789024, 8.559751132760933, 8.328398011450732, 8.428284010342994};

static const float w2[32][16] = {
    {7.155901295873429, 6.551722759581383, 7.389289007400014, 6.417321184676959, 7.441342756636604, 7.171429901374394, 7.306588621258101, 7.038495977468029, 7.0956310961444835, 7.259341126561993, 7.189948286683243, 7.336416001653699, 6.240024270207037, 7.121501769294651, 6.943996148385701, 7.525864497912316},
    {6.656258313101621, 5.931559986823924, 6.6434483438298795, 6.375000945945975, 6.996972034320692, 7.165080205688222, 7.111155334770788, 6.497170040240059, 7.291936913134289, 6.706822511173362, 6.469060552023107, 6.812660302531693, 5.656570052459476, 6.940077902932138, 6.818500422130316, 7.258511714700955},
    {6.929642080133272, 6.358895731180415, 7.226820408432153, 6.759157311451954, 7.270761093396868, 7.023927226486124, 7.3043801070975265, 7.017175104204773, 7.223873559574224, 7.208352592508711, 7.033597099794087, 7.280246156009934, 5.9816034163184995, 6.9892161955908, 7.0326814686659604, 7.2382210625433006},
    {7.888769278081246, 6.579769024537287, 7.30883300620339, 7.110206081143536, 7.837416932262058, 7.497862162405604, 7.396676739609465, 7.257664817569798, 7.54830332479602, 7.639369506049858, 7.221317809700266, 7.570800306734433, 6.547320453400329, 8.088135168725016, 7.446765030819051, 7.335745358248175},
    {7.805013286255841, 6.596971164699943, 7.4228113577749015, 7.0806274402376435, 7.696502928113673, 8.038788442412892, 7.980364628091999, 7.5819507558667265, 7.542348825893382, 7.7364036503257045, 7.330921935629279, 7.453768017196507, 6.918751057941502, 7.967030241514637, 7.297271642722249, 7.598442558302501},
    {7.417359851911171, 6.5744063512202455, 7.827072887883597, 6.863356771845212, 7.8308132750927895, 7.777162500672398, 7.769787098981182, 7.6554181188540955, 8.016853599678946, 7.684783710004955, 7.744346974833713, 7.6375842930944655, 6.642765485287094, 7.740077785339389, 8.05074523418431, 7.707974431791954},
    {6.7041610174829405, 5.88458028945998, 6.772837527723327, 6.403167299591172, 7.047887966688394, 7.196273137783647, 6.699109450483713, 6.870288669028194, 6.849657484771299, 6.870962541417666, 6.438877334265836, 6.867357769714886, 6.107472227829124, 6.86851266590889, 6.753308412820804, 6.909146696141921},
    {7.697583610337114, 7.2034403698617, 7.646136231046016, 7.348100193678698, 7.612224344559854, 7.734388749853303, 7.302786299493262, 7.557221456646869, 7.688648948344678, 7.166226646770891, 7.636181956005172, 7.592808571919087, 6.5793948610390505, 6.969150397724258, 7.500799457920084, 7.4650309508347625},
    {7.830138315137638, 6.842217264267568, 7.198564146857068, 7.128660347904112, 7.717587710380287, 7.421660056099713, 8.038557998081613, 7.460704947102717, 8.066185890745224, 8.019911649387563, 7.025229704385245, 8.280232852422339, 6.901721722974349, 7.2515737430143155, 7.821058442673429, 7.471047600704578},
    {6.924836824056904, 6.0960368139493974, 7.138523655398456, 7.186009778599996, 7.356424210917188, 7.282906205651098, 6.558951594805994, 6.834147564486731, 6.567867180830571, 7.226963900050346, 6.907428799171191, 7.1398441837620705, 5.91509319493436, 7.014627508675952, 7.192619374534858, 7.0883080542915335},
    {6.905929432148999, 6.0611369514525855, 6.704764078741709, 6.468316071552178, 7.485625308626279, 7.356778877919678, 7.0754010754784575, 7.368293392137293, 7.465680778842306, 6.970694941320567, 7.196320724048134, 7.158179464085196, 6.117818316854996, 7.211887924929076, 7.183577679541187, 7.375429173688919},
    {7.60462707905598, 6.678973458395483, 7.264012652947125, 7.154724270446196, 7.649524363383176, 7.382257916893048, 7.633030824368851, 7.531209329591801, 7.521250575467674, 7.444530851925861, 7.439161199554828, 6.657093280283542, 6.011054735200245, 7.6416755391915565, 7.119003505798076, 7.185268302608686},
    {7.178848905085753, 6.81343939655939, 7.107790474793903, 6.85787878128329, 7.245788002196172, 7.123207210898888, 7.13549289645811, 7.359188645264961, 7.581461308977155, 7.5896561818925505, 7.2212501099823205, 7.319908070299826, 6.1538067185029846, 7.583465384293227, 6.7433800549094505, 7.457598432039875},
    {7.31330953881345, 6.365923249192788, 7.009614711225, 6.882616067348063, 7.470644943268826, 7.563129209372221, 7.132694755866785, 6.829847153995679, 7.823302369564869, 7.0742680512128, 7.527202349926325, 7.389524129845524, 6.269852419545781, 7.048667223298499, 7.344450056895732, 7.34381629775215},
    {7.408966069750736, 6.548789846624085, 7.171564629551658, 7.207503590764616, 7.557052349956595, 7.360082933693208, 7.477888680424205, 6.984851613329435, 7.306399526503817, 7.68538862935693, 7.6137056588733545, 7.775915124242672, 6.892521043594292, 7.487505712017036, 7.605734096890064, 7.9604963038714205},
    {7.186735378914739, 6.325956644420133, 7.6805982617680915, 6.730181195844631, 7.612149095806744, 6.963868401869638, 7.091829885140636, 7.355162114504751, 7.526232541374383, 7.195885352782319, 7.382690553116645, 7.4213814722603875, 6.299666689654784, 7.887567124182578, 7.455225890309843, 7.385957417471822},
    {6.696118246458664, 5.973348227072351, 6.607200269148378, 6.996190824253127, 7.250879978266598, 6.70149170404912, 6.772233779337548, 6.745159634073431, 6.853684506809765, 6.54611247905206, 6.420619579729113, 6.92044024155735, 5.739386751641976, 7.042589059205901, 7.057115923630583, 7.094574405911897},
    {6.902788704764556, 6.056846033367258, 6.630977661666755, 6.162664435630625, 7.25056508722475, 6.6713032680832836, 7.095049769452367, 7.037690742060944, 7.215322362975444, 6.541409550442123, 6.5464836737865415, 6.9151224444683415, 5.763437989196054, 7.124103224194058, 7.003752803128556, 6.733226662538151},
    {7.387261825746038, 7.056062680174234, 7.38577098153968, 7.162993328373566, 7.699791352712054, 6.696781169599587, 7.886617331602607, 7.7387439022340105, 7.2517431589665415, 7.758028166381128, 7.435792130566393, 7.730831508900153, 6.437528816521644, 8.004816057260648, 7.67667236568016, 7.408304132779696},
    {7.604969045486862, 7.054125379316616, 8.10148442877834, 7.4578163148641385, 7.577544929129917, 8.37704227268614, 7.925808902851956, 7.825722350795576, 8.054236841838307, 8.066548373587652, 7.395838419421125, 8.023891955457241, 6.84389161330843, 7.447318552782644, 8.111278517711948, 8.032254866381034},
    {6.473123324945172, 6.613848610476217, 7.283015485772282, 6.654822118873677, 7.176184963015872, 6.932267857992173, 6.990708265683312, 7.223962325238447, 6.895592772896912, 7.082028890627768, 6.940153548682736, 7.111479318901659, 5.920457300181821, 7.020056874788942, 6.708554874489368, 7.569844167005252},
    {7.402773328491514, 7.027839647330089, 7.988325002627683, 7.215671178458723, 7.560481442287172, 7.606538177173469, 7.507398337276837, 7.783583010121432, 7.367583265208887, 7.809686183813089, 7.7643427185834355, 7.896988516772393, 7.224635536095523, 7.403655220891635, 7.3997155720839425, 7.29297904094635},
    {7.960846521746085, 6.726326227486619, 7.735150678849173, 7.839179838778374, 7.860929014529145, 7.859127134476127, 8.002757545731086, 7.872033765429683, 7.721439893719176, 7.970980949665533, 8.17003624876636, 7.779305045572704, 6.5077119393107035, 8.184137906951632, 7.9902994102142895, 7.815032791035533},
    {6.462799645637917, 5.7272857803327675, 6.791639810039646, 6.869067061772164, 7.362126717776139, 7.026293156132283, 7.581496520706072, 6.622048573689905, 6.652407041759004, 6.67322925106409, 7.04589665456697, 7.774943198859293, 6.589326974814513, 6.706345249336417, 7.193014417873875, 7.656003681658923},
    {7.154906887258033, 6.404333804512378, 7.2561580174328775, 6.973210367058207, 7.382031263868152, 6.874021787376201, 7.230809805994142, 7.22228469263494, 7.109790390379661, 6.981492602067873, 7.07186345513336, 7.371550371001246, 6.62569672904457, 7.294091120957886, 7.448970500280274, 7.422923198194915},
    {6.964749378001851, 6.257606403514638, 7.0533062168768, 6.589023758446182, 7.780031074496337, 7.236953059166221, 7.039914379344242, 7.175617840244295, 7.040978734970858, 7.204080020659062, 7.584172125055717, 7.104072318825474, 5.801533102998351, 7.21319193097095, 7.415733805311194, 7.88284192363578},
    {7.698187894027332, 6.979776859273047, 7.336995868102216, 7.4951379825599105, 8.255700480523693, 7.835369095236316, 7.73127119003175, 7.924074715432701, 7.99154188217251, 7.864570654083971, 8.21140385514596, 7.741847669930432, 6.516004539596704, 7.847467944291997, 8.417802000624157, 7.881176491150117},
    {7.2050618088076215, 5.868934598719875, 7.32868860511214, 6.5248844373758565, 7.048715726025913, 7.177145673655337, 6.953284037118856, 7.121468539489311, 6.999732570200801, 6.58505368265926, 7.07112897502715, 7.1172500384809325, 6.445336057478874, 6.966802122059385, 6.920002895689543, 7.565580469614851},
    {6.856036068918482, 6.4472716758608755, 6.732136677452889, 6.157905583446791, 7.44618470969728, 7.089117065441194, 6.878703173604521, 6.655278393536875, 7.133040265409998, 7.149072870373493, 7.344509842774184, 7.0004189642753225, 6.128080364313845, 6.985016663417737, 6.993186076990444, 6.9546988516871115},
    {7.542852002188149, 6.566963989530553, 7.476996091119496, 7.099715654665048, 7.5752354384755805, 7.788771509318727, 7.937547617827287, 7.401628305190758, 7.171894088309904, 7.63501477915531, 7.704604203220388, 7.573468935335065, 6.498730137212879, 7.6214045671695425, 7.906622413052757, 7.964310502368111},
    {7.316850859659143, 6.84323061459683, 7.380878000618899, 7.142099319718098, 7.563761001742861, 7.169058441322713, 7.642509826985052, 7.102075105066497, 7.16315686106644, 7.325397915097283, 7.5910095291699875, 6.937378203411995, 6.429459483577053, 7.233968364681428, 7.12722947043714, 7.7132615209977535},
    {7.382834320439584, 6.447849280115434, 7.35996213143205, 6.683779105112392, 7.912109386116888, 7.524455963752367, 7.679912877881194, 7.663185692545252, 7.1575973513233, 7.634154181248057, 7.714219440043061, 7.699263573457931, 6.409174360675817, 7.6470577703475895, 7.482050239539749, 7.055011892676092}
};

static const float b2[16] = {7.354915519594725, 7.082764032997069, 6.970353473803264, 7.2505760708409115, 7.263226329064965, 6.9919054797238385, 7.1691113543729195, 7.147650451141521, 7.2525546910144705, 7.246911146282985, 7.23048937115113, 7.112002050437684, 7.161798007022098, 7.0171927321933065, 7.206437202280496, 7.207738441897989};

static const float w3[16][12] = {
    {-4.90448372336317, -5.045313889125162, -5.116057841778236, -4.874522402417506, -4.601244434771046, -4.632261554854968, -4.688383048889713, -4.734600607605973, -4.923402030542936, -5.150427977505081, -4.750000133533349, -4.860888091086494},
    {-3.7031507955780074, -3.4332139057592777, -3.918637769549498, -4.09941704539356, -4.167420767861633, -3.9670911985333093, -4.25531942655848, -3.8967982773378127, -4.431502164119849, -4.187448331470716, -4.425917171424867, -5.135830953716889},
    {-5.289523903694034, -5.042363188886614, -4.916751384146542, -4.967613746192792, -5.351064280200227, -3.9665178511031924, -5.156757498858189, -5.04720431051684, -5.6440781630608, -4.834863527731982, -5.647625391210644, -5.160828447588875},
    {-5.287133793890545, -4.118700985593346, -4.686753540891002, -4.535640433258473, -5.0217797044785515, -5.00120639111833, -4.720528767240379, -4.180192791964212, -4.40934266285022, -4.617306775576198, -4.669084618270543, -4.255506444606474},
    {-4.6604993129899555, -5.214427039694822, -5.416286591061973, -4.684863248890434, -4.911132624506331, -5.368795587815413, -4.896594929954185, -5.2459080118404575, -5.073701992281166, -4.869904780390908, -4.815067734186599, -5.2782036360206535},
    {-5.618144367303729, -5.003299765183055, -3.9530890446994182, -4.44819662754232, -5.137885766096569, -5.373265287254972, -5.341796623687773, -5.562236039829567, -5.594408076966846, -4.91195795803581, -4.740834914011968, -5.497395486644076},
    {-5.418641238012919, -5.369878632249093, -5.5437625968330115, -4.754468915044409, -4.920670797833796, -4.52565543001447, -4.975065630872183, -5.0977906387792595, -4.875317971214144, -5.52242553788797, -5.212102562180117, -5.186463377887051},
    {-4.526390050240346, -5.598172029685475, -5.3257584716390305, -4.723352005562442, -5.682896549430176, -5.542653886923432, -4.905854674975682, -4.9808209624791004, -5.22686829030362, -5.05973711501456, -5.614590301231268, -5.993286468551897},
    {-5.73684085766786, -5.215106137879154, -5.5794171460260165, -5.019330612451744, -5.184755748707848, -5.393329682797428, -5.211610867252199, -5.4269158700089735, -4.686717187561157, -4.768300088535101, -4.784310879098792, -4.598179387681929},
    {-4.69691527502385, -5.407277456340982, -5.04160408990125, -5.330954912737345, -4.981868316526178, -4.712526267316644, -5.607562451595364, -4.148314569073186, -5.306370364529295, -5.261664233468608, -5.5848928709501715, -4.656596593737282},
    {-5.157104990392457, -5.214224154652021, -4.967500581139598, -6.047897282890363, -4.946101608432439, -5.437283813006504, -4.525729109776282, -5.62301624916979, -4.905788081801412, -4.788620529414069, -5.17692560697021, -4.474908696621752},
    {-5.095667471753693, -5.203139335070523, -4.6270016742197555, -5.224636000688801, -5.3964776063954165, -5.108377891682753, -5.581104213048689, -5.419529267310839, -5.522573994123829, -5.315850087914766, -4.657887901097417, -4.755501959351973},
    {-4.673375464111777, -3.9921768683864305, -4.32475194515417, -4.482572732873831, -4.87625676433478, -4.476863762488806, -4.049334362139278, -4.697955717148925, -4.497244463493037, -4.761342617918207, -4.600316535384002, -3.427506015128178},
    {-4.641247920639343, -5.301723203871732, -5.195558743806937, -5.298720972422135, -5.056113505767352, -4.873486774860415, -5.289779715241838, -4.825423588442748, -4.347817291751811, -5.385825492091341, -4.867206089204947, -5.866771394131767},
    {-5.136539238486566, -4.6834337816115434, -4.892782784552612, -5.701145767702212, -4.808218525839474, -5.389492387180437, -4.6556583019669615, -4.910632822267437, -4.551533221379263, -5.027795982504327, -4.7590823001346365, -5.169426668831715},
    {-4.687148666909263, -5.176657823554221, -5.6471748306062635, -4.998561370700339, -4.2615071057876905, -5.3993665850391475, -5.3192692851404955, -5.3600127360851, -5.226857878704232, -4.771804184931641, -4.977243427763333, -4.8349692490612854}
};

static const float b3[12] = {-2.3731886514905725, -3.237247327166886, -2.66705990115786, -2.2812230663970485, -3.4515112441489277, -3.3336815171669736, -3.383557139415454, -2.9683145561406774, -1.874977563115923, -3.708081125881088, -2.1084024412945097, -2.0400279680843596};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
