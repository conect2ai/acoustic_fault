#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5176404755383995, 1.0747359869322277, -0.21085079016127464, 0.07859211740197063, -0.5065183439649686, 0.015204493405401358, -0.553185873641593, 0.3388470319472944, -0.29444588507581954, 0.7032077241209838, -1.0026742859643865, 0.8651107586015848, -0.1110144080775053, -0.8832238979376841, 1.0357709343852157, -0.3420176128779685, -0.31214994352270015, -0.39615122942186975, -0.26918399809999366, 0.1997903755676587, 0.622201765749061, -0.508479071915825, -0.1011077247023523, -0.8368896085789304, 0.2216977017460216, 1.2067146047061108, -1.543477013500107, -0.2920214320808787, 0.38408822333927767, -0.3714153162099927, 0.4481635111405919, 0.25562185829763534, 1.3214106652782307, -1.2218876538774042, -1.2218238860301571, 0.16658541493241144, 0.5663589676662041, 1.3774107347437674, -0.5902309761369665, 0.6303542379064194, -0.046228843305198324, -0.1148358011891223, 0.2614697288205115, -0.46670564818153815, -0.3865734116649572, -0.22204766775356638, 0.66236019293744, -0.9188997815991353, -0.36314037331150356, -0.9331610854300144, -0.37071702630159126, -0.7909911640896893, 0.8376706062458282, 0.35958944335309184, 0.9793979309239823, 0.187279266778583, -0.21312054086160442, -0.23483315832857823, -0.24951352328621132, -0.18760229759955663, -0.5016627780243181, -0.5543980554425525, 0.41745429329390915, -1.2681006379161397},
    {-0.8489464789391048, -0.3749311702032408, -0.9224353069504605, -1.3103014007797689, 0.4252018352485133, -0.6874285280864494, 0.13043206284864134, -0.5446330131677847, -0.806685031399237, 0.9267944813328208, 0.7121539674335502, 0.7181255110855034, -1.346386616728915, 0.747436228070673, 0.35753853878619585, 0.17731070677725635, -0.5341872331149075, -0.11204054430594046, -1.3845117294752927, -1.0676190714785918, -0.36202801891552605, 0.6638879991855059, 1.0205203937193033, -0.7006463042328499, -0.6427293238248377, 0.05699645837584866, 1.0767933337104734, 0.8345392430002293, 0.8222887190734217, -0.2972418474710002, 0.8278006772067972, -0.23627602778685447, -0.889416493767766, 0.5463940834633068, -0.017632425862700574, -0.9336578162679363, -0.1425127104426928, -0.6444092471004795, -0.7585877538456138, 1.103741445665011, -1.0825303059924585, -0.09218441083430567, 0.08689484180548027, 1.0425707250308465, 0.5307268138599001, -1.3129769881787121, 0.5119614041076901, -0.7851145369692726, -0.30735635102206466, 0.08667485754688597, 0.41184230188377813, 0.9447274696146019, 0.8365131541843204, -0.8736312599379853, -1.2205252491964844, -0.523434132144564, 0.3284113472532123, 0.08953160812218748, -0.18479891428891201, 0.8653090214315649, -0.04871106288844675, -0.15117912396582006, -0.5811791639316812, 1.0411450258758705},
    {0.7883677053556594, 0.7240380962820352, 1.3726579564147405, -0.3739741222076932, -0.9489093807604229, 0.9001934826285745, -0.37203537960834643, -0.5692473700614361, 0.012707507261444598, 1.3019229947767572, -0.28699609993300595, 1.2842296775909507, 0.06074870940677588, -0.43802751350494873, 0.4442394400182295, 0.20913318990505916, -0.40009467971346, 0.2364037224559417, -0.18475954035533132, 0.21154055156208604, -0.2596019692331696, 0.9773600626934977, 0.7077358021792622, -0.43503880743434564, -0.958452949880806, 0.033320918203315494, 1.4291153576221314, 0.9819369615729361, 0.7683250446467889, -0.7758460790118996, -0.0876643189672069, -0.7253399637965264, 1.0720355489724394, -0.4133364903680623, 1.1375214669650147, 1.1193207285465403, 0.7484742579120743, -0.6905722552240819, -1.0067200564163323, -0.5215303275509751, 0.4945357228825259, -0.6448282123689866, 0.7807854136302418, -0.6526092376911717, 1.0642479773658127, -0.0141183576089767, -1.1850131805623676, -0.15666152407600728, -0.1674762988577214, 1.1276680992225898, 0.8879345775601722, 0.02863045718452679, 0.7290772784107739, -1.4629132155117304, 0.12164748087517328, -0.11986234740465954, 0.05077102794654009, 0.8684181279835447, -0.9974329605764374, -1.1342000911980537, -1.2418080682257189, 0.9315961166531217, 0.9500791788076004, -0.4875479711910951},
    {-0.08096704997236526, 0.4897481874525327, 0.6123630270173017, 0.7816577518948941, -0.9125525501484718, -0.32238798697001364, -1.0466119838467485, 0.2625733025400916, 0.13573070883674812, 0.6264588588280368, 0.9267581864035731, 0.590086284863901, 0.12465776752920682, -1.0739524107129428, 0.08013209680993053, -0.3996681397958028, -0.9945810823816569, -0.4985825877170582, 0.15495254340122003, 0.8636982833476111, 0.9053173887125213, 1.110051063651458, -0.35656262796861693, 0.6532555311458272, -0.8059204528947118, -0.5062006695329232, 1.0682473010505655, 1.2041940022666435, 0.897339701813614, -0.7777837454945008, 1.0228597407002475, -0.9015223126715116, 0.49885649529200593, -0.2366162626586671, 1.41874225188647, 0.9229635124131803, 0.42020243193389234, -0.37633967802412827, -0.7120466138488409, -0.9112997925494648, 1.4220901693017731, -1.0373700737481497, -0.18083128000899484, 0.12898245488787796, -0.26058580569619094, 0.8903800506527388, -0.13109222018849323, -0.0034775779327836337, 0.18516427696958404, 1.0798266652192032, 0.40292145796133577, -0.3095545564121931, -1.1179320544419866, 0.6986792150717483, 0.42378503186912064, 0.8592663904629074, -1.2435744085871696, 0.8367024823386168, -0.6386124994189576, 0.28638603444250643, -1.1016196186045148, 0.7679229313203249, -0.5936646906928084, 0.4516682851049985},
    {-0.016296577916927707, -0.33288371388609317, -0.11878034496621767, 0.061449112709941515, 1.1522715761572977, 1.2493107639870875, 1.0438626341446415, 1.0630425997143171, 1.2159051534231742, -0.3529238727067834, 1.2194294738916902, -0.3250200343575102, -0.46344161794651373, 1.2119243220513516, 0.31381746730847954, -0.05228585082780866, -0.33388767428057226, 1.0072246637492854, 1.090269464526808, 1.1286160507543743, 0.4596493801225507, -0.9346314605828183, 0.22887917691560578, 1.2725475283549512, -1.2048058614276425, -0.7089052864223563, -0.2834670541804684, 1.162446198140378, 1.2489519206281194, 1.36371985247179, -0.5060706857348655, 0.8642659493082112, -0.9576401355986386, 1.189290280139653, -0.763806316301008, 0.6612774780386407, 0.7375661108584555, 0.7952647918495548, 1.0285104745311626, 0.3777696229329035, 0.6902126710578771, -0.1456363556443769, 1.3804969826613056, -1.2788362041562498, -0.32598807521778417, -0.5953555115297584, 0.6359835252053434, -0.3487365680991908, 0.029109773247278942, 0.17416790812746932, 0.1781582774722489, -0.3934674788004494, 0.1541859192678316, -0.6202983965203259, 0.7672485384467708, 0.22485090810183123, 0.8151838240230955, -0.8031501661483875, -0.07165706133468208, -0.6403061330683307, -0.40918593953412463, 0.6225880134572312, 0.37322897927527404, -0.43557964362363155},
    {0.8598927316910334, -0.7827514185320309, 0.2871469900161564, 0.010185637517526106, 1.0262506522110713, -0.6991543628943545, 0.45933977206772103, 0.472125887256181, 1.7932368046500509, 0.5500464723128835, 0.04370032606075504, -0.07391385425367433, 0.047688418571509565, 0.869328452001591, -0.6364027191769436, -0.08314010886073389, -0.7381567212023271, 1.3949057106405538, 0.09889752753269054, 1.7247978300045457, 0.5047836823665113, -0.8253802213161179, -0.5374447828514066, 0.0763517396130102, -0.6532543013905517, 0.4998308912843925, -0.11421983724973465, -0.33203519853304886, 0.40715382257532806, 1.3080425494701229, 0.23092895922864992, 0.1934136693434921, 0.43395433264454, 1.5376266715232454, -0.5156484173060613, 0.5076986885979721, -0.22451681412838378, -0.004583904848551252, -0.3209208797091459, -0.8313646801090568, 0.32796831202329935, 0.4756980876663894, 0.20448645282152578, 0.9182394633628937, 0.8257358252900403, 1.1423544727724753, 0.31398379446175195, 1.0955866389267217, 0.418065024284695, 0.4137685773330675, -0.6919085531066268, 1.219294017914275, 0.7076514081512273, -0.5005357283204698, 1.4666717141023955, 1.4516090537713826, 0.1643962883896106, -0.7944230676235573, 0.06320469423494449, 0.4728570614095265, -1.0270882579713458, 1.4639561214981287, -0.7477040650732228, -0.6504232453420927},
    {0.7464762672623902, 0.6572969406850953, 1.2025899581916148, -0.9528712730630614, 0.17290109542134838, -0.9360710617581137, -1.111337006238082, 1.1470132288494952, 0.5387582357205674, 0.9656270171618342, 0.4251474701838498, 0.8542304836019131, -0.17786758535053857, 0.5076162280241518, -0.34561666575996525, -0.2465057740407894, -0.04575716362478268, 1.3153622051654186, 1.3720874464771056, 1.6260980588153406, 0.027153497194901483, 0.5653591077734965, 1.001763412164482, 1.0452997203096017, -1.045881840957599, 0.13577173679330745, 0.4484288269119794, -0.5766662738922668, 0.7003468322130777, 1.3839676347266137, -0.05787986845253874, -0.9170598682309377, -0.0851393579238903, 0.9293024050822185, -0.10406222865038872, -0.9746564079462983, 0.5602497054850828, 0.26829696900658156, 1.1569780204650155, -1.0560553191632684, -0.4035660039830016, 0.7905102906019918, 0.87916168924058, -0.9820176142956146, 0.10926004712910851, 1.4269874293250762, 0.008796053520206529, 0.8710321738936246, -0.937673915299693, 0.946039453054174, -0.724935777354437, -0.5988899338369075, -1.086643960558378, -0.34267093369731644, 0.3663243683170532, 1.2765304657359808, -1.0387066445965083, 0.3980479593984831, 0.135281842324952, -0.31027440000369527, 0.47656176324823346, 0.44370258927037864, -0.7898524972659735, 0.7717158214091537},
    {-1.075894649647262, -1.2229510172856093, 0.9361433553067151, -0.022663332650871313, -1.0993396631285, 0.7347106021213756, 0.18798560497129205, 0.11418887200035051, 0.6275910667997494, -0.10247395176773233, 0.10942708461987168, 1.1742176176223615, -0.8500961209629778, -0.6316029520045071, 0.9442637918611893, -0.8244211782061461, -0.38606855554582326, 0.6807052149092798, 0.08155069733540585, 0.47935277557316425, 0.2538654323373152, 0.43162266374403757, 0.5993123623032001, -0.24589595950674512, -0.7550314306862268, -0.7978946990144071, 0.983520450680201, -0.8023443195867205, 0.26477400317110233, 0.9786855402926854, 0.6876435974250248, -1.1068447222813764, -0.9441945786387388, -0.014710795936321262, 0.5130734097114739, -0.26762088306442605, -0.9055342081797486, -1.1932769887927694, -0.1408571366713175, 0.6327630460502212, -0.764452507293267, 1.044229049714345, 0.8590744802917928, -0.26625031157807894, 0.643538658726118, -0.02291003996886476, -0.5503326938828248, -1.044546779411755, 0.2164883143936869, 0.6423476684208549, 0.37888200661464944, 1.0470977523005232, -0.6354432394890459, -0.6059758226485454, -0.319247829742428, 0.007077378230127335, 0.40592482136618907, -0.4552222534758459, -0.9046367612206022, 0.31564220323973413, 1.1051269112391715, -0.2070836788973394, -1.247784150346039, 0.911658984986756},
    {0.7723433315543383, -0.7724541011555404, -0.13317121916751956, -0.7608377752642931, -0.3012851501638188, -0.19424609987582217, 0.2712837778686718, -1.0720079076370823, 0.9508026615315216, 0.6559356486346231, -0.9279754932123027, 0.8633718759369194, 0.6592801715875869, -1.0227736660583657, -0.14788706112379285, 0.33212041673716397, -1.1592725200540748, 0.5737877707088607, -0.42082202300456956, -0.2510452272220734, -0.4715297885302209, -0.1368963118517103, -1.0594164001094442, 1.26953989379178, -1.308423176955131, -1.0091068705061086, 0.7088888320252912, 1.1357527834347434, 0.9827799776233234, -0.3410506061805374, 0.22141636553243313, -1.223726149336094, -1.2626715687345733, -0.8230222312001539, -1.0476812542696101, 0.24280616500861368, -0.6551097889573382, 0.2628023140612978, 0.26267129202886746, 0.40685519064150494, -0.5607581857486558, 1.0036206638611556, 1.2032148008129744, -0.648072711033203, -0.5081321231509599, -0.026511777837679582, 1.1211656004294812, -0.41148587131723524, 0.744926194293347, -0.1317624081414486, -0.1244062878228048, 0.8056483078218389, 0.6655165982766302, -1.2857326606715016, -0.5597423357501516, 0.2828169800911823, 0.7477447886258357, 0.8344580497713794, 0.8793896831193415, -0.6774577643651952, 0.5531772551739412, -0.019874633882879144, 0.9627402314740432, -0.016278399426615707},
    {-1.492526223487922, -1.4787304334007156, 0.18275830054071135, -0.05379786141510751, 0.219313305837663, 0.2859529885977926, 0.5653912457685207, -0.7990380110797515, -1.2007846344887523, 0.5523860140097117, -0.46226245995664433, -1.381724908300909, -1.0496977170258148, -0.20795237361805238, 0.8638803877211716, -0.074176044121707, -0.24556919050643317, 0.31568018546414, -0.2515538522928994, -0.6634731058057558, -0.8757226153570746, -1.254750502578548, 0.6971167248685516, -0.6658606175409567, 0.9463580111589399, 0.06554255481817681, -0.25991124995893955, -0.010843653033436132, -0.8480649216825921, 1.119575513891441, -0.2631692404064437, 0.810922791374288, -1.112229952104847, 0.4105160232442572, 0.6514249866646834, -1.1673494448379993, 0.2472219773200295, -1.3654680909537156, -0.15528701807046638, 0.0731086704596503, 0.30316861964891684, -0.881782116268479, 0.9494160116507133, -0.08952570958301787, -0.09419818291033126, -1.2943922646788262, 1.1353398373357564, 0.6866986494303782, 0.2558437084689178, -0.7612549113195284, 0.0676913346823385, -0.8237553508772119, 0.649218186731973, 0.8291554769928441, 0.8281745052831427, 0.5953611183445674, -0.733796405443673, -1.0147554642593501, -0.16554198980400703, 0.6037309414853571, -0.37903256596768437, 0.6779726155259742, -1.0180765559832985, -1.1472859716891675},
    {0.18214711695132854, 0.4871180053446933, -0.5022743571018782, -0.9144421395875204, 1.2181282390438022, -0.8154734158133126, -0.8533898096228938, 0.11296113663812343, 0.5584425505053747, 0.584507388150601, -0.8423118235150356, 0.1004786459058351, 1.1871959078536773, 0.24657696391271716, -0.9888518976846961, 1.0238262006626642, -1.0633253242386522, -0.12230304731316649, 0.41486759012197794, -0.8140019611049422, 0.6125212949962713, 1.069025985592505, 1.283146137327924, -0.9732573755254785, 0.12559421843223795, -0.45593847604853693, 0.6378662896495138, -0.06694313514824636, -0.7584343882070387, -0.05772038191979468, -1.1360891866976919, -0.5576275953043056, -1.1063071728916998, 0.9906917069338261, 0.9377304020064996, 0.7515915434647568, 0.15922380871409883, -1.1346039780451913, -0.34158742479229837, 0.793683638281535, -1.1658535899017093, -0.7949635359391259, -0.9167975372814292, 0.09338327918019926, 0.6296629565563613, 1.4585454403633307, -0.4186470764672939, 0.5747742948002909, -0.007716386793395235, -0.004497387563836547, -0.6129954599497545, -0.30962642003075735, 0.2019496147436897, -1.1058213816336833, 0.7097510988323675, 1.2717095207592213, 0.6642433332583629, 0.2223030110644601, 0.4135458044014731, 0.22693732280010015, -0.3631354437177926, 0.6601349330671512, -1.1788256886113702, 0.9390373047853898},
    {-0.5483245576585927, 0.6071965988079066, 0.4052232763889891, 0.45151586076828026, -0.1378675479338123, -1.073099079312812, -1.0084569991278969, 0.845256887892797, 0.09154649345963148, 0.4986695916424699, -0.8480158715081002, 0.5541049024563954, -1.2323292300027857, -1.391871771956799, -0.3428398319324419, 0.8849039092325791, -0.2817266582534423, 0.7672493805569525, -0.9932586057307599, 1.0194728321895632, 0.6662765947323877, -0.7350043089198514, 1.0849443660421987, 0.5045653197083692, -0.09543198927298387, 0.11094515581264223, 0.08280134284893093, 0.7968526689527675, -0.8726682214186195, 0.7073847060000713, -0.3037036096256239, -1.0607264895567041, 1.3317630944248544, -1.0200417646735047, -1.1073994437060157, 1.0397333199282328, 0.7488321930044753, -1.1427718376994547, 0.3617236643113986, 0.07960323576340317, 0.5130859293608181, -0.6105022972884196, -0.6016203035740433, 0.09853273761581473, -0.7136687850738903, 0.4628625955696963, 0.03666509466392682, -1.1581869985512014, 0.6846122906172494, 0.5274785094914195, 0.30814909029279014, 0.18505550226877895, -0.7103655008540959, -0.8627549302759142, -0.7212270724892299, -0.8675841209098671, -0.9627615322809344, -0.15532999828706245, 1.0987681719356999, -0.4278941328351587, -0.48786919735447265, -0.7406346927874858, 0.14728861114459219, 0.4677012322039161},
    {-0.11101822356180552, -0.10342019074110273, -0.8270474010016513, -1.0169786011903743, 0.4260274274630665, -1.0917235254841784, -1.0784574316374258, 0.3189774170265617, -0.40489698245031924, 0.6116107039129283, -0.07523284933590553, 0.9726272780288568, -0.2647154983124236, -0.19937779202626416, 0.31194448907079364, 0.5774221466477157, 0.04782669834644268, 0.21468969669577706, -0.8676217541349929, 0.9343593873564136, 0.021410779928393926, 0.708702243047597, 0.9955439673382669, 0.7882068223449982, 0.3516863901519592, -0.8590769853853892, -0.3388014301151234, -1.0363074119668878, 0.8523430221948973, -0.41992426169330715, -0.9833465541724095, -0.45494046246327235, -1.0953638925368643, -0.2822491286027351, -0.29712775021069876, 0.24518508305186124, 0.9524745926694175, 0.23922414436966902, 0.9899471961609867, -0.9354288696448867, -0.8198282420305419, 0.3225201556990417, -0.5181671104248347, -0.6183062316366827, -0.5192227050919529, -0.12411584697021287, 0.1381642600931726, -0.9923093817434829, 0.27297414946317405, 0.11674141445490432, -1.0361809756354419, 1.3405360733753804, 1.2165336248779337, -0.6734036127279112, 1.0526041899620577, 0.8724860174892529, 0.9886240020669337, -0.2489562307373998, -0.18306722375071774, 0.9920881840262425, 1.3275791499009146, -0.8387125276009679, 0.5859952078529339, 0.5369705475667317},
    {0.3768632729626166, -0.7923416735573591, -0.4992405227015651, 0.21958739963979157, -0.3979080334004744, -0.7789943222078308, -0.5111493382214322, -0.7159961944899345, 0.29019666984720593, -1.0235511591200839, 0.8831721370413443, 0.1404167549261339, 1.171336361987516, -1.0168613643151347, 0.16824669349680943, -0.6407858427494336, -0.37134754590946323, 0.5518326478900752, 1.3911880231364815, 1.63302183332459, -0.5528686935140498, 1.421312186895593, 0.8602511351082017, 0.4579124719926265, -0.030005006254816644, -0.7217065052099302, 1.1148100221893502, 0.6970730644250832, -1.21440766457666, -0.19297627182069615, 0.020944139039237773, -0.4831942798397658, 1.2326475651302176, 0.5666000143033308, 0.8196185926028081, -0.9169013765224324, -0.4434407885984457, 0.2436230581905692, -0.8009469828025912, 0.33666398695601496, 1.2023353215483998, -0.4556977393705896, 1.1658234310827376, 0.06650865498670509, 1.6127434391021538, 1.35620980121229, 0.9841277514540591, -0.47187622164429727, -1.4151518372266845, -1.091575196043626, 0.6486716400878079, -0.6382146910479196, -1.293136841147642, -0.9926097269506725, 0.3051012861792872, 0.03457663468234932, -0.7293891216446442, -0.3020456540733427, 1.0750482615479762, -0.5860952934862206, -0.37437916175685637, 0.7105647814881815, -0.9303066476631601, 0.8062917422624213},
    {0.9767892215450854, 0.8523144783031716, 0.6102727869196215, 0.2422654149526851, -0.15559900063138032, -0.45289536473005676, -0.34648319126801225, -0.36846242342634533, -0.4341533119744682, -0.12616986484638923, -0.777860252960137, 0.8685470702875933, 1.1059700572114506, 1.0793786330564548, 0.9245083262842428, 0.9759688998849458, 0.09760269486277173, -0.13594504848131556, 1.5298073838907509, 1.6119820332080987, 0.6372131949620551, 1.1068816289058552, 0.14012595674777487, 0.21405960885076325, -0.063278707137993, -0.03604650829829402, 0.2553135354209568, 0.4875784085139221, -0.030511173964274853, 0.6833425183026994, -0.020927213110719208, 0.5042310317993957, -0.1977752139330132, 0.7639453423231956, 1.377611384579877, 1.4757048698579782, 1.1110644281069642, 0.34784942065655206, 0.28118348718217595, 0.7804701607685838, -0.021071223074605676, -1.150520495218332, 0.44154820456968014, -0.2646952066287968, 0.7873846836009561, 0.6998017394617687, -0.5220596960384464, -0.47210927168411326, -0.8801143173579262, -0.12023764394683507, 0.16950991880878896, 1.1179823098190045, -0.511243757001824, -0.5754085928575988, -0.1493354067080702, -0.18274748980728223, 0.523700896479089, 0.18466719426937875, -0.6640516597973984, 1.3456944394953714, -0.7588876061563958, 0.2754442153230511, 1.0759458947407887, 0.7837686053155913},
    {-0.6035912510650754, 0.850830801858857, -1.2703429439301135, -1.0395279418223726, -0.7464160957733291, -0.5301627524837436, 0.41894122373578674, 0.8589879186729672, -1.0526286088554444, -0.35356079885907815, 1.0295224355600205, 0.6184027319882721, -0.7572007651629459, -0.1778004910253992, -0.24363811758548767, -0.24266840417588859, -0.37326907254553476, -0.8512184049006394, 0.4785699702117784, 0.949698182813185, 0.621275867079456, -1.1539310438813764, 0.13685869692587124, -0.8134118236072334, 0.32003677138173137, 0.9645871501072077, -0.15621550127649098, -0.9435660114591248, -0.013592403305309258, -0.15451204872161303, -1.182279059625591, 0.9812686962748869, -0.6985196589713792, 0.49400552419271493, 0.21090595390817854, 1.2122395001964252, 0.7172190611148908, -0.6991992607988542, -0.790750588063042, 0.19252601903694638, 1.005056271661557, 0.9728231328153997, -0.879204079336156, 0.3615348571002085, 0.9109856352662503, 0.5975554541994705, 0.1562936037275562, 0.2126536212565339, -0.3486253436132069, -0.14926939816103407, -0.850245972693091, 1.2630591654225505, -0.5573661583097869, 1.0519299429527922, 0.44207774945048944, -0.5699342224391976, 0.6009801047302057, 0.4701175807643295, 0.45404545170785926, 0.9720253227982278, -0.5320931166074112, -0.9899105599813349, 1.291483666306908, -0.31191381676468977},
    {1.3937656844666657, -0.08078767713429164, 1.1192272996431907, 1.3231112061424484, 0.6708238472125816, -0.18484577031736288, -0.4540207832716411, -0.9162098118009461, 1.1929041362594406, -0.9691193507402348, 1.1448112952465606, 1.2675764531242035, 0.8009121855730321, 0.6993503153047403, 1.1089386684095377, -0.9119259189334336, 1.0184821065255711, -0.479804025455065, -0.008297878093038471, 1.2516675874620056, 1.0720928982899083, -0.13528459235134593, -0.4179552440478428, 0.4856653201480522, -1.2688479879741972, -0.9024840376683237, 0.5428119797043036, 0.6250434704707069, 0.6621706361926941, 1.1083999401533051, 0.31274542360097435, 1.0674600182145082, 0.7641352029543182, 0.5298795422270727, 1.3767275756009214, -0.4454455724273322, 0.76132047897383, -0.8577231472824371, 1.0401246049712973, -1.082101211873447, 0.5297021595669622, -1.0860683700906357, 0.40643386024577377, 0.4555743756766337, 1.2681723167367336, -0.18694193298022604, 0.34477287284676406, -0.037858801410155254, -0.3927372971900625, -0.2583667036672177, -0.4362426348252555, 0.3911932543683048, -1.0558258950310007, -0.5762054896759957, -0.3555003596059436, -0.625897757651832, -0.5046280891465093, -0.5777722946508396, 0.6113208153945292, 0.7776593246978002, 0.8973812087194828, 1.1082241857071438, 0.7017338986447634, 1.4031114856355225},
    {-0.04366534402685105, 0.876261596932029, 0.5893146059146359, -0.9531436726755426, 1.3856942173360436, -1.4430816263894723, 0.6379378033431454, 0.6488701407326157, 0.9502958188356813, -0.560207799566703, -0.12913216199298724, -0.5970969979543523, -0.6941520319576582, -0.7492840568269749, -0.07596534654849249, 0.38347260214452916, 0.19553281324346217, 0.4929438795452483, 1.2549903735282848, 0.9314547183242363, -0.6433313566272852, 0.07755223870072725, 0.9139260581575676, -1.020843950021858, -0.012340639923901234, -1.0117287334170004, -0.38193281084718533, 0.8138988774974145, -0.9454678491762386, 0.5573053851155289, -0.3816339247537112, -0.5670796235273248, -0.10980154450867483, 0.9776391057818696, -0.38102185009317363, 0.71380053270922, -0.34211381014120823, 1.0545208049309795, -0.12543833333115098, -1.2552270980834523, 1.198751631555117, 0.7450043210734321, -0.7749731057387815, 0.8853433277992696, 0.6100079667917122, 0.7267067667926066, 0.4261260212341048, 0.6107091323637099, 0.2551097709135571, -0.6676887719615678, -0.5040138900438409, 1.3204929387877957, -0.9783860216577311, -1.1337551004108695, 1.1819834890028682, 0.9367886272090286, -0.03843896692284859, -0.40892853280186897, 0.19873702280584699, 0.13802850010113657, 0.013934135958733882, 0.44366319381979524, 0.41529942531178576, 0.6667734717093845},
    {0.4364632075196187, 1.141518531383138, 0.6606687493626127, -0.9472812305854539, 0.29625582275546963, 0.5514448181609753, 0.22456953265498739, 0.34845631122811266, 0.2826900178551459, -0.8250269224797093, -0.2608056527314506, 0.9272322206336802, -0.006031583741867708, 0.5200524617391991, 0.5986813343457961, -0.20058668191065937, -0.20100627469810117, -0.6242344322503292, 0.5003440985889439, -0.8249731345897828, 0.22941038904160976, 0.3775194696453068, 0.3892445555287746, -0.3483686450085453, -0.3492772977528113, -0.324411670853569, -0.8390892902371055, -0.2836421954150043, -0.5201157928815424, 0.17320166304174542, -0.9385378272511493, -0.7433078882739417, 1.1492095833532197, 0.455869698892813, -1.0484921199326533, 1.0348757141160132, 0.3394453157579361, 0.9898299460514821, 0.2852789818961302, -1.086898959825899, 1.0718617240231758, -0.7859677782914612, 0.08458948666778823, -1.1832215519777265, 0.19760902514973563, -0.6649790725396546, 1.0694867318709196, -1.0119055947192015, -0.23138849991709798, 0.35414160588272553, -0.03008055189524919, 0.4116753178962886, -0.0035653520123600504, 0.5550367048283691, 0.04109316952183412, 0.5755038204833621, -0.0900674265078324, -0.047295957403107845, -0.40181069874014064, 0.3738975035720686, -0.6893583525891073, 0.98544159839761, 1.2145850193412355, -0.6485769955129573},
    {0.11734862783059957, 0.2605919899771798, 0.7634017346422289, 0.48142768550226434, -0.38313030745558146, -0.0920299929573535, -0.8431612640630083, -0.9124374517289461, 0.8509604050898971, -1.108797067122636, 1.018699807332486, -0.7321169969260147, -0.26854215437704604, -0.6320235456894014, 0.5973985634795839, 0.7668397824996547, 0.6182394111558341, 0.19071108234656403, -0.42531421650977297, -0.39846946053741583, -0.08504645286036536, -0.35447088447061553, -0.48162550811395466, -0.2190521709046016, 0.5519381994109192, 0.12069683805583026, -1.0446213898622878, -0.1210682391557845, -0.4374691887959929, -0.6732572955352155, 0.24849869238067301, 0.520324997280206, -0.9613233629927721, -0.5557534186200287, 0.3052405129953904, -0.40967632991273656, 0.9279205645009455, 0.7534763112962416, -0.5224199161782912, 0.4994671313029722, 0.6438021002056021, 0.5904876334908594, 1.1265098361647907, -0.2851654346150624, 0.21067126608476094, -0.4173719430740733, 0.9050304944707901, 0.7770838686017413, -0.41668165807520324, -0.11394739749828865, -0.8690252001585604, 0.5564794543861827, -1.4253996564606746, 0.1078320051796272, -1.035758163791475, -0.48457146373791155, -0.2612321271989271, 0.8006418108943322, 0.8552184280348725, -0.3973739848055837, -0.36298557570296347, 0.05175390922028416, -0.2451223357438822, 1.0634728996489677},
    {0.4301553967841819, 1.2234677325493264, 0.4713226371634775, 1.4425734952382077, 1.0132993113373892, -0.40536054572565816, 0.4699360498077284, 0.4201173773881498, -1.2544584311971037, -1.2847477181789615, 0.37586164961034096, -0.8710784713989481, -0.9820734782081972, 0.9532844340882186, -0.789305591704803, 1.0578276398693902, 0.8806500396619834, 0.21410007766104128, 0.9294414681670639, 0.1685258743499957, -0.7052476778378556, 0.7563643698815438, -0.8620671126000086, -0.8090979753229277, -0.37682819481137964, 0.470217115739007, 0.6877108696185928, -0.5908270187282512, -0.2756908341321833, -0.19994156304346666, 0.3223353257322384, 0.22932630723165115, -0.09956431793277845, 0.39088271566613025, 1.1611314850504342, 0.7112660649240978, 0.1558495271984679, -0.5427102461555043, -0.10542956766236827, 0.36166225125766005, 0.8599018446465458, -0.09706002417081105, -0.8893300830113552, -0.5817290789456218, 1.3227157700429568, 1.2190205990385257, -0.13387200395973617, -0.4616792676463086, -0.5388590286163292, -0.2622309834637999, 0.4302303393839353, 0.7284036122385047, 0.29065601740464947, -0.22961805283600545, 0.14180214895066898, -0.8224175590359014, -1.2982774898726475, -0.40168796645655486, 0.47922766607012224, 0.11424218135665104, -0.21768485269421206, 0.023754960809033415, -1.0335168216782127, 1.0130712433504785},
    {-0.2878194242063695, 1.0692011590414654, 1.482743858141009, 0.8248921968907464, -1.1172992094453718, -0.2689129103731544, -0.35423088271586706, -0.7444212179327457, -0.7438015315795848, -0.1883224190478097, 0.3097042322655758, 1.0993466229552975, 0.13350744584893148, 1.0475818310821974, -0.8331820005784435, -0.3185614035316633, -0.45371043581653875, 0.6035306462108307, 0.7002221659697345, 1.2044223743291387, 0.13762995855325746, 0.3742091992783365, 0.16984976201109284, -0.6023331795121817, -1.0414496348005653, 0.7550589720044694, -0.35312452862712, -0.036217938245782955, -1.218627709240833, -0.04516535600394443, 0.7342709976168271, 0.5109517477730443, -0.16470600101443572, -0.9902343944755054, 0.3808712910894648, -0.388181220759327, 0.7261513104787483, 0.8897939481368404, -0.6177275751793287, -0.09346204467964009, 0.6229331773650398, 0.2852432454084719, 0.69117154558528, -0.7348252429132878, 1.5641916105574234, 0.7560838726763878, 1.0265970533217001, -0.8449548147335983, -1.0054835602299192, -0.19632142193150995, 0.740112644923103, -1.484566801816883, -0.13461828695715433, 0.13313745446720207, -0.5251973179555414, 0.2926999788456733, -0.15654189044908762, 1.03370240886755, 0.7944714684877933, -0.8852288629891164, -0.4978440174778426, -0.19635737253768246, -0.6148158181414599, 0.18122416406936515},
    {0.8782428915922518, 0.07306535012434176, 0.10639321229889273, 0.5507219269196479, 0.5620754849082436, -1.1550354532679727, 0.1269845862534435, 0.18517171562573292, -0.630497521925857, -1.2695092634930403, -0.6069629396815064, 0.11224632222533491, 0.9561400156016404, -0.7632567564686181, 0.4795065302523917, -0.4613691193874775, -0.0656455122791155, 0.8450384365724658, 0.5414948619203616, 0.35445732528000506, 0.20363898052857535, 0.4577383757305731, -0.1649092627308578, -1.132957560352849, -0.7286165176290761, 0.15198221930300382, -0.4532740143508771, 0.4333065842150872, -1.3622194875873606, -0.7944696296590958, -0.9485868619270755, -0.4006132897887334, 0.9338226286944131, -0.5306471696955634, 0.9525680823888624, -0.7659790201779095, -0.14106513333165321, -1.051796158266118, 0.397848101940371, 0.5091299502163492, 0.7910319588565325, 0.708244066059333, 0.795447558601339, 0.4642808184437407, -0.09858134376670437, -0.7939571406780378, -0.8859154191076954, -0.9415472921204772, 0.6896476177035233, -0.9059693524618752, -0.8473005540525853, -0.021322861421440853, -0.07083255501991605, -0.5741803334709968, 0.1447211347538376, -0.5282604529922622, -0.8863878882974007, 0.23229003546059393, -0.8018537942488206, 0.7162616717664361, 0.23306198438000783, -0.3581819092803494, -0.3531929689730917, 1.243660648437511},
    {-0.3449475679963615, 0.6501105198205124, 0.8383401467005235, 0.5052793341637162, -1.182542563645308, 0.04668292862948153, 0.45772003839183417, -0.9514174721757721, -0.0015140726854816172, -0.041735172588670204, -0.16196314789115843, -0.5104760880513664, 1.0264558642297545, -0.9226293497696172, 0.27695297981290173, 0.7997527595543563, -0.20793002901100593, 0.9661830188846077, -0.1952393290274532, -0.27719302428758413, 1.2102547975439673, -0.2681681443713604, 0.7876058559366215, -0.748490438746847, -0.2840419042124631, -0.21647247939247855, 0.4786576735697511, 0.189488158310655, -1.1478621490865424, 0.19732299467059208, 0.9881919752142105, -0.6605987477059745, 0.1319429653922699, -0.468588246615766, 0.5935501925891614, -1.2076943721494877, -0.481020329752712, -0.6021396188397814, -0.8393308356554833, -1.1644412612708384, 0.017799105417783578, 0.5890911678708506, -0.6751973230976653, -0.5146154444039394, 1.0753559739808318, -0.9795265914073956, -0.5609242709480906, 0.7934878209341736, -0.8960159988605941, 0.12022548080550498, 0.5392465355691478, -0.17012275535690935, 0.3125625389061642, 0.22601199383889323, -1.1932071308756433, -0.061144261142144926, 0.7908046168104571, -0.418170127988237, -0.7199789539285326, -0.6485747729619734, -0.3230978412542862, 1.0031752925521273, -0.23901207113156223, -0.2504465114630858},
    {0.729173247530366, 0.8441943652647079, 1.568745077479769, 1.3747393834368244, -0.35067096241172113, 0.6265790801934359, 0.16396989052990898, 0.7109080433304528, -0.022503409331079874, -0.9310434457612426, -1.1012236190871094, 1.3549029855750414, 0.38805191234818226, -0.5140927116951493, 0.2789215027928255, 1.0893267947332308, 0.0013298031771458985, -0.09188261576636765, 1.332552084180672, 0.8060054772111498, -0.3464870442428481, 1.0850684623048468, -0.4611306583155765, 0.7726388429022754, -1.2617762478177026, -0.42123049225422143, 0.019670849907377053, 1.363039827518312, 0.7384320842165425, -0.23079973835030962, -0.1896904119782782, 0.854527379495362, 0.9846640962359179, -0.9879977546153607, 1.2173076435991108, -1.2232445463720278, -0.7910757309376945, -1.1837998084341927, 0.5321776345363626, 0.3365534758818411, 0.8575403592649142, -0.9246917854642328, -0.3736067345615921, 0.15667997651866197, 0.870704212338068, -0.5799155299889657, 0.6975913716288822, -0.8642119118391242, -1.111649599221674, 0.6988891074847652, -0.9109353764189382, -0.19956631334277844, -1.2110005540584095, -1.1828726914040986, -0.699366371419201, -0.2048377941651786, -0.1308122194361521, 1.2708853208171897, 0.507274468187434, -0.40237327618684837, -0.6058767128878334, -0.6233567324504784, -1.4537031244612262, 1.1319129327004582},
    {-1.0426833429611893, 0.8851285762078036, -0.8502027808981524, -0.4015457043259892, 0.07911260996445633, 0.5798941557201859, 0.26971821859468464, -0.5885928010439085, -0.7787754524322712, -0.250577622575082, 0.45248230876783885, -0.8612227900605519, -0.910144600987125, -1.086753963166902, -0.1867664712584527, 0.6632614249805246, -0.7315386649481648, -0.20636694427602723, 1.094015160209157, -0.7543801161193918, 1.1341067982894741, -0.4193540370023454, 0.5479758824760234, -0.6385612464674886, -0.9810299278710047, -0.3230338288970012, 0.190773090197684, 1.2941396642495384, 0.009981065983113806, 0.28262324018697316, 0.4243052709478512, 0.5782996540087895, 1.06396857755324, -1.1692528907545423, 0.12683841731355303, -0.7254727445387736, 0.024905079176857966, -0.3421331106831306, 0.44967197676319703, 0.8513254861496903, 0.15814869809256663, -0.972340015910461, 0.4453678366105194, -1.004426494918178, 0.5015514407179247, -0.3737597248782149, 1.1568492331285634, 0.7811439873034935, -0.8542601474034722, 1.03377406968116, 1.0545948518101302, -0.7501584590985282, -1.2309233968728164, -0.38630368931585674, -0.40252156797845745, -0.9483784675951012, 0.12144219136857061, 0.3213789661613312, 0.6642944258291933, 0.20134097339681736, -0.6708746591873229, -0.6584775655993986, -0.6941804969650914, -0.9290321987818663},
    {-1.2110969464983448, 1.163899574495379, -0.8114667063642165, 0.8003362183674653, 0.38373982254659966, 0.45559199289556807, 0.7930798519767976, -0.16030714923972292, -0.90327443609979, -0.8735845152506311, -1.059084948788882, -0.08115605085459647, -1.060463512673583, 0.36882390581987157, -0.717065074386693, 0.7043004614439462, 1.350907105128175, -0.6257947454841698, 1.0057574590154594, -1.1072863374771023, 0.17141479514869146, -0.836731883423702, -0.9932613140443306, -1.4801851370202799, 0.8189921334284614, 0.3321035143727657, -0.7730190560492748, -0.19764987654363206, -1.4826668670458418, 0.3521549459754217, -0.5881518418208661, 0.16767469401916657, 1.5730935940621655, -1.3965625005315625, -0.7249531143082784, 0.35592392503929426, -0.8536383976913933, -1.1809155835591982, -0.04743360053757227, -0.09706766217067118, -0.7103325015715816, 0.20383791711039417, 0.0890949672609162, -0.5065300871087135, -0.23898805002556078, -0.06561298243662864, 0.8891044485209314, 1.1106033689273642, -1.1348891753560297, 1.0477698081086477, -0.582902570775542, -0.8430499617049341, 0.32200427566353845, 0.7788046875995129, -0.6952828961482463, -1.3637845572271177, -0.3816442639045467, 1.0469491966494973, -0.3752892255183899, 0.5547969548796593, -1.0801929681684987, 0.5879922823268097, -1.399506357224561, -0.2125324455811836},
    {-0.8317729985646652, -0.3683931580419937, -0.16501619526898273, 0.6994389028789182, 0.578214308549834, -0.5410221886445052, 0.22096259929196232, -0.21523579820585576, 0.6399753707251196, 0.09580440850358654, -0.5231312456987046, 0.459968453534044, -0.9600604134939057, -0.4104489178714198, -0.3175444124435581, 0.8734306461251059, -0.21711240966515813, 0.7636792081488566, 1.0546242634537981, -0.8936587134667642, -0.23788673967370466, 0.5890590381274562, -0.10477988747374042, -0.6961461695095296, 0.5933803826385821, 0.492346166375504, 0.05432274047408532, -0.7211900087259953, 0.09244908797255072, -0.4433061556917297, 0.6673377964551039, -0.8031548398623484, 1.0829458023117702, -0.08667137091452339, 0.4491152516691305, -0.9811596056574537, -0.3372617055524727, -0.23748597606583938, -0.08569836114162147, -1.0369278120285634, 0.9199603073245304, 0.8201190477436378, -0.48690185316284024, -0.03203389995721442, 0.45325199969233165, 0.13219784034804236, 1.0336825146942727, 0.27613725356727714, -1.4026560199029343, 0.8197900856622913, 0.8907786470282095, 0.5324456955473091, -0.2520760951458316, -0.9462136600512991, -1.213879094552635, 0.39327366230136623, 0.08282329960662924, 1.101971162669827, -0.16870289100605074, -0.49863806001960875, 0.17865092417232556, 0.24111796312860406, -1.0936954141338062, 0.68931718987538},
    {-1.1307259658029503, 0.42080215437432483, -0.38115759080433964, 0.4246574217438173, -1.128822401834917, -0.733245726559774, -0.5118124354080982, -0.8888629305508722, 0.3534344003650649, -1.3492729680841868, -1.2857233617392325, 0.9685508225405974, 0.08264280168369487, -1.4467385944442306, 0.4878842915424729, -0.0006668236163565151, 1.0270223560543932, -0.04918691540883067, 1.1450902363772528, -0.10385909882710173, 0.7988741079328318, 1.2947414508489992, 1.1296942278591058, -0.6607772873970607, 0.6911096993875695, -1.1807268524267365, 1.1017402613742262, 0.5181806234284326, -1.2052108265596067, 0.6318773657693462, 0.6885220245611973, 0.9686561532181834, 0.1703607365066445, 0.5325627978304811, -0.3575536551933439, 0.3071253339566199, -1.1601950416296785, -1.1885681572304831, 0.5601959865539186, 0.09725879049988047, -0.9264055081647299, -0.9777847133496942, 0.19525711357654363, -0.7600055970882034, 1.6474508123633869, 0.7270641810619025, 0.5703886714531144, -0.186045924092989, -1.411544468015424, 0.15964351450573228, 0.06089634771347247, -0.27745634935997127, -0.8493071523093524, -0.03515319418688179, 0.8131362646790982, -0.09026633596531082, -1.3614010150253062, 0.9942381023443466, 1.3943159430011154, -0.4686036165574968, -0.6951956361612218, -0.3946960232975517, -0.7432249645052538, 0.01295400694160794},
    {0.7065386300240293, -0.36170161620020974, 1.0064014103907626, 1.3773098330444007, 0.9704748350321187, -0.849339649047398, 0.750801799463865, -0.30955110212730785, 0.6313241521035348, -0.23598571221616926, 0.3171517173811388, 1.0510508451487732, 0.605748853646154, 1.01257805573027, 0.448340600169677, -0.45766625638144776, -0.3762449565252393, 0.37448790449155656, -0.7050945747643502, 0.2608961701312066, 0.8391472997271492, 0.8322201568152164, 0.5118362041856144, -0.9954171503856281, 0.5563896874583917, -0.22737636458989266, -1.0098371856805424, 0.36680028464996334, -0.6593654149335247, -1.1525897771452218, -0.7940297080665115, 0.7199513428699857, 1.3312513443733165, -0.020231726149221307, 1.190741153132416, -1.0815491102466588, -0.45888563602795734, -0.15613828084864573, -0.4537392777609522, -0.3237524902050307, -0.27195177914951857, -1.2434054695388408, -0.6860240393972653, -1.3667184598334692, 0.602486415026389, -0.6260743477589582, 0.11003136242690403, 0.19731948625578205, -0.3052231043521785, 0.6325556372871071, -0.6369453692786011, -0.571635596628581, 0.07060324390118934, 0.018435693081384645, 0.4477904755791179, -0.31360793802429615, -1.4736721647327993, 1.077187221173402, -0.37836013835106636, 0.5858364569146954, 0.10560657048011837, 0.9818004621315842, 0.45732432164264675, 0.7848506697231429},
    {0.23959043438307168, 0.8380799512375644, -0.8813402530986316, 0.29082820239870255, 0.1831800380364963, -1.035849909780198, -1.3726782227483856, -1.2982408911337138, 0.28820926659208185, -1.652024937464512, -0.9767428063468715, 0.6167167381767442, 0.7082047394264968, -0.8087870063714763, 0.6034795858961431, -1.6932438551237432, -0.5925352142437832, -1.1742763047133746, 0.15132157034211222, 0.26887457711937374, 0.5623033104666203, 1.1830964390641354, -0.4076666771195182, -0.28279157867901716, 0.5943404207740055, 0.08298740706968236, -1.4472478772699702, 0.1880554212762944, -0.7260248606904429, -0.14782143316524776, 0.16205161076943475, -1.0983107687197262, -0.2883108331616082, -1.756162412006316, 0.14306784541432352, -1.688151136399635, -1.3147044395263479, 0.7159700036684623, -1.1440255091553273, 0.10039927371326483, 0.15667003391232312, -0.9387591589698904, -0.017097865600890088, -0.4163841313660418, 0.6354860515906736, 0.4226690529705751, -0.923342788315172, -0.7314878054106474, -1.0677699785855497, 0.627677711988904, 0.31420855267464354, -0.40414093463928735, 0.04653154879282328, 0.19612162203192143, 0.4374276607108509, 0.32055433277731216, -0.6210546320528462, -1.0667566700409432, 0.8512240996150886, 0.07813620703231054, -1.201116508886799, 0.7972221284181112, 0.3596189856728358, 0.7851245778229422},
    {-0.9843374445351716, -0.7927654849116096, -0.321400801827982, 1.064125939668553, -1.6979163127246555, 0.5926797148183196, -0.5280566206935295, 0.2468550021406984, -1.4760351796004239, -0.39474519155869864, -0.5803845405031037, 1.1280057184282233, -0.5865987478552105, -1.005607542340238, 0.771280286174277, -1.0976041388728868, -0.027757165024047945, -0.49428864602992484, 0.35282614929005335, 0.5497773525829415, 0.39512883633700063, 0.8774987549078029, 1.002439530271094, 0.5106006842124284, -0.7245552979786085, 0.15555773981738039, 0.7468915347774676, 1.0303883511947782, -1.518022545560395, -0.703541854327938, -0.9469804379843351, 0.22066700954358498, 1.447656301450474, 0.20102262981315797, 0.8709334377348849, -0.6357049230198186, 0.8399575298548563, 1.0237017866704015, -0.8175811755703231, -0.5907507046983178, 0.7702385424182933, -0.21014207484015313, 0.1173213521943858, 0.429699826261073, 1.0938224269892118, -0.5080517350093517, -1.0259302895688778, -0.6020449809885278, -1.2092817079452516, 0.6828813752518753, 0.02243952386796692, -0.25546736044120294, -1.091202909356684, -0.7931094214586284, -0.4446294784060421, 0.06279629375093825, -0.05242024916163095, -0.8046112381948023, -0.5593912442591684, -0.544001722499772, 0.6032523513986511, -0.7230196477868103, 0.8961020297948655, -0.6945416967506933},
    {-0.48722305375073344, -0.051176639151630024, -1.0860704845057412, 0.4537510929312087, -0.7888581524629718, -0.6774501363846925, 0.24327657539677539, -0.15413373099520844, -0.28729750184420316, -0.6187736707764829, 0.3263219468009459, 0.10955703551268861, 0.42167529342610255, -1.1404237964340624, -0.7920979398784093, -1.5507990218378498, -1.4378983875999434, -1.2369648108254203, -0.09969782776842934, 0.8338705592467195, -0.3786260196522108, -0.505437350287979, -0.9612091533397434, 0.6818513361251359, 0.1599902431279477, 1.032578012261458, 0.36877080696874476, 0.01571933805221124, -0.6101759301117117, -0.23471188167064005, 0.7898168743232615, -1.0578739905550072, 1.0821633872906868, -1.2881077543980164, -1.1711283388882812, -0.9500858276966062, -1.4936669428756486, 1.068363781062022, -0.6450004556877319, 0.30301097919193914, 0.49517445710827124, -0.725574025989047, -0.5561633091493215, 0.2869227407279861, -1.1242527712216448, 0.6641905880779395, -0.755826687084639, 0.7476827471073317, -0.5940739459616868, -0.40836336237557447, 0.6495519511127996, 0.7801858496019145, 0.21159603290529883, -0.029208524002147296, 0.5881016651143737, -0.3366803933324985, -1.4507175704505226, -0.8066974524830196, 0.9920794689980418, 0.9626510396981051, -0.5002424006146607, -1.155015695629605, 0.9970340916058494, 0.6240807014331561},
    {-0.5999880355748609, 0.5054306288472192, -0.7843852126115143, -0.8208564163118821, -0.01905212109545362, -0.9846318100804221, -0.12320162959746656, -0.00767930651118567, -1.003179586907873, -0.4325320873216792, -1.3239551745604488, -0.9520198903304531, 0.3348871143020632, -0.536958850019388, 0.38743665302418767, -0.9332439205843667, -1.0894838825071265, -1.20389657067084, 0.08534541509262807, 0.19027456786372807, 0.009835947738061545, 0.3276950699218911, 0.48562006608406055, 0.37813919792204886, 0.8228933678369061, 0.6409715731616509, -0.36855907394903636, -0.1004358242090942, -0.8064192823704635, 0.6165074365777682, -0.5500248469789724, -1.236304000526704, 0.3956585897740012, -0.6483146347434458, -0.407221720675263, -0.42499717052682306, -1.4383392714385155, -1.08437999036886, -0.41572482878124123, -0.41490729438041035, 0.681197394325999, -1.0711230236965543, -0.2854378216610081, -0.4419624717021257, 0.10848212700260687, -0.20709132872750427, -0.7488563860612901, 0.08142086399013962, -0.32975538241003266, -0.8635293232214003, -1.2075731176870694, 0.31261437917197826, -0.03949238912794378, -0.41221603132023993, 0.6001414111583384, 0.942514345023659, 0.045556651799226994, -0.32745912652950226, 0.2358882915627838, -0.060140825709739214, -0.7328564479422534, 0.5085588918143752, 0.8467441199293032, -1.2725014573019227},
    {-1.3872116626885331, 0.044679158459530625, -0.34355761261463735, 0.5000923116175687, 1.0141702383413667, 0.27148697606954625, -0.8025540880391707, 0.91133116012675, -0.59828776135754, -0.42704072784080943, -0.4708252124526537, -0.9979855580706029, -1.2995467555884868, 0.592760542526685, -0.017327008087371195, -0.12332576400931931, -0.27100928440325234, -0.1386708622362434, 0.027121094628978205, 0.674935722842632, -0.3699927755761891, 0.7640852918474308, 0.9588186686100676, 0.5266616530110978, -0.6620084404059756, 0.995009934862777, -1.1261469572640639, 0.3647170732308716, -0.286121681975245, 0.9270885255022946, 0.2503907038413683, -0.25252861719487796, 0.16027133246734504, -0.9732456789671019, 0.4625865644608565, 0.8603385427853627, -0.975647429624983, 0.296047785821285, -0.5559931686622209, -0.39222288695053203, 0.15772539197157975, 0.47016577723975356, 0.5894439535588726, -1.2162240104089803, 0.9239110764356944, 0.6423439027486696, 0.6914165077551155, -1.1766310306312984, 0.436230633598458, 0.5363875952837439, -0.3389310150391908, -0.23046266417200068, -0.05165163261229115, 0.9644338588373313, 0.4550581395602028, 0.697118803200384, -1.053303402162094, -1.2238984196261085, 0.9673081142667385, -0.5057451075273981, -0.20330962422918644, -0.45916579163573856, -0.15559476475315942, -0.09323849036647333},
    {-0.43799072255396676, 0.3807474464025402, 0.20529201039098247, 0.41575990127918255, -0.37360951400274184, 0.4775627895032069, -0.3631346355480509, 0.2626943302748545, -0.9048403169616626, 0.2565533641835768, 0.6914941331401415, 0.64563727177963, -0.12147625236439033, -1.3822112942022247, -0.9763826193341069, -0.1293410802739591, -0.02031402183737272, 0.10606477566870011, -0.3039738354723583, -1.216524117759483, 1.047178864014815, -0.4651173232913933, -0.890767864357996, -0.24292569419625393, 0.9645023063748198, 0.32286200978950813, -0.8214355111533722, 0.27019232750622746, 0.15736908877746703, 1.1547711139835692, -0.4334204651209173, -0.3771884573612585, -0.5455497692193986, -0.898043110214433, -0.2569970647402207, 0.45349380649557436, 0.7759055762907432, -0.8081004664754731, 0.7433878455937584, -0.3741916105203774, 1.1699852107754487, 0.7189479450566862, -0.19769153046910512, 0.7303237286266899, 0.8948125567548704, 0.298407758632761, -0.3931423205233036, 1.006481101330222, 1.0851794806987634, 0.2956329012989947, 0.9326486814024408, 0.7226018282504298, -0.8568578829971657, -0.45650201614117286, -0.6997848847683458, -0.28264732787872254, -0.6806132700111577, -0.948036726178346, -0.8026451491106502, -0.8643991567884381, -0.3755113960713025, 1.283034153592679, 0.6030565429803006, -0.47570580377072214},
    {-0.0585429014839786, 0.41613289683751803, 0.7724213925289324, -1.0444309587070066, -0.5982115349679549, -1.2678948077190946, 0.23364595383182243, 0.4608339649016534, 0.6517403855356957, 0.8906186895765937, -1.105602327866226, 0.00965174626825643, -1.3024351650785055, 0.006139578895835853, 0.08549685584736066, -0.8953883925445763, -0.8959439416647538, -0.42117645291075995, 0.3249949045599729, -0.39239845710712196, 0.9193205783057595, -0.25624476115756967, -0.3076187050404566, -1.3846316837775383, 0.02762765521751343, -0.91853957944573, 0.509760794277257, -0.8678056473122651, 0.9559897367815829, 0.11146852712284472, -0.3961287630981373, -0.3633361662669655, 0.6558638134280252, -0.6781845615898301, -0.56821431970064, -0.886791780231444, 0.30076164257370164, 0.3930321421233642, -0.1318257348361998, -0.09085092779945746, -0.017060178736307354, -1.0504823194272639, -0.7470843038177098, -1.093039633693948, 0.5004243231683978, -0.19967056386860998, 0.13555863103568486, 0.3950364675534019, -0.8134969455279476, -0.4114885136389957, -0.43837142680382274, 1.0403711595606675, 0.9058492079386374, -0.4949766925727477, -0.1256806729934627, -0.053354076970930864, -0.22618149179661926, -0.5340130933643606, -0.14327457138829033, 0.9853323657777366, -0.660205972537539, 0.7733713643783159, -0.3441297334483474, -1.100854402732587},
    {-1.202091715447259, 0.7857169977721211, -0.2640933181477084, -0.45619967794646216, -0.916156026407327, 0.012883504632371671, -1.0837231412047248, 1.2615913886541998, 0.7415491630017448, -0.7652505074441479, 0.6059885197706772, -0.06575212509477331, -0.3696520994409724, 0.8120093283897024, -0.4643326111398009, -0.33590154833293817, 0.7578164495389547, 0.18608038610429875, -0.17595499600794104, 0.24602169809429864, -1.088166847728513, 0.6120207899150786, -0.2524630362453238, -0.2096329013053969, -0.24576725455492826, -0.5572569369921331, 0.0988703143962858, 0.5413368028152542, 0.8931267768769031, -0.4661487754558066, 0.3001057083989191, 0.8864464383322103, -0.856978140566426, 0.48712603794181125, -0.55328936025575, -0.041872548831830336, 0.8606366372653094, 1.0552086652986958, -0.9608160774988928, -0.4855269643696126, -0.7139520139211175, -1.104893480632892, -0.4262368493274887, 0.8039340828010816, -0.7241387791397622, 0.6205617072947256, -1.1334104134850542, 0.523659989134914, 0.9336512217820865, -0.18725005190372052, -0.4249075318104728, -1.0357901669883358, 0.9899403337120113, 1.101912565103262, 0.07558273296309996, 0.04358310895921374, -1.4843534011756194, 0.5259811511220195, -0.7832544978350281, -0.1891603176803815, 0.3260285920459109, -0.264024889011781, -0.8610232636668267, -0.43480516839454625},
    {0.03360324321878317, 0.21775423651781767, -0.24216226865539092, -0.06160758316419886, 0.7342593171245098, -0.35387743307415365, -1.0254272050234903, 0.44302057931788086, -0.12323362986752943, -0.6656813890981823, -0.2609474407490067, -0.5398302009303442, -0.3229322680337067, -0.5545943343856519, -0.20927111484181013, 0.8341127864449677, 0.18077879913041428, 0.4888521204713419, 0.47187324894938953, -1.0936495217871163, -0.7844347094674521, -1.0894929403070857, -1.200004709891063, -0.28103358215642776, -0.07487484588418164, -0.3034657272488989, 0.2871108145478969, -0.3090594252889083, 0.5250409349192117, -0.26317510173345565, 0.8453225992683132, 0.09646362763741995, -0.1855472601554401, -0.04393536630121335, -1.157943320708614, -0.8678224046070111, 0.7761836121153152, -0.38411594061439114, -0.4878192094247632, 0.18664457012358193, -0.036021620064842885, 0.49319369874253755, 0.39834236110942367, 0.08944502494683067, 0.4153795852114964, 1.0645237682594386, -1.1074852312479642, 0.07253763662983197, -0.652461478794692, 0.9454452778877579, -0.5023835695433652, -0.504230995054933, 0.7516452557458981, 0.3796529420375951, 1.3834956385202155, -0.09281453482429655, -0.18104691847234008, -0.752316940285878, -0.12031966819647281, -0.4793747245490917, -1.1170200417057936, 0.3369757172343338, -1.25326695438027, -0.0014925518164991328},
    {1.16984117454691, 1.1466461601309583, 0.10966070520109346, 1.077828417751563, 1.0578657215125113, -0.6873871732182373, -1.1533856169424745, -1.1770506729139947, -0.08700879158653972, 0.564834840615045, -1.258899443032836, -1.3799149001003015, 1.0753446181085098, -0.8511660962757105, -1.0176925744363274, 0.06370523527774793, 0.43970458295967807, -1.1048678878513967, -1.1658152204414824, -0.9748815528504972, 0.352833891754916, 1.2168304464269462, -0.8624904718972913, -0.3868972889453745, -1.3014933311679375, -0.756371545224236, 0.11634408660971715, 0.885887509742301, 1.1266474278028924, -0.5413597817843917, 0.27257444514557105, 0.43159177815857896, 0.44555901335033055, 0.3683433305991293, 0.7009016600154623, 0.6882339932497057, -0.9144342407248006, -0.5419159019104017, 0.7729446727942156, 0.36579608179809603, -0.45201477197441886, 0.232156365065652, 0.5072457631514794, 0.3675315293847384, 0.35783311462131084, 1.054793623842795, 1.145461504624069, 1.1156269079009489, -0.9660232834717075, 1.0758285048986993, -0.7772261755597578, 0.2859570012558403, -1.2936968076293547, 1.005922270496182, -0.16458278772746218, 0.9494940008292853, -0.20439208774042728, -0.3252885890160771, -0.9622218039252034, -0.1718698200700401, -1.088280498057786, -1.0174903600555547, 1.2484841580020467, -0.5074765488268593},
    {0.4992092953151178, -0.3274458492062062, -0.6694222567030979, -0.6427716792499242, 0.6825031847621652, -0.664171928266852, 0.47659337022595044, 0.4216104054959683, -0.2327803150038952, 0.03356665423335545, 0.4005910197803086, -0.9152863438872295, -1.0661104439489208, -0.4985422204215191, -1.1791688251100216, -0.12445988711693713, 0.01494285469727148, -0.601338916610951, -0.26279148596320623, -0.06847077982827397, -1.102914738664846, 1.097153427621466, -0.29377130258418543, 1.0693647063121547, -0.41026457680352474, 0.19884756903268264, -0.18386785040551717, -0.4351326311422199, 0.6756118229055138, -0.43677946616152313, -0.9018209127425781, -0.6586738910654858, 0.5959096582906184, 0.3229704909964096, -0.9159313931898112, -0.9589957954464736, 0.5421491696921718, -0.4582492342236669, 0.022703592570441303, 1.2707619769994438, -0.8413550824289904, -0.9778941147678588, 0.9428744349911304, 1.4131231051816595, -0.5655387875139009, 0.6071391117673197, 0.5173317264892754, -0.9544314631433866, -0.23385540270905986, -0.8877589823874606, -0.9162893279172405, -0.2208907083712625, -0.12903302731198998, -0.4162805013843051, -0.4228416070484927, -0.24569307243164815, 0.2425159005848913, 0.6249791333633788, -0.22828655145656793, -0.7603271896086465, 0.5345999869615787, 0.5967198438336849, -0.39654408231642474, -0.38552684115458014},
    {-0.9091362604728814, 0.5886631335238008, -0.0510577644323682, 0.7854945039277053, 0.946978769725681, 0.8426738376178885, 0.1112369174029477, 0.16686450320028692, 0.4862649678497328, 0.010874040028155965, 0.7406869831592005, -0.674458273037704, -0.8167514214410627, 0.032737707164758545, 0.34184673752135963, -1.1192664573315982, 0.6779863291428552, 0.3168614625591485, 0.15350098457013736, 0.07283433351525728, -1.0484310711111218, -0.9309394473058578, -1.1993613669224203, -0.8275608752974093, -0.19372101734906635, -0.2949922207971299, -0.7743056684005066, 0.7426080213369861, 0.885860730060831, -0.33694625706743264, 0.09108963207637036, 0.004038485508017631, -0.8629401626136756, 0.30697954527859134, 0.5592559300643084, -0.562704354587861, 0.14340179930068947, -1.068150295524941, -0.7924420853626649, -1.151461320766207, -0.752621025147013, -1.1766427609614754, 0.8570409304318677, -1.0061878862180695, -0.8302461626701482, 1.0542851759127208, 0.018664711171821863, -0.9843631805950508, 0.6603072203518845, -0.39511529099763826, 0.8610661879966838, 0.053273423727823864, 0.5662640283821953, -1.316326229599354, 0.7652011884191903, -0.08811622252646288, -0.0960300591042046, 0.19108771228758026, -0.3316018613272919, -0.48761434310679136, 0.753092663795119, -0.5160334702096863, 1.0424642671681048, 0.7127108233716924},
    {-1.014479361252584, 0.850618051259469, 0.6678937404451032, 0.6419347893181486, -0.6334798851370602, 0.9506291538796005, 0.7224901368901244, 1.079485981876726, -0.8895386838739815, 0.3259204332240832, -1.0699201506215152, -0.09278285986181356, -0.2608168247989718, 0.18913034100534049, 0.010108292700478076, -0.8389957430682329, -0.6527363938603483, 0.27280044252240016, -0.16334310632530963, 0.07917882514521248, 0.8225874449265154, 1.0883232471196678, 0.9344295422323202, -0.3683202136298221, 0.20935685392583545, 1.036465807453255, -1.0910141408717056, -1.0731601206439259, 0.45520678665185654, 0.6262541726200973, -0.09418532440392563, 0.6178976942246441, -0.2821866463286514, -0.47903769932803847, 0.3315840063180197, 0.040414944793605606, 1.0718123195161682, -0.2421762362996893, -0.7736920432219803, -0.5008412431291599, 0.22068715880170875, -0.041706127544147674, -0.4884990960210455, -0.08063841426631013, 0.14668459345980114, 0.39662718963735116, 0.19668970915822862, 1.0823797270724866, 1.0639564019702015, -0.015747528780875184, 0.22425721831327974, 0.9034264898945499, -0.9524504505867025, -1.0168354090862337, 0.09680540545806021, -0.6401274289597456, -1.186595670062329, 1.0321859049159756, 0.4503061529247811, -0.06650230548643803, 1.213535722787371, -0.0671140816580156, -0.1663341494934398, -0.2881869788912618},
    {-0.07672530261852056, 1.1658425668220953, 0.32536430631794605, -0.12209723275712286, 0.8486119203128314, 0.7306786223170083, 0.9056025713966661, 0.48865530376779803, -0.08432384728582515, -0.37591134908176244, 0.34780639585936485, 0.4271437325111234, 0.6669222107198085, -0.04175379580223322, 0.6805883152928994, -1.11689780088568, -0.5782162961912494, 0.5192026775520079, -0.881689038678655, -0.33340511213811713, 0.015195752086328512, 0.4737566824997572, 0.2745685133157405, 0.4789208772206394, -0.39158130925892204, -0.46221223940113493, 0.8978936132736948, -0.26658591363636447, 0.835510625935806, 0.7755814071505356, 1.1292767527224683, 0.75335102913147, 0.0752918810581637, -0.5138076630800729, -0.5821262476933747, -0.6271176322168707, -0.5847109063283745, -0.16983789893447135, 0.9776478122449904, -0.30734015126116093, 0.18699936380569607, -1.1119192224867758, -0.5644926885949553, 0.185882505429478, 1.0255553024045865, 0.13617991073464508, 1.0115647486846022, -0.6657220869409933, -0.2625762598607125, -0.33505981989263206, -0.13829350595656725, 0.4104922404419682, -0.6493279293043408, 0.41737966501272633, -0.5862007341129768, 0.8778166725610824, 0.9374094578819852, 0.526384177326981, 0.290214408399354, 0.7698922470808972, 0.12003427768424303, -0.1400805478291354, 0.41902362322665504, 0.6718760447819672},
    {-0.3297308243358191, 0.15163525028821034, 0.49803871539278216, 0.43282751549924464, -0.6062269001609792, -0.4473340033353783, 0.023106648650657285, -1.1020257367310744, 0.2932702427287998, -0.23654932244734583, -1.4075935032341196, -0.2617064424481459, -0.7744432469602438, -0.8901426158397447, 1.0325465168108245, 1.1197535970050354, -0.8611702798737036, -0.9416069454302275, -0.3852315824010906, 0.9422482781556225, -0.20190610929714384, -0.30970128665244245, -0.5935463852352763, 0.13538296449553863, 0.6623374304601056, -0.08412124404006685, -0.9097011355559089, 0.839639218792828, 0.45512759266975866, 1.113044278523657, 0.19794633102226183, -1.1089025356425943, -0.24255227246615632, 0.7962698013109911, -0.5103112698771476, 0.7183198999329482, 0.0573810275999206, 0.8369045142645689, 1.1162164357559992, 0.9282817715361096, 0.40144469811397504, -0.07699215147258469, 1.1220041861520447, -0.5365744521184082, -0.6133043306709938, -0.3462049445658333, -0.21397231019634225, -0.05350276443713465, -0.5380745996647662, -0.9727594896580987, -0.5706367856232908, -0.020213320786205642, -0.9096714553453487, -0.025384870273309837, -0.21060234969635067, -1.10733487484334, -0.475075081532289, -0.9075380626469218, 0.4988379183724086, -0.9933038596023372, -0.9651412030670244, 0.30356158865688915, 0.9886656863337627, 0.6783208537642172},
    {-1.1888570460584689, 0.4616135120083589, 0.994942107142667, 0.0971984491022115, -0.48423266725612407, -0.9508174436018287, -0.47296930481473287, -0.044021644412623705, -0.7894271046470345, -1.1374758531215006, -1.0111617660168208, -0.3808413737608448, -0.150699684254898, -1.3425460997002123, -0.3387825782907165, 1.1752088383850932, 0.7785270729373471, 0.49795976176817874, -1.2089309640181805, 1.2636280093528174, 0.30616266426651945, -1.062481626431399, 0.5763716400517607, -0.19202344483992784, 0.9100797599851783, -0.31513423976464666, -0.8639821126773246, 1.2889143048981382, 1.1336005450529842, 0.6500362715395426, 0.11308110972897266, -0.14258196441608711, -0.8187391507496442, -0.22581298722094492, 0.9835926905484559, -1.100402569951131, 0.021177559493515054, 0.6984484632278648, -0.6849019744144322, 0.4114343793803594, 0.11392221614941232, -1.1181030080248986, 1.4846834993242175, -0.2868218632851601, 0.9456114595815567, -1.1114171406254079, 1.1547007162331087, 0.09376698043653958, -1.1794169552352325, 0.7827661816763458, 0.08091858915385786, -1.1975635673256542, -1.001454191196961, -1.2595681710663083, 0.23040232951313913, 0.15126804357149876, -0.800412249406451, 0.05889721385762736, 1.1020043546239575, -1.0580177886145994, 0.20361454502297868, 0.008490393861466158, -1.0824277258924373, 0.3134649007659204},
    {0.4612516732291621, -0.10396082619139338, 1.1669454946903415, 0.005769355223902687, -0.7560337517674267, -0.40265753653966047, -0.9066084437787794, -0.7347171805039913, -0.7234153599835779, 1.0713121889337476, 0.39453034355599553, -1.1347720964733525, -1.3249613241975517, 0.14347356313563037, -0.9669725916168417, -1.3723090765381063, 0.41922800102806945, 1.0102659998153602, -0.7308589318989187, 1.147126029637806, 1.1324955432728692, 0.6245794570605048, -1.0525390254206377, -0.7979926266479819, -0.6338463199792015, -1.2792237188068265, 0.1950345122269154, 0.28118197538713513, 0.9643878400778159, 0.020807552313797648, 0.6429949494268004, 1.175145815095573, 0.7954805093891661, 0.4976047222376061, -0.5102386149008229, -1.1952920207954123, -0.9654948394657724, 0.14561610183418397, 1.1433136051183335, 1.1385872129767667, 1.1562419699014155, 0.41874017667153646, 1.3527562031154978, 0.1761335380863183, 0.6392723694197378, 0.7793757139377333, -0.9478385426185398, -1.2043054140977636, -0.7561362023534286, -0.4803989087698125, 0.07388520478762313, -0.8770669602374048, 0.7219332148878825, -0.3626835921720355, -0.24537273670914214, 0.9434663869790335, -0.8595650221602281, -0.6217651406736451, 0.5678720701301306, 1.17878313991854, 1.0020744449213135, 0.9958807322917754, 0.5904218661162195, 0.0315981340216537},
    {-0.07903421139403544, -0.7630283237183375, 0.274943569780748, -0.884304043376429, -0.08548499569878829, -1.0433784460626025, -0.11778604871330223, -0.8756875439553264, 0.5966578352952058, 0.3406137093228564, 0.2929678690613476, -1.0402602017527105, -1.319463136753403, -0.29003380424258834, -1.174466015790829, -0.7018053765559313, 0.10007797473259551, -1.159530465736873, 1.0823807256145028, 0.20146604633118909, -0.8275458339730305, 0.20334408463802323, 0.1301498185052774, 0.7361676457866686, 0.8048781044347483, -0.8082794960712836, -0.37844040710194815, 0.34980372954676386, 0.5580148883559987, 0.4487954193432805, 0.5911177033663602, -0.47561558025713263, -0.6169421667414406, 0.47356257287700243, 0.6212563165813835, -0.6453120203984732, 0.542655163388917, 1.095752898685756, -0.08322077192416465, -0.749252921967407, 1.2817642446620692, -0.7323085472036635, 1.1847067931485624, -0.18875314793688883, 0.34787490345906263, 0.3416092807958048, -0.9039363957525142, -1.0277131354281244, 0.7551803957494309, 1.2445940689792616, -0.7069191690210029, 1.1947596980470783, -1.0226889630678024, -0.6797270978252432, 0.4770092220338718, 0.23070253534614402, -0.19587682012999405, -0.23471213600667373, -0.36003515357880067, -0.9536480867546441, 1.0680809876203352, -0.5345935974829686, 0.8871718098013276, -0.47909260627064987},
    {-0.33127401772045373, 0.702760470439697, -0.5403844217991207, -0.23415341290667988, 0.6812164581667454, -0.7715241424319257, 0.09369069837716347, 0.7806740582522296, -0.6041009246267135, -1.1786474280205241, -0.45563600851212877, 0.1751525166830018, -0.48370813854858746, -0.01051525708244836, 0.02634618996574865, 0.5776753444718582, -0.10850905897593092, -0.2331989817649719, -0.1501850439228045, 1.3060468898076512, -0.8267722025554087, -0.31914400982721314, -0.585748221686875, -0.5930365013488816, -1.3934917288421413, -0.7705161094127786, 1.2934376634780484, 0.8663347298564854, 0.48304688527243655, -0.5032958495036582, -0.893480578918845, -0.31130713240661934, 0.9206035634888382, 0.8213353826143278, -1.0484431817871276, -0.11009820212369763, -0.7170901337347859, -0.8335856879649112, -0.21643232801567616, -0.7764281619005843, 0.978059204566154, 0.8412255759929711, -0.3034893448519098, 1.0929359021255964, -0.6895704758072789, -0.7854611636535773, 0.9054638089641724, 0.8613526546646255, -0.9908958002425314, 0.4519381662253402, 0.5815419591786248, -0.800116284856032, 0.49403773815702995, -0.9713498165429161, 0.9642073307109144, -0.7113899413174838, -0.6626434638221788, -0.2867719708027601, -0.9984008113589719, 0.9898238310385871, 0.37201878579627595, -0.7720610689806771, 0.06577441749175514, 0.6779316505171725},
    {-0.2634399067881971, 0.7807906321157947, 0.021877538045317047, -0.6061581627298657, 0.4682912392393379, 0.39910679539032856, 0.024449723352177936, -1.335483167754073, -0.5795832211052955, 0.6910433764662286, 0.9090768952969851, 0.05113292410096078, -0.7884995703151835, -0.6281572160569285, -0.16012698666304964, -0.39516404765419383, 1.0980197764813657, -1.4086462353694695, -0.2695326897821682, 1.066208250374434, 0.05160733712245362, 1.1492035073001323, -0.5545279614035875, -0.7981973929945418, -0.07974925807786992, -0.7914320947116575, 0.2915467343449838, 0.674764188995282, 0.7731650188858759, 0.4127840173111624, -0.1571210768916559, 0.44385473535079845, 0.29308324287212684, 0.5458507839073136, -0.12585172128389818, -0.11228358744729224, 0.14619607522433378, -1.3055278425997556, 0.12443254612843842, 0.8266500543663425, 0.3183016483720258, 0.6270458771064652, -0.08900375214395395, -0.9214699516989816, -1.2573823229398728, -1.0770542654231816, -1.269618652183046, -1.0812908852216707, 0.22416757755248484, -0.004790301493264442, -0.12234528289111962, -0.9946381804005137, -0.4393627447197812, 0.27848122944816184, -0.7742209806168283, 0.8775741190189719, 0.7148770441988109, 0.5487377602107304, -0.8712020659563322, 0.8256903068344997, -0.9223114148730561, -0.8873611234200041, -0.9944651807371828, 0.923425381624346},
    {0.006897090555738938, -0.5683687822616873, 1.1693024947468709, -0.9249776747923844, 1.0129486277712665, 0.21286157631754588, 0.17022702772775347, 0.9508554891013097, 1.0162565705182136, -0.6043538102122226, 1.0145899480616638, -0.33572564482700934, -1.1201021798522361, 1.1677881879670677, -1.1271151808754691, 0.6250713328481426, -1.0548025250570672, -1.2527769384596839, -0.3130043564838704, -0.1364513302320796, -0.06476766440189384, -0.08105708269420613, -1.03471490439397, 0.20370821460788577, -1.2147444860855794, 0.12623323905681058, 0.8100016145957104, 0.05636821750785428, 0.09850489223148932, 0.947939333243152, -0.07224164017408144, 0.3262269734709575, 0.10993444108474205, 0.3920727669117891, 1.0081428444476481, -0.719121633987679, -0.07650924893393915, 0.7962613329486555, 0.24262157686010902, -0.7706723826430754, 0.12147361745845464, 1.1975916986609343, -0.660379542788003, -1.0873896781699366, -0.7345619992432207, 0.3909994368041463, -0.6512121514565592, -0.13753918240361446, -0.6270260223709104, -0.24781197100612123, -1.0691078047053997, 0.7924477209670597, 1.0942758656812097, -0.07740654282235912, 0.21580187654398003, 0.09969918675190755, 0.057846697830858794, 0.8504694045434534, -0.07114381135355678, -0.9774875303875861, -1.1097788867008698, -0.6067025693951041, -0.8674159753477968, -0.432769209107274},
    {0.613066766794185, 0.5099464994487354, 0.7427640335059519, -0.5564330019860237, 0.012390981007682782, -1.0792480868287189, -1.2664092058078096, 0.8801118706929448, 1.1269929401920447, 0.3855884378988683, -0.961037864997366, 0.25325954695199865, -1.1078550652908639, -0.05628495166254291, -0.7074330184538619, -0.727503821027608, -0.26919198901475316, 0.3995853021443555, -1.070163107012187, 0.10166206094548377, -0.1867430733446833, -0.14360388456503612, -0.9069036595483346, 1.0782178412399628, 0.06827929307335333, 0.29796851295734456, 0.585769734666166, 0.5617925347436298, 1.137914952885911, 0.6920873006882471, 0.7255855315530703, -0.6168496885352563, 1.0492238419846445, -0.04958478666594334, 0.026840863656874606, 0.956706318944626, -0.722691744130983, -1.1139629379307718, -0.11614451695303238, 0.056409403264063296, -0.7950376386931537, 0.5674211995114549, 0.7013592928577288, 0.06581240801409428, -0.8121043539243396, -0.24345829679730693, -0.7952804850031236, -0.6935753524861605, 0.10712305047355666, 1.234885339950409, -1.1525342711321118, 0.35495128882739757, 0.6824708561495765, -0.9636876405206557, 0.11083757166313088, -0.2832676091762922, -0.3865423627447697, 0.9056603552750929, -0.9987438887647314, -0.3310329281079261, 0.6797687520577366, 0.6937272062837804, -0.8461800647906251, -0.529832950988406},
    {-0.0851616503180648, -0.15212543892459202, -0.0650178022290187, 0.5639100394960105, 0.37928183037375696, 0.9882027977344731, -1.188594754127215, -0.6872742414658212, -0.08419592649228133, -0.505645496117645, 0.9572526030024621, 0.5027570352567141, 0.18473169874942136, 0.1539209311917595, -0.31306167663829665, 0.5659426296799717, -0.8742102464051986, 0.04429453412940466, 1.0723564793577567, -0.8691350946778312, 0.9682830042602789, -0.3050970317355812, 1.021288752949716, -0.28378144474376366, -0.8707703378383348, -0.8429862646273694, -0.7696383470254017, 0.6604326697503039, -0.9557670039313942, -1.007540991097879, 0.36727051236082064, -0.2846195862773321, 0.5998971892637819, -0.31450927920304395, -0.12999036721194554, -0.09590074489000389, 0.7675274538603882, -0.2986652198669177, 0.5114505505953006, 0.5478294128684063, 0.49651653747339747, 0.9128248336415374, 0.9959270518900076, 0.805075239595095, 0.39343819626482546, 0.6423078919891008, 0.3893330299177952, 0.9786496654631803, 0.7401679783812524, -0.8035845558560442, -1.4993146457234279, 0.04408106349173055, -0.32538503066748886, -1.0337663530316943, -0.758453791978473, 0.9746398355290914, 1.003558053242824, 0.9883019478899219, 0.021289684268070857, 0.5373446890886755, 0.6329617072601446, 0.4136968127999237, 0.8976607294245704, -0.8556780984320098},
    {-0.28428229373128994, 0.22763408979745486, 0.4795220232882981, 0.6313284787657004, 0.7461597373947911, 0.11356029613918497, -0.059117634282302385, 1.0013932493290671, 0.761540705856195, -0.5730918724665741, 0.3997695184727734, -0.8701070540771848, 0.003157433774356818, -0.1448139188928291, -0.8627265131465058, -1.0213731123890246, -0.580021447041554, -0.8847498044282129, -0.5461315659053224, 0.004257789665017036, -0.8057948169822776, -0.03981278194768122, -0.8188807996117143, -0.5505709630496479, 1.1496516785510353, 0.5394298208639046, 0.7262523434306061, 0.6689930776752339, 0.08441554926250817, -0.8190073280395043, -0.42051303071938717, 0.4840084018610619, 0.13062466552528784, -0.35040247877736974, 0.633498829098327, 0.3362674984608246, -0.8457619761279238, -1.0612178279906546, 0.32558384933028756, 0.57640695277145, 0.27158342672782776, 0.5946365527433893, 0.784583872965359, 0.29270269020364226, -0.28625237607757764, 1.0867519791577984, 1.2657802178013764, 0.9808929635202237, 0.5218520988919148, 0.7782236892714754, -1.282494357310123, -1.0441535212992334, 0.24030982384445776, -0.13894851848570816, 0.15917172802202134, -1.2228344306319656, 0.33468830737854743, -0.7292810085140604, -0.8948079888525111, 0.3373643642507535, 0.5144502699920013, 0.3866051559093251, -0.5957629887570562, 0.8186132316757779},
    {0.023210534601984734, 0.7660864825264615, -0.8646644520952876, -1.0084691289496535, -1.1747346960180727, 0.19049649604255567, 0.3801540315641845, 0.35441107083745743, -0.9573097955943113, -0.47440813238590435, -1.1006498127321156, -0.8176511152122972, 0.04761674201512021, -1.11303676498444, -0.03981915006191937, -0.341998271377756, -0.5204638207383655, -0.19045075991305094, 0.8669535528183577, 0.9513246692684145, -0.8498743576845625, -0.6380524283651846, -1.0782797174216852, 0.7948720428780158, 0.7972000853066912, 0.5131910608655982, 0.2847870232459165, -0.5174907799549263, -0.9097772732052504, -1.0701538657379135, -0.852697808369693, -0.19132559689291703, 0.46855955838688457, 0.6913891972313424, 1.0528618192015664, 0.04930105888391155, 0.1991766262150481, 0.4477355564019727, -1.119681668633831, -0.7056433513554472, 1.1112937126864275, 0.8613446828367696, 0.7322226238592209, -1.3069887016798072, 0.25084824866744687, 0.18660764030222252, 0.8315976232516764, -0.18758755401894234, -0.5543262690115979, -0.31766216833753785, 0.00271784760937369, -1.271223432121673, 0.7597823964937783, -0.43316821499765373, 1.0436501775094587, 0.7267402276200728, 0.38547574881579594, 0.6491112329563277, -0.8447035663058665, -0.6656727088879286, -0.7995239170382165, 1.073298518312849, 0.06427562970061174, 0.49741905177094836},
    {0.8764913494102904, 0.9504968231305121, -0.7377244476575258, -0.01973189932077548, 0.7450890799317527, 1.059300535500994, -0.3031629157669664, 0.8386731852818912, -0.9605197631159903, 0.2380155485638753, -0.3762155919996926, 0.18248437201135184, 0.23378631955139245, -1.3001975109871906, 0.3975744690489995, -0.5096412814046074, -0.8256486456606442, 0.8823397584648832, -0.9069273735617664, 0.2243210512698795, 0.3116070580054974, 0.43183607137189406, 0.36686833793123996, -0.8155786888225994, -0.39201390408493636, -0.46814060117284617, 0.9327817089823505, 0.963721375247416, 0.38941259652793975, -0.8012857896379914, -0.6913281371110609, -0.05286966160459983, 0.19828210932958004, -0.9905319125197863, -0.5963107474892017, -1.033959066807984, -0.3616665835551387, 0.10482599622573448, -1.0711111330970626, -1.015093608912114, 0.5883623659938187, -0.8469558611962748, -0.10037237435632437, -0.5277603302182641, -1.0001787953200771, -0.7009973658795157, 0.9247767698975611, -0.0006025372151385862, -0.7268461457201711, -1.1341031155383174, 1.0938040068447026, -0.7174938153875267, -0.13292186085799337, 0.6932191207112404, 0.7422555238236167, -1.1964730358884845, -0.04585941735401252, -0.8164308903600173, 0.512699254014682, 1.1310411744992217, 1.1357438979192789, 0.5396653558225841, -1.2988684470542138, -0.685843886752881},
    {-0.8850302695345036, 0.4339433642403176, -0.6867708611167657, -0.9608839178191613, 0.8099300748065197, -0.6615802621058917, -1.0170913455107085, -0.6086759871823277, 0.8161601799049277, 0.1001280545984162, -0.2677325166037884, 0.9746570512775272, -0.4998853182855105, 0.8920638771700667, -0.3088751433932421, 0.2548534136433993, 0.5677965149787609, 0.7197862831205138, -0.8494831747863928, 1.1388983941741357, -0.5767491333866996, -0.769975611864763, -0.8715221702906484, -0.4467126517650814, -0.5861624767980419, -0.3613522719848666, 0.4098927842196083, 0.25591518456072665, -1.1095111072379977, 0.6213728749322609, 0.7666464835341752, -0.3186705323003856, -0.21688256931261105, 0.6545437633014095, -0.3246248099905579, 1.129029915802059, -0.6833510290642022, -0.824767651395236, -0.760585722717453, -0.0979991002276781, -0.8412377485359496, 1.1590422157088913, -0.49964505295031597, 0.14444674851442904, -0.13263366120099782, 0.857194738634367, 0.8472199017070249, 0.4206035409826128, -0.3223832035577148, 1.076239658625143, -1.3264001935100311, -0.9915731701469436, -1.0099623913594913, 0.7312115984873547, 0.7590467131892198, -0.6815735454167327, -1.095133977323982, 0.12219300162701248, 0.9050174391853275, 0.5031296878038702, 0.8901243199495086, -0.8279343201665135, -0.8179034370362636, -0.0025941442768573834},
    {1.2074514655310784, -0.040109626855234726, 0.9459135069779877, -0.5176024145963944, 0.9266063578323243, -0.41612324253277366, 0.998671278025339, -1.0523089767860518, 0.7521414659216955, 0.8441931482617663, -0.2547043497960329, -1.126635419419071, 1.0438097377072968, 0.1505632628374609, -0.32226776495236176, -1.0403703391149248, -0.5181950971322717, 0.04715133172559275, -0.02888618716959127, -0.6826281644076685, 0.7046513975394222, 0.8543995172029176, -0.06816068954840944, -0.46982168900746707, 0.32934527433543054, -1.1813255502014899, -0.507072089617158, -0.3566133611545221, 0.7015343097619772, 0.21383136648026865, -0.3817538570803708, -0.7470292785565626, 1.0569992050959354, 0.3016837737044805, 0.9829660818276331, 0.8478509160104, 0.27089166432192097, -0.6613272366881922, 0.2647575112846081, 0.5854160030500775, -0.8933262129644655, 0.310257443192404, -0.4663934714164593, 1.0555616064954008, 1.3155005792036163, 0.5873734405193295, 0.4838234991739896, 1.1193173438698596, 0.2796238695395856, 1.1452429849397021, 0.4123254668079402, 0.846719281718489, -0.21815102981795112, 0.995893340606921, 0.21340402175427672, 0.3183274272873177, 0.64503833589389, 1.0585027564487646, -0.7530508404798728, -0.3609272100417529, -0.9649275001476695, 0.3752174356738067, 0.18059345943823898, -0.8127101090881008},
    {0.4672847088106898, 0.6917351679553942, 1.3728956323386676, 1.2914272338063797, -0.5007947286618891, 0.1899881604552426, 1.1779639174002952, -0.6214480510712861, 0.9563002499448543, 0.5002636160930221, -0.5792020102097065, -0.9662600276637574, -0.2786992607189022, -0.361580972834098, 0.7404323953875915, 0.20008380159055936, -0.09813567050782405, -0.6034665747364194, 1.066177795640007, 0.895253800058072, -0.5107878959155538, 0.06381840116712162, -0.7662927908218868, -0.41147953202585835, -0.328103139615155, -0.6033187490076732, 0.6605380833169939, -0.38615995006669956, -0.6689961577283952, -1.095107578800111, 0.1814462674334355, 0.9988659691770861, 0.2763080406104063, -0.15854404047563667, -0.44419025099521164, 1.159706673427783, 0.640036595375056, 1.1026826308889597, -0.8991921443561938, -0.4675752335637435, -0.7176761502712151, -1.0897725818068038, -0.12766468818877924, -0.6622267584005092, -0.32192178949308203, 0.45682454749553913, 0.3924548704947089, -0.555409888615995, -1.0321649136676683, 0.5961166434338423, -0.17362717679504452, 1.0379461572539666, -0.2529579089497511, 1.0418637929484331, -0.7552544157436442, 0.6339782990833139, 0.6352346654161629, -0.01551312380631407, 0.22107618834627316, -1.140664660997347, 0.3543231151390268, 0.22136459668884062, -0.5260690429551623, 0.9747925495142432},
    {0.27265704236044214, 1.3032636186764004, 1.1663154043933284, 0.5801711977872734, 0.24548775504381937, -0.30000119898703886, -0.5195022869417328, -1.1088928734344852, 0.03386596160489612, 0.41809293720718943, 0.9569006890000404, -0.2792562872696035, 0.7641807650206417, -0.5608387426484172, 0.6406634220742904, 0.7255572988951674, 0.5383976104415521, -0.7201138275684957, 0.9931687674037764, -0.19288230847104915, -0.5680037918318516, -0.9674051080766034, -0.32343677100844986, 0.9562877016159131, 0.24823458994695516, 0.33361484934028945, 0.47805667823948345, 0.2297304899791818, -1.1344813210938323, -1.1328900010956442, 0.6886949064730221, 0.5066277421360437, 1.427583471502064, 0.48955921810723746, 0.30488159803681847, -0.3736779255615892, 0.2612777326207095, 0.6619674016062164, -0.8300333147319794, 1.0490276571238526, -0.4265035314342136, 0.8739716695126003, 0.6917143525942103, -0.5144742733105514, -0.6965763195857116, 0.8057448785292346, 0.400116138211703, -0.8345114803719805, -0.5555078067132252, 0.36254024402680873, -0.9592357265886062, 0.8214599434259922, 0.50664499803702, 0.47130233514165043, 1.4807686818457926, -0.3473799588209015, 0.259368630865931, -0.7725355856484575, 0.7276341810596073, 1.1279091051207697, 0.43317949688906304, 0.2735427806507759, -0.26182152947521603, -0.9328362086514839},
    {0.25449646059528436, 0.25352154434757496, 0.9022302256757867, 1.055263757607039, 0.7020828938841791, -1.1274858351305075, 0.5499382479007549, 1.0281370123545914, -0.5897104327490191, 0.6677841826763209, -0.4401336292771342, 1.1277144956036274, -0.5393574210137679, -0.2617313723189324, 0.908414700753695, -0.026241710597151687, 0.12410130849066653, -0.4801500852225824, 0.2899135358883881, -0.1809490734471665, -0.2349434847045956, -1.0660299013725059, 0.5590092685098551, 0.006696909183400161, 0.07647260343211983, 0.14116433819210034, 0.0722722592950794, -1.0565610622344859, -1.039643636214601, -0.8370038401598868, 0.24978207630817778, 0.8076201264172981, 0.39062044471495655, -0.5416237097435173, 0.8357164894315225, 0.5876903983258803, 0.5333825023786034, 0.25547638826763597, -0.009619119871175159, 0.40772737708890094, -0.5434153451135617, 0.6750596422809784, 0.5724090442998128, 1.0453385783864475, -1.0259035623055766, 1.0950024197153725, -1.0227989947930551, -1.0730577409140676, -0.23771051211740649, 0.4753353387237333, -0.033711465968516714, 0.1243316967004344, 1.0589076604460146, 0.2540593440764665, -0.6851543894850916, 0.5762294164911279, -0.33679569979438545, -0.15341975720655582, -0.6240085383469083, -0.289608559596394, 1.105621018777957, 0.5994599823326915, -0.8921726072718915, 0.9382273191229208},
    {-0.49279241013334213, 0.7362082179727121, -0.8377368739669737, 1.1264704531590097, -0.5468271633843788, -0.976129499111339, -0.24756735260645996, -1.1774922743900549, -0.12492515933915456, 0.0005679229378913923, -0.14603969746369838, 0.6541563762274496, 0.5928576394524173, 0.40146716895284335, -1.1384341994421745, 1.1848501901253135, -0.9357890946151637, -0.8466453804980028, 0.27885368922820947, 0.4340943148317488, -0.283398688435277, -0.9592986135478306, -0.6993628191808455, -0.9969850930078181, 0.3164643107794067, 0.9030107040335167, -0.870338052677567, -0.2589393216583224, -0.5061810673774014, -0.6750345026835294, -0.5649016136071722, 0.26175532833838727, -0.592573507957723, -0.4749091635868828, 0.156805112438306, 0.02709026266721594, -0.33234676555862436, 0.45478032941829283, -0.8931024810796713, 0.5199840532677443, 0.7518966184140895, -0.4741794750629522, -1.0534926143461878, 0.3259380955070135, -0.37802406288707746, 0.5196608075625896, -0.6599620011375881, -1.0910710679808227, -0.015929590822538187, -0.9285852725686043, 1.037373221963433, -0.06731795570857393, -1.0440565959819814, -0.25282419372092096, 1.0054907143632412, -1.1686449249770405, 1.0202585838648832, 1.1402683506797464, -0.24016360332118528, -0.05033077212860833, -0.07765897005582752, 0.3909539673116393, 1.0206327678739526, -0.6636129221633578},
    {0.028344235986779487, 0.23918254087493374, -0.7720772259922453, -0.48631432101185995, -0.5761198475165964, -0.4756670250992997, 0.37569717190573504, 0.23690159488167442, 0.47374965091441756, 0.7781424268403129, -0.3721557966909969, 0.267235820488874, -0.7577821076652739, -1.0652995125731939, -0.22067832262283102, 1.042034303860714, 0.7466310838367134, 1.2316543594608307, 0.8772674160473372, -0.6506400762847925, -0.8819203364095003, -0.10611923964955486, -1.1165577944826688, -0.5285081248747344, -0.17464368501295907, -0.1735728687699167, -1.0509197480156436, -0.4550698144348911, -0.004512755217966603, -0.1452990970826991, 0.13858103705707625, 0.06449807224745673, -0.26489891201920973, 1.1297409301782513, -0.02035688984968599, 0.7429835055375875, 0.7516153939104402, 0.6927408749801492, -0.3819710053751595, 0.2576965895391562, 1.295383668542538, -0.017703461369931957, -0.15185796379289615, 0.20232460660245913, 0.966433753772964, -0.109895323532973, -0.6048226534269723, 0.635301150173872, 0.35615122894693635, -0.5250925519332766, 1.3625750006758877, 0.09272140957498369, 0.09686497843009018, 0.2540410788660097, -0.20974986285910596, -1.1422600438877282, 0.8908829380910991, 0.5762240181681787, -0.28651487724611024, 0.2744285436861409, 0.4424565721510174, 0.6339217909676252, 0.12325024081627285, -0.6786104281198587},
    {1.0389679076742278, 0.5943473713959466, -0.046139790183175204, -0.41302164890775817, 0.7757167102314558, -0.45380672745320905, -0.18860400286395074, -1.2217092045086206, 0.3165999126615235, -1.2278664351558823, 0.9376139552360925, -0.15557747953787018, 1.002085509533652, -0.6330400688154925, 0.9468568573804718, -0.9936578568656854, 0.7682143861964121, 0.6088451218857066, -1.0614100034225455, 0.3968108298050559, -0.17015962178254526, 0.8008847865747956, -0.47553802617232105, 0.6667941905278144, -0.4183172755707318, -0.19138260518756461, 1.0574297628759781, 0.22297572668810495, -1.0256599100893498, 0.4169906397739462, 1.1148608726720395, 0.7360230192281623, 0.8854293279096253, 1.1101022464535164, -0.09149417077803168, -0.0696259361680026, -0.652013552103275, -0.3792746585345202, 0.11003150227244277, 0.8245285796009608, 1.1841753972005797, 0.5058079943984652, 0.8257308393520967, -0.6401562951172104, -1.0329865877091267, -0.027999370551800937, 0.1730872188648986, 0.34327286622389797, 1.0835462660409962, 0.44298125777522257, 1.3070380751121802, -0.9565553039612198, -0.7569324511903817, 0.1831700256206906, -0.4240716122876091, -0.8532425341015625, -0.0011862941140527528, 0.587562753267798, 0.00628637459094687, 0.381580854511377, 0.4486206900588861, -0.8091678678336821, 0.7582245399211941, -0.4660489529315248},
    {0.2583493102587321, -0.19135602982076352, -1.1634327574512247, 0.4273895230280415, 0.8158205867329328, 0.12339678034355828, 1.0620709709448632, 0.2107599968301024, -0.8539146414751825, -1.311886694445967, -0.26791362448257827, 0.33721647655713044, 0.6206643165313103, 0.3900843262116126, -0.46686092476354657, -0.5886120988970653, -0.5457496089451969, 0.7563501005503434, -0.7812349009244175, 0.5270840075981039, -0.5096996308525557, 0.7877869592848469, 0.8337045964463542, 0.43665458528044593, -0.5324477537624733, -0.3366753957257521, 0.8594323208782432, -0.09307818690327796, 0.5061896963532152, -0.015225310352346888, -1.0661671098931766, 0.43784352626028233, -1.161437308177433, -1.1323497422796385, 0.8106077758517682, 0.20918626098600657, -0.4270407832555642, -0.06162730616286436, -0.286188910589405, -0.6905239616340069, -0.5735573692518957, 0.5335471044897745, -1.1558258634219043, -1.2089645110986729, -1.2077073767812996, 0.20343004299039003, 0.3555186401342563, 0.799173218112152, 0.846227107124834, 0.9203875846934392, 0.7287935150570258, 0.9247211828259493, 0.8093960846660665, -0.9306047528003714, -0.32391942667152723, 0.6801754983142276, -0.09639979384416687, -0.8631527757368467, 0.24096033005785275, -0.1498485620904824, -0.01875086394369633, -1.0036432096188448, -0.1713206827093068, 0.12059066579806543},
    {-0.0795492090260038, 0.6585631210799726, -0.6574322535648772, 0.8195949063800313, -0.04717455084219768, -0.18891630784824937, -0.012279958459453918, 1.1962844371237475, -0.8203474286300924, 0.6987381471328524, 0.7260869119833004, 0.3575903253973651, -0.3333026635909629, -0.4653875163856433, 0.5457196984620364, -0.007903302825734263, 0.8514267296841326, -0.9123422123628411, -0.42196762509106445, -1.148294465260792, -0.7715687968725352, 0.7809050731196897, 0.6030479382623982, -0.1354184534868289, 0.7278149723653905, 0.5951369451532276, -0.7071181131825891, -0.7121902292583833, -0.07858946266945181, -0.1484478664680228, 0.3975204635265645, -0.04596123788418384, -0.4129901117930003, 0.37818319115302795, 0.3832815200624398, 0.7268827736638237, 0.5028037456969604, 0.2517344407140104, 0.47374488383592145, 0.256941673023544, 0.4521828152495299, -0.8962018276696512, 0.27041081681647916, 0.026884853170502935, 1.0467001400004277, 0.3898035637562602, 0.9180613150293041, 1.1792937932393055, 0.59763671551258, 1.0284823215998113, 0.17156420124647215, 1.0892415595411555, -0.5325591987372539, -0.3989309473119472, 1.179000548226393, 0.45527993516357673, -0.9166458402163973, -0.9961522781755049, -0.8588706027358818, -0.2984544880345791, 0.4057949074440363, 0.8815582566805759, -0.9617407361535457, 0.8267060279983334},
    {0.28553055060550947, 0.9579755845207045, -1.1708544890561046, 0.8633789846172885, 0.298260294314272, -1.083070572515811, 0.42739201695983625, 0.16236952064361643, 0.2803426868472279, 0.25173272833686056, 0.9174948865845857, -0.35762481167489685, 0.16620573062513805, 0.6744104951504272, -0.7795231035500282, 1.1147570034705034, 0.9541928274220941, -0.28114592882484707, 0.4436229914554747, -0.6923435158549687, 1.0593815451424018, 0.02386774825851197, -0.7252507476938425, -0.597072767958256, 0.29665179475094555, -0.49815699222073734, -0.3797673750823865, 0.27364169275753, -0.880209186039752, 0.5540700055367782, -0.6513848091710656, -0.40701769976420715, 0.6727185206548468, -0.1392226970378447, 1.104088565565585, -0.3922095343326446, -0.919969533003963, -0.12802433480859488, 0.7444917599704826, 1.2931747652864591, -0.22141836209413224, 0.06702931740691787, 1.1091535038926024, -0.6749794927093986, 0.49333052012095635, 1.2165331003782887, -0.2753537974261527, 1.0981622202783339, -0.49179444570786063, 0.43453642909708057, 0.07482143886193743, 0.39940439176295034, -0.6663634353536192, 0.7965172904381495, 0.984941821853977, 0.5093595182690918, 0.7285292553498498, 0.06300279927352354, -0.6928512004239927, -0.10744198260222777, -0.9218505386507221, 0.3725071589893154, -0.4419901405697155, 0.9376840895117374},
    {-0.7052865416745606, -0.9987081950812068, -0.6081573493527909, 0.024944354474447508, -0.6977285986307367, 0.026306538195312805, -1.2535460620860135, -1.1103428340958716, -0.9140154357812297, 0.6303833559955915, 0.6988601091780221, 0.9512857735616914, 1.049367584655482, -1.3171467709632014, -0.9262374408536274, 0.9137671006301945, -0.6518320438263544, -0.8387216283566876, 0.41264241527236456, -0.882882999740594, 0.4271406863323961, 1.1694870507752293, 0.46858757441039134, 0.23210998525468945, -0.33434725103078666, 0.9532793862049463, 0.2732422939590151, 1.1212183222444891, -0.570314853147262, 0.9882803937657388, -0.7866806543524689, 0.4279931664020829, -0.45454932796768055, -0.4028253311558472, -0.6938069460063652, -0.7456981713212633, 0.6550441755208367, 0.8989963064301575, 0.09087974367361211, -0.7690530432008286, -0.5821386715943137, -0.6282717203121783, -0.27042238847918876, 0.9947826738565845, 0.32257002096303256, 0.06960401836785207, -0.8167181185943135, 1.0631000689472527, 1.1201171299278005, -0.5765066501557297, 0.6095537453428, 0.19555158669546532, 0.6233055855964517, 0.009364829326185126, -0.9546530072215049, -1.2731961747303389, -0.9035408212357943, -0.5802501947461374, -0.8583377400361933, 1.1099632892207583, -1.0182217645961826, -0.4158120850063594, -1.1541370587695912, 0.5948452300117817},
    {-0.26682571229697305, -0.08193968214044899, 0.13090512027059908, -0.7058347908168526, -1.3740305096828762, 0.06598356047061255, 0.25886508726321283, -0.15753788122768544, -0.3107572801021402, -0.864583900109344, 0.5897394849176417, -0.2417365396303342, -0.5837536361317753, -1.201147803978348, 0.7301974579557027, -0.46653626178182334, -1.1441807184828965, 0.344050179308265, 0.45377969788164163, -0.45199111089671107, -0.1665494647575973, -0.5224167879261695, 0.4175948351894928, 0.5016349012878674, -0.9856830102951156, -0.005672917022626931, 0.3692624281644586, 0.3517894142343832, 0.5362715130966671, -0.44654849882203257, -0.7315243813859037, -0.1307515498362789, -0.9489280758969457, 0.7168070806845583, 0.38396917672110287, -0.14747408783745997, -0.6929344324660626, -0.5383752412014938, 0.2098864938038535, -1.0735218607408115, -0.9297832024100344, 1.0214316018445564, 0.43808885136844516, -0.49017640454111183, -0.8728016525671838, -0.08552971647191572, -0.2194617440245826, -0.3619004198530558, 0.5076751097740394, -0.23611484297898563, -1.0992895986397853, 0.8637970291676609, -0.4374310817431016, 0.07766020225726596, 0.8680891058630124, -0.6167224486959281, 1.1088265063141667, -1.11855011552786, -0.12034812249392232, 0.2762352225291046, -1.16818999986525, 0.8623775095741145, 1.024961742817963, -0.7053992928569612},
    {0.56069567742792, -1.0042959508404639, -1.0752526907945206, 0.03465535628518443, 0.4310353700460088, 0.9538820670110114, -0.4598921568980155, -0.8896292564510312, -0.1652732144383967, 1.0161002623964357, 0.7265195037879706, 0.5433348464450007, 0.1497897026353697, 0.7148793614744158, 0.5188829717870301, -0.9516713608841619, -1.1937316467333132, -1.0337214759433755, 0.24337725282778627, -0.7909713879321607, -0.06235710583581025, 0.9420965957916487, -0.25605771541972466, 1.0845239884683675, -0.14712329567947624, -1.1192807051498195, 0.8245425449217537, -0.9720606444532798, -0.33172053438267884, -1.0194396976276945, 0.3719998234857357, 0.22895370803610787, 0.6529753628656466, 0.9211680665969265, -0.6428671120919313, 0.06111821850994177, -1.188352945574445, -1.0785662370892855, -1.1672160271030756, 0.2987795225081817, 0.04606886859519163, -0.8710667992599954, -0.505660229422021, 0.42917525410784535, 0.8121638977254828, -0.21886892842021843, -0.17477776119623203, 0.8197475506240058, -1.016205047540377, 0.1608199017349081, -1.1214176921394852, 1.1468672595930607, 0.7872464227870564, 0.05971279964286283, -1.4091633975153488, 0.3608163451282273, -0.5472279657622762, -0.6329287376780528, -1.1192897934934944, -0.5850952056020927, 0.5964615894813312, -0.5088318332795512, 0.6550203456936519, -0.9865418531844843},
    {0.7763173749151483, 0.6055169579514348, -0.31140052930224543, 0.5081713143101022, 0.5004747929536844, 1.0432537835082607, 0.29632862606210636, -0.5282892771687897, 0.4934442005977368, 0.6703495347896508, -0.4724337043312006, 0.05019061301811107, -0.6426690908466975, 0.4822786015385044, -0.2914797588070508, -0.8168801403372189, 1.156174942814729, 0.9486860234818307, -0.062308560764274636, -0.04305546353737012, -0.46857779695390295, 0.823720954686974, -0.700262756655011, 0.9474418958984023, -0.07613719381376725, 0.0522822550901654, -0.4508147119643066, 0.5386002767551835, -1.1480606258091453, -0.26600645476972845, -0.035447247199973934, 1.1147274597757826, -1.0835870508586884, -0.5772485226723917, -0.3468138242300785, 0.514460517960549, -1.294357714941128, -0.5914782571997712, -0.2774107545161701, -0.14189765145494884, -1.0429906286363104, -0.45148168453473814, -0.6607912738310596, 1.1688608841882848, -0.12974769632753108, -1.008229431061373, 1.068762256251005, -0.2776950265700923, -0.350942673180182, -0.12022520965061892, -0.4699350251601416, 0.04318802369838244, 1.1575418227036773, 0.2913604699481051, -0.200159369690591, -1.0867852523395123, 0.4314846936041753, 0.1328070175207948, 0.8599688328391818, -1.0736324093383578, -0.1820047822508784, -0.2759327338300469, -0.0013548423940134976, -0.8486663061448061},
    {-1.1683482796460822, 0.18384357308046134, 0.07810537310747455, -0.7391984248979947, 0.852022329513669, 0.021143329090637538, 0.00566242371512253, 0.004200316620412016, 0.3811736673337296, 0.6983959480094901, -0.2048211200776531, -0.8147288929962726, 0.04787945713337561, 0.9296048160559317, 0.1005992356467959, -0.8675170768353955, -0.8682253433592289, 0.752621757137923, 0.8359540914616805, 0.8727500177458192, -0.33020377390089983, -0.32568109551587837, 0.7932551278060009, 0.5413440820422746, 0.6527052198888901, 0.7412308609347794, -0.9243285409967589, 0.345140812240571, 0.5157305469161527, 0.3842041063208479, -0.5887301374990588, 0.3769448809514405, 0.38343722583440815, 1.1134844580780183, -0.42027517664586184, 0.9965068129317787, -0.9738063033130481, -0.5777174900209235, 0.6469911052678252, 0.4384545106310144, -0.07641809940182606, -0.7719432692110902, -0.8709221150721908, 0.9633691198505591, 1.0221555376559368, -0.2945094158298332, 0.2321270688879855, -0.41960000692230115, -0.4752752344558729, -0.15567849073121, -1.190039341984034, 0.41521201276871555, -0.3919858396056752, 0.23245828367745, 1.1811332367977143, 0.8793646625452454, 0.2835178064927402, 1.05801088541083, 1.1494783640543549, 0.2837287701176074, -0.19048493600946872, 0.8007502617545412, -0.9482922745790648, 0.4945419867049006},
    {-0.7528178803290695, 0.035614912273080335, 0.34810292535189424, 0.13632783132209636, 0.2197434153639426, 0.9866744915137328, 0.7187070408839668, 0.033540192088127266, 0.7455893008295974, 0.11397720806845453, -1.1853079313203496, 0.23124331045774213, -0.024150214473465156, -0.886533007650264, -0.839732998481676, -0.3466427990054623, -0.7067584536443199, -0.7003987049861917, -1.0529039865573222, 0.5596211680728199, 0.3736017191969635, 0.9276823114248941, -0.7326471183044638, -0.3493314857559177, -0.7372137986725011, -1.0088315082163617, -1.0723996596478482, 0.6100499014897556, 0.712915507951836, 1.0554198080652082, -0.37482393660062774, -0.6353110015672984, 1.1976029554528245, 0.45367118424017366, 0.1929682532505909, 0.7104519519305442, -1.1204971949406444, 1.1365646779029976, -0.4841956425058108, 0.3709111130143273, -0.14226663397040099, 0.28858694514895716, 0.65113193887875, -0.5715605031611892, 1.1548195171773334, -1.2263461225284267, 1.0412722835892319, -0.9136712318832212, -0.8876533781402373, -0.09757295178500129, -0.2123871586915348, -0.8154467257805502, -0.1314397266305951, 1.0213871195161666, 1.0801090789139849, 1.119695993568878, -0.06474904642705466, -0.8118401227769608, -1.063198676263737, 0.3434904921362504, 0.6431057612841913, 0.5692854588633892, -0.4982137688363816, -0.8679242527124822},
    {-0.9169399083983428, 1.1464440073281743, 0.5786874997098607, -0.8208065610654651, 0.812560499195729, 0.351897269283906, 1.0728353094186127, 0.2892813332584868, -0.9583361217750657, 1.0969919530368912, -0.7419841555515835, -0.6876854705292431, 0.26520057661320984, -0.5049590041872629, 0.6103304893975925, 1.2711298585521598, -0.4833536535593299, 0.9003382774538233, -0.2604080573598435, 0.5073128747934365, 0.07169246764681475, -1.107948521509699, -0.9878699495059858, 1.020487611372798, -0.39790774919278443, 0.4640328662996197, 0.052652863817633726, -0.2472209626667072, 0.5129919199775848, -0.3865452436182884, 0.23695728299911828, -0.5219276326613582, 1.0845368144447265, -1.0936123523310877, -1.0177774335713934, -0.17006994114304144, -0.8949753781941362, -0.6327707554921781, 0.964258431952907, 1.054549293539327, 0.10574933784669886, -1.011104187428789, -0.9531647029828746, 0.6220256925245159, -0.286570464258164, 0.8545776478783347, -0.26857816202157886, 0.4617282002781454, -0.015200048184391525, 1.0535163099468947, -0.45875211110049774, -0.8988945756230342, -0.8764905049843582, 0.42230562841601954, -0.9000389317518206, -0.8904769663487617, 1.3325097653399625, -0.9298709003881522, 0.647566730963867, 1.0223894099888207, -0.05666576143724406, -0.5069116058901288, -0.17677015802080115, 1.0014125046878977},
    {-0.532774458606738, -0.2103638359397401, -0.5838964560778873, 0.6917955960261172, -0.1281400637468452, 0.2612023927066257, -0.8093375486776397, 0.8680768743695442, 1.0937400422028964, 0.7249442768744035, 0.360921980439405, -0.37368476098982184, 0.07530678300215156, -0.7528157029694041, 1.0152937963139417, 1.4354761105740412, 0.07790260673417958, -0.2623765445749735, 0.3385102273483892, 1.3249225418939092, -0.7119216580790035, -0.33645336685034394, -0.12414612212267555, 0.43594727051401716, -0.296143210058379, 0.15765367484365608, -0.5040801625788748, -0.25665312852361954, -0.22393243450643202, -0.02027036353918786, 0.9479696280631339, -0.814141266523072, 0.348897575523028, -0.03263294480250766, -0.13252833891091667, 0.17117476977959295, 0.7132761544383895, -1.0399126387187474, -0.0994442804669359, 0.4444109742032631, -0.1839972643616266, 1.2272844585482243, 0.6132023917900142, 0.6046148340601897, -0.47998890473076966, -0.12440043098461177, 0.38052815610296414, -0.23199675175763135, -0.59246777622469, -0.8552083762668816, 0.28074246406490494, 0.0012473081897508807, 0.2249089115050785, -0.1194112327996467, 0.17184260931312076, -0.7434525527528529, -0.514332097724909, 0.18562603217541637, -0.5340849256310042, 1.0735195679316056, 1.1945717392501187, 0.06934875233659875, -0.45015797791093, 1.0344067225145694},
    {-0.2778401713747372, 0.037322596198518625, 1.1535891080567553, -0.06412367213510017, 0.4095242069246757, 0.3960940807210402, 0.6877891978256104, 1.2067202889612338, 1.1595196897587767, -0.7353719708836218, 0.3120339087525728, -0.06254000760300345, 0.8949136054845905, 0.19038949054327167, -0.2640318403569562, -0.21571473455358112, 0.6696821323161354, 0.5737166602066306, -1.2612274972017947, 0.7533186171831121, 0.162731910478819, 1.362451859087787, -0.7578857835288416, 1.149747355977174, 0.9667063662510574, -0.5362400981181844, -0.9151452858346453, -0.18992002443237896, 1.2806749212878998, -0.574849513505175, 0.8238113526585351, 1.0761657684227497, -0.6541852451597399, 1.181209510817928, -0.07503755048755542, -0.6836387623592873, 0.5010262590435031, 0.5055381671942454, -0.5454187701502908, -0.5797376389959904, -0.03356169078532801, 0.27426731929309833, 0.754784809992403, -1.2123915524999875, -0.8041637090020297, -0.4852860718349707, 0.3783586580824598, -0.4966530442936776, -0.3635238954665492, -0.16050083036271096, -0.9600568476528792, -0.7011119723830168, 0.011450487705441848, -1.0459129763855695, -0.08963243955881246, -0.4992929854297997, -0.5802111421793694, -0.5958938916799367, -1.0407345699170505, 0.23463188261851634, 0.6782366613299545, 0.8930351410881628, 1.0150451177075595, 0.46089962994533296},
    {-0.7059802393550315, 1.1099848531803747, -0.31927166396532347, 0.6237004364951062, 0.7685931058847821, -0.9373070712587726, -0.4807534766177678, 0.22680417951736004, -0.11120173333836275, -1.0087091739242084, -0.6762479233961353, -0.1338289997450312, -0.4302687727293774, 0.8626860082884025, -0.5624302080120541, 0.9076543000543805, -0.23418721054426744, 1.0024915465554936, 0.028159533908985724, -0.12819466237244678, -0.02810570051647328, -0.20099954375541212, -0.6788000260788766, -0.8975019629640095, 1.0124215183582521, -1.2701604978897572, -0.5520349358096286, 1.0906319838579566, 0.9336212068715338, 0.36060879104725585, -0.38950271494289723, 0.6626384048485554, -0.08574734535157506, 0.6774624443650082, 0.5914559746815572, 0.8023638636515414, 0.2119853910831628, -1.1543821206622376, 1.2710524758471968, 0.6364161136734041, -0.14418126025339573, 0.10397197341050124, 0.7118468589457954, -0.9231762254657169, 0.9163752394213348, 0.04759255861962202, 1.0157847744564241, 0.19141237565345126, -0.1463744497837776, 0.36814090920904496, -0.8544845274527052, 0.5543681406844114, 0.9809046130218789, 0.4337686863313163, 0.8293169235786195, 0.08672312850374676, 1.0492762375868618, 0.18364851082355038, 1.1529712531040701, -0.6543783695478167, -0.6668721418219017, -0.7746159063177166, -0.22462066805121145, 0.592319485164313},
    {0.2619638924693101, 0.5758563762540431, -1.0510051681368688, -0.18862182040819273, 1.2092192360597749, -1.1035125116800584, -1.1433146964704137, -1.273094758174124, -0.23055563456274372, 0.06347960798345972, -0.9193176705254251, -0.9684944795839912, 0.5768240010236146, 0.5259163957725823, -0.7235741864126455, 0.5579192876975507, -0.1945904491485014, -0.19418801197133473, 0.9964191414874544, -0.19177425184517002, 0.8956833440586427, -0.4353014462249039, 0.07960141684798348, -0.19903022606655427, 0.03796736742209617, -0.7694818342426888, -0.22408842252373296, 1.2556146862786697, -0.8974826881808895, 0.10275412614520428, -0.7998983799251715, 0.07285944509269891, 0.44293637831574023, 0.6951034737374948, -0.5413248230237763, 1.1431955621590784, -0.42783476169060436, 0.4528382964526408, -0.21299906532001206, 0.5522149569640274, 0.15465959800597295, -0.1607125205200069, 1.2067201573965798, -0.6092936983354807, -0.8411806646898597, -1.2287897735162085, 0.3889279200095019, -0.764878304590738, -0.946803263483208, -0.9856525416399089, 0.5430978660611693, -0.6103030614237459, -1.0872574977029823, -0.5617713363704319, -0.4315056707165096, 0.8433461328653473, 0.9480377283269544, 0.5007782986447465, 0.10824529981544541, -1.1635580672312766, -1.2540154862531459, 0.9831328816294101, 0.8411952685533788, 1.1627447201632064},
    {0.34160100693344064, -0.7833748943174519, 0.745889810292385, -1.054926709011559, 1.0237092600982307, -0.5548690665657857, 0.27079224291596515, 1.0892486305648963, -0.4300923047990498, 0.21605170386515252, -0.03534718333172253, -0.8204104549396244, 0.2759933692045307, 0.017019163538441934, -0.6096169542931122, 0.9760921590920721, -1.1667090230850392, -1.0063829797241617, 0.4922360991011745, 0.013213814532492481, 0.94194315074867, 1.03393630954141, 1.0486597519861987, 0.01810991603911295, -0.4683618374694157, 0.4382305809883106, 0.6685147734150867, -0.529063074850778, 0.44132876816258143, -1.0940559367174878, 0.6967221536908741, -0.04082878953015219, -0.1444492514808576, -1.0860612673019476, -1.2166393411055982, 0.05107092062377836, 1.0036598136932973, -0.3287885697740274, 0.09907910928081859, 0.7619496981865787, 0.6976564534358958, -0.8317630295362506, -1.0386674669993352, -0.12448461087293874, 0.8977503157832277, -1.109941033928895, 0.6063970205997987, -0.8602683156075842, -0.4664253948782936, -0.4063653510125885, 0.5949979365420144, 0.24475025530522584, -0.43485957153002947, -1.1287321257799579, 0.2039480928657423, 0.2609471962065243, -0.8777984653713649, 0.5268244012471683, 1.281937510430073, 0.2109145749920186, -0.8755749818117456, 0.6043941934520157, -0.03843419311123065, 0.9938100513755365},
    {0.9991010163476471, 1.174641298755376, -0.02449790335529423, 1.1700892764578037, 0.35044581585937107, 1.1351411443571038, -0.4050172065211031, -0.6980252187156437, -0.5165798481622271, -1.1041117354878187, -0.23148092854582597, 0.1868814266450079, 0.6305820352865907, -0.15931606051573052, -0.6197640292367983, 0.8109654140180959, -0.41077573733632733, -0.19928627613931696, -0.010433213488714798, -0.883400963350032, 0.39857482961455176, -1.0231412410437142, 1.2216033526179535, -0.25280706940372444, 0.7598363463928858, -0.40753893856938966, 0.3744256993620571, -0.615463598151361, -0.8243512282078225, 0.9343210372277174, 0.5492574656100953, 1.0097089997820181, 1.0754696356213038, -1.409410617698262, -1.0205825498958927, -0.6453336119574908, 0.6561417660949816, -1.036918821549377, 0.13759852233778921, -0.4622459081480607, -0.9300739529248988, -1.1628317092273364, 0.12613477888365124, 0.06865892688874015, -0.5819085288960439, 1.1493653220899087, 0.8160591636623594, 1.0016623497793136, -0.3428350865438427, 0.07751277316587235, -0.7215098744443723, 0.7271655428133569, -0.9028588535088635, -0.11817692528094931, 0.11533612201771898, 0.9704244888320732, -1.1479679575584385, -0.38670755103718485, 0.8982481445089266, 0.2666478963463233, 0.7334995003262975, 0.07784535645715321, -1.1942773040659713, -0.07044348696485886},
    {0.8854135577596609, -0.810719122724964, 0.15837937198979546, 0.284797800417115, -0.07073994324679145, -0.14325396830753828, -0.24795754044953033, 1.1689256959314176, 1.0826045110819997, -0.08884552661352867, -0.38974770754410165, -0.9127771155492999, 0.7611264514405695, 0.6153023041723839, -0.30888299439480094, 0.24087322612933731, 0.27140318001283215, -0.654541101987293, 1.0234365128207823, -1.2197252446482918, 0.10891994773163154, 0.6207650570617652, -0.12412564930720081, 0.2771872312529328, -0.03589670742001702, 0.42912887650734244, 0.8994680848091438, 0.20304982276438516, -1.2529345315089884, -0.6524685872627223, -0.7477817712793456, -0.08254598422949355, -0.8852340302539333, -0.03083899321575007, 0.5886584089570244, 1.064175780323034, 0.703902889421854, -0.992107461790133, -1.2151569919901353, 0.33654359680631274, -1.1709202312819327, 0.17293900691510594, 0.35655427632471476, 0.2767907096312014, -0.5139588004243484, -0.3685084182419622, -1.2097087746969495, 0.9419753997919177, 0.6575957735682283, -0.46332035698282975, 0.4679563662463029, -1.2617502897487152, -0.7695462695958316, 0.40196383990064705, -0.11444253378609441, 0.8634900723618544, 0.21194187767151906, -0.7086685689008292, -0.09510003389027676, 1.1970433317637021, -0.1549283518840093, -0.995068021223183, -1.2403153560235467, -0.6189024128223486},
    {-0.9971469353671366, -0.8198118163934516, 0.9544664864126248, -0.6575254716556833, -1.1343174855660507, -0.3484847887638022, 0.48566826893672915, -0.1349824933575402, 0.4733775051310392, -1.0335206587089818, -0.3030768239895206, -0.8340231013337162, 1.2077184479406817, 0.8590397486347833, 0.011249887702551071, -0.5075535614065759, 0.8832611860065607, -0.8676172832397807, 0.4923780603110549, 0.9473298576069504, -0.26940916766423484, -0.6071749610225498, 0.7115710022455117, -1.0149478379506587, -0.1769295298741006, -1.0416525944051775, 1.1375987998598986, 0.054361818326031736, -0.8053348094024537, -1.0581646559480822, 0.21605108101049889, -0.3604700546297718, -0.6408159010469324, 1.1713774669181973, -0.38249213788231623, -1.0482558008240361, 0.020730050467904906, -0.732809616297563, -0.29390767165755227, 0.943881030649856, 0.2826625795203839, 1.240103101253129, -0.5805336668902212, 0.6385061885693057, 0.9683107183679026, -1.2053396182033886, -1.0202264054745576, -0.7489670429388695, 0.48371265575870276, 1.115613838319338, 0.8110388761309474, 0.438560251768803, -0.3024414331984763, 0.873339690737204, -0.15536830416399472, 0.36130235604918876, 0.4272322997222765, -0.047631054042801574, 1.076200389671138, 1.0625566541516263, 0.42477907453732966, -0.7153408365665188, -0.8663758105841134, -1.0673863073239094},
    {-0.9384783475982539, -0.34280189177860804, 0.24357530450645, -0.8553924249846264, -0.5532296745114439, -0.6370583474037688, 0.4278807947747907, 0.06499590067758503, 0.34110479036477775, 0.991591757567538, -1.0497847738747554, -1.0727557750803505, 0.829339372770585, -1.1215109061656976, -0.027670815157265032, -0.7369569496432302, 0.21917692672788705, -0.8633755733802903, 1.1880366607532737, 0.7814931691599543, -0.8211180797469917, -0.3606500078672317, -1.00900492201419, 0.03973773936227902, 0.7368370746838837, -0.738428833675323, -0.01569182235598624, -0.7166073759219268, 0.6860483795868726, 1.2513376411871948, 1.1775577161713395, 0.8718253888910457, 0.9887998514780942, -0.8327322128811047, -1.0044229072016484, -1.027405433521461, 0.9214223231136994, 0.8814519215244442, 0.04218932449435601, 0.7028010292465803, -0.9186168692714868, -0.2680070137756992, 0.985240719003164, 1.20687847073947, -0.8320603746075703, 0.03837075953128775, -0.043115035231800054, 1.3750384742343933, 0.010967386215825378, 0.4732623569226023, -0.4322359371541575, 0.21463888464008712, 0.336896062511429, 0.6751996660048206, -1.0472894839292322, 0.5969995010183348, 1.15684658432215, 0.44325904329622107, 0.3910437208105166, 0.585532150416317, 0.319747216164961, 0.291729874449913, -0.08302999558128075, -0.5513367123234304},
    {-0.8583509573955949, -0.43196766728750813, -0.9813107012955185, -0.12540892083681396, 0.19911055984937698, 0.26915866334648353, 1.0695672979673227, -0.8556492708864883, -0.34535665636215673, 0.9504578873995819, -0.7650977233372109, -0.10663517273117952, 0.774370531732128, -1.1405178862971246, -0.02117818571878029, -1.1330800610163063, 0.5869545093211913, -0.8004647955369667, 0.9144921927327303, -0.5943673514067072, -0.551591025217464, -1.1662000563635364, -1.0480073696474077, -0.9950574556209673, -0.8574394595450232, -0.7893745512484173, -0.0920512695716522, -0.3797570677761754, 0.45593222365474634, 0.24270618986845213, 0.24896012166705966, 0.8015417715267948, 0.009780931428254702, 0.6974214436311161, -0.01589895508839326, 0.13401169930934112, -0.5341315603730465, 0.8112514822624259, 0.6341697598829558, -0.007729780793790936, -0.2627423643907308, -0.8767173054734666, -0.47100948260864167, -0.040735857493803686, 0.9828731577349246, 0.5646886911519405, 0.6505039769220632, -0.4001062955660361, 0.0997096883516954, 0.4747128984058894, 0.26309926377948717, -0.19896685641383408, 0.8949004953415312, 0.34138003521834226, 0.9164575204671165, 0.38496242067442765, 0.7858381053832822, -0.9581971840727093, -0.7320291641371313, -0.4394916621620634, -0.03348793447939858, -0.6292616407494304, -0.028468247811928124, -0.9870313309708219},
    {-0.5755040529935795, 0.652830632464138, -1.1138327384538278, -0.18008090338620186, -1.1161134554226049, -0.13313434124311135, 0.7018626332405489, -0.141657477615469, 0.29896493354379605, 1.2075247803249525, -0.2990164297956706, 0.8585096029358094, 0.37698460891314134, -0.616685055078914, -1.0001877596720286, 0.6292647067113235, -0.4110156207449106, -1.2005079313081304, -0.24731866043722459, 0.8235078073894867, 1.0559716412875548, 0.45966676925545313, 0.5089407439642837, -0.848408153381723, 0.08337263746427678, 0.1245012613492236, -1.1084555395560307, -0.6132929647155708, -0.280683413144502, -0.320030350092496, 0.8788529793534855, 0.5900695193870683, 0.7893287852547656, 0.8817016902072022, 0.44229395034680435, -0.9858129334168976, 0.9387252804614735, -0.44517065095954866, 0.9011165968730622, 1.0601063998176985, -0.1498014104801768, 0.6992753478400232, 0.9879230233616593, -0.900167109650464, -0.153968597274031, -0.7060311553658284, 1.1320118770395018, -0.8505166632702904, -0.37204813528061575, 0.6295890431043638, -0.6849762115253754, 1.2003767136761276, -0.5128465284283489, -0.5762614439316115, -0.039484375352552496, 1.0868246294670727, -0.3614085583007132, -0.2791787923480305, -0.48122845677138204, -1.167671848549613, -0.11053368818661691, -0.21338673855124196, -0.44426337280976447, -0.40901604659673},
    {-0.537844070125685, -0.44580937721277847, 0.9680954247607709, -0.36731715190136566, 0.767667456056244, 0.03326467401838694, 0.07008202554444065, 0.8571009341872559, 1.2510292615772014, -0.3689308781205813, 0.4980194141568038, 0.2779994265872107, -1.2214955982303644, -1.1993407496120356, -0.8613741321569683, 0.7150244358046869, -0.9049654559692994, 0.1280641749640692, 1.0962048951871681, 0.06985852988903342, -0.5652284993781651, -0.10740668011284335, -0.06141419176343429, 0.9133985741806879, -0.6384961396662934, 0.0004870072273102638, -0.6131180903306694, -0.8799855573076356, -0.5272275342714812, -0.8534777470943709, 0.1694225875172045, 0.12817592007367481, 0.45821525439948424, -0.1365375508673673, -0.2133851660505644, 0.6465166364567057, -0.5840460761476861, -0.44418458124819427, -0.22971211774800937, 0.10328808286142238, -0.21685405189379384, 0.8338154470091377, -0.23952060648310916, 0.2669096054313108, -0.005471062948250898, 0.5426982169835146, -0.09523177630681702, 0.5944128506913539, -0.7441245599517335, 0.012400393315516223, 0.22690836727312136, -0.7932532654657761, 0.2552866328484375, 1.245504303301995, 0.042155953929786175, 0.9778862360894682, 0.6285906525727093, 0.4883961482604443, -0.2048954352021433, -0.13921789954143776, 0.9372030189796303, 1.1943861985258735, 0.4504116673531235, 0.07407795562498956},
    {0.357683555424281, -0.82628499216333, -0.012005324477925844, -0.8204795454197348, -1.045583094542493, 0.02315571566743295, -0.3639916549239271, 0.9684083718841129, -0.32941854225016265, -0.8277131713798488, 0.6709108063390343, 0.5467182147369157, -0.5662912460198632, 0.19894806906107934, 0.9023271218723544, -0.455690815653564, 0.5902893919384415, 1.1524045532665217, 1.121800077816054, -0.5071673585259485, -0.11605154894413029, 0.36791925499945766, -0.6067040635002285, -0.5481700085246861, 0.7303253129975671, -1.0027925250300704, 0.1627518676597728, -0.34677899259599815, -0.8035750720384173, 0.9688803189630888, -1.0271405081239522, -0.18234923548292076, 0.32168287085900094, -0.5893999000937002, 0.6053484870334738, -0.5661816456277897, -0.07595965461628686, -0.9425990276485384, -0.5137000577427999, 0.8090529574027183, 0.7871348896560452, -0.8355200759568029, -0.5849938080115756, -0.5793569050619501, -0.3166374375205521, 0.4379451478409438, -1.140032233458942, 0.5259721492164082, -0.3671309328814216, 0.5944620736675228, 0.5961679108574996, -0.4294665547633845, -0.9468891629015452, 0.7427595512588071, -0.11338695676434869, -1.0234622655338106, 0.0036804016125194967, 0.36076785742600354, -0.11295995583431905, 0.4799099280634072, -1.230202288428615, -0.7761651147994058, 0.9890982803075504, 0.8952011365218825},
    {0.5036322142383199, -0.21702675344876485, -0.8534344172105148, -0.9493388414215314, 1.09065330559123, -1.2185395804364492, 0.038570091232819355, -0.2662656871900506, -0.40506407890631324, -0.9533470482145855, 0.13231716380932954, -0.23460486557397442, -0.3079612080757412, 0.27692990165946096, -0.7547118911410714, -0.3009466566861123, -1.0078960299059168, 0.104089298876728, -0.4023721057502143, -0.5980666584801481, -0.9185767519893773, -1.0802482009873136, -1.2692120190760923, -1.1211247100854012, -0.5825683287525982, -0.5319848997886266, 0.9557084737924428, -0.18300534145038527, 0.5104309764361586, -0.5643352335901411, -0.07682991642234277, -0.2097016980551841, 0.7891540985888796, -1.1286453697891934, -0.7232630015312786, 0.12311725039685488, 0.5651190735289671, -0.775161752141933, 0.3584299889207211, -1.0657909333549027, 0.009162242394689902, 0.14505640204370757, 0.531965058445985, -0.820844349329008, 0.9761943803032759, -0.47335663603492656, 0.003326034546938711, -1.00577936799688, -1.0744190233580753, 0.4404845348571547, 0.4706425198290203, -0.5999772668586821, 0.20630277952509773, -0.5356061888034248, 0.6223861157388217, -1.0657535890030982, 0.24763104831160498, 0.9162368163705904, -0.11113182334949469, -0.3834597613337629, -0.3823171476748058, 0.42348646902329684, -1.122181971479647, 0.8779290274667624},
    {0.8333366963432526, -0.39146634774411, 0.35216955974355235, 1.0814011271772836, 0.3725969233389072, -0.2745916048680929, 0.9980766578408663, 0.4114856715208725, 0.41938064052114293, -0.0008115864195106328, 0.8865398169406882, 0.08705021449178608, 0.7085143828341717, -0.7703137778734954, 0.6602737994003631, -0.2721021947830718, -1.3752906871113326, -1.3437938602092248, -0.7545122525731164, 0.39906245003361657, -0.26650617921405734, 0.32550325498915816, 0.7956333159005735, -0.036880331391854114, -0.8014639618403859, 1.2861122495968103, 0.10862543510795165, -0.8629737215285257, -0.3393450450062992, 0.9860336648081763, 0.4304632558465817, -0.7081199048426228, 0.6722416412000919, -0.816157570716495, -0.7941416272564157, 0.5541402346916173, -1.1960709829812748, 0.3246732763906813, 0.8886398578592419, 0.3355958646916402, 0.2996323404844007, -0.950950104200169, -1.2035310420296788, -0.5822298774723379, 0.24002027734015927, -0.21060297411932336, 0.16393339624570555, 0.19936859991038774, 0.4429553347923883, 0.013366077564712595, 1.16236343963932, -0.4140531373304189, -0.5756548660946266, 0.27650868045322374, 0.4792157902501408, -0.9865322749892133, -0.8214043771203473, -0.06240671787440101, 0.779664218332935, -0.337067835432999, -0.33600716743018066, 0.655522378192667, 0.44763971538115055, -0.19966980265289888},
    {-0.1913803293645259, -1.0304765445337605, -0.5381561897181198, 0.923958754593145, 0.6591939853149051, 0.23387565907142482, -0.8971467640004351, -0.21233282942181825, -0.10752441034737238, -0.8306686544568798, -0.9809011278849519, -0.5748091207159649, 1.2651454336150056, 0.21831415121628786, 1.035915774889004, -0.013578429912694664, 0.23539517637891477, 0.03240094564753557, 0.37944985176968377, -0.9421106717717712, 0.08484526692615216, 0.6757442113127418, -0.22282766657138847, 0.4283107630956433, 1.1220503907595947, -0.7311346780865818, 0.3612558118126475, -0.899961540191756, -0.9359062255896549, 1.0013596705388739, -0.7631272474290574, 0.6767183073348764, -0.8502433492226876, 1.0793287459047984, 0.8841789612349206, 1.191711644395008, 0.5686372088687209, 0.7238828336050402, -0.24026263454119218, -0.09872554988330577, 0.7609122758903192, -0.5827369857404878, 0.9133862791766502, -0.784431017722949, -0.004996681909563657, 0.8898021526502436, 0.49194913491618814, 0.6894399620456784, -0.11527440991533505, -0.7237576834067224, -1.0470706933789802, 0.18413206722524736, 0.9542411381939614, -1.2657011715594828, -0.6639459124478259, -1.0157916113506988, 1.0352813524854907, 0.5858575822197141, 0.41920330387808713, 0.1636029364986381, 0.4917334090333356, -0.03869267231056902, 1.0311048399868343, -0.2356689278885377},
    {-0.3953752281507158, -0.5594749097017387, 0.2980513094259604, 0.693583114574455, -1.3427916649050016, -0.5799438328476313, -0.23175443985550256, 0.07122905544084661, -0.06459511783075748, -1.6373357163151527, 0.2188234183782039, -0.7885744938474354, 0.5709192822021011, -1.700344418369421, 0.2051919048952563, -1.3116590627412863, 0.31995193279799766, 0.08463394573642329, -1.0007458825359665, 0.22827359908625955, 0.9190400034409102, 0.7631800261917068, 0.3091304096903867, -0.5762487345964484, -0.4916710677873761, -1.1262252554205994, -0.7776190407844198, 0.03673363941429658, -1.2386939157044476, -0.7366968745094833, -0.45374747048898934, 0.39626909236800134, 1.017338914012718, -0.6649023847892401, 0.8884191933677608, -1.0100355208711973, -0.8849282707431493, 0.354545551546681, 0.28842660006815063, -0.6422601612886641, -0.5989995483801632, -0.7340624329065821, -0.9305339688583925, -0.43080445571534254, 0.305592818737806, 0.25120130058709167, 0.3606533589386972, -0.437975604590611, -1.2809684697914012, 0.6365717399622377, 0.3660432680312343, -0.12587905331040097, -0.1532450889681495, -0.1509471721029549, 0.6783887062771295, -0.5164230745738948, -0.7818586804512266, -0.4000363546675695, -0.15249557961792945, 0.6114061939444267, -1.0669116678203505, 0.07916419421577438, 0.12598583690427798, 0.9296810354283368},
    {0.24030740377353854, -0.8535613560562679, 0.9808262974754826, 0.41407862543945423, -1.43015016658532, 0.20532635005735844, -1.525199095012831, -0.22622348641635692, -0.47189564890350627, -1.0648862551308793, 0.5906394980558718, 0.5372235165954247, -0.4908461898270813, -1.561884562087608, 0.588374301105738, -1.1310232514022591, 0.7304214349814893, 0.4617930009494192, 1.0710508990143575, -0.1770310900309678, 0.9778864169584499, 0.7594498834473747, 0.1129113349383425, 0.5111495445519932, -0.6393938832758486, 0.7975662819565834, 0.8782148210485025, 1.09024364679777, -1.4852535710239299, -0.09145919888560375, -0.6755478084025281, -0.7725005670674416, 0.0011140979280175917, 0.568249391794067, 0.4964065648127463, 0.6781308786723926, -0.185360083573077, -0.16569414799091123, 0.8130901589828309, -0.14497728975303434, 0.8020646223244146, -0.16818026948430548, 0.6932637675094062, -0.2588324212456083, 0.012055806651480443, -1.1506023303158308, 0.25084746724445783, -0.37240610474548735, -0.23337173982257856, 0.8272703728249455, -1.0086438037342038, -0.22597226314044153, -0.08148035171068697, 0.3762341617084082, 0.425163732160499, -0.6765395679478481, 0.30577552055445795, 0.5212492002730995, 0.6283731393031752, 0.420028201926447, 0.7850024793547686, 0.7656104642265517, 0.21606495400658088, 0.7855680188180411},
    {-0.8404513129940266, 0.06673250007806779, -0.66169288013708, -0.08412147455997948, -1.2491319273664327, -1.2026978504141304, -1.3664453402431231, -1.0140052139161833, 0.7184720774767461, 0.7116328607882102, -0.7195507021724616, 0.11065979811240076, -0.2702804431806308, -0.9788257662679904, -0.8066414118305846, 0.3549660481753385, -1.3190498931424968, -0.4624055487203076, -0.6857716255002966, -0.06783274277824933, 0.5209108769569629, 1.1730148014494524, -0.6935617914773585, -0.5320937518487955, -1.0395933600011533, 0.8297807926814598, 0.6191130868845666, -1.0931860371069162, 0.13658194139581234, 0.04296323375995896, -0.2275239566743864, -0.7983034490757401, 1.059232364339289, 0.2224239926718185, 0.9013273867985878, -0.9804295183123657, -1.2135356691033339, 0.5161706749378084, 0.6371639917248505, -0.705053620860441, -0.2760096869683288, 0.24493627084826783, -1.1080971211811534, 1.0459799248693626, 0.5644828744131014, -0.17820662429248413, -0.09237437412496366, 0.9918828158234397, -0.320203734775855, 0.20764556577498897, -0.8535607512737049, -0.343776037617482, -0.5964892901034207, 0.5955406089311865, -0.9154148814252114, -0.5001832922004508, 0.321005293645941, 0.31334815416361333, -0.1814321088273303, -0.6151495772485646, -0.21683124247383315, 0.5305834557134673, 0.9253810900057025, -1.2492208397121467},
    {-0.553600331570183, -0.028535970172428676, -0.7166244689187771, -0.9938380887337699, 0.7435882166762448, -1.0616330885310845, 0.2193998701775859, -0.7181664239361939, -1.1628439154545134, -0.06474335937153937, -0.9913220391747678, -0.681972160486547, -0.5921444401132665, -0.30743627186646194, -0.5030724374461256, -0.23485246349643513, 0.5648471388078841, 0.807315983768687, -0.9142486411183608, 0.034507511050016204, -0.42903667472187934, 0.48557798023722565, 0.9432646410278558, -0.553694576012837, -0.48739481603726886, 0.1898906285930735, -0.7399915055599311, 0.8499549031004159, -0.2525491837218791, 0.13319953812764782, 0.4348997607225241, -0.7963828565674604, 1.2734529409743576, -1.4030762432163706, 0.1505940351699962, -0.9797345159780365, -1.1953143609305275, 0.3442775796713162, -0.5261777495663593, -0.9700209141174638, -0.394368223066424, -0.3854498350952086, 0.5037871340423941, 0.9415073028487873, -0.2773619583935964, -0.6514924026784328, 1.0886811044013744, -0.7101612733762419, 0.7267081428562141, 0.43216956141870394, -1.3021697085098585, -0.21135536215974302, -0.2733183312579141, -1.1801847114148685, 0.9627734421037342, -0.4293040321870101, -0.8190477590368777, 0.7026088283431423, 1.2164550499735731, 1.0794676953003273, -0.20353707445719238, 0.2926169169038255, 0.11584331375105333, 0.30799519143531784},
    {-1.1373406437846558, 0.919606978791444, -0.5334835720037272, -1.0117973980633954, -0.02899059079186214, -1.0184243478861212, -0.6369503027337631, 0.008970220464268904, -0.31818186805371174, -0.39442369020094603, 0.26701298392327255, 0.09310447230845198, -0.013634689978733933, -1.0351437409429445, -0.3158372057109513, -0.11161117830228953, 0.413197181312728, -0.06650467700787499, -0.942158192254715, 0.2039717325701269, -0.8076097445533554, -0.478205370805222, 0.33563023603088193, 0.736746780387704, 0.3956584013420783, 0.47501181661756486, -0.7298412868483674, -0.36328017550624647, -0.11884306594040688, 1.1621477136625433, -0.46971878418314367, 0.3771811339160579, -1.1213268183751268, -0.9061427769060433, 0.5741034050562827, 0.2108743163187916, -0.30522168102706054, -1.0763612084379615, -0.7585568268058754, 0.870517564921218, 1.1506839410817926, -0.6580261550827399, -0.8723237490063227, -0.7313225120056888, 0.30591941345839463, 0.6074488978086057, -0.18762681686670624, -0.5986310891752468, 0.27389446363619724, 0.0994045685874132, 0.7311251630333445, -0.5236376501004532, -1.0714348525097261, 0.6713462795328046, -0.04399952169767114, 0.15485984649021933, -0.7570350719019484, -1.1403617972988251, 0.3425667337634495, 0.10071975259927517, -0.8207547812824497, 0.08527697965259827, 0.5092136439134703, 0.878432918331126},
    {-1.388999890632548, -0.5765479314284652, 1.0261452427929385, -0.3988309321259582, 0.2407174510130222, -1.2188378673204532, 0.43090712108465035, -0.29065792272725405, 0.44267010553889224, 0.6188054537514951, -0.4994257394629925, -0.43268750168995335, -1.158512809283339, -0.30988675216394046, -0.7039442396364995, -0.4284959562463795, -0.8323478942703344, 0.9116777117364365, 0.3952374559906045, -1.017833696775553, 0.8439359085461567, 0.9458563301025801, 0.21481748085022595, -1.1374814093492416, -0.8514628663277126, -0.7173989770497698, 0.27976581399579925, -0.26790992336254993, 0.22445354170108334, 1.1734756600578569, 0.8614889048794512, 0.3073295844786738, -1.1090116410666544, -1.363971931329933, 0.47157205536323293, -1.0694132636507796, -0.8936245715822614, 0.3093989680141337, 0.460942556742376, -0.7976538212219344, 0.8603556061616756, 0.23748088824279498, -0.004562667991621162, 0.3735225815530991, 0.16386224645909434, 0.3719008509830585, -0.2884496125266029, 0.3133148691468432, 1.0196788193650925, 1.0920644140838203, -0.7841773467038607, -0.9405033522139229, -0.9900808349422813, 0.11549190185470097, 0.15525935101792937, 0.01394347760675378, -0.7952924467657542, 0.6872495416262029, 0.9041521774734156, -0.1666543673204252, -0.1111818692150069, 1.0415150477479354, 0.8173920906453954, -1.193728754544534},
    {-0.40169341718633633, -0.8809174756335196, -0.7097469093862241, -0.08330369363937958, 0.9749345630740078, -0.3663180539137338, 0.34920113034504147, -0.027237119492718783, -0.1924193980797006, -0.9054517193239463, -0.7548899373693875, -1.1067979242507027, -0.6475719344370864, -1.00859812867168, 0.2833078109417356, 0.5028863161478642, -0.9932578914510317, 0.24086246751294896, 0.9234781303106514, -0.04289307617819113, 0.3964288098687547, 0.6364120115516704, 0.4610193713584055, -0.8603008758409384, -0.4687803125344606, 1.039006303498576, 0.38568763496616865, 0.42435350391204346, 0.5167626723722378, -0.8106971845078897, 0.6292257467658, 0.3211967599326126, 0.653082263005065, -0.6353304017207361, -0.3990996703304683, 0.8934196642185651, -0.5486216726137331, -0.4199665737259172, 0.6857067099678792, -0.06517821964901205, -1.0120731944502692, 0.8296956994698267, -0.9924968461972763, -0.0016474004090635559, 0.8439295161692774, 0.07401734405821347, 0.36928131618606586, -0.6051524251342977, 0.6616812728264366, 0.9674278005175053, 0.41711417517389143, 0.10993033056643048, -1.1418179538352764, 0.24474724659343597, -0.3767539634489293, -0.19004303607111167, -0.05308560666114547, -0.9328399443156185, 0.2519019934298855, 1.0920370496979086, 0.37056008707815985, 1.0403181554141125, 0.043903557846513085, 0.2650971170112791},
    {-0.5621644325484759, 0.10515237203702381, 0.47746588275459095, 1.2474447729019442, -0.6097989795054735, 0.20040063164174818, -0.4527414269199067, 0.3721694387538226, 0.4060792920214544, -1.0112847232170334, -0.37935641566134987, -0.46724203272705583, -0.6025641003615113, 0.14593747896319817, 1.1989405528281265, 0.2502335220009709, -0.7498883786466136, 1.233158344800614, 0.1827824390784059, 0.21752089232330324, 9.94076947653123e-05, -0.19554548023599577, 0.12085972871255511, 0.18327267502045594, 1.0919690287423471, -0.009105943864792658, 0.3325980794875663, -0.8597095780107681, -0.45443729240083525, -0.24792023243660377, 0.9126347973478512, 1.1025773267633148, -0.39467602845643385, -0.16774625580500044, -0.5167531029664608, 0.7831426237266674, 0.9550532951762409, 0.5277900115160054, 0.25254925186034893, 0.3927950808280149, 1.2666888807129293, -0.45615901320307245, 0.34127388542158926, -0.213845611334718, 1.2725486216055804, 0.10565924307120705, -0.5712622926521197, 0.5760866415354231, -0.9609058311455201, -0.0788499752325019, 0.4232085061915029, 0.2298411706297094, -0.6291507069301543, 0.7833118134276374, 0.19893866473291302, -1.08665357525139, -1.2189986305014116, 0.2629829468921438, -0.2407879426378261, 1.1291635153392494, 1.1992059609359256, 1.068506884176989, 0.5363607775951875, -0.9611343338985533},
    {0.04394730832573832, 0.7782247398713087, -0.7787477341336043, 0.44358485285328647, -0.1820137211799298, 0.5317023983553082, -1.2098965988166515, 0.9405661157733576, -0.7613897398150081, 0.13572349766260677, 0.3107838349141059, 1.0741142530386374, -1.1583900302916827, 0.6545019014904261, 0.6832316796144653, -0.9333038496713046, 0.3789197840676225, -0.9088482028529187, -0.059405692813311435, 0.3765455029782334, 0.6596993602319154, -0.17450532148890727, -0.6192080411862746, -0.2772824626786917, 0.9794833274741626, 1.0935277079612853, -0.9664046300674396, 0.17026932355766078, 0.41748826108571213, 0.702512383512512, -0.91811938921847, 0.348188487075857, 0.8357027696751799, -0.05736975586455247, -0.520090413024781, -0.6125505759965633, -0.6996841434830314, -0.5265255345399099, -0.41925179375984134, -0.25105361004309634, 0.16677286194365476, 0.5365557588520425, 0.27745855862568597, -1.1760189727711448, 1.1065509946792327, 0.058315201667484225, 0.5897149871213467, 0.9620707852912866, -0.8472854972214197, 0.9387296434288019, -0.13610379733595135, 1.0252903885142215, -0.7354299630924556, 0.7424464631604349, 0.7851667901537627, -0.15166898507750212, -1.4836338544219634, -0.9696259772161634, -0.9866376383276014, 0.7770281506755828, 0.7273772776370144, -0.6280823402391889, -0.9320421415141693, 0.5855672377026835},
    {0.992452825227536, 0.49151862835171833, 0.2596793977471073, 1.2251118684718807, 0.39365358240526405, -1.1149341455948933, 0.39567779136336695, -0.504631365614723, 0.7884267603251872, -1.005351067811617, 0.3785210077704269, -1.2955797692574345, 0.2195778706268384, -0.09553290083123236, 0.18455131581814166, -0.6772426860280026, -0.06654830077904524, -0.4644095438913508, -0.41690011944186045, -1.2264643223893772, -0.7727768462128832, 1.188199538094389, -0.4279644109197799, 0.056709932662885924, -0.7174735131492805, -1.3065849552233313, 1.0146359178314424, 1.2042985672848672, 0.5986450981774674, 0.6220660746548965, -0.9671796068878952, -1.0032274468686961, 0.013313066272403392, 0.9833371301452409, -0.44232548257743504, 0.9340479584925264, 0.5607493886186352, 0.6235653539913601, 0.8578667797439259, 1.024886482361393, -0.11067993683075668, -0.8414246320758066, -0.40323053421460714, 1.2088909356385988, 0.4482245182992337, -0.28944136323156217, 0.9743353155558641, -0.6309295140767087, 0.33477852044452766, 1.2150989813861581, -1.2466374023131273, -0.7745652175005004, -1.280266318068514, 0.209645194824328, -1.0667535828643397, 1.0953504259360747, 0.5293500551067559, 0.5768819695154468, 0.724663215232943, -1.0250393463431149, 0.09542227868993548, -0.8792406953935992, 0.09061403575904362, -0.10860645175914425},
    {-0.8741888396158578, 0.5623834167410152, 0.8093019705750033, -0.3547704569296722, -0.5624064631668684, -0.8266760043057738, 0.8543071431169671, 0.6592463756293071, -1.1949474365170354, -0.23074068471368397, 0.7672688956328529, -0.10340970338222275, -0.14103162789524873, 0.6272282316965565, -0.6006395449242055, -0.8797116351524809, 0.7938671602124108, 1.1146075587053932, 0.583248072034308, -1.1807544433207842, -0.9451157086106569, -1.0823234755151103, 0.6535133909443336, 0.03657181397424039, -0.2820423471986763, -1.158608533715449, -0.12958475353934215, -1.0472406358723, 0.2967901603421963, 1.0062932559002633, 0.6440695863996502, -0.5351863827520671, 0.8803022401308235, -0.2086758860767774, -0.8124964270599895, -0.8500026083498992, -0.9421719394998849, 0.5931402585573359, 1.0202424178120506, 0.4039588078937213, -1.0847886957469342, -0.35545570074355964, -0.022912514927583758, 0.8556720005301292, -0.06428003132371506, -0.2960825626199179, 1.047885675443911, 1.1653638695530666, 0.40274621237811503, -0.40080565636230464, -1.228027540190255, -0.8879365764424232, -0.7980056200107047, 1.1944082772896294, -0.9143050383202747, 0.06233345184088614, -0.839473051508746, 0.2400459167127765, -0.582407495049443, -0.8845092438625742, -0.15762452263769006, -0.6824733183589303, 0.12211955307515365, 0.726267381996928},
    {-0.2679219190913606, -0.27584738154655924, 0.7023369909288534, 0.6939981463732537, -0.9847555528655746, -0.6224738569772289, 0.23520845174987304, -0.6051681936262436, -0.5724175682690205, 1.011267362370116, -1.0120392902960915, 0.5738446724338897, 0.6619038666995087, -0.17222584772640523, -1.1978729997528872, 0.09150136386022249, -0.8731626331552069, -0.4114260121857639, -1.1944562623139334, -0.35327600333631504, 0.6760415439983557, -0.6226581805609036, -1.2372808161925133, -0.5886144543346056, 0.7489870143367462, -0.35729126861323063, 0.4262558859660622, 0.6270404357547604, 0.726784930615321, 0.685002823521991, 0.8861714983929285, -0.7490383225156214, 0.2797611657560859, -0.5438642980670109, -1.005983617590735, -0.4938274756173869, -0.23202601808043907, -0.5315358081175514, 0.07824194550309556, 0.1600108383202123, -0.09206912065388885, -0.04232690730254661, 1.0985370736412385, 0.004621509564226701, -0.9526169951846519, -0.38667737119446394, 0.3540011422533987, 0.6318376909290989, -0.21079180023205146, 0.8551195950301187, -0.1848191593403355, 0.2416294908977639, -0.995582574299516, -0.6942047675406318, 0.16869832751873667, 0.664686825336876, 0.0017195412553514685, 0.24080462088614954, -0.23128026065281418, 0.05863610074036784, -0.8593530666695821, -1.3895274169798695, 0.20919843734874088, -0.9564294521363358},
    {0.906799678530567, 0.1871124101750232, 0.656068082930865, 0.09857003243568174, -0.560552667696004, 1.054264509339301, 1.1970725008660457, -0.4597524358575488, 1.0923056201384336, 0.8961942818933267, 0.2818950983527217, 0.6952381097574727, 0.5508577207452199, 1.0733317709890526, -0.6552043002451723, 0.8029743938579577, 0.5071213359663547, -0.16088659714779924, 0.4510156484669724, -0.19704010685726087, -0.17922925889503155, -0.9800637071017446, -1.0803055149150622, -0.2585267520329939, -0.9492483474361914, 1.3182699255972086, -1.059088635793687, -1.0851617215236038, -0.7662672232267751, -1.1828659132369956, -0.9128923932890022, 0.3108030685093654, 0.5746514664390484, -1.0880823229433976, -0.9146332924289864, 0.5573750478230868, -0.971662171590957, 0.3945353243499542, -1.2123199898740884, 0.5123535582004867, 0.6949873475064319, -1.4033403132515359, 0.14045484407559164, -0.8863900993977436, 1.0891402561648886, -0.8215407150470426, 0.4781593652584933, 1.2800018115784448, 0.17192323810009635, 0.3870202678573234, 1.11237982602493, -0.9538038917702659, -0.7209518282594476, -1.1149533497383528, 0.4926014412941235, -0.9157531790352309, -1.2925357176148384, -0.8935342680869043, 0.04065633237985727, 1.1488334878036417, 1.093886393189171, -0.591955245955711, 0.5362492416820841, -0.8316973983800068},
    {-0.29220790530174506, -0.2635739492898638, -0.09413854263530001, -0.06751075545163228, -0.5755350146969086, -0.3607597667375096, 0.9538421865239494, 0.8022730897359812, -0.8780064628226107, -0.26549228716611767, 0.22902990443886584, 0.5890730670657099, -0.8503799196973042, -0.9300447511126161, -0.7059856290042917, -0.15495938913482754, -0.48233164028002207, 1.0148920259309369, -0.11643408564181003, -1.2727916672160589, 0.4937376050275294, 1.2327196964472815, -0.35416832538949633, 0.650431057979484, 0.5140299918197895, -0.6310907906053023, 0.5069537635941003, -1.1810088588341627, -0.3622780765499538, -0.13048642828459345, 0.0037863491163969434, 0.7306158130629903, 0.3442853505111457, -1.419964105495233, 0.3133158536128758, -1.0957953239719591, -1.200606505795887, -0.33260713649820045, 1.1575688806898639, -0.9261181886020053, -0.8713427590410721, -0.9349396941240956, -0.26678029108660356, 1.0365965132756378, 0.37664440554956086, -0.8477344137500267, 0.07850314982677978, -0.44371045869604303, 0.39311396086992134, -1.0280996184477844, 0.13474863430165424, 0.037034652617757596, 1.010077802474648, 0.16588028669577246, 0.7776381174169802, 0.8402903511305483, -0.5950464998757319, -0.8380053882146463, 0.5174398229215476, 0.3159585844170815, -0.3347770281755698, 0.5658643477739026, 0.09880559740911228, -0.6844239459484457},
    {-1.185259787324917, -0.4380016839099479, -0.6419186500264638, -0.2580559549454714, -1.3835549087295933, 0.34635328307413144, -1.3226683688535992, -0.5865919903283292, -1.0307912003313167, 0.7022808188751996, -1.2846678395209699, -0.4304709372407395, 0.5956740093374093, 0.17283828117056357, 0.08399594008501325, 0.07957796260200405, 0.018849403924268416, 0.6731788892650629, -0.44554678081874893, 0.5572170553859839, -0.6246653865486664, -0.23381766992534067, -1.019333508791762, -1.1900069676770666, -0.5770587962974191, -0.4966409085110108, 0.6809614743293486, -0.5574440402330367, 0.847757282145019, -0.6457087859254234, 0.1286006406487425, -0.05353143439898037, 0.09219055730226938, 0.19229358264540966, -0.3904822145514231, 0.9696629201957392, 0.6171103415896255, 0.43118832395835216, 0.6944932014239487, 0.7218151977395522, 0.15583164410303071, -0.37986666525407536, 0.837461390558465, 0.45775827708021677, -1.053575545100531, -0.2865135167634965, 1.01895629724735, 0.5571960695868892, -0.1761410734467362, 0.71056000739715, -0.22784831640945938, -0.20915771858656176, -1.3693364730484205, -0.4212846081737548, 0.8527833092092623, 0.6772232253605134, 0.007213084838771867, 0.03769748327799353, -0.2985914222874358, -1.0264626450390015, -1.1432335370733682, -0.5644892798710145, -0.9542735667482775, -0.08150841857973583},
    {-0.26512677511151167, 0.22316591951076484, 1.2221113445663503, 0.5583501389048177, -0.009421153989213034, 0.4420928341996672, -1.1774222057146733, 1.0517736770793447, 0.8144569170487443, -1.5144488354662378, -1.2726275022980684, -0.6052641303800159, 0.11975469488411403, -0.7877254333478261, -0.6424073171820026, -0.12684880480035393, -0.07489009992806822, 0.06672030155478945, -0.7341968479957658, 0.9604921956501121, 0.21548701114736776, 0.011943854725074428, -1.114591319190855, 0.04148543522723774, 0.652515201142414, -0.013828409723806695, 0.7871831577655172, -0.07530779278955595, 0.8658366777338817, 1.0741683293409412, -0.8511482521431263, 0.909247246034871, 0.6088425915915844, 0.8237733003231712, 1.0274684753361127, -0.7313834701150577, 0.5179469093521277, 1.1144771807493372, -0.6446880603986609, -0.6208810436799617, -0.42759924342089783, -0.9766506488149244, 1.2510600375151089, -0.1185279337415543, 0.27388133368650563, 0.788202388723607, 0.12924615762239913, 0.21360106728619419, -1.1593039606567663, -0.4526898970519393, -0.32025347459561354, -1.0313465849093775, -1.338553445672083, -1.2674338035407613, 0.5528023024978188, 1.0186959667769544, 0.5480952911812446, 0.01270681701835492, -0.6252836674504275, -0.9656064450062404, 0.39934540917697464, 0.14067269616320702, -0.4760471515908541, 0.9226985898919801},
    {-0.3840189858239844, -1.2289143360201464, -1.0578437228506807, -1.1668445644265548, -0.036657510511802806, 1.0243060283529728, 0.3472094304408548, -0.14543655669984873, -0.5855709890223515, 0.9426422043354736, 0.9386250079684959, -1.3370996200615675, -0.7330449603401165, -0.8907959236292766, -0.507454601247199, -0.6691349906572027, 0.3637653001867761, 0.5684892752799531, 0.41633862985769887, -0.4361092252088184, -0.542462763155017, 0.9047289049642536, -1.1430358688950917, -1.3569295776764825, -1.2717924389263626, -0.6202592846236099, 0.4309595821555609, 0.45118595905666053, 1.1409621410851594, 0.2680226711614574, 0.27589231073433956, 1.0319239061196488, -0.22771856803449722, -1.208830025389838, 0.8139668204523658, -0.8456915914052593, -0.6046540312237836, -0.23764792608893773, 0.7066210311559331, 0.9227335445758628, -0.6253574039738177, -0.5919590227654691, 1.1998576434518122, 0.2461585543779183, -0.11694075142098176, 0.4892946599350625, 0.6083805975608679, -1.3176772787415785, -1.3998442354119462, -1.0173556747472947, 0.6565643921694969, -0.6623582788876251, -0.213141078064152, -0.4288759218310194, -0.38538203476623817, -0.8038460762823451, -1.4350354876731222, -1.0328779066269582, -1.0249685559354895, 0.4487221113707738, -0.09381555827752916, -1.0123598029804206, -1.300761557982458, 0.6418887296296031},
    {0.5124135871363723, -1.1337358106142368, -0.8485621455661365, 0.23705973240246947, -0.17928328488678222, -0.9614878947043651, -1.2115287761921765, 0.6629694410965079, -0.49253135789436636, -0.8626241532848669, 0.15408204305037462, 0.4511519374570188, 0.6583815557767015, 0.37307007738109593, -0.33494620317685, 0.5685470087862851, 1.263371465307509, 0.5021096942145002, 1.013780281358276, -0.09749247888402048, -1.0556671781276583, 0.7712807002679957, 0.8002711561061702, -0.6657504376108652, 0.6456316857459783, 0.08314274496543138, 0.037068250971701494, -1.1404104912933446, -0.3557347563520717, -0.7796093817903479, 0.12833501579416093, 0.09659788045631335, 1.0287801719514131, -0.5597261983276336, -0.3717873712628189, -0.2426653944756916, -0.01906023906550131, 1.0888219423660326, 0.7186183957975852, 0.4082136620840385, 0.6371420237737629, 0.2643805973043084, 0.49030751784715304, -0.1978451454514547, -1.0176637372072879, 0.38608478286146597, -0.4869748714217211, 0.9430059567067914, -1.016597112733767, -0.24598582454125886, 0.7896149633402395, 0.25547892142758616, 0.2711551386470113, 0.6950553046020722, -1.1118579706386031, -0.8373542936153405, -0.4087992841153622, -0.8638602813676078, 0.6692005306291208, -0.06644004059750099, -0.23536635492057903, 0.08352899643360302, -0.9214946715881049, -0.5524144206622259},
    {-0.31242040473216404, -0.1686482161705395, -0.5335428005484404, -0.3465186724292802, -0.398305121600047, -0.4632773370088526, 1.0108898983641006, 0.4738831008240664, 0.6262640677693473, -1.2149010328619285, 0.7020977663054381, -0.8999383435150032, -1.2370112372217597, 0.024422782713353502, -1.0240567327935657, -0.5643815703107978, 0.6129806543491907, -0.8986478472030089, 0.16118966209895766, 0.8903827337764585, -0.010625848709898295, 1.1651507974819453, -0.8939316261885527, -1.2049019826996739, -1.4459980929699723, -0.3093876846445532, 0.20921727285577799, 1.2910735534765476, 1.1429397300681075, 0.9512326077091853, -0.886775555747461, -0.06914523925830442, -0.4132932476764118, 0.036211736190476074, -1.253956075244129, -0.0508548810817109, 0.31543250917714766, -0.03528080364089088, -1.1957702590563402, 1.0321889893187093, -0.8889443428746633, 0.42834226949329596, -0.35036078441610763, 0.8194154395875304, -0.4007942463513512, 0.8149097028391333, 1.0406308163101743, 0.14301006421012788, -0.6920628259389019, -0.7137015319487167, 0.23862786650257498, 0.9020868762177902, -0.80099493218634, -0.8992161170211379, 0.20854218835864527, 0.7153530154694512, -0.7983347633268151, -0.2428801836325182, 0.08991997088423015, 1.344712998759879, 0.7325248365877427, 0.990642779631843, -0.8627788566014828, 0.19796821946024262},
    {0.7696215936278357, -0.3225949198212223, -0.7702153210755973, -0.86035375537751, -0.02230309248460652, 0.6620852081624817, 0.9847038311261976, -0.9523442563298063, -0.4200852155824904, 1.1640426446390468, 0.6402350886333138, -0.4501322379213011, -0.8972197798351663, -0.06387188079573317, -0.8177543315663811, 0.6267518205246473, 0.9978156600470395, -1.3763265804123261, -0.5196929217757156, 0.3465711241483453, -0.38049402338375893, 0.8763279452289983, -0.3990674448941771, -0.3605329169193235, -0.5334435758444672, -1.033540295931683, 0.6227328319309644, 1.0815847168368584, 0.23969651665801564, -1.0655909079652799, 0.1914642511060324, 0.5358926363743474, -1.219214263740278, -1.1328451341348957, 0.2782250523485891, -0.39736284897749435, -0.9843244464188005, -0.3755730214284642, -0.5201613586111282, -0.07363848848159342, 0.2620956611252318, 0.5651271131322755, 0.8706203465617235, 0.33682706626374526, 0.5300833705136665, -0.6245960208895844, -0.8612347857247581, 0.5764326586865546, -1.0450509893506044, 0.6591860295221535, 0.5810458200211343, -0.12340858966750809, -0.8616887533404108, -0.8978504822671699, 0.5324416665723485, 0.6174352055575684, 1.0287362245092462, -0.3330141238602872, 0.3545417815129711, 0.41492983627801605, 0.6505057410514473, 0.7627866082582334, -0.48357357769718884, -1.0195642766648976},
    {-0.9195045549343588, -1.164912718681539, 0.041197228239158244, 0.16433520543708524, -0.5972873009724016, 0.31697312861504323, -0.2319023421063311, -0.8248945990845118, -1.1162760746405276, -0.5778716485699517, 0.2776091384841475, 0.498825289195828, 0.3889781533312348, 0.9181717113283289, -1.2903648092971396, 0.04898789482204718, -0.8640521095617472, -1.3946738492699393, 0.5225229473654251, -0.22217806920776684, 0.9076023987033002, -0.20923087065070411, -0.4192305243974758, -0.5035410443518132, -1.255404717416982, 0.5495839656487258, 0.06054212840021258, -0.7702988110218052, -1.0151787701015298, 0.7725301006347411, -0.4072510738146823, 0.12582358656976517, -0.030347933017876638, -0.2041863561882542, 0.5339102266825231, -0.7816624697699969, -0.16414615859665047, 0.2956789044141381, -0.9202262343507893, -0.8496999076689441, 0.7774993102556259, 0.019945503281347254, 0.03501697633327765, 0.09070217934050134, 0.39155589601493107, 0.9952193251814104, -0.9736798902465676, -0.12330213445421266, 0.21786141599115405, 0.44524921040009113, -1.4746482762619195, 0.8108724506413102, -0.0875693775815368, -1.063413706467781, 0.10454007166950559, 0.03096659488962945, -1.230198598187671, -0.7063644805468339, -0.74507494249253, -0.45236160868751074, -0.6030147881235379, 0.463289820835591, 0.7486348062279194, 0.8619169667051212},
    {0.6931078587641307, 0.9671789608852476, -0.6252773583543636, 0.4895173628968014, -0.4027633551418542, -0.0285396294568625, -0.715449130346502, 1.1050481717614866, -0.497333749275806, 0.9227980277771499, -0.05085807359037529, 0.5202058411847129, -1.1084500599943545, 1.0322655692102516, -1.1105027934744767, -0.9788185620521215, -0.01903778483764459, -0.3356027514889596, -1.225479041408192, 0.2734222418941018, -0.5472829089138561, 0.03311692930396972, -0.9689376001657544, 0.5629576443641718, -0.9554186107792862, 0.04338139526042689, 1.2519116684842233, 1.0468139998499673, -0.08832332992245794, 0.7085203878555721, 0.058890838562101123, -0.4514901478530541, 0.4774537864637647, 0.23642087671381645, 1.0649149727906715, 0.27353802696285157, 0.06607132413994658, -0.9728278380507827, -0.20814407238714328, 0.36148624012382113, 0.36604858803384527, -0.20520418006668234, -0.8898573240048284, -0.6276269758958725, -0.5964085478723291, 0.5145699910898585, 0.03690077000829676, 0.4062748786190753, 0.29725107071698237, 1.090171525961068, -0.3863011839137812, -0.5049179835920109, 0.9109880455529411, -1.0893838573526384, 0.06437003260582946, 0.4387290251433059, 0.9089441793261406, -0.04597472905609352, 0.3928302674176828, 1.0884917542374652, 0.14910371942431389, 1.1653070510607721, -0.6893644596347557, 1.0272759904498254},
    {-1.1289584189102104, -0.36300843554188006, -0.34586582054959514, -0.865086034204993, 1.0355173145604257, 1.0525836672144355, -0.6935487753311949, -1.2125160757063007, 0.6241315654403212, 0.7309315686616434, -0.6059589698066327, 0.8769160127651492, -0.8752931423591164, -0.9320253823906824, 1.0966561755675028, 1.0531572853123747, -0.3253866600538396, -0.5244103082168686, 0.14916829627820433, -0.9049919032159562, 0.2886181977194803, 0.18312059626924224, -0.40699701342781003, 0.19438207873170288, 0.8746166799500188, -0.6289385437068605, 0.8810703877333864, 0.0359290247305048, -0.4071940872312072, 1.1323157389811802, 0.5123855172108891, 0.20878256325641367, 0.753933148631957, 0.01572457911814976, -0.013514433987325854, -0.6419221289355965, 0.6810778499074924, 0.6037623894454097, 0.9459480706993946, -0.9775757404473996, -0.1776727212690991, -0.35029955209504826, 0.5195656242383085, -0.6542176427684018, -0.3927595477450817, -0.18044583768241745, -1.208265055084936, -0.4649397319392475, -0.027149009678154038, 0.07793073760940983, -1.3728647832253047, 0.5410848170786894, 0.1860787988935226, 0.9844461401575252, -0.12915109456953133, -0.518249996575596, -1.109088972295405, -0.29570875639481753, -0.047433226103062984, 0.30550936888900354, 1.0848319709954677, -0.1967244064345884, -1.066856038064007, 0.08205441885201098},
    {-1.0041191851411255, -0.1313292845137031, -0.6274405396213388, -0.42159111686330714, 0.17698919676195188, 0.03949005715134038, 0.7860578732320272, -0.6692432726750456, -0.8025427016903893, -0.20690315161420716, -1.1551861162914001, 0.7958457310107736, 0.39192129366320577, 0.08361698100856421, -1.2335298299795467, 0.4028521440536836, -1.1266735478875494, -0.6689617824287961, 0.8247710258043803, -1.0239699443998918, 0.4137847851350749, -0.0630846841380357, 0.13061654287764185, -0.4591711250741206, 0.9961300961582249, 0.24635197443064755, 0.762336380364188, 0.14224972694367757, -0.4228345492465539, 0.859443279897614, -0.7940222293312317, -0.8736086913401048, -0.740251901080197, 0.21501370521594004, 0.3670010196442197, -0.6502718303753842, 0.4622840334696737, 0.2634745088745058, 0.03446809581680264, 0.6900505051107361, 0.6874349194026615, 0.19552877670047103, -0.9043566878546953, -0.7344413553365311, 0.31361723709988987, -0.7074591264948892, 0.8665033521747876, 0.4788370638408618, 0.6642206315566558, 0.727079243882162, 0.3252543687661585, -1.1014781476554083, -0.2030497929064024, -0.32732251320779016, -0.6291680395640646, 0.12820649855489902, -0.5705008380870809, 0.37487327275206084, -1.3322151980594517, 0.8435442110949353, 0.44012709959073304, -0.19503061411022568, 0.08510450771993612, -0.8411591473874558},
    {-0.14870789972218562, 0.4566446924925517, 0.26296118115696127, -0.20458756927692923, -0.6047229109050445, -0.15749344898729534, 0.5738703928667904, 0.2537288330153264, -0.5074001351434742, 0.4495028247336282, -1.087867780428635, 0.48069885934404183, 1.016165090402749, -1.1175708423478266, -0.10560608179785098, 1.0006141646317657, -0.5749799058493713, -0.041476759123395254, 1.060817954458123, -0.865088673868265, -0.3252320445941335, 0.12905489289855102, -1.1767424501754176, 0.42683867379830265, -0.4370883055873158, -0.3286415966442567, -0.9787082197825004, 0.8095047670425949, -0.7722406185262599, 0.9213691768305777, -0.38589400565805293, -0.7341580651910682, -1.2202796112806285, -1.0210067866755481, -1.1384375843639376, 0.10168654880133758, -0.6631047584825146, -1.1838756786312206, -0.09786164776571098, -0.1253742238836085, 0.20809073020859903, -0.42378455885284216, 0.10448079778646373, 0.012444463639405512, 0.805131708253648, 0.4734095194986323, 0.9649916461677714, -0.6614163918033481, 0.5809697703723303, 0.6409110925088601, -0.8254950388403012, -1.1635179050325672, -0.26851180227433746, 1.0423978438595267, 0.6161581527816142, 0.3596327037755221, 0.9751013296444723, 1.0194784488872923, -0.18355322952218703, -1.0038724519091256, -0.693506268649281, -0.275220544634308, 0.625035345040114, 0.4284040068485169},
    {-0.5320879577137424, -0.12887749423797634, -0.002294428518733975, -0.9606475501504405, 0.9912764881681325, 0.7633422056234704, -1.1486554485215623, -0.4480213510462836, 0.874597500748768, 0.9851174105063505, -1.1412956480070193, -0.64694990715259, 0.5049341174735273, -0.8455654260183789, 1.048485947016616, -0.6080624075422755, -1.5187160602738632, -1.2521176922440438, 0.04895844737542378, -0.6425938733098102, 0.0041403646234234245, -0.5219083104475686, 0.23707150935614063, -0.8072006001997298, 0.6335148239438821, 1.0279463152600874, -1.1034920339595469, 0.08998012390079291, 0.4279648071154332, -0.23596594730006426, -0.03215616288021152, 0.660978968383324, 0.5526524922980945, 0.401672002883179, -0.055250437344812865, 0.3757908217661819, -0.31797547236269047, 0.6890039474970644, -0.5158416454277733, 0.7511426501378524, -0.11390551616419535, 0.8533976744787574, 1.0046478300522714, -0.3865162339660391, -1.1623020619365125, 0.9032515336038169, -0.37630622391391144, 1.076843187327254, 0.38432688876407045, -1.204750832127006, -0.2343494879698175, 0.1969741064831482, -1.127313003335071, -1.1286757546736204, 0.41382457155096347, 0.07089563563645858, -0.9827730756810065, 0.04214682254507742, -0.3554004450553905, 0.5129679872269831, 0.5457235628926218, 0.7274295575075336, -1.161492147751164, -0.4661593333730286},
    {-0.5413563657238203, -0.09271308540213655, 0.21622156329591288, -0.057927858042934544, 0.10671856316320143, 0.8674827670022173, 0.19221814255434996, 0.6593726323287912, -0.5768365309355459, 0.6336162189227165, -1.1165475531922353, -0.35519550440742625, -1.175738190676199, -0.09444490624285135, 0.5757495957451523, -0.04462232249562029, -0.4504264231910444, 0.8899469700328305, -0.7436640548082105, -0.7493138263862007, -1.079323856318132, -0.2888764275378157, -0.33780642650875575, 0.42571359392364616, 0.23982787111929213, -0.18664059738506766, 0.6112816332093214, 0.9170022546627583, -1.1219820964700733, -0.6890474833335987, -0.1985315285740782, 0.5101437363903443, 0.22151843199232818, -0.2883239028622822, 0.4084309618918994, -0.4882905030450584, 0.44584407384697394, 0.9590108659142169, -0.5536608459854697, -0.9298588191963808, 0.9186916969397155, -0.5553650984757342, 0.9610110770984304, -1.0396378195509473, 0.11468521633967647, 0.29003343117014274, 0.020282736863166534, -0.44223406755824546, 0.9901357236143219, -0.6172536551659068, -0.779415165415543, -0.5090481381002773, 0.6086988454414735, -0.884209190891588, 0.37015198289407536, -0.8889346305557181, 0.4635612805809872, 0.11178611192835315, 0.7541722327293698, 1.1230638626104872, -0.008164182857833005, 0.32062260661737757, 0.2711154339791163, -0.7066734834451287},
    {-0.4953454142237436, -0.6583952814158828, -0.07567460832974891, -0.7346185175060806, -0.5549556524625746, -0.047436867209949746, -0.1363225839188098, -0.5777677096116496, 0.6655706623088342, -0.28691999128220563, -0.48741566133524267, -1.2598640533665997, -1.0654000797374432, -1.0561085650380948, -0.3304965732540443, 0.3727686139416349, 0.2599251003028443, -0.6233422840243092, -1.032038936405302, -0.03295092801748222, 0.6573886585295801, -0.0629661411749784, -0.10806743375826915, -0.23501995155645028, -0.5028754109860913, -0.19976278489831853, -1.0588335595961105, -0.4668019805051026, 0.7421445701928331, 0.3221286700251992, 0.6698275661215387, -1.0979118967599177, 0.42599395716636357, -0.13560513850499395, -0.5812565884431382, -0.27439189187372004, -1.083276730212209, 0.12014527070163489, 0.06955484459641367, -0.1403499330025173, -0.39769447827482446, 0.0206767939255117, -0.28645148435253304, 0.1628879427238773, 0.9853844101187607, 0.6253297495919167, -0.7293119556622517, -0.594239688427948, -0.4200257055095917, -0.2018804376581677, -0.6868163132649077, 0.5629410121188594, 0.31682332412882747, -0.6237627691646407, 0.7632752467136819, 0.2261293980536857, 0.3083377336256771, 0.41905072013291783, -0.005353769189182396, -0.038938413151040775, -0.7078969373079237, -1.0074446584993457, -0.2518387794701948, 0.9711639375591911},
    {0.9868934271015023, 1.107370051553725, 0.6924973564158525, 0.23340578929176048, -0.894572422368925, -0.5395114760971227, 0.2758529667639922, 0.48380388154066395, -0.17038916517665043, -0.9795035267300573, -0.4601892034308482, 0.5267956113948311, 0.2917334033421324, 0.513284136273254, 1.178701662130156, -0.05722169457382758, -0.23847777679863336, 0.1613437970656743, -0.029392456828804946, -0.14884758038261395, -0.870497051612699, -0.19397753928869585, -1.1111811487072145, 0.05760422066452685, -0.36514325476429443, 0.30525669352343404, -0.33208249427691755, -0.8149236257371202, -0.7935748589150784, -0.5213920829223426, 0.4447099333522341, 1.1855499832588314, -0.09053335054004791, -0.2669973308229601, -0.2910670967565041, 1.195966684949767, 0.539433270912957, 0.022275492303503047, 0.47648367946943115, -1.2579567425538374, 0.4225832306454974, -0.1003826009770621, 1.0034438250811182, -0.06834348268922175, -0.9962549341866053, -0.6016881740755797, -0.5245987329494081, 0.37433785186506857, 0.7817974337802954, 0.35604962615954866, 1.0778034710259625, 0.5520052984432625, 0.46080125384830845, -0.02787196715755186, 1.0236258739066995, 0.726657658982598, -0.5103272046496625, -0.12849565643621597, 1.2066037163982346, -1.2303628281699295, -0.7908547003219362, 1.0170503941680005, 0.7066417226599063, -0.5648970738662926},
    {0.4704933417290638, 0.43800242517806615, 0.24239338484328463, 0.43076473784573915, -0.12111713129266156, -0.21217909648407696, -0.35755257401581103, -1.1360473120629273, -0.6677136940598675, -0.08104375387433496, -0.12274747575653698, 0.3798190766965615, -0.2090197396654432, 0.9727758765652688, -0.5597145147246706, 0.2431326067398579, 0.14034759693455903, 0.10140451368691411, 0.7238350274524681, -0.8872502072968461, -0.8267773920403718, -0.9042943764719258, 0.8318403242911645, -0.7410676963783115, -1.194269612455292, -0.27631664321199695, -0.013946070711150348, -0.15368190704592574, -1.3076275384799063, -0.7850510816285173, 0.5993288764592111, -1.0055668999220184, -0.02055703462413639, -0.11206260722753304, 0.03348152820064213, 0.18370714304764862, 0.8223972727655834, -0.11418370444715843, -0.648244824946265, 0.5048342905476572, 0.0356079656319526, -1.0022423117994705, 0.5696833317535793, -0.46143261138939307, -0.4207132037834699, -0.8286234729575255, -0.5329296125418523, -0.13908300485036335, 0.05611242406293154, 0.4528381328544978, -1.2111136262935611, 0.7228873382806625, -0.7570327558143901, 1.0555899958531743, 1.235805645606515, -0.5017477177961822, 0.6753561314943418, 1.1094113117716735, 0.12631435440133396, 1.3245959718161688, -0.6359595971428357, -0.395341131493675, -0.5877601405232101, -0.8134439083347585}
};

static const float b1[64] = {1.5779710879171214, 1.1014257139312473, 1.6467337391432946, 1.3310906967430574, 1.4098489828894571, 1.2226942055094157, 1.5232025197949468, 1.4622289416964673, 1.3128030493117528, 1.747306092417926, 1.2689764485012642, 1.4584427200298908, 1.6352808714926368, 1.633563840961782, 0.9615534028434501, 1.6644988208379545, 1.6115790334404887, 1.367687323673277, 1.4967208745058345, 1.5476039019460694, 0.7000496450821735, 1.4210794132788311, 1.1991360431381937, 1.333329367664716, 1.3312552130953181, 1.1817879603665098, 1.4595792912450503, 1.3808683846819176, 1.5517794515992667, 1.4260217781643398, 0.8893694784105484, 1.009208659119571, 1.6882419461839016, 1.5192385283210477, 1.5108790825646474, 1.5564766134952632, 1.2677186543806118, 1.4783564253292731, 1.3166553792929732, 1.5361353788943994, 1.2996166833502263, 1.5515228976831403, 1.2151123802145312, 1.3667403579899502, 1.4736618596212165, 1.6361255596553743, 1.468900866456171, 1.3271871400404867, 1.358632193678071, 0.9829827519009374, 1.5947034914565148, 1.4792152785716244, 1.3272948755621574, 1.48773838036954, 1.5577639855764072, 1.3634835105935568, 1.6508142015346836, 0.8323917807345111, 1.1845990775348945, 1.5264309726353502, 1.2646416486986052, 1.2195418875359325, 1.2518603722354924, 1.194436731041313};

static const float w2[64][32] = {
    {0.49078270534622986, -0.913568887113709, 0.12210303302736904, 0.3496487454236669, 0.1335924221491704, 0.874843530237546, -0.9425871874964731, 1.4595304071661734, -0.29696818053673185, -0.23635217568210948, 0.7978148908283691, 0.4894645474589851, 0.17748953883078342, -0.6543364065996379, 0.6814137363156404, 0.513885213512861, -0.3054134843347443, -0.8995765908997901, -0.16219536275909158, 1.0658310230220287, 1.6599120369970246, 0.35331070436369233, 1.567793266877158, 1.770609152129238, -0.09846728673943508, 1.3993250467972493, 1.2329045329534962, 1.411698014764132, 0.6594458035182214, -0.17789047528196947, 1.301439856467751, 0.519127995608342},
    {0.7598528449561909, -0.17187375212654266, -0.9655093881770197, 0.5633517590298839, 1.32872164578957, 1.5348790890763826, -0.17150522039676566, 1.0441147877054993, 0.42998514314431546, 0.9152088716045158, 0.19322750153620688, 0.4160100962714009, 1.471604023717417, -0.24637436946970745, 0.5595709759007468, 1.192828567647721, -0.4044882791397456, 0.5625951923461467, 0.3246120121668793, 1.2016322519807607, 0.7444487840225412, -0.3206895108260763, 0.5397990064641912, 0.23369652478214092, -0.12948203962278895, 0.7657697016310393, 1.4337470454823442, 1.116420478488824, 0.9871625110634004, -0.45529526274209114, 0.9889882775525991, 1.5831279613640177},
    {1.4909949670198035, -0.635681158892352, -0.6045129659006218, 1.7121775132208277, 0.8480254814089139, 1.869121271061515, 0.425333298537998, 1.004550926270784, -0.5510075300422516, 0.2873102903611292, 0.8650000736253651, 0.39963930749583737, 1.0001435870286397, -0.8744976808977731, 0.16391898737378782, 1.332780032088151, -1.0520176999798407, 0.5184299677129918, 0.48118913904392563, 2.087170537969194, 1.9448246612337603, 1.4928466400715918, 1.4222916470773814, 1.9662381944997238, -0.16253727451260877, 1.8799362360237464, 1.4049496531488366, 0.4340305588456931, 0.18559987766425573, -0.21687497178020368, 0.9072688172962897, 1.056388324625861},
    {-0.08130748434017883, -0.9292082648938272, -0.1994720307926784, 0.568931055700645, 1.748998164470673, 0.5563245408266685, 0.49099394200821783, 1.483077142907795, -0.32884575373783165, 0.25333498641532826, 1.307488008421625, 0.585334524668459, 1.0465783979879468, -0.9350660992741624, -0.5979390446812263, 0.25142083254595543, 0.17443577954047854, -0.27522863754868043, -0.4183100581464047, 0.9926292783016444, 0.19016302563292567, 1.2409929060321143, 0.7459587116224112, 1.4182971051606428, 0.06889432714122883, 1.0067007495424267, 0.9586147146814085, 0.5264186350065666, 1.92466787354415, -0.6635015977169227, 1.6797003622614601, 0.2612451437270592},
    {1.457217726932407, -0.10572843323800352, -0.7994423618738262, 0.5660544180792604, 0.045548799522945334, 1.869434318353814, 0.4471286629818766, 0.23215838071157296, -0.5465675371178409, 1.1669685330945143, 0.07356627466661185, 0.686750871054208, 0.3802306331430056, -0.27192135612889157, 0.5230714513157525, -0.09520550445974946, -0.9140996072831511, 0.6916784140336876, 0.5918015476880496, 0.46908211749974066, 0.7220515836932552, 1.3156286540876014, 1.3255035056780264, 1.6678880752001022, 0.9466360926296248, 1.842633358282452, 0.08970081678589492, -0.34973788359225694, 1.940373306987987, 0.12556550871855346, 0.8705408373554792, 1.5288561225098478},
    {0.9806208500703648, -0.683976461749045, -0.7045787801214998, 1.6094314039297741, 1.9224628839681572, 1.6599293083194457, 0.40309761296233354, 1.8426083150060424, 0.38825722509419774, 0.9513752049888263, 1.5772499728854859, 0.8812002579891756, 0.9965831925155589, 0.6571548741713328, -0.3010936540165861, 1.1086378132835055, 0.10887037028860677, -0.9948743378607823, -1.05466712776134, 0.4838238448872591, 1.5916272442430324, 1.0851915333549245, 0.163507860216899, 1.1375312859666311, -0.19653062670623006, 0.8464252172422075, 0.08837823439292493, 0.24961027667818905, 1.7668904396912515, -1.1805445647623685, 1.6435964186487222, 1.5849363585236786},
    {0.6753639408423083, -0.6281951774533179, 0.7318610109731994, 0.9609015406334408, 1.7199183811754573, 2.105803690220972, -0.7059999831073179, 1.2469190704144564, 0.10320964335028994, 0.8201233358649311, 0.27810483789425977, 0.8827019107273755, 1.4168066950138793, 0.6384797505945445, -0.3279564764203506, 0.927453642797824, 0.2881822411110247, -0.6477787834713594, -0.850934469628913, 1.6003471369824938, 1.0301590704182133, 0.15008812768102067, 1.0486920574611354, 1.2828454841310721, 0.46448463615422175, 1.462295234403814, 0.5788705295356661, -0.2638807288796113, 1.4874697700853747, 0.6557771793029068, 0.5064991520110171, 0.341445148383144},
    {0.07060168567675269, 0.39105628661448394, -0.19398250105045123, 0.9802667729628608, 1.7072324597844064, 0.8935217785776463, -1.17861653581267, 0.950017538649867, -0.7289634747964371, 0.8885674259362422, 1.2958807161501442, 0.5221936476740583, 0.7883542958121529, -0.0963873737614173, -0.6384765196782842, 0.23245888114149094, 0.4169224514578816, -0.42202831954006487, -0.4098868188145772, 0.9492981462977114, 0.2243611668306018, 0.909215508043669, 0.3075698383717184, 1.6969051897852003, -0.9473965211263198, 1.1727576673940259, 0.8059855260985958, 1.2000663236837261, 2.0524750030928507, 0.03236550826086374, 1.1382103177366976, 0.6101787033309746},
    {1.0658866172695212, 0.3179326441319696, -0.7016728686375544, 1.1004415808156847, 1.9215827494333602, 0.7649282051645198, 0.3776599782785702, 0.6443700502276218, -0.7901662008764074, 1.2337825938949674, 1.263249485555017, 1.405983193901111, 1.1713814699435952, -0.551308815527984, 0.4878628550276869, -0.09677212393563722, 0.7823052638361757, -0.7469685215344248, -0.37685470707749685, 1.8129652155548373, 1.0478029692206543, 0.9832496705669442, 1.7130191406438113, 0.5178510767024838, 0.2738014871628609, 0.9043842629641297, 0.1906961147394444, -0.14170605029059433, 0.6546609371637456, -0.008923409167708457, 1.2646460266944364, 1.403081377986208},
    {0.22564149634629493, -0.06047304915174518, 0.4339114754497751, 1.6501510368361159, 1.9077363809332901, 0.9510052937681241, -1.0748284785322464, 1.2920252382599295, -0.5641764969561809, -0.1709625604858775, 0.7549111848594109, 1.6073829377239646, 0.23003596842490737, -0.85521141995209, -0.9347457618079187, 0.8942892042730333, -0.5329652585908061, -0.7391660707849292, 0.21867275658579613, 2.0546586868100594, 1.4848413712046384, 0.07799538805552576, 1.7229711690152523, 1.9587877856556348, -0.3593019474273647, 1.8734970453832753, 1.0161084631929609, 0.18036139261825038, 0.9935120385128077, -0.5390019918796746, 0.2851386265976881, 0.9416419825520418},
    {0.20828074236168995, 0.0732657453744915, 0.21083757063371597, 0.7329372702417989, 0.9034857059663123, 1.387123299609107, 0.14485818232121242, 0.6791531646430865, 0.005199717404222927, 1.485724706512131, 1.0565498858932847, 1.416386297070346, 0.5196463779638172, 0.02147488326781638, -0.16053073451921757, 0.08413454958522358, -0.5334287812395083, 0.48283809991720783, 0.737210363051443, 0.3074324191782359, 0.27579703518357707, 0.796517871043405, 1.8433179371658732, 1.625315006952448, -0.7188100689096198, 1.9785262470661937, 0.565617241516396, 1.49887231946805, 2.01401870152308, 0.0763210054176438, 1.2295365173136894, 0.32552953967872217},
    {0.7148671800666103, 0.21722808100340882, -0.4102937012437062, 0.2732223305910265, 1.8813998583241918, 1.8076571290367671, -0.6618594344497352, 1.5426459253689158, 0.5616240177830077, -0.1613967864192189, 1.7591886941795551, 0.24960474429849447, 0.8228883450116271, 0.34425123266395974, -1.1267148794055653, -0.19887576734330714, 0.5878839914793116, -0.5644881275923644, -1.0720273170843266, 1.1999350376723077, 0.24263296972569007, -0.2659858577214558, 1.036304077037456, 1.3730080386973684, 0.6001223083072669, 0.679310773539103, 1.3606056315201354, 1.1104754863512085, 0.26448480882474884, -0.7802572179515583, 0.8323459658355976, 0.8814572322089063},
    {1.3082978466236537, -0.7876074270288268, -0.5562936967413803, 1.1965338757780257, 0.9024509232671715, 1.9322977474916174, 0.35308289484862265, 0.29026015395307453, -1.1417862478433742, 0.6785747805936864, 0.43761438607675773, 0.23229773256141953, 0.6373288535453643, 0.27097639541587565, -0.8758694537050867, 0.17423672286942632, 0.23862069879454034, 0.35978087636192485, 0.3189951205332601, 2.0121119162497516, 1.2105198967576918, 0.44963799060290194, 0.19867904361574176, 1.8705346451586646, -0.9996936251506469, 1.4360175884790278, 1.4515792550699471, -0.07180590083198295, 0.7316322228845419, -0.458387295312633, 1.263978407646116, 0.884914834193462},
    {1.474893883129514, -0.37524240885764837, -0.1682707699220927, 0.7318288354149284, 0.6222887368671742, 1.1002389665272547, -0.6213917084280207, 1.8553039062778485, 0.4883747375294731, 0.7447402885021916, 1.78111041935144, 0.7970355596522695, 0.8657242497388052, 0.7610005722448138, -0.7501020577461935, 0.01096084187645646, -0.20077971858600566, 0.20154605870972317, -0.01462023494448111, 2.1542147495740918, 1.1528222190395476, 0.6509714637117389, 2.0259941165868924, 1.1528961519255772, -0.6125042958035757, 1.1687326409963377, 0.4391413767657528, 0.9522036884078603, 1.1243801011786696, 0.004432495979266427, 1.3598661036159758, 0.028258322350707864},
    {1.382542977508886, 0.26102783003396096, 0.24715601106758445, 1.8006546731179236, 0.7712803852084091, 0.08723792018331598, 0.3244430302380938, 0.5595136988756689, -0.3754414005109271, 0.7323916466183763, 1.0137094974618401, 0.033849702190565496, 0.6725999864813935, 0.8775481453158506, -0.14489186003875656, -0.07505283973561244, -0.1378267451332074, -0.6175784900251186, 0.513257562657166, 1.2953856083277846, 1.1525556270391464, -0.1332316806319496, 0.07361079492510557, 0.7373347250733292, -0.5506411678645131, 0.5747785281970365, 1.5459908914688183, -0.3801039227511248, 1.604460748812501, -0.03097758536141025, 1.8524513056507972, 1.3320173792873111},
    {0.733479635998752, -0.2059412702203598, 0.6529680036121633, 1.3633118184490578, 1.1901182299649429, 0.9975796938519249, -0.07705969974300075, 0.6848786730704458, 0.34783980258961195, 0.05470749578224068, 1.265238537337502, 0.47878807266796863, -0.26512005660395743, -0.627036684330672, -0.9224152652365474, 0.7261072173650811, 0.19569518596096774, 0.1276566442614248, -0.8619856816707558, 1.573453915719135, 0.20042941210917964, 0.8847790925237844, 0.8485689806857062, 0.4452440522154757, -0.7743404449517556, 1.9350919040985777, 1.790361715076123, 1.3935328034834538, 1.381520653196092, 0.004832343214446535, 1.1880200288892604, -0.11164393310648553},
    {1.2446614318466742, 0.8435449625995074, -0.08899338459652896, 1.1895602483877503, 0.8020927970945807, 1.8753641096292624, -0.7826831826720776, 0.5040575520702241, -0.8292110964814993, 1.0955561080562963, 0.8072205285326529, 1.2906240793404165, 0.8623301552635897, -0.284781223516869, 0.3751985158998471, -0.1196537373338107, 0.49040554173418144, -0.5745846473091338, 0.4756154675895972, 0.6282453311771502, 1.9289183071042897, -0.20443738670613407, 1.663313595725987, 1.5280568473320848, 0.2299763764366651, 2.2339797103094843, 0.9147577026348879, 0.29444785314019806, 0.27536197068102564, -0.5144112528251249, 1.5109641381708414, 1.1261736994470144},
    {1.314835239418586, -0.592100811025109, 0.46769632759920415, 0.536709645058315, 0.906388484543765, 0.5704063490466701, 0.2970514942279323, 0.7269418687747593, 0.5697109789872233, 0.9775722979025968, 1.4515478457717301, 0.5994386988876647, 1.0568343164423573, -0.6370776854327058, 0.3648554401821879, -0.19370602378246643, -0.7652617725435381, -0.21258695526574523, -0.4409474850010097, 1.9232345308973275, 1.138461124816875, 1.4543834633452282, 0.8074091543860928, 1.7214065314764238, 0.5781861336080255, 1.653346588079765, 0.6918296511796896, 0.536467568983451, 1.5292712090675484, 0.5793974967438013, 0.5563544174216066, 1.533286876029454},
    {0.04443279692874004, 0.12020117478369899, 0.13363250952851755, 0.09314554153005682, 1.0230165666452482, 2.092509391117047, 0.4409941999102415, 1.6625970795843399, -0.313764192270944, 1.4668486201518223, 1.4289896779245457, 0.8644636763622658, -0.1799371534957622, 0.2484780086493227, -0.5795217948534912, 1.5676019519842999, 0.08766186611396441, 0.39381137226082663, -0.9425618138580472, 0.7444953719771195, 1.657140161306522, 0.45089567306103057, 1.1099872277797167, 0.14747034419409177, -0.35627184172817694, 1.6121212432825, 0.6926107203225023, 0.565702319457848, 0.9617139467724616, 0.031164903813281852, 1.7259865033556507, 0.6200362359970734},
    {1.7401239990427195, -0.791500419586595, 0.5674384465817344, 1.8596958230574483, 0.39359329507788, 1.762091043610793, 0.12887447951045902, 0.6512704092628132, 0.009363246819947636, 1.191629722586951, 0.4121912904838521, 0.7054655867471824, 0.7758929323497455, -0.021949314902135086, -0.608223308252807, 1.4387782145472923, 0.04513953204426914, 0.08910620471484576, -0.8051163462826334, 0.9967096787820928, 1.4363488203005639, 0.23899579960029554, 1.3132125881022032, 1.6068288878958517, -0.253825156666209, 1.8629136473996326, 1.7693665570113708, 0.8252124025181741, 1.4984600547694635, -0.31048595626013764, 1.5635646774473486, 0.5031467685654935},
    {0.7424344662123137, -0.5075040203149023, 0.45069769135073207, 1.8309639293792999, 1.5171627268990346, 0.11926001100851377, -0.9460104553496865, 1.0326678932326472, -0.06098708529361751, 0.32844966590812635, 0.978838400084584, 0.7951660250019008, -0.4208927756079798, -0.35205051037725005, 0.6721710933667916, 0.3135992759499188, -0.2292996809385655, 0.2830132498300836, -0.5652436688784553, 0.2736533697604848, 1.3550404142934196, 0.8735889508366124, 0.6389221534111359, 0.22301553748090122, -0.5533037858412727, 1.0187071635526292, 1.764563918466769, 1.0793594661471297, 0.6474020781068012, 0.4466509818764777, 1.6595311959791825, 0.13292833889067152},
    {0.22334274694018783, -0.23291790554690903, 0.21933253630404234, 0.09161675747626848, 0.1358731441407773, 1.3447135001835262, -1.2417430558611235, 1.2668189230227054, 0.5727340241404432, 1.026922688870847, 0.07233661535837488, 0.12462220338173899, 1.2240673435322948, 0.17667802171101718, -0.20763867761389468, -0.2470876280123872, -0.8374045353467683, 0.512306293577066, 0.4520892418312929, 2.008442978086413, 1.5892413032505022, 0.46453346663675366, 0.49076014804662343, 0.765190096155471, -1.0773515230209003, 1.5707568806260468, 0.7851813209385483, 1.081074273495866, 1.8202172943218786, 0.27118371591290313, 1.3655204097108582, 1.5975813238723824},
    {0.9063246653383905, 0.3797519537556381, 0.16701951058959755, 1.3133073396255364, 1.2807510285640094, 0.3100512813895149, 0.27813994457145297, 1.3602066327972882, 0.509823526567033, 0.27727997981751734, 1.041432943165072, 0.3486095192096651, -0.058587224661886324, 0.1576896248858943, -0.8598611197327157, -0.01500376148192635, 0.031641229128326585, -0.9440621524742586, 0.6684692309678957, 1.3399531521927368, 0.07116468894359997, 0.5109475861169624, 1.0522082133129955, 1.4313276633591545, 0.28122978163197676, 0.8144578318876212, 0.19440532623704596, 0.06612904666753794, 1.1469188195218964, 0.15027205759390558, 0.5874013609675731, 0.0371159724821565},
    {0.7930118836571884, -0.018384128615585166, -0.4760784579601991, 0.28700339329349606, 0.9840013392125093, 1.1692102556698867, 0.0026441394794463535, 0.5123920473938821, 0.38418440826000616, 1.5178131463244575, 0.1880489197461013, 0.2576605718469595, 0.7698151086621527, -0.4700945982881741, 0.4911464494307705, 0.4021749590677131, -0.2633316305406232, 0.845369617379174, -0.841034059024384, 0.842806342955992, 0.3460643093056235, 0.5588116314117638, 1.7081199938035214, 1.61212186975309, -0.5591407941904739, 1.7914196274469114, 1.8964615377399594, 0.5837181365735247, 0.2750065028440644, 0.05875479488107076, 1.4940718002891527, 0.3335335483352642},
    {0.3778511602115278, -0.5698574215977846, -0.4634890319200784, 1.628633072993849, 1.6890842589830553, 1.3483890004334602, -0.867000914435952, 0.7551583463000949, -1.0093728649439646, 1.1642474364824074, 0.4118409940422511, 1.385414576999285, 1.0233285352454056, -0.23620082097851622, 0.23293613852606387, 1.095018706957487, -0.24120643070435607, -0.90602556038482, -0.8684849273992755, 2.1870836122903214, 1.5112818873902671, -0.023494813849555343, 1.1552303963174098, 0.16567731900825014, -0.7038205216478648, 0.25290349614593277, 0.8375147746099244, -0.19471033661836515, 1.1161283247718952, 0.18331535274659957, 0.9942071030184438, 0.47687832400880786},
    {0.45095790020910204, -0.1436877711800252, 0.5838431286087081, 0.6755482146990512, 1.383118149553668, 0.6385931636040296, 0.30178487379632835, 1.4457964369617349, -0.6207203029422468, 1.334467148881775, 1.7419690113013826, 0.36194127885327554, 1.4306264974547984, -0.4870517502782808, 0.5415490435187506, -0.12195323095477414, -1.0596792124627352, -0.16649159816833087, 0.051404989556126705, 1.0218995203791112, 1.2481639570630632, 0.794114193610802, 0.9012875027004738, 0.2593024233936926, -0.8322868969237567, 2.0030403544011355, 0.5116670045005298, 0.42042595463601107, 0.35465166902400114, 0.7700630770290199, 0.48777357519335235, 0.7576948608577566},
    {0.474311009732908, -0.01903505825906363, -1.1301656290646587, 1.4371819890266861, 0.24122759655481993, 0.31376886801049686, 0.12258818318776343, 0.6699878235763531, 0.1651424618092475, 1.2980028263349854, 1.7999174212988507, 1.640830285664362, 0.40681611916818744, -0.9967142334713573, -0.8946432127518722, 1.565624455798329, -0.3864335180280351, -1.0606754307743416, -0.6065285107734649, 1.1824266249175786, 1.024816067746838, -0.30135621439315285, 0.9890289951140303, 0.3533871051477541, 0.1893216661439542, 1.8014674988774386, 0.06699823876751212, -0.28736835798676397, 0.3373634796671961, 0.1809705025833488, 0.9728015866244714, 1.0422631745661606},
    {0.6098039898874041, 0.1355322299502195, 0.5679787204142039, 0.07004120835445277, 1.621390273202877, 1.7649677371583858, -0.7204031232236604, 2.061530520859339, -0.7777398089765517, 0.5002282546847241, 0.5144634358644813, 0.4051026506524594, -0.08869444239537345, 0.21236477308915774, 0.36133595255510864, 1.5729444187573192, -0.6586946224875293, -1.0096859766471182, -0.1318953931501302, 1.0519873880525603, 0.5597586289609956, 0.7588253250743525, 0.22228113193372756, 0.27549295067174356, -0.7990709632783861, 1.2413452197998758, 0.42854822264888087, 1.510720024100209, 0.6387760658643031, 0.3108596710379183, 0.4274861375127363, 0.29391360833583097},
    {1.5180471177515347, 0.13338907864744148, -0.9984909593463952, -0.015422923409111782, 1.2848868697653792, 1.9122361662835894, -1.0700802706258348, 1.391038306756259, -0.15236131621103433, 1.3540050879652237, 0.7599168239962438, 1.1981633472373459, -0.1551767570468624, 0.16438671592737739, 0.4405481478912848, 1.0414045563310472, 0.8069546904440946, 0.4317446833469378, 0.166901060168528, 1.4676111544785433, 1.8724902572805826, 0.16591697117691515, 1.419066261453525, 1.9120219513759638, 0.3762462000478852, 2.1736195660396667, 0.46404458076601485, 1.3039530845783733, 1.979827337578939, 0.49572858433942946, 0.5375944639257559, 1.6198284293851701},
    {0.9471723760459052, -0.009889745860876502, -0.4218529295011056, 1.5791720626948216, 0.17255998457597657, 0.7874661011649822, -0.23065221770340588, 0.9770921406919236, -0.7206281444733217, 0.9259535113182757, 1.5123492299582344, 0.7396603251694128, -0.2180584934319274, -1.0129524207398841, 0.7222361524217515, 0.9049761223882745, -0.785294551885662, 0.43849733959152815, 0.3103692468869992, 1.4584711017662648, 0.10386969438211131, 1.2349379805832765, 1.277067464578244, 2.0224264172414683, 0.13105359086210736, 1.4066907583676214, 1.6077478586987992, 1.4008490749811306, 1.7787192514079193, -0.38060533156031884, 0.7546093702128948, -0.18563679039160702},
    {0.5425325417238768, -0.4588380293765851, 0.6301846832624772, 0.23753110511530756, 1.1505975070738166, 0.4065546622088278, 0.4060946202393114, 1.983640159832393, -0.9009556576921615, 1.0810255535256743, 0.33175839308358485, 0.25084402013430007, 1.3043125845732264, 0.36886831879511683, 0.5961333108427621, 0.516539796299016, -0.95923146431776, -0.03143987478243046, -0.5994078497707469, 1.1435868155431554, 1.1150583768494868, 0.4097755575279466, 0.5783319667272572, 0.10753250906947656, 0.6170430545207441, 1.0631694844045616, 1.0408815622542993, 0.3185350625705693, 0.22326446338634195, -0.6036901449727534, 1.7020413173537106, -0.08179735345652865},
    {0.48011674268765553, -0.05268415666369695, 0.05177174994280895, 1.5989161540212808, 0.0779355165172343, 0.8573965753023871, 0.35233290966744624, 0.8744682375761245, -0.6886944179190693, 1.0677696329413602, 1.6626342141542787, 1.82297584299853, -0.09122161601377823, -0.26750110822026574, -0.9623139913243729, 0.6270976127078101, -0.9114299046765483, -0.31064175486003587, 0.4253341630599389, 0.7058471736617601, 0.3514802587389624, 0.5963187303816033, 1.7484332191295826, 1.8243749183648368, -0.628312669541672, 0.27930721285283056, 1.7034505946808014, 0.21759588703540464, 1.9047483094210822, 0.551276848663561, 0.6025132163308219, 0.6163779939605243},
    {0.5567740786347114, -0.3779086293302836, -0.9185493802170889, 1.1404668161084888, 0.10838685750266588, 1.0742887062836888, -1.0299645177955266, 0.46865829968790723, -1.1229838050132843, 0.7628902998819044, 1.5353531939558913, 0.22855584937702625, 1.292381034508174, -0.9949647780689146, -1.019322754618967, 0.27335920065169433, -0.9830324494419768, 0.4204499561950856, -0.8701528962034139, 1.6024949600508667, 1.427424005251756, 0.0015785819050237627, 1.6348398127957149, 0.6139540973232372, 0.20098742359693553, 2.212601030725171, 0.2597985794881395, 1.4525604125566596, 1.6749095624583816, -0.10123358346704844, 0.33120704539046053, 0.8434761273336819},
    {0.13867355206740245, -0.8747450602722312, 0.7598309346481237, 0.7829312298253726, 0.6290735498402693, 0.7513714129444716, -0.8486769455807077, 1.5681400684272202, 0.5054231362793994, 0.4737449121583419, 0.5049470470267726, 0.969069337731063, 0.7937621988312654, -0.21391191883072516, -0.7344341998773299, 0.7719747715477592, -1.0403742878562132, -0.41997867657898946, -0.9857104189124558, 1.1922862983932323, 0.5764522224029706, 1.0629632807202074, 0.16959591995946957, 1.2485891374196134, -0.7267085783647712, 1.5256592525297832, 0.7507062414854778, 0.4568063401907589, 0.5610261813109412, 0.5943820762052997, 1.1339236937353538, 0.6509707423230177},
    {1.4341712356815666, -0.9333965197822859, 0.34421215793607524, 1.3211543167907498, 0.18715342526956155, 1.7766349475745455, 0.4199736031214841, 1.7491684764347257, 0.24980792202573043, 1.4066887709914075, 0.17440876228083743, 1.3117663693141512, 1.1849759036399348, -0.42971412663840036, 0.24366750167130724, 0.9331737335228573, -0.2820778615426776, -0.2803162242659646, -0.06895362653731704, 1.7407519321560312, 1.3260810925583348, 0.9614830144689027, 1.0476942814049528, 0.4054506739875279, 0.005822508964817634, 2.2407135962893956, 1.2350026143374329, 0.2450127498688465, 1.0679975623771691, -0.5959462334700303, 1.9122125476724348, 0.6489196112403145},
    {0.38435015315529714, -0.211322466704584, -0.4714223846982395, 0.7965531133605785, 0.913677479334149, 0.35358456757071977, 0.2882926886227237, 0.5090355939560874, -0.5305148646964064, 0.16771118551781994, 0.551978755056013, 1.5942750960766365, 0.7401034801986658, 0.4297253139761594, -1.1691489512447637, 0.15653855197341793, 0.3102267703634515, -0.9677206708757763, -0.5045821020356004, 0.9713508373496824, 0.5653331165115872, 0.8725753411233074, 0.27049172645816255, 1.7483346962755562, 0.12267558069473378, 2.2495016720417005, 0.6201997494138225, 1.511114677877636, 1.0546189771816625, -0.058214274160490395, 1.8041295947842233, 0.4362741181783148},
    {-0.08108175486796644, 0.49364342293787455, -0.8577085408720526, 1.7390355803739548, 0.007999578879161357, 1.1083824734801637, -0.904219564298573, 1.6788039788959552, 0.2642239879871786, 0.7233466195067754, 0.7563831974747663, 0.9361754637434778, 0.9549450893738055, -0.9945091102213836, -0.3505710213012394, 0.3184450713925402, 0.1473709001407546, -0.09411120974687762, -0.9586360228680448, 1.5429812226125525, 1.0004034547750422, 1.6388920291269629, 0.5580755288887967, 0.685716119313378, 0.14518863925089998, 0.3625279783110229, 1.6136629347753415, 0.2065652506683945, 1.2940048141489418, 0.6585766268124451, 1.2010619083285887, 0.05986782968904692},
    {1.6686305014301106, -1.0754355376655622, -0.955936205641631, 1.4550234926393353, 0.8380779920066357, 0.3006860109765329, -0.1902778242690058, 0.46099454207350227, -1.0095401805819035, 0.42617446537888615, 0.6289118358565474, 0.40215210734728113, 0.3387733012433944, 0.7293150534255357, 0.18346900938124786, 0.3889815424400445, -0.9331216792312732, 0.4457633725270592, -0.789157756987225, 1.0389855766990475, 1.1473530062679138, 1.315500003266497, 1.6427168133068102, 1.7052398938195559, -0.1587381072166174, 1.5248980469886713, 0.44861695247491373, 0.6138271215762481, 1.1267622970846836, -0.22826721614141895, 0.933908058806839, 0.2829269652188594},
    {0.9991475761712745, -1.0448961232129945, 0.061146166449823194, 0.26672140169813896, 1.476717037462305, 0.631734566998135, -0.8974431167626951, 0.8056597914100664, -0.9691014640448414, -0.3731902924259907, 1.5136354228481836, 0.49909138368323486, 1.2608089520528993, -0.25802508040171085, 0.5812110330698347, -0.2032854375128438, -0.6557605431767419, -0.7571449944751341, -0.4624023795949252, 1.194881155860184, 1.5510053954549146, 0.42630451785861695, 1.0079929434403647, 0.4960341084312758, 0.5107416273281179, 0.7495480920273978, 1.8617204889266556, 1.420943870567699, 1.368937059813536, -0.30783296805567995, 1.3090545632818722, 0.7206524512503727},
    {0.27563620498922414, -0.8070867604285731, -0.0180377733074981, 0.10224915056835063, 0.8095296154206684, 0.8545013729216835, 0.17530487138523276, 0.5549914579673216, 0.45503878993700864, -0.3679087471144206, 0.7108590807624684, 1.3028365772971933, 0.7786946813099473, -0.957903275809885, -1.1185414240479934, 0.8719256870684384, -0.4658459164488534, -0.6067860747886962, -0.096998123904555, 2.0623973881290816, 1.2792075542045924, 1.088963589045221, 1.3276887624998688, 1.398826421323746, -0.33833089214241396, 0.3656056918930972, 0.6409004884806268, -0.23169514282429138, 0.8682646114773385, -0.9406118233859544, 0.12503943979776797, -0.1598021887731088},
    {0.7148559160091033, 0.39852831948545364, -0.15747499858153446, 0.48546977315615725, 0.974767679290433, 1.337614685684576, 0.34592773022870266, 2.0647259814576033, -0.37916589948236373, 1.1070201316131643, 0.5842139178242098, 1.434482413454823, 0.4364206879156145, -1.0265511772290155, 0.05495296953470046, 0.29698192866898687, 0.8119792684951266, -1.0457008476197411, -0.25754661411201424, 1.642984475357109, 0.5253302571772445, 0.1621900379063198, 0.6807650387297303, 1.7859633958102281, 0.67772319876272, 0.762923590013115, 1.8410015051244424, 1.2337765681989106, 1.2457243168328607, -0.07218608892139465, 1.4919664493121807, 0.7535108888326736},
    {1.6197421676993538, 0.6103245725945274, -1.063235311606382, 0.21610707501484794, 0.9913722668475734, 2.130454704357367, 0.47017100847258747, 1.1778509620954913, -0.5189489694113589, 1.4275092852053626, 0.9333284459117062, 0.5809310884198368, -0.2554481245614231, 0.28457188755755725, -1.011307805876404, 1.1461434183097516, 0.4593282284863474, 0.6291816534363037, -0.07763907560029572, 1.1736392938268054, 0.7690606071186598, 1.2982654639277496, 1.4471855801108675, 0.9652117248196274, -0.4845353079704781, 1.6554244640215798, 0.6513027825192613, 0.723832470183397, 0.1497646786290373, -0.6519388463493807, 0.7305823301267599, 0.4532331784894791},
    {1.3417312108426154, -0.8992400738875044, -0.13137101333041612, 0.5714252573511871, 1.3455526684368766, 1.5872543721129224, 0.5957422219028827, 1.324351539438093, 0.1667970283074851, 1.4157135206868918, 1.8024915473986427, 1.3455296975235778, 0.7882552340465974, -0.26500230536532127, 0.25523041333254887, 1.108140879118097, 0.5327108004857082, -0.29796932406667037, -1.0153034563835752, 0.7207535343747998, 0.5682395360158932, 0.8313355061735731, 0.3115344550212657, 0.23591330230109572, -0.6332167946930538, 1.46294224741144, 0.9258858427079674, 0.5973903910134534, 0.7911567482099375, -0.13145373954036202, 0.1480269810376125, 0.12946388122373065},
    {1.4296353649653384, -0.9491217354088569, -1.1550566578015378, 1.4483053636648533, 0.4576448455911008, 1.282610364553778, 0.6949728192452964, 1.7242938956843312, 0.17403868224344182, 0.5477090689253159, 0.09124889044403839, 1.81067807006199, 0.7680419216903328, -0.3447169191350047, 0.5372902365692308, 0.30752762173713577, -0.24896924179855207, -1.1199439538826423, 0.039765993229700335, 0.9537491624667578, 1.2179294122444608, 0.9216295192844393, 1.036454528755754, 1.0703430953878528, 0.17301292280430172, 1.284380283784599, 0.2922789614700711, 0.2631350551208824, 0.4004947347250861, -0.5584724359832824, 0.8330541136495953, 0.2362415233494083},
    {1.4817964383000375, -0.6159376579486048, -1.129810493133588, 0.30184970293865504, 1.3355245509708276, 2.090400970281749, -0.031056386746063834, 0.3742841448528796, 0.4024118618282087, 1.4150904497694783, 1.3915878332884173, 1.1442373343910734, 0.35480322509903445, -0.3633601811068795, -0.39582313541310404, 0.5148903933545363, -0.7679663198281208, -0.6840434865648293, -0.273280516323435, 1.4028525360445567, 0.9226012029022004, 0.11757159956784631, 1.2702881153713554, 1.4214988534221795, -0.7341597615262393, 1.9747409362924278, 0.43732179824132045, 1.4985405599892367, 1.4863667799862366, -0.8866086463273068, 0.8718994198877789, 0.9300333674923437},
    {0.2592142369536394, -0.8208307115065997, -1.0900454176914287, 0.08185732206112221, 1.9793357078106852, 2.0605625394828144, -0.4961821486391807, 1.4737596234754087, -0.26030473865415993, 0.2794067699455815, 1.3161621931246315, 1.0377432125149066, 0.8506484905808347, -0.6117675063190051, -1.064993526390041, -0.2722999442890049, -0.5317851069043318, -0.5598676687263413, 0.32447783240337114, 0.7814408228628145, 0.1536635400850743, 0.29056341303051575, 1.0895862240239529, 1.290467056028712, -0.586843524220665, 1.1533854545217803, 1.6549370357008069, -0.38600059571808026, 1.6104567446433538, 0.10026505127746538, 1.1763462005015684, 0.09920169220691642},
    {1.1852488270655483, 0.0618085699967347, 0.7212819583457345, 0.3105874425827039, 0.3970672279682819, 0.46252037437401106, 0.20998101289371807, 0.6689876143064439, -0.1205496370808467, 0.2723520107378734, 0.9973418457072262, 1.259080644887476, -0.2015959122228118, 0.23380489014195904, -0.5223346471739048, 1.4517657504972348, 0.7529309182980621, -0.38771286210051925, -0.8716311010083724, 1.1189133223157073, 1.2866517012355212, -0.015461928748077263, 1.569441581924778, 1.2023462794184812, -0.3396291403006605, 1.826986648990318, 0.43833383479716076, 1.2926621599016568, 1.1464702312445159, 0.3512860632909853, 0.2840471955033681, 0.7991019962175929},
    {-0.2203582527683037, 0.09492521207560056, -0.7014100853365842, 0.30200737522719817, 0.3912392327227898, 0.2713483703810916, 0.15334135030298648, 1.8154759867515158, 0.3610968050165641, 1.3538428019847475, 1.5541944980432911, 1.3174754698073652, -0.1831595523406324, -0.8436762410056425, 0.27330604570038974, 0.9670873318934705, 0.017922814022026615, 0.24735692137247017, -0.729855596636849, 1.0167240290639843, 0.6612870253958957, 0.9410928291092668, 0.7787333860613975, 0.38538078306566126, 0.4598593208001349, 1.8086310062708117, 1.1762437703571509, 1.2794150242687832, 0.7047364767936898, 0.02059235479478023, 1.6691968049255927, 1.6276031265380881},
    {0.7923776281897088, 0.5198977103712709, 0.23252776865929786, 0.27434232142961396, 0.21652483978614517, 1.676967972709539, -0.17027948984275207, 1.4317051577392017, -0.5670789840751382, 0.6449845916245565, 1.1047356614776387, 1.7080046680704086, 0.6411109005043519, 0.17083020314753358, 0.531625230579619, 0.14553870066092903, -0.3424259664966183, -0.7156483756944775, -0.9359435925681681, 1.087526054919968, 1.3914980870922824, 1.2012472474556974, 0.9423320688280725, 1.1158026941503043, -0.6984791249331289, 1.0814306079070435, 0.39714326667615046, -0.27612268509049764, 1.1099844016191698, 0.07482529212223102, 0.6760405277312235, 0.9236171390045085},
    {0.37428931875155647, -0.9319757859984358, 0.6130910694236843, 0.5177547483585213, 0.2202637259152471, 0.34283822462276103, 0.4807618407505801, 1.2560891969791863, -0.2856173039821411, 0.7839328800136417, 1.8282509475464566, 1.2954887299416533, -0.08810501975347806, -0.851836465884899, -0.7145200216452497, 0.4250935509887074, -0.2705448615655896, -1.0820126042905835, 0.011288627712678686, 0.9768095389477782, 0.12109471442874996, 1.688222589955642, 1.4118060041436593, 0.5096771405618827, 0.6700427679972835, 0.8302709691110094, 1.012233749135937, 1.1622270972406474, 0.8700420720744695, 0.08781265600885733, 1.8884447731628193, 1.069295322444464},
    {-0.14895446193512782, -0.41008116647782406, -1.170634901555085, 0.33096562888205067, 0.5424400319560108, 2.0648673499911445, -0.15251797234462713, 1.7263585650665405, -0.3161798101321661, 0.22989351102099298, 0.14501371990694203, 1.6934292471311032, 0.8083707561695569, -0.846222598959605, -0.47038987496979096, 1.0884838990535406, -1.0361881507678001, -0.011957944043038602, -0.44411334386956225, 1.2638489203762622, 0.0568547791559778, -0.11972592151608209, 2.0436443720450237, 1.2282319054540196, 0.05372788497199652, 1.5238910819608393, 0.535033530732953, 1.2748042729792275, 1.621385546735822, -0.9583918652711023, 0.03665038894538064, 1.2990313950329406},
    {0.8676400971413046, -0.20096532865128416, -0.767853832438886, 1.5888564902301359, 0.1857941756210175, 1.0115344656936975, 0.5127626254472208, 0.8392869564688469, 0.12375590987490998, 1.004353614817483, 0.5878303974971, 1.5655159888387773, 0.24703076717145664, -0.6203050543786502, -0.787998223571153, 0.5850100219233395, -0.7413761321814374, 0.31040763280668804, -0.05932241022009489, 0.5269702576686867, 1.8863060335792972, -0.019253161111377905, 1.7061259414235108, 1.6513597331785073, -0.012085066595520645, 1.7025939162800694, 1.0807117014386938, -0.3014385525064929, 1.2812566081023964, -0.908363992468548, 0.756695947320054, -0.12269690197824584},
    {0.7157550659670671, 0.7153465168234533, 0.7593505993819213, 0.6786434605358783, 0.9599078229321044, 1.6918340438162234, -0.00522881597074063, 0.9324749521890305, -0.0656668037554971, 0.15990889328128258, -0.03379048332818885, 1.3622810908619536, 1.3686819330696451, 0.24894624440605317, 0.5403503600378703, 1.3131262753198925, -0.1896977041758131, -0.41216811207543047, -0.03407538900597766, 2.027615103470346, 1.6201097636873396, 1.4941300228376149, 0.6810276232314801, 1.982277150588052, 0.8090237109689559, 0.763947995524059, 0.047990781781634656, -0.3176476121420547, 0.4029580873950364, -0.35328002206821696, 1.103583138711722, 0.703166382336389},
    {1.1690605700384287, 0.12185796355343144, 0.6030924504578182, 0.514217434072193, 0.7731439684333458, 0.6345491664043377, -0.5699251020396102, 1.851873341743741, 0.2485502533422972, 0.7522216159489604, 0.550008079712161, 0.0164942190491227, 1.2690645670798486, -0.9163374745386342, 0.47947893179863055, 0.9153475425151792, -0.47274930660923437, -0.11572529716278739, 0.44631023417295773, 1.8465804394844794, 1.3001608922708436, 0.19511456093911472, 1.314897991390804, 1.9874956316940486, -0.6374707171373043, 1.814167066650142, 0.4046324775267654, 0.06391872033962971, 1.0869406605667287, 0.12784306045535535, 1.0323260681542497, 0.8074413948881802},
    {0.2416624138258425, -0.40872172046311156, -0.3279161147993947, 0.8579228138268535, 1.6373105843246984, 0.6341686516088697, 0.10443982857868028, 1.6746498833724646, -0.5641148067898333, 0.16769207904927685, 0.6080790584483893, 0.47307213718330865, 0.5584410790741475, 0.7549459853147162, -0.45970880551663357, 0.6272224589909617, -0.984136492535199, -0.947709328204677, 0.036785679704162674, 1.6328355324964787, 1.2178662371675948, 1.1285550980619423, 1.9630365599296118, 0.12845956213865276, -0.37071998199721107, 0.7842638104780124, 1.5020059139054172, 1.1679499433391798, 1.258569632090116, -0.4781394261687835, 0.4841560136434032, 1.0263140256204542},
    {0.5322738421248959, -1.0226205952960712, -0.46879223217232785, 1.5379392755355046, 1.086103572265373, 0.4677396076661805, -0.3677961582298855, 1.797233500445555, 0.10094301245117167, 0.0910142550514042, 1.0328960759774473, 1.009372324280205, 1.4393381823047773, 0.21663481624095454, -0.5440809132505706, 1.5333410511820598, 0.6561803140141325, 0.5200956079825636, -0.3303527488451758, 0.5762712189273526, 1.1475533500597541, 1.5889972089044417, 2.075077950439208, 0.8652082081849445, -0.06739557536277328, 1.2224991172573618, 1.7670599739623436, 0.04298820738407946, 1.3483126479142624, 0.02783429650789234, 0.5808159948180787, 0.5657239523868156},
    {0.5536670957660723, 0.7460282995050227, -0.09280080520729814, 0.6570064394980158, 0.15111592884527297, 1.2707965579959002, -0.552277552967388, 1.7688303951308615, -0.9777258351233599, -0.2573929429428163, 0.5397639060816127, 0.9564132674680177, 1.1382709235212511, -0.1535146623364233, -0.9371811762711536, 0.7665385999990886, -0.27035514882082157, 0.23962571166007723, -0.26832539273345474, 1.5319560770969733, 0.8836607814135418, 1.3565015283560309, 1.3312624815994518, 1.7129647164388435, 0.321122392885775, 1.7720492863439319, 0.03426680346001991, -0.10320910892432308, 2.0569853425935625, -0.011181994209356198, 1.3704531586985582, 0.22851235008167778},
    {1.019202325123819, 0.052127576267357346, -0.9057772777784331, 1.551157356576819, 1.7064719574369624, 0.215353976415403, -1.0877319138226624, 0.47702611252948834, 0.052762282918627085, 0.2311222913396784, 0.05770201968714522, 0.5452996924394962, -0.3905627772310768, 0.04413867328541952, -0.2817901475795081, 0.3672341457543577, 0.6112547178089187, -0.5780231935106942, 0.7132705342852033, 0.3955844384476142, 0.5184715598290444, 0.45245363331716776, 1.3526873884749262, 0.9647440043963085, -0.3618114861767211, 1.2081742558402335, 1.5800034767270577, 0.5117265239439719, 0.4754489094027439, 0.076648765997301, 0.1953370224318755, 0.39551304839645757},
    {0.9662603765965385, 0.709407040835447, 0.6760541718948846, 1.3874293933719848, 0.9204101479732603, 1.583342483354395, 0.15046711201287177, 1.2071851522629349, -0.25274181114977684, -0.1307897466601498, 1.6951933697511883, 1.7885746884109142, 0.05311486517119579, -0.7923391239668395, -0.29877979309217423, 0.43328349620783063, -0.004454145791819845, 0.7822260795567132, 0.013304466391225199, 0.35480383977731506, 1.6284946323158407, 1.613216988141094, 0.41033670802200894, 0.5450327303665733, 0.13043759556476, 1.2385077396538748, 0.8743157591200952, -0.18172611053291796, 1.054758462293678, -0.884819101271467, 0.7926495327052052, 0.8255677190156347},
    {-0.16352219669117232, -0.9714060175816248, -0.415600846213583, 0.8655121565184271, 1.7964820733769602, 1.8600405967171263, 0.6544701944852542, 1.4040247626155022, 0.04837879215211849, 0.7425242698632297, 0.8484116592562742, 0.9193483067779867, 0.6844620437621034, 0.4101885605122248, 0.4621360431186492, 1.376989730773159, 0.1912526186022649, 0.2886137879434296, -0.7890067817653386, 1.9225093408838503, 1.2952831294133946, 1.3743159642254734, 0.3636770526866517, 1.731590310538232, -0.059693495525373876, 1.926750548274548, 1.2578599332128881, -0.10571473312516937, 2.022932799423318, 0.47409580121969885, 0.23604713096386726, -0.1277255693752535},
    {0.3816617270859855, 0.7180984749021085, 0.4359705357580623, 0.8262332558236799, 0.026848669885726435, 0.47225181155637697, -0.4490139447113953, 0.9178671156544808, 0.32111524501822464, -0.02032898085270684, 1.6725178873990154, 1.6305585694222864, -0.1423267255701216, -0.4395143906671785, 0.20644954752223815, -0.1063198433652149, -0.05389362269040646, -0.90876331291159, -0.15492731352563, 1.736552422528638, 1.443805068739092, 1.5708099005501899, 1.2493490546798385, 1.423029471417851, -0.44064550021492815, 0.7025437799165141, 1.1167406289598856, 1.3316082843707617, 0.7235602780704675, -0.23404210156094193, 0.8949090912776015, 1.2458777809741024},
    {1.1030674779611878, 0.6305839076430222, -0.9315513002744286, 1.0263353819307899, 0.8984724437925482, 1.9522526940273333, -0.47365700591689797, 0.303096848354755, 0.5404161361536116, 0.15703258105091877, 1.7319666065535901, 0.056060076518484665, -0.15857381498187378, 0.3590433089435721, 0.5051367721103736, 0.5951587624374302, 0.48805320440081446, 0.540727951022754, 0.34853289761422607, 0.37885924962534984, 0.7597599531263503, 1.1119764230279758, 0.48380632396631934, 1.4976234480521653, 0.2515833705133408, 0.8673903853084898, 1.809338976205688, 0.2910711907925357, 1.4654945826820864, -0.9048332483162388, 0.3362675689865516, 0.9341530485233768},
    {0.19236711779571616, -0.9776307158549932, -1.081458513002707, 1.5476298238469857, 1.5181772134902463, 1.116401294705439, 0.6390396528584404, 0.37886624708939776, -0.06268058503293299, 1.3491773413363, 1.2847155608849419, 0.0845649505443026, 1.0036690748954489, -0.15616806625776888, -0.0591361356448671, 0.6520461862104504, -0.6635784577013684, -0.7457427100313688, 0.7352795378885073, 0.3355382207215574, 0.779377458353512, 1.3441126558120486, 1.8235992770376437, 1.8550557687026872, -0.7228700480661212, 1.5235162860899576, 1.0099458843694997, -0.28445977332311445, 1.3457232556144325, -0.5586638974198719, 1.1154454947369068, -0.17215053387088228},
    {0.584862082512331, 0.4420001353073138, 0.5032145566579439, 0.8574064417098692, 0.07838469188504021, 0.6968535661540769, -0.12757047978185318, 1.0284048557706926, -0.487463472134413, 1.3935666923233256, 0.6934895416277493, 1.0722648179280356, -0.1595032102653821, -0.45717345146699156, -0.841927324268637, -0.018975666161692935, 0.3733982782872819, -0.993865666801326, 0.7637253524289643, 1.4596170120328724, 0.1000896565994359, 1.0337808100513635, 0.15926933384646125, 1.4445836857787475, 0.8445693529862771, 0.8474308493877996, 0.3701978585450546, -0.34618664115510406, 0.20961131541168276, -0.910320527932571, 1.5720283951125298, 0.5840649653824133}
};

static const float b2[32] = {0.937836296722075, -0.16773534830506148, -0.35134282525075006, 1.2708716999133394, 1.2329403067703768, 1.3819268291769349, -0.39613190336123116, 1.4104561473540913, -0.29438439629933977, 0.5981950091114412, 1.3270996938761563, 1.2146293885789683, 0.6565009903248278, -0.14933375760953072, -0.3608574515834982, 0.9819267095899317, -0.08770955924579667, -0.18353179100760567, -0.23888034961947008, 1.5211469724659108, 1.2829090374057968, 0.8963784403138795, 1.3491329313184461, 1.2953148691684737, -0.14771672905348857, 1.5120952832694092, 1.2990821557613048, 0.7213579681118738, 1.373425901455417, -0.3781745310304053, 1.2475165240281474, 0.9154302062764216};

static const float w3[32][16] = {
    {0.698157573529635, 0.48970040236880774, 0.26935594070463514, 1.4552394705192997, 1.1538588251235844, -0.26766883321432444, 0.9163545137777639, -0.9926134009122323, 1.7127165883981823, 0.9009692101454833, 1.7443334825939747, 0.7966096318160512, 1.790568342855077, 0.46697826357269995, 0.21282899645935238, -0.8279584966831002},
    {0.6268069769907374, -0.7172652555811496, 0.05148779051141296, -0.3791331278730943, 0.0648890368901444, -0.5914114426905902, -0.9336582195098516, -0.6252563012279304, -0.6477771414308845, -0.49625249801320825, -0.06851465581566453, 0.008989547629844987, 0.8769500535151412, -0.5255420832613759, -0.3358261722177015, 0.7023108448185436},
    {-0.2103576636448205, 0.24811505524176053, 0.5031989327600221, -0.6194251351068581, -0.6469429905392217, 0.471092964801699, -0.8814876805455071, 0.06513698943541643, 0.4483389705271612, -0.31369990773688883, 0.8999269591156895, -0.3137757940963424, 0.37179003790065285, -0.11390457990687251, -0.4682925670010223, -0.35453427951744726},
    {0.3260770017721326, 0.9415220626912418, 0.18892332890975672, 1.973605817955392, 1.3051908117259126, -0.1508401128245704, 1.186386282932948, -0.940824310741684, 1.9178015533662578, 0.14087166730594722, 0.7102471548061566, 1.182012613575488, 0.20866564732167994, 1.3699958480541394, -0.39851837664653894, 0.1343983092705806},
    {0.33651179020711225, 1.7444493501639788, -0.7320088469367491, 1.5434665605923183, 1.5046845720341002, 0.014393861030559537, 0.670694568843582, -1.0318749774871632, 1.444817609992517, 1.2579228350846858, 0.46662774239962557, 1.5157111515439596, 0.8874792282931778, 1.5699133029752717, -0.09142344241979841, 0.7646769674020715},
    {1.2216469147085867, 1.6250065154346667, -0.03488457089860694, 1.6105714782579732, 2.3510561603333033, 0.7800378771502332, 1.124701780817403, 0.5100971456208719, 0.9098410668015731, 0.8160201215049996, 1.6931643709306425, 0.4159619203501159, 0.504813678248463, 2.1923937939370832, 0.46633990262359, 0.48827361477307746},
    {0.7171811666294627, 0.018966494396464, 0.23947710599365055, -0.08196584752404626, -0.19965949654918708, 0.8153195718497454, 0.5871370443504776, 0.4909010353847089, -0.5609372218506242, -0.309315105892648, -0.41465495054212137, 0.27869665203781085, 0.5658121203514503, -0.37573716501206683, -0.33770967059455487, -0.6447527580324397},
    {1.1393978250997963, 1.6858801058552113, -0.17844400344540073, 2.0732700054758584, 1.1709433971364969, -0.42825037898617085, 1.3430668171880509, 0.48931537615060905, 1.5465775485638973, 1.019991183340896, 0.5325898033827009, 0.497681915774529, 0.9625469063824057, 1.9025180531524186, -0.1292908750051951, -0.4034197533072203},
    {-0.4262368758533427, 0.10310548661206849, -0.562491050605751, -0.466069841873121, 0.12640449367104814, -0.41431665012894237, 0.7543455343863718, 0.615972365237358, -0.08497668741710256, 0.5554540455073508, -0.5870096240415117, 0.0762746166737303, -0.6015890699356835, -0.5373589743804694, -0.7215927008127403, 0.8252260829644281},
    {1.1427866602382057, 0.5873170181695078, -0.29805582669478686, 1.3205110704141811, 0.578573423046191, -0.8390873983031915, 0.9935929645660572, 0.2956331823760846, 1.5600148959364062, 1.1900636587901123, 0.7332112741906723, 1.4847425824849823, 0.5099123640593731, 1.0966199412631368, 0.6207825484049893, 0.13430415315500466},
    {1.4249060137624054, 1.5525037429752844, -0.5055238212371308, 1.9388018677351442, 2.2970308058762607, 0.6549931757293532, 1.2147863187880217, -0.6949718915899064, 0.8809425362157894, 0.9392162514295015, 0.6181076095027245, 0.9535587252053023, 0.36484836418753264, 0.6191269910871858, -0.5543800132811004, 0.02861468688970559},
    {1.5672712837397749, 2.095815599901469, 0.6287056307571732, 1.1901787972807654, 1.4976738568785355, -0.7799774970201594, 0.7290426767438697, 0.03861842077850798, 1.739930030114069, 1.2223207629305144, 1.1580985072256798, 1.8795117908479433, 1.1494926539193935, 1.538842983164537, -0.15388627794015997, -0.305963043408349},
    {0.9575862888485939, 1.2448520353299946, -0.530582094751071, 0.4587190810224308, 1.2332206058149136, 0.6300451979764253, 0.5618117062880055, 0.4013904456110079, 1.0919781782206603, -0.007118523933675913, 1.578890519542808, 0.826813463206738, -0.040750110561188824, 0.6309175007949219, -0.44041573888256386, 0.15489899306382393},
    {-0.032154215903208556, 0.09044895367621465, -0.7880307627035726, 0.15657310045515407, -0.37801706094863047, 0.3760222701187354, 0.08702488963243124, -0.8655861583244392, 0.5363220381468542, -0.4720357756886991, -0.7993806733860445, -0.4883959308103065, -0.030240663706142087, -0.514698973520307, -0.39868582029827965, -0.938574459950485},
    {0.017927038883391873, 0.02129287771516965, 0.7681768350432566, -0.6759412971682547, -0.6206274562224365, 0.5145855135981748, 0.5693612730056485, -0.7241482238080585, 0.7128972637262472, 0.4177624646666229, -0.2202710633626926, -0.7146380427692667, -0.0638753307838101, 0.052037330007141155, 0.291719995054928, -0.1261190330754002},
    {0.5228566426061771, 1.8137711188266898, -0.21367469583862564, 1.6749609721078471, 0.8950404355749392, 0.5779029339258128, 0.4500858357259434, -0.4930573262580717, 1.749155959506225, 1.1557159101121655, 1.9523665567071784, 0.455038590254584, 0.12309699620800117, 1.0320532236256044, -0.07368314138120977, 0.2792141023181789},
    {-0.8026500474194102, -0.5561534346408783, -0.3697291043389484, -0.18269693854362526, -0.016211636484707852, -0.9264410103568377, -0.24198605215092053, 0.6647426342164512, 0.28092325274003943, -0.9618775103224065, -0.2659150922967244, 0.17751936830674692, -0.19223201032916926, -0.1651565438331991, -0.785511464227301, -0.6995338193696422},
    {0.2067686749829486, -0.7916088001604434, 0.3340933664074246, -0.7824674288782766, -0.7226455182432395, -1.035119097228366, -0.6124820587412707, -0.26427034192813514, -0.5880894937839389, -0.35117148371737994, 0.5638621358795388, -0.5432766382785092, 0.3431057952499372, 0.21739280963126137, 0.21312138047739054, -0.1370062283611471},
    {0.4169355753006174, -0.4406944758361193, -0.4322684995358006, -0.26615291192628654, -0.4844220205135497, 0.8832913225415375, 0.38108504086654127, -0.6921274440097789, -0.0378727251684875, 0.6820418123451493, -0.7308341120969737, 0.2510615852589981, 1.0233119714236183, -0.5648472237847721, 0.4126228036137921, -0.5202153512766241},
    {1.0553465472771515, 1.1099571090480025, 0.060454780345803885, 2.470820354900671, 2.5701581044226374, -1.0510796090690577, 0.545368004150779, -0.5270586840900175, 1.9306527389789618, -0.24774580821487555, 1.6224287777843758, 1.8546128043709345, 1.1797584444197802, 1.861813530875913, -0.6364817292850731, -0.9747221729325558},
    {1.5725331186841254, 0.6648110331533728, 0.09332972615810609, 1.5406091525721501, 1.5694234646314085, -0.38513962765489124, 1.211712635139957, -0.3448519996823599, 0.671871614770677, 1.3910429597986422, 1.2108701649359142, 0.5043909399956404, 1.4989293499870437, 2.1987930342732995, 0.3090888392476463, 0.753298308716489},
    {1.417636208444069, 0.32949576715472595, 0.2311177656984412, 0.5534136019754357, 1.917963363812502, -0.4763020318044588, 0.3289993442202559, -1.0474087181074914, 0.6304631407035097, 1.4333003058588887, 0.967949000488947, 1.5723893123543828, 0.69771021390435, 1.4959659446907365, 0.10137434360491107, 0.470423907551008},
    {1.4349862685959156, 1.2979138135512491, -0.9770593862795743, 2.068994495810029, 1.9788979124929178, -0.4497468203067014, 1.0061274232690212, 0.2615286930666365, 0.42100327298495366, 1.5462198751246317, 0.45831787393262435, 1.7638282818794615, 1.938309692531997, 1.8555976520387123, 0.6247761393400662, 0.17316266684158524},
    {1.2906970891479943, 1.8643548295234662, -0.9128350539709592, 1.7062613099098056, 1.7058056228274294, -0.5721919079328447, 1.3989800400394303, 0.715204677965847, 0.49716539539499505, 1.1299663915922697, 0.3930235680261989, 1.484196788634363, 1.8096851161707839, 1.4768922510026017, -0.6114829343592374, 0.6911864877736761},
    {0.06344004060122324, 1.114371806752895, -0.6752479946944023, -0.3905506045140008, 0.4184544146462752, 0.38915788458634754, 0.7153548828133445, 0.321717777919362, -0.030840199391248716, -0.20467829958516828, -0.24171824468478004, -0.8705576120968493, -0.7916118358536173, 0.1648679806219357, -0.14431355778717625, 0.8722244893878952},
    {0.12920208808215303, 1.2096963814696848, -1.0273215701853426, 2.2707078152132336, 2.2906413123525966, -0.5301333508916554, 0.15495431641393143, -0.9187597506230089, 0.8887707353357854, -0.25075730332209273, 0.9382429736468565, 1.12119140247706, 0.12670358070764653, 1.5589575749658717, -1.0183136375243411, -0.57922747860377},
    {1.3490241798017202, 1.872378731893181, -0.5123634262064595, 1.3853392322383613, 1.5689569560661145, -0.9114396202884274, 0.2887321826127246, 0.547359056469715, 0.20834384001149142, 0.8105450856552164, 0.8907880731225748, 1.4007912900699067, 1.9688645325943162, 1.6727897086761587, 0.6273954874382172, 0.7299117552863141},
    {0.9661812177572994, 1.2957827541637568, 0.8053055051484004, 0.18753078658266345, 1.5620709056018294, 0.6091149079164818, 1.029097281233128, 0.48553156286012306, 0.6172371431217785, 1.238517838905992, 1.548376421398394, 1.2832203518293852, 1.8525579501458291, 0.24785609431005615, -0.5819455860247335, -0.2227336989635339},
    {0.1703018463070616, 1.9900569066618539, 0.5224292995197064, 1.6235112227760906, 2.1734508409086084, -0.5595432652075081, -0.0006852338263583167, 0.05762212555048749, 0.9003132787224035, 0.33881560384778825, 2.2274774496323873, 1.5321750835714745, 2.038810825786662, 0.6488215338192102, -1.016130366165611, -0.8150957334308999},
    {-0.7493922369457346, -0.22199163441266037, 0.6999491948771239, -0.000711196736782967, -0.6510167034522657, 0.4337946885347218, 0.07412916831419387, -0.3529505783099821, -0.5976161782570557, -0.7896641124222146, 0.0848188547431652, -0.4091721910558804, -0.5260945244392693, -0.4128524390433746, 0.29858596904845996, 0.4311461505212246},
    {0.046301694676288, 0.8770172735259552, 0.45173314449326885, 1.032015700992831, 1.9731869932005803, 0.30731922666203937, 1.039422875538584, 0.264337159311552, 0.5397809841461627, 0.5442637936976269, 1.7135730422340698, 0.8506596702825961, 0.8093413620810912, 2.139893860698259, -0.07094671088566684, -0.9229467537329201},
    {1.3594949750392795, 1.5674084869479203, 0.46364901134139813, 0.875812120514915, 0.6809105315767868, 0.10276083803501167, 1.183754286734748, -0.3961790647440875, 1.1825028350652071, 0.8631819228924301, 1.206460752553765, 1.4399787889502598, 1.329785266105192, 1.7185471140003148, 0.6196624328048108, 0.4287992653317196}
};

static const float b3[16] = {0.765266119327295, 0.9396941506559324, -0.09028057071773653, 0.9621032068718648, 1.1902595353261423, -0.18558240963105496, 0.475825149136925, -0.2085612974049967, 0.5186609028339425, 0.3043231560094159, 0.7771282180424579, 0.42403743383189485, 0.8229676877005534, 0.8388551485758782, -0.06405426871330723, -0.17573538124259194};

static const float w4[16][12] = {
    {-0.3775162286106528, 0.022509080641392783, -1.5734889287389633, -0.8090833592778992, -1.3601121813546582, -0.28908268573754814, -1.6252747342999685, -1.3257620576114817, -0.9648274680950204, -1.305437765478332, -0.3340981163990752, -0.17167981649512298},
    {-0.8082328339034658, -1.0747937091681605, -0.12657366482015184, -1.6188173485787307, -1.9790874605664521, -1.9769785136184626, -0.8218220394766618, -0.9258475738016815, -2.033215482347999, -0.08492376851022158, -0.47275452181310806, -0.6138382168127295},
    {0.5484180691954273, 0.10715444391516109, 0.35319762578663494, 0.26438494497518067, -0.7070287764416325, 0.6572303599974688, -0.9786360333849259, -0.05438223113922103, 0.45447369336178134, -0.9409984999172503, 0.8533416800934507, 0.22254633690500644},
    {-0.5573036984023105, -1.077676799833995, -1.735997614764081, -1.5552349301350625, -1.428457465657292, -0.6841138615373205, -1.9382246675337855, -2.110391262805295, -1.513701272228215, -1.2218349520549778, -1.839382992404911, -0.26872775181632774},
    {-2.083715814587213, -0.6647522472778981, -1.862445045306629, -1.9368838440229592, -2.046465934560656, -1.067452886564153, -1.0906100615851486, -0.990331336643852, -1.454331586816823, -1.5709649840542492, -0.5914637662016974, -2.150622697345369},
    {-0.8793534013907414, -0.42509146635576367, 0.8103510806237573, 0.8559128610841147, 0.45567252543593406, 0.5020363397761335, -0.12124991593767052, -0.9606171132484603, 0.5678086940626977, 0.2676717127752001, 0.7290535565259948, 0.23203508955797036},
    {-0.9779259226590027, -0.13767503365880374, -1.292932007128921, -1.7642573068426861, -0.3057237622174873, -0.6935890030808267, -0.10905159318586957, -1.421616614059916, -0.5077185039808345, -0.10036817243063366, -0.6632677317739243, -0.2948459719365044},
    {0.44568472671815673, 0.5200462049704214, 0.3965305688253021, -0.35377576042636477, 0.5388774122878773, 0.7801471008815334, -0.3068083010836734, 0.43701478606057687, 0.13397283135613192, 0.02680956568891339, -1.1663986470378467, -0.2856784353145969},
    {-1.2955755559493316, -1.9384680304224429, -0.4956677260533234, -0.32376499202179454, -0.1503752896444671, -1.9552668591919111, -0.17652942671112584, -0.906888026092874, -1.2721242754533784, -1.7021239550093423, -0.8699359198991635, -1.3163907049634418},
    {-1.712038906394775, -0.35716661435515507, -0.11382019465356354, -0.706675466220167, -1.3414738848981544, -0.4665186626242238, 0.2744581980111139, 0.09734015684178951, -0.939010262927946, -0.807618976840266, -1.023867619143439, -0.19817614862141328},
    {-1.0330576151928845, -1.7423065232379913, -0.4820033656814973, -0.7155648743341354, -0.7820049135756343, -1.076457972717743, -1.8446190077946873, -0.6852891530076082, -0.2473250730492107, -1.4942719420353205, -1.6051140352606474, -1.8837347088078165},
    {-0.8489253842447163, -1.5998666355560833, -1.7409048701617436, -0.23127191621941093, -1.0195927508035147, -0.6940786076998438, -0.1768956402203332, -1.2335935823266164, -1.2926584454300962, -1.4649294005260418, -0.886426921693025, -0.7992436726307488},
    {-0.25084485032624837, -1.019220174311543, -1.5307849991646931, -0.6107141972469415, -0.46382251041166705, -0.5837599589470893, -1.824487626767722, -1.2528592460899826, -0.5472474709230483, -1.2253464229467923, -0.9811578960339002, -1.3306928752403446},
    {-1.5932557877524678, -1.574594162307289, -0.3445610304055326, -0.8904370073194104, -0.29025711130763604, -1.6829551483755205, -1.3821190409881283, -0.5834430971363355, -0.45018305779402845, -0.5786006012389957, -1.9723671003932717, -1.7736336994642155},
    {-0.04765176656918868, -0.6139341511324371, 0.9138924898575165, -0.5420468489988236, 0.6734789879035659, -0.7759196485238732, 0.40606954726186695, -0.20727040548073958, 0.3056080447673675, 0.6226430468720798, 0.4982311210173805, 0.4881991577159161},
    {-0.24520834400377084, -0.04149948210802576, 0.664328661666107, 0.825283798678589, 0.3300106119103931, -0.8716238851341032, 0.1061767648473231, 0.5122840845776631, 0.47271310258967675, 0.488185691382159, -0.6302178078943174, 0.2871714805086091}
};

static const float b4[12] = {-0.6295757080744, -0.5195703417737239, -0.565963785263055, -0.4839484692299709, -0.5653196707203242, -0.592098878981326, -0.5253061020896604, -0.636063871849786, -0.6081642263687055, -0.424296125498233, -0.5478372478491073, -0.5015799878033064};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
