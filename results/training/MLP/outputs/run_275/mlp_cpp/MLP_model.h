#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {1.3564663649441504, -0.13824861108478084, 0.22848217941224924, 0.33372031460488405, -0.9237103687265539, -0.8050000861605682, 0.8956869549583482, 0.6952254531591195, -1.3007459254651403, 0.18002633584873245, 1.869764019892958, 1.170067022848262, -0.7589033375476996, 1.0005552930195005, -1.7051149550419042, -0.5344757231837851, 1.6402928901946656, 0.5545433546352773, 1.310717433241259, 2.3199598179746026, 1.2175740158781434, -0.4603954965718983, 1.0153623528216504, 0.6909545976666122, 0.6021107819923311, -1.6692455711851524, -0.3302106732920916, 0.1305327964785499, 0.07109540674134447, -0.2170765416902072, 0.3584700041822279, 0.2217195158256529, 0.23253760354149233, 0.5694748424010802, 1.1780026824717849, -0.3123732897039679, 0.2805860798420756, -0.0053384097152864496, 0.6751924639214956, 0.9262501222760662, 1.8251065117159337, -0.7251750723890213, 0.7473470260198544, -0.6719020949413598, 0.14774937678639144, -0.4063349149556572, -0.1906441756516299, 1.430476202961827, -0.16804907909214092, 0.13547504733818297, 0.8454288115636711, 1.3553587887799752, 0.11023991804569058, 2.908065104546247, -0.3603088366468478, -1.4042703302283581, -1.0399687700516145, -0.13071233408839014, 0.2563041924522585, -0.5490323686072931, 0.44118407419395395, 0.041292962518250466, 0.17372428182048325, -0.6549964598786572},
    {0.06379231372918664, 1.4677482869990641, -1.1218557330922505, -0.10559809055090343, -1.3717889726295913, 1.231383931102606, 0.7976657212670271, 1.6965849090345582, 2.4821356702326187, 1.3062223933634713, -0.14852091708275972, -0.06415056463152582, -1.3960093158016074, 0.4095302420909961, -0.5438573331342101, 0.6223571658177757, -0.7381801406622096, -0.13639228296959127, -0.6709484475623, 0.3960403036635584, -0.45625575227228804, 2.3356023071293386, 0.35597532734547105, -0.44691993062090185, -2.091629663863094, -1.0123423718161477, 0.517953802029959, 0.7586178710219592, -0.00951954961270968, 0.800139506466256, -1.9209269401739, 0.015955096623813593, 0.7556475087161898, 0.36278451155821345, 1.5219065463307013, 0.5334377936659647, 0.021654979588961204, 1.1215161979667063, 1.3888948724126247, -1.5337168980634852, 0.09333997061634713, -0.6109735028838219, 0.2221891054343903, -1.313048162626194, -1.1346135248459912, -0.1973803326058984, -1.2065911047515214, -0.7378288090315184, -1.3301120334551129, -0.41391934767945104, 1.393727639354527, -1.3223359374439256, -1.0312085610608266, 0.5744507854702687, 0.7383272091337275, 2.1906892170348775, -1.3942867645528674, 0.005742042084240018, 1.7237159225349508, 0.6448223244306169, -0.5346161380573887, 0.04608750210457752, -0.19206263946275764, 0.6190094961808175},
    {0.22581341344517716, 0.21933772555659706, 0.33836714202566803, 2.0470673561552126, -0.5146763993374033, 1.1946313868080014, -1.7704625889377161, -1.271926748054903, 1.6538607081039005, 0.41211603540058583, 0.6636860068676022, -1.6223113256999344, -0.40910820293929956, 0.6036810678425097, -0.5429512397388193, 1.176036846994303, 0.34912736022127117, -0.6724923056818668, 0.011893872981122067, 0.8815912136363089, 0.2571770852363341, -0.5795093054401267, -0.25617676588015414, 1.1132361002639173, 2.1517133041575014, -2.1953322034002727, 2.1960294064472428, 0.1749412870917451, 1.5137497948122858, -0.518133871063375, 1.6737793699519639, -0.10352704995406868, -0.477959471305249, -0.5563673394724779, -1.3868797295815338, 0.7974052076527576, 1.0412802830814523, -0.16826585847002481, 0.8299304019520585, 1.2415479075773317, -1.7691379635941824, -0.9127845492824505, 0.23123111818746678, 0.7966470365467728, -0.28066606551295054, 0.37790610011580866, 1.6411795738095567, -0.708619606091249, 0.24557466543335923, 0.15571928825308784, 1.3486066827313112, -0.7325853046955805, 0.5512666261987823, 0.6566365618322868, -0.2135607080645403, 0.31689523768823985, 0.8008928237513576, -0.25270845586823026, 0.5400718307738076, -0.030415673739343386, -0.4791562795219751, -0.3700460312535773, 0.4927806412445627, 0.9220700219588486},
    {-2.0446899422149674, 0.957278920168848, 0.35195279100447324, -0.524369061119976, 1.1357179501083092, -0.3346860730118035, 0.9844317046672836, -0.7772495305948137, 1.0561000725854741, 0.9491479190806519, 1.6128019392814936, -1.0237412755103574, 0.19057211251329065, 1.9967515527875823, -0.758745950730444, -1.5491454286295283, 0.4476081937756166, 0.11573558333084304, 0.7595503278663536, -1.7240874502640489, 1.2342944676589749, -0.21145525163141726, 1.52723347512749, -0.3697130282802239, -0.7778902112200717, 1.109610639935023, 0.11244826971629464, 1.5065517784781324, -2.141042993277581, 0.5380977383078805, 0.9622183919482177, 0.2747195542498322, 1.105887963158486, 0.4176647842761047, 1.0380281401642903, 0.1812085470871592, 0.6745858694025245, 0.784869840189997, -0.12355685683887437, 0.31419847817508084, -0.8473087775653448, 0.7491913799440091, -0.5078370120460054, 0.8987101849218941, -2.2143685209771733, 0.34515006833809786, -1.4844002009765338, -0.12581694049527634, 0.45686982657302194, 1.3327097802922614, 0.15214216317739632, -1.583543520245759, -1.2379009546472834, 0.716601468321986, 0.33256113815919297, -1.5339453281571958, 1.5346612382394933, 2.3389766996720875, -0.3698044034086277, -0.06661556660465653, -0.052067482186287956, 0.39015909645248015, -2.045672139639692, 0.7559532450151457},
    {-0.170501777487897, 1.323435766903393, -0.13636135763015245, -0.39828326980471407, -1.445289038396749, 0.9983236586419846, -0.3028300336553164, 0.6196160799049621, -0.4088544150806946, -0.9895912778654423, 0.38817118762868486, 0.4185798984896132, -1.7785294313409707, 0.6531081262476507, -1.763058936595827, 2.4607309767972567, 0.14566856496031547, 0.5679028779570208, -0.21461446841384024, -0.7369179344994033, 0.10239094509391464, -0.6286739876828946, 1.2296781401930836, 1.5362352808374666, -2.1354349267858312, -0.10522772708923925, -0.5027787776798305, 0.5359367460105788, 0.8658715678272438, 0.7066084751277186, -0.5442995451210279, -2.1467502167206876, -1.5593480508456352, 1.4641154328971497, 1.7377597282307917, -0.020284107127365544, -0.043307001359618874, 0.2371661032882751, -0.08935361208088285, 1.7688598572650773, -0.45905657196869876, -2.2858006925455485, 0.23483831805771838, -0.5662200137135027, 0.07912747319321195, -0.843469541556258, 0.05706916115188655, 1.4225115516936726, 0.4844165879966082, 0.41857902426526084, -0.682224071649254, -0.0891653257535349, -0.8134819790319471, 0.8337101847412561, -0.2222391797680364, 2.092020758423602, -0.6257427386583572, 0.029718648306067567, 1.7905801705943176, 0.367411391513388, 0.42213769469645923, 0.5435754588157689, 0.49079795533950915, -0.982406600170204},
    {-1.0000622041213012, -0.3214885339933189, -0.37506124065637253, 1.3181485648376026, 0.821123124555591, -1.0047064268034989, -0.3608353499804536, 0.4653430238706195, -0.09074560332321714, 1.746247140551113, 1.2811550852139533, -1.2472284522031911, 2.489370644088826, -0.013309899548148771, -1.5615993213851351, 0.7501881621235326, -0.8929064145734712, -0.6726102028794106, 1.7117773536421383, -0.40608351982788476, 1.5994713015880393, -0.23817847660733635, 0.3544627427194392, -0.11449985900745163, -0.20355382308935002, -1.7893673068568439, 0.47195481079294466, -0.6802043235643214, 1.0060978407988137, 0.6900022182941165, -0.14608703854052393, -0.8061537068115838, -0.45123017844963453, -0.1150490850923018, 0.650750423167324, -0.27444718970429827, 0.7732657359629407, -0.0025004105719813245, 0.20462684775804912, -1.8229288035640552, 1.0366115349227234, -0.42749188718066067, 0.7147972520974698, -0.2174872453140923, -0.43508589708484596, 0.14647351960768273, -0.588879064467549, -1.3869331297092622, 0.2998973997788007, 1.4379209802112678, 0.6300477160542949, -0.9149116802432179, 2.4785133825032792, 0.8767743766103764, 0.18302778150792542, -0.5910523482398061, 0.10305797995444245, -0.47618060225753284, 2.4356598559882237, 1.4448645568811822, 0.6993437178552626, 1.0798045759373542, -1.944027620304834, -0.6127535096449422},
    {0.5534547560728907, 0.019008649676820328, 2.673677596274949, -0.21687773315378678, 0.17713992922266658, -0.7598030495916526, -1.9239431094337538, -0.9235476381918901, -0.46206420623556577, -0.8178002207642908, 0.9422968895631251, -0.7793749625573566, -1.8278996380547532, 1.6842462875236395, 0.33583149891515157, 0.519181001697612, 1.7195374321371706, 0.0024035054698291255, -0.00041988159708501217, 0.3368765122593667, -0.5939950642888746, -1.6156655846833918, 0.44177321019261684, -1.30037695579131, 0.6660374822954364, 0.30974881715574454, 0.7350784200056676, 1.7509713017809652, -1.8980991594034307, -0.12102763913080244, 0.9253518330459318, -1.3777938387292568, 1.452027684351812, 1.4651761810356574, 1.1663967950553675, 0.48025582736695, 0.9526210958682841, -0.7728378852434931, -0.28921124928851116, -0.9180505293545144, 0.1978104937420332, -1.1202402771670932, -1.1250349485058844, 0.09265682772386545, 0.3062120748390945, 0.3813847412426878, 1.6399479601305662, 1.5546929188660439, -0.4322548970002187, 0.4424564087404778, 0.2306289584031405, -0.6024670294719969, -0.8711442248902647, 0.64854256036592, -0.8279149732835109, -2.58865435167626, 0.9237567577599695, 0.8433613986098117, 0.7063904481178821, 0.914002994781873, -0.3648328716215237, 1.915865984095262, -0.9448681526689394, -0.8713415733480752},
    {1.1646092782635915, 0.7397967235264753, 1.4240655849286863, -0.10467758301284646, -0.28301486557820266, 2.740256697084325, -0.7636875592289362, -0.5034868154518068, -0.6221906660117495, -0.36740548159767006, -0.12374830169920394, -0.6136264271952939, -1.4656928056284604, -0.32806239996879, 1.6169334484225975, 0.9007384260107957, 1.1563412300435068, 0.572623508528873, 0.3679234989896823, -0.8056689701291272, -0.8484115405253659, -0.16141073717324325, -2.087687784328827, 1.3069440089005557, -0.2971726050280582, 0.45577341067669885, -2.4300800757364667, 0.6400231228273366, 1.6588581270200695, -0.5673044150790273, -0.7542487918563048, -1.2274671856111354, 0.5517260981411362, 0.4408369892386869, 1.2740900767988674, -1.8768804968960702, -0.46944737097246214, -0.12225630714401758, -0.9113516174377247, 0.7633123697355049, -1.9020212980245412, -0.5589597566772416, -0.1640021240368613, -1.5231020969521278, -1.5748924441319412, 0.9755295645855363, 0.21083453763185137, 1.4481451956860343, 0.7109276528183595, -2.2562767855311576, 1.4291962085452923, 0.5768586820742493, 0.4444803027848862, 0.9145271020339019, -1.7439417445012813, 0.24368826383148756, 0.667286378589944, -0.9797308254159753, -1.2186166621204484, -1.8042070529090672, 0.5374651435985177, 0.20031094526867513, -0.3771426326995181, -2.5073099463438697},
    {0.10528093769386195, 0.8030467354977017, 0.5514105713703981, -0.8676997855899071, 1.49449343429111, 0.6379605300503945, 0.4870902828994621, 0.7770304008505208, 1.2816917525873668, 0.7509684300405093, 0.8279621997515632, -1.4143520696059435, -0.3512147296911037, -0.03296714467014011, -0.8554593752726015, 0.1262906438379721, -0.3841182228338714, 0.7476806895701515, 1.1738822155418744, 1.5543844665595015, -0.8795740609911504, 0.8023713759841022, 0.7436244359728376, -0.895157393556253, 0.4703184178595877, -1.1892818360561292, -0.6819640982527471, 1.3944552331645188, -1.2436723988122707, 0.6552486199306515, 0.45760707644840776, -2.5648139478683833, 0.8821772657013832, 2.5170454812772225, -0.5054138869003723, 0.13416184968603545, 1.387898188861115, -1.6304522003343882, 1.2089197124203566, 1.3849117688530694, -0.6594243431650414, -0.6295116152274853, 0.25509192625147387, -0.6632288984321343, -0.2545668396941562, -1.1215706715319056, 0.045001265451077466, 1.5456019584789065, -1.0317632581357343, 0.0664145410979381, -0.1920054751123793, 0.9922994572121552, -0.49298108370322585, 1.414166067993563, 0.8547149105488838, -0.6034448634070089, 0.7448036835140118, -0.9448750715795267, 0.6227449972316434, 2.3011524344388286, -0.6219337299878599, -0.0005629742739697132, -0.06273510980449576, 0.02525231891192881},
    {-0.6948257212494701, 0.1314732706175364, 0.5273793445127504, 1.0442693333518696, -0.9072772254703866, 0.29947062743392194, -0.6186693008392095, -0.2331184491282404, 0.9007702842911172, 1.7261868455258964, 1.082163404421335, 1.458985510541289, 0.3598251569410162, -1.325007870697289, 0.22972770144783558, 0.1676649101713326, 0.10621912620148659, 0.15155945090157313, 0.5348651685724648, 1.400592265345643, 0.4783385419575272, 1.889557486874445, -0.46149191804207634, -0.3027383224973898, 0.3243962991975296, -1.418059420768177, -0.056369643820560415, -0.47218096458894865, -0.07491536245208483, 0.5817626267084633, -1.3111168872574468, -0.5051312816691343, -0.5995076547845387, 0.04051993855850835, -0.16322256325862008, 0.3943652033765282, -0.08305481727957488, -1.1791234069918477, -1.7825191152662128, 1.4345215758129721, 0.6321854458116294, 0.5348843356947498, -0.4308220386191198, 0.9568546889768175, -1.4382133461072975, -0.12715722692276135, 0.9040556667260391, -0.7629512930499587, -1.324908799897031, 0.3849274602176845, 0.10101030816336505, 0.8121768518791188, -2.9665190897800557, -0.11180860177664781, -0.7788150240168981, -0.1689040053333426, 0.9341883718150524, -0.5724703347823155, 0.41578528910418866, 0.7891174157977761, 0.5627509195975331, -0.7803761245144988, 0.23752901067617013, -0.50997630890893},
    {0.2874296908220824, -1.609109899069262, -0.14957710010913533, 0.07450667454130432, 0.8773969896429545, -0.7047779497641034, 0.8040210208649714, 1.1062021840229077, 0.8005727748692135, -0.4954149974900453, 0.4570815185914381, 1.1122352598297627, -1.6393017070382825, 0.787555955835874, -1.0958618580190063, -0.39845952384969097, 0.10919187301774871, -0.382549489740864, 0.6416610368352428, -2.011280603369004, -0.28311698739751257, -1.1806759347785178, -1.0346102732561675, -0.3233889073248762, -0.02120462873862739, 1.206558476550697, 0.947810116568517, -0.27060310807668186, -0.11870003902144845, -1.3807446821600378, -1.292952121883216, -0.7503505866486792, -0.477169104536917, -0.34001843504822027, 0.1359891724890459, -0.5222732395744728, -0.307290745792945, -0.20924109470525187, -2.2426645231487696, -0.033859982151630386, -0.08184237688291815, 0.4798229819320599, -1.2766471012018485, 0.7105664994841004, 0.28561329380227624, 1.3697586746464308, 1.0633748159832759, 1.729563258001825, 0.5179458869051078, -0.738860427968094, 1.006758150943705, -0.3151841265301215, 0.4040999643131648, 0.5285586710952718, 0.5364626021192122, -0.8088779391247516, 1.2419907969729937, 0.356758755576256, 0.9678211695016526, 2.225467557116147, 0.46955161945399126, 0.05558198744872486, -0.7364612383790272, 0.5479264589934022},
    {1.2555224783231924, -0.2835657514218672, 1.2456446719570402, -2.2443439153857025, 0.4529235581543489, -1.4369850518381853, 0.7267983233341281, -1.0309840724960162, -1.7858041364969652, -1.2177933650480681, -0.2819114577541121, 0.0896533551808749, -1.3841722180569442, 0.5270607196385335, 0.17879871615680212, 1.0139734409321983, 1.9461080216576643, 0.3760238618745513, 0.43754689474993086, -0.6295937187112399, -0.288865578666822, -0.9943648005681065, 1.6009493127280408, 1.7719165672800397, 0.6106280793708286, -1.0081117837472755, 0.6126456211363904, -0.5587995894357838, -0.30948416146042623, 0.06145100327524928, 1.0240106662067197, 0.07503390553398116, -0.3048773392254321, -1.0919234816924834, -0.01321583999010222, 0.5728781452375552, -0.18929433224541375, 0.758411664659809, -1.0820206658466476, 0.5115983246963525, 0.33082637295593054, -2.434770586880407, -0.6595806498655831, -0.26944456570338765, -1.892712991112766, -0.624791271666109, 0.7409732102272626, -1.0030196442311132, -2.8238076854697804, -0.7698357224061566, 1.3970007338772528, 1.415575392783724, 1.072730651457296, -0.3779251218114697, 1.3029813584853083, -0.960545309861493, -0.10151415484490998, -0.06573062825191689, -0.008758982888742101, 0.6456253195734509, 0.18098386814681136, -1.4473822741087077, -0.371352693615082, 1.5908601020353679},
    {0.43531265581026923, -0.4159862482606452, 1.954886933845462, 0.47058225184571084, 1.3079565526359729, -0.34719811249412075, 0.3493665197717225, 0.2128967125751242, 0.5908965049472243, -0.7875066969634146, -0.4702691251099595, 1.2110204737762504, 0.6084791463212178, -1.432973025858984, -0.5102715401001517, -0.2565745746642844, -1.359338615894329, 0.2927988598504747, 1.6880680135820012, 0.026473476029686308, -1.5472285364015357, -0.07327852346784294, 0.3469866932247906, -0.7875363249472126, 1.2450055067655752, -0.15789157778277624, -0.5209852697952017, 1.347470721662361, 0.28453105366645043, 0.019951044347588143, 0.14373915631028505, -0.00195788377646053, -0.2540869878866787, 0.13386866405346326, -1.408237165651583, 0.26784058290682994, -0.36623707547736706, -0.920375538413278, -0.4490146716341093, -0.14960954411202942, 0.8824738803918194, -1.8553865897812132, 0.24831524019208176, -0.36693603333326225, -0.09453350750008288, -0.07789838385594397, -1.4178544148163992, -0.38997495207312155, 2.2056944522401345, -0.5734796421193925, 1.3505756879862125, -1.3741287230018828, -0.9084788578657672, 1.139906818598476, -0.12872587997074328, 0.4082710332746947, -0.3169508167945738, -1.6314796822023039, 0.519042909703691, -0.7147427429026977, -0.7695591202448238, -0.8311461671276397, 1.8995863062999898, -0.7626201738977028},
    {0.2112739433535063, -0.6074417829803165, 1.1484702760393817, 0.8255933192774563, 0.6262025493888778, 0.31297244197879326, -1.1802887711001704, -1.8712012107312477, 0.7965072280639934, -0.44165069094082654, -1.1824640976439615, -0.8761433179021528, 1.4544503106229225, -0.43778103548377856, -1.547224776109558, 0.05862087481044213, -2.426351186197909, -0.9078326454055847, 0.2530316870960145, -0.34399153168475227, 0.6930305398887815, 0.6388717306002413, 0.5212855780354716, 1.4648682896364293, 0.8692886226102114, -1.2353995364319272, -0.043311664019447194, -0.4404267055328081, -0.17337205383305906, 2.0311571904912804, 0.5860208425087147, -1.4490360721132243, -2.296750201590524, 1.164359030122762, -0.8226631717138089, 1.2279496766401037, -1.3278697199524556, -0.20075139183274862, -0.9186375205451704, -0.8550604429066782, -1.017983888201384, -0.7464800968001676, 1.1790417214599407, -0.7075100501936745, -1.517974065822815, -0.5943247900193583, -1.664695181630207, -1.8951323764958405, 0.02773505729984604, 0.8293340191614557, -1.3212191194724716, 1.3295963742138788, -1.0967531190867765, -1.5147181904879528, 0.012741768566488247, 1.1935323527359791, -2.2527107881294746, -0.32143607709620975, -1.2417498974239218, 0.5210573710654567, 0.8623034882297793, 0.6622970400086448, 0.9611708141155596, 0.7283787479044586},
    {-0.30202279910768715, 1.986601385005785, -0.17380150367916333, -0.10928881686633558, 1.0889586132675715, 0.23576046100300288, 0.22105517025812144, -0.5587808255485862, 0.3839578670192797, -0.35086011160175273, -2.956190479573801, -0.4970538928725383, 2.252517005209599, 1.6557572207136504, 1.3679667475567445, 1.0682596693258026, -0.934451920378296, 0.8973908080407765, -0.5961644363392885, -0.33538381597683786, 0.13550310951665082, 1.5597403789340285, 0.5816080971697466, 0.2965551466727445, 0.7750262877294432, -0.002577606746081717, 0.25496012933218765, 1.4478074373562027, -0.9859902016930819, -0.2532351497395433, -0.4058290924308683, -0.6598459797405193, -0.8298431280949574, 0.610735885900546, 1.0157366200985465, 1.3911952670057104, 1.9114619413788798, 0.12755776388352952, -0.5861868691957582, 0.20134804071388732, 1.1754824763039218, -1.298511675613877, -1.2923068177319939, -0.9760222474223448, 1.4745561730972772, -0.7291382321690532, 0.09117242288189725, 1.8120986033373916, -1.2749638422254836, 0.4266949563594005, 0.34931927847234023, -0.49813561481139695, 1.02094861942624, -0.33872817502805175, -1.3601763165936491, -1.1861619651866189, -1.8082988711512886, -0.42851770827096236, -0.5187860424517212, 1.0949404105722025, -1.5773258269497625, -1.6795096781901584, -0.6284172329741621, -0.16306077087918058},
    {1.5986974496303812, 1.6594016077389955, 2.7649675910170664, -2.893558744592967, 0.4937867900825086, 0.7894895360003388, -1.8096863220714312, 1.5185092167108885, 1.4713428490161722, -0.6311758696858792, -0.724713067993987, 0.532809583172394, -1.3009220305583997, -1.2889257540205488, 1.061023466375784, 1.2131684663346878, 0.510942292259387, 0.18063639394341996, 2.3835087570031654, -0.579586319451796, 0.21170142830047617, -1.5897356189968723, 0.512928215401445, 0.015084084846995732, 0.3847125293708162, -1.3839547371104668, 0.256377799262408, 1.2835211036130358, 1.098528505866759, -0.6893847125467588, 0.5249397715946149, 0.2663185828269444, -0.24886118792308076, 0.17646936792639153, 1.3775666263747521, 0.07658033830365385, 0.6591431352276825, 0.1573342482790531, 0.08419297268211871, -0.22405151526161607, -1.813323190947151, -0.5473949106521508, 0.3938002180324373, 0.02519628156588763, -1.4823789231123021, -0.13896247161006128, 0.7106658410787755, -0.4939942995695609, -1.169847246442136, -0.6756986043424362, -0.36601491079680964, 0.0674419916399854, -0.252096803974283, -1.2532795418450882, -0.875488843230144, 0.24442089567435732, 0.34295139010004444, -0.0018758601044116413, -0.7320011760643753, -0.511034494421664, -0.15010255070600897, 0.07984183255103001, -0.9351856360515476, -0.06177017456871439},
    {-0.30009390569464295, -0.4071155779739907, -0.862561107794237, -1.3229472834437468, 1.3192597871661647, 0.33710977056884645, -0.5545371179120645, 1.701092498566786, 0.6056182592687505, -0.2856753569515156, 1.1875258039324939, 0.20756822582144516, -1.1789424056171145, -1.721887947144187, 0.944560920436538, 0.6111949760354827, 0.4852212409472328, 0.2948410320686704, -1.8952097131187342, 0.06108978299516857, 0.6983911354084055, 1.1286126532688239, -0.8449388158582241, -1.2722553848348015, -0.9659067599933144, -0.6732787637813815, -0.6816384866518648, -0.5034888406739674, 0.7386281362011006, 0.00961678682048526, -0.5779002083279634, -0.4201238188733484, -1.7873089656540657, -1.0526195138906045, -0.6599637951259053, 0.16815208991275282, -0.5480732624620565, -0.09095947211448027, -0.07214015467126941, -0.8652142145495436, 1.8134052254321218, 0.11009998388174365, 1.8890753169565053, -0.529730787067011, 0.5009251392347776, 0.40975597694250265, -0.020185890350867416, 1.4834863521493293, 0.21713195489079903, -1.2878464871081758, -0.1901328846782733, -0.7465590737719031, 0.7512982769897611, -0.8976521801890659, 1.0953521662481935, -1.7236485523939957, -0.8301658677121672, 0.23205939977476592, 0.5858033334226268, 0.2866216769828158, 0.30563488598076055, -0.6603182595533598, 0.9582480844814182, 1.0595252657973728},
    {-0.15239668011881824, -1.4864941605101931, 0.12210173590444416, -0.2101300703403544, -1.3161121732151329, -0.6286701444803281, 0.638748809618537, -0.5321862314182457, 1.7884784846603319, 0.9028068979468988, -0.26474927968082246, -0.6316562504685662, -1.4021223867777548, 0.5564174539980475, -2.456424481315803, 0.8594809670362458, 0.25313889577648024, 1.0728777473034672, 1.2324524003131976, 0.213839702973944, -0.3911096152056616, -0.5933529287082155, -0.8806131938571368, 1.3918045559833312, -1.3122165462173003, 0.08120334004384817, 0.24505936702495953, 1.594292276167904, 0.03127028808274695, 1.0008827698539977, -2.1064777725402895, 0.13467094373770225, 0.022717010199769436, 0.42791767404261744, -0.22233848777765863, 1.54270746775857, -0.14334885559920674, 1.1165601523740947, -0.5126687317214987, -0.09648244009364722, -0.24736017075624722, -0.5061057461993139, 0.282641939448423, 0.9437809673345635, -1.4432489813031988, -2.741876530746866, 1.0418101823497696, -1.0013814810802413, 0.7022940457094976, 0.7065169758116928, -0.2183021066717122, 0.7652218148742547, 0.5606146246463934, 0.5303863053438621, -0.43053115956181076, 1.4044588843121295, 0.3130082220973489, -0.4091793920291395, 0.6959887279729732, 1.652327984788616, 0.10490135045126048, -0.9967174916919855, -0.1677942875188012, -0.023965603210360124},
    {-0.6385560206154937, 0.4265224823736058, 1.676650344227045, -1.4209880951694192, 1.156945718808458, 0.09026632690087016, -0.23542625454381136, 0.9812720915643194, 0.58312265948444, 1.0784381251848776, 0.7642503715355405, 0.5829767829186605, 0.1599284056443224, -0.5895764307845694, 1.3738448036050053, 0.37740360662380773, -2.624999818051703, 0.8834664339762407, -0.9339765405765126, 1.248764890933706, 0.9792576177986405, 0.8565170509244854, -1.2530345564579015, 0.02467567665564536, -1.0768209923305083, -0.1497477409126398, 0.6586667163571569, -0.11523513817712627, 1.0840271777211408, -0.9283275409961829, 0.1476615262484705, -2.5257510642379133, -0.18525454798331228, 0.6792918403287737, 1.0535913357137452, -1.4603308621422695, -1.2141787713089265, -0.592216859469246, 0.2710075211630666, 0.5218247039956856, -0.03882488297538804, -1.3420401348216087, -1.9098906600337966, 1.3943259173499758, 0.4243398137449866, -1.46512447849385, 0.2958037853732606, 0.22969177302863836, 1.0563216341286004, -0.8557283600362866, -0.2263304320694744, -0.9699972248012118, 1.0754504173030195, 1.580303228209484, -1.587921237020726, 1.4674169146183231, -2.0154668377997407, -0.15899646067466439, -1.2603230786275066, -0.7703107893356015, 1.0889899864809578, -1.3229562120181397, -0.2684484405479676, 0.24144522819657327},
    {0.09961923727475135, -0.013257899663842134, -1.1295061467241274, -1.0916367333660915, -0.5077927125736962, 0.466410591892899, -0.6618219071607879, -0.2982623569611126, -1.199838001399009, 0.6603183020086715, 0.3421902909968389, -0.4204360448821417, -0.5219550938495712, 1.3556840556418426, -0.5157186970816229, -0.13213650714611183, -2.1151620292260453, -0.15753708071497904, -0.6591990425020694, -2.3607749682661137, 0.2016034170296008, -0.6672491559205365, -0.674634594865555, 2.717131730829158, 0.560656431525505, -0.1365448675003106, -0.32242117590542985, 1.2750008118355152, -1.1121751662947745, -0.35784550102585094, -0.5606911216029079, -1.193447844655224, 0.5708595376367201, -0.7931819353614332, -0.5042395233524269, 1.4923739239206562, 0.03245257622517731, -0.6401931478645672, 1.5421294867566961, 0.5583687538197218, 0.2982998898317066, -0.6150945979879993, -1.4353553366270921, 0.23355894925855308, -2.2863471453162223, 0.6743456546305322, 0.05022190034380293, -0.9898941783744142, 1.622464959980181, -0.3437678240777974, -2.4303708765973404, -0.4448049846752229, -0.9482246326839411, -2.612992161046547, 0.813478048524884, 0.4719052074708874, -0.5385000756827177, 0.9193367041008923, 0.8047650885249188, -0.3671553598584506, -1.491164495015113, 0.6632265124756377, 0.7057816186829103, 1.6135243672549615},
    {-0.8866535975475371, -0.40110095149104674, 0.29727206387575816, -1.1794863186375608, 0.364670211412876, -1.0407382026911138, 0.4640031012941289, 0.07570087481402187, 0.813327964181469, -1.0414979851650064, 0.39690102061570715, -0.8602125779667286, -1.1651868972920911, 0.16656986346279737, 0.21793319293274818, -0.1366305165673202, -1.1161165861691573, -0.4012914931662586, -0.24211821946296708, 1.0658353871204116, -0.005534914492289993, 0.654244890204727, -1.3747930913775672, 1.2899397141232418, 0.26045020186102275, -0.9685532966770051, -1.3493541541667056, 0.7085546343957236, 0.9769099371414727, 1.0931121471882064, -0.9226178891664762, -1.2199995663726202, -0.6656702100746622, 1.1143987283765118, 0.21285823626491454, 0.9575916775914536, 0.8523509759603449, 0.716813468824324, -1.7415449120435216, 1.047624249005567, 0.04535132665644019, 0.894127365765243, 0.9052902595944363, -0.2836604013971, 0.06352671674564575, 0.7213063243773083, 1.0147343271843765, -0.9296551422130368, -0.5904452253698316, -0.49728204883178684, 0.005009975241715652, 1.3628778789338303, 1.0338973194995091, 1.3622116984428658, -0.42308852759296334, 1.1659651865450738, 1.426590376443825, -0.9251352040772225, 0.3874588113689033, 0.026958419719803742, 0.31147256991813954, -0.6420013399484857, 1.7017677961967042, -0.5830788937305053},
    {-1.9053559501482902, -0.0273843039797311, -0.7867709275806137, 0.022674145030958923, -0.1150656000181035, -1.072923989298144, -0.33687544783920736, 0.6706091662628597, 0.6333822523965745, -0.8549090068212652, 0.3960200915229682, 1.3900917427089334, -0.17296699078437439, -0.05032911204771619, 0.21891975613898207, 0.7029571700054841, 1.072707089571748, -1.2280923191669495, -0.3703033839049062, -0.7789303322670744, 1.2695394807839144, -0.446713298382932, -0.2582680406365325, 0.29932845486906134, -0.666218769012615, 0.529862798137772, -1.4448486466254238, 1.3044342501062394, 2.270734481050126, 1.2397504266002994, 0.4744687325034474, 0.23195882653097993, -0.5168099657291378, 0.48458257724278875, -0.3123343945610295, -0.9556679296779477, -0.9431488492903055, -1.4343353832637995, -0.20550776619614552, 1.136399194060459, -2.3285855024163653, -1.0102720567113421, 0.7973199671000488, -0.8770443585321551, -1.8216935646619408, -0.704823924105938, -0.2586442218992009, -0.8034879000904955, 0.642077180896376, -0.07197803697809223, -0.7385213681636242, -0.03220101211878587, -0.24629674687195927, -0.9828812798612193, 0.2991307500388949, -0.526243523641643, -1.1656819274938133, 0.8036650337998706, 1.1031974647020888, -0.5872988453885639, 1.1805246488059775, 0.7937784254103953, 0.3777388377789172, -0.9688607879310658},
    {-0.2417475646053819, -0.9364026830444551, -0.5835160153210428, 1.9138407642041608, -1.4098990922562034, 0.7920486345095812, 0.9341024650916337, -0.23658949450636743, -0.16556856806982218, -0.6238484518778368, -0.3260003170178228, 2.06057477453536, -0.4497799003144438, 0.47168243340748556, 0.5465398197021968, 0.5129779460000478, -1.3060735541120658, -1.2269634584021067, -0.29239612033996754, -1.8168626996473667, -0.44553317005406307, 0.23761015482995215, -0.23228559523769443, -1.3975371768302436, -0.11971606023492953, 0.17838001444649448, -0.3360460771807411, -0.804778883177096, -1.4183287591839597, 0.7414897265702519, 0.45971167185921197, -1.4972072565072565, -0.15472902836775132, 1.0321325818743008, 0.44287464843074636, -0.5123025851417543, -0.10187909208358231, 0.38940076945295143, -0.5373919188547256, -0.9075177461922632, -0.9018418510089458, -2.251416626650301, -0.7162059411803466, -0.9990987035053102, -0.892856806934173, -0.2628226896236336, 1.4079783622528865, 0.49977144232737286, 1.2529882810065565, -1.4812271053169772, 2.5112361427097585, 1.2732963377851363, 0.6729943095195128, -1.2182416716051279, 0.3107569392138687, 0.9884424138902106, 2.2515103124575226, 1.4597938875315324, -0.1852415146064568, -0.6222852366530486, -0.1985946769418371, -0.0611112003273118, -0.9355572999844344, 0.3167953983376246},
    {0.8235258890622941, 1.3560202598836926, -0.2182639590367105, 0.9559689976190735, 0.758001292731285, 1.0363593063367966, 1.0984155171465506, -1.462899823213629, -0.7309083068348667, 1.6216007036054774, 1.037484560920072, -0.24152806314618913, 0.39201590924785396, 0.8970884550156822, -1.1132871698892353, 0.740820278860132, 0.37888556256001715, -0.26794827014278244, -0.02144376389805035, -0.9863353456822832, -0.8652335235388852, -0.0004568119396130952, 1.1556678072284856, -0.013215538956159519, 1.0223206534619433, 0.6768938272936736, 0.07305133698078718, -0.2609441891170694, -1.3963187953480025, -0.09416227167720466, 0.35117803178501705, -0.9401533305450849, 1.6282547990743619, 1.7668815733435743, -0.7245870613458638, -0.4199990975922697, -1.1553679758631872, 0.7687986429775358, 0.8033711459760566, -0.13328104635604182, -0.7568694416225193, -0.5582116845877793, -0.0001613279788308249, -1.2296631857039877, 1.1460103168662945, -0.3205800445217204, 1.2527650881918482, -0.26440544929744814, 0.6345735020363744, -1.2268386006159326, -0.5198420445727816, 1.2163189950760205, -0.6722710350588108, -0.5990949733548014, -0.05166951454942051, 1.320423929184433, -1.326324820497954, -0.20285240159542917, -1.471503497774358, -0.22348637912712252, 0.4574299989080883, 0.990288872750393, -1.2022671449118771, 0.5084445293997449},
    {-3.099500004324399, -0.042405416044256114, 0.14147856515453475, -0.6317623708965695, -0.5157272945861889, -1.2628882902559853, -0.42970945871674426, 0.06999288273637189, 0.23566152097699725, 2.2435639891387233, -0.4006982895877495, -0.7129810114420105, 1.1561753267370407, -0.19021309375570544, 0.3300032718556003, -0.9861715363086154, -1.0671634933999825, -0.17353819073221988, 1.0610462720892857, -0.3988338379877643, -0.9812212037780809, 0.44726255670609194, -1.8640026049341378, -0.07879279430425411, -0.06821277167082342, 0.19393215367916572, 0.9746882526359939, 1.2026659780688251, -1.1657699983229204, -1.52628841270756, -0.3402253176670154, -0.15259663529322473, 0.6091950609918673, -0.9075974133551613, 0.4571398932368196, 0.8566941212427609, -0.11765611443168829, 0.1913471782524527, -0.05953137132568977, -0.954249449403877, -2.6506867147781152, -1.163327623681954, 0.3596525778244349, -1.3521955401407748, -0.530229741990998, -0.16377682213063469, 1.4964320796858743, 0.702916239030238, 1.4786592437207189, 1.3791849622644725, -0.9383402016654294, -1.41503320500676, 0.2251544721036797, 0.45796104128458504, -0.5645656399215659, -0.7358177615610175, 1.7859815386855236, -1.31957866361567, 0.4033199448611762, -0.15326853145371566, -1.714842513868775, -0.1312556893683051, -0.028037522348899453, 0.4687595815538058},
    {-0.7961773966641291, -0.1842681018452755, 1.6225290307574511, -0.6749532403514632, -0.8414935082618432, 0.7050932445382043, 0.13593832194597577, 0.8481666936599052, 0.5297463680424866, -0.8739123319282448, -0.8105528872439983, 0.9354886743820761, -1.8688269510421796, -0.9847893245559897, 1.472553597565353, 0.7199572522888927, -1.447519382737438, -1.4262940690344281, 1.0128347980725023, 1.0419305541065949, -0.6726998330842896, 0.6423856948546617, 0.7175347844020431, -1.3913559450090895, 0.7912505186661957, -0.3219338007431477, -1.5401566658717407, 0.7268763574634329, -1.8858405109284573, -0.23906999451401512, 1.5763779954709096, -0.8283739422979189, -0.945019550291021, 0.22948021731020918, 2.073861258627746, -0.34531106900922226, -0.6485246822446261, -1.0392824985482298, 1.1386073664211311, 0.9220563933270715, 0.5211490667421789, -1.3772329492308388, 0.2334002401695658, -1.517425100313541, -0.005258177958712028, 0.9334174250452155, 1.9140190879158745, -0.1265082988478801, 1.7280095043338108, 1.2208529356574822, -0.0443164381121016, -0.3880227198723491, 0.8331277944422311, -0.44702281437138774, -1.1228716885371661, 1.1258213171123863, -0.03377579179416, -0.41657973889300554, -0.609765399561884, -1.014505285217098, -0.7298088736598185, 0.8882672137586857, -0.04666439851574332, -0.11277584992142228},
    {-0.655250728246207, 2.220845072035248, 0.09216345080913799, 0.06206644461070448, -0.05233856951161849, -0.8144820974947942, 1.691429671896182, -1.0317547259930326, 0.1462160063812651, 0.5307670816300997, -0.47407462745507634, -0.07111477078485338, -0.39924240495740476, -0.2443330184748858, 1.4243913985548162, -1.2386908113266708, 1.3452658563065338, 1.6757433638034969, 0.7956722921260387, 0.6723172051790314, 0.5481532840328147, 2.415982573951963, -1.918481257344002, 1.5611484879342803, -0.8212583955425728, -1.1582487742242331, 1.0215939002129169, -0.4541859027226467, 0.3618958439638016, -0.8696866014049083, 0.1307909073493812, -1.469040423158296, -0.33186300253373835, 0.9070252362602491, 0.24285317346877067, 0.1301100673141839, -0.32027647634884865, -0.721193666437941, 2.006051644140235, 1.6429940925613222, 0.04804082309721554, 1.0275406849879845, 2.451538982321006, 0.5222663362129456, -0.9613018495640866, 0.3601252017724488, 0.8083463973899281, -0.20329811660426023, -0.4310699003029756, 0.6821204387958697, 0.03797702324818889, -1.4591406583360744, -1.4311167315348816, -0.14499885521586325, 0.20945625994799494, -0.23420544715060615, -1.372150955600359, -0.6902016385024857, 0.6567485476309312, -1.2079433034067932, 0.7485061280626207, 0.5956377291914582, -0.0650188218656289, -0.000678363822347282},
    {-0.8677828895259152, 0.19480266556592543, 1.7538635740798496, -1.2836554515874692, -0.6708481937348424, 1.6556109056646129, -0.5227430012855176, -0.28270968490618964, 0.9301113681284724, 0.24349141483040698, 0.09592480481082559, -0.15949015720596496, -0.028818463000219723, -2.1484496769086543, -2.378933834324269, 2.2122604212420582, -0.6490488835171938, -0.9120512969312754, 0.25806588401896396, 0.1225303283593883, 0.36280550776242004, 0.560932634659566, 0.31934349908495663, 0.12058803060498376, 0.12968782852618604, 1.466072978108099, -0.2233050418945677, -0.39245292813062677, -0.1212470221864714, -1.9348089125509689, -0.9047470785810386, 2.558451465587683, 0.09960698605003639, -0.8541908156661909, -0.22474044762552325, -1.9077225995979987, 0.039655168936704455, -0.007751149729526313, -0.035687180424573285, -1.8839216494202293, 0.7433482972665415, 1.2063741295185868, -0.6092956027443159, -0.5625439453995892, -1.5854243058087214, -0.22637132618117675, 1.7022199412630732, 1.090714264759661, -0.43014407033976937, 0.8859699519667992, -2.4033947574094845, 0.5583924078672883, 0.5599057016494333, -0.5267431371172303, 0.5009148524660579, 1.7446783881380417, 0.8001312351574069, 1.5335937681205307, 0.3575649655148278, 1.1110842554772586, 1.2619634903970385, 0.696131946615853, -0.18656642510540666, 0.625744871373479},
    {-0.7624912618570906, 0.677379241834949, 0.1549352539237427, -1.635197224979181, -0.2804525248827583, 0.949661916275842, -1.1996334515394464, 0.6336035290990384, 0.8855215198175541, -0.39279949466235303, 0.4059608003518194, -0.27022350526464956, -1.2435418122551363, 2.1653983152476917, -0.13007970562929533, 0.9758213377745231, -0.6907994671803894, -1.2679757175427127, 0.747944853570033, 0.36263659334791193, 1.7512207399687783, -0.4903544812661696, -0.5197482318597585, -0.9630819893579284, -0.7860651121488099, -2.2084913162407394, 0.3308106742012281, 0.6039848027673703, -0.4830627709177628, -2.1777235649057065, -0.04194306157372652, -1.0508822689149593, 1.0473944595513727, -0.5542524955059329, -0.23770898414674985, 1.1160693649130022, -2.0126391448174727, -0.4319305092494556, -1.8553805964236847, 1.0891965058614583, 0.00684346175563139, -0.5312016463052558, 0.7493813907141702, 1.334799306089566, -0.09105186469850297, 1.1604505208344051, 1.805030680465375, -0.06169787617044621, 0.8161071754564991, -0.8449875580974717, 0.39337429226949017, -1.4771301503492018, 2.504852603992482, 0.13305089752795182, -0.16615438842672514, 1.438425312848641, 1.4314022380506257, -1.2449064957135563, -1.8598752391961721, 0.13836458109190675, -0.48642629309100277, 1.0844797494736065, -0.6976797889750773, -1.1704092599369205},
    {-0.8593805082103199, -0.4740723587847487, 1.7721659629441306, -0.641190719927574, 0.9267618437119909, 0.3802141574691393, 0.005145982262023334, 0.798969503251323, 0.26709877692027617, -0.0890872426852339, -0.3484669674563032, -0.6565784320291198, -0.7140801827721351, -1.5942073905339593, 1.5366971395446412, 0.4522094593022589, 0.731702697836373, -1.0265500920852613, -0.1543794710408622, -1.2353683632666268, 0.16619136657680494, 0.39128224302069936, -1.3042195345709846, -0.2936774068266021, -0.7554052115255977, -1.2913707972970918, -0.546325967663015, -0.016280384323909804, 1.224919252698169, -0.40977281123967896, 0.10377598619005367, 0.964316230308171, 1.0287616419847694, 1.6455452987715307, -0.7237054523094072, -0.5766761515416038, -1.3097328832216928, 0.21718702047033792, 1.6339340334024286, -1.450308446388469, -2.100024617432013, 1.3469901950150116, -0.31152251086913724, 0.5049012390075021, -1.2804684229935677, 1.3602581361449704, 1.7484793492156638, -1.5890039346017537, -0.29544290431354464, 0.13358690427062977, 1.4692273108325897, 2.286315850568808, -0.16774275566055794, 0.9529350336014003, -1.1976858673024227, 0.7924124811234464, 0.8571137141453716, -0.10150322175649351, 0.9047519371659842, -0.5142362989429712, -0.5557874493732061, 1.417553987990412, -1.3028400782817806, 0.8232969654793172},
    {0.15464109937045742, 1.7398397798335516, -1.464556022989674, 1.1414503473982078, 0.5981275818385702, 1.0983001331491187, -0.28945914803624434, 0.6833936427350824, 1.3132655055232232, 0.9273924908167257, -0.6807370731226622, 0.07717735379185153, 0.8474249331178317, 0.6390804835720916, -0.3558544081067431, -1.550303850029014, 1.2442305243812275, -1.3795662325786158, -1.0398103761172828, -0.6729449260995971, -1.038310694416391, 2.027635909554223, -1.539747743317942, 1.8360506191472343, 0.8467845528804547, -0.39161509018784874, -0.983112344281036, 0.720862121306887, -0.9781170118565824, -0.30580043058179823, 0.9778966585862677, -1.3318289436136768, -0.30323036310170226, 0.9925121662917517, 1.0117510459849626, 0.8329006147460752, 1.0904205897700479, 2.1743434215599717, -0.8081666994790745, 1.3157764170173298, -0.44210733654479545, 1.63916450102665, 0.5417998831105691, -1.3772508917788666, 0.17179986884439324, 1.8977451219067543, 1.4407071420090836, -0.30129652622867775, -1.3990448709833108, -1.4658648877171927, 0.7494566509447526, 0.1695928765248131, -0.058818950177595405, 1.24925520480591, 0.325702934955727, -1.2156578644414946, -2.147304537198349, 0.92898161068885, -1.03116169830501, 0.994457229776059, 2.29952360841663, -0.4883930915777659, 1.2935997737185365, 2.390372774278885},
    {0.6243728728077412, 0.2795207059245032, -0.3762888518338354, 0.32579458915576526, 0.035816304163069315, -0.4624085375262136, 0.6180816585788405, 0.04471942503722504, -0.7197682496408776, 0.02093327780672218, -0.018139404982838784, -0.34016367291977145, 1.129560098727752, 0.07796098447299366, 0.07253402608087237, -0.18592732585596616, -0.34543290727718134, -0.383415645013907, -0.90064819739969, 1.406292195689049, 0.03238912756662384, -0.8175554548248516, 0.3041711682728067, 0.40418829243284327, 0.1408546534378465, 1.2649043014768768, 1.4114232903845125, 0.5865577995275384, -1.5711066726133327, -1.2749002108667027, 0.8571022746951726, -1.7835485257596857, -1.8922352943844147, 0.01223608087878983, -0.2132222171993163, 0.6988472219316617, -0.5877151464117527, -0.1923265976458733, 0.5455429475768151, -0.5661019718576646, -0.6316118587537575, -0.5077330562165563, 1.9591233649574131, -1.7418360503534827, 0.5249280225141497, -0.6330480935814335, -1.0379717225218765, 0.46217768834089556, 0.6674054805505134, -0.5604878102646752, -2.015026925434086, 0.3374348750337273, 1.5295257449662152, 0.07213290042691198, -0.6530530781879496, 0.38409107625739153, 0.7462697325572075, 0.2052494242425281, -0.38481176306084763, 0.6348325879116303, 0.6666647358394708, 0.871687030874653, 0.0461453614728057, 0.1746156850557903},
    {-0.37870964141184243, 1.0520523121112544, -1.1014732009003507, -1.1101400431100916, 0.2511531644759237, -0.5479585691365493, -0.6195512785303559, -0.5756689092204081, 1.0369516329178508, -0.42997642983770534, -0.10937101064907824, -1.4251302469699751, -1.379810571432861, 0.45522917648079403, -1.6244737499146018, 1.328170004732156, -0.58693916237397, -0.7641360898558736, -0.2930929719311884, 1.8746191433554147, -1.4711047540783766, -0.37306413440352176, 0.8194292258914087, 1.8703084521006381, 1.5340230464351514, -1.146161450832674, 0.39855436919581666, -0.10990667281283364, -0.06915465543049709, 1.8648861911947072, -1.5400061220014174, -1.8242090722790532, 0.6164593269586679, -1.3204170572929763, 1.4936394899057663, -2.564875133266276, -0.25729450841638335, -0.644510216492499, 0.14754901498019046, -0.6034386737867689, -0.039319233636804944, 0.3330241511508958, -0.2844301289993996, -0.29052868726917863, 1.1391507703318935, 0.9984595788447597, 0.4606674866998575, -0.8817965428592489, 1.939426710930019, -0.6130355040112581, 0.14379990710531468, -0.06268329543589937, -0.23081888393094377, -1.1367063295517412, 0.014409325111727673, 0.2764371158585097, -1.5622526692977339, 0.17229163605225326, 0.05450665575661273, -0.006301402792702684, 2.2345895046734023, 0.19609903387807512, -0.0822458107629807, 1.5660644534338741},
    {-0.8341815166374239, 0.5408589684120948, -0.7486509458419044, -1.2763600099976324, -0.5573348388998295, -0.06772590106211024, 0.6486357445022611, 0.8484910831486023, 0.09187539233192252, -0.16123790955131354, 0.46519358121945414, -0.01492918860553517, -0.2623073483133684, 1.2610832873785, -0.9483272534529603, 1.0679819791980663, -0.10175582044479854, 0.09229915198108675, 0.2079708190232161, 0.9736643536380893, -0.23662069559715734, 0.522811760255946, -1.1414948793265254, -0.1811915889635075, -0.6900503870620196, 0.8707866915700069, 0.5159088911309492, 0.4722219559599649, -0.028152522904284567, -2.792433209091481, 0.28701088207610675, -1.514279058303587, 0.20334815543985857, 0.15482009170765929, 0.4243944944041802, 0.6746200008461258, -1.462158514099874, -0.3358862049866552, -1.5121539690212866, 0.48195277228175565, 0.9420924489175381, 0.442619682197048, -1.1558077105306686, 0.013240148078845717, -0.7119894713942512, -0.6838481966963487, -1.2677275369745118, 0.292334718791989, 0.6170787303049282, 0.058024228657873926, 0.48894930494896377, 0.32331456641096773, 1.5268243660294365, -1.2813209258327054, -0.16466029689272751, -0.15138116938938548, -0.6256688322893327, -0.1954776467573146, 0.3538860101542914, -1.1382918667496038, 0.5760728816699229, -0.8212636154453669, 0.5121176484980152, 1.4341436342638165},
    {-1.1403705884244928, 1.1789131187102821, -0.5097036091291869, 0.9152954596147423, 0.5389530569531034, 1.441341900361121, 0.0665323184167958, 0.727151932221784, -1.1228790242577276, 1.1610583400869323, -2.1445991672605027, -0.11656593063670069, -0.1859399370276799, -0.3195884386204972, -0.3770030501639855, 2.071476605080969, -0.5320061132159521, -0.16778145669964725, 0.4195213346335856, 3.0064266299660436, 0.1789198003836887, -0.9413317115359743, -2.3263315487839504, 0.1309902496845752, 0.9191998442578672, -2.04666188981624, 0.8778483312019705, 0.39567717697182675, -0.5834460397478659, 0.545692085685305, 2.3662409948065237, -0.22899722170227088, 0.08499158510284688, -0.37814900724653067, 0.4421537986872574, 0.1082883955349859, 0.6426507023096002, 1.9168184576475966, 0.723971442947723, -0.17575174960158857, 1.0996265923045212, 0.3237991963582782, 0.3537720876602217, -0.6570127608172608, 1.6682848708973808, 1.1252635558646307, -1.2066616940515422, -2.5666349662234818, 0.5712017525806675, 0.29984302577179867, 1.3817565550413167, 0.46721859958794376, -0.06355489988226172, 1.539649131395159, -0.030904423584826844, -0.9360668720859113, 0.40033598562372097, -0.2400574833432692, -0.05192964893525731, 0.2747422249665761, 0.21676722071800572, -0.562167421800841, -0.4559901448813418, -1.563958336147462},
    {-0.8791943411736464, -0.9531301997233075, -2.1642427641831357, 0.6174631661928013, -1.0592044900496733, 2.2226704938948596, -0.19233409498882204, -2.476086571765768, -0.5560416740653035, 0.4827831941483443, -0.8477525689150606, 2.569650351208618, -0.08854139688115198, -0.26381789906217307, 0.5479359551634595, -0.8080234075636245, -2.0450035474528234, 1.0484082584542624, 1.4372168773946061, -0.6065219876965658, 0.17107598280921557, -1.8616325847014072, 1.6140126354411497, 0.9111734532718422, 0.5935421305484219, -0.2205009490015757, 0.07096507922272058, -0.27484437329572564, 0.6755708777350177, 0.3850054038204484, -0.31493663324511867, 1.0271445313134644, 0.16922273151029704, -0.5484936937381389, 0.039852770286066104, 1.161142978205737, 1.1395542742849138, 0.63527467252579, -1.2553280968540423, 0.02986469317964643, -1.793916198403765, 0.7588556439333105, -0.25989821193826623, 0.5019260493637503, -1.015169876705359, -0.34665609625885274, -0.506315049426035, -1.3718573555165456, 0.1729805803904325, -0.3816146599160741, -0.8897532719294509, -0.59984404719927, 0.6957053315455877, 1.22534595677415, -0.86867524913519, 0.46091212870710235, 1.9798006340448189, 1.5258531751405227, -0.6992719157803691, 0.4105573364238203, 1.9002207167225333, 0.4435374060444125, -0.8148492466047718, 0.3707959550196842},
    {-0.0461100353801884, 0.4477912655587843, 0.4542968504899812, 1.806876354574939, -1.597761631015804, 0.37281722130648703, -0.4425770182279003, 0.4120529418135815, 0.9478291187499036, -0.7209239771675826, -0.5329725417984407, -0.7437541137532246, -1.13599011999016, -0.9918293352781621, 1.7363457603471009, -0.6675503931822763, 1.2347881405171608, 1.4698539682723284, -1.1686491537642956, -0.5413032100604536, -0.2131126361216991, -1.9367643192832282, 1.3142610440840397, -2.177055905167195, -0.41880425823939654, -1.1483781684203884, 0.8789882806912301, 0.33376274956843116, 1.043154716284891, 0.008553195913584843, -1.8190726459919424, -1.252750539486107, -0.25841766621557927, -0.9643012674118623, 0.1328585529705138, -1.0358362300846895, 0.23154914042727798, 0.1885697068212457, -0.5672192828312147, -0.034564485480493116, 0.6393034804119407, -0.23353632743891883, 0.4078184868682321, -0.4627612805632966, -0.6557500127973829, 0.8889370475911463, -1.2900626724306505, 0.8388784186546514, 1.4821499922432517, -0.038405313711424874, -0.045566344203779, -0.03149584063371898, 1.3376911121298631, -0.68963401504892, 0.2607465654828803, 2.0826543773837924, -0.1240652634128986, -1.458863523463874, -0.7065144579736107, 0.6569097724789703, 0.11589539123475731, 0.4681747302919377, -0.6217310256542102, 0.3276849404216466},
    {1.6522389907042134, 0.7872411416219508, 1.3523945534313384, -0.3634778683001335, -1.5052178452646556, -0.615710119526432, 0.4017679643731388, 0.09567622476891131, 0.9612406158888015, -0.5669445291214446, -0.7570918831403355, 0.27897250681486435, 0.48909426886879026, 0.25181140655369605, 0.5549454574910925, 1.0033029166731857, 1.4744487372557122, 0.7478500224031043, -0.6091332312067014, -1.303633409011077, -0.9052753670912214, 0.2282121851417054, -0.2114373136952204, 0.6724961252101234, 0.9301849390318979, -1.1647679006354208, -1.6453867237152766, -1.2301962742865729, -0.31130759768600963, -0.308415317823263, -2.3388928031762535, 0.30893900373220995, 0.5383348469773067, 0.16025645965615437, -0.8226029470876588, 0.056095934918693725, 0.782756134667691, 0.5151995830775565, -0.5674781597857879, 0.42839011111381003, -2.2299117802415984, 0.5735106774202894, -1.4421863141768192, 0.38461697696553326, -1.0421193136619027, -0.5127758202356315, -0.7628959782170533, -0.8501501381852952, -0.3829381428814417, 1.5516907373224964, 0.6673853238644223, -1.5419993500429632, -1.1610383749342639, -0.904034964700324, -1.3420857407897266, -0.9288441503124868, 2.4375689580908935, 1.1165346550924444, -0.4756728857477425, 2.016983544945157, 0.5404097408003601, -0.18777564668461083, 0.41100058718818344, 0.2574208437077981},
    {0.9520838627718186, -1.1627557832649, -0.538145840946686, -0.4277590728219967, 0.17977573111600004, -0.03013688413450096, -0.1493248395551518, -0.36976806182493127, 0.690301250188291, 1.5366947566909832, -1.367197972972767, -1.5635063255281965, -0.22956396655235986, 1.8237149574931135, 0.5432818550616548, -1.128718410662989, -1.4662110591249504, 0.4276028134291262, 2.8264611267172466, 0.0027523053716760042, 0.7611765813985186, -0.10425381838087117, 0.08693581351783061, -0.7924233666100695, 0.9887642688890945, -0.9072269749425522, -0.154302364985592, 0.38743789799852346, 0.4033209372018077, -2.2821549322291768, 1.1599169023267657, -0.46714563434002254, -0.9886029670885936, -1.930558171313352, 1.1253044769342204, -0.47316368082232496, 1.417008187413107, -0.6079152954427584, -1.1607213581670173, 0.9869687588863473, 0.40835843663315874, -0.6038294472560711, -0.5585096875294439, -0.578051241226064, -0.1428297007024623, 1.6493315527750114, -0.09053537459513691, 0.6254829071620329, 1.663801984297531, -0.007690144043625028, -0.17945727381236495, -0.9868565985088404, 1.3689621597233232, 0.535860588480697, 0.21544626119998878, -0.11351636788026466, -1.426043176666232, 0.3012125342057612, 0.48863148589102745, 0.7602034211517417, -2.197892502721445, -1.1126590806524699, -0.30692108241954047, 0.29871573338491114},
    {-0.9732278114416146, 0.06883054553735407, -0.3573555351974417, 0.36289671525596084, -0.4905436255296286, 0.12646290620485134, -0.44785683360936324, -0.13671365254182755, -0.06575364503424859, -0.04118721340573142, -0.15117641907421758, -0.4514055786710652, 0.7776940560923756, -0.13112714270527598, 0.8549685158627706, 1.5064895214821277, -0.0630350000860524, -0.8436743778909384, 0.9498532953949633, 0.861184286787355, 2.8793419270934453, -0.8873647937131418, -0.7323408709301867, 0.0948412105801653, 1.8791319525247119, -0.17552106554212216, -0.8774477991024754, 0.5282049633983714, 0.4440921275107393, -0.4161887574017942, -1.0600395453772633, -0.6383900000553067, -1.316158121891904, -2.612970253289419, 1.6985542753611254, -0.5432611438954567, -0.8055226529117275, 1.6251679152020146, -2.2345581542691084, 0.3548699793696006, -0.1769519051203216, -0.6589198669796036, 1.9910616809758968, -0.8784367444560611, -1.1091906867537193, 0.03077865482615364, -0.056038764199338564, 0.6661302247755373, 0.3614353852392678, -0.8532605272356525, -0.474880837032838, -1.2258262942125449, 0.9146486686827308, -0.3876061528922108, 1.112101544489237, 0.547093111751802, -0.22815847167554643, -0.5497955891271095, 0.7027890480338839, -0.2656079875774857, 0.13741095436098635, -0.14424855041514326, -1.4783807233563155, 0.154773404888885},
    {0.8549733989885119, -0.8592771217355073, -0.03332669000473133, 0.008032087187201917, 0.7370227654904395, 0.5133549614880968, -0.9503017149848482, 0.19945572897322336, -1.629269161800714, 1.3011455615662606, 1.0970599472136833, -0.10915688615685185, 0.3028194238326657, 0.9189033309282553, 0.19850382253963414, -0.8023807842105126, -0.8714888428121645, 0.09088543115205465, -1.5663157255142401, 0.3892362230663785, -0.10806078786807191, -0.7788122794618983, -0.26314292988750293, 1.3098697022561248, 0.7136969370966885, 0.8758626011529983, 0.6129244801556993, 0.4799578353679412, 0.9098078668634753, 1.8997684044035343, -1.2693181076299338, -0.8626986141236233, 0.11620481291642493, -1.0621189877465695, -0.3663456850820442, -0.6879629160832308, 1.4988318179485192, -1.1357631772110057, -1.6204946714157211, 0.38545072072396097, 1.208075644974011, -0.6640586439062915, -1.745174678818407, 0.051584443543475786, -1.068770288824515, 1.248611318418626, -0.05279356538912929, -0.8242753979283162, -0.5230673687882631, -0.5973191630668314, -0.6248150326547002, 0.5845317168830252, -0.1309209007577955, -0.5237963967724987, 0.7445472801562626, -1.0735535729992496, 0.3226420132610032, 1.1972568240809387, -1.5109506072053118, -0.7978011702322862, -1.0027713760902592, 0.2559096804174576, -0.28291296304323016, 1.3841897824086273},
    {-0.32026811413148315, -0.5457648579311581, -0.6222287316731927, -0.021429665219396727, 1.8314763261259301, 0.34469610222543484, 1.2038863135755085, 0.1298648701461289, -0.3152350081657913, -0.42972100511881267, 0.7362162525299832, 0.9710058965782775, 0.12240087551967005, 0.47224052625228097, 0.2932365058231826, -0.3396111648038481, 1.9367511904685903, 0.30546706171578536, 0.6328848438672546, -0.2153219656643802, 0.027932339124734813, -2.4938963686352515, 0.6063362473745461, -0.9983740873317103, 0.3914724835149002, 0.10733657973504743, -1.8059987911015838, 0.2708754148014997, -0.4148836384806362, 0.7313665312903216, -0.6025262947882497, -0.4452849718976183, 1.911530077475533, -0.9253099083386965, -0.5239890514890857, 0.33986027570322586, -0.6301366466343924, 2.937253858334852, 0.14780362695837704, 1.5617159530164213, 0.11414049755852662, 0.535264625430366, -1.3480735170440414, 1.421953534383865, 0.9697898901533041, -1.349694903421184, -0.17108192752029155, -0.07478006204854558, 0.0814555629693291, -0.40713326145801215, -0.39664011984007846, 0.42475922456216436, -0.9796768742276238, -0.11263552954752701, 0.6400817661850978, -1.2390525585466061, -0.31477458506810363, -1.4528990209202224, 0.2890229966868752, -0.027688294356298618, -0.9685258135715147, 0.0802346031852713, 0.5418536169509497, -0.4717646596397098},
    {-0.9653700146205639, -0.4246531653577621, 0.08426617836165107, 0.34173206864902766, 1.3695219737231024, 0.8936938112269486, -1.325772232914442, 1.272199011830154, -0.4247365180306712, 0.23225723218488914, -0.2502130089491708, -1.298714643963506, 0.12330051307826333, -0.2337781055901158, -0.343301880572311, 0.5270710584878938, 0.5639043500785708, -0.6075728892694774, 1.0873509711113782, -1.5034041232484279, 0.2327469088131738, -0.8076777419776048, -1.0012040083959752, -0.9123729406259734, 0.07416076166369714, -0.25203992630579525, -0.4219610363011418, -0.2835701776624179, 0.6070083975947388, 1.028819033112594, -0.5113161513440215, -0.046299381831464155, -0.436577226179873, 0.4130913029195742, 0.5347962492827492, 1.6359285079040922, -1.9617047233383997, -0.9520852562622206, 0.14212302048125122, -0.19535699618819863, 0.32797725619870616, -0.5912889003548774, -0.34982449851645353, 0.879271216630892, 1.7207180803066726, 0.6703685018245894, -0.44686694033698116, 0.08578029132684893, 0.16085468482125018, -0.2402441492365078, 1.0900901479775416, 0.045482485644024684, -0.061258475735102416, 0.675308843404938, -0.6631094082531841, -0.9279540769176013, 0.4040949060361532, -0.07002832831767695, 1.702154004961828, 0.4891618889809292, -0.2996186119710155, 0.6485853073395287, 1.8642816841272714, -0.7192359786076581},
    {-0.06017852162310749, 1.6380417587149296, 0.5736294952725854, 1.524228195708495, 0.21709004993307449, -0.5973388716049493, 0.17803032713511222, -0.14119453095715748, 0.052546818455923974, 0.715701155615989, 0.1234447915229542, 0.8111773024911451, -1.8129947135716198, -0.778189365916282, -0.16751902304348765, 0.1223375950377095, 1.181967688202699, -1.4311217959208566, -1.5852258110966582, 0.14327158225621925, 0.44486483038636937, 0.649651501667431, -0.616998569865657, 0.5446121899661996, 0.3828728647852939, 0.4745332854902776, 0.2964985973782052, -0.5511135598556569, -0.6094664188232982, -0.13598846700954992, 1.4356418594649503, 1.5269704297837858, 1.9019186919260256, 0.8488283000395512, 0.6183353656379166, -0.9875627285899534, 0.41435649625173593, 0.08534201622064426, -0.6812496298837347, -0.6828410284093896, -0.8828016493894446, 1.3914598043827537, 1.281080774435059, 0.11003510866932861, -0.6335314910731353, 0.8127029875358683, 1.2076499946682269, 0.3077178463159257, 0.39376096922673726, -1.8596660921238302, -0.7525750864832436, -1.1477285371618882, -1.1954493367849013, 0.5885845908825051, 0.6636144844348474, 0.7682550110173271, -0.0828266677505461, -1.1475800398967606, -0.5884714262020739, -2.441596081284392, 0.8751771048290847, -0.3185667702456511, 0.3611872951749276, -0.43154543991779043},
    {-0.7372032055052257, -0.1809884911086359, -0.17655817747921343, 0.5646040927366394, -1.1282154878077855, -0.9931786703377672, 0.33233918725274925, -0.06907197867840327, 0.5318835163333305, 0.5045070205700645, 1.075973830175123, 0.5543367263735706, 1.6170514050080478, -0.8469858013089717, 0.007360370429119553, -0.6297392738806828, -1.3182032931360008, 1.5985726275807486, 1.2950071387263578, -0.2306093784231034, 0.1166222670061466, -1.5347743430311538, 0.595874341333089, -0.24405577785820196, 0.32358686088432104, 1.9861306328542288, 0.3630970647275592, -2.2819088503548928, 0.5427014037191918, 1.182310483512263, 1.343133334209197, 1.7193490805142273, 1.021831801654961, 1.2974467609039286, 0.6021152647910352, 0.7062322087420806, 0.5184104452984066, 0.10068469123944329, -0.16954409391508257, 1.3400517764885467, 0.46550764762142227, 0.9193115167858157, -1.3865320587536925, 0.14455765468496135, 0.6722500435200236, -0.26765342806895687, -0.17476865789489, 1.354170478926915, -1.839804805261144, 0.06996684651540576, -1.4336625940333876, 0.40942229357468646, -1.1059534852590152, 0.8669790422186204, -0.8469046253765571, -0.4328656719041266, 1.467636679602129, -1.0699015563222896, 0.9005439256628471, -1.1314969256735428, -1.283904444533362, 0.45251862089008155, -1.6718248921415797, -0.08635455495213484},
    {-0.4178955947249042, 1.036475673282358, -1.9239930328007881, -0.6450028430603963, 2.219403690597232, -0.851799161181902, 1.0553952127608164, -0.3276821198173899, -1.1420132848821063, 2.181943050071304, 0.22722678656490208, -0.7907307504145804, -0.94783101872303, -1.0849520575964795, -0.6232797293242329, -0.7862974317096538, 1.0153814660072482, 0.08802193937760626, -0.5471371501802436, 0.9613294509872843, -1.262172916294468, -2.980611453997256, -0.8899682099603963, -0.960773259067595, -2.504737461937163, 0.9044529284380272, -0.4835823001003888, -0.7768758583340939, -0.6760515968302251, -2.4689164512421913, 0.22014170253629925, -0.6740813554089875, -0.6743958496794912, 0.08756315804447326, -0.48351626199558356, 0.9356425107165292, 0.0018824167094788449, 0.9986311622736267, -0.3976206304465606, 0.11048576666583344, 0.6494322112284802, -0.4400533569179914, 1.2254238686973171, -1.0272386482377671, 0.4890897840398174, -0.7808262419075093, -1.1182958406306316, 1.1221139518951007, 0.3133199669449213, -0.9472138443788884, 0.3285598501819705, -0.36310826628554455, 1.1454138272635508, -1.1990364265682925, 2.512263682137548, -0.862707233945828, -0.8624659420919275, 0.2909667921561789, -1.305387884323349, -1.446155952095497, -0.14291834551097338, 0.6746601389789947, 1.413849489863091, 0.39213873094808976},
    {0.28706163818065844, 0.36508291536771026, -0.014475427378758213, 0.896607466879345, -0.8453815509314084, 0.4330219679483083, 1.5058586281586357, -0.6370816626230302, -1.2014867770340638, -0.596159781785383, 0.5907159433208927, 0.34093056710662484, 0.02813071281080476, 0.050565883982098304, -0.8250425956062609, -0.14908864042548975, -0.49216520405492564, 1.163149936158258, -0.29871652947801, -0.8197582532470448, 0.38987262453417043, -0.1963256173368531, -0.7946680789535014, 1.1888765294524388, 0.5633803526828607, -0.3747860625948344, -0.6999050441867063, -2.0818553590558126, 1.3037501237293738, -0.49822613758277473, -1.4616899879323135, -2.0988430749892033, -0.7805200103061513, 0.06676959631355038, -0.028195795961210884, -2.211295126383771, -0.8349596584627771, -0.020472139550288728, -1.2882293400421703, 0.10782792532944886, 0.1963403318013103, -0.4775483992757278, -0.6694762138638848, -0.7202401448161493, -0.6715074971113382, 0.5257371509762355, -0.9252546933212658, -0.588094314223731, -1.7506719915334916, -1.987551190455913, -1.1989048801077085, 0.05005341542820366, 0.0009302507984851499, -0.9474262932124631, -0.39307870198590883, 0.0003970788194010328, 0.47571092598860254, -0.836207411066611, -0.8392245561041415, 0.4134312290483567, -0.6509841623367842, -0.2651557656259886, 0.46452734274006474, -0.24423001199010222},
    {-1.6722482524626947, -0.6020359553468626, 0.44042331192604445, -0.37878055904896774, 1.0210571950538987, 0.9681912824229421, 1.0913777591800233, 0.18243419701595306, -1.0763536723284457, 0.6963197961922368, 1.2792706964951526, -1.0457385125469703, -0.6274119953338201, -0.9000081087992848, -0.25344629578813127, -1.1391459315131192, -0.13485942865391864, 0.7667108292797195, -0.5442864971073438, -1.0304426319878204, 0.4752396372824491, -1.910161031116534, 0.27728110367258585, 0.3578054585323704, 1.1786784992221127, 1.2864403852937116, 0.5788280449779423, -0.8180950209533445, 2.3806840479486158, -1.6438715772286736, -0.05782962037353069, 1.4313424620542747, 0.41238627878609574, -0.5081046790847579, -0.18432478984619738, -0.7950050208501404, 0.7016353352728227, 0.8681810985149638, 0.8151311546583928, -0.7786642819422771, 0.5450103393019436, -1.575312628404389, 1.0510691222231665, -0.7969660797604444, 1.5727787005656109, 0.782514888031835, -0.7102146213405365, -0.07736967976521272, -0.00074436330117528, 0.25772895075976215, 0.4608742649401995, 0.4186709447688857, 0.7206905975584138, -0.5506229460812653, 1.1847221327909514, 0.6486951134268646, -1.6277701358047905, 0.16530289906029935, -0.06489284219545571, -2.761615416444041, -1.4168627568936576, -0.037174857612234, 1.0654410028046624, -0.2634802617069599},
    {0.30287218150510237, -1.0649578965451756, -1.6206222708854097, -1.6963766782215173, 0.442279915668286, -0.7674272207829786, -0.06364128503335423, 0.2045386763067248, 0.41279770495879525, 1.0417025372244437, 0.6999599615262521, 1.5491902663747972, -0.6633922623631192, 0.7478714315054289, -0.6043815658205911, -0.3586439743486021, 0.4490525014697425, -0.7391203522892793, 0.30962148229949055, -0.04725573163606474, -2.5674134684900998, 0.27101431948412524, 0.2942146887196774, -2.24047758790328, 1.4159390232196245, 0.780092613873978, 0.7759875825036572, -1.5170882816922544, 0.1503975010674368, 0.6107515389765956, -0.22122830561297477, -0.20970134259583822, 0.4906369347351514, 0.0373002128978118, 0.006567119129605172, 1.305087080040036, -1.3543061685668374, -2.2191612565937056, 1.2188887172094713, -0.6070138129753403, 0.8676687207819658, -1.1539794098429135, 0.7515216416238416, 0.9842519097902248, -0.07544446166197696, -0.7846319877865737, -1.261827754218397, 0.05822372714599718, -1.5155173180281434, -0.5675356875103185, -0.5450683645439652, 0.5135031257186461, -0.1412802141451671, 2.7093996651444305, -1.0152855108011596, 0.6470591628081741, -0.8274811699134561, -1.3922032151760155, 0.7879029826437465, -0.8030316423528335, 0.9660629146590345, 0.8483027013640914, 2.6771970584686438, -1.7371739507623198},
    {-0.6374170656884293, 0.5861337231586851, -0.6643215264311124, -1.2161577967554318, 1.5436597349777017, 0.012089066952442606, -0.595981206506881, -0.6980709489945345, -0.1977127164858387, -0.09653827264176598, 0.05846525166399945, -1.000543058152362, -0.37730645196977886, -0.9737723193987163, -0.170187156051661, -0.8457793830140025, 0.03917803507996399, 1.0476305306709446, 2.296957959131586, 0.02225226058288636, 1.6954302657561264, -0.9240054899399253, -0.28154641478751913, 0.000548617340483727, -1.0384863454075401, -0.5293213416633407, -0.2647061420629203, -1.374813200368859, 0.04695722774278288, -0.9337483380643774, -0.9373165631430718, -0.27159258353445176, 1.0357037878750044, -0.14581741086363156, -0.8775886746261827, -1.736958219028046, 1.186058347470385, -2.279726844731754, -0.2588365584673837, -1.570454664273118, 0.17697841534226452, 1.2278390101699586, -1.3080867755712347, -0.6443463037189694, -1.1518450336652382, 0.3180078601973201, -0.9483064610470069, 0.16986848437204113, 1.4283571767420629, -0.362543023408673, 0.281825304769627, 1.4919445515019676, -0.43229753168812685, 1.138546887589699, 0.8073658005520732, -1.0166477006428145, 0.5324015533383808, 0.695999523539134, 0.07559637793104039, -1.205938924988808, -1.1289577637285553, 0.6009255988357808, -0.37004314406726907, -0.7572900272306954},
    {0.5618715315305037, 2.7108693248541624, 1.608514141598778, -1.6496801999117405, 0.8829552224775161, 1.823435223031539, -1.8840588673666996, 0.4092318915601887, -0.21240041694094122, -0.07991862040265278, -2.212420338915375, -0.3719113078224409, -0.6226166357746061, -0.004509794591574855, -1.9259574016917187, 1.91368627234066, 0.93464722146242, -1.0064615308080103, -1.3625542127502233, -0.19810154904526434, -0.29288337700230294, -2.368337871529418, 1.4471471365252861, -0.5741230469046897, -0.36989406200143093, -0.5049341752726244, 0.5186991538202164, -0.6110238492814469, 0.05776430037561058, -0.1978488994434594, 0.31588736281314067, -0.6950218356548881, -0.6664684886639967, 0.8364238655341694, -0.8016248321884566, -0.765021799225991, -0.008821826909164282, 0.4616460513705106, 1.9522800592237164, -1.3576440015198408, 1.430229580363697, 1.0529697576924208, -0.549483351259466, 1.207491655403742, 1.313556597649557, 0.5289876353149336, -1.435464453505495, 0.330455056294747, 1.8234499085998663, 0.14207614936934823, -0.3112615632965652, -1.6500255224808917, 1.3655757706009342, -0.2820600447558325, -0.6892187797315619, -1.4674256745889191, 1.9517213510454012, 0.6984650328801594, -0.2889630623894895, 0.014611890908433671, -1.3382128509667752, -1.0922047332082943, -1.211259200085186, -0.6609781873867158},
    {0.8887687643062621, 0.339204755375237, -0.8199549440189753, -1.4462152319388784, -0.5618927304139266, -0.41620997256556425, -1.360540519014964, -0.9897250246320966, 1.0132767903962627, 0.657145769775448, -1.7964640571430366, -1.7623665240438047, -2.383945138728103, 0.7358642279236726, 1.2468973969464263, -0.40702095519197423, 0.7168857402717732, 0.443991787461991, -0.48995569422773066, -0.1195569462073595, 0.4448513412699148, 1.638755922983102, 1.1981728290188753, -0.6993324414804597, -0.7431127859391976, 0.3723354102840391, 1.2013886611414433, -1.4870797198876884, -2.2569732084362006, -0.8931343524920073, -1.0816606209084145, -1.0539752829242812, -0.2752000680656214, 0.6269320641229069, -1.4927872327569711, 0.6635377328155172, -0.1354431377457214, 0.9994060830072938, -1.8042007955980381, 0.5021160199571107, 0.7439946152815898, 0.13463922531074018, -0.949248285390607, 1.713704318440838, -1.4766319703370554, 0.9627101592235903, -1.0226670246309864, -1.7295898825925975, -0.3057532837511536, -0.63530629183982, 0.3538856533098012, 0.8122254710977845, -1.348791306272704, 1.4494117807979712, -0.1545266872366355, 1.0897062752799012, 0.4964936915379555, -0.1185484747720442, -0.19312345402941153, 0.46136496793682663, -0.7021499897141574, 1.680262124567899, -0.431350818891549, -0.6810605718387803},
    {-0.6189933792682788, 0.33890430771596897, 0.5270885688437511, -0.5888861790345437, 0.8072671566643557, 0.6700491176828898, 1.0206932291003232, -2.332407598816078, 0.14939763629305183, 1.257379040211921, 0.05397805697671364, 0.21489747621064467, -0.20786441421673932, 0.015926596715025367, 1.4090254287389985, -1.4731062305449518, -0.6287938139679125, -1.5670437963278498, -0.2120618625801019, 0.8944365014926335, -0.8321042642999782, -0.8055718688586109, -0.6723865827031815, 0.7521319608962723, 0.8250905043271476, -0.7411618466828422, 1.0226751347343064, -1.3040458797223218, 0.5290136686799426, 1.119397401933904, -2.210862433478754, -0.27070187789868544, -0.11906929278559768, 1.8915869782805932, -2.605941309912228, -0.3297057822663296, -0.41657223786790926, 0.7013820280944666, 1.2929458812157484, -0.4055549507952742, 1.7263041875702148, -0.3108348736938934, -0.029389589145794596, 0.6168596597897843, -0.28952666183188375, 0.10364971255019063, -1.06055550249853, -0.7115042267511136, 0.027311607780706158, 0.1666613603446907, 0.04152460560595284, 0.1378506825523659, -0.14373218773473426, -0.500161516499095, 2.6067011927065553, 1.5732806658278153, 0.013070444199270531, -0.39161824268522855, -0.7948793623044208, -0.1164267329542348, 1.3643346422564135, -0.22043458871824506, 0.11858119047540927, -1.0946330755809481},
    {0.13167902942199147, -1.827255275866234, -0.7962162821520474, 0.9744949859142181, -0.2527165466350191, 0.3633697069948412, 0.7515706970950052, -0.26346558153718364, 0.596725486965194, 0.3391916947779888, -0.17214974841503866, 0.29422092537769834, 0.2744873779206532, 1.0603557533483203, -0.09096309556321386, 0.6369934443272864, -1.0522542016363987, -0.5681266700031664, 1.2819168023584233, 1.1545683568602272, 0.6672589930016469, -0.07850097052586272, 0.5458297067767479, -0.04560389501065162, -0.6064073380169781, 0.19053566320385754, 0.6695557680814155, 0.5663911295646373, -0.0783846095467628, -0.643461885382327, 0.6309614088699232, -0.04559603425064004, 0.5790329777894508, 0.3457697985978193, -0.6820244047410247, -0.31277132663657564, -1.5059496053772394, -0.47535904089396436, 0.023782344901937907, -0.46305668623917895, -0.17549582972041555, 1.0545299590361927, -1.5799517217164918, 0.2208387624953396, -0.6433001470758265, -1.2272424051863546, -1.0991153045089772, -0.061976936253200984, -0.19652797633920677, -0.9883547306199322, -0.4124816888036554, -0.06728928726582058, -0.24895146119502112, 0.3279304925735163, 1.676378306166126, -0.5518176099267132, -0.2734730864609503, -0.4911930137745583, 0.7054182395129585, -0.4747559085478245, -0.41785380848332115, 0.932178115667421, 0.4184348930099989, -0.34134197175783976},
    {-1.1270503517179846, -0.5573658692404536, -0.08858057869149767, 1.2117438686646114, -1.9929307291439355, 0.0004960047416531424, -1.7025957710168416, -1.3559470357092134, -0.025469237216958127, -0.7451062512239406, 1.004288689648154, -1.5335245732800873, -0.2575537540953299, 0.9349673299330074, -2.091967846454015, -1.1374869880302045, 0.3752694796455431, -0.3221427369159152, -1.0399749163615193, 1.3446800695065522, 0.7303843239930814, -0.053500707412159565, -0.012885117024356137, 0.20278477843287554, 0.34244811516023566, 1.8151226958439197, 0.05151287204824256, 0.734865066345401, -0.054600048251491944, 1.1281322130513396, -0.2026559431206248, -0.17295327449928416, -0.23626105648520182, -1.3125522235381817, -1.2364109357942756, 0.14147171985258356, 0.11592111713045547, 0.19389620720663872, -1.4961382093427074, 1.497702181801753, -0.08372754632260974, -0.969996776930475, 1.4500397935341576, 0.02700726376752128, 1.8184195847730116, -0.5318638897568949, -0.26405294389885714, -1.43055659382229, 1.0826062327103114, 0.9887748964611296, 0.8632219005242098, 0.2823243759081988, -1.866162348305205, 2.169400701755713, 1.2036255818822486, -0.3537882814013553, 1.5861429673690577, -1.0650027523444, -0.08303822447110701, -0.28891463193941364, -0.13401467812309897, -0.5616598872289007, -0.8088078765969315, 0.4770095213527708},
    {-0.19159619628257588, 1.2685420470742088, -0.6313266903620756, 2.0583457377165133, 0.4863807500339027, 0.4886653714999139, 0.7893261777535973, 1.319769276415403, -0.03445375256481233, 0.5174373089921117, -0.23483726820798626, 1.4021389879030601, 0.5156760977205095, 0.2826695604092857, 0.3460140238690657, 1.09498477515039, -1.0078675198248712, -0.7775245803576859, -0.0071348606526898655, -0.7517065647307626, 0.8558688551561158, -1.057503934559571, -1.7197527070158765, 0.12583288381711483, -0.2896873642710396, 0.15759860015491856, -0.6443914893040755, -1.1059414680937023, 1.0498364908166558, 1.77122510196539, -0.10749751795433764, -0.8927165054844846, -1.5463562838070088, 0.9901363877860614, -1.1297637913283705, -0.048819586735010134, 1.3379851325016106, 0.2739990407945792, 0.4259769853797249, 0.790504393562824, -0.7112128182961726, -2.1464711101726706, 0.11415503281896239, 0.18247265258885795, -1.2696852825749216, -1.7791471781794426, 1.073950616195886, -2.1999236924580456, -0.39067070587189706, -1.0117104735575437, -0.46160055761179347, 0.17833626653139592, -0.43084869805498077, 0.007226199694870163, 1.7966216083336197, 0.45378048899016216, 1.2694958747292344, -0.14846883784527606, 0.29468647985073837, -0.39259106290755813, 0.706577529422513, 1.8870483886459344, -0.2362714241388439, -1.06674916267283},
    {-1.4964758017937831, -0.8977899884184549, 0.31780971173950745, -1.943042093729588, 1.2987073187646658, -0.48700978761987473, 0.9324178358176894, 1.5967490437377645, 0.8655049932714057, 1.1015361759019033, 0.011567179791876847, -0.6367620323890114, -0.14057304190854378, -1.0317741247044538, 2.949013878825754, 0.23966618888615304, 0.19733799360962398, 1.5531779651991344, -0.1996503052330389, -2.0428198292993573, 0.31778294088541525, -0.6463549427405132, 0.5386757516934912, 1.2599766793750133, 0.9883288430141008, 0.26424595589649474, 0.7655930831999952, -0.9024022801870615, 1.3041423269894943, 0.7701677671346258, 0.6741154707816541, 1.5130393791953924, 1.3005196693611965, -0.4642149533600534, 0.7794477625072983, 1.6427889902786403, -0.9005284966714763, 1.4113865782961115, 1.071759058277864, 0.9045379529026389, -1.498330469749919, -1.310932396172216, -0.11023425292287586, 0.5986428445600642, 0.22873924513964136, -1.210148623744214, 0.27141501133668294, 0.9364603333900781, -0.7802881223815024, -0.35417334663349415, 0.25206399734194235, 1.7438586887978533, -0.8381654618725871, 1.451057000798485, 1.7018441375306776, 0.4252023779074025, -1.4771824456362348, 1.239866994352278, -1.4439758405386827, -0.5032109922745276, -1.0791709504962037, -0.13466506658577757, 1.0160739142188369, -0.4221106202159987},
    {0.9758192436227292, -0.936429886950794, 0.7384817844808582, 0.1654707847288203, -0.4153048838919383, -1.4337804365004967, -0.9383344914076798, -0.0718342109232684, 1.9134267607203712, -0.09949991218402711, -0.821496705178637, 0.6008522159733465, -1.5441344923126268, 0.16992744350847952, -1.9186903012503262, 1.0738763792581325, 0.3029765965125396, 0.6779845754760279, 0.2790393177837983, 0.3101803873209885, -0.18259694925572792, -0.9480227145025941, 1.5669824624826416, -0.5615529395978257, 1.7153548890098096, 0.6695004089544716, 0.3115853405353109, -0.5812886452086593, 1.4142138214678242, -0.3344523492664082, 0.4243384597847032, 0.3368591370728815, 0.6883336168216306, 0.10423874930254823, 1.3479046988207593, 0.6119472323239419, 0.22543508896743913, 0.5151350111054254, -1.9550157457303177, -1.2578465488120054, 0.9747030837636426, 0.517174540160059, 1.1158259260486054, 1.3299987324390137, -0.6215033771387347, -0.5335643060194687, -0.3193174209386458, 0.7001818299032099, -0.631738362041325, -1.0606246718469043, 0.5965159613923319, -0.5694132101661905, -2.2628376302680864, 0.9635203859967318, -0.7200081907186111, -0.7785193624796237, -0.024473392604927816, -0.06220495202184469, 1.4611793232922352, 0.6680489651119095, -0.8516014820248528, 0.7537281884833381, 0.6915362323318244, 1.4359159801073833},
    {-0.8372118602987496, 0.8798654162150287, 0.3207994672939127, 0.7347793039662466, -0.4004083711525079, 0.08783406892221503, -0.8773858486725379, -1.5387336563925804, -0.11011829808451212, 1.3693777898816553, -0.25349183228964556, -0.2026703231298992, 0.2759330155954122, 0.27994424046010813, 1.782587792383783, -0.25953214371892774, -0.778708740294806, 0.4939451749756052, -1.8869457225198074, -1.388647324765311, -0.7868176860016275, -0.23609982556298634, -0.234115947379976, -0.1725747179150916, 0.8526662049661262, -0.7804722559379704, 0.1233703017999674, 1.2445954078534847, -0.0033619932927325354, 0.7501743147414951, 1.4761697707024337, -0.6188740442305481, 1.587022324064113, 0.182389030494442, 0.3984693979442097, -0.26888460811235904, 0.015507202702082511, 0.5993444536719024, -1.4045906135729385, 0.2494491046223336, 0.545896295931403, 1.5576931163067997, 1.7215124076133048, -0.5412884087324173, -0.6002774476394447, 0.16122280794719174, -0.47212800446947817, -0.06953392190529822, -0.8971888618881173, -1.085143527128173, -0.44543275371648816, -0.9002340668237107, 0.35072806116666594, -1.1404716059808493, 2.128521759723786, -0.6873692554690264, -0.862041039152259, -0.27024440707865627, 1.142439172150265, 0.4276896615688909, 0.02042433866868555, 0.8204690867008992, -1.0764983147894205, -0.24695451181649736},
    {-0.1413365685968252, -0.7743536650052363, 0.7889597903695007, -0.4061332362131145, 0.5802241457066205, 1.2467108679402918, -0.8864009084789023, 1.103788503286442, -1.800482343840079, 0.19551926103981465, 0.6135145655452283, -0.37786386516987575, -0.40894221780623097, -0.7556940074271323, 0.807471246933703, 0.1633946164198602, 1.8110704237942075, 0.7508493821587761, 0.419013648182347, -0.6105666953893231, -1.7072180845352933, -0.6525005066077504, 0.9015781916697867, 0.32316464945577367, -1.5597766770773356, 0.9770277774036005, 1.0371067091617765, -1.2171263390894071, -1.178218387818353, 0.5491857549556058, -0.33315104736434253, -1.386853202663243, 0.14571611711365942, 0.15911222933401156, -1.6440072454958785, 0.2794051714968007, 0.24577472300104616, -0.9568713096781061, 0.16826903736594825, -0.6374387099019867, -0.4820567798480806, 1.5560805135120288, -1.0422606980691458, 1.0299863522086279, 0.21179836949152836, -0.8907446920228628, 1.2279871899987553, 0.3347895407160641, 0.1469626809511118, -0.7464410469807364, -1.2198769547440507, 0.5715537582284536, 1.5748003736367884, 0.2781604910664668, 0.7980503127521285, -0.6982017035789002, 0.16906656314772603, 0.6859178574464639, 0.6108214181778168, -1.8570724132963734, -0.06682178480485834, -0.1733527526058221, 0.9409306428908243, 0.11754585318792139},
    {-0.8617859667220683, -0.006147278898546646, 0.969000925983037, -0.17771618764775163, 0.692303123441758, 0.46784273105938806, -0.502960852707668, 0.051583384924474916, -0.7796464539985029, -0.2971291552730377, -0.23339488052793486, 1.987981511638374, 0.7304014376759386, 0.19255106753890416, 0.494340775793156, -0.7401419566640299, 0.13885299606347415, -0.8374835829332349, -0.9199960069476804, -1.045417722629863, -0.2482506843356323, -0.6044989327535658, 0.34715664115696815, 0.7068604019000192, -0.45133997844133406, -0.2476073883988793, -0.016588008822566787, -1.461910687037162, -0.223409107355745, -0.7891691657060845, 0.8450293909280291, 1.520907023310926, 0.5097646280122623, 1.2507760780084365, 0.4457185743674714, -0.052432997095597934, 0.5489894918908605, -0.8624037559313482, 0.20269543323161748, -0.03882387863738914, -0.6742858835055697, -0.18094487359516276, 0.6504910398674772, -0.8836133269454314, 0.16310920982089108, 0.8521961204215073, -0.708532900600044, 2.129131438139591, 0.13396855142128, 0.015045220487425558, -0.026475110549999976, 0.3622771071116843, 0.5516706214417341, -0.18555424227010303, 0.5186829404723355, -0.6741404272504289, 1.0835763008198493, 1.0788976976195424, 0.4096994573089047, -0.4734632469520373, -0.6934934636663354, -0.011356448179331697, 0.3071847844306189, -0.9870112961127671},
    {0.1148467206393601, 0.17893802617332763, -1.7912414326999373, 0.20581411766609364, 0.3297416318216084, -0.7790816649261368, 0.29227643360397765, -0.5421116942809453, -0.46401430769612867, -0.22227406265409916, 1.3136987187626474, 1.0432440244675119, -1.8168416426601481, 0.6923869380532349, -1.2637509060909728, 1.1990661787976915, -0.39484101551452516, -0.20510835408374578, -1.3725738979873991, 1.1923234595076133, 0.791692267064878, 0.6379472520995313, 0.4443672097155473, 0.476091665917925, 2.0142957070121295, -2.3013290147216874, 0.28124190394709714, 0.8811204648254637, -2.48896604288524, -2.357429991630055, 0.3262741126858735, -0.4104014498154686, -1.038495217086329, 0.05827894463565545, 0.6709339924812081, -1.904048943317403, -2.4870677490254542, 1.0628895856437983, -0.7072655017133981, 1.4687716026843518, -0.656792796282675, -1.88921753772667, -0.03138127559473272, 0.6021208424484839, -1.9231704291890745, -0.771033302219462, -0.5884191695816269, 0.12493674251573485, 0.02135475152746539, -0.7508574368601619, -0.20065200630622979, 1.4489369494067574, 0.9416762102005323, -0.9021677548841215, 0.8860457472793284, 0.27930671783247873, 0.6508097345694119, -0.5450665771344593, -0.995905082111853, -1.561302261216271, -1.0678554124681756, 0.010936211900064604, -1.8043978887268295, -2.119710174010506},
    {0.9244935409756215, -0.011967571214587606, 0.9567364986901322, 0.6065935376655803, 0.13792801072787264, 1.6909493468858332, 1.7101513821451713, -0.4766501819387633, 0.38255570166299324, -0.4171492464146111, 0.05919943316328154, -0.6699440205978047, 2.3036546023674873, -1.2733370345888815, 0.6316858454766007, -0.8191583825678961, -1.2513150973823153, -1.2942803507927962, -0.7631612808152424, 2.239080916097484, 1.2586985696288528, -0.0965661936408709, 0.9177139343524351, 0.03961862916721779, -0.49130576864054976, 2.273732486009279, 1.0943411786484698, -0.2652592487328925, 0.4406714031024176, 0.5364307405374948, 0.3884792083966938, -0.462542176630048, 0.7505228614594579, 1.3513404969488487, 1.9823291603559658, 0.6916041009003839, 1.8740790753365468, 0.7327720106806145, -1.0870534518220552, -0.21880409234695258, 0.4872685839442931, 1.0228856644377387, -2.3266829656676977, -0.4805035995897496, 2.211914422594697, -2.5341183053293963, -0.2965970537259306, 0.21195651135013804, 2.1627089533265345, -0.1992245076521043, -0.8086290239770868, 0.3205636995219201, 1.546419731253703, 1.2834911151132242, -0.2565077753221858, 1.4270057476652747, 0.9356372722361805, -1.8796817792880915, 0.3510220771286413, -0.3695901466203068, 0.3967000181185838, -0.5640171041648406, -0.5569755381485975, 1.3120689238385894},
    {0.30773420706018545, 0.11058195459597346, -0.717911279344772, 0.12864588208955705, 0.8420349172164648, 0.9879390093546718, 0.12788799260807895, 0.7687079059912324, 1.7018308943175502, -1.930290639371336, 0.014266007031061179, 0.4287761577190596, -1.9982648201357482, 1.4808149931527252, -0.4854613814600765, -0.42543900596020545, -0.32842501164258037, 1.0876609614577788, 0.2957838415274608, -1.6809108569453697, 0.9975056268354361, 0.44841171061275836, -0.6825747663151926, -0.6252752169327757, 0.4657407990933715, 0.23873416666872932, -0.018384035143375124, 0.5827664229197392, -0.19292875648519792, -0.3776424844742025, -0.6738835629895038, 0.47421917485246085, 0.8386359326945497, 0.5238886651387882, 1.4668065551419733, -1.501279040057674, 0.8123508450137338, 1.2212139126246375, -0.6779555398917314, -0.3678933403750875, 0.8245578452419038, 0.8023812508991144, -1.466229911261313, -1.8495596440913025, 0.11731165791741288, 2.7345908416311038, 0.38393023206227606, 1.6970176237703118, 1.8665971407521247, -1.1904804301623366, -0.9577310395955202, 1.3122746173507223, -0.5220906885138079, -0.7516156495345016, -0.4140932331823422, -0.9639042703586341, 1.0063626296477413, 0.7422759706547511, -1.65218635773002, 0.286381118802575, -0.7246110016731951, -0.07387159979955257, -2.6109163671409146, 1.4444899411851215},
    {0.31597294894469197, 0.020786293533875354, -0.9535844892412368, 1.3017281257609563, -0.9317898841550808, -1.058523549319427, -2.264977284393575, -0.7046710454838716, -0.4069303630824115, 1.5134803661511629, 0.8125212668286688, -0.7296757067872811, -1.6183812267012596, -1.3124543831478985, 0.3878744345466647, 2.641551764308046, -1.141941646218337, -1.0012454864726534, -0.08343766044015458, -0.4364134888051057, 0.8885486215756706, 0.39772629447828095, -2.2086808490084984, 1.1024500272834903, -0.3697175293043262, -0.7701699355774854, 0.832446600377404, -0.8884990748430597, 0.8037620998305185, -0.28295909821326903, 1.949610962871196, -0.0886888377833456, 1.7466761405410534, -0.8145954060909415, -1.2309668745130993, 1.1005518644285308, 0.7924275662393319, -0.12027104394607555, -0.3207148537304881, 0.4077578915423199, 1.2683176773065934, -0.728274902867989, -1.8215288921506723, 0.26593537034034087, 1.3399337232783424, -0.09034204505748343, -1.0826590484156156, 0.4888453376768277, 0.3697816572660616, 1.4920354258423465, 2.1183415844489337, -0.2571567130701324, 0.04166506135569469, -0.04180423518777524, 2.9821790374563166, -0.3122057404823651, 0.5140398599848892, -0.6402906818191492, 0.24802687794531578, -1.6900987813129915, 1.2311190946766792, 0.3153107760896887, -1.3649961288452872, -0.750183699746485},
    {1.0643191928562026, -0.18030619539808046, 0.41191473333878736, -0.9319652203350651, 0.4411819257908852, 1.2420893578047258, 0.5388248650357965, 0.6935075485187645, -0.5287568935636654, -0.1581917864153832, 1.3776749401012003, 0.9597885123744624, -0.4591167215220844, -1.1612454810396922, -0.3560539956652255, -0.5667415177019479, 0.5342101129396108, 0.06951967936819164, 0.295647192029344, 0.3616591593346242, -0.14789519525493244, -1.212869927633235, 0.4366733508451828, -1.1697693687890274, 2.041312177684836, -1.0496537395416914, 0.815966352724811, 0.665516333677304, 0.26213954553746266, -2.644587596541788, -0.17592869142255457, -1.0132814861265529, 0.2562369991178224, -0.8329662259600208, 1.5268672112207182, -1.0543427638693519, -0.7093283568610081, -1.6572608912707818, -0.3082545470720138, 0.30752777702550116, 1.6972727776553105, 0.8208747701396706, -0.9426097637453933, 0.032384318581485695, 0.7046719937690594, -1.120636723278286, 1.6870448096927386, -0.4823341327844248, 0.11193618630838086, 0.15261919169073504, 0.8008475203608404, -0.21342314371429277, -0.08063629759393998, 0.36995425276070554, -0.035587939503613886, -0.24587573320876205, -1.4387854128122737, -0.6198544368688864, -0.2621798104514031, -0.1618403547576297, 0.9113794862038281, 1.7803076526366581, -1.2007414321315348, 0.9794566655658596},
    {-1.4947237673426537, 0.3571057055648474, -0.07668143480034514, -0.2699419726756868, 1.501296794534876, 1.0719959014355276, -0.05727078314283963, 0.3858470283708074, 0.6688849142768901, -1.0341661948171432, 0.03204437998312534, 0.29209637796051263, 0.3048494948060677, -0.9606501300234962, -0.7864866227170662, -0.3682364496416658, 0.5125617262643132, 0.13435542543908305, -0.6563614235738722, -1.5228057753624933, -0.3170038182411432, 0.40422842470782133, -0.9934390614696395, -1.1802387936650076, -0.14560706710298782, 1.2772746268773283, 0.4909364661343604, 0.5774421433246033, 0.3556225663484134, -0.9414246465112047, -0.2770053707149138, -0.9708011314493454, 0.45728647027445385, 0.6826993961065801, -1.3023693457519467, 0.8369159707093777, -0.6611803277892531, 0.9534086229599148, 0.6336078653990813, 1.3137794828257507, -0.5699152360529901, 0.1721336218622137, 0.4457718002533937, 0.1295718801272882, -1.7039601333475187, -0.11337317580330915, -1.1282054422472654, 0.21346405932726312, -1.3498111729827487, 0.6856369668511525, -2.455481625086249, 0.5308427532885884, -0.8522505427635312, 0.7016519364390743, 0.5646278742522597, 0.9912103770413607, -0.37061086384002245, -0.09552637892823886, -0.018112334153248307, 0.9757216674251262, 0.703862174944589, 1.783917463378011, -0.30581281801002885, -0.7520357618295259},
    {0.19255911041702947, 0.457652318827277, -0.5699793858319306, 0.4804441596984331, 2.2425922137447167, 0.4742131750283515, -0.8547418101473778, -0.6447811632502062, -0.7513358192059396, 0.16922875537226081, 1.1177567570790485, 0.7059292191031571, -0.7369124482208406, -1.7064788177435657, -1.8902644228949854, 0.5270397477162078, 0.15327776517354932, -0.8097190790795449, -1.1040606340956562, -1.9300827551842992, 0.7176556457274035, 1.127900506609618, 0.5251503131955867, 1.859641570309498, 0.1566928684407945, -0.13700572524833002, -0.021786824406594088, -0.8814548006977491, -0.7052992287778205, -0.10038304601773941, -1.514685959859893, -0.28480243327542465, -0.12188827926777421, 0.2700642342388094, -0.28445697600104636, 2.0885420733661535, 0.30316251152919377, 1.0933689195160283, 2.674683035832702, 0.2160065577858322, 0.4716032869688987, -0.22958832808721688, -0.8484145279815067, 1.6832182260922155, -0.5614418325854816, 1.5829457822387039, 0.47589916008279737, 0.26628543608694577, 1.1392507870233903, 1.0114848483970966, -2.365152272443312, 1.6390393164959656, 0.41383058014685775, 1.8483951995003878, 2.2133631288270372, -0.8514239535644136, -0.9842911185025449, 2.049961120942545, 0.6882801800926891, 0.1941976827854122, -1.0811146368577618, 0.5254990268225314, -0.6079735685206672, 0.33385119697110366},
    {-0.9985074939333561, 0.49865130943197034, 0.4443170484253056, -2.4199778723491754, -2.438103947781912, 0.2418848365595847, -0.44769385179596216, -0.22157949791162324, -0.15190544591732721, -0.2928078781018912, -0.9657462287727123, 1.0448430648343803, 1.034819642206267, 1.2189528941100662, -1.9223787286668326, -0.055680794221651946, -0.004370951133783448, 0.1963209936074447, -0.7873799089123276, 1.6220511821901522, 0.23738385331336445, 0.2932762504155637, -0.4902879546656124, 1.3350761846878278, -0.06122564145635663, 0.6427655723946262, -1.0940389501980157, -0.509754909691843, 0.0971999142238414, -0.7521835631877668, 1.2164214665119149, -0.9227888974204401, -0.979686295149963, 2.130418042524612, 0.6615276524503866, -1.771591702480917, 2.4103433126849834, 0.27169382102462825, -1.0239822231337783, -0.1430119453839381, -0.07863914200793702, 0.14995280487837007, -1.2512657923850594, 0.15693512096688586, 0.23569066456592577, -0.5938430280990441, -0.35936824268142115, 1.1693683780360788, -1.2171844686080622, -0.9155931164976602, 0.9551456871521209, -0.6062508071946688, 2.05682208482635, -1.9514612763636099, -0.050592630062361296, -0.9425734281556222, 1.0275730558272476, -0.24344895064962835, -0.5330404339098358, 0.26634115952842313, 0.24722332845808284, -0.24277685016390804, -0.1385322271485242, -1.2701816814502447},
    {-0.32355476109801506, 1.152016408612906, 0.37592620436812063, 0.5163453389341025, 0.9143022485066755, 0.3580854632741382, 0.022924932459105332, -0.5296045121741993, -0.8139737091156324, 0.11258195964653589, 0.517449375628018, -0.16041629972036697, 0.44077684918310445, -1.2216526293318943, 1.0459556220811952, -1.5497700417583464, 0.39957792699851163, 0.04021726010891448, -2.234830050174989, 0.08341719138773512, 0.8296292418037343, -1.1251564641881773, -0.3643525070468216, -0.07912202843305398, -0.7649667008499983, 0.4829191755378894, 0.8239131639803098, 0.5131106999966454, 0.5410160535081373, -0.27237124569100707, -0.0720373664677353, 0.2153261018232808, -0.8115429750933522, -1.9868076038584266, 0.49090364100069755, -0.2286481442836547, -0.8032320565025823, -0.4619499343773193, -0.20428204983835505, 1.8932305604107857, -0.2735541539543184, 0.7975082745399171, 0.31655816570568146, -2.13196127775765, 0.464289573814401, -1.039822603056045, -0.0458474930814785, -0.011168244199565214, -0.1825961459383602, 0.8055248417718813, -1.1902161717812345, -0.6994172530758543, -0.534242259688149, 0.1567698723226596, -0.1801489752845746, 1.1570844346218516, 0.1672188034804451, -0.1452483718648116, 0.3263614186673449, -0.7049457920023942, 0.2152291393388766, 0.5056479817672376, -0.16085769326627852, -1.3688175662205424},
    {0.9711656752172934, 0.3081959148222428, -0.8712612258609315, -0.38916126214321206, -1.9253607310525038, -0.8096584655620942, 0.033077650684850586, 0.47028140306779387, -0.5315048535165304, -1.8244514519196942, 0.34199070496756206, 0.023854885986009468, 0.5120152617175886, -1.7188685253630493, 0.9390933317583606, 0.04431131134246391, 0.12383475807261159, 2.3585076253312365, -0.647944401379773, -0.7012148674740223, 0.8385979616570883, -1.2897870612883597, -0.021984986443830207, -1.1398932278287954, -0.8261134248591459, -1.9609507040971264, 0.8294283198479082, 0.4910319058380233, 0.41249630826647055, -0.8248925026272957, -0.7122495041514401, 2.627331373628558, -0.46429253417403804, -1.496044237517814, 0.45980358166128804, 0.3024124094453427, 1.2191503411847673, -0.5134558592660048, -0.24114357616317234, -0.915534099064951, -0.9878495628042878, -1.3428124279554323, -0.1753336007659985, -1.8466337009750484, -1.1536718823137837, -1.2098981916897706, -0.9406994248561861, 0.357461435782543, -0.34811620442290453, -1.0545467879924115, 2.0907181412970166, -0.19294878324689185, 1.506246300370412, 1.7529481956609594, 1.167545444707103, 0.5538384515454434, 0.7237878621525768, 0.03738583239753842, -0.23005396822728874, 1.0429320306937868, -0.32903790628460294, 0.25058449880635836, 0.7721616011119816, -0.14153633646355498},
    {0.6273049392359876, 0.34945647796134677, 0.21534053875357853, 0.33412360683551073, -0.7220394135648827, 0.38845754201049304, 0.3068464928639048, -0.46248823157617686, -0.7136897116137458, 0.15825910444545868, 0.30730865635854265, -0.8109580967538011, 0.19140968004987077, 0.28179937978613506, -0.16934904634437328, -0.004640108205498147, 0.6036270403659917, 2.1427973075467497, -1.325371940335521, 1.5373051158374593, -0.36858387200403236, -1.9031991141970908, -0.13766678182278788, 0.7599392037552193, 0.3945468137100125, 1.5761661766334616, 0.012074323245275137, 0.11495846057240022, -1.2424323967180708, 0.9867769075900799, 2.1015286758011844, -0.35070110101865026, 1.7092895640172512, 2.5766259858048497, 0.2596427116037666, -0.9243311886119516, 1.6297107176131975, 1.9885345175433278, 1.2256772260039484, 0.17889910001050965, 0.37966913069740915, -0.9424974881184062, 1.268985515076724, 0.8901123475668123, -1.4419654120423766, 0.22952503611383498, 0.4737321361103478, -0.7086903713077327, -1.5455898534438335, 0.25086674802553866, -1.4631400027989252, 0.14183703844013051, -0.18185988249094942, -0.03881959400225641, 0.5985670090457001, 0.05632823031143352, 3.211701654027195, 0.16515067343410988, -0.22213893338692023, -0.884078076967348, -0.190533859120809, 0.359896186533043, 0.7539559977912378, 0.5282635097866172},
    {2.340770214898981, 0.8269511660564554, 0.7362651830442297, 0.3565153648243609, 1.5107542106412921, 0.749174737962071, 1.0983793659837968, 0.29078613632641503, 0.31708250632456436, 0.23362761716850386, 0.0875494249136763, 0.1916850500133977, 0.17601630766013746, -1.0120793739798162, 0.6420374129579156, 0.4526753206299583, 0.7949248164386087, -1.1994520229984473, -0.4437691300246699, 0.7713818037724505, -0.9448659337571873, 1.230966540698386, -1.2376934312958785, 0.2050829909318955, -0.9591494592100823, -1.251153232013093, -1.3501647812483037, 0.8230031737588285, -0.52960198932602, 1.3437729715300268, 0.4192850331104967, 0.890158553054039, -1.750780554271752, -0.04301857022032856, -0.6026873829120913, 0.8885743688560547, 1.7754578107364278, 0.9331598043248625, 0.16965893149922773, 0.7459760548758455, 0.10518908674478626, 0.7699926993480148, -0.5965966456808007, 0.19962988039127344, -0.6599461801850909, -0.9193094739581066, 1.0193081621881241, -0.05791244728598486, 1.3783123844792518, -0.6654933442146095, 0.18193013659460178, 0.04020730809210091, -0.018017066792039897, 0.8626314722974208, -0.47038557399436454, -1.42063208929953, 0.7353243477233165, -0.11898532603345602, 0.12539323986994177, 0.0030335115310749666, 0.07149083766581332, 0.9242904068623893, 0.0638116247821034, 0.2739365733137167},
    {1.6364639472129314, 0.5184311895210404, 0.6294525058877983, -0.40702721748018694, 1.40165752716737, -0.8683422176629746, -1.1235377388445724, 0.7337471301493741, 1.4774130741154567, 1.8711636640857907, 2.451784781643271, -1.1852720145647748, -0.7244340753824091, 2.2391067585908035, 1.2396466690204204, 0.5655879478635827, 0.22618935703687856, -0.7200896443720596, -1.9494547655776613, 1.5288921672380087, -0.03364953420798511, -0.08767501033809062, 0.37856315903273574, -0.6017283846531896, -0.011316233680562908, 0.8983221008381203, -1.7009121249075427, 1.0327910143037056, 0.7279467869989033, 2.4758876698265193, -0.39400518806617324, -1.2486181357151689, 0.31047097657791123, -0.45742360259605025, -0.5192431565987814, -0.9886210828274241, 0.8885627838769455, -0.3872652134290699, -0.8345295787828149, -0.7389393970958587, 1.0650554038542268, 0.2654601597144218, 0.07984607585658024, -0.32738451294700255, -1.4182396830143056, -1.2771581603376871, -1.2382873977575732, 0.2740026601248331, 0.9166827309259724, -0.15081516207401274, 0.6558379394717208, 0.9532638547498221, -1.0538312982642928, 1.514576987684661, -0.7707436473447825, 0.29361161986595324, -0.42762772431836676, -0.6527028481434556, -0.26400309191151666, -0.8027196592969957, 0.3107613611028684, -0.19801862493307615, 1.1320347547083829, -0.9772355987567282},
    {0.7128501902335018, -0.07763319079640744, -0.5901229183437326, -0.749091829834591, 0.899071521671009, -1.2117745850762398, 1.5800490102429217, 0.9469470279514166, -0.16922541878557387, 0.10377864615000276, -0.4113730399408818, -0.635003634159523, 0.513143389471688, 0.019377134519016067, -1.099398654328257, 0.7432156840992218, 0.15741027060452753, 0.9119845256667943, 0.8872301488459844, 0.24919001308065528, 1.0739684458792698, 0.9054590757314529, -0.8727194211580088, -2.5813550236912763, 0.224460825220691, -1.2400822652017303, 0.5082690414433426, 1.1502382908927251, -0.06952132981882192, 0.740900919354157, 1.206655013819653, 1.1955729695319857, 0.4607688232366664, 2.456829821128602, 0.7499830298507025, -0.3261613562476732, -1.6059256262793755, -0.32968944347547147, 0.2814867911950834, 0.19468115196775013, -0.37356995567815343, -1.853663047654156, -0.3302776739675431, 0.1942247776101663, 0.025934121237157333, -0.3928589232652729, 0.008844263148422246, -2.10562552560109, -0.6144493019051931, -1.2852693922887266, -0.059596065204559845, 1.5460368560491906, 0.9099707868680127, 1.1322787248883248, -0.06975290319568467, -2.0981663948369063, -0.09638827765573141, 0.5764121966993091, -0.19626757087902572, -0.82235452431199, -2.006255875712434, 0.869335418358122, -0.8986678247505694, -0.3180925706111462},
    {1.323207740220066, -1.497358715183046, -1.0501683922361396, 0.6682839871045666, -0.2479945926302448, -1.635308994175747, -1.6234198957481223, 0.4375997352615922, -1.1122640069522283, 1.1044136051446625, 2.088070452555551, 0.2536941152119006, 0.09045985903259726, 0.9466291570896178, 0.6884688487528727, -1.0578731032404127, -0.14636463432584393, 0.04437797443998757, 1.0154796847892, -1.7727734836363522, 0.39404614680548605, -0.7389236322239132, 1.0463634788728422, -1.413737412425826, -0.19842694671244931, -0.29457243051015636, 0.6914883673683799, 0.6367939424317692, -0.5775708295249038, 0.10730339451719818, -0.38375217648631627, -0.012530987601527585, 1.7848713103143656, -0.9344384539922581, -0.4167156233329033, 0.12453974481987114, -0.9102604939290225, -0.6869931015374965, -1.2300123841883743, 0.5878658516239859, -1.3392038667872046, 0.6279734938722488, 2.100144661593295, -0.41475368613111624, 0.7776810114804221, 0.7520856516035568, 0.5384086112190531, 0.04546350195564895, -0.6998342133374367, 0.7840870231442719, -0.1644795283614822, -0.14526816858830435, -0.5496750207397773, 0.06926191241477433, 0.16300439747283102, -0.26129039742669913, 1.105649000463251, 0.39544150132848405, -0.13122196520043053, 1.5972362159704558, 1.1338523271878085, 0.8424362454678257, 0.02191285584641172, 0.07667025565294218},
    {-0.15257346076284684, 1.692907631113661, 0.7179496519601145, 0.4464723159103834, 0.32936373299615596, 0.8563214784137821, -0.8470201107535044, 1.1419117597394346, 0.6407988060948104, 1.776754530154197, -0.3558257154466676, 0.722444824037578, -1.1776861987745515, 0.2785240571748748, -0.1975427769013047, -0.050740200226722126, 1.9896497512582711, -1.078498929385122, 0.048524444576547344, -0.5618536182466799, 0.9241462731334001, 0.6132644610685487, -0.5003918749249746, 0.9751783303428945, -1.2208662151198273, -0.5183202249638895, -0.480251450836491, 0.5162517145931966, -0.4922191423633527, 1.4734546825837884, -1.9187916835720427, 0.15103008638406848, -0.2180009375991911, -0.5589140285507503, 0.0881508125362889, 1.3583182164428518, -1.4423135223683676, 0.36138240722497894, 1.8492810205680923, 2.456326996164467, 0.2473951840686901, -0.8971751824113924, -1.0418202403903227, 0.7211354891977094, 0.15107426109153477, 1.0320589056628713, -1.0796523411685541, 0.25459588136766653, 0.5015098086908664, -0.8642772421012558, -0.648943553038207, 0.24711124891423575, 1.602823638950141, 1.5812660788288326, 0.9416558585452308, 0.47793319155804037, 0.7185038425912222, 0.23515693719998454, 1.05161840903336, -0.42005556883939116, -1.749473199246686, -1.3390207071555287, 0.47633572416666714, -1.1238547644860182},
    {-0.33318518974863776, 0.09261030526853807, 0.23065833318003678, 1.5998472687682013, -1.1111520262892907, -0.43263787537451354, 0.6056702467535917, -0.13661288307259317, -0.41115326592055446, -0.45283003636057667, -0.752324907717938, 0.7555545726467103, 2.3118435812953497, -0.213408664668331, 0.30065582476588804, -1.258788586379185, -0.8564757034141961, -0.31573703531700303, 1.2776260995050903, 0.9831271368330858, 1.8928627320290226, 0.7416930978094826, 0.9218698689472217, 1.6665717965628504, -0.9314304574492019, 1.743109290247392, -0.9864826547317569, 0.2958116286367198, 1.2369668428491585, -0.27700018294268786, -1.0394049645052625, 0.6249443140801013, 0.3285204640338219, -1.6321152893543578, 0.16571728437267494, 1.363999685630768, -0.9311047894715083, -0.08771064174608538, -1.361132122469935, 1.730068282500499, 0.8137092811377723, 1.27007084765511, -0.3658849999409603, 0.05890253972404077, 0.36822620212316326, 0.07965817926008405, 1.1087607924575906, 0.6900386063850714, 0.9000185813044702, 1.4499132209223518, 1.0794139698147083, -0.004874921379122885, 1.2443404959185103, -0.9325703088316022, 0.7991550565498207, 1.5809014036683429, -1.7785368742468648, -0.7513044125789539, -0.04227539074874235, 0.5343515897828144, 1.5041915569970619, 0.7821762466958817, 0.6565423466514447, 0.017347824372573276},
    {1.1093414031994173, 0.9099841182423362, -0.5869958786569199, 0.8658273197540055, 0.09114613962347305, 0.11075696881621094, 1.23747550662399, -1.0202696580575088, 0.1926959824722771, -0.17592277305003812, 0.14900559627830817, -1.2179532808163385, 1.2340994568976358, 0.5133548994804032, 0.46777022711136873, 0.9701480766085682, 0.12206681335968346, -2.5960369228728823, -0.4896696364908283, 1.271094633364154, -0.7767612922778017, 0.15706529435411337, 0.8353969505791452, -0.6803659893735061, 0.05699111107804472, 0.3854687856040637, -0.6806059278797565, 0.42394833122962794, -0.4744900454256295, -1.212154758571832, 0.2794468074820281, -0.2335567196800201, -1.189620744910178, 0.16264503697946373, 1.0479849779481634, 0.23602293854710413, 0.3091647223489354, -0.01212474070670857, 1.1907078412995964, 1.0966860397342495, -0.5687237165205192, -1.5676525432174697, 0.011571399805439319, -0.7258304641119414, -0.40801798547950535, 0.25731416967829857, 0.008165924392326846, -0.4955291747435276, 1.238752947759469, 0.4321281670256723, 2.145621144165984, 0.3123180871743242, 1.3390716976992536, -0.1289394756981675, 0.04488866686722364, 0.06286765660815621, 0.13170163667602622, 0.6198349312097026, -0.39738844972066456, 1.8141083199688928, -1.0564679158399635, 1.8367089787598425, 0.7062700567923675, -0.26030526301097917},
    {0.8096636997011258, -0.033686770388362056, -0.12340048029615899, -0.8524347350268018, 1.5207187937354332, -0.6978135429724648, 2.1813831502085113, -0.10118361026998539, -1.3195681725694626, 2.8377159899394044, 1.6262945869935719, 0.5778661963985223, 0.0008007281437427087, 0.49719254826260806, 0.8896958555290735, -0.8906542610901681, 0.4299449730039486, -0.10401305515494484, 0.07836876562350481, -1.051315834813121, -0.8566175244650022, 1.8735319776451116, -1.1379383513140802, -0.34118887676094445, -1.1612604615046973, 0.6030806211085973, -1.215256980501145, -1.7261846671862309, 0.8608238522199567, 1.1836879538181981, 1.1251079917717184, -0.863996703979943, 0.03598178197420094, -0.6057906478455075, 0.5007732184700469, 0.26074442950250465, -0.8798558434092469, -0.506364783711296, -0.918834535795687, -0.29643366742847443, -0.7529474891092255, -0.6951480983256724, 0.9627714879311113, 0.7392966118811107, -0.9214706821924441, -0.28464859376411006, -0.8587442528442314, -1.0987081372909158, -0.6941017943493931, 1.6636192533885537, -0.002255276560428941, -1.8237908408768353, 0.9011135646030545, 0.5772945045886582, -0.0835910117447331, 2.6441252328071703, -0.3056668476441747, 1.4408547529944087, -0.8172283173113196, -0.28813839784354206, -0.12468830303523988, 1.6679515024117846, 0.3048666085540476, 0.633823193638686},
    {-1.3791511796014173, -0.2434198310243442, 0.5573575117410964, -0.19683498461214083, -1.4235032806735692, 1.5349935270088273, -1.0316622745564892, 1.1030483164115514, 1.1197607745829743, 0.982206732627526, -0.21253970994184435, -0.11646440218318473, -0.7305357378351324, 0.5422639086627123, 0.39447969658389487, 1.2024698098009745, -0.12029298387836275, 0.6205555807495766, 0.7733638470592759, 1.202076264951996, -0.774953474210141, 1.775618817443928, -1.1688551873024975, -0.6848135988243548, -1.160846375700564, -0.2512771557146739, -0.2501389304623722, 0.7627576364866652, 0.06254790220667425, -0.5270133599633038, 0.03043680173117872, 0.39479516786174806, 2.313963474961252, -0.5348121387333639, 0.11187779030329038, 0.3590744227006998, -1.468010916901459, 1.844447758819646, 0.15973848183882783, -0.8938287646016033, -0.008145709016349327, -0.4355651960260427, 0.8442970334336005, 0.350196099619301, -1.63965406919997, -1.6503594274524997, 1.3910508134850625, 0.21180611585746234, -0.09583810118116098, 0.34380203697674905, 1.6741642207185055, -1.327198249732713, -0.67339429353713, 0.06961301615476223, -0.1856240119229489, -0.038370293343229396, -0.14469864730795903, -1.345636219907741, 0.7665614315053562, 0.5152348371542266, 0.13529904463550987, 1.0185828889114263, 0.1037848895158681, 0.5349889691979497},
    {-0.5796615044360859, 0.06587326239208578, 0.6951847382652645, 1.4941300146204486, 0.2882362067710495, 0.4216390392598005, 0.511103966413002, 1.7385381396348611, 0.46153298677499627, -1.199284735662654, -0.45977273764648297, 0.34596515545297074, -1.7670447206263018, -1.055813033260489, 0.76895567527989, 0.009404308248023423, 0.9348781751578765, -0.3084905652578055, -0.543462449253694, -0.35897288016122997, -0.46497609376123344, 0.45315296557946666, 0.16087974237693486, -0.1761744748998071, -2.2143233106162983, 0.751812178207536, 0.8894116163767156, -0.9245737425105802, 0.4021377883490605, 1.2133728128539167, -0.8004423784433314, 0.4157978412754894, 0.5566764776693978, -0.06316914889470525, 0.0735084570452731, -1.1321057433877102, -0.29796221402058015, 1.3009311573659943, -0.2878544442802726, 0.2735555112519423, -0.6303227280917874, -0.019191290328877442, 0.8159241741487163, -1.8839161539686422, 2.1413040615663683, -0.5358898210269519, 0.7315633139803308, 0.07879568911408161, -0.0399637492711525, -2.3756338166424413, -0.8309317645725802, 1.4181898232389833, 0.462109125462441, -0.7455645081643397, 1.3939604694144085, 2.173301486192479, 0.31833838535608094, 0.8895306502042626, 0.4027011977209546, -0.6587446891919901, -0.974821736276748, -0.6648601366584048, -1.0263031750252694, -0.11494174587753786},
    {-0.50038731426139, -0.17255826809570435, -0.5582844187303283, -1.4787488064147467, -0.8904910480303774, 0.15841000221724744, -0.5468909108190391, 0.7122477944439233, 0.2828259979974835, 1.1141783219166859, 0.4324922315973986, -1.0882013663906858, -0.8664715762004298, -0.3068819142011696, 0.6556072545559151, -0.5555712332312694, 0.3760404330379299, -1.101553230318849, 0.46545477702105353, 0.34050792958605763, 0.38739401787837213, 1.4088183182264697, 0.8754301995004722, -0.36340805570311846, -0.03839172167176523, 0.8708179293718706, 0.24118667186600848, 1.0101172361814947, 0.7083673536652622, -0.25909936344966755, 1.3365250462580751, 0.0911101227167637, -0.3849675802363088, 2.2342797807998345, -0.09212094548287099, 0.7673087263281962, 0.28940384172613093, 1.4332729070581383, 1.4063613641570276, -0.0250354800631424, 0.08921981973300447, 0.24201731612607252, -0.9079749245891793, -0.17467040766077685, -0.4665931245069885, 1.061255406002273, -0.4943606249720542, -0.7242315479988035, -1.215314485965177, -1.2403017907715985, 0.7600873770453381, 0.008546777336523467, -0.09386503833827992, 1.1179271572743021, -0.9999267275073987, 0.21973945051221774, 0.9161031186694346, 0.5528142477208996, 0.9033134372243073, 0.8278105385614734, 1.0227264638566864, 2.4609483082931196, 0.5762059575590033, -0.1744402968735937},
    {-0.0538966255690061, 1.590789671621247, -0.5830822554942884, 0.7584632370114661, 1.3136196599020793, 0.17809915792600117, 0.20292923575696534, 0.0015046998934817961, -0.7731072443676571, 1.2718064232600657, 0.6331076483059032, -1.4662477969707537, -0.048064835221800196, 2.3340066951683616, 0.7169844256156337, -2.9831664706707204, -0.014491583878306126, -0.5050234680859715, -0.10688030749295392, -0.5651998805761628, 1.4546114213652133, -1.4163541887422224, -0.027467728504998356, -1.6264013666348902, 0.2732629751974918, 0.07728522044715354, -0.2478348772577105, 0.9839154582829546, -0.054219317111386896, -1.1636158803884866, 1.1634326844686624, 0.000300626069451357, -1.5869949400197918, -0.25073153244674895, -0.21419622067406507, -2.5076947136942223, -0.21031482744263125, -0.15771645896886227, -0.6882535456348652, -1.1220154169983287, 0.005092816955257639, -1.5034008546427273, 0.5320735843040543, 1.1652988180774753, 0.2888114841491511, 0.2852435493577251, 0.008167747855255186, 0.7175486341985201, -0.18852927334717065, 1.7007947314069523, 0.5739379642877509, 1.3128218136135044, 2.3438466850929083, 1.0935818943048725, -0.540026892079947, -1.6145385053003902, -0.8334379182774578, 0.26236510492575404, -0.8397196279034493, 1.373832202147336, 0.43702339815825236, -0.5791132840556016, -0.7499819650485494, -0.4864471483519215},
    {0.14343497855390389, 0.30880665494419907, -0.5335591843698134, 0.2748844926680153, 1.6766279232329466, -0.7519925080018068, -0.9170765437056121, -0.19812579911049744, 0.22712159419187508, 0.13075525846942265, -1.275042225369656, -0.10512384513824409, -0.12268036431907552, 0.9056343312967932, 0.6593128730527219, 1.0604531783234679, 1.430686952887492, 0.9543607753586942, -0.9893496101057534, 0.8114879566831414, -0.256584589133031, 0.25641266232968385, 0.42559029816664473, 0.5995564543178834, -0.15128821228004477, 0.8750345560838203, -1.2218639018365773, 0.8242631113879597, -0.6217410705770812, -0.18352846591973881, -0.5682802013483897, 1.565813024670603, 0.3157073564121127, 0.9039953030010606, -1.6195824556310323, 2.812512911910345, -1.2507172313208548, -1.4065863180766627, -1.865239562367546, -0.06955028483693709, 1.0445401227620421, 1.3963568557731556, 0.7970714635895407, 0.35433800725043413, 0.14880371544027043, 0.06719762674785515, 2.551019381011663, 1.0313688493107345, -0.7781139162323645, -0.2692176637156921, -1.3036325090682452, 1.1878680157590644, -0.47684838608270236, -0.3111870500818218, 0.07631794912105033, -0.07528981172281562, 1.5407128680239317, 0.801899940049164, -0.08291784618570291, 0.6710787808521467, -1.7959223509382538, -0.11850493343987441, -0.5739458467454964, -0.5607649441266348},
    {0.8098437672507293, 0.5066203790090844, -1.470847306422441, -0.17672431805080052, -1.9611665529573843, 0.6651454090375218, -0.9882393196307212, -1.2635279563760933, 0.5243623956249598, -0.025125642151522742, -2.1335387461301334, -0.5587657604971825, 0.30291194141418615, 1.4459572442378772, -0.13755955211645002, -0.4063066289789553, -0.007659790170323358, 1.0003464895698342, -2.0549711983205046, 0.2801817177216858, 1.576992159836018, 1.0444134712238133, -0.9594599888610127, 0.31508745374931496, 1.362257792300275, 0.12759553919563957, 0.09180884190389152, -0.7007388737587956, 1.4297837601804233, 0.5902684225941298, 1.6662680048558904, -0.5816774272092312, 0.16365372691608318, -0.8966182435312982, 0.9237151547912252, -0.02333369357406083, 0.5604274395081158, -0.8115245607801546, -0.9375582619836433, 0.834590081662636, 2.240961603072494, 1.0200169899641096, -0.9636344332364247, 1.08663986256006, 0.5402803986152511, 0.6510449878097303, 1.5010767493268098, -0.30289746647700894, -0.42385366706005945, -0.23005443731228947, 1.5327691915507586, 0.1744463870773095, 2.4179408445351975, -0.2320287222481428, -0.9530494390866233, -1.9780134832686798, 0.5733673320723519, -0.13222969268107995, -1.297944475483434, 1.3741398622438314, -0.7451393741619595, -0.12946812799162358, -1.9663848395875543, -1.419684988819007},
    {-0.9329195791639543, -3.136798856277054, -0.3423583562234432, 0.9169724771810752, 1.514930112779286, -1.027379055528544, -0.2198790273171298, 0.3381530118722777, 0.5015413844939578, 1.0706201945379341, -0.27503247988528157, 0.11247283864261393, 1.2751609760237033, 1.3657573369959943, 0.05298420455378743, -2.0605496161897, -1.703768048282574, 0.40031507752714635, -1.0427420916603263, -1.3063303381624176, -0.9994406470056869, 2.8534760980526377, 0.259954984039153, -1.6157169717500284, -2.2195017943116553, -0.14030911360553516, 0.055098391749237544, -0.672503028888189, 0.7774172950090177, -0.23450889937449673, -0.41616543823637986, 1.1514458333552546, 0.8653666381103465, 0.4758362552454248, 0.7062772997718534, -0.5697203952368961, -0.17584834304552213, -2.07689730270058, -0.32391080529449917, -0.2670111922851602, -0.25378233067850525, 1.013546866521084, -0.32423020510673295, 1.0530547696906607, 1.1895839888620698, 0.9977671703235103, 0.1338123084062135, -0.6950031598012518, 0.2397295374108144, 0.608332778424386, -1.2826514767461166, 0.042049617350927694, 0.45990492978604697, -0.013367392411005768, -0.0611827426460477, 0.6865998938152927, -0.558802998246404, 0.6711645219607928, -0.8508011678501893, 0.01888866169395319, 0.7752780052875166, -0.4938092849193228, -0.4901867407413759, -2.3296880080776066},
    {-1.4169765424905532, -1.240986887409688, 1.5219775901596546, -0.6147532095105266, 0.2875412126939336, 1.6802917299014275, 0.6260027634198823, -0.7173776053951704, -1.1064778593243407, 0.6482631072246613, -0.366649474309482, 0.8486330177896128, -0.05845154742982322, 0.49515551055523077, 1.8155341722575453, -0.17925087872556486, 0.3656097622242821, 0.6073189885670556, 0.43568022694419284, -1.5549534194391665, 0.8555980189125033, 0.5090020590543768, 0.3090955907305733, -1.4102212628438442, 0.3718580397456774, 1.043835749893264, 1.102134095576724, -0.4798045411239456, 0.7331336521900951, 0.13910687206097253, 0.9863112229535275, 0.2495594762591405, 0.1386094220310423, 0.8247607306367973, 0.7909720840343396, -1.9933369175766957, -0.3059452414296014, -1.6523143160228713, 0.5785244991734707, -0.13513657198301499, 0.6138027408678186, 0.33980909627444267, -1.1317265872171127, -0.651972546869674, -0.0878509962127076, 1.9770079901896407, -0.584402321347549, -0.1250361137861468, -0.1709579752911079, 0.7959748477020056, 0.451342996850421, -0.9248525728331946, -0.7577858662700229, -0.09937059167534389, 1.290556651998341, 0.34660365059624504, -0.10096316550016561, 0.041358952303847014, -1.1826404144246805, -0.975033355287748, 0.06171855401655388, 0.7247026043474798, 0.3401151240116688, 1.8514389120787917},
    {-0.6036531375724535, -0.34851348258613546, -0.5601023724092504, 0.5244767242536226, 0.28776617992076925, -0.7990236914176939, -1.0994224937037345, -0.4782586595581057, -0.12492402964778011, 0.41196584786497886, -1.0794227231837226, -0.8037403673311712, 0.709959687589056, -0.5354986053232785, -1.3803424732292024, -0.3207516616756225, 0.1739451234621395, -0.6388856544205486, 0.033260123919833504, 1.2147217943512043, 0.8561192822371064, 1.894535732771544, -0.4172717880950655, -1.8483411021141936, 0.6850205165268023, 0.742569509158898, -1.8289590758062269, 1.171157160173522, 0.49631698603940705, 0.44207306364358034, -0.8295571119432973, 0.2089183390018987, -0.7581112210067493, 0.5667780347385694, 0.987798160819783, 0.9574124388049252, 0.9497630477255284, 1.337486643916396, -0.545639213385428, 0.6394639293150072, -1.0410087329327442, 1.5371699585701877, -0.5295819204344938, 2.167400993916919, -0.022731342367938785, 1.0362419821677986, 1.2288554888905228, 1.7673128898791173, -0.7125573833735815, -0.12800858688507155, -0.820679936273835, 0.6370322622111835, -0.16731979215046844, -0.8092901702459764, -0.6070112845852319, -0.6988039668363948, 0.7300431804918212, -1.4394094471200722, 0.9678971273972165, -0.33325223342074956, -0.3938583364422731, 1.3995813857256327, 0.23664365697625916, -0.9260515365679728},
    {0.49984505808153556, -0.8524383605897232, 0.7830394713301532, -0.7483297080335678, -1.8687183300865928, 0.09148501453365399, 1.7584885486438442, 0.17785475244585006, 1.4235123451117515, -1.0304192623899984, 2.184272099897675, -0.690871651213526, 0.6494250208889493, 0.8150266742683578, 0.7340225511546531, -0.6460998637302541, 1.2729897093479923, 1.2260439176698792, -0.9526821531228384, 0.18611664156593655, 0.6665018162811367, 0.1545558792395136, -0.6752217373209343, 0.9090084403935689, -0.8599086319207863, 0.9608846595648054, 1.6505937889484321, 1.0925687431562514, -0.8311169707517275, -0.013796148123053726, 1.019015478504496, 0.6755514085614139, -0.4122968832311426, 1.245509877803817, 0.39365278173629026, -0.09474124213075127, -2.4213623360928183, -1.3260860307571585, -0.878112859716719, 0.04665443220932414, 1.2784654103842028, 0.1854767997542464, 0.29491301564168876, -0.5257072932547764, 0.8944513468997799, -0.7352316537003039, -0.05436571647818793, 0.4092995506389154, -0.2564082380473969, 0.8645828444879305, -0.9191261073511887, 1.3825505591528575, -0.6002398968479308, -1.122448380606429, 1.4313290309376487, 0.721120206474892, -1.3469577332499043, -1.5378604876499038, 0.8364622538634297, 0.9771151539854654, -0.34048721141713073, 0.9900182918610241, 0.05396883782276201, -0.6941280556990203},
    {-1.6990935867431145, 1.2392441539353964, 0.9273632288088709, -1.094558272086964, -0.9815099631210972, -0.8288527687625253, 0.15105625645282486, -1.4611083967617342, -0.3943577348721115, -0.37218032003086726, -0.09725706264482868, -0.03824842424152023, 0.49350947979804244, -0.6274250702844058, 1.2895541648650466, 0.10054062563155802, 0.028967725158078012, 0.23994963614526585, -0.8426997623578037, -0.10196450351743427, 0.4540633367012107, 1.0909132247161908, -1.6475902965164897, 2.803637369198395, 0.652270713794582, -0.6084839119029425, 2.564565592117568, 0.075983910486837, -0.18608053923136728, 0.7670337178819384, -0.01601208379932167, 0.3128054675125361, 0.5795841868540643, 0.6278010430130087, 2.0587159870535565, -2.1840708695436533, -0.23692966991498945, -0.9559807422022962, -1.0556367801413815, 1.2018194088886114, 1.1363845567151607, 0.591455422657023, 0.17140458858484187, 2.2871014099167053, 1.0745142629713924, -0.759423281729342, -1.161705015205315, 0.5658037359397061, 0.5753868078557256, -1.1458069414481087, 1.2320517912326279, -0.6295060631718468, -0.20450565673372606, -1.6515048166474267, 0.44852640911519903, 0.9613508405623102, 0.00757852019486071, 0.19853789676716177, 0.11514176386001959, 0.4266207898692828, -0.8945967082089646, 0.42684357444922344, -2.0834239381981794, -1.224162032875398},
    {-1.036279586163292, 0.4459593876037714, -0.06778352014713847, 0.5247755242393913, -0.5348675852441485, 1.9368572511027076, -0.7944781571062127, -0.9031807853007665, 0.678518291288921, -0.6295167325684169, -0.018520757311948497, -1.989867269698967, 0.8960060135902982, -0.6180371870153256, 0.5584010505883404, 0.28841622573961373, -0.8897364829808314, -0.8265219457616131, 1.1354997203111123, 0.6030640592875459, 0.84358280839425, -0.19294067285927782, 0.18561950660153226, -0.5502729009087234, 1.1856821771560646, -0.44588308793849113, 0.43673503629653593, 1.211766139228469, -0.440566328144084, 0.017693550088173218, -0.6274135724744099, -0.10201061560063925, 0.2139926272207464, 0.7106967767581907, -0.8668077892953275, -0.12406806530207812, -0.347282229649776, 0.5542021370009061, -0.13398911102950972, 0.32098684906759756, 0.7727164857807328, -2.0648012795794286, -0.6867016012054193, -0.4510561242258143, 0.7905119089070093, -0.06669712510907709, -1.630022373755295, 0.5486560099392936, 2.4186392604668896, -0.10617888731970758, -1.0084148073880828, 0.7314344491376753, 1.0743180187033423, -1.4291018179276902, 0.6993012408217929, -1.1621051681121206, 1.6193481488819974, 0.11351965267051896, -0.0725997513420237, 1.6300849874310293, 0.1653532309478143, 0.2216739646894471, -0.4930134723455715, 0.5449475983944677},
    {-0.2812825546322533, 0.9038628741565962, 1.006774335440719, -1.1506394471730323, -0.42126509556986996, -0.5765492098592656, 0.7902432094155584, -0.327964330932749, 1.743069902343689, -1.246453170441932, 2.3251705090854893, 1.3393231841276663, 0.4256209639026339, -1.1616819190967336, -0.8805630382149838, -0.5761379140362574, 0.0008758109325493855, 0.7556287239111333, -0.8435760965885818, 1.623165646492111, 0.3085416226754835, 0.08590751996364275, 0.2238414605651142, 0.3276299936610023, 1.648445204157905, -0.8778478703501507, -0.7939639057743986, -0.1936742103978723, 0.4228474114519042, 3.2162595027159915, 1.1541203534075146, -0.144325602612229, 1.0201883529699798, 1.1371276214561565, -0.08053855198726821, -0.523660649631512, -0.37474693303270146, 1.0840619362017503, -0.8690233197796328, -1.208574485002752, 0.8445829587321922, -0.09247417161066546, 0.761721588895723, 0.11552673034545087, -0.32723200224792953, 0.7759449209991436, -0.3304020342519835, 0.19395679496477644, -0.3245866439583349, -1.6964383289580498, -0.7896386375957192, -0.05354011058272952, 0.8423889853141242, 0.19810311714952167, 0.7273130797497926, -0.15179314071983227, 0.24559089662083902, 0.37693030474655054, -0.5110781120807469, -1.6988187754234274, -0.4574017136356629, 0.8972453791162095, 1.2038671252657707, 0.09125708059129366},
    {0.4393938264806984, 0.08953116310455073, -1.3103250280670982, 0.3393714243824954, 1.1320012403746345, 0.372141543795324, -0.004680254359411755, -1.3983508105124298, 0.6081531677322356, -1.2454472138781065, -0.04651754231553935, 0.6869091652171121, -1.1191841684935928, 0.7134905788990739, 0.2719593853448122, 0.4747548020316608, 0.23217573911004344, -0.055234459759308734, 0.030266856764884255, 0.1768356293343876, 0.6784560078863909, 0.7143351429066621, -0.7612465089337433, -0.24234993284642437, 1.255872836436878, 0.3641221481691685, -0.38023944048162034, 0.37521505962666424, 0.08911521510400257, -2.022326131914147, 0.14807536937132412, 1.1462669307913833, -0.6947830972808884, -0.8401671224664147, 1.26330890928112, -1.8856301081310998, -1.1679359507685216, -0.12912250594162727, -1.0831942579986729, -1.0375530375376905, -0.8261557073075757, -0.3657202327633203, 1.5856945894621224, -1.3803766363161798, 1.180397438303084, -0.46356593355070963, -3.3743617381119058, -0.8574281321155818, -0.9307232007496764, -0.33376712888705384, 0.29189844824838473, -0.2636238143241223, -0.9030981799213367, -1.3312961371620768, -0.6115725595033981, 1.1306689248444655, -0.890734791190069, -0.6638424433621948, 0.9328978222700971, -1.7790981332936628, 2.134064174321874, -0.4167659850139908, 1.502616497290239, -0.6903758827894654},
    {0.8156563485242293, 0.14176820118193326, -0.02287058708471277, -1.3912717934262817, 0.16727992322419694, 0.9431358371102903, -0.1298105662801644, 0.7487232424805125, -0.02046159682682079, -1.5108254419785085, -0.04993716766087692, -0.9639173343233383, -1.0451586697522728, 0.388822921073113, 0.020963013924324918, -0.04118887385061757, -0.15507516112248673, -0.363111277771002, 1.140459845175408, -0.05393132611443304, 1.7936564525392116, 0.49481567738355525, 0.12051648567273929, 0.189625115728991, -0.21649503176517357, 1.8260144204064785, -1.0047837196517206, 1.0636766577646193, 0.6219533776947087, 0.35387587437791823, -1.3391006608019598, 0.6863779617533058, 0.6931956685981693, 0.35976244322683765, -1.0273228645128292, 1.0066055036131478, -1.2171925033497957, -0.10918000993675393, 0.3435309705478339, -0.06343944308620339, -0.027622383856000406, 0.5745334750152686, 0.05883055767842589, -0.14128805124033011, 0.9017624432062118, 0.02059033381515428, -0.11830947395036828, -0.13740163752827997, -1.7038562746834203, -0.17633433164934767, -0.05203677262768851, -0.5176343005582617, 1.3067502317473365, 0.3357840837191968, 1.400398475157127, 0.30741431550850673, 1.3051574590319166, -0.5728355687969743, 1.4238801703364767, -1.3899593608444207, -1.3659442244978168, -1.5217068569228678, 1.7275152956047972, 0.9264400704827431},
    {-1.1338348483957315, -1.264925603996924, 1.2996076406761143, 1.0999317783382514, -0.4642625275878026, -0.6867923104609444, -0.6864627646508173, 1.2145660326619871, -0.7233173832626303, -0.26521540708553676, 0.4623377532698105, -1.1126123568908286, 0.1294250375351489, -1.0133399973796093, -0.9498903908451488, -0.3371773495434276, 0.23388382676174208, -0.4729741891027557, -1.3331466044939908, 0.8053624301474586, 0.35056630346839257, 1.837711976099639, -0.35460561881064573, 0.46737549546550844, 0.3801637556487925, 0.1330210603571815, 0.4397119296591786, -0.8741684343600575, -0.4998708051236382, -0.8223485273034217, -0.8048711843773196, 0.2724152743553436, 0.5451150907321338, 0.3606096792910721, -1.7037779884513, -1.1051564575886101, -0.10819721204107802, 0.6812839402378322, -0.7507143619431812, 0.7667258166773159, -1.068626297080745, 1.2964960716834535, 0.8279349984118458, 0.5693394725530647, 0.7047608026442861, 0.31789456533759697, -0.6447510911100593, -0.7116966037691684, 0.7729952302309058, -1.0699258834217213, 2.6389997528184, 1.5652191686626606, -1.782179653728653, -2.121574636587451, 0.11748493636827569, -0.16081396602198086, -1.4051811228464588, -0.5323973573477064, -1.0204759971364108, 1.0195485432948168, -3.018000214646187, -1.4733546837471412, -0.6454476333660291, 0.2782075801453064},
    {0.6892509666513268, -0.6490875732332761, 1.3652668842261626, 1.2837029768022874, 1.5620707606275062, 0.28851869362945404, -0.8675224520300866, 0.6490226808906743, 0.9466556066130141, -0.9235656277804248, 1.642248171323685, -0.6661030388532446, -1.22749526390238, -0.34832223902954906, -0.49135362609484656, -0.06005613429550404, 0.5030541956134681, -0.6328298457426365, -0.9899350165782858, 1.2563946092629479, 0.4330771902214541, -0.11056615522305743, 0.9423347816601498, -0.061046208978988076, 1.7369669880988174, 0.7110406295340225, -0.04579465523405747, 0.5494615739454337, -0.6097897897285302, 1.959980376375, 0.11196434534008365, 1.4209288213632885, -0.428919043701245, -0.04040092944707616, 0.5124111452868861, -1.0221987090435591, -0.7763696733543395, -1.145065905420779, -0.7598078614180223, 0.4192825815528468, -0.6218109665294611, 0.403442146668385, 0.36383900753331877, -0.0373081652072337, 0.6001638813936879, -0.5728491648033128, -1.1649313120721534, 1.1632506106229383, -0.7173861665795404, 1.6505533498348952, -0.2898568109496994, 0.004146550176652361, 0.5628314478644165, 2.2065135170912598, -0.13729960200675972, -0.24912218153482432, -0.48766251058905546, 0.9315368872928431, 0.5145781615920636, -1.5015561053751043, 0.5699269667659654, -2.143756541311031, -0.7133411846106266, 0.7120430486782483},
    {-0.13546898469839405, -0.9255634837767456, -1.2257467831671187, 0.6275928356909306, -0.24319218286109714, -0.21666898238089458, 1.044379475156595, 0.444932337474948, 0.455869351610076, -0.34920105300766324, 0.7925970880403299, -2.5421638904162362, 0.36160899709322825, 0.527373330896505, 0.23194493635225658, 0.6337089928498786, -0.8359707288422848, 0.07293859533645436, 0.648325120600489, -0.2089593383573395, 0.2683265521190599, -0.7063395541329827, -2.6433469005640737, 0.5171953504197002, 0.3873659950107086, 0.5858076007582257, -0.8460541095202126, 0.5352854454387825, -1.0871173539424184, -1.2418901411960648, 0.6215597142826892, 0.11030473954722735, -0.6752984063929385, 1.2137383932385364, -0.4885872831742172, -0.02612950068669162, -0.850390763017386, 0.3094804155556118, -0.9842175732452119, -0.22116420513923343, 0.39851215871846185, 0.28742634305243203, -0.1232424000510291, -0.18848474898940576, 1.3343934094479535, 0.6429485897890024, -0.24627015366668495, 0.7685933782246518, -1.0647644079936263, 0.631583206817208, 0.98752093430863, 0.1201106266579868, 0.11331798855691683, 0.8448658277166208, 0.7366288802513951, 2.1237876732626164, -0.01626044639674452, 0.7307860887650743, -2.2724186039077634, -0.0049216769316010765, 2.465286286250713, 0.023831499548506115, 0.8671406374077434, 0.11629920694998895},
    {0.3442672653592014, 0.23171153697831964, -1.6840942634865725, 0.2523593482800774, -0.5809308296844761, -0.5787894310088, -0.315270948048258, 0.062318642115359243, 1.7890941442287172, 0.5324969170263254, 0.43529311779117275, 0.06259764228234133, 0.6045834433534476, 1.3266771832719482, -1.1190725403450688, 2.966952033490871, 0.15289708084683412, -1.7188096178653793, 0.3571533008119534, -1.5724231684766732, -0.760178207226742, 0.027737126852359597, -0.7320603805130969, -0.034393465710129405, 0.49875973386492184, 0.9991510143467418, -0.4609459447797638, -0.0594867861787176, -0.20981134554184636, 0.5128191917480782, -0.34104152968694845, -1.1410501568362645, -0.4193289859188396, 0.012476111109555797, 0.9533066410208835, 0.6866948330604707, -0.19760664342265416, 0.21565155833324487, 1.1292417136695185, 1.3432728214530134, 0.06764541035450221, -1.8262800500485312, -1.5853060317025505, -0.16090611228104879, -0.09530373569873397, -0.950261936520503, -0.5606080371129043, -1.030406723401323, 1.4906736605438606, 0.031446768464556005, 1.7830612611274017, -1.8837865117340906, -1.2986487847238177, 1.4774058011260172, -0.8191929685704864, 0.71429080834877, -0.663864005569532, -0.1419695976075925, -0.35124650058414625, 0.5061028572376596, -0.39698640080751246, 0.13274791841223615, -0.41114465452660576, -0.24343022227004452},
    {-1.7093842201094565, 0.5472146553843852, 0.5250373222449428, -1.0144291066181705, 1.5360338460342575, -0.9290267845889129, 0.16126358332643356, -1.5387430237591317, -1.9762800438216022, 0.4774726610222384, 1.375842931371867, -1.4235317776068765, 2.2594876067304113, -0.012314233441334066, 0.5382656364042449, -0.798127382895193, -0.4497191839710916, -0.21802386040665034, -0.003421297868324341, 1.9360370157922568, -0.6314494164105884, -0.1603412181668453, -1.1694866722516062, 0.4832419909731154, -0.17915438364900263, -0.9626190425078164, 0.25919218173628045, 0.7277867860561603, -0.21476820320375564, -1.2734418491628132, -0.5309430086524637, -0.14533772356312874, -0.7874800181336146, -0.08702204181011743, 1.2096424235447747, 0.5993708024896915, 0.7357894524811004, 0.13958816590389103, -1.2783516554005594, 0.753976374768456, -0.36077308224065874, -1.4667386395975974, 1.4620017774505174, -0.05175853307563051, -0.8167971651813254, 1.091816795096936, -1.9332590546489061, 0.9240372648425763, 1.236618850918618, -0.5782534855987612, 0.09245128997151186, -0.05718727640694743, -0.5490834821471376, -0.27884799442310126, 0.2686914643661428, -1.2485303324740802, 1.935054412417497, 0.6000482362265357, 1.9054701058143133, 1.7944180215090986, 0.8217304993353581, -0.2823610569925811, 0.3741343802037503, 0.24283982291883555},
    {1.074956340088168, -0.58557900274797, 0.4351612461608798, -1.3926683998530451, -0.15970909093391963, 0.2204500015398092, 1.3909610834581614, 0.6572639343106578, 0.4726661708963969, 1.2946493411257702, -0.1982057391956522, -0.4081655300243236, -1.5451440456091508, 0.9885406792705959, -0.5036315939970926, 0.8269790828868128, 0.928810092308889, -0.38291933211684603, 1.0203877044420557, 0.2491367418141678, 2.1733699275259375, 0.5243645921674914, -1.083032490489984, -0.5787664159461293, -0.24137341598867337, -2.4633349349985405, 0.5132098183190553, -0.09102552764965123, 1.5410079515851358, -1.707535763547122, 1.2915696841923097, 0.0683393709144122, -0.9257234528293776, -0.0018036482319894723, -0.6654631490168668, -0.08470536967053557, 0.3525593812909851, -2.0257095678282626, 1.410094518174316, -0.3425338890904968, 1.0793035358078245, 0.613273998941684, 0.0141099866820699, -0.5289120058352749, 1.1858378731946366, 0.05797424792286967, 1.064415883572428, -0.8984594235297165, 0.3956643524462331, -0.8808686574864552, -0.3364014718415512, 1.9933655049291366, 0.6144221331557044, 1.4681919017398406, -0.9007490793758179, 0.3769453559117193, -1.2803492636117488, -0.5208701663030463, -0.8186093835671122, -1.3493029243856443, -1.7829235154817276, 0.44899926275138524, -1.4594848428493818, 0.3239977351716101},
    {-0.38200456543738687, -1.1692409332874971, 0.8593542290052111, -1.2353099032538641, 0.33302077284087483, 0.4273269431524348, 0.9796220898442325, -0.01629051812894888, -0.02472879069050926, 0.3797532472457682, -0.12090922059457922, -0.5956559393754765, 0.3607728899718691, 0.8176083704960911, -0.2694694492749102, 0.48870590702330047, -0.975104741472251, 0.7185406389599039, 0.4809120065819846, 1.0252979542181184, -0.034266155628441125, 0.7416488436187184, -0.70389861272337, -0.6040704259999253, -0.9357821936860495, 0.20848999757779602, 0.72673973078458, 0.016034922953124996, -0.08689081745923827, -0.11941736418227411, 0.9542661231522191, -2.751759936025387, 1.2198020862334553, -0.17360461789785206, -0.6351170995796055, 1.2193252861180974, 0.4208029874034292, -2.152880937310175, 0.3147107195314037, 0.7174722086313146, 0.771447624863082, 0.6941164955683174, 1.1365037535247566, 0.40582719095910996, 0.23383647020796436, 2.6237716970229727, -0.2738408159190613, -0.7584581562209419, -0.9402922323570296, 1.4327819532579458, -0.7963620502038683, 0.009230299990940868, 1.0506732124501423, 1.0193538520730216, 0.2643218956394916, 0.03757323779355075, 0.4441291602400646, 1.4232533005638535, 0.6457190906689746, -0.9165398001645274, 1.4795042967392134, -1.834636021711251, -0.690850183046396, -2.141136868413537},
    {-0.8320930734316466, -1.4860370123620341, -1.2822323842185095, 1.2211240029464618, -1.598362071178934, 0.12563402010260213, 0.06275970873873678, -0.6089170169752542, -0.6704107331240392, 0.2151338163133478, -0.7972223944280503, 1.4001278683105933, -1.0314558079519556, 0.7068138484240847, 1.0503768247511893, 0.6261372239013344, -0.945726203533863, 0.06942069817761075, 0.45670555808119134, 0.409144462792102, -0.8579508232168448, 0.6348831798136183, 1.2748175001534239, -1.663170652861867, -0.066847497135725, -0.516343146019259, 0.3384415275753762, -0.16186626764774392, 1.3532701987988023, -1.2574142430292998, -0.5191791262066594, -0.2105149224706661, 1.0129552445888361, -0.8716256659668973, -1.7540934141375166, 0.27138222077438623, 1.3483933743694896, 1.084150047289472, 1.550849514906025, -1.2675738102414134, 0.08596463974325803, -1.654498876735773, 0.8021032473286113, -1.345646788818386, -0.42072300905138765, -1.3076513732333914, -0.20379143566015936, -0.9552880005974611, -1.0151325366077595, 0.567267778219306, 0.14118791880720688, -0.06480578616505539, -0.5882198141418374, 0.37415064498188827, -1.8950773613979792, -0.21996891386375111, -0.8320374155837496, 1.1700925265840723, 0.24148419093163317, 1.060799941760574, 1.566288451915856, 0.8962472950532749, -0.3393876380162777, 1.1665128176044546},
    {-0.10573263294214971, 0.2076203965177408, -0.6773654686676297, -1.8412179154248887, -1.355065159457763, 1.5396182683527706, 1.4047446561830272, 0.2262981667861952, 0.2842509156687441, 1.2755323956412268, 1.3359306754259535, 0.04781239840009268, 0.7011923077164296, -1.6889104861342479, -0.3084593362960028, 0.16352446884152388, 0.07002548800705094, -0.06638715841823452, -2.430143880935183, -0.8382313460164059, -1.222043463953853, 0.13851501991005913, 1.2455728441109961, 0.8886256106450449, -1.3199133909024197, -1.6430791321059366, 0.14703292330672635, -1.982608150235628, -1.2848043911143041, 0.352873416600059, 0.9943657712676411, -0.30319827398270677, -0.11743462560964063, -0.8145168690714671, 1.9441505265772532, 0.36545943133186937, -0.44335839007184324, 1.3929116490190299, -0.2211728382740172, 1.3967969014577788, -0.5999665922673962, 1.4273419872942368, 0.2514823988029463, -0.31371225848564516, -0.11827291861645979, -1.538028312707424, -0.22335103806413398, 0.5855621929658813, 0.20070805650846363, -1.1442845485861945, 1.1586197339103292, 0.8531515276121182, -0.4082173141545252, -0.2713753486068595, -0.652427604882511, 1.1347935904216442, -1.5386147346396872, -0.23752969059584267, -0.3780898540044809, 0.008762580855921543, 1.1336931028350918, -0.6748571581369289, 1.3280149818087488, -0.4543712100399718},
    {-0.1387111878650362, -0.33982601769491894, 0.5817680823903054, -0.5604785531769553, 1.0004127795647444, 0.20038875064071068, 0.6226040903704309, 0.6240427701743939, 0.5483175675820455, -0.3358839962062036, -0.4732118575983479, 0.02664505539613283, -1.5017338275795136, 0.976722146617395, -2.144294772226439, 0.9353044830314826, 1.5575903446749293, -0.43177912325959894, -0.6228566015491757, -0.17357525551364011, -1.3866270390922113, -0.6020671457932476, 2.0039643255190813, -0.15071704427925514, -0.005599604228919801, -0.8557895178592104, -0.7295874056337986, 0.6556103329709492, -0.8736116532295511, 0.2660148185855392, 0.3335409569106556, -0.14781398601212908, -0.18258265834682896, -0.4448005209650859, -0.7664367795513242, 0.5377692417550892, 0.5966218410017244, -0.6447869624067942, 1.1068025651371978, -0.13507202458623857, -0.3368286537490615, 0.5905320162769977, -0.5058689441337889, -0.29970429290674994, 1.8981393282044436, 0.32719068342389657, -0.3492574218637431, 0.16779449719283873, -0.8688080937603708, -0.07609255772172815, -1.4197896358120554, 0.852776322622616, 1.4456554488416726, -0.04868016361011326, -0.2397293351136945, -2.2375772942549994, 0.805012363838791, -0.030583061089840026, -1.8674141492910585, 1.5774105944327825, -0.064958841061444, 0.8237007179147187, -0.9829914587642441, 1.7632296090492572},
    {1.2348295635656614, 1.3880327891135018, 1.0347556480322693, 0.7623504670282816, -1.1547611955410098, 0.22988898664847465, 1.842200127503171, 0.8497625489087389, -0.7261115898878526, 0.6016135005194397, 0.422980298280777, -0.42394139956005383, 2.1652570380025398, -0.21820591768756625, -0.46464807034760114, 0.489087846593194, 0.9076025727598197, 0.3671875876089823, 1.4080598234650432, 0.9274272718430211, 1.2345345598067454, -1.455584653750089, 1.1557706549689966, 0.46890993229547834, -1.1584812398959095, -1.139248375855219, 1.3138967115044196, 0.710235823904462, 0.22082767830957623, -0.4660241959663171, -0.04641389072607798, -2.0039058032408485, -1.6025263737065667, 0.9027420846267943, 1.6393509370268473, 0.38827506836232745, -0.44018815255558574, -1.7066281246830233, -0.11184704206818771, 0.6545928043490694, 0.9665796681155417, -2.4557891106654175, -0.0071483623819384385, -0.7219408683236485, -1.395044370611666, 0.380722352910856, 1.9421323538833741, -0.5231349971565108, 0.5546211643574597, -0.6148270311003784, -1.1129248004319552, 1.8407959274720964, 1.4549114384682837, -0.9601242018545192, -0.8509352741704418, 0.18788011094658605, 0.753678508663953, -1.9566349637372238, 0.4670084471367225, -1.1858385054951497, 0.67164722100934, 2.1734831023547048, 0.2486972801553327, -0.5237326114589939},
    {-1.316076358661564, 0.27165142984832635, 0.8980684686469173, 0.9223320872720644, 1.760464878352488, 0.8852641584033516, 1.5959847378792986, 0.053750226491227356, 1.2899989371943847, -2.376391600326102, -1.0160721290105197, 1.2082065101826633, 0.3654221591922264, -0.2682913858642766, 2.095390474219966, 0.25510506471441075, -0.9569437106186766, -1.418480026617045, -0.4640588869045679, 0.18289132001745595, -0.465029770229457, -0.32988832656434075, 0.9460923587975878, 1.0732841411688248, 1.9063282124084526, 0.14306904033568296, 0.4871879071173103, 1.192049706406705, -0.905720527179923, -0.5648063085918384, 1.9704852384795544, -1.7652098577065607, -0.32478495921293943, -0.3685505122814453, 0.34799824021478154, -1.3845143921150995, 0.9365600143723235, 0.06094247602786217, -1.2634527267542766, 0.26390308799897816, 0.05395253103117457, -0.17409113469625737, 0.9407961985498939, 3.003659668687368, 1.4322913202861223, 0.8414234112296196, -0.9338057601531656, 1.2885160676052818, 0.43710832251607706, 1.5899501226963773, -0.8907893084456744, -0.2394286958484697, 0.17431790763149466, 0.07629170424360068, 0.32863426310869503, -0.284016965927054, 0.27141132178334776, -2.2344813654483278, 1.2064152891553113, -0.8838448366774234, 1.3423022697831666, -1.0720958636515057, 1.340515589641125, -0.8435341968641002},
    {0.45306129154664065, 1.4473422657044674, -0.6635960991948379, 2.003593617042135, 0.155804128525481, -1.650047841079278, -0.2828362958512461, 1.0332042859787176, 0.8719498773823101, -0.07619032276249399, -0.1126619545647699, 0.591475322114239, 1.0466211416139588, -1.092828203586769, 0.5006655040311192, -0.08126058234720442, 0.20600693612900695, 0.7189343457350981, -0.2596558813103592, 0.9307872562275893, 0.8130441388518183, -2.972090890452404, 0.268479689272667, -0.1524039779012573, -1.4747684915302735, -0.27074263913112656, -1.3514114854379908, 1.0455442022599897, 0.26072721328051723, 0.21847891394271224, -0.4759623870846096, 0.563832284109023, 0.9233338695867197, 0.7359107139220218, 0.18847234789047804, 0.6751012204159212, 0.37090861372690803, 0.09898479772392105, 0.40375683678417745, -0.8514878740000551, 0.8512401512216276, -0.6705808956260458, 0.5267241883047793, 0.016898912240735448, 0.7797715109191098, 0.1561620811307302, -0.6607114226259132, -0.5518345345697391, -1.2053622497726315, 1.1729660854172712, -0.5567184214528663, 1.8644720219711786, -0.5792356134974518, -0.6958050499668296, -0.6697659406528029, -1.792289513923315, 0.7947288745958988, 0.9598902439489999, -0.03420781681533461, 0.7212498115450262, 1.0326511507054783, -0.16103292080053763, 0.4680058106062703, 0.4593726368308145},
    {-0.14149763620499894, -2.168122784909328, 1.0326895292915756, -1.3981415778556119, 0.31622282276802666, -0.310921630742931, 0.20357470426957083, 0.9834300326082044, 2.5983764642460105, -0.9688886648630085, -0.45221070285591974, 0.5160652055807528, 0.23396795397248893, 0.27087971428467345, 0.48877489622862624, 0.3547162982255179, -1.277277255168856, 1.1351682118570035, -0.44280335091608936, 0.5731130648905295, 0.6546742250386826, -1.2169579757037863, 0.14354483499113138, -0.53939072169048, 0.6354954286224803, -1.624344322028314, 1.105375180081105, -1.5192525665031182, 1.3836467499586027, -0.4977514139359556, -0.5222218622045007, -0.45914452025755476, 0.7347390477667493, 0.47786321653186514, -1.5925957239507091, 2.9003645970676883, 2.501108951782859, 1.0069261161746748, -0.3441010661550746, -0.8096943363088134, 0.9554167288588647, -0.24439815260505396, 1.3217253263143434, 0.7609411272697973, 1.8575699015578577, -0.6926933134372907, 0.25276276252444674, -0.6785547167915227, -1.1190623799538153, -2.271658323400271, 1.2453709334425742, 2.88131206668955, 1.502599798989535, -0.23379744263776187, -0.30742999557633527, -1.6751943081409533, 0.6874819763046627, -0.5121191048975574, 0.42278345932477823, 1.3351331668851958, -0.5906019490033175, 0.17784268291757735, -0.806182743324623, -0.015480439549709154},
    {1.2372996912634207, -0.2968404668115192, 1.1987599723193492, 0.7818409123737596, -1.1035740148051554, -1.0644427764227922, -0.09013472152665303, -1.4983687939134103, 0.1850871052188083, -0.5359712397784627, 0.05639769193694864, 0.26908463974873875, -0.15329857577582004, 0.5321731029526073, 1.650323668465048, -0.4197048511828181, -1.4588881105504299, 0.5199473332600897, 1.298346373727147, -2.2958099253614614, 1.401598728677561, 1.424277731992353, 0.0203635246616804, 0.03301068973012472, -1.7630145887178532, -0.8147424805218262, -3.076498133953281, -0.5565142559302627, 1.2340157716548183, 1.6165879767894256, -0.7764559256292356, 0.5008422996314391, 0.40696669879616815, 0.2647010405523398, -0.061366260132169496, -0.22108192140867197, -1.2387560007285852, 1.7553406273286263, -0.49440187618023723, -0.22198011158270103, 0.09895911066146884, 0.11733230496204083, 0.4008079064313268, -0.5549509235393476, -0.43561273238089643, 1.6948703615083058, -0.07912652373129953, -0.15823286361450592, 0.1722733228962432, -0.5803397419453012, 1.3695018936127221, 0.8776701476297829, -0.940700561665216, 1.3754903803888987, 0.665975764043707, 0.02900172041508019, 1.1547271009933184, 1.3888149821227393, -0.8282073944453153, -0.46212827441236287, -0.06342464150566027, -0.44706218481778115, 0.14510097762889076, -0.2300750361869874},
    {-0.48506817104494687, 1.0040852954353752, -0.9658313047917081, 1.7257400799627458, 1.1885370011635021, 0.12797318225930682, -2.3911975085018335, 0.05042711085209268, 0.6053712406244257, -0.7469758941771186, 0.3739746887815821, 0.4373628924201622, -1.4891488458602449, -0.32960609600759644, 0.721913957129334, -0.7910467088479182, 0.3783043985339961, -1.8232563955425412, -0.385263815111808, -2.0257830901867258, 0.3714800851196902, -0.040708534519679304, -0.00027851831134499065, 1.731509063757998, 1.4668700592377564, -0.11624427477217227, 2.675267920934587, -0.9721381159860034, -0.5310761788253454, 1.4261944906532515, 0.9416579268127617, 1.2450279779977178, 1.0129377742638863, -0.13976079202450323, -1.3104480448437725, 0.5361898138173186, 0.43193510044714467, 1.3949470535577915, -0.3697530389168002, 0.2729217739306985, 1.7622895297956898, 1.4612877941347429, -0.8970919334106462, 0.4601525358494941, -1.4194525082515015, 0.4008464055921229, 0.36899720908163625, -0.24951125436697605, 1.622989102985377, 0.961600271259031, 2.091860331649551, 0.14435229470628935, -0.03562892555744294, 0.8491876542144716, 1.6638137639379624, -0.5120929316452093, -2.7424706391476725, 0.7091426671489411, -1.6098506534830337, 0.24473928212452373, 0.9180882813558343, -0.11181854756605814, 1.1636251328513254, -1.625391287512861},
    {-0.49275358995958, -0.044097292020236094, -0.40114945767664906, 1.2370818462758681, 1.7876738703913189, -0.6179406507281773, 0.5426402613683503, -2.0265515849842166, 0.7827848970601964, -0.0036536138710712997, -1.752318601308089, -0.785726777331355, -1.054954699914012, -1.3889407310625757, 0.014906272532778635, -0.523131260338651, 0.04555802976129159, 0.9876073573627773, 0.5027416625092291, -0.05652953924788461, 1.1338622248722752, 1.1094766558524753, -0.3133163418316694, 0.5315077312238686, -0.9329121203662514, 1.0813348241767748, 2.7788342090136924, 0.23261172686468864, 0.6253151355933219, -2.8261693637851963, 1.8748921016305686, 0.11802151298134766, -0.8291092134695089, 0.34858975251104013, -1.6988956037710345, -1.0029314772677433, 0.10586699458160741, 1.824306499862441, -0.8778775692192984, -0.3476304803915591, 0.6122808559372018, 0.6678309455187841, 1.046558009950891, 0.15995711643996632, 0.9300560838219596, 0.7249328299452155, -0.9505419829079287, 0.9912938293828104, 1.3776840758864628, -0.08396048853993524, 1.5827170791467728, 0.5507514054807028, 0.20741335276035516, 2.6698898509630125, -1.118027618165239, 0.21571973906001984, -0.48330119643014424, -0.9013236142740276, 1.0311946322096794, -0.2286609555147259, -0.7359765725690488, -1.739376603165624, 1.430103937125923, -0.5738630036547319},
    {1.0068193025297612, 0.11474598699666105, -0.37922115146121277, -0.3184329718590755, 0.3839986844178171, -0.006372278779227888, -0.04973050994052549, 0.28285891409294706, -0.694458120403206, -0.4868944587584382, -1.094498055748112, -1.0641322042184262, -1.7942845222471353, 0.332037089889495, -0.8438782051177156, 2.1027057710672468, 0.3222253743121453, 0.034294675974178256, -0.05468471759678319, 0.3091130233700422, -0.49643862828139473, -0.3298307439205674, 0.015444098234452768, 2.0543564794628777, 0.21048256514816593, 1.622371020673324, 0.14762894284945555, -0.03849383577462901, 0.3695113692484264, 0.23655811270118432, 1.5710266819851035, 0.19906624709739765, 1.039941685230788, 1.323153766966128, 1.030925786369599, 0.6464107766786131, -1.5690967677797993, 0.6436257931585382, -0.6369525498888605, -0.3590352326674989, -0.10603164337209894, 2.0049954160779486, -0.7282737874993214, 0.9444974435510093, 2.1632582019733864, -0.6149977684122914, 0.19684897832545284, 0.0851295018391303, 0.21805864785695542, -2.5427029777647463, 0.4009902109711031, -0.7489657808425234, 2.015346715252559, 0.28043861251307256, -1.7902309453245104, 2.0945228138903156, -0.024301553150033597, -1.1749205705717793, -0.08056267289243578, 0.15653229640928634, -0.25280707624717347, -0.11866784788926855, -0.008324728567080176, -0.6948320871611524},
    {0.8192481762329323, -0.1375341871230997, 0.739707251570482, -1.1357653258961806, -1.7446994183255227, 1.4849490795728602, -0.014691209604338668, 0.7444916670293336, 0.3546716362600276, -0.11972057387406955, 0.5708026888181736, -0.622075306614827, -1.2845458511916927, 0.9726138623886879, -0.5872197455195165, -1.031780421551106, -1.2353172546857327, 0.2299277654167129, -0.5660369409469362, 0.36483221353758555, 0.9136331245730224, 0.5047365647574316, 1.0407378639060387, -0.15012711813541696, 1.1597547311746244, 2.86142487706774, 0.13292172176754216, 1.20824235697691, 0.7871275268467046, 0.7756082795691741, -1.2441255909992068, 0.6512227178385904, 0.4215425373132637, -0.6926777089954723, 0.5659838408016716, 0.7321990888316395, -1.1292899342782552, -1.723804824449572, -0.5324683049580193, -0.5646972686629396, -1.0600796233924545, 0.13432782163782353, -1.0187651457437965, 1.3992729956593104, 0.34470833633257536, -0.9783430754768092, 0.1759466061324601, 0.5609281635963242, 1.3230890708139345, 0.20804846319645173, 0.08358398574368604, 0.7188949685922101, -0.835933893309368, -0.5484988732823021, 0.09252166280130733, 0.2158378928208716, -0.6539025142113332, 0.9801345928425, -0.5036328520449642, 0.764232956619096, -0.3854329838929216, -0.289631304133104, 0.08903080618242037, -0.22097387071962155},
    {2.230875255753997, -0.3413282368938701, -0.6804291569447325, -0.3356606358700757, -0.34964502461723307, -0.5793777993375129, 0.9491093420489582, 0.8306391187551352, -1.3728026688839245, -1.6609236815566335, 0.9619211680457057, -0.25736201428588307, -0.38002762877150664, 0.21381066951931296, -0.8147623632913733, 2.06206792214877, -2.4675449684124624, 0.9705353014059565, 1.399755397659673, 1.9696457829401242, 1.2760665892540917, -0.6418799172273065, 0.184724626069258, 0.06277372822034463, 1.3501128254525714, -0.5535411062050025, 1.2844542445570262, 0.35833689424013226, 0.08952517352959871, -1.0497019431325683, 1.2923259422362974, 0.5164323308932836, 1.4927799048766384, 0.4891672305829389, -1.3372848311708645, 0.47876928381873113, 0.17626812955129192, 0.6393471932340168, -1.3553969582798757, -1.4524131142021006, 0.5100999400659257, -0.11926272960796891, 2.8487645242948987, 1.1056456525198948, -0.5256424556760196, -1.8064259158357705, 0.15396274258185522, -0.7619964172850018, 1.2355879084868135, -0.5401466500547216, 0.2959848168546971, 1.4929188093406336, -0.8385759599620107, -1.1007041344374375, -1.562939695973132, -0.45792751480085947, -1.635096991195072, -0.6107571472000191, -1.4981519077287597, 0.27565478894892387, 0.8140998509329292, 0.688759782797623, -0.35349532670424233, -0.9315020533632126},
    {1.2284020938408249, 0.31952047753916113, -1.4669848511169576, 0.2472775266908519, 0.4021345294196989, 0.21022105837833044, 1.5930359714604876, 0.3802039750745531, -0.05636858696511138, -1.3815463898726974, -0.387604197443283, -0.5482542955726287, -1.7577484831051116, -0.28246374136040897, -0.5507948444043745, -0.7759194821446997, 0.13028402118459245, -0.5365052283590407, 0.9183330203136142, 0.3783446428461207, 0.9599895759924884, 0.9582450108775026, -0.8337011555701908, -0.7022967722962395, -0.14407294833633244, 0.11997859485077138, -0.23237687810622853, 0.36574989977091593, 1.9413713127797751, -0.07275901043771753, -0.7170028610189416, -0.38702556256284826, -0.9061350256665434, -0.5960216785581464, -0.040150944161944854, 0.4402476866763936, -0.7480317327524374, -0.677230765870501, -1.2337473869545945, -0.340638702855681, 0.346359760708053, -0.16397326911131344, 0.3572265338635264, -0.8338364730455162, -0.8580138874803892, -0.3127271837196116, 0.4387245748993813, -1.1494913339944457, 0.5125567404454489, 0.03915454796424387, 2.458911549804447, -1.3452384715403634, -0.6410728495249791, 0.4658089813154618, -0.7745798327702126, -1.4737347226498245, 1.9619937532030434, 1.3005380861550644, -0.9023862812017397, 1.244858739335843, 1.3647908547452043, 0.0009000951727646454, -0.019107541499943898, -1.3524865751655304},
    {-0.7110230018419351, 0.8463890798129446, 0.7239931175254698, -0.8785328981012513, -0.3136011470011752, -0.8967503509924912, 0.4369962650062208, 1.2444989614193145, 0.8731911095307178, 0.6956090489972411, -1.1485570123446123, 0.21488061728142163, 0.43601229836797384, 0.5380279335117186, -0.23344058611545984, 0.15730829713406885, 0.7582591059268287, -1.2132183522517916, 1.027371601122529, -0.08337742529644555, 0.8720961931649385, 0.6132871485621996, -0.17780956227806274, -1.635879044832204, 0.9566607934698359, -1.3055085110769868, -1.2041235343773729, 0.5928682541793087, 0.30599871937569606, -0.15537723175385992, -0.05677124016137129, -2.352850290101694, -1.9032445171195915, -1.859135253925435, -0.23934021127618318, -2.35389692836158, -1.0763043897379072, 0.8760671330580823, -1.2761818403204526, -0.6831507226410075, 0.12136965539414046, -0.41951956420724523, 1.775205529455295, 0.18703404843672872, -0.4230634187792881, 0.8217529453715696, -0.7587229908102299, -1.9624145613722412, -2.081364204054994, 0.712403087277263, 0.28535213501611245, -0.534155287362936, -1.1928550233056554, -0.17742201008540842, -0.5265051261077054, -1.0030253540054272, -0.1038768398931981, -1.1314328018043593, 0.25266976249605233, 0.041017323976777646, -2.033394732051191, 0.42795195622432486, 0.02632756728971805, -0.07141114921061652},
    {-0.24314206575489464, 0.8519117051138728, -0.24185632199688176, 0.5717863632152655, 0.26319713224702374, 1.7904237754686172, 0.5893507018884384, -0.1847106567933797, 1.117292013419104, -0.41537958605194253, 1.8223849982035014, -2.305460130993976, 0.4845149750953597, 0.6211921116993356, 0.6726021207989501, 0.42122810303469393, -0.02373062434115508, 1.3294616897844007, -0.5361922424883349, -1.075886102307927, 0.7607775789967482, 0.7050799272049633, -1.2790302601346102, -0.21319011684129174, -0.00814760543707852, 0.6523576068144408, -1.1788231532978637, -0.4939383496156926, 0.43350325357951436, 1.2105684686375136, -0.9102225091951028, -1.1198651360588878, -0.16545723303437684, 0.08741805759861904, 0.9081572574158119, -0.35920007796318393, 2.3109397001016605, -0.1556965046062007, -2.2175072889972647, 0.9761805689178472, -1.1885756615877385, -0.23668524971648564, -0.13968920455309336, -0.4236263210285275, 0.07410529236007934, 0.746284151500015, 1.9972536394029063, -0.009573121126595764, -0.2555405934906864, -0.15968483464233937, 0.11210820986279509, -0.5897016104548761, -0.3464305529045819, 0.7954335739710376, 0.6950610450222442, -0.2515977366095003, 0.9795140333544206, 2.442964205568485, -0.7010497203720336, 1.1891246798924904, 0.27623647541349394, -0.7777636412788079, 0.7208266303271192, -0.2021768248060313},
    {1.3654601565218625, -0.658081980897599, 0.03408832736022222, 0.24263521083823614, 0.5602500756061427, -1.1799921060515242, 0.4454271318989068, -0.6383982763444869, 0.1280627496859981, 0.6224321615333884, -0.20400232509925734, 0.912449310403783, -1.897224120760058, -1.0109995426635332, 0.7634113076800841, -0.09232206496257093, 0.4313555853313187, 0.4507077226034089, 0.11719864117747344, 1.0821991378098248, 0.26537711551877385, 1.2738664556864083, 0.25353730069285507, -0.7580281500566114, 2.2285481104746356, -1.194681849064485, -1.6005487642579161, -1.2026901347498022, -0.5988967723294037, 1.283146182341739, 0.034384587015901524, 0.5888001824090151, -0.48337793235055, 0.8090414167025811, -0.8686971929296584, 0.5209193144178407, 1.2000716834684713, -0.09863126212614172, -0.7807057616013131, -1.112826448386068, -0.612063258162634, 1.5664384598194887, -1.2067703832612624, -1.1923089482721507, -0.8951185124312492, 0.6980078837863278, -0.03108910323970326, -1.1229878401774762, -0.2138783948071314, -1.5102637817069982, 1.4464143508602585, -0.8799324738134822, -0.4166037635349625, -0.4373658739764228, -1.0199221282372313, 0.12736975541188553, 0.9517645362630032, 1.0791032644861456, -0.20790870686687188, -1.3559188684543027, 0.5906898332066841, 0.2510659531324948, -0.9334075244574008, 1.0197954709095516},
    {-1.5362130556004168, 1.9150483580597752, 1.4489671542814264, -1.5000664007431352, 1.62388471069461, -0.971415462883305, 1.0988492604844402, -0.6989065956589589, 0.06214402841212404, -0.5091437675674046, 1.4952126383865403, 1.2715123920546942, 0.10679520716313881, 1.006298204056591, 0.2768219574082277, -1.1282990152317942, -1.8705169291184303, 0.8849007763347575, -2.2253311915657874, 0.6076910820888408, 1.0271284085553398, -0.9155761016721775, -0.0035874077243543408, 0.15399529187343639, 1.5052527496743195, -0.2391312368553712, 0.429480719912863, 0.019112715700428683, -1.6564073168645692, 0.09773135429583464, -0.19451899449228835, 0.8343764025559341, 0.09187906384424664, 0.012979870902934896, -1.0946068856327749, -1.1090146341292384, -0.8227100620645392, -1.8019142092190517, -1.0134211939369198, 2.225696615715001, -0.15273834739873868, -1.5162400697532146, 0.12021954099529442, -0.6989244623444126, 0.426208438407084, 0.5283596924064096, 0.908593210386877, 1.37297311052352, -1.5775461748612947, 0.16291989271559668, -1.4766588065703858, 0.5150065498314471, -0.2152285257119808, 1.55831420740361, 2.275677254684545, -0.951416431806589, 0.02640649103952642, -1.4273242883708575, 1.5111995046968567, 0.362682413941007, 0.7671677074002463, 0.5193401465936912, 0.5542298082007721, 1.0163482768127785}
};

static const float b1[64] = {0.1984477647064711, -0.002232105009049332, 0.03718613580374679, -0.3151408872836164, -0.30841596457483045, -0.20526170230421084, 0.1053004039838251, 0.09471130007338793, 0.21547606994494248, -0.14669393466086408, 0.01658634087326278, 0.11384089915035171, -0.1721681685393805, -0.2762616603993189, -0.32914928863229453, 0.18662570542983267, -0.09970922992186393, -0.4556737601864714, 0.17201337988893317, 0.113394344773391, -0.12736712121977298, 0.4573222245997463, -0.054947539017987594, 0.06419594983876539, 0.19992893034589418, 0.19864734818603907, 0.09484583265176491, 0.0638951422563003, -0.36072916108397673, 0.34182497493724284, -0.05878480709986339, 0.5400114765206672, -0.2971497194971318, -0.13017334597636926, 0.2800233347273214, 0.05282531180412726, -0.13006388028535565, -0.17612607542170408, 0.40321273101718486, 0.08444433330931389, -0.1867595813430299, 0.19713015648660273, 0.007957959555300211, 0.18910936060613123, 0.3074640342989491, -0.13071358226308089, 0.475741769899259, 0.08000314748208424, 0.25217963664774007, 0.5628580449984499, -0.16369762857200648, -0.30637736543309774, -0.14051795157076583, 0.37283219053140015, -0.09500870439710153, 0.24994014765929778, 0.12944256818718836, -0.35048417084913924, 0.03849835705075098, -0.016822612592364065, -0.2760369032851936, -0.08037377281033298, 0.10142646569018948, -0.35076926003137016};

static const float w2[64][32] = {
    {3.6754598201342463, 0.35285991622863744, 1.0788145082716813, -0.5614335480857827, -0.016323764377334533, 1.5911258482646746, -1.7500896990708348, -1.365374679946249, -2.517958266458623, -0.2271674597184443, -0.15093777609846842, -1.0996162708039274, 0.9664794584955156, 0.8402730806728348, 0.02442009984851962, -1.3383265503800787, 0.9155297987937095, 0.3100258471418159, -1.4449892299599953, -0.5312976179007285, 0.05358842732884943, -0.6922947324206222, -2.770722320435379, -0.38055916190282324, 1.6928267193168967, 2.426639049258433, -0.3065859352340826, 0.0019381848000627568, 0.8434839678772965, -0.08149214187748469, -1.5927866324926976, -0.34424153597974355},
    {0.7018037165559232, -0.15676290041390023, -0.648504319720584, 2.578687565494179, 0.8055948645312135, -0.20472004110046538, -1.9195364364844143, -1.17984252873864, 0.4325186470811718, 0.6959554944019052, 0.28005569919561557, -0.7468265842813275, -0.6345133920928204, 0.5085801434548798, 1.596904184178951, 0.6849707672371056, -1.3610005946328627, -0.6992848975985193, -0.43989988201597574, -0.5120540731046069, -1.3739633151172692, -0.6448959082871946, -1.0908426350198324, 0.9918307200828259, 1.1483642203647955, -0.059507987398875986, -0.1924191167440725, 1.373647511352477, 0.9299648530508109, 0.37826511258453877, 0.411444611894536, -0.04291705795836035},
    {1.4662609541722111, 1.7070218517461193, -0.39929174011863766, 0.30002735458519547, 0.040413207047556236, -0.231210816346747, 1.430469358181539, -1.2876620304400017, -1.0412185342655138, 0.3178699792772447, 0.8887470010328005, 0.16536581278109663, -1.4681879350124492, -0.0879250994434078, -1.5025034222109763, 0.3515559391236584, 0.1239612875999578, 0.8497103606932589, 0.2813112766388815, -0.2096383428123348, 0.16091344178482414, -0.3025478883425071, 0.20887778154237857, -0.7144288856290137, 0.8207600027830615, 0.5764299429486668, 0.7711830631804915, 0.20880932986580372, 0.42605678463685415, -1.002515993885339, 0.5825432795861055, 0.8388571725252048},
    {-1.0692439606487243, -1.719289227239218, 0.49074979153357734, 0.049306031065458625, 1.1281981678358075, -0.7818531824215109, 0.3244145663827225, -1.190165007964335, -0.7885254861082477, 0.01485963700884422, -1.0550484712794261, 0.5991147321518218, -1.4811418300072088, 0.1535529311703335, 0.4429733149626201, 0.5310392676356374, -0.14191447267086735, 1.2590626474134468, -0.1465958913850403, 0.9865850681181156, -2.102007307933226, -0.1682142323751742, 0.5032927250753697, -0.011597686368405611, 1.085333484653835, -0.3912964893878058, 0.06006977830436042, 0.636066446774117, -1.2150067812268168, -1.528499380870397, 1.1043227665317408, -1.8362464464074704},
    {-0.6460315086918902, -1.114045166467875, 0.22505033161949778, -0.45568550257169577, -0.2282176986310148, 0.5171099092822613, -1.5343682137067522, -0.026175962278739154, 1.2763355337741575, 0.40001631016088823, -1.2171710230602755, -0.12006062193553924, 0.17849311611817642, -0.8640137478870299, 0.7051448782353068, 0.025019349784172352, 1.3699757339709366, -0.033846264679594326, -0.6092972711958448, 1.0060797846022211, -0.3100775112717623, 0.07938909531260549, 0.17407770339491338, 1.582912094758391, -0.16344696494532637, -0.3764716260040905, 0.7187612025275815, -0.2827622310519062, -1.1888302805032185, -1.6467675493603968, -0.39234816281111706, -0.713035896704262},
    {0.14511084098597443, 0.08281960157373804, -0.23876403832548548, 0.28454625956588575, 1.3306613309216344, 0.6272764302652182, 0.48449689823988634, 0.8500258709026334, 0.8598193701160246, 0.911213596498482, 0.999135430343146, 1.047087749956161, 2.02121518585786, 0.8390872237305929, -0.4426118183565081, -0.2963983014119706, 1.6226993563688112, 1.3038560568727968, 0.14945511039306245, -1.6126480623879453, 0.21875149221758391, -0.830796903628647, -0.5292020395599006, 0.7111826547584655, -0.6851942684637886, 0.35345610365035723, -0.013236590336355644, -0.4309754903353741, -0.6240385819522161, 0.2731523152392281, -2.1853409125181114, -0.3275995399963745},
    {0.5378129996616604, 1.2536580867676754, 0.33215961598021543, 0.7647128214104298, -0.6766143820388423, 0.36536830553215677, 0.8217656408365631, 0.1977754017172679, 0.8575740056224278, -1.4568115675318472, 1.7201640711292807, 1.4968061719938777, 1.42861033791691, -0.09984695694461085, -0.6787144299284357, -1.2792371761119776, -1.213604621284717, -0.23113204526147307, 1.044303673740048, -0.3013175086670857, -1.0906770737372695, 0.07374896404445115, 0.8131880823216041, 0.5631977534056585, 0.418891787047884, -1.0538859771909828, 0.034399472931238885, -0.9821775050384691, 1.0117356425132926, 1.2719000870717425, -0.7624755548375555, -0.7827093391685255},
    {0.12480479625640048, 1.439024595462893, 0.5461667158436356, 0.83800268175166, -0.9512158702936451, 1.3474641319412755, -1.3695214468255865, -0.02488902356304603, 1.1708423653082236, -0.005760261363144478, 1.9745430668434127, 1.1846520086943004, 0.22854668125839395, -0.8100552624217178, 2.311021695735783, 0.5797692309033604, -0.5473859300420953, 1.5989652417019644, -0.15233155540680915, 0.14127674991021857, -0.4480480701455077, 0.17897579411097583, -0.04357533424379115, -1.28662320243191, 0.3114241107810914, 0.17900002591492759, -0.5634309033249314, -1.1808518555921217, 0.439388960171021, 1.6869350986022793, -0.1159617190607816, 2.060563974540784},
    {0.13043654787051853, 1.124506408194415, -0.2445635547322427, -0.5861028259212832, -1.0064686029488834, 0.4330958513184013, -0.6841509030724522, 1.1963008958362957, -1.7892900841156099, -1.1254772771634662, 0.17725228240006977, 0.2926589552408523, -0.09437037956499186, 0.8404819257378837, -0.7295039675568086, -0.5475985109234488, -1.0118949140632665, -1.371805643712603, -0.07224401851768979, -1.553482254883962, -1.2078137198466259, -1.957638717390894, -0.5269400783965169, -0.052442720222514054, -0.6083442726311707, -1.8009160910549404, -0.9485053561585095, -0.4291993943349856, -0.05669549764884797, -1.4765736868088943, 2.143981639565929, -1.0471722280217988},
    {0.4888919053434115, -0.5428241484907192, 0.048074925087136636, -1.1345295337432244, -0.42206967208025004, 0.8601072110214536, 2.1946181976146266, 1.5278148950725352, 0.9260524331043453, 0.21121323273524154, -0.5404811291657569, -1.574084005714364, 0.797137230514375, -0.5089411153027747, 0.6791108904539535, -0.15722303273970056, -0.7858655971942031, -1.1188554218629159, -0.9424417111122915, -1.3426373218440577, -0.15482782728148073, 0.5325367994826163, -1.5344980592126338, 0.3231983868881811, -0.7358365925620419, 0.6811874417448318, 0.6942243926557388, 0.7975383126042274, -1.2096691448811068, 0.5790071922000675, -1.0830524499561327, -1.4388810993020458},
    {0.3332107390676716, 1.8159009384868212, -0.46068800960773265, 0.4018160166675596, -0.24632061099827793, 0.08371476535010577, -1.0932121757404338, 0.36009113199525483, 1.3498549759508218, -0.4236652981690911, -0.25880429636153174, 0.05086067307553034, 1.9868937629028265, -0.23880191346388227, -1.7367199665851945, -0.9885626811132696, 0.11392248367635865, 0.10753264118817307, -0.7415145256278034, 1.3020724210654688, 1.605046237211699, -1.0190631263511671, 0.1316245338126111, 0.8608920068399978, -0.9631027446058654, -0.7505257032899962, -0.8189809989788989, 1.2341156147652441, 0.9294011988615608, 0.438361013181692, 0.024889519170267896, -0.40690796853029226},
    {-1.027254283187208, 1.6917685229107617, -1.196484176133068, -1.3358485975513479, 1.0225047833431105, -0.05014024558282686, 0.10200452793224259, 0.6945792692735216, -1.2033678828609233, 0.3921986155535552, -1.8849358171321577, -0.4952056220107496, -0.24416701207399635, -1.8282634928223593, -0.4553559062210741, -0.5174837775784985, 1.2643233200525954, -0.3356534169036423, -0.0904304039731715, 0.3714488902598602, -0.7761181728489004, 2.724887645101047, 0.04214685616515287, -0.6416139843962201, 0.7753214740662777, 0.45453995053683344, 1.7560058395094225, 0.6204455652618924, -0.12404326551402992, 0.27544050802180936, -1.8634871907246306, -0.3626275699867548},
    {0.1607941943988295, -0.6352948153328531, 1.0820930814178553, 0.3079373633700196, 0.665347077331861, 0.15530807577343467, -1.8614538102223037, 0.41953996953577355, 0.4299581619032684, 0.8977727977787138, 0.05945299561811845, -2.9185839387974033, -0.5418781157400568, 1.5044784162668297, -0.23579897138480355, 0.884555380450306, 0.011596993630754646, -0.2656588974759553, 0.2889866909864691, -0.12193265568307508, 0.04405452886490809, -0.4202674357524928, -0.7418404838336402, -0.9892119474099961, 0.013662002900267636, -0.9872184022788625, -2.361206665824768, 0.07786280851804007, 0.9552573630544337, 0.9211542468505959, -0.331329174478339, 1.1291999075274994},
    {-0.595966793893171, -0.7387755873280523, -0.5752184414009687, -0.997772553642439, 1.0769621694023772, -0.4053432090474883, -1.411525768720244, 0.7406714074208033, -0.1705887919214968, 1.7514006001776328, 0.397653445597211, -0.21711506466520097, 0.19842604136853925, -0.2735603742721447, -0.702955248727629, -1.476956524150951, -0.4087169817306677, 3.16629470860797, -0.8422420383097756, 1.4220947837248354, 0.3423174893072744, -1.758892094938805, 0.38607385423578355, -0.7337363429013041, -0.7176647138566848, -2.1551435080271046, 0.14028151970563624, -0.5875076826815542, -0.14526794347276403, 0.30972113083523417, 2.193013166872668, 0.5650572672996053},
    {-0.6909714917815659, -1.2003914894084107, 0.5434290065542593, 0.41005914542055033, -0.5972751668110059, -0.7349700107720486, -1.8178549321877238, -0.22786651428125895, -0.2991917634109532, -0.20937826447651434, -0.28572728699022854, 1.1025773874310767, 0.08373787146183229, 0.4317554547454035, 1.0248813616977572, 0.2987403050311378, -0.3083552018595643, -2.379275282628098, 0.14189975276823882, -0.6907516764526453, -0.27354836855073017, 0.505088444488935, -0.31164170425102317, 0.5219723349359726, -1.348452004085417, 1.187647107358541, 0.7727657415068617, 0.3494176256648359, 1.314669452389963, 0.3238856969573995, 0.5003681568081655, -0.18875132830028535},
    {-0.5444110493825332, -0.3070726724986005, -0.8831714201330978, 1.1515331599142833, 0.17014399495581106, -0.6536822319784638, 0.00014382601654769404, 0.5274539885755882, -1.0343038319303692, 0.39458182009722764, 0.26195634966899045, 0.707265072866962, 0.7089224296140847, -0.9014560716910703, 0.5398661301839822, 0.7294072824343276, -0.08390480812932137, -0.8528203689876995, -1.555838942860723, 1.4765231573647521, -1.4160898587510897, 0.5477986718463579, -0.6624912850446062, 1.8725760793759894, 0.0034396181362545937, -0.21022811554564627, -0.049424475572894706, -1.9044152163012866, 2.4653428633254584, -1.4769786256934256, 1.3015170191367298, 0.8577784619958729},
    {0.11494719342629516, 1.5289784448514978, 0.19914448842891594, 0.5739841793775329, -0.09367605990948902, 0.5990984100802295, 0.5464411727584509, 0.024160867644225186, -0.3696352973491269, -0.9845057739716756, -1.605747115422626, 0.447122151137039, 0.6169920049705875, 0.41060916089975646, 0.9003010296056471, 0.3549766474351216, -0.42074784041266616, 0.9521162625210036, 0.589711980508075, 0.11453134251206447, 0.9573991032040255, -0.19666489341184007, 0.9335748349324572, -0.31087929624227123, -0.5123416724233342, -1.1413922557592142, -0.5456830755495615, 0.06797940645308798, -0.4519415622525686, -0.8703907573183477, -0.64411993308069, 0.8275515957347408},
    {-0.7212388577368508, -1.2636688275947476, -0.03181521246228781, -0.10610126249697961, -1.0520842727202833, -0.08029209990577545, 0.6866504585108709, -0.8436366848164115, 0.634131662820523, -1.15527079912144, -0.5730503854845519, -0.19702371999269577, 0.2644062288017295, 0.17088594728327117, -0.4260739499405304, -0.10891574133212283, -1.2352387877669437, -1.1072762065834303, -0.4515184265453291, 1.0588253143343227, 2.579766419253308, -0.42892961564854526, 0.09794948526046655, -0.8198978167283628, 0.7343720185022048, -0.6010160868460812, -0.7321979662366036, 2.3334558004345918, 0.4986389582102844, 0.3303377777170894, -0.6436026769547354, 0.09248140045989865},
    {-1.8935743975610984, 1.1413827564262378, -1.1939464931876387, -0.15997277264625495, -1.1235793681737174, 1.1299384576290086, -1.0483982857339689, 0.2941118871898673, 0.018413055010220343, -0.388248010481144, 0.00450165404361347, 1.5521650595864114, -0.4280754179378508, -0.8603884372775171, -0.9296208977811804, -0.7997258299839981, -0.17135800118236977, 1.6046797486555644, -0.44392876735814524, 0.8173642347897577, -1.2704094710276599, -0.042742971109875696, -0.2519177754769004, -0.10543725202578776, 1.8237466881790645, -0.07529181804184845, 1.1266928271434888, -1.0795408752083528, 0.9673460130798945, -0.34776468149985157, -0.4043949585477651, 2.029215483315794},
    {-0.298484250503477, 0.22826445396391712, 0.4073784891277582, -0.7474355876889706, 0.20938099358599635, 1.602797133257823, 1.40256866945169, -0.10512338591978031, 0.300473521351639, -0.21547393052509972, -2.197139002152474, 0.1363789525207182, 1.8046272038523872, 1.886405579479104, 0.09441703109254243, 0.8558672649307179, 0.20603932762146712, 0.26289737949998504, 0.5571847271589372, 0.42322129035923345, 0.06361895438553536, -0.8601666458769623, 0.11525248364140767, 1.428416673998446, -0.14143171896686202, -0.7026512480413998, -0.40645377723968645, -1.2580057705825578, 0.3220557068099603, 2.2231600224212817, -0.1299777165469996, -1.0267442860201779},
    {-0.718807025030777, -0.3163733533091506, 0.6282809742839185, -1.083924474346295, 1.545970169599584, -0.3727819229081617, -1.671994192547755, 2.287701496809556, -1.0602899116579274, 0.17121883434862004, 2.0535864687363445, 0.625692801311364, 0.8272797606764742, 0.571562645591549, 0.3079141114803339, 0.5544413363918484, -1.1534284874540508, -0.32649757747367747, 0.8807251459923326, 0.7080546220942542, 0.39681692141854236, -0.4681847417581978, -0.27735515929366866, -0.7219394202590625, -0.02408733829957939, -0.6048084298122742, -0.6197455733273195, -0.38601530912826904, 0.399659114014958, -0.2682145463463509, 0.18819662797391754, -0.00357326766944645},
    {0.7707391585762264, -0.30229609321488826, -0.21206078243882967, 0.6651363321025898, 1.1433857065108537, 1.2851331228906808, -1.648271935855913, 0.9061185036602951, -2.6512855691181354, 0.15080944646108477, -0.8666034987284124, 1.2325180738894999, -1.7589844725553265, -1.4808272458784977, -1.159092026337084, 0.7232448258016906, -0.41528923947693963, -1.2195565603519836, -1.1963785645663654, -2.1117449430529263, 0.5053739391550609, 0.18466993840128562, 0.03580215318572548, 1.8320183660120557, 0.2840646226080994, 0.4085498914897463, -2.2549997303908524, -1.4817235617872129, 0.21075701848604883, 1.4003777985863883, 0.699416500432426, 1.5495895236122967},
    {0.3220267544623808, 0.27309071113823796, 0.7964476211929469, 0.10947226545273782, 0.11334633807451443, 1.6405148434023071, 0.022737731998730693, -0.7725110264108008, -0.7658110843386526, 1.2714941252254297, 0.9789201743739384, 1.4292206019318654, 0.27176621318410166, -0.50354774762963, 1.4549107186144594, -0.2222757331229828, -1.0973225949357872, -0.04312840968359727, -0.6025926587191103, 0.3992533482200878, 0.5894023395895532, -0.9904951363544815, 0.3105971494170523, 1.7842544642167026, -0.30032301251479304, 1.0405626744405136, -1.5549704216057922, -0.6409755490447897, 0.3692509877263897, -1.335756523936581, 0.041910681776824, 0.6269603094059572},
    {0.5779165186666909, 0.6155727451386305, 1.2328822338759338, -1.186501481296448, 0.11715237714986171, 0.741732174041732, -0.8504566465246148, 1.6949449325815078, 1.2155713872941156, -1.04057599929797, 1.2700172600791746, 0.6687699995241921, 0.3593900687972881, -0.2346824021801623, -1.6232565099539966, 1.2816766189300797, -0.056628053499028906, 2.246365571692953, -0.4529449450301754, 0.19356515505923605, 1.5537690078354345, -0.7343062487363792, -1.644586806149678, 1.356411057392484, -1.990283501252425, -0.08830643139467945, 0.28583378643197344, 0.6326985676384718, 1.014702733798498, 0.06028630850597029, 0.3991746224389472, 0.9983087219097975},
    {0.8932711000655739, 1.3925644199214877, -1.055929197556614, 0.39333654388900063, -0.08727881834680956, 0.9107381261212651, -0.830114810772329, 0.7405236892728977, 0.2426147996293909, -0.7044119207266357, -0.7700536900087941, -1.7594121048975229, -1.1994950724430826, 0.08153202076527154, -0.9386234986194565, -0.6262963223174252, 0.4990148522087452, 1.2927526565884684, -0.46851037404064966, 1.0904664235413153, -0.588535532492391, 0.039095037336100424, 1.6336865174664053, 1.576417136548289, -1.8323467754392273, -0.9921264579452419, 0.7377278664836511, 1.6058617402149016, 0.8876928198559575, 0.47277277811106855, -0.10900825133299417, -0.41006434196688124},
    {-0.05289116749242532, 0.8941936854534235, -0.3323286058465806, -1.0762222755692459, 0.8925827664798471, 0.03526147307691719, -0.35687347325566127, 1.40866660610307, -1.0201950653262573, -0.6302517417882818, -0.8180309746117109, -0.5494022093033241, 0.05454030264865307, -0.9104008380565063, 0.1574511488160313, 1.7266206789910485, -0.012861443978682904, -0.29813527560217007, 1.4985871154795374, 0.24287953567975015, 1.5331311855111898, 0.07087127851596473, -0.6936606590796633, 0.5823324389861442, -0.1645323339044904, -0.15049014599323055, -1.2508258730848654, -1.49494211234522, 0.20856329656177983, 0.6361000707321411, 0.1348101141770661, -0.2431559808793893},
    {-0.38811973842334563, 1.4249141765376612, -0.1259372486884824, 1.016801828624324, 0.17077284197941, 0.27096493136583527, -1.5286932890090683, 0.7104397281552491, -0.3891326962176047, 0.48373389323675037, 0.6273597298903627, 1.8109160268537043, -2.13768104871114, 0.8494577388223197, 1.2561354050248652, -0.19777706918604532, -1.2537074797921415, -1.3658676433943562, -1.1223379778439144, 0.6152044677217169, -1.7827423900433994, -1.0243924951204144, -0.7770264441860034, 0.7365318051410857, 0.36649694497238816, -0.3791668340863936, -1.026302391540912, -0.02795796154237062, -0.4847377821549303, 0.3882069643223417, 2.0795688371620065, 0.16074910022410502},
    {-0.5098316856239512, 1.2830511832852745, -0.48759295994054475, -1.5227393180739712, 0.12317594292473077, 0.037947012581756576, -1.1233998181007723, -1.104046681991854, -2.501830297461808, -0.3383392398199552, 0.1780489417696962, 1.002611492767812, -0.7113038486958577, -0.9886142412179139, -0.7391213228969828, 0.07423695324590655, 1.6640776967862823, 0.9476603953469515, 1.70855767133628, -0.9222997051686302, 0.40977034089154873, 1.140466880211179, 1.436492560893999, -1.3179369331928354, 2.145378231179516, -1.4769501719313853, 1.7404572856006626, -0.19282505414601545, 0.7301936845174885, 0.8438739908646468, -0.15438773071517983, -1.5912984347590988},
    {-1.8145016389793014, -0.15797168390066227, 0.5241548754171833, 1.576000211416105, 1.3735229889914797, -0.8814364469736512, -1.7824339881952367, -0.7995436248322306, -0.6431159723049864, -0.020932461783534178, -1.2817887460937438, -0.5893395733437091, -1.3722708093234133, 0.9693929295298066, 0.24195880559781013, 0.18889978073808375, -1.6802777707216054, -0.7552497200098175, -0.8547277390246091, 0.6398929702102364, -0.22766259334922806, 0.4131590547325051, -0.6248642214761984, -0.3951259348244607, -2.214518396969961, 1.0432064130833454, -0.16987251689083593, -2.0631140368118364, -0.7340282040284871, -0.45718514340264277, -1.3996812838579307, -0.3919314519496065},
    {1.473984727658532, 1.530879560536825, -0.08477510525104773, -1.1238217112382558, -0.3099418585228873, 1.8314390686924729, -0.4176910187214115, 0.9491716660480087, 0.13533449310523446, 1.2162829330903588, 0.4575862721190744, 0.6249362970715769, 0.31351251690444953, 0.8569918757429227, 0.2799774469730206, 0.26080814504485644, -0.5485565901284007, 0.8500524951128855, -0.3320513366182153, -1.1340413484273622, 0.8183470297420957, 0.14161789979125633, -1.4343366320646669, 2.3073855948398854, 0.7352275862272317, -0.19438628815092515, -0.40634823953217236, -0.33500022739803403, 0.004257381042680055, 0.012637357490088907, 0.8044449445798038, -0.8118075954892051},
    {0.9728757633016474, -0.8258152431839033, 0.17692036604401656, -1.1405081397747425, -1.585083835894161, 1.4694358742512308, -0.014877556017965678, 0.25464385681384183, 0.34655731924873817, 1.2219991534730625, 0.5833650479388014, 0.26443980999319483, 1.1895472387465582, -1.3408686351952999, 0.29877133171322345, 0.26993710162000595, -1.482105624022574, -0.4449640071632493, -1.6105062649601531, -0.5701004009024019, -0.026252236868987956, -0.6854968337507632, -2.472419800399065, 0.904134867722489, -0.7435932530936801, 0.8213799913179248, -0.3908723074690124, 0.6381059516672211, -0.9978847854310191, -0.39384183573494014, -0.5794575639420781, -0.32887657754750743},
    {0.28951293773764614, 1.4735551544860022, 0.22841113686917847, -0.5793852625496438, 2.8271309144130394, 1.9979016814465844, -0.21641315771153938, 2.3766271736000935, -0.8938421960020215, -1.3379258735958175, -1.2337418670352518, -0.7290110366523738, -0.20049622562634134, 0.41094768260416936, -0.2804920168130526, 1.8743273208297275, -0.5734724928620308, -0.7688210340460676, -1.7449990843183305, 1.2182536253093104, -1.107660437249226, -1.0365954070965795, 1.0495172911427413, -1.204438040171171, -1.1239099982630985, -1.119089548856735, 1.046599646746425, -0.03760278465164269, 1.1149536506174678, -0.7226990340842906, -1.0829863472168577, 0.5832968546223017},
    {1.4419387649872186, -1.5875169692173388, 0.31406497155461705, -1.7032489296372606, 0.8180794901256025, -0.2987761415751901, -0.6752701012908362, -0.6850518590704536, 0.05503773420432129, -1.100352431483707, 1.7570770831177638, -0.5035486374045148, -0.6586038197224622, -0.5111881852106777, 0.15703141938772844, -0.9922993785371065, -1.2054799930777012, -0.6314513540873973, -0.2665930830058163, 0.2579515252109173, 0.7538672915538852, -0.8106634936772094, -0.41566993791531487, 0.707138266713412, 1.445489511460496, -0.4255278243540478, 0.6660811256571602, 1.025628798112715, 0.7336900226757447, -1.48682976338852, -0.359170508218076, -0.12563974575148645},
    {-0.2382186322837874, 0.159940344630435, -0.3475661048526275, -0.029324019993796288, 0.8342654716427217, 0.7743955633040328, -0.1526265200235153, -0.5219674508496405, 0.9056087113872513, -1.321300404619312, -0.6354379547873379, -1.3878296596825157, 0.18951908916847254, 0.13128072325688567, 1.8993644156555214, 2.0447410732579305, 1.415761415770245, 0.14275658484214102, -0.787263342185506, 1.8500554509302325, -0.7440138966043299, -0.037650887253000614, 2.534353037552043, 0.03088595884280428, 0.0980656865846559, 0.015425384044032556, -0.03238200913273493, 0.6608886046788897, -0.1641792952946548, -0.7492025296103263, -0.43854343307335814, -0.3807374803217234},
    {-0.2523317905297946, 1.4372130933653926, 0.953509017643146, -1.0295855213183802, -0.9482442019770544, 1.0817315878060638, -1.0984914005434563, 0.6998359331638206, 1.2287969963648189, -0.3169913827683431, -0.41786058670058657, -1.229670905613208, -1.006519890943795, -0.5600778503826174, 0.3766459548121971, -1.5740864692881713, 1.7018057242642959, -0.8850906641314883, -1.8090332046006492, 1.7269460629905853, -0.9189112589182232, -1.3254190475334144, 0.3473924837428958, 1.2103160524862109, -1.5548033054359476, 0.4554582454812309, -1.266335077664148, -0.22090429399447223, 1.5475016432657887, 0.3626949713718898, -0.4848454551638039, -1.1553384961956943},
    {0.947329525629145, -0.09029250822521685, 0.26578190213859354, 0.2134557275942291, 0.41823089596498086, 2.2038737175463714, -2.272615158854972, 0.31536572299705656, -0.3824585215138744, 0.6819276159071458, -0.6559345750349459, -0.17108741119602086, 0.31887051942916783, -1.2516821208487694, -1.2007651859394441, -1.3092166266917398, -2.1438840678795454, -0.3915832801826299, -0.031099722463465575, 0.1765546730366742, 0.14828940876720606, -1.282140172540182, -0.655160160697396, -2.3330426120581156, 0.5616333343860578, 1.292933811996604, 1.765203666472722, 0.14891001341562374, 0.5126258626479977, 1.708783271123334, -0.7543727133416664, -1.1220514874410312},
    {0.4310734580608505, -0.6213177965532768, 0.0695069627310807, -2.087144143134136, -0.8538481473725344, -0.3675293345185189, -0.9420788992736226, -0.19220929473044776, -0.9774244768842512, -0.573025619280739, 0.3151134009824349, -0.3228747988086863, -0.27227556682769444, 0.8441287114512468, -0.25128324761948817, 0.5118354724186385, -2.1490640848183493, 0.7914846303205822, 1.5422526621324888, -0.5026722390057399, -0.9167412988681071, -1.3136512908840545, -1.1459542376790544, 1.3755149136424425, 1.6767721984643382, -1.0079875731989214, 0.05795638306701455, -1.580986549441814, 0.01128212426127609, 0.361434011767507, 0.4534922261398524, 0.29922773738392816},
    {-1.6297702906242806, -1.6712858648102003, -0.20438173572494303, 0.1554076112961708, 0.2967349715561672, 0.2882578320815931, -1.1620309319004332, -0.200552329413622, -0.7270284980224958, -0.8924193419711076, -0.1732851940622645, -0.0490783436249032, 0.7373128537809329, 0.27787397837400096, 0.06547975497491332, -0.027212245002904333, 0.31338377263361356, 0.4207159050132027, -0.9815333040508385, -0.23490603951180772, -0.2955520618996936, 1.2380539861890691, -0.22852746279153932, 1.4647874726236072, 0.13377865926551705, -1.3472351124248247, -1.5776107764790335, -0.3104009847124659, -1.7472852080195314, 1.1152128807074013, 1.009827681019345, 2.0107524922450195},
    {0.4475527306876752, 1.231330152398693, 1.7548553009833603, -0.03792479164770543, 2.5555552465589275, 0.6320248794158597, -0.37394533144230235, 1.3846017238816448, 0.4081161470866581, -0.8166784132984694, -2.051563564524699, 0.0358971334232237, 0.06741243170321877, -1.0809631901583059, 0.747959673759477, -0.3735973478884285, 1.0327231740573797, -0.3876182782857101, -2.026876475401572, 0.78978441787042, 0.6536043777809605, -1.0738176405157227, -0.6870549558140144, 0.4618038981817543, 0.24208385480956346, -0.0681941292358628, -0.8696582074575194, 0.13262664058227425, 0.723721852195044, 0.16867086881431828, -1.387026158909599, -0.14237661274316635},
    {-0.5012994582228543, 0.7996953004401014, 0.2904679439519295, -0.1788337602998937, 0.34900721087157616, 1.3781989244380952, -0.697018933169129, 0.1994400672722455, -0.6080699526269182, 0.12932567926548233, 0.04553669477336802, 0.30700499069221987, -0.618896990458078, -1.7844143678423046, -0.9640315461358978, -3.482414767273555, 1.1706666452705916, -0.3788022931318218, -0.18171885063149457, 2.698169723218474, 0.11381009111623276, 0.03626137406546935, 0.3701758755439358, -0.6570693953288126, -1.4365818831049746, -0.5978571189971068, 0.050979054127506446, -0.33698340733488574, -0.8510227457659818, 0.2961204944935559, 0.03151857524469986, -1.2680470232190417},
    {1.069886987565092, -1.7824724738470947, -0.42615757487169686, -0.13369488861834014, -0.5985075564683072, 0.16459950415068614, -0.01352999302408899, 1.2750213930942773, 0.1991963398458322, 1.7407507133578919, 2.030225507360332, -0.12211415941024044, -0.32662814054463685, -1.8496823125049464, -3.2279355788092614, -0.7307366731350486, -0.590842617251254, 0.12225920791756116, 0.743094149106337, 0.33820378233889203, -0.21585942545573827, -0.1443077229040757, -0.44541849286588625, 0.5376639570273839, -1.463476123501617, -0.9967914756756509, 1.5436126130310217, -0.6848419246775388, -1.0518396311279978, 1.250404342699671, 0.834547299588818, 0.6599746525213285},
    {2.4930943695158283, -0.5342160625898551, -1.5028888560280012, -0.2301793613886734, -0.8907178250854554, -0.4283520452162804, -2.2521961564844455, 1.2460212810910103, 0.3504052912137102, -0.2736866120365352, -2.0485502629811014, -0.847528426928415, -1.5137234363149925, -0.5791213438941847, -1.4429356876679715, 0.3689195327791453, -0.18157867165519206, -0.8379340456093977, 0.1865792094900371, 0.655986630505646, 0.9555067570323109, -0.23470709574951154, -1.2357838178365987, 1.737951622703162, 0.2852240101352749, 1.057029024604187, 0.019505906466717227, 0.8944415827119907, -0.039352263625685606, 1.4504318186398053, 0.6955008680720404, 1.2414976947809389},
    {-0.28938731216073227, 0.17118624651796954, -1.3874198949967163, -0.8495054129363732, -1.0735609365110668, 1.425467928898991, 1.3402725461267162, 2.1902167491451148, 0.6867068885112702, -0.194722173954344, -1.9995680155949125, -0.3526650119938624, 0.9196070125668764, 0.7817381121794311, 0.12183009817648385, 1.0555350255592386, 1.4060724335053256, -1.2726356219559152, 0.038412089199826596, -0.7694542603923717, 1.1035205731774496, -0.7109180137541565, -0.14777531856356144, -1.2824493879524934, -1.680452676477555, 0.02930914466037174, -2.548663446502118, 0.712378700161781, -1.694375713145902, 1.4439655560583282, -0.012737802103644155, -0.4314505796014015},
    {-0.07689729481703093, -0.0991555798665434, -0.4070499071404884, -1.0027475044317313, -0.32764020607181255, 1.6038254451779894, -1.8469437400142672, 1.5790128851607517, 1.1040505563141163, -0.8133579682488954, -0.20826455748160685, 1.127156258799109, -0.6488304964798928, -0.3754312205552349, 1.4535526521001603, -0.5557078600205326, 0.1917434309070247, 0.7455819843392842, -0.6629054750091563, 0.850061038901975, -0.28096606169422284, 0.4314256141846279, -1.2461829184335156, 0.908785680037497, 0.029489890202828124, -0.2503292304523952, -0.13078741583062214, 0.03158297626838128, 0.30496632123616857, 1.1927332933940373, 1.808991608528, -0.7382574113160553},
    {-1.4688259649228423, -1.034547254717317, 0.04487465665456109, 2.233371588530912, -0.09131623118021835, 3.1322758591481863, -1.7346012516399845, 0.30421369845609186, -1.3645221768681886, 1.406415736771347, -1.0994879387239584, 0.29517413235103834, -0.02661542384029586, -1.0161565603205749, -0.4505769367213028, 0.622294476392029, 0.7767795456738347, 0.8447467006369568, -0.19751340784637994, 0.3171659473390848, -0.16608315392429257, 0.32195954177861047, 0.25242476679778253, 0.7230307998227159, 0.7279127141508972, -1.1960500206034315, -1.3629243979957935, -2.348246752615989, 0.05699727926681563, 0.7719040021241647, -0.2040457849424259, 1.1578697468617114},
    {-1.5634360881856197, -1.017896484375549, -0.31265164130235723, -0.29059026951432815, -1.7762402411922389, 0.0009930050196977828, -0.9178459740895123, 0.869652924613713, -0.07226397304411064, -1.8909722504003075, 0.7414597700521366, 1.2036113127792893, 1.1917025455233725, -1.339912416829905, -0.6018652389531721, -0.5482259659337315, 0.4082040188976492, -1.0933094634291682, -1.223585433015114, -1.6140688961653467, -0.5752005729108784, -0.17989683888557814, -0.7969310136373414, 0.24320438842001235, -1.00780073542612, -0.7474576437953856, -1.429264664512828, -1.1670606374405887, -1.6328187257478088, -1.2177637311787772, -1.0318626457677564, 0.3921169392548248},
    {0.0929898808489225, 1.7811529832176733, 0.49108914227623424, -1.4201320663486197, 2.627414345680673, 0.6860684249600459, -0.4496364171960538, -1.2282164071325687, -1.1546367971864573, -1.1130445014042756, -0.860196040176122, 1.0981223648756193, 0.2601821815425173, -0.9406154943203843, -0.5749213628619402, 0.6821825754031946, 0.5685853219966491, -1.7665466298913817, -1.2992578159152455, 0.37663621244158174, -1.3786709940019077, 0.21582186300161665, 0.2502562584234456, -0.34630569455553345, 0.896208637916359, -1.3769271371167724, -1.6779368690910317, -1.0935692608212817, -1.0900849042464076, 1.3941358284022745, 1.975633940960683, 0.8705993151006607},
    {-0.0036851901886612404, 1.9221922795765238, -1.6805769316672077, -0.5694659590115924, 1.4075888749712036, 0.09164057543542928, -0.1224657740500417, -1.4227889240987044, 1.038354498767692, -0.5938579694708875, -1.4587915880558693, 0.15407385484115027, -1.2749880277802728, 2.400016416230949, -0.08351128500813383, -0.3053958742490341, 0.20737033375389563, -0.9308359553183169, 0.8807601386369617, -0.9723220325904565, -0.046633203133868706, 0.4230226163818773, 0.015180450496405127, 0.8875178308307434, 0.3153904644336572, 1.117825014642557, 0.7663175608818479, 0.14595213583333477, 0.04190115958737721, 0.3367984274338883, 1.493487959598893, 1.4260117740683778},
    {-0.21324852264345368, 0.41737055106825155, -0.5428932858587041, -1.476165329133641, 1.3786901417754078, 2.5330323741341263, -0.7803295910700414, 0.49595653737801354, -0.7993497303446424, 0.011370377303258336, 0.7280535812300065, -0.975085450383218, 0.24627209643372414, -1.4499918813567767, 0.20727460463749645, 2.840737157576641, 0.17766541107718017, -0.09936224218585087, 0.3629669324570519, 0.5250625284351506, 1.3135200141308045, -1.19161301166837, 0.9862313598948879, 0.0032251186422738954, 1.8425584437210267, 0.6426367881462715, -2.043528899038132, 0.6908557559870878, -0.7423287148312518, -0.5799291115985561, -0.5762600943875608, -0.16619155855267628},
    {0.33013297337864356, 0.638783106067964, -1.1066202549891173, -0.9461090087613464, -0.03855123942026506, 1.3628188332079287, 0.3346400510639468, 0.9925997885285153, -1.6426657079560456, -0.027431698464617273, -2.5480858161050532, -0.44307601715066375, 0.5195704624742056, -1.7993710995110008, -0.5985820839912293, 2.543485540228068, -0.4093694756921043, 0.3100355013909898, -0.5353758316396883, 0.6079293574103429, -0.388000881855515, 0.1122109411412813, -0.5556210555670531, 1.0767354652647076, -1.1837744697178456, -0.10070742096738605, -0.15771440391375566, -0.6074047263817427, 0.06188244506282108, -0.03930662051498833, -0.4582073059909394, 2.006123300018753},
    {-0.002797277811534414, -0.5505935579102118, 0.38982807963362004, -0.06459314409369278, 0.9083576721934081, 0.33988633389823036, 0.3137474383158036, 0.8602833070835088, -0.007813298054940769, -0.1891989080329496, -0.004807763274518057, 0.1153179281095506, -0.2519675284965679, -1.1965133609661383, -1.0347106109603512, -0.5075269164340329, -0.329667623358729, 0.08927317095185905, 1.1470788415852484, 0.8531063728150092, -0.23810028253076482, -0.06977676913011485, -0.5250961370981411, -1.0957775566842753, 0.9839039438572671, -0.29780843702761556, 0.3163601926836473, -1.0952597399249866, -1.8759223840867918, -0.34967878769555594, -1.0941558812420658, 0.12524626288872018},
    {1.1310201526829877, 0.6377036508155157, -0.8813576303903696, 0.550365016894954, 0.9484562838491634, 0.28907818088979004, 1.1359138355473855, -1.9659909583588275, 1.1086320655167483, -0.6856691696519656, 2.077959030582778, 0.7061795792684744, -0.8000835194690831, 1.0573799563819741, -0.4355096966074007, -0.681331095511923, 0.6689145621210022, -0.25801317423911674, 1.7939388410884285, 1.6607831089757725, -0.6891604772350418, -3.0394619197059005, -0.8163486247915339, -0.07145171063136546, 0.06824133185837132, 1.1274968255234272, 2.1376416630609616, -0.049095758072620545, -0.9576005657462585, 0.8412578449522423, -0.7885568862747154, 0.7008872291295798},
    {1.1068799596085588, 0.19836478396206111, -0.4630220121214667, 0.3349271667301183, -0.38788853028730375, -0.3821279555235263, -1.206456818014672, 0.6426700968403865, 0.09323806709611275, 0.7865736791547725, -0.856865239762635, 0.7363394763523684, 0.7066452178549288, -0.13801756735938084, -0.27857446407862146, -1.7670873685330586, -2.2648221628643914, 1.2392250266330056, 1.748514561704168, -0.6376567408058306, 1.8593930143224942, -0.9217747151133028, 1.7716136033743113, -0.11564760414344001, 1.3518712074487225, -0.8132330314259727, -1.9192900245605429, 1.6087140385040253, 0.6167343031483147, 1.5301254069738444, -0.16063284034155198, 0.4665243503789685},
    {-0.6536122316286055, 0.9605995848951114, -0.4354629439195593, -0.8912333467649135, -1.5528825363095626, 2.2874018625912096, -0.49127672096583436, 0.37779304221426296, 1.073404189856234, -0.9216487908376971, -1.3809773949794555, 1.5661940528512148, -1.7910855067192013, -0.09790790115884698, 0.2984936041006521, 1.3691853816660446, 0.6425019078285386, -0.06197889794314127, 0.17438035381543765, 0.6378692667401192, 0.3685902980431994, 0.04784883548467497, 0.5458095774670179, -0.9861809574355721, 0.8853346416289763, 0.21865687082183285, -0.8564749219747829, -1.5721671237050205, 0.8887986034822587, 0.5024862959334496, -0.8615987307730948, -0.4580237706085044},
    {-0.711866836850796, -0.35119286334536753, 2.322210493860374, -0.6792102653194807, 0.34947154915366735, -0.2258735325204474, -2.4624913737004133, 0.6555620679875278, -1.4349379552029224, 0.5059886695371881, -1.4220181247377242, -2.02157190068779, 0.02602221479491182, -0.06699229098977047, -0.7463681940275312, -1.4488160395645835, 0.17802333423471403, 2.221109047228726, 1.6082961871547572, -0.8283398899175906, -2.908118915088189, 0.3688888811466493, 0.32585345910377445, -0.7779263080980268, -0.6340619570969432, 0.5953410484950875, 0.4440732357309964, 0.039495209675784876, 0.28785127944924976, 0.841718334726512, 1.771147762846487, 0.2852071543577236},
    {-0.7816995809243124, 0.7140012691907481, -0.45127424305606656, 1.4938495389540816, -0.25769283474676075, 0.668078562649645, 1.102226416235699, 0.4941340988463121, -1.3231055790460384, -0.7451065658105406, -0.8799221326610943, -0.22059232239137588, 0.7522555286605402, -1.6748043662963876, -1.0044876879983, -1.037716803082331, -0.4013477038939237, 0.5765465761418295, -1.6975863600139194, -0.1418251205604546, -0.6309900155677594, -1.7842559133004072, -1.1884278257691523, -0.00424139605594871, -0.3958845492679112, -0.49862559966522474, 0.5356983897205427, -0.3188734898411846, -1.1002577471348025, 2.0605776231400466, 1.0176338335777961, 0.21938592179875466},
    {-1.1396880341829856, 1.7767400062797114, 0.6549060725331075, 0.2861419305715932, -0.6456258054991135, 1.291509611413128, 0.4203338635185237, 2.5757405520262084, 0.5528379070279854, -0.6208153732120588, 0.3742782692271391, -0.7231222590144752, 0.4900239487859608, -0.41888892895750673, -0.37158776407068655, -0.9001409231536804, 1.5791746432589207, 3.0342175749547144, 0.21538511299901447, 0.10238040588315597, -0.1860655846164865, 0.49833352375919965, -0.5416320912590993, 0.7030164658470378, 0.8601988937920854, -0.08776958600946964, 0.699488278193443, -1.0963295197976324, 0.20999753217517655, 1.5684638639016923, -0.7095647805860681, 1.2129167527586422},
    {0.1794133033814692, -0.30053574496179103, -0.11744068848465114, 0.7417566932620316, 0.35084835731760394, -0.6907210861126806, 0.1777036155858656, -2.8709838381584234, 0.9439459034704333, 1.1965625284910517, 0.5653564737533056, 0.30511005957167386, 0.28613237023760624, -0.4362522254610876, -0.1209770501125845, 0.13827790364048687, -0.8533393836172155, -2.4579578547608634, -0.25602594778060084, 2.157837295425386, -0.416244362601578, -1.230583821326835, 0.6145881883443983, -0.8038331864339445, -0.08361747751908476, -1.5916084309905245, -0.016844729401029452, -1.6408529066193211, -3.1094527063545407, -2.3590737437829397, 1.4030491280492003, 1.827292938639825},
    {1.7292308834582715, 1.1923307663315592, 1.4845063392276239, 1.8680321566288052, -1.805879059559141, -1.140751346849361, 0.2925700359995564, -0.2261609417001984, -1.2826438631906238, -0.7151097407470787, 0.6238184540167842, 1.7149344530863706, 0.15509279388982278, 1.2413824735178964, -0.4783622221711967, 0.00498585219832444, -0.35211794011701464, -0.6500254909369654, 0.5848515029748416, 1.9486009180187718, -1.0073722799080669, 0.8205568034510466, -1.017101927031204, 0.794098329185877, 0.9734245197216067, 1.005962156233987, 1.122964953423051, 0.5466712813618065, 1.478609164304095, -0.1620359668980465, -1.2500576094499833, -0.6133509323526515},
    {0.7521638344945346, -0.7932924899832104, -1.4989497188258187, -1.5462248583862168, -0.8386292082807888, -0.2488086422952445, 0.10684603086284834, 1.0841954374677616, -0.832484131853607, 0.21023482104146235, 0.4234319760193494, -0.3553389724296566, -1.1251155011199114, -1.2181292585574133, 0.19281908945610546, 2.248951420947754, 0.1422742123934468, -0.7306577850739306, -0.108670274700861, 1.0739548860412624, -0.5700512838915066, -0.9595887852879633, -1.1832825023330384, -1.5597638470717177, 0.7524940675077618, 0.5041670173838412, 1.0504498249761032, -0.18040969611433516, 0.4554408592284965, -1.284225639779869, -0.7744846042547894, 1.30916367586194},
    {-0.43053415841302856, -1.2423634730401456, 2.1764840320358636, -0.4456099209365627, 1.0112122623662136, -0.17236501198666265, 0.8571597310653809, 0.24815845471195658, -1.4528529407017627, 0.4506109367463158, 0.9861587312133365, 0.6271662412937631, 1.1644768618188996, 0.17541100603243934, -1.1163943965207637, -0.2970760213393614, -0.9716587096059476, -1.3552150264211307, -0.23702674761365355, 0.4885974853516327, -0.4713453916338763, 0.7487613945223236, -0.8397166039597176, -0.8292414569727895, 0.0584671435372918, -0.43362349410189593, 0.6848002670171167, -1.1556280643376788, -0.5371128288474674, -0.425690396442992, -0.8204115543552146, -0.6658144466829673},
    {-0.9160946800130605, 2.06376738409328, -0.08045378220753632, -0.21099708212428134, -1.2065904853842304, 0.20325387330543873, 2.159920958390393, 0.39100162061519905, 0.3886092955040973, 1.5837723569558972, 0.3901134202889343, 1.0622941553139056, 0.5036909026416708, -0.025276666593366273, 0.5157134124783525, 0.2790887210679063, -0.5327328224247404, -1.012645337381193, -0.936009791112618, 0.7172914345788708, 1.2390922174302854, -0.2679039551151161, -0.2884116260996717, -0.9650431811319653, 0.46999701839296276, 0.08056160140664972, -0.19611295832187584, -1.7794198293095693, 0.4214159487281762, -0.046057639108061495, -1.9019349750279375, 1.4458174432990742},
    {-0.3201257278935909, -0.903997441593783, 0.4747884683720767, -3.312808640329278, 0.01222919400295859, 0.22221298879643003, 0.1422370400949904, 1.072786441953516, -0.2960935228380847, -0.004071030727011113, -1.163894651967465, -0.4157375133442127, 0.6975378673025117, -1.4229507334884943, 0.16178917830153738, -0.6915144188264194, 0.2364267975595021, -0.8369213897906931, 1.0510192803389353, 0.07284496207003904, -0.6610266440570358, -1.75618613796748, 0.5995488226199831, 0.4974740332056484, -0.5807030300715602, -0.2643940652832722, -0.7913609805337051, -0.8566006811970569, 0.10799474139977143, 0.24072674595767388, -0.6110466278792392, 1.0724449258438966},
    {-0.6358497390320456, -0.11165470466674411, -0.4837115745413697, -0.35084493220604585, -0.5190781122403043, 1.063013151897107, -0.16712635431407386, 0.8258551474235228, 0.2579600060852648, 0.40750297842467215, -0.7198757223804486, -0.15972422538897643, -2.0332633406097074, 0.24927299003487438, 1.862771144872784, -1.221216863372249, -1.3520885632377861, 1.0236466425989548, 1.1343646871982118, -0.03087622718342464, 0.9091223490029169, -0.11733099957863063, 0.08107948628228459, -1.0552186413216478, -0.5391008962979467, 1.3661669946703403, 0.6043170582539902, -0.5027177215598895, -0.3532864712942131, -0.31197668140706003, -0.46070541904142515, -0.612020397050981}
};

static const float b2[32] = {0.261989120859232, 0.6844779343305744, -0.1380534097818344, -0.19889406407742502, 0.4805368416577114, 0.6190556596989225, -0.15902737838167502, 0.17030206554227004, -0.3163578165202253, -0.19407511382076306, -0.25066465518435593, 0.12973475895684902, -0.063539575217509, -0.20093201405885935, -0.07902236209010809, 0.25158525969395695, -0.0686448514985504, -0.19391354477097442, -0.13058101354959278, 0.0402461299283412, -0.3633478539327179, -0.1326758283169686, -0.2147123933382774, 0.17348918478661798, 0.09327172270043806, -0.15229926630570553, -0.2097933836971035, -0.2546484725539628, 0.40765068062689663, 0.3498765308876416, -0.09209932190274046, 0.10062294817672277};

static const float w3[32][16] = {
    {-0.35377242261012265, -0.839394654828779, -0.10655667872505423, -0.03988735696451993, -0.2920847193150124, -2.236715098127586, 0.6646181940283807, -0.8822707313525322, 0.6819988415000742, 0.643958543996562, 0.22197719313598807, -2.948387867624716, -1.4262410896831343, -0.6014231164767485, 0.7655968518391603, -1.767884658238302},
    {-2.3931227853273938, 0.16703105354360023, -0.5903415485141589, -0.8428234412204406, -0.2585506515244547, -0.3626537722136799, 0.06550806227399907, -0.5858435158659379, -0.566994654042851, -0.4479824735023337, -1.648286976740448, -1.3185536370698483, -0.7901168618795058, -0.7795868404127733, -0.6033773625871831, -1.5138673630570922},
    {-0.5888333465210749, -1.4138537558615778, 0.93341126120561, -0.098905647224187, -0.9802740578406616, 0.013925018142048412, -0.03503651483383241, 0.20578181582592228, 0.13785805070749646, 0.1085440352580971, -1.8617097436150836, 0.08509356567218915, -1.4441955413145, -1.3730092797432547, -0.502262200231106, 0.3624973231838238},
    {0.6294004399589621, 0.6436430956162229, 0.06810245831823865, 1.203584895349911, -0.37119913759470563, -0.7883592618494137, 0.6573197479193537, 0.10696267644207232, 0.956155050198343, -0.6364612559573922, 0.35426149644220334, -1.4035645849865261, -1.6799300593213653, -0.7997930196576999, 0.6987642942688638, 0.11748370909832981},
    {0.225787923732156, -0.2651451192781316, -0.21584549822480267, -1.0072144283808202, -1.0189010175580375, -0.3370909691917466, 0.25585188054271724, 0.28445458469782153, -0.8758567375361647, -1.364623623912674, -1.77815373056512, -0.17204884000494283, -0.5397804440667422, -1.0419080582577362, -0.6648420816349287, -1.61711407980231},
    {-1.1219643688831302, -0.6003140208507919, -1.369121228817655, -0.15986100827549288, -0.44443521161745736, -2.2683455022403023, 0.422258055976894, -1.6748350294415095, -0.11945931178355311, -0.3405908403016414, -1.3395265828541034, 0.6040438963357461, 0.803472366765084, -0.41604650403110627, 0.30557336754338493, -1.0415637237672375},
    {-0.9374537321645204, 1.1859412632728956, 0.8829492731086426, 0.4158993035897616, 0.6498688728678733, -0.8458165264629725, -1.5545883939645182, -0.5193898861908569, 0.38962620203727366, -0.6425081068054892, -0.7860068041551095, 1.251369955570248, 0.4699540839199772, -0.48219627584981684, 0.31532275307291546, 0.00405496098924199},
    {0.39668870523515215, -1.0277599777769617, -0.841869478064162, -0.5886468413827123, 0.8765040232642303, 2.1506552391001867, 0.4015952488047974, 1.258393461294857, -0.6858974139962318, -0.544690178541604, 1.068032792859786, -1.002716323475352, -1.7780299282325271, 0.5194284464023274, -0.3206170690908406, -0.33523119473912727},
    {0.45173384083122525, -0.8969976761273937, -0.056210014918535736, 1.0957300710336213, 0.40352111434703175, -1.4399650235186041, -0.6282413307727953, 0.7185294735989186, 0.9662547758010779, 1.3447772237922477, -0.977704022879936, 1.300584600747427, 0.5648103920616703, 0.4169622351057327, 1.560162732455328, -0.9566588409030086},
    {0.47595867979385725, 1.566315874792066, 1.3582769364610932, -0.38098246445512, -1.9041001710381436, -1.3682681254179712, -1.1607890172748516, 1.2866767997218738, -0.5179175933772106, 0.08825603726288596, -0.433247585771459, -1.2461562992522717, -0.8158744879429678, -0.46196607214285224, -0.9971937796122612, 1.0183572656833204},
    {0.5358297142588655, -1.044428496084221, 0.5768809095397477, 0.30208096783148886, -0.6897755070474519, 0.5733033584418689, -0.872028779986238, -0.35242414907904934, 1.3215209436265911, -0.20004829067711363, 0.3639754494220332, -0.6572421997265786, 0.3588489939604335, -1.201545563131358, 1.4349381272696942, -3.8378245265672466},
    {0.2702534308297394, -1.104521509088298, 0.8167961055748868, 0.6214496153489613, -1.0274818851538923, -1.5396343796481147, -0.6584446960229584, -0.8681904993333233, 0.6549562210828989, -0.7920879174824537, -0.22604129947150253, -0.8833678786419795, -1.693388887139273, -0.1260440643634293, -0.5770849207063495, 0.5824519723155307},
    {-1.5312476760046605, -1.5118555864015555, -0.12672926911771173, -0.9188792724594058, -2.0754529272893225, -1.0562523346847636, -0.21000052534267663, 0.5394949882988787, 0.9508925625693988, -1.704682667351745, -1.8222466981829395, 0.6005406758397002, 1.2204660426419585, -0.9634093803141034, 0.6629193069581962, -1.6333914534180656},
    {-0.17603955054196865, -1.4219458371268967, -1.030899403091214, -0.5932815807736422, -1.359223332311213, -0.43769420963326044, -1.2477124728186746, 0.1456552300986368, 1.6875736558184267, -0.9949896824839191, 1.6716452522439318, 1.725640358943083, -0.725233307357753, 0.6859180794844307, 0.12365304465193555, -0.3104741515357677},
    {1.2063083940012236, 1.0143813690291996, -1.2692225533584842, -3.1313775899434417, 1.829232320656997, -1.1393757910186508, 0.7238469966114719, -0.7396970934848159, -2.182127312859667, -1.1030809280010432, 1.4011934316270576, 0.011489263094805444, 0.5421050609178821, 0.33584897742936537, -0.8530284755570584, 0.6010197985491842},
    {-1.033938201094199, -0.3511508969746164, -1.0558755705629814, 0.14669761453682031, 0.10804004381873313, 0.3329656656814433, -1.4418491965362021, -2.8519645439511105, 0.5419264895675752, 0.07539326564651026, 0.030690502601837245, -0.1702913284148253, -0.09860779576516618, -0.6318799041855511, -1.8136892919569527, 0.7051782405520516},
    {-0.39690328235295685, -1.8475824880365017, 0.6946759545605201, -0.5275463254936426, 1.9742968583825542, -0.28275356394276174, 0.12408257228797245, -0.6198498761953416, -0.4571450594989622, 0.3481979195214772, 0.8920684403703026, -1.055203084541489, -0.8000736818793337, 0.7938612436809042, 0.40653591471013356, 1.8331008623217409},
    {-0.10087866020441726, -0.7129235278254459, 0.6079053973198905, 0.6844379117506724, 0.8407820942496402, 1.448946621987879, -0.9225498037275303, -0.03223225126717038, -0.10412598865017567, -1.212590949117295, -0.060956708465140216, -1.1722134494407637, -1.1658525286867722, -0.9565783679551418, -0.6794707276599591, 0.6967845964992909},
    {-2.17178766520403, -0.41622963150251446, 1.378668471177735, 0.9868385727782144, 0.6721041902392739, 0.17739486668715523, 0.4258205482784759, -1.2791448559178045, -0.5359883020784447, 0.7187347505203862, -0.5595663184009372, -0.842499195552115, 0.8500366904151966, 2.015009725714538, 0.6195344998076493, -0.16215506253492684},
    {1.2674120047760593, 1.014207400212685, 0.16237923449843938, 0.033433230537345114, -1.5236419308173665, -1.9557099897522672, -1.3700682066444165, -0.4352747501373463, 0.10593389359233008, -0.8395415930813198, -0.3083150955023504, -0.5050057740725696, 0.28565964181411907, -0.5264751374526699, -1.0597369740029092, -0.5690514078548473},
    {-1.7188249348915823, 0.4742266582409643, 1.1947912402596552, 1.3713813698650945, 0.4701877318206929, -0.22869915947056105, -1.3162032908692292, 0.12031742159762562, 0.9870340009521655, 0.2962865390003665, -1.4230969796182316, -0.02608089927663895, 0.16912418745427749, -1.3304379084171387, 0.13783233851370164, -0.785504213500511},
    {0.72058129671134, 0.2293356376995583, 0.96272913882274, 0.0847922327781433, -1.2083353130016214, 0.5857734444565499, -0.7131357945531133, -0.7612199700633547, 0.34153486906109126, -1.302295308213362, 0.5417902148107585, -0.47696738847726555, 0.44116128815557726, 1.169399255761957, -0.4215419203043111, -0.44354854049469},
    {0.9075107828379966, -0.23624644167772352, 0.31409892240427106, 0.2420775617315123, -0.956314920200122, -0.5773540752896429, 0.1368135331805702, 0.9375465598131526, -1.621995577887366, 0.20162974654534635, 0.6880131179817258, 1.394498420696898, -1.0613129406259771, 1.651189655011833, -1.623812156664147, 1.8059521308610857},
    {-1.2122989486866953, 0.45646719636138194, -0.9093955362555919, -0.10951030729191631, -0.7247301037275669, 0.8773156895313055, -0.7629024381165452, -0.38937604326041, -1.2902578151520643, -1.7467473963545905, -2.3011365775988746, 0.17812483866696963, -0.9683442399165569, -0.7636407700326439, -0.9268115279415474, 0.5046715246640078},
    {1.252911973075351, -1.1024620549519084, -1.0843576517380207, -1.2398107780770609, -0.031154204645899814, 1.1866514886189952, -1.1589393930091891, 0.15324751020722355, -1.5565344149643832, 0.12592310711542898, 0.9637974713243348, 0.49246947649552075, 0.06894269940439911, 1.0187052092353546, -0.28734112744260926, -0.4630491522489265},
    {-2.1731409591294057, -0.4399904847406757, 1.1301211881180842, -0.013675068424216176, -0.5547936869676551, -0.8572847619797609, 0.7302744902802255, -0.3084169753607201, 0.6767174046914249, 0.582940738966668, -1.220945708134566, 0.31774883193242165, -0.15747689682599028, -1.6132634347074464, 1.3943017355133678, 0.07781521063637685},
    {-0.32770424094080797, 0.0692147725875378, 0.9974344197825241, -0.5421689019406907, -0.44101304148206383, -0.3319697955164826, -1.6910156957895472, -0.6586884952275356, 0.8138939160210213, -1.828197634007694, -0.260805167269141, 1.6726334729776446, -0.8524501828460058, 1.1768832183972933, 1.0382205738064658, -1.7787388971704596},
    {0.9484019119002055, 0.7372502772868437, -0.29049173574979575, -1.8743230099824892, 0.7881023042426847, 0.5339650781237478, 0.8917726970039277, -0.14948274947648021, 0.6735610430024542, -0.19299168601791594, -0.10693309810741883, 0.9979772661792208, -0.5437151929505958, -0.029518027567233145, 0.09257995771020759, 0.6367204760055443},
    {0.6949922319635048, -0.7601581943637297, -1.7726789447800995, 0.6286037764926564, -0.9492574603248439, -0.6370982340539706, -1.080689624864652, 1.0599833952606414, -1.358840662851206, -0.14457096415449958, 0.20115070900145388, -1.0572655698068747, -1.142037069674366, -2.8111093740716715, -0.44317136867670903, -0.8816115812845542},
    {0.03586200424549194, -0.4117627303104125, 0.2412178831679297, -0.5842779420750079, -1.7747398173880216, -1.142874078109458, -1.4467231932729556, -2.8823489354938365, -0.4973377545217311, 0.6815849113857707, 0.7244366684066806, -0.5707115145007522, -0.7651575856195749, -0.6630042006530118, -0.7953204584676493, 0.27661679602367306},
    {-1.0222900321835648, 0.510305681704721, 0.41325284577963756, 0.9576543394818341, -1.228208802863334, -1.991023724280561, -1.8407330390843681, -0.5065602025599869, -0.8198053931306944, 1.1937117620719202, -0.08224611581827874, 0.34330492259221446, -0.33036949714327074, -1.1445124926984804, 0.7844104676886426, -1.8888483574202273},
    {-2.1134983759816617, -1.2878167901270923, 0.8285807406241656, -0.7275454403825525, 0.4654112542995732, -0.31468411313034933, -2.3745014220873455, -0.6126095258588637, -0.25315879239356265, -0.4044850647652989, -0.6281086518347876, -0.020997557553423574, -0.1951649765922358, 0.19753824643605825, -0.2765351976341313, -0.13724426818410268}
};

static const float b3[16] = {-0.42507012608687966, -0.3912570158129731, -0.6094122104073519, -0.20171443230569863, -0.2468013632034354, -0.49488682860537886, -0.2360730102741335, -0.13128810797744148, -0.5145634370582759, -0.21308196305038124, -0.2615515104518787, -0.49575508622588865, -0.2527471692569336, -0.20473283687644342, -0.36976803793136603, -0.3073585136928274};

static const float w4[16][12] = {
    {-0.26195588931997443, -1.1681564191775635, -0.7464498518390948, -0.27588895685059733, -0.815426680844458, 0.610995947857715, 0.13159693361652425, -0.3915498595810151, 0.4487239438565934, -0.3369336667496447, 0.072874168943818, 0.950177130919523},
    {-0.10556505414041595, -0.5439781207427036, 0.4386871409469113, 0.32464978879845646, -2.133833675975842, 1.7140210359973531, -0.5737622982006275, 0.27313008490483387, 1.1627024594036297, 1.777261937460145, -0.21853702861757215, 0.5869393552725954},
    {0.066866402303711, 1.7140677754451858, 1.161494735658331, -0.49622707407448546, -0.8069575088632954, 0.3995516500217978, -0.09516758047723413, 0.9001034548727664, 0.46526816902154317, -0.05330043627210332, -1.5198674417195404, -0.13257803707306093},
    {-0.3906755274836138, 0.34464760423285346, -0.5807440117320919, -1.0858245186513664, -0.6050918432919876, 0.3330068993534248, 0.3701203755532665, -0.6640691185520311, 1.9343703207491592, 0.7934230681569093, -1.9294131412006124, -2.588786870907567},
    {1.3085167288418063, -1.7933486787019244, 0.9683626959979433, -0.47198363097563373, -1.4860667650908708, 0.8500137881259504, 0.4724724958925706, -1.8970563424457902, -1.4378164067329886, -1.3534861500536675, 0.9424862985124737, -1.177955133310965},
    {1.185460028525109, 0.7610365295164891, -1.1186830809250206, -0.18990092308485304, -0.7178366699163263, 0.10076872594659084, -0.5357003302141307, -0.2953330073444084, 0.23881206662487883, 0.6650621241060508, -0.2990987440843303, 1.0858015965457972},
    {0.3672249656268743, -1.4093444009524563, 0.20242573871908062, -2.406476915117431, 1.109254223608039, -0.7828637553626528, 1.40158879670073, 0.0779161119684788, -2.1983745162283146, 1.695317316494161, 1.3979909776283734, -0.46625961826506673},
    {0.911422710185099, 1.0625388155045687, -1.2757885662586441, 1.6252884838743857, 0.17385494389016595, 0.06752045820467652, 0.3551812610255918, -0.5621017571625424, -0.005342484458354059, 1.202015800693683, -0.28346215114505213, -0.8110663270093637},
    {0.33444359621152536, 0.347448240255862, -1.2649520248997523, -1.10409983100142, 0.11058793998730095, 0.7068253553045856, -0.5883307916861037, -1.3608750608430409, 0.6509913577483593, 0.8637139206401185, 0.14401867035086804, 0.135210621404173},
    {0.2455123833747547, 0.03145858927617235, 1.7213164958917124, -0.02553242914978695, -0.9904489215316534, 1.9411231068743717, 0.8166216062471405, 1.0626126620885796, -0.1449421691463499, 1.6205940528100091, 0.9695405245811906, -0.9819607827704839},
    {0.8324127634301501, 0.7529335314865605, -0.22951293770786121, 1.4874770253667775, 0.7572311934197286, -0.0954349336787579, -0.2715352619945082, 1.0889873313982668, 0.12106429506388496, -0.05215602968561278, -0.5083381667000583, 0.8111102360869622},
    {1.357951563578438, 2.488433334696596, -0.4893500753749866, -0.19555310082714003, 0.14851491830854133, 0.20688098262228333, -0.2409077593940043, 1.3430459633745555, -0.7445910915379867, 1.2074097709155338, 0.7112345383870553, -0.9594307973124777},
    {-0.7810777424118015, -1.2865596923793725, 0.17233017181881077, 1.027646662139877, -0.6521772909877532, 1.0526528912723887, -0.5415676515634655, 0.6457537676433047, -0.7696271970538182, -1.3710403361620502, -1.2708508322583552, -0.428891273151877},
    {-0.5677356019799157, 0.672449454307283, 0.7722091589875123, 1.027222386792845, 0.9699651115822061, -0.06030829912594637, -0.9738051794236336, -0.39690939509034057, -0.24557114815451497, 1.003825024917086, 0.19408329263293275, -0.8956901712658036},
    {-0.02958871826732434, 1.341267980323645, -0.03758841201656269, 1.3655068261494006, -2.032829364432913, 0.3970880405857948, 0.811195578522609, 0.25509716133834914, -0.05195034896862781, -2.3868409000377118, -0.5061979944384059, 1.1707615891343806},
    {-0.7300004481280785, 0.08870731965996445, 1.9733692352907912, 0.837911326830687, 1.0493141925913472, -0.4068008883109812, -0.31952742732067735, -0.32865180499482083, 0.13954017638343114, -0.4577608969513194, -0.5942862284816319, -1.7031104139699096}
};

static const float b4[12] = {-9.359324158039792, -9.276339302870486, -9.333015622842824, -9.328933127974866, -9.375689856212274, -9.285285089609996, -9.328649432669705, -9.026401693086285, -9.256298016046973, -9.302755919602452, -9.346410056605189, -9.26443407805399};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
