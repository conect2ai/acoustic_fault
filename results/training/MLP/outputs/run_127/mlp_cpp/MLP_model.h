#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.4826811665899036, -0.8114416354659854, -1.3961548262630585, 0.4225747514561726, 4.052699288935376, 0.5066190279181055, 3.322655883534659, -0.5130554136581545, -0.7742458467789325, -0.7049626965645602, 2.511234080851826, -3.6163554912016793, 1.9626853293757254, -2.950515602132131, 2.6858314752913537, 1.2424446432381484},
    {-0.02078214018695324, -1.102688387417917, 2.517969384876341, -3.0065249872306015, -1.838023430225455, -0.7485402687094286, -3.4425861622580887, 0.8541019211190474, -1.657965081761925, -0.6310414541308522, -1.391866318473403, 0.9669822796566307, -0.3961453551578546, 0.18226717532656286, -1.7466510496010996, -0.7771248322181917},
    {1.729206436060191, 3.049462215242368, 2.869318937733849, 1.552792520606321, 0.46227914305318996, -2.4834967048997862, 0.09769829396381445, 1.2600793149455458, 0.3629700755702928, 1.038020947469035, -1.6967811735496667, 5.162919620870838, -0.8900380780511764, 3.2906446926351993, 0.142818516378663, -1.8636900728336654},
    {1.3443615308706116, 2.6131428137076003, 1.1324896240278222, 0.6229183989272052, 0.7824926450860875, -2.8637235571918853, 2.1482695658029174, 1.6061064022058371, 3.6090083402975917, 2.9782869939395353, 0.1284841635390073, 3.02935946185365, 2.161225867465626, 1.129119996671705, 3.2973443889561933, -2.4590152582778417},
    {1.5993883498005126, 1.8531295110589894, 0.8371933393989621, -0.7885517335747532, -2.432517699569954, -1.815330008864481, -0.5395725448600893, 0.47585200983261544, 2.2226804133424065, 2.030624014148283, -2.0608015537021553, 3.5845777501347054, 0.6042056294659108, 1.104831274721847, 0.24122008629389666, -1.6805338012068898},
    {1.8033152589858217, 3.548285114987237, 1.4261805934100955, 1.0910514918538365, -0.22562053506196258, 0.09021539086242487, 0.3515286727236352, 3.6626955050276115, 2.4139762356983225, 3.784119549855115, 0.9135357983296839, 5.116118002548712, -0.44072459206932185, 5.289337352343147, -0.5665949485471543, 1.789485184166059},
    {2.1727152095115825, 3.2593641129895756, 0.5165358123536138, 1.1648017552807495, -0.6666585298807838, -1.1507576485264714, 0.4130760328315419, 4.601744281141274, 3.768314921487747, 2.380559295441221, 0.15561147047386734, 4.677376417703177, 0.046700278980532944, 3.8933860122573574, 0.46906408517628684, 0.7825916657494085},
    {-0.18690722717790045, 0.23983735603740416, 1.8011650648366242, 0.7950196438639945, -2.4777136965068993, -0.4403638268289, -2.245521526319552, 0.44400850934173297, 0.38920891801736474, 1.6539808243057608, -2.2203995503538496, 3.3890473865313733, -1.0189101932410478, 0.9833691717709568, -1.131806479742234, -0.57366787999137},
    {1.16048044159157, 0.8677000552766702, 2.929433178833403, 2.297602550796487, 0.7463175510035218, 1.5060752573732954, 0.9318503318179067, 2.9533035601380746, 1.2619576196489233, 3.1604898257456595, -1.404496792104572, 3.171367751984542, 0.9655697110526318, 2.609794203168412, 0.7082571037144977, -0.9290665964799156},
    {1.5791719224095084, -2.5025170407433306, -1.0449552105674556, -2.1305178854444438, -1.7748988530053196, 2.2399002226960145, -2.1274765988739763, -0.8089531548673456, -2.914135502585557, -0.8886196909680674, -2.1538202648416, -2.2704614877761737, -1.2080893063041993, -0.2527462541833488, -1.372400736934978, 0.5325788056797376},
    {-0.5882220620539454, -1.5871409249328223, -0.5509739871177979, -0.8431135608314086, -1.2415490952691373, -0.7614178572342547, -1.5091813940541359, 1.476408843100862, -0.9732762515956949, 0.3001584662023169, -0.5318029169092618, -0.9773405046679025, -1.8647313497507843, -0.6951296678892545, -2.8520771034931127, -1.0197375377356404},
    {0.2778808908785546, 0.15927625870932088, 2.079091881970434, -0.2941210929617685, 1.025923428499803, -0.36268681712552897, 2.034783945790628, 1.2837773536593484, 1.9711902232614003, -1.8640291648805503, 0.015657519622057914, 0.11782062569214559, 1.7621960308301823, 0.6585775587431452, 2.291859030255561, -0.3974691181170782},
    {2.2456627195201158, -0.17988615368736732, 2.321269597086265, 0.3447417856576455, -1.675551153301808, 2.550305127607054, -3.2263862165081947, 1.4526171421589462, -1.6960647261039552, 1.376512631717994, 1.6101995204157689, 1.9878332090881157, -1.7329456137547217, 2.740330701103619, -2.2793596501436477, 0.8439236125226728},
    {-1.4098812858207053, 0.014221148482277311, -1.5829235163797104, 0.7830447996758652, 1.7695279321075281, 0.15980433086092025, 0.4932117650179272, 1.8717642848751674, 3.19094170415309, 1.3596871936976944, 0.9461839362378045, -0.6301037677495869, 1.236391981443144, -0.33535434892740573, 0.9386555691358647, 0.577084686281894},
    {2.4166218654431955, 3.8390283861646424, -0.7004910568979951, 3.8897265446742746, 3.697772395737681, -0.7877001413987149, 2.401906451293705, 4.357800660508937, 3.032033738113255, 3.710474280101628, 3.501394805039796, 1.9940736358897355, 1.820772385954407, 2.057462013504215, 3.462916649173433, 1.650972759690934},
    {2.3882575950026244, 3.06834209188901, 3.063090344933497, 4.086038269192201, 2.077571884045308, 1.6774787747522537, -1.5047826387544563, 3.7798290703311914, 0.5474600158569275, 3.903887299272105, 3.920906616520554, 0.45197233190748093, 1.0110511376786002, 2.9925814339866084, -0.4540668759000265, 3.5434257406456613},
    {0.13889184462627657, 0.7292901748873646, 0.02706791522941006, -0.7936218150089752, 1.2883201393830686, -0.7229077615668519, 1.4564229524015626, 4.206245819533089, 4.587841723867166, 2.465764237963543, 2.7298814882094624, 3.275598936643387, 4.793092526711415, 2.9464165838947305, 2.4146820364282195, 0.08374390227279792},
    {1.1035246089892201, 1.1020676431927323, 0.19615742767291103, 0.20627891417856825, 1.9727657412704418, -1.7725371973706177, 1.3713257067675861, 2.7183644102993116, 2.0784259885261154, 2.6835023769970614, 2.0201075334311396, 1.2955452088011155, 2.0020786736338283, 2.029412201547427, 0.9123454083871314, 0.7033527928616499},
    {-0.7383218673719993, 1.5316338429941, 0.6912021629758225, 0.950300973886217, 2.88315958383302, -3.1587620341438174, 2.069077297260683, 1.6773693543336088, 3.5495341386449195, 1.1869933654864255, 3.356018784416075, 3.2194807795648734, 4.3841871685183404, -0.911366954098304, 3.1831810061583963, -1.392293082495534},
    {-2.3257894527348406, -2.0622650523502415, -2.0355369969444377, -0.9833639913568828, 1.5052264551135432, -1.0258407659106907, 0.8906521170808591, 1.3377664445333075, 0.17660333334433095, -1.9232027191413494, 1.2178800415798228, -0.8791785328907966, 1.2609780032113083, -2.4324208975238863, -0.3278410710933921, -0.6116895925466098},
    {0.665248641977629, 1.1723916697406258, 0.5981992299514626, 1.0840773621335982, 2.1686855351483403, -2.327431202314129, 3.7977724391063687, 1.7539709138608504, 4.041091682760307, 0.39116572574345443, 3.1617710573327287, 1.8715629660899076, 3.323774553109136, -0.19664324112835388, 3.6926357986588423, -0.6970256806830883},
    {-2.167084625738454, -2.86195429066211, -3.7734851648780445, -3.8861225582635304, 1.0690440044791827, -2.2065505275474617, 0.2672639481980681, 0.5327554551304661, 2.5121917790568693, -1.643909312146862, 1.0284877107309591, -3.2829630418725646, 1.0325589169731315, -2.968728798581566, -0.61772340277042, -1.7813216667031846},
    {-1.1245719026979606, -2.0771249562081056, -0.36335972713939263, -1.849438427883252, 1.3447389431828503, -3.578800800191651, 1.0453585587817193, 1.43390253290423, 2.6938446629297723, -1.6308363950512976, 2.003328963918467, -0.5299236216397913, 1.6896146408116886, -2.723038140564867, 2.677037123391125, -0.6806228349418636},
    {-1.6751724887944266, -2.879261735280974, -2.146051308118247, -4.128716703505696, -1.1546728153649586, -1.3345959014895497, 0.1258741065225838, -3.550893476452837, 0.6693400087917871, -4.204140248725188, -1.6380811430474682, -2.41521083565257, 1.4967219331129202, -2.537007667628679, -0.49990332678408067, -2.3925758538717123},
    {-0.892812503636249, -1.7185383272151658, -1.0229062136793263, -2.1085453071999996, 1.3025094766610594, -1.0976560139987568, 2.644087677393564, -1.0247054795912254, 2.914917569850963, -2.528498439029188, -0.11699489746501587, -0.7720171837661262, 3.325759799743137, -2.159380333100505, 1.8678540308857843, 0.08157744461524502},
    {-2.2869845947173744, -2.2297790093805805, -1.8392939510507074, -2.9737927676629075, 1.6072538098247584, -2.0482070007278637, 3.982606298032323, -0.2586236297746325, 1.3678367308149741, -2.982636630041737, 1.1200876089347112, -0.9446418468855625, 3.8605940956715368, -3.342227728833847, 4.272395965871314, -1.8051594165750828},
    {-1.8901044432789131, -2.6925289849684724, -2.4719037921962763, -3.6235283968740646, 1.2767194060566371, -0.7796400075626216, 2.8059504182636976, -0.3233378574504888, 0.9449718066108139, -2.192333132394764, 1.1566992962155986, -2.213722052006913, 1.453430722855787, -4.198859685165793, 2.4546245425416013, 0.24068572783132208},
    {-1.0640913956130473, -1.6912887042399576, -0.3750302110934375, -1.13513038433741, 0.24047874821147694, -2.110220920124433, 2.3911399767837502, -1.0715309735336396, 0.6137387168760146, -2.222876763061553, 1.6877584347935584, 0.9870451822338522, 1.1967245666468316, -1.4953894286606764, 2.4862357823677828, -0.5245799352020287},
    {-0.4961614924067375, -2.6066234070369236, -0.8615146352425407, -1.6874695492597827, 1.5479564430725874, -2.5889718301557205, 3.5660229502897693, 0.03556160753056585, 4.133221156979683, -2.253559223755041, -0.39673578543020255, -1.4920689248196581, 4.027054310208564, -0.6681987202726466, 3.123441379601005, -1.4748548305551397},
    {-0.5190682355087113, 0.7549364922482649, -1.1607748088040029, -2.211704676067699, 1.8546556537446974, -3.4815816476714807, 2.4212518229963225, 0.6236219292715606, 2.778400591124689, -0.8591228715180338, -0.9814491901481863, 1.9616430101103093, 2.5156581766895822, -1.761089098679843, 0.9419984164566655, -0.49086388289678184},
    {-3.8878442318842623, -1.6330646627535619, -5.553521087034416, -2.409237567496227, 2.8911918714618006, 1.8479135227142032, 2.0797311238417238, -0.604047741593282, 1.425197832381323, -3.549442276167309, 0.9320322999793087, -2.503943609315393, 1.2285095420519905, -3.533877963713537, 0.7108851919691198, 1.9647803377605872},
    {-3.824114457877747, -1.6580533979067489, -2.9709600542449275, -1.2659354419737394, 2.688624904029296, 0.9901797777191333, 3.2116880565077173, 1.8045023401022282, 1.6117372126930312, -2.170690888050511, 1.8561663608439296, 0.726291513307287, 3.0973640856015003, -3.2998814667463643, 0.4170451553059407, 1.049519685479146},
    {-1.3763798948813042, -2.78349648962262, -0.8495360126287201, -0.9543936573664304, 1.6286878285011803, 0.3027956050915096, 2.30020680961412, -2.0124055686117366, -1.4016576269325955, -3.58088371211518, 1.6024933556481789, -3.064298709246222, 1.4358348513152217, -1.0963909290455203, -0.527406675586908, 1.1870024447300584},
    {-3.014073640723148, -0.3253462081805766, -1.049911240414248, 1.1048450806361387, 0.8358367979279201, 2.421440748361349, 1.4977916397463773, -1.550683070461756, -0.9619220106509008, -3.014924378319068, 1.4938688379242882, -0.9339064503897349, 0.36457060843952627, -0.7452632362958033, 0.2447761555105307, 1.0877039207290182},
    {-1.8206134575907365, -1.578339545502654, -1.6709236797116427, -0.25810260701980664, 2.029415033767203, 1.3750511642255072, 0.704509346189716, -2.0826158141203432, 0.2561697249409208, -3.5579186953447386, 1.1804194710617324, -0.8044716838333578, 3.1545330913750345, -0.4257636418910054, 1.3961275078266262, 1.6053218833117697},
    {-2.1665399640327476, 0.12900632268820542, 0.21420845162458488, 0.7778733806715571, 0.7672386884110526, 1.5856374888772822, 1.6000094890148049, -0.5279538071208927, -1.0228377380552327, -0.7784911093439161, -0.15615903235603865, -2.0799885074120694, 0.705432736034861, -1.4567650599367639, -0.1311793198122364, 1.4741740796069274},
    {-0.14374359423064187, 0.7450188454559662, -0.7463442353076003, 0.5571760119397853, 2.730942475185668, -1.7807225170424696, 2.8705428273305658, 0.5513546953185404, -0.1383476666015739, -1.1018794114895891, 0.6335346918466535, -0.8221266917343961, 0.47657652218701585, -2.390175312250119, -0.44692152381994926, 1.0161129793659358},
    {0.6172496895987364, -0.48728080662516504, 0.6557804240338687, 1.1278240979343683, -0.35834088184102464, -0.8179731557722469, 1.9245199662606423, -1.1356992457850639, 0.2595795098750634, -0.8660697036899612, -1.6782647371101327, -1.4673813979236394, -1.3710100057951646, -1.4768928404206323, -1.073276278759753, 0.6848130339874853},
    {-2.876384219156446, -1.8487678368340132, -1.5851627368728702, -0.5456808860834846, 0.777968688240272, -0.18592045080311503, -0.31256880525592345, -1.2812405027508629, -0.03857733351081857, -2.245301886203827, -1.129139897162819, -0.052453975189583564, 0.15246310668047422, -2.3226486015778804, 0.0742240813384593, -0.5057411838656877},
    {0.9325517045768882, -0.6247858081459327, 0.12253761521832775, -0.42807067725160847, 1.6201915967850737, -0.7993919371086486, 1.510894501999373, 0.9572949384188026, 1.2067908390988773, 1.5133920366359268, 3.3388873827073424, -0.8716961020064665, 2.7978107992742163, 0.5571809078481185, 0.0826989358311354, -1.9560233205384474},
    {0.2331963132034834, -1.149351034816632, -1.0371067422386868, -1.7735889787535666, -1.159191360231987, 0.173196554152915, -0.5494232403226489, -1.941867409212009, -1.309226008880234, -1.7253581620411065, -0.5036148120923376, -0.11478562449707773, 1.6413276943376658, 1.310029592576187, 0.001584866544195213, -1.066488445677778},
    {-1.4989092512572306, 1.296834313973106, 0.17845916766872974, -1.017362035545988, -0.5615699330286907, 0.40070179660387645, -1.869846756318645, -0.2767941234509291, -1.6069961513730007, 0.49090465943833017, -0.7423033275491226, -0.4981279520001469, -2.034261494611454, 1.0906420701582291, -0.1680767987099211, 0.7816835696245346},
    {0.11090036956628743, -0.12955381507257355, 1.4305408822021617, 1.2589160128951056, 1.8175088113605753, 1.3458568403814821, 1.8202395601483743, -1.0550118810017257, 0.029098662653919437, 0.27868951170347966, 1.1122826046672123, 0.4887882336136249, 0.586174609280458, 0.697864344932825, 0.21443286204733383, 0.6192057497577647},
    {0.2013564208618235, 1.107644082286811, -2.1207734915822654, -1.4525525835967121, 0.8678152369578568, -1.9705693968708498, -0.3271732867971497, 1.6771978179672642, 1.6123231141100791, 1.175935518632744, -0.6876925294729804, 1.279681821058672, 1.4719720768001339, -1.9923020051374223, 0.8442832452516273, 0.32716488482297285},
    {0.6189398935809298, 0.17988468836619467, 0.03230860975973319, 0.15758441662306535, 0.04120253017223374, -0.5355872284523067, 0.8967548016878409, -0.5841749826548093, -1.144461737362783, 1.386923121544235, 1.3349072497893018, 0.4941662593264595, -0.9387095242019939, 0.5865922750780131, -0.5019049793798271, -1.6660288819639946},
    {0.19794358847636548, -1.0513198980347065, -1.591021545673963, -1.0738732673589257, 1.595684197430495, -2.044822641461561, 0.8532710648080029, -0.8313940622716998, 0.6137932602085381, -1.1318151811330401, -0.9660552162128175, -0.7818137225035394, 1.6944638761007997, -1.7346960934132838, -0.19828217126078254, -0.8768247162290826},
    {-1.6564757917465438, -0.746756686542881, -1.5084263128400548, -2.3750705533111454, -0.23375632029063925, -0.9349372909070089, 0.19305136719578492, -0.570007822699022, -0.2776447615293359, 0.08402264139335802, -3.139777712053444, 1.5787823323796555, -2.4319865057522585, -1.2586005044991067, -2.0884711659658572, 0.06048147171850914},
    {-0.024649385160773314, -0.3162116632845662, 1.5845608170412488, 2.2344625720991003, 0.4723810282844784, -1.4846310788221844, 0.9827833594093889, -0.5423035119937677, -1.6821173576745707, 0.9440937868931198, 1.159617351961041, -1.6162752341730595, -0.9335441184626289, -0.004724530791877307, -0.5206661715052903, -0.4625624478606551},
    {0.511008055966381, 0.38446543256269217, 1.7973702553224429, 0.9505720937341317, 0.5380023114090804, 1.376241442682608, 0.764891411288777, -1.9070825824577295, -1.7414187092471525, 0.0012569831951468426, -0.7693485780945714, -1.2680968854667634, -1.562453756319441, 1.2521035646098868, -1.173540810849201, 0.30241306898873477},
    {0.13735698752031905, 1.0494882180123557, 0.7105840299434073, 0.3042050721067721, -1.6998305277952106, -2.0270418560039145, -0.6977810495443376, 0.6902730661145549, -1.2989331563065472, 1.9175859689441768, -0.499118922503794, 1.8421029141235374, -1.473243716622908, 0.9499770928830427, -0.6243508162415393, -2.0744386826606394},
    {-0.07570147673591793, 0.44813127018735427, -0.31969270715054354, 0.16381692693953745, 0.41946153268654957, -1.0227662304161391, 0.6080426107112995, -0.1076266480501375, -0.015541399367974565, -1.1390658416424884, 0.9534737949720856, -0.5291911895147828, 1.343104698047904, 0.33931529724804416, -0.5534599810526128, -3.054863942563704},
    {0.40948606526746345, 0.2726161862229762, 0.9012521221698945, -0.9944867853130686, -2.266224157992335, -1.3028586468714862, -0.15945461052497706, 0.2214551761407416, -0.08311273241223699, -0.1155524184628304, -0.688872733545427, -0.14682667490588075, 0.13884091565390805, 1.3635484355368017, 0.8921332398290661, -1.7437132700644624},
    {-0.04480473409168665, -0.25768665227831583, -1.7080862665686514, -0.21906011717409385, 0.5091139734640415, -0.8200032807260713, 0.4139921272453613, 0.9745518122200032, -0.13677768544022414, 0.18729504400268027, -0.6616456979446278, -1.0066055560702334, -0.5080923615504119, -1.2400337630815501, -0.8432131042655263, -1.740586876041469},
    {-0.9772815494881238, -0.14463333829441258, -0.4384611457955396, 0.061414997852670496, -0.9449172506709622, 0.7773273035720353, -1.5572161569010332, -1.371292051069042, -0.4652465652946425, -1.6131522036974564, -1.493343826002778, -1.1208502058692245, -0.8551807227327644, -0.34247911544771836, -0.9362529915395725, -0.7448933385510464},
    {-1.4681846648233061, 0.3798185874817122, -0.7731548572095372, -0.0443112963015475, -0.3715740690492427, -0.36036557607149194, 0.2839605571300037, -0.13155022536464983, 1.1104409377996742, -1.0745085577383848, 0.7145390439774487, 1.637741374514084, 1.1849501658857768, -0.9632313370131049, 0.6165181039571014, -0.08659238912221452},
    {-2.13522168334028, -1.417433123814252, 0.45923477077328734, 0.34783984438488946, -2.7943149805720195, -0.9008783089993453, 0.04281027129065675, -1.4029350520643047, -0.8312915685099506, 0.09358187089762332, -0.3513808293426989, 1.597092846410335, -0.2900012306827079, 0.6574280994574626, 0.6094491435008629, -2.0085353866280027},
    {-0.232876662363519, -1.6648162387639365, -0.41556180139345406, 0.19468838736971425, -0.29321422763393695, -2.3587866711728056, 1.728179401252586, -0.024229953989721966, 0.17407394386351518, -1.1875739950386301, 0.20499159742362327, 0.23620012142286154, 1.571101970568906, -1.1436816885040133, -0.9907392827689658, -1.7743615382917153},
    {-0.025964283365585514, -1.0333824784331358, -0.9794526683038532, 0.12180402557627859, 0.479880896506938, -1.449173325044884, 0.7699312373938708, 0.8474982419461634, 0.9153460751212955, -1.1214334647278759, 2.226471466398351, 0.7934803067986023, 1.0263779826897605, -1.8106689025378715, -0.48458333703271583, -0.46661256171299775},
    {-0.39136761472696985, 0.5080236721283193, 0.478973149809568, -0.12727774383477064, 2.6710995947748217, -1.083368021775072, 1.56872294194039, 1.3200700020760816, 1.5397128291727862, 0.5146716537054327, 0.797712503062719, 0.4992722980975457, 2.3714040482363123, -0.22344397514004796, 1.4791169713441146, 1.5750129863492006},
    {-1.4418693128949907, -0.49225852690865646, -0.46397937438473125, 0.03649582178469715, 2.187606550059281, -2.2966540515311977, 2.4952234308113908, 1.434038352683203, 1.7802389224444857, -1.1206838187289583, -0.17352666815967457, 1.0357984990023215, 1.2464305625682532, -2.3665211187062822, 1.538567991000906, -0.5048304905961426},
    {-1.078605430260848, 0.004063310476425629, -0.9349927136594093, 0.8978973812321698, -0.2493257902423372, -0.3051122741039339, -0.8761777199023063, -1.3622514385090836, -0.898205716480963, -0.46400836811945134, 0.7468674504320614, -0.4902495804742456, -0.9334892736782203, -1.6526343807072783, 0.2776010508586761, -1.4871389135764768},
    {0.8990712004323618, 0.3759685531716162, 0.2776709936459626, -0.1915375966865331, 0.5337605714585208, -1.6645588053530866, 0.14379020998931208, -1.6963494324513169, -0.8060066219993257, -0.7118794246300594, 0.32222793932471633, 0.09518906814080985, -0.6712928724049062, 0.5260932804158172, -1.261280234645202, 0.6678435962070045},
    {0.5314016484562816, -0.5618641613583482, -0.40877130070817197, 0.35205672087094986, 0.4793544641723019, -0.5907298758747936, -0.33493332505813184, 0.6268493185208792, 0.7237729005982481, 0.06986285343183428, 1.6039661839237593, -1.2717865234606034, 1.046861169859345, -0.4947302100828377, 0.5957912399947402, -1.7712152510689652},
    {0.27573607182990095, -0.1384350475328161, -0.3064053350340664, -0.1565488724322366, 0.012094736064425028, 1.767598832795984, 1.153095317139006, 0.8575807790989456, 1.1012099568045677, 0.6860698582680733, 1.0344975289306793, -0.3761208685394106, -0.4888905574607281, -1.1797612589938362, 0.20385023987650186, -0.015200629623132999},
    {-0.9624774282899574, 1.265517980358294, -0.7283383044029554, -0.9877803551742559, -1.3288048175303613, -0.12833952307959656, -0.937452313552099, 0.8083133971915032, -0.21079413715817902, 0.06858617299564798, -2.002599970236448, 1.1928673516012898, -1.8312727076195356, 0.47497359304684295, -1.5022067856903065, 0.18582273571097546},
    {1.1504537636074876, 0.7916130726718527, -1.1193335180991857, -1.6528777189021577, 0.3205581008775552, -0.8784927517171462, -0.0325834030868707, 1.2480753098592825, -0.05097489682276878, 0.9486046326264206, 1.4074440720637795, 1.790816781790326, 1.3160517959367926, 0.39190623498660715, 0.9601017044278025, -0.5182323003012776},
    {0.9214175285217137, -0.7312058613064164, -0.05267843930355373, -0.21713505943154135, 0.32704885272630485, 0.5966438513129566, -0.3564458365682751, -0.7936313375173503, 1.0104995446479796, -1.0975223254131046, -0.4062559532185242, -0.2740234057156116, 0.8996340934574264, 1.2260803687660906, 0.7793185422529594, 0.46304539680770973},
    {-0.3698665105394596, 1.2997404639670196, -0.22045644502236747, 1.6843229968115405, -1.020796139371374, 0.7299557523582179, -0.20962046672662787, -0.7722218522560973, -0.8182366029151824, 0.5360046346035847, -1.1121745341635743, -0.740336581569223, -1.350884256531219, -0.8862935492460456, 0.2637781214932557, -0.36889315251139426},
    {-0.2146347372919548, -0.6895577295693143, -0.939640518809318, 1.049135324788339, -1.8649473765321107, 0.7871273433184289, -2.2427899784022203, 0.02592801873832982, -1.458634643899423, -1.7190091876720468, -2.572081417315632, -1.4083666300331028, -1.8269030584394594, -0.9612586955704255, 0.37398805742601626, -1.4149763059006777},
    {1.399041646267985, -0.14891251125441257, 0.32382831947359664, -0.27259809963386034, -0.4074444521883605, 0.4028665653857428, 0.5390019078447837, -0.7989117489986993, -0.7377539289880564, 0.12507629538479323, 0.44294403070184124, -0.995722632513895, -0.29347147813013197, 1.5647649718535812, -1.2531641247176182, 0.1206224906798628},
    {-0.07791345787177738, 1.590898519196312, 0.008074846014921868, -0.5714620437161853, 0.4822494832482215, 0.372688253773972, 0.5982251898331122, -0.12386744595265796, -0.652508183361599, -0.36651376838994354, 2.4870418478014953, -1.0486924004410922, 1.728719077135605, 0.3007397816925838, -0.4210408469551469, 1.0797322361132509},
    {-0.11346118855297167, -0.08695723500727992, 0.11990465192153293, -0.29452271103555533, 1.3974245255898397, 1.0409335785955365, 0.1410470078804015, -0.5119082059252311, 0.9851294171022121, -0.7957239352473973, -0.3772849424128696, 1.3929348639658004, 2.164714324096974, 1.4351451103114066, -0.4870228446161423, 0.10303263593615745},
    {1.6696641636743135, -0.1436466549723735, 0.49542650095489005, 0.882250836080684, 0.48201115526826144, -0.25536098234301297, 0.6687554938962615, 1.2091870243860918, 0.9126760523770864, 0.15937003125943078, 0.1778779438522499, 0.2056556548102729, 1.6996779550078933, -0.8810798950687289, 0.6034622852362032, -1.051515747855842},
    {0.6164905889221515, 0.6625478576820283, -1.118302712928406, -0.9633815055891308, 1.5040214809964032, -0.7053588911225879, 0.7523479384135626, 0.8485346101495321, 1.1841497804677008, 0.48198475516958245, -0.5497993762942732, 0.41128552530997753, 0.19124775143459474, 0.6428849559900495, -0.9576971951275245, 0.7770757943186452},
    {-1.3286391959732737, 0.5167751496547255, -0.4037779301646646, 0.7313537873591421, 0.9441431618705148, 0.8796136060452188, -0.44460822278018863, 0.6259085038315736, -0.160024051977081, 1.4350604871905885, 0.5565961164268179, 0.5277639545834459, -1.0488782619533557, 0.4247509731000976, -1.6248037443459507, 0.659568732094787},
    {-2.059206341431001, 1.3790259913053178, -0.3722457509305985, 0.04135648993298593, -1.745564465222231, -1.407891970879561, -0.2797911213988905, 0.6879628003575144, -1.4155280351023607, 1.5698722712928384, -0.6777702585423174, 1.2272432664724098, -1.7893063018279212, -0.49115145565011803, -2.7133922563757666, -0.8800223765708153},
    {-2.219533533657873, -0.6347246686999077, -0.7839097721079353, 1.231556037488008, -2.154057651892977, -0.3567352074600719, -0.5272587871238559, -0.8862502054841707, -1.424177518425457, 0.2169382228309141, 0.596747323131719, 0.2792347610057255, -0.6544051496708072, -1.1637450154943982, -0.6358449951187854, -2.046037571201827},
    {-1.5242564407223367, -1.629534518491987, -1.40343891135384, -1.281600730261151, -1.056138018810572, 1.0996665418740372, -1.2203203251780255, -1.5169502555555985, 0.6343312965176884, -2.1386432640444575, -1.1116707931192453, -0.83346469130118, -0.5243440144465792, -0.7214007153389239, 1.2949597098278864, -1.6282036612807513},
    {-0.6134177866674555, 0.5670788619548698, -0.807732149848434, -0.9228794880847612, 1.4551563895761424, -1.0744820228691851, 0.4398214757375825, 1.757660141022566, 1.5642784408302752, 0.5377570318178749, 1.1244234389847931, 0.8012861331797255, 1.3374256562182323, -1.101377409472235, 1.345609268824678, -0.320045620887976},
    {-0.21234854684734064, 1.11952948764098, 2.1107201809719767, 1.6031109827569787, 1.7312098421125657, 1.5240532498174706, 0.8913396273078026, 0.6553211735406923, 1.1753812131372274, -0.20372043320540842, 0.3580439114001175, 0.8815038303110504, 0.13448248616870292, 1.2982120921173605, -0.22490280266171755, 2.5694716029425617},
    {-1.2951248128977615, -1.4124024779779232, 0.015639767152702305, 0.45035357526647324, 0.09353882291978165, 0.8176316647588922, -1.005451200628163, -0.33967062730554126, -1.4588415639603192, 0.11691678839970557, -0.6640499949603395, 0.43852243077117437, -2.000710751722853, -0.8249114660646234, -1.8324532101402184, 1.2238876839136201},
    {0.0042178506105744525, 0.7420059830987614, -0.6618662652781993, 0.8262704194863135, -0.0072357156924044595, -0.15623663213355107, -1.205948532919331, 1.6373852287296702, -0.8076097187506985, 1.3660399312026839, 0.9631324925844497, -1.1510388752802252, -2.2206005892526925, -2.4879540238570006, 0.8271400205233574, 0.7193556446618766},
    {1.2087375060593455, 0.35243091730958276, 0.2904965825313879, 0.8852289151715567, 1.5208430019483077, -0.4672291858540603, -0.48038245930553375, -0.2795757998645295, 0.5474341284973805, 0.8066876170525068, -0.24764141149259447, -1.1796272040859956, 0.2979409173346054, -0.3173625795004053, -0.9482012347060342, 0.9803819197147727},
    {-1.7172036208365526, 0.06533893440228208, 0.18220297758586135, 1.1790221240758127, 0.146896679941242, 0.9134111567994948, 1.0491386235564286, -0.5369676497039522, 0.5614455035328568, -0.6204083501447722, -1.6754691138794784, -0.2510633621612027, 0.12884944518117145, -0.8136460546950514, -0.31754060465784123, 0.06558911774361396},
    {0.9510566387042815, 0.45624249492946917, 0.2855642612121225, -0.055956569479520116, -0.8580418377169587, 1.8425401775190573, -0.4260738462801192, 0.11824776594905749, 1.8374936178817345, -1.3949284414810141, -1.5848300563700726, 1.9326512344581954, 1.454305446495425, 0.7741953619120782, 1.8190429706374673, 1.304065325896787},
    {-0.6817883885531908, 0.6995311959196044, 0.18193061630545193, -0.5336873439881479, -1.178919527550853, 1.5476457610326466, -1.0010017008376244, -0.3290700832972857, -0.2354186218641643, -0.978396137468021, -0.9416363333408202, 1.3628073067782984, -0.7193147831317666, 0.5670554654772699, -0.4390978708688357, 1.563326764687934},
    {-2.834898521277632, -1.5004049053540953, 0.2869431040244993, 0.9457451290762988, -1.29246193696126, 1.4373373364470678, -0.9611915777926294, -2.050823778398685, -1.8035787836392474, -1.9860397078740764, 0.1035676502762093, -1.0468637119982511, -2.0548581620487107, -0.9783290972313744, -1.9620470046689003, 0.09422873052952196},
    {1.7028241948182443, 0.36597193913004544, 0.15781136939629656, 0.49423538248028454, 0.9792752693255942, -1.2692809699408658, -0.4719305252668095, 0.21922722110409373, 0.8290741026908693, 0.043322231563806456, -0.9788949530938302, -1.465746037560054, 0.2868598271221987, -0.5087526180863818, -1.6466945310998562, -0.5019015593451663},
    {0.31700090312160517, 0.2616280436931473, -0.9309381755553621, -0.9474867399919596, -0.6433279733581403, -1.3216366906016208, -1.3047858387475628, 0.24123437456233424, -0.7645538299938874, 1.1529714620306248, -0.8555656625278037, -0.00404070002979837, -1.3850607272008597, -1.1908281709239443, 1.737878546489934, 0.8593833810590431},
    {0.9431682174617764, -0.6802647494596216, 0.07996667336427209, -0.6704108112047573, -0.5361711819572469, -0.4896915168161744, -0.32212875717230877, 0.4639625448106147, 1.2880418127753854, -1.3729138110041508, 0.1842771729014389, 0.39690117043676704, 0.4167941821732899, -0.46290580191999137, 1.9645708527491241, 0.08860522814061192},
    {-1.114721886063003, -1.7840520655728127, -4.390413987068263, -3.0203593433064677, 1.1649441645648335, 1.8806984034086116, 1.3320272013258003, 0.2227007392705695, 1.669650563582317, -3.410272294040338, 1.6157620123611098, -1.4240469536498905, 3.0301507214381176, -3.674059874146633, 0.9322390459152715, 2.4559537454888587},
    {-3.1912327320038325, -0.5760506471695885, -3.0286047253497963, -3.5011027654140547, 2.1835570810621228, 0.646582745842139, 1.6106899058843007, 1.4901097335628495, 0.8478400459499613, -2.9563199247948364, 1.5934476164850768, 0.6733799724453468, 2.539626160600651, -2.8689254930316217, 1.507804135865424, -0.25071288714638595},
    {-2.0912479855325907, -1.730351513845891, -0.9739787401273451, -0.6182246916864851, 2.8386527397112724, 1.228948363498391, 0.6297897995171152, -2.681305617379682, -0.04068690563032517, -2.959013973188024, 1.7848183149332995, -2.1388374637619374, 2.2266548439988205, -1.3444037826547912, -0.5523788928851473, 1.5565022201077112},
    {-1.6783564886745665, -0.33542074083987145, 0.7415349205441069, 1.1440373452467136, 2.126366100128638, 1.9430028550631564, 1.2867558915074544, -0.44557671119948206, -0.2905448421637977, -2.277073724467642, 1.0760406352533065, -2.0764054387362076, -0.7247300785805202, -0.17335446691971862, -1.1079666813199807, 1.84955110312495},
    {-2.6301915700623284, -2.231066050195208, -0.6446788442887955, -1.9418330176403362, -0.4779900436298271, 0.3927337240293782, 0.34698396554142047, -0.9403069149556681, 0.7732332366246377, -3.9751526029834685, 1.4387363746658879, -0.5871618647650613, 1.8336809537560725, -1.7175601821819448, -0.01185371783182198, -0.03060123801863324},
    {-1.7860838281347553, 1.1078618325349976, -1.698373825260097, -0.5962809827300823, 0.11495553245519972, 1.2511750274125322, 0.42468886876694834, 0.7250932311432671, -0.20806272625537933, -1.3369476047292739, 0.6088146736408937, 0.08475389107917168, 0.48928035912245077, -1.0995657898807973, -0.48626271489096556, 1.4457815011579553},
    {0.8454740638620225, -1.4908481596633947, -0.9300982133139064, -1.1890336688775849, 2.181764619025866, -2.4813298962471206, 2.605207238206889, 1.7857096040344198, 1.8905607809695042, -1.3964992180195657, -0.01882416152369047, -0.5452326023944924, 1.6099455822706958, -2.4654354834159817, 0.0768645264375046, 1.076809439000038},
    {-2.0057658830902074, -2.1699984608615814, -1.1056615951580284, -0.035770067574647804, 1.4901428972387845, 0.34746876253390596, 1.1304696331650919, -1.5976456818661247, -1.2088783527005982, -2.8265618828738814, -2.2990969703504245, -0.3759804660680208, -0.7467941724540087, -1.2287458313706268, 0.09832873621932749, 0.9390924235319047},
    {-2.517988337349698, -0.08558289983768887, -1.6601335216760418, -0.7915462094191709, 2.624271473413573, -0.35284269497976345, 0.27221836603411403, 0.4666811448084717, 1.404334917886302, -1.3979475510406314, 0.5448375968332427, 0.614514082996799, 2.0292750849115566, -0.7896156523565484, 1.5118408409330966, 0.7268881172804502},
    {1.4520776170189067, -0.10884865599865093, 0.47911383864142243, -0.3804194437826181, 1.969141255632365, -0.5433092125885763, 0.9525559030464992, -0.6179865647182144, -0.14267074796160212, 1.6329420240221433, 3.3310335772432036, -1.1400434462852345, 2.0823975300488975, 0.28513934201310953, -0.4645641816088589, -1.2181041831549322},
    {1.7151716587669565, 0.8882843869321042, -0.46386742689429, 0.904206921798694, -0.4166254337502964, 2.8557320801460833, -0.16471632503301564, -2.0953096634102746, -1.0441940390488997, -0.9289810195440898, 1.4475660875634404, -1.4176188791602082, 2.88734531133046, 1.123104330511853, 1.312904698822194, -0.44419416198478473},
    {-2.1164362103053116, -0.12218272607187891, -0.987876660163087, -0.13277273905735784, -0.4369088445804993, 0.48394898060056507, -1.442660170884262, 0.4077550364653516, -1.2422382191120545, -0.21170741606482807, -1.807986186271623, -1.4130825237772238, -1.55136963789255, -0.4866230855729112, -0.6968586792717824, -0.23326866672548982},
    {-1.6438094285632168, -1.0903068665264648, 0.3895940252475845, -0.7420119834775909, 2.1729409171534755, -1.1678600108611108, 1.9931459373966482, -0.6126366895856307, 1.0874353323720254, -0.34583469831796143, 0.6266718527609009, 0.1745151703269414, 1.3445428346161636, -0.916976262546026, -1.2540317852307958, 0.3341064016029595},
    {-0.19815047299124117, 1.5506804994851258, -1.7555261212755529, -0.8398793146374526, 0.5768552956352571, 0.4629166632899117, 0.007461063189919232, -0.07249327149687079, 0.672506599271889, 0.17899501043788404, -1.9698563642175062, -0.6890407103921448, 0.44769077124321116, -1.1740192080417509, 0.5768121027549199, -0.4342661564347289},
    {-0.463586089154385, -0.926458629248012, 0.5188334477352142, -0.7345509566964202, -1.7376586230387387, -0.11850367046333597, -0.39288736893872134, -1.7168187360457645, -2.0718620425706753, 0.6270328698030944, -0.7675257358035587, -0.27408455289902584, -1.08778866922889, 0.5906293560928886, -1.260630501016522, 0.3728216466311484},
    {0.7694846715358988, -0.3463331788045596, -1.7246601666357497, -1.677495947723813, 0.9429196838382283, -1.816979625977415, 0.6374631240679842, -0.9668816049306954, 1.7472238338132666, -0.8532379985579417, -1.0505589397474089, 0.3229462828423719, 3.3241123080992168, -1.2845696067757222, 0.6961272887428102, -1.2317070214422423},
    {-2.0584842452572905, -0.8827817979734405, -2.959486960018915, -1.5665004846676867, -0.9070596359387839, -0.23440787013191344, -1.7661581081406073, -1.7593710447153652, -2.0218910388158613, -2.5096712367780394, -3.919871334957561, 0.16163176400828702, -2.8294392386355574, -1.4378771113426956, -1.5312725268023708, -0.3218941254541818},
    {0.9750576882286933, 1.3053988439864805, 1.9740569517094864, 2.2691558874509004, 1.6766230681699803, -1.6992492632037575, 2.1251388176109987, -0.34402656267018755, -0.6476532180696641, 1.0202857653733535, 2.545826789453224, -1.7170534721657982, 0.2504530046796947, -0.23510958527754267, -0.049629940631348, -0.6449415445359457},
    {0.015609864409637407, 1.865007020407724, -0.027457209138042372, 0.7647696497946258, 1.0086192687613889, 0.8182257765212237, 1.2380686199506392, 0.9362413927183137, 0.47656845529199177, 0.07827702420318297, -0.9774193142144042, 0.4094174929142325, 1.1852898844339417, -0.44832105270433614, -0.943489065208245, 2.145364399445533},
    {-1.8380504852479622, 1.6501145320173283, 0.6292382092470847, -1.8781382650842775, -0.2630454727403713, -0.15489622993037444, 0.7972683653334962, 0.5454551602716771, -0.9533714918459081, 0.7249654037441461, 1.4929787468458526, 0.15867649989942476, -0.3941297230191661, 0.4673827404565852, -1.3611017855999519, 0.17606437676250436},
    {-0.9650090616173735, 0.26512627041175524, -0.27047141833615274, 0.3238980177640838, -0.2378010646838179, 0.9751099757380189, 0.2324205394191703, -1.193459501425727, 1.200389421056002, -0.45425295905114615, 1.9856421988980109, -0.77308067727092, 2.074920157740352, -1.4271968089432656, -0.34809558649399996, -1.7427289179963883},
    {1.5586649325665314, 1.1986942840518902, -0.04649578655644355, -0.2421472908028003, -1.8452155562867196, 1.1535230713052598, -0.08220688174402516, 0.3241008641151254, 0.03342475061885953, 1.2108894669541785, 0.3243886232862848, 0.676611805866921, 0.5116153905629583, 1.7183676633042362, 0.6818774626490898, -1.747255110643852},
    {-0.8201370948437949, 1.5548122238799522, -1.2477639181963884, 1.4938719873269204, 1.3531464261086381, 1.3128314667824619, 0.30542039186100534, -0.5000055503455743, -0.4028334482014033, -0.5176488045506018, -0.46501980796572623, -1.493762152201477, 1.7926849913285183, -1.393665759983657, 0.07584828675369196, 0.13995282447488555},
    {0.1143615008278101, 1.1251156298968414, 0.07487428038585256, -0.6986008999216601, -1.1197451833954337, 1.9926616037623945, 0.37779592451849, -1.2899035480193572, 0.8522649539883402, -0.6814366654277072, -0.16077320777103363, 0.37726937883751976, 1.04082369305221, 1.3875403582841688, 0.4277318927441327, 1.199672743519907},
    {-1.06459304087393, -1.200572939736305, 0.048870002325894404, 1.1286342938940295, -1.0300570374099012, 1.4596251658647303, -1.1550701475708076, -0.5410890347809664, 1.0910898022985358, -1.4084244148825225, -1.9518159921061562, -1.2553310525339432, 0.027964243258763823, -0.5103209436530719, 0.7254030768229089, -0.9671516039601286},
    {-1.1997642977784815, -0.6893243479868766, 0.14113922051535155, -0.5509294908103569, -1.480991903127828, 0.5387526884388814, 0.06291852937907481, -1.4777232775521132, 0.07800591786920211, -1.275998674555972, -1.24496181639703, 1.2545509996837816, 0.028150011902210316, 0.5255043942003244, -0.2510595697744096, -1.0676944025513062},
    {-0.5216191298117341, -0.7283811778784586, -0.2942224248791263, 0.8972394619122308, 1.6013085233209174, -0.09779786445528972, 0.9541573312118371, -1.9133899261477563, 0.2633746916058451, -1.8415350764811103, 1.6597070247367438, -2.85431844333485, 1.683745387195417, -1.9484862837733852, -1.5982839274088672, -0.7601056348108821},
    {0.2394520293832717, 0.3264839553595282, -0.9013130754485521, -1.2056230487374178, 0.803164926197205, 0.44832318427380674, 1.3254288964167313, -1.440415106815072, -1.435994441627862, -0.16891096855930363, 2.0447438741972253, -1.356397069149052, -0.1056995197513519, 0.24511957691266936, -1.0085133955265775, -0.9848512351537231},
    {-1.3871798386721865, 0.4662241931899317, 0.10576223218861233, -0.05147125813451233, 1.8446438112441346, 0.4577559501964251, -0.08740373958733073, -1.4778421117955378, 0.16878900645304024, -1.5365489454116057, 1.396578070140914, -1.0984490428768459, 1.6480084801818682, -0.2876562781863482, -1.5600649527524524, 1.0272828461868326},
    {0.03809290651767136, 0.29330562182984443, -0.9881256717163543, 0.28899161584113153, 0.29268159265242927, -2.163789658785064, 1.6060028948707685, 0.682130074369035, 0.4166953133787695, -0.6558052975938136, -0.5912352556291387, 0.2618139379232724, 0.25400923978354073, -1.884963857218204, 0.5376787145747499, -0.8938963453797556}
};

static const float b1[16] = {6.386434445791387, 6.1159318729027525, 6.244828886577702, 6.593956379612429, 6.460005734737404, 6.651631574175529, 6.3937319317682695, 6.269675257151503, 6.386347613020688, 6.4812509979876145, 6.329854366742538, 6.487555096012058, 7.047395232580187, 6.525321657803164, 5.773576633315594, 5.987044816118887};

static const float w2[16][12] = {
    {-3.2393077887419044, -3.9618344124643166, -4.0908468732166945, -2.7671336354349596, -2.8172379329591135, -3.107647209853545, -3.7493055050341835, -3.0828773470799833, -4.129576086429642, -2.836479015452443, -2.9293516199392524, -3.4007939742679985},
    {-4.457944547076863, -3.9092716317238203, -3.004816101919738, -3.8945945045927286, -2.7886729425401993, -3.078453117661126, -3.63745118827773, -3.041414114361106, -3.7749556685843837, -2.675056252136964, -2.8622976464662377, -2.7353835852134103},
    {-3.503710808562456, -3.1743167592825343, -3.5254040700387614, -1.860108037100776, -2.324842225106127, -2.9080404987484054, -3.701008019143346, -2.8096760079316745, -3.660564775275516, -4.016430517755741, -3.433759446888807, -1.884016794153848},
    {-2.7610254543910617, -3.483219919563215, -3.3391156064141465, -3.9760236002543996, -3.2056043901679057, -3.0302579739776654, -2.264432558196661, -2.7548293107023882, -3.848118461561266, -2.4783680243913593, -3.690263686253541, -3.692296048741198},
    {-4.321211300423434, -3.468147065868635, -3.6770479640592915, -2.745377227885228, -3.2252690312385175, -3.1721123268338896, -3.0427231461329067, -3.166657608674733, -2.929175343033497, -3.1199499382798184, -4.357172009762462, -2.5746535653928695},
    {-3.371205944168584, -3.0488868672134743, -3.3345438959956386, -2.444706378889187, -3.249817551330132, -2.6954566629324943, -3.522782732009192, -2.8494136556049434, -2.751410607152979, -3.602975751809249, -2.548329837782964, -2.719682257730595},
    {-3.2865844749775097, -3.5715469491353122, -2.6748424959732895, -3.625550726291546, -4.6617894188123685, -3.901516288285042, -3.6162616366857674, -3.6346045837799172, -3.093471135165649, -3.440482338497461, -2.7538852361894284, -3.256294089438364},
    {-2.3721347702402706, -2.7250919362382624, -3.841029342283657, -3.3753127955573214, -3.8564516255394112, -2.751858577445203, -4.13033319056811, -3.7574103717214125, -3.0654263321842743, -3.2585115973077823, -3.5009020704694214, -2.811073761523591},
    {-3.1648215984535684, -2.6907093642822413, -2.317239434541828, -3.2742677115972447, -2.6365768043155664, -3.4226439543129423, -3.1009515178992855, -3.569214035399703, -3.268829415192788, -2.896141897233798, -3.8195850860249267, -4.237758806233241},
    {-3.1862019483147828, -2.801023329691964, -2.5679563034225334, -3.5060884872453455, -3.7644031663939472, -3.7444680550637512, -2.4009077568412134, -3.1830786467649306, -3.237456973770196, -4.434546885194795, -3.4939229830441842, -4.062225339287638},
    {-3.213951738826421, -3.530399875897578, -3.5964630924733845, -3.4559571146829255, -2.83716122175075, -3.1888719387873894, -3.664546729342614, -3.285496178049156, -3.5421946326771456, -2.6216767603090263, -3.298903403626175, -4.027298832173057},
    {-4.319467783763898, -4.242873945020834, -4.426121673626713, -3.0628360639535575, -3.1248990462925046, -3.2190667879982433, -3.1905549481014903, -3.9136292149387915, -4.059260304308765, -3.414933147015541, -3.470876823912906, -3.4065478070250697},
    {-3.4454625069410607, -3.2389407899935643, -4.122200486343658, -4.09636342500627, -3.732232361915609, -3.345991989791478, -3.574400190776771, -3.92245261278021, -3.740951328295748, -4.95017748662179, -3.320601269321341, -3.488590898477635},
    {-2.5847697989334613, -2.8350549488985086, -3.3359718082879133, -4.086338711824167, -3.8207649562497097, -3.616974862143815, -3.441739075256841, -3.918348188092572, -3.221752618202961, -2.607479263741167, -3.7721727959884426, -3.6509789709742044},
    {-3.3484075998036804, -3.2897642161739498, -2.555813660338326, -3.46948879021866, -3.456856299406865, -3.26400930083661, -2.499848763151495, -2.3354323170492868, -2.154765074546285, -3.0828311955811523, -2.666213722156267, -2.760563919476797},
    {-2.0845897459994043, -2.3300744638422177, -2.4984393099337225, -3.5137589748266467, -2.8469266595361, -3.0879509040501323, -2.7725782248065007, -2.66983032585166, -3.86415990134874, -2.9731271709799274, -2.7944482387571585, -3.6498897719428296}
};

static const float b2[12] = {-3.1836099652072747, -3.641843764479442, -4.190925642553606, -3.3927910774939223, -3.288191467153158, -4.411844425300829, -3.6717073237605566, -4.33031886194387, -4.313103685544715, -3.4678948037541186, -1.6248652573006994, -2.850968583519274};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
