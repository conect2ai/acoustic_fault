#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-5.793151151722442, 5.837207910012241, -5.506234861597487, -5.502974354467053, 6.179631791481006, -5.372486286521063, -4.907121104954604, -4.917318650325708, 4.347629990234896, 3.877595068339386, -4.8982008868664755, -5.227804471681041, -5.453411674525776, -1.0607833980390486, -0.5381780676744506, -5.83441763731243},
    {-4.859882616380675, 5.750171101158651, -5.068471081313843, -3.7718774467827614, 4.755206381983427, -4.228610360619839, -3.6987562368558606, -4.263883097842216, 2.2146816032366368, 4.375085770219718, -3.8092751230371578, -5.04612760446856, -5.617851127534256, 1.1792035105599632, -1.1976285440444214, -4.576967832114671},
    {-7.178917534893552, 4.907188098499281, -7.464927615799247, -7.425146269723867, 4.847927386264909, -7.825621952888909, -6.739083005150161, -7.4391349951476755, 3.9825002046350204, 3.7637550583546906, -7.022288267381044, -7.938816948174774, -7.947555603762781, -4.130419270524864, -4.357919651769419, -7.30529769608451},
    {-7.688882956375752, 5.396784596637843, -7.42375599735689, -7.556760314527669, 5.140133264720604, -7.4791759848148995, -7.343970918337617, -7.606786138768199, 1.9986827527981337, 3.9777360647178712, -7.554490526229717, -7.885371354121432, -8.000345309840423, -4.805576607175141, -4.906272009574174, -7.574885404990334},
    {-7.866078691357773, 2.938493000337972, -8.008568476761234, -7.712719404258427, 2.768941919818057, -7.954908423271934, -8.093094090515317, -7.879286196637357, -1.143302006062807, 1.1930738588711824, -7.85677707087803, -7.78259744243206, -7.925956267185, -5.791839628947219, -6.168408887908596, -8.052300246208196},
    {-7.425430947942935, 0.9933601166628401, -6.977370364426028, -6.784257758149554, 0.5934485608455237, -6.852306894678978, -7.22166875500633, -6.713944550101259, -2.4672636689876715, -0.6983618612199611, -6.875337655616304, -7.165025419019258, -7.2597373942204895, -5.14822118478364, -6.3124450253361895, -7.337796755710562},
    {-6.451490924525762, 1.6747236986336993, -6.016096250770596, -5.088138170324885, 0.6380336070684816, -5.643324327218047, -5.792956084161948, -5.084227929492479, -2.207683885339638, -0.22952618411583953, -5.584771726916546, -5.461233807302897, -6.2649054291112325, -3.8024856591233807, -5.592497326439304, -5.905753553339627},
    {-7.607644165951458, 3.6403999375645837, -7.261526649043563, -6.914432430891557, 2.9455520025472137, -7.124732871923949, -7.331970354199533, -6.879114529937845, 1.0567015641999133, 2.8757582926867373, -7.143883721104584, -7.016452824743259, -7.608400410642792, -4.769919683721907, -4.908186270999817, -7.261339945863632},
    {-7.691884332089811, 4.579991220553668, -7.58352936257429, -7.055505997037275, 3.9000855837038793, -7.689199591012163, -7.542385826553996, -7.251287953628014, 1.7586604561168218, 4.246446679203289, -7.6612827455797525, -7.749405547657785, -7.791441445158054, -4.4189620809487415, -4.7181653832078245, -7.508141914833697},
    {-7.711590018191831, 5.387480082380318, -7.491530347607126, -7.034097397110363, 4.861434707382495, -7.317241503451798, -7.231669706355661, -7.362129730179133, 1.9000255203618888, 4.370100429565855, -7.488431412690317, -7.579735412583036, -7.724095558461239, -2.5597893760097787, -3.9973998178024384, -7.261796393905046},
    {-7.0546863390525045, 4.957281020180724, -6.698532598076103, -6.285817569852586, 4.355577039451594, -6.239573379005796, -6.108528118920942, -6.229130736411707, 0.5361412826847085, 3.7331990814533516, -6.162540927586185, -6.672424409936567, -7.112359912747593, -1.7719227161871873, -3.1239455319553033, -6.739252876054363},
    {-7.761594809860848, 4.83180590708425, -7.19627802218633, -7.091710991889194, 4.308330045856024, -7.438069521623796, -7.318017723354155, -7.680872612555964, 2.7110785874674868, 4.8090687566599675, -7.592709972227743, -7.59737013673377, -7.7311911417601, -3.9225702198293146, -3.0866318585996946, -7.6092035203440345},
    {-7.91633275942553, 4.912687735668313, -7.8114217944274715, -7.667362097580576, 4.368584566794659, -7.888228885622208, -7.602271642139836, -7.706265917669211, 3.5241187052610163, 5.37505448354647, -7.67342598475341, -7.783166418873957, -7.9776035323377625, -4.452922044910744, -3.4039255638499415, -7.657666158952992},
    {-7.869152633286271, 4.758720158994128, -7.7017198654764565, -7.6767150625748535, 4.263855860420955, -8.098525343672755, -7.7683907415633024, -7.732501476113296, 3.8545682096876996, 5.276371192055577, -7.5625047121861035, -8.152400080887546, -7.724740861715133, -4.398124113393046, -3.955059128232021, -7.7047041234163585},
    {-7.695013589479571, 5.114463531705976, -7.405252202293387, -7.193404938886087, 4.761814846027664, -7.672013576815525, -7.491322280989393, -7.629916628962284, 3.7862196654539244, 5.492716649275124, -7.299473054660442, -8.068414762598154, -7.823989788096993, -4.8044416587232295, -4.260095510585861, -7.940333865075255},
    {-7.766330847368039, 4.856220228123814, -7.6729579186625685, -7.187162773911886, 4.29398809312879, -7.633388488194116, -7.315898560724655, -7.571773039791879, 2.957169557718592, 5.042299428651955, -7.4681165161310075, -8.099156112427854, -8.22177216618706, -4.140538444713109, -5.062748432738428, -7.647538369880131},
    {-7.997251111555803, 5.417681837053555, -7.992249988455213, -7.490617071389387, 4.874843509308845, -7.925607475071176, -7.694314994591819, -7.978317610545365, 4.141412355150524, 5.563460296147764, -7.601194048270159, -8.41225358135167, -8.310954777472796, -4.207591908034097, -5.13960258378409, -7.948315723582039},
    {-7.876177441709119, 6.4022970976823625, -7.7335782371153705, -7.739352695689684, 6.434709308277069, -8.014550753536767, -7.436969361820313, -7.84255788195844, 5.690486530739778, 6.014609202643742, -7.670302020345538, -8.427876492367846, -8.168709515570425, -4.2870533881158615, -4.318873646251297, -7.833358137471779},
    {-7.749910602506934, 5.820935290178295, -7.650819000470889, -7.855882546214761, 5.925214242873635, -8.033969927246604, -7.812234282523227, -7.806177686678133, 5.868718216568137, 5.933313892088096, -7.787263123728241, -8.067342678719172, -8.148121849686294, -4.352534942153191, -4.119262386215125, -7.840654370129571},
    {-8.192088358897841, 5.6147200406504885, -7.927113699223748, -7.618019077070762, 5.60144473978672, -7.839393612631706, -7.758987826691366, -7.819533002152719, 5.178444841147373, 5.579407041371957, -8.029111309344357, -7.947769832763452, -7.788843498058491, -3.827139822655389, -3.9396184823691565, -8.156872470246128},
    {-7.894181770494, 5.854175737847653, -7.570510818259248, -7.553419364689352, 5.633599842904668, -8.056368956783729, -7.937392002396836, -8.104290811998393, 4.677638147147235, 5.77262554796765, -7.775815256838792, -8.278360818232176, -8.235539874446612, -4.0078894503840345, -3.8415976091969433, -8.203555980893107},
    {-7.7995596525767, 6.405243304861992, -7.438432270407211, -7.331592983297452, 6.398212629822223, -7.56558314945442, -7.252749328243741, -7.667295716403497, 5.706499022906683, 6.26057193541303, -7.597902924321826, -7.705009770345104, -7.996437520778439, -3.703178430292502, -3.750725286485419, -7.930574376433182},
    {-7.8314023382756, 6.732816002274992, -7.617849154837818, -7.132284136310431, 6.55768522930615, -7.474449990520773, -6.991534456884267, -7.477237552179506, 6.042891717201266, 6.3278487802362, -6.778092015278548, -7.857473212583546, -7.800848443247878, -3.5766637515225526, -2.9221252979802412, -7.442988219151379},
    {-7.7588368454186885, 6.460923877518466, -7.5719697515114355, -7.48995305593601, 6.338443762560904, -7.722965947514187, -7.367215369121478, -7.697791429369962, 5.711541220320549, 6.362244782803245, -7.382587221884603, -8.016311635277827, -7.651502780404926, -3.5265214502817845, -3.4880929399260974, -8.00930579925639},
    {-7.945168068732177, 6.062241743398933, -7.678659365084491, -7.369174578854826, 5.695657392634212, -7.648779558604908, -7.0918542699573806, -7.848288652942002, 4.75105431499031, 5.939771439560161, -7.469632473034819, -7.9145209165255475, -8.062217294721245, -3.643074517014646, -3.538229726118305, -8.128380503772005},
    {-7.6319068763144715, 6.124419369932338, -7.3751101935900145, -7.1192603406204364, 6.066991471889084, -7.674800770871988, -7.164938389182789, -7.619534228763562, 5.638789476372614, 6.2521918213082515, -7.586069171036367, -8.056333672028924, -7.849628040832641, -3.4988604416947777, -2.9099552307636274, -7.723278746825318},
    {-7.592338536474536, 6.394786479300813, -7.616086197865238, -7.53338546355017, 6.065760971777414, -7.8800553058323795, -6.936127173833141, -7.907451154003975, 5.640920092445579, 5.872654412914117, -7.536223256998496, -7.8515639630637155, -7.965494606366946, -3.545353256337211, -3.410782441910118, -7.68074428490194},
    {-8.077048857865186, 5.798567915298176, -8.090387697443521, -7.788087370627584, 6.037586705239274, -7.998050412117577, -7.405944153702028, -8.032740529422544, 4.952373756307655, 5.604808216648938, -7.50228521337323, -8.042570549930874, -8.159702914359135, -4.323434230789211, -4.116830905299366, -7.934747418766448},
    {-7.865710407787536, 5.849280936771701, -7.751532266569072, -7.1962247552831835, 5.900105295272111, -7.655008133346388, -6.880009380461366, -7.7749213319039985, 4.271389413945458, 5.632728528908258, -7.286965794822707, -8.202520688471358, -8.038958240974805, -3.0070474385002184, -3.669472761801221, -7.999640725816501},
    {-7.868741208182044, 6.022592906627064, -7.682685063539016, -7.168009388640018, 5.960716789536244, -8.065276411284483, -6.992507836720871, -7.899151902810158, 5.033298019710033, 5.940314438255756, -7.830853336964351, -8.159164752208657, -8.376818774113357, -3.294395300027744, -3.6153586585519744, -7.870017631960384},
    {2.9707609331080014, 0.4937856507538568, 1.5415444142474184, 2.101388535889896, 0.4342827783788568, 2.4096435985720377, 2.010314591967017, 2.703516866123089, 2.603933612773679, 0.21916029590190167, 2.1060388134947416, 2.5500810514204133, 1.6349994751149792, 0.6253409721771392, 1.9339751335445095, 2.7750309933187403},
    {-5.418461869400522, 1.5613404116409015, -5.098833427196593, -4.997366777864858, 1.7750758628999412, -5.1291113910156145, -4.647002317401351, -4.60168319910226, -1.1613144972168872, -0.15890616798616408, -4.59980155880733, -5.092158739486014, -5.51671174491132, -3.151571247100636, -2.7659701737569344, -5.296134089551141},
    {-4.418513182421072, -0.5454166867123336, -4.042405956113096, -5.1898549673809855, 0.06900973409786593, -5.24601762130126, -5.103609354108983, -4.831690175186708, 1.086802433907331, 0.44012373928804643, -4.902803942229548, -4.792233432852117, -3.982847300706216, -5.52019606351492, -1.1119369343637155, -4.3953945126657645},
    {-4.469568737890585, 1.415968811966445, -3.996415814209598, -4.535146012446212, 1.0907908297406061, -4.208578127882205, -4.375506184019757, -4.462807211946542, 0.5322478407490168, 1.6438789553394957, -4.333405027980238, -4.405268972382685, -3.9597614423777894, -3.496325235953435, 0.16994015711220625, -4.306264523062213},
    {-4.936307609658504, 1.0887044093028793, -4.676799460780941, -5.398673534818973, 1.5648201408950286, -5.4318398170208555, -4.928100797880642, -5.281561708554934, -0.24582588143871784, 0.7238555320434314, -5.307410087570872, -5.6414059484296555, -5.043542275104599, -4.653027214443356, -1.5551326362408489, -4.896395536697525},
    {-4.241254846629274, 1.8646325460667343, -4.327768028822985, -4.510570540806873, 2.0588473574001127, -4.915350881177113, -4.2763603227570455, -4.451420889563648, 0.9146310169347874, 2.120541527562521, -4.6010361912380215, -4.642176914212142, -4.176927571232353, -3.2371675877383392, -0.3844195699568006, -4.4898404484015995},
    {-3.4724289528723715, 1.1416870402814063, -3.555719852266193, -3.55087063186943, 1.3596680788493511, -3.321480443929754, -3.0643300040098254, -3.6683286806600104, 0.3213307349731492, 0.9229341756388483, -3.7720308502835334, -3.4471942584867006, -3.4106003074172824, -3.5617166633248742, -0.14919285392111684, -3.2793649822188673},
    {-5.071371086801883, 1.5457314328328464, -5.3863142555884576, -5.953479990996969, 1.496129213145997, -5.750213212256939, -5.287051436488661, -5.674610554823786, 0.47452203646404706, 1.2786020713327484, -5.650883679289837, -5.616757556990757, -5.218172339319634, -5.375421632677561, -1.1091559911137032, -5.382937846060303},
    {-5.33953363950283, 1.556467000013075, -5.211414161644198, -5.775926401108554, 1.7197365685680963, -5.677402710765861, -5.8882349770991524, -5.640269277604377, -0.25068954862840614, 1.4886620639500499, -5.797181388092988, -5.624678122989375, -5.170482149802955, -5.525741586702788, -1.2453377955803897, -5.449827633785922},
    {-5.084490301720306, 2.1651901664228266, -5.200201905480767, -5.0501757443271265, 2.1023633604538783, -4.920595877342439, -5.244188820519094, -5.0476907623924765, 1.7379772717979993, 2.2989741495415577, -5.0253574861285655, -5.089906182291917, -5.350972767645901, -4.668823288014949, -0.9850042538095622, -4.609857507979974},
    {-5.008931125623562, 0.43448358975159196, -4.956052927279228, -4.861419055344136, 0.6208701063627238, -4.593924864594489, -4.92084874312895, -4.785664196687516, -0.6911505637115347, 0.19545974223568116, -4.7552204713777995, -4.674517282959063, -5.010993869207397, -4.801760255630957, -0.6616460293156239, -4.598934530285971},
    {-5.080434098806363, 1.324387045418934, -5.126665907952808, -5.007614886029275, 1.4896120500291075, -5.1940015139150875, -5.3796059895099555, -4.8382358866175155, 0.21413261516718932, 1.5887577717338315, -5.276872754580575, -5.1201811126258026, -4.914096273663237, -4.322778191925439, -1.3715471959879344, -4.884426040572767},
    {-5.363080428661335, 0.8225860242637244, -5.588964667915613, -6.16541838081132, 0.4636973558161051, -5.801621999046131, -6.110749541376778, -5.987910759954555, 0.29341883028307764, 0.6612108172899536, -5.938426985669415, -5.817691731511605, -5.406419302800004, -5.705324511715214, -1.150672907689158, -5.595957527112312},
    {-5.508040173336512, 0.5409641501065827, -5.5067290049653925, -5.532534321042596, 0.27652184339783975, -5.286885886297552, -5.515368370473799, -5.230209815675207, 0.3484276811989521, 0.5471126990816987, -5.546545008955575, -5.379994261673018, -5.436396653436749, -5.295938465049548, -1.1833182834652418, -5.208381417508679},
    {-5.312293411945771, 0.12579936894533025, -5.393963576655955, -5.915956969886446, 0.25367267789485354, -5.867669969715413, -5.770079508580614, -5.672608596166004, 0.2043860386950312, -0.13537220322921634, -5.70093298129466, -5.538546012234157, -5.709534482955219, -5.87830153281418, -1.739017583713569, -5.3301930746114445},
    {-5.500976731177541, -1.003042067238936, -5.491586691407188, -5.52935909285386, -1.1826325029035043, -5.068262864657329, -5.5897518367772046, -5.192327027997698, -0.2001215924496317, -0.9382844562562084, -5.462908751652848, -5.056219663014625, -5.54059818045932, -5.834897086019579, -2.292806966907055, -4.780070437433303},
    {-5.298289012333114, 0.7154743232592383, -5.006006236786731, -5.544533091736296, 0.6699866522332114, -5.348559371530474, -5.325360614187725, -5.408153690478992, 0.6365325557600555, 0.9198528198511297, -5.168618078974274, -5.247571510759527, -5.2952556517566425, -5.291939913193333, -1.4702703337628913, -4.906315001497698},
    {-6.113766428597188, 0.9465265169000945, -6.156560070027953, -6.443449676175878, 0.5447117786336079, -6.141979713970469, -5.946647534276047, -6.222378862675303, 1.731614172705949, 0.9024183475543599, -6.155338795981041, -6.035136321693137, -6.134428981924399, -5.995280256691669, -2.055083435992694, -5.8983874644710195},
    {-5.8412261128748915, -0.6766434727165976, -5.7964721276573945, -5.885753930772019, -1.265031286417758, -6.082330711359842, -5.834385082051968, -6.035935514902698, -0.030588667958184126, -0.6931391831568434, -5.5656430145714735, -5.470240559931861, -5.839859435965524, -6.619151171528409, -2.4376970274732637, -5.483393370076235},
    {-5.08093350650709, 0.6840122944228623, -5.197563280621155, -5.6781009374980815, 0.34899255818906655, -5.055511028417213, -5.559537231927251, -5.020773675968587, -0.05596258914295731, 0.2813923158482709, -5.622861347628649, -5.066730264461658, -5.065853673877571, -5.605278165283027, -1.478045683818874, -4.921873506787665},
    {-6.147875142699552, -0.12602766370210153, -6.064091697852337, -6.313258644269771, -0.5903044325426202, -6.155286805877192, -6.434548947791751, -6.42729073379717, -1.3672968907565866, 0.011126758804145983, -6.316807971264229, -6.005100869603302, -6.111890356711239, -6.51678906075127, -2.1072046531531545, -5.718700533480765},
    {-6.657075280739924, 0.8443647382928278, -6.615771206838523, -6.822938889062994, 1.1101352499192225, -6.433451153739788, -6.68100815354998, -6.252912482382546, 0.6345050774170886, -0.43009720298211457, -6.514555707921965, -6.5164607516663136, -6.331355542998233, -5.772981269919538, -3.1260144417660807, -6.141480522598754},
    {-4.82290180102493, -0.5764646982001347, -4.941797271162338, -5.1509435629050415, -0.39872059830404666, -4.8508699326220786, -4.790306082177988, -4.6701204582464015, 1.253809954889601, -2.1282968062726573, -5.056974725300911, -3.917079438080128, -4.467294386446225, -5.934952143102118, -2.381501894146651, -4.054346396258392},
    {-4.4345958390080975, 0.06050124814560258, -4.331546902814209, -5.457722231290601, -0.00650211922617609, -5.385834697421145, -5.0722072696466665, -4.912405578245016, 1.3089525707574419, -0.2763000631870004, -5.564359984021595, -4.645076704707612, -4.432757292469762, -6.786626032388432, -1.3372258439820968, -4.132166506332841},
    {-5.915986708676338, -0.010043904145269969, -5.70278647979476, -6.7339140280614505, -0.3387464717945791, -6.731767274658807, -6.28462907686459, -6.556730710823579, -0.23636745074508828, -0.1636736166799475, -6.690050729675294, -6.2548071851037, -6.073083062625067, -6.990779171730739, -1.7551204960090787, -6.137440365792591},
    {-4.75204840439496, -0.1278697530501456, -4.675705141651406, -5.433160224592862, 0.5710167650145068, -4.871771129629502, -4.789110333596073, -4.978812448383985, 1.6201941394107657, -0.16913521135398912, -5.094454457512522, -3.707887948780863, -4.598749368396893, -6.156064787102101, -0.8427691256211568, -3.3285979448327767},
    {-4.536643215806397, 1.2897733819321382, -4.757148656504234, -4.233984691550834, 0.9756633079048387, -3.6309298913707004, -4.045547657847769, -3.423614751232254, 2.577456915117176, 0.6257527676275325, -4.171746562876282, -3.148373825047846, -4.405932762710622, -5.985608066824305, -0.8460478863319963, -2.551605485217917},
    {-5.613059997729313, 0.29645484086500284, -5.365811697916408, -6.092528656408245, 0.2731332693156923, -5.952872216092693, -5.460017414999796, -5.485320877756484, 1.8864313479495813, 0.12794434688370596, -6.044580018056568, -5.295344938534359, -5.558143572458924, -6.323930204801967, -1.230294588418448, -5.043309183219799},
    {-5.119362358545702, -0.003586138107872847, -5.250383717939069, -5.724788627485315, -0.47253052313090166, -5.568172461789007, -5.005840033782877, -5.272656726517691, 0.8293834362424131, -0.46396220392177673, -5.2521226319022984, -4.286250797628499, -5.057528328274935, -6.514546780376453, -1.673315302972473, -4.272168620540356},
    {-4.308346925730894, 1.0715611349380567, -4.545366145586964, -4.772459035578905, 0.6519981674060973, -3.8962435143992162, -4.521121189341596, -3.851739628708113, 3.2843025878287517, 0.9465958430153368, -4.593796034654677, -3.994325854712306, -4.085412417158628, -5.20308918963537, -0.33023076804452905, -3.5349923455602035},
    {-1.8728988112876654, -1.7622186505010509, -1.551429178017559, 2.945198306116871, -1.7171310228618912, 2.294722159409274, 1.92144193863706, 2.3451654852686414, -1.2348924507682093, -1.8635363247716228, 2.338088461999108, 1.7781655292480985, -1.3516197824183525, 0.7437486780009069, -3.2948498785397105, 1.8618035046669639},
    {-0.49533123003103163, -0.826796507332419, -1.0658524221092354, 3.534896458104252, -1.048064476866612, 3.2473812350573947, 2.798418723916974, 3.1794629579395988, -1.0286908318086894, -1.3175036927645056, 3.5488040010842528, 2.731842626889424, -0.16741333074260037, 2.641380922365861, -3.445704380088005, 2.576677904569176},
    {-0.8681539866353118, -2.345735321533798, -1.4119830369814026, 3.9414822232976885, -2.290603503401231, 3.533013045270457, 2.5537975778050215, 3.451373942361601, -2.0142451469865548, -2.4982154610843734, 3.7448702084060246, 2.646433149797484, -0.318291247272805, 2.554039339678631, -5.067770165809046, 2.5659744738662216},
    {-0.8939064163785014, -1.6569616870734007, -1.0367606221970784, 3.7051830007416613, -1.72315875222785, 3.6600532825011274, 2.612372321995065, 3.5129534831092397, -1.5477570658966406, -2.0451114713861456, 3.6455213549298273, 2.856479441315957, -0.25248319603151337, 3.2989197843053923, -4.180012913798736, 2.6027503791814195},
    {-0.8013073815189349, -1.2497208382861134, -0.9674651108527451, 3.872769301427198, -1.246279737313266, 3.8588419619810974, 3.2291588275349246, 3.8560821716871776, -1.110600628382776, -1.3545961907825883, 3.834986892362979, 3.063179984535724, 0.28292537363538517, 3.4032545312267906, -4.011144849788062, 3.2115039054989376},
    {-1.3867076493063653, -1.4542638002458104, -1.5959580337122166, 3.6197581177679083, -1.9313864393334066, 3.6810631879555356, 2.7617878607945285, 3.687245250833936, -1.4867076952607612, -1.896006878241317, 3.8037157664498205, 2.7922647778996925, -0.6612744257341547, 2.3481887961921726, -4.858341867540005, 2.635165185255206},
    {-1.8645326985586872, -2.582902743546675, -2.372608184809157, 3.37537484956347, -2.9929436603190105, 3.3258159830186793, 1.897216222066013, 3.1732949310225167, -2.393607130487583, -2.606626122615106, 3.296700976727994, 2.6613635569810334, -1.3074388820163252, 0.8068546878352452, -5.118466687788765, 2.292588143699513},
    {-1.9967355493996193, -3.1849050900375446, -2.338403504843199, 3.934410791593592, -3.3914071184062555, 3.61034373245617, 2.3904167722368044, 3.596044312848735, -3.1525303602820074, -3.476591658293662, 3.550910641275624, 2.936596096511012, -1.4959826636508289, 2.100837416666552, -5.31046695416473, 2.6401114936173857},
    {-2.093563089287107, -2.675533719549019, -2.5536182723829377, 3.9598195742278315, -3.2136289478681164, 3.930930060827121, 2.9521902197449195, 4.0894174564688885, -2.8316864359297163, -3.281589717193226, 3.7425514233259296, 3.093299226752745, -1.3592769495354093, 2.25250247909652, -5.173976482305783, 2.938239939725327},
    {-2.1213642030669253, -2.1613817758586853, -2.59600633739659, 3.5615421898612145, -2.7323025271021604, 3.684495386636932, 2.409929096328562, 3.659947829575712, -1.8315310233161963, -2.6367281338365554, 3.3119160177750446, 2.746130814074068, -1.7879504234319215, 1.1454383920813238, -5.180405581523738, 2.59471536137038},
    {-1.8006423358056813, -2.209840806292392, -2.0016782786097314, 3.653709222145766, -2.6562264655599384, 3.32528284601872, 2.351718835608846, 3.4716418167115273, -1.8280586156631522, -2.5404781042345177, 3.4364008917449804, 2.6819097504807115, -1.4658929328838515, 1.6404085024326402, -5.337267615837676, 2.354246586459516},
    {-1.396564480597678, -1.7347337831356375, -1.6791081768670204, 4.377758991714496, -1.6918118306639807, 3.9699267215888043, 3.1067797369171077, 4.275563576353054, -1.1841756231253875, -1.9755146996697737, 4.449254396860229, 3.7951225196534413, -0.5762990348504271, 3.4965335361886876, -5.217236747129731, 3.601834681108346},
    {-1.7627934281231654, -1.7391372672756977, -1.7989927835844035, 3.9715685957190234, -2.1343606359166998, 4.240800501862737, 2.577212524653543, 4.202014443400109, -1.5838982984328167, -2.0425289059903977, 4.176064918745875, 3.3942601878217937, -1.4228893530165891, 2.6577199945758823, -4.846349082611518, 3.207595063131366},
    {-1.960558479352164, -2.3780185561846516, -2.200338995683864, 2.9423796351147784, -2.7002437972843407, 3.271886149230599, 2.0364948077753793, 3.150243930428627, -1.526143453447845, -2.5738186034003725, 3.0494752905663143, 2.5727827625904767, -1.4324372884896088, 1.3646825066058217, -4.321253142388891, 2.517851542533028},
    {-1.3898662987237056, -3.0541143683029475, -1.6872000187793976, 3.9214813370016137, -3.1170650606032364, 3.6090014635261083, 2.7760031579501923, 3.895894307465715, -2.0674735177960932, -3.1707245288908075, 3.7463390535365986, 3.199484830020994, -1.112536595779365, 1.942170884283586, -4.11244257416202, 2.829980230092193},
    {-2.334072459818211, -2.9705918474798647, -2.636554900671753, 3.6233266709408363, -3.2592995731012357, 3.187194273434606, 2.6402069492802593, 3.5938557807261877, -3.0228267681232053, -3.4478882891941662, 3.617956288156573, 2.6261929151286143, -1.4946096987390265, 2.0602224594960057, -5.223526059607541, 2.459217080447651},
    {-2.5551987726665497, -2.555176231065542, -2.5303495507047384, 4.207170381448982, -2.865542433907764, 3.6254377882154194, 3.084562069141987, 3.6532580979943376, -2.5042664914763026, -3.0538664037818877, 3.929336144797798, 2.923963356438502, -1.5242321715069012, 2.563900047681438, -5.830158257899775, 2.772056843336761},
    {-2.2101465831644105, -3.349804042079539, -2.4728940752210433, 4.359948574981559, -3.6329205016049544, 4.105195090279874, 2.952821578576766, 3.929421069397549, -2.787763299919243, -3.74798605179318, 4.117495322640405, 3.2102319491267752, -1.4259292788186542, 2.456779967570881, -5.6965652314441995, 2.7435346495371014},
    {-1.9740151008273688, -3.281088510833861, -1.8720055841419938, 4.231807104290276, -3.7109173398062, 4.000375157757676, 3.1588513972170937, 3.9860055548306237, -2.5548340955978044, -3.504509813908645, 4.25122323052441, 3.501303610377634, -1.2825677767218961, 2.0366730729159706, -5.422937128283954, 3.2879788381470223},
    {-1.5836722796336469, -2.5027019628292884, -1.9337830444055075, 4.1349151078706035, -2.868175341291981, 4.035903119316006, 2.8648109983369157, 3.96311651091026, -2.2596292344250117, -2.856024506761418, 4.097282241085049, 3.102198672202049, -1.0367791820169168, 2.6828076743989984, -5.236908629967344, 2.9049547446421364},
    {-2.1377981138959585, -2.781002052113945, -2.4370917344201066, 4.025292364886011, -2.916042536768054, 3.6615894432902656, 3.0795290189684486, 3.9666632928361962, -2.5016105639790194, -3.0884966603764683, 4.024179442931909, 3.1777625493865185, -1.3842135228651722, 2.9473821732043612, -5.747995206079865, 2.739011399428294},
    {-2.5793617942086784, -3.5131670024498263, -2.9285794787709825, 4.412582535509209, -3.7838652890564424, 4.043033451395199, 3.147737685235553, 4.379397448865534, -2.6208327841197487, -3.958777698325352, 4.387381506887371, 3.597809407525131, -1.6381129893972366, 2.32111635727228, -5.700143634012496, 3.102784185941159},
    {-2.7320167109794578, -4.076395578515237, -3.0721549104573964, 4.725480241581383, -4.415476246679276, 4.208191270404616, 3.3520314452347004, 4.336573049761767, -3.199889856244531, -4.381000233046706, 4.503865245208653, 3.6021314319332234, -1.9541472350127054, 2.188789967658136, -6.085274995244151, 3.290232132976622},
    {-2.9857096056849293, -3.504642997365178, -3.0525296688465455, 4.786083825971224, -4.126196772028739, 4.716748184124465, 3.4573234797029198, 4.566914633848487, -3.085848500546479, -4.0002043158834395, 4.8970345622649765, 3.536091807428882, -2.029440405206955, 2.963517779714095, -5.9812901779257786, 2.9336149388242445},
    {-2.8940728830310953, -3.386800264793741, -3.0200751839854854, 4.651836823791952, -3.5634848001094217, 4.274972735296547, 2.6914214333508935, 4.316160425608108, -3.3208574570099, -3.7086420032186354, 4.333379189371182, 2.868330296339639, -2.399140361018117, 2.6117889858034906, -5.825526186126885, 3.003514787563585},
    {-3.5283865887863706, -4.231900425153584, -3.8823684805547134, 4.028691394312746, -4.351067485580146, 3.8708795312613096, 2.5590037573968187, 3.8914322460164317, -3.8472033900509017, -4.625286121139977, 3.953507994396688, 2.7306508352207763, -2.8383375109291156, 1.3096941272816813, -6.1572360478019, 2.470821909824664},
    {-3.486370624981602, -4.00200275226387, -3.5347554208884, 4.55871410349072, -4.5731914369695055, 4.320405309044144, 2.943605490451184, 4.449211566915118, -3.469340086147043, -4.219597092105886, 4.402713566994007, 3.343758392664619, -2.3872637428071775, 2.47414607402459, -6.260543002311693, 2.996062451090087},
    {-3.3241778912289055, -3.933052169295319, -3.4331310011297473, 4.319711896440877, -4.440842258279465, 3.773470999964006, 2.6226747193053397, 4.022754919151245, -3.909783830892259, -4.34433870519202, 4.128118465672556, 2.8233786852141236, -2.475315789016228, 1.570579320349479, -6.3196428941538345, 2.4320456994972037},
    {-3.6201779765191615, -3.734340563316053, -3.9843211187670224, 3.990716483133011, -3.861189340171685, 3.6187875833568426, 2.100668966514834, 3.7380895514664614, -3.5578426740275324, -4.019640174781401, 3.7229607388123966, 2.4836219772699986, -2.839262083015701, 1.6164894790897362, -6.191906553653417, 2.052623002657279},
    {-3.6435208913912027, -3.7002112718535023, -3.8659734427874364, 4.332798973985908, -3.9944578665104515, 3.8809025390029728, 2.89207126889052, 4.06602519088637, -3.7101709832817047, -4.214891708115866, 4.259387435912388, 2.911631293369813, -2.7661220366123356, 1.769571296463735, -6.099760700526541, 2.608484741954138},
    {3.610037756625073, 0.40794495261133434, 2.8492523541917993, 2.5170923214377017, 0.21934376367048689, 3.120383208629522, 2.191887433936916, 3.167755110509185, 3.278022484016468, 1.035265987502929, 2.348456976872446, 2.9096761273993303, 3.2694010952404575, -0.43917590636064857, 3.401670912507138, 3.333728138706659},
    {-1.091429826286762, -0.8590290186409519, -0.27886055182325736, -1.8181819931674903, -0.015392181595502744, -2.2493194111698886, -1.3076237931593029, -2.3077308470405895, -0.7920794982739205, -1.258985052775342, -0.7827165536705293, -0.590193942130712, -0.48394142892244285, -2.6515394054071324, -1.514385848295287, -0.8490278830571892},
    {-0.3237259371518409, 1.5246860348456812, -0.10820768647566377, -1.582965806606642, 1.6535530234044231, -1.3454522050628077, -1.4836795419439055, -1.2548699777824432, 2.8034051395644117, 2.0610949506696583, -1.5718737552910678, -1.00887069931916, -0.23061856333321487, -1.6344931695924025, 2.333653868699279, -0.809501788673381},
    {-2.210537533469176, 1.2762989591843636, -1.9328578839195991, -3.051999018744842, 1.303909231977622, -2.68585325729913, -2.7542466509195007, -2.2357939956912967, 1.7994188436836511, 2.139106658372757, -2.7155924043514825, -2.200549896103053, -1.6479677275248281, -2.5946021188966917, 2.10759756582172, -2.4406544642838317},
    {-3.685736401783347, 1.0817349102806812, -3.810659313326981, -3.9707573988353304, 1.5375472768227045, -3.8718261226745736, -3.905039293719602, -4.304351642025422, 0.11901001094473337, 1.2183043507102733, -4.048082894275326, -4.117180674397063, -3.994233387438596, -3.513368652348184, -0.5646587142706558, -4.1681015730611835},
    {-3.083008896522781, 1.8276483613193686, -2.692442166373093, -4.1898157046494395, 2.2686749065816585, -3.951291417590223, -3.461724052028507, -4.218358433373107, 1.598729850659391, 2.2659889635547934, -4.064510347652357, -3.6848249385866616, -2.90158766878898, -2.9213023730254024, 0.616629136183838, -3.902523098227436},
    {-1.7705137008457914, 1.598952458125654, -1.9410777054774901, -2.5828150054016703, 1.6177506784510038, -1.962548237604149, -1.7919151597570404, -1.8230083019162489, 1.0699148072101825, 1.5535469203521255, -2.5269449362920664, -1.8528986595786845, -1.8492225161696119, -2.879637344742803, 0.4820004285270602, -1.4704396846004901},
    {-3.5838309334008702, 1.8108054652022318, -3.558304749927345, -3.9958911451510484, 1.7836897463545978, -3.905571283476028, -3.7516045001204197, -4.144978900829166, 0.7400675885103305, 1.796305601330647, -3.763978038612812, -3.6608321635651246, -3.3308527604448104, -3.795127414212748, 0.3317798593351871, -3.4521577062189195},
    {-3.8187177182697893, 1.2545783667973107, -3.5616135249449346, -4.3423678319596615, 1.1827644552648429, -4.244940347331905, -4.239208308548678, -4.404849405918459, -0.42240636765502976, 0.949425616087091, -4.222896842247743, -4.046023825584979, -3.7805524804743746, -3.8153295472012134, -1.1865596763646453, -3.9622001326187317},
    {-2.7634828697677687, 1.9887426121306992, -3.2079920190380182, -3.0065045341423313, 1.9733505723524158, -2.9894584185180806, -3.5627042830174642, -2.78886412215004, 2.0550330918605644, 1.9630481175878705, -3.089538756671821, -3.0247041766777287, -3.164905676504139, -3.525655221124892, -0.1423031984833688, -2.856877054254464},
    {-2.1464806445713536, -0.008833535194643737, -2.5625816569862887, -2.445406056765348, -0.14441979197537683, -2.1290542904389023, -2.815774127920156, -1.620106201244812, -0.30768349565901937, -0.40778965682348833, -2.3023018128148016, -1.8061695453230535, -2.401522475534189, -3.7706077584281776, 0.2074659710138589, -1.2032194229027655},
    {-2.8509270896093537, 0.35751188879652096, -2.878785137555719, -3.346555329746767, 0.5186416781832023, -2.7344026671238972, -3.1822472177585115, -2.6819337385819106, 1.1210801740707168, 0.793039500669371, -2.8830632157458678, -2.961301479821304, -2.6129667958776315, -3.8846013016795116, 0.016692601115302894, -2.3627771620621525},
    {-1.732257521418961, 0.39833824422339714, -2.187209261020256, -3.0801711354820385, 0.5169521546956728, -2.264276324617806, -2.836938213765992, -2.2807346373131367, 1.2586282301173701, 0.6497724373631161, -2.72654959538222, -2.2758702124328534, -1.8048249911375482, -3.4231098937189737, 0.9969644403966574, -1.8108755783104962},
    {-1.7087293019056495, 0.7390859744118775, -2.0741332969124318, -2.564581103096963, 0.6936567896239002, -1.9412190204077324, -2.4244813760928854, -1.9649369162968804, 1.642436728989393, 1.1093641271607233, -2.517716726183762, -1.9446162373730123, -1.7815605345450367, -3.1162611411228216, 0.4322369393226265, -1.615167163482869},
    {-2.73609952922277, -0.22237631488578677, -3.1694475634765107, -3.562527898557776, 0.1350987892820819, -3.2053937577845395, -3.75738824261899, -3.162540944729255, 1.5539057298007164, 0.16225591808663198, -3.688668551947597, -2.8226619939645543, -2.842634240432141, -4.784009695585447, -0.7752368612506593, -2.101992630952766},
    {-2.9658587381126846, -0.9368671536400696, -3.2030960061945217, -2.58506284243895, -0.9947590371426654, -1.9067533544638329, -2.959916924892185, -2.2873980073519093, 0.19561586591910346, -1.0029309599451108, -2.4603633708701205, -2.3783746406226243, -2.942167486444194, -4.120623560571704, -1.254162220524578, -2.093515088812734},
    {-2.3949961954659935, 0.6554607875468574, -2.2635211143104157, -2.503347411011254, 0.28511440228190094, -1.8097941626786236, -2.5326684496912306, -2.311279789070501, 0.7291732560120258, 0.18340402971444092, -2.5414700826527867, -2.1349252951629354, -2.018976281371315, -3.602439379832388, 0.04113930373968711, -1.401688887220557},
    {-3.1256724143182377, -0.14854433432700742, -3.2613348974141463, -3.9320899899242985, -0.11689565118925745, -3.6614809155555914, -3.619363374329057, -3.8055652363557977, 1.27115685700711, -0.31152256513127674, -3.94531980325756, -3.2521825503817023, -3.3128596006942748, -5.267142329442551, -0.7614107883841406, -2.848990703814169},
    {-3.3838432136718692, -0.6044558094523712, -3.4011624947525294, -3.7215304583166207, -0.7125320373619827, -3.5313011262412046, -3.4683998683604824, -3.368468257051755, 0.6426111558039664, -0.758732427249604, -3.4702029411656468, -2.693339747125737, -3.378841418958571, -5.246296387171076, -1.1543216711384205, -2.314501035412194},
    {-2.833811666143255, -0.4446608508115934, -3.457455524211022, -3.161237406004167, -1.0125499384635004, -2.478215531765054, -3.337944469155243, -2.4212914714495057, -0.41727145479636957, -0.7968469926603798, -3.342842313404661, -2.350842313179026, -3.143571534855495, -5.0453119771372075, -1.062034717709571, -1.8924488777308657},
    {-2.0025775628537907, -0.6304843105867903, -2.867063780764039, -2.7449346623675406, -0.9139533211600549, -1.3370401823185716, -2.855616393708452, -1.868573457900342, 0.6499964884512965, -0.7156498863008958, -2.5057081268002124, -1.5920720261027712, -1.8907537039289353, -4.807367800162208, -0.40736067232476464, -0.8529107022623191},
    {-1.5229504310671313, -1.2149907502031327, -1.8761441103771892, -3.0575059876630375, -0.7767552397348573, -1.797980696769764, -3.0527534282480984, -2.0151056569986046, 2.643537265051137, -1.6160257496834083, -3.04977314183258, -1.0244567163936333, -1.226531196161048, -5.305934445432018, 0.4200643213822728, -1.0472869397448905},
    {1.2027810711668936, -1.6999144994806634, 0.45037961802537274, -0.5429562457602838, -0.9573527607764443, 0.6833080825315441, -0.6897443455487555, 0.6505104787844814, 3.0765093698152923, -2.2586699134898462, -0.43742595571009485, 1.947331303348145, 1.7411575056853816, -3.880636382671983, 1.5462418404910714, 2.1314652150290523},
    {0.015182152679236404, -0.8459561802058453, -0.6243257843585233, -2.1491961290447037, -0.9189768674607525, -0.763884126009658, -1.7174652321208712, -0.8697451065594609, 2.091419859713834, -1.0013161732728897, -1.6626497451851225, 0.2751963999971614, 0.3368000410451541, -5.398875947151477, 0.49289467036192747, 0.4468840979581255},
    {-2.9987758318847306, -1.4385462883726867, -3.3994561680086806, -4.222009635685357, -1.2819972015666439, -3.6926358525572303, -4.199295504024404, -3.7821429454760533, 0.31249824112916513, -1.0845682405087669, -4.229037193231192, -3.421917839644558, -3.2242482571688917, -6.1323572266131565, -0.6761344142313004, -2.8394835672628607},
    {-0.47054525471820347, -1.3361974102315568, -0.8754181450172349, -1.1559461901818557, -0.6618790442980398, -0.3724574884890848, -1.2488020874574555, -0.26157786019874696, 2.560430803693183, -1.2374660779880549, -0.9621392136185479, 1.1208740420256085, -0.10971861649845133, -5.253082193118292, 1.1624463928807536, 1.1297324600009917},
    {1.0224357692321688, -0.33384147813148907, 0.12629712830999562, -0.61693468202985, -0.33165197505140903, 0.8897920852936411, -0.43734602223836067, 0.9728508485218331, 3.207319594993947, -0.6577891971520056, -0.3807494154256502, 2.0269799868415266, 1.1524816920807035, -4.917483534116375, 1.4586550318137284, 2.2702944022851796},
    {0.039766311150416116, -1.3023627672065274, -0.9512507032281726, -1.7034328833536956, -1.2909641132622227, -1.0806500867855238, -1.998692091435703, -0.4403776547518654, 2.3344019575721884, -1.3918565569029073, -1.9275966472665687, 0.3076344726609557, 0.04766454433285056, -5.347443987586953, 1.0718065564965915, 0.4751396939614517},
    {-0.1624201184713906, -1.8699180383099165, -0.6164758769823436, -1.8625846619455826, -1.6556597431068005, -0.537153370024695, -1.5552634733565878, -0.45250668939316385, 1.8898577758192465, -1.9465861447632382, -1.6268798978909054, 0.5814958217969105, 0.06087975699514235, -5.821782282877089, 0.47611054100529476, 1.0638347604372862},
    {2.142352112454136, -1.0881477758210987, 0.9954386226572514, 0.2611626765736308, -1.6169436317919246, 1.839748999702431, -0.05316552174136744, 1.7919233096897629, 3.438768173567569, -1.4861262264529356, -0.007259035684188538, 2.201436065031985, 2.3496319834013426, -4.154283061356993, 2.3584125681691206, 2.6797832185517416}
};

static const float b1[16] = {8.49902541370504, 7.810033910151476, 8.324575416187733, 8.348238690976286, 7.915762712136235, 8.51980328661015, 8.522449276826778, 8.559272196685429, 8.016966657091762, 7.934881759497194, 8.478066541946811, 8.654430040586373, 8.516573568162853, 8.819179524599027, 8.278455031491141, 8.47077953059328};

static const float w2[16][12] = {
    {-5.5668403830566975, -5.468657214684407, -5.189475425406115, -5.230283281684196, -4.97002450472541, -5.289558477517427, -5.070955018195067, -5.565896305674877, -5.117982534532726, -5.070914203509229, -4.952542167866275, -5.32190020032753},
    {-4.057108285065537, -3.5851497128960994, -4.521257913768454, -3.662326303560693, -4.0718636447106595, -3.4299305659547423, -3.739249372110686, -3.659220300761936, -4.198426591669238, -3.9657349404911306, -3.9918078408846074, -3.4199747639464495},
    {-4.964935263019297, -5.475209074594533, -5.289267550550168, -4.827062955426327, -5.372239901932146, -5.6864463046572435, -5.663457380634244, -4.813953075729127, -5.563892607678097, -5.615551641800803, -5.679244435351241, -5.360406626869176},
    {-5.547955196786141, -5.138739024027002, -5.368240939946219, -5.627058618182374, -5.782005319301596, -4.891569166954003, -5.585646633034441, -4.982761961563344, -4.645829993539689, -5.299293141974108, -4.786862374471629, -5.534702295601311},
    {-3.5698290512399136, -3.710196989365398, -3.5738292052748366, -4.210260650082254, -3.5335150946079477, -4.180521715397246, -4.01799702723951, -4.315662371267122, -3.1396034144845553, -3.544946396202756, -3.836351014600229, -3.02704410084925},
    {-5.280629768047689, -5.733543415997728, -5.550648044660127, -5.174004522235434, -5.233954731721178, -4.9564561587976845, -5.561019214824271, -5.646732725021966, -5.039414833548274, -4.940673391239604, -5.413607609218947, -5.5868078603554645},
    {-5.464697978134802, -5.5984026872213315, -4.903948546428789, -5.373392278172707, -4.940245261017911, -5.881404292658206, -5.114772040801155, -5.4000129380910336, -6.140580466312195, -5.1273468868086685, -5.576456920789841, -5.353422028520578},
    {-4.8742389063474825, -5.677822252859347, -5.761727004642377, -5.8144144215889595, -5.509264699133229, -5.2216902490577795, -4.90483683915764, -5.126925513410003, -5.452320938500117, -5.271761190543271, -5.2112698103672574, -4.518957043207001},
    {-4.100310821453918, -3.953772745017319, -3.907543227483077, -4.654375978610403, -4.144691304343768, -4.067044138145554, -3.765690817012416, -4.466261235707997, -3.4669652858545486, -4.270058784648847, -3.810293017902929, -4.5410049129971},
    {-3.784053670046278, -4.198562108321279, -3.489023980140613, -3.2994912150288753, -3.8080087980942583, -3.866961535482729, -3.8737723351960147, -3.2106104466514975, -4.55133221381027, -3.8756521414855403, -3.795394594464921, -4.729762450246947},
    {-5.368224130326621, -5.014745158895261, -4.731779395539817, -5.343732709594469, -5.258069623355908, -5.645038726409064, -5.187589440531604, -5.681882654559583, -5.67668065081738, -5.644300101347328, -5.623142686910113, -4.9746709032654595},
    {-5.4579227740363985, -4.948374982606993, -6.119358357824935, -5.512428425470036, -5.545959318478152, -5.582549491484113, -5.802741508686986, -5.7208860538965975, -5.063316999818641, -6.129871895994591, -5.466594590987097, -5.68000931352785},
    {-4.893976079923956, -4.980697718031243, -5.911996799634854, -5.356656905785186, -5.640939808613655, -4.921995063123009, -5.750517991138062, -5.692484623033353, -5.5685981813446475, -5.731194013548909, -5.190762513580694, -5.394473684667669},
    {-5.086565526493612, -5.028567104842957, -4.619775040917059, -4.867812590698425, -4.890554447331754, -4.912587882194728, -4.350021036511966, -4.653285465931366, -4.730236438563497, -4.3969231431468385, -5.125257564586781, -4.782132241462092},
    {-4.755139135692314, -4.412440310083675, -4.199806426208768, -4.967970358365588, -4.508240686747766, -4.2907011859246715, -4.176176115499842, -4.476843818113809, -4.304823164181345, -4.05245077079374, -4.469641136899123, -4.2014160740771045},
    {-5.912734643987199, -5.525234730388029, -5.219860862186337, -5.125323561368827, -5.330118916265328, -5.639397601348442, -5.939335156334007, -5.241967574120141, -5.809454842992967, -5.455871477496244, -5.587206915452498, -6.186115090455051}
};

static const float b2[12] = {-4.725112638726002, -4.632417341324796, -3.3709010828486523, -3.3829887261895504, -4.130995272186535, -4.000098241681643, -4.388565894771948, -4.3075988127391796, -3.976214350741834, -4.91512445302186, -4.220669140895567, -3.836017410990549};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
