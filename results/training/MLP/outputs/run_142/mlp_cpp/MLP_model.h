#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.16439594837368807, -2.9837066091562283, -0.5612784482070192, 1.0948919073828125, -2.1357281659461607, 0.3294918546937855, 2.304528528969657, -1.9441845861660825, -1.9991007142629873, -0.12945506222776618, -4.180971183234434, -0.7823287843442724, 0.4690308760109273, -1.0030788014959897, -3.7546635499829732, 0.2276557618031952, 1.9054162456154684, -3.7776449630004043, -0.8506092712510858, -2.9640628454582343, 0.3005699359410176, -4.800127261877153, -1.0425134682611124, 0.19046659667446056, -2.626314530982397, -2.2815821782951966, -1.5728663761571677, -1.2286736062341315, -1.339159110927582, -0.29085135445346477, -3.3960676882467182, -1.8382772712728883},
    {-0.06879854222459991, 2.197203434548402, -4.7255262527642286, -1.8775208825735006, -3.422299553092407, 1.5752964298739356, 0.3282875577035815, -1.3995298008469912, 0.12254402636504859, -0.295218525127753, -1.2760451409431264, -3.369613267287301, 0.9595687566239445, -0.213737173822364, -1.425904623920855, 0.4437345402983297, -4.057763542292388, 1.4789903387156407, 0.760579878693476, 1.135723618774255, -0.06326694627722607, -1.3231249083848902, 0.2481706847795398, -0.05726994362588168, 0.44183587851444794, -0.23010323098576715, 0.18187620251693912, 3.4564554998413803, 4.345793081187783, 0.5587794419344075, -1.1453323954158525, -1.3596596713776812},
    {1.0493567269299422, 3.1090335409587566, 0.46263133634928993, 1.1174750095090904, -0.01672603458325209, -0.47314038127188424, 2.0672385674001093, -0.14221973835254204, -0.1714707519518404, -0.9144130526862427, 3.3341461900892755, 0.19580978555751802, -1.6542909396470498, 4.437253149162866, -0.3329699180824382, 2.0594938778942176, -2.2392668713855506, 3.2687382412443244, -3.273505167006931, 0.6375613729320994, -1.1186368016687143, 3.106994641911662, 2.915011722793632, 3.9899991554396355, 2.3846309976544626, -0.38411078721687886, -0.8700843838092125, 0.9373001368726441, -0.9979034387618161, -0.5887646701905038, 3.704330208392485, -2.8915539310735507},
    {-0.499876499243908, 0.173568205947959, 2.154041742044988, 2.3821499442691416, 2.437764192888165, -2.649534011271812, -1.078091440595257, 2.793134769247596, 0.18177627391246406, -0.3872612904872316, 1.978755568814879, 1.9537888977576716, -2.190296090648976, 0.7772195273163518, 2.2072686566963435, 0.4795574799046003, 1.2797023847100435, 0.32370157877577443, -4.331870756173738, 3.7891659139012597, -1.2261226747148553, 3.8951375889137054, 0.7537951649050623, 2.4326454320340396, 2.994894668160911, 0.3902511684560833, 0.007129048653959125, -2.5946911131037336, -2.893058458987619, -1.2415198464143502, 4.612987944767363, -2.9194700020661832},
    {1.5862913682748891, 3.213057092537173, 1.2772932537385207, 0.9005871813150859, 1.260112585498826, -2.8278958903835254, 0.9782980632565867, 1.0322853941989718, -0.7209530497081753, -0.781494325749118, 4.023030186214016, 1.3997165522228483, -3.31964646376589, 3.0777157342738146, 1.8210920428798665, 1.008108597095068, -0.5264683961175181, 2.6730570799243054, -2.1435994667763043, 3.3873437202777827, -0.5317781023395728, 3.444473622529642, -0.26267267939420236, 3.183809930702614, 2.041551511424795, 3.1311730782486333, 0.43841736269796977, -2.9528351708359235, -3.605345469732985, -0.6803359171302285, 4.790571137489837, -0.20877782659799907},
    {-0.8091282980231412, 3.8766011851093753, 0.3184346103410716, 1.2547938125675353, 2.6883531999948413, 0.248130981910253, -0.7019050625813531, 2.443285542489055, 0.4665345251084369, 0.44642542513078687, 6.470798737053889, 1.5289020496128967, -2.1775861778927026, 3.526906471638209, 6.0773271617233995, 1.316998860427431, -1.3730830450553255, 5.3533332662554995, -1.332977505322795, 4.5141910834069225, -0.3524072975337715, 5.1029051584373075, 1.6308785624040645, 3.0901812103370707, 5.559616275680806, 3.886593786826185, 0.5066990902425316, -0.8006867381902321, -2.2179638999475313, 2.132740354862602, 5.789847423440097, 1.446968229517929},
    {-0.30377617227622616, 3.9180444902789877, 1.2738497996076177, 0.847781028600027, 1.3606692947551937, 0.006808780477952207, -1.7235052575329568, 1.2942492481254217, 0.16378298804680785, 0.7343577868098712, 4.220966079490953, 1.0821413376879945, -3.5329177244402072, 1.8956148502861494, 4.7759886207408995, 0.3702766069917994, -1.4818131281194493, 3.400808451297163, -0.6993496090319318, 3.998294540202125, 0.2579001145408772, 5.202306302664544, 2.1775496233307035, 3.296517246878839, 3.226757202159806, 2.596454085636599, 0.4951702562695041, -0.6728325660494094, -1.7244529817419882, 0.8851083098928865, 5.285196859996289, -0.6968979894913987},
    {-0.7708449534476484, 2.744169835485004, -2.8790529627333896, -1.824153029489586, 0.44969428889411867, -1.8814756095272618, 1.0296065767982026, 0.6170592426176758, -1.556387401132484, -1.7565708853837758, 2.27587687397101, -2.880787181421836, -0.973054047471829, 2.500470485523464, -0.4685619795705794, 0.05863650496764818, -3.987539295476803, 1.2039035054615892, -2.376535065104306, 0.48908576882592786, -2.1693247604897383, -0.4384692908196759, -0.8258123083635495, 2.0266134271283502, 1.9808953649762149, 1.941740165422982, -1.082091498373471, 0.12568148357053133, 1.0697649007636345, -1.8714028819520092, 0.19565572665828018, -3.2262376232693555},
    {2.1040637958341954, 3.677526649964147, -1.8487778161834658, -2.485573430718203, -1.6261806966694476, 2.7981094753823785, 0.13270811080717226, 2.3909483526520194, 1.8801986144252807, 0.31118758911634925, 1.3376698977514876, -1.1044944811829793, -0.8831030135000769, 1.2610978256984442, 0.6678089021585008, 0.8006053790915766, -3.6182085700524866, -0.043397568036210026, -0.18506540371614252, 1.4837295334389247, -0.508845059925687, 0.5338406284293545, 1.6064377588942964, 2.1148364433237976, -0.03463227191403159, 1.845836953587801, 0.783410988266227, 0.0601180410978637, 2.98683020031529, 0.38164385096564113, 0.6360539775624267, -1.4283415852641457},
    {-0.3998118886387433, 1.784863112367664, -3.6410873761510696, -2.901047728038995, -3.3803544396884706, 1.3534293968744844, -1.3897284118186983, -3.3720599236391444, -1.2498268694133159, -1.4108375805350448, -0.5328974276136104, -1.9384490626712094, 3.2697109481804425, -0.11239410250713294, -1.6291280885267634, -1.442115167146934, -2.1320652829197706, -0.9588936848066949, 1.3258807026559896, 1.1914230769760232, -0.45430945965330605, 0.10949801855939366, 0.49228932826997057, -2.73797457697079, -0.6711491748347881, 0.8313700604373342, 0.15934617089239703, 1.0485909202755863, 1.3698896444744326, 0.7423597921301969, -0.2878096826971961, 0.18531471191336213},
    {-0.6986205983872289, 0.7263553594591149, -0.2313212743385749, -0.6887673183401118, -3.242758342388663, -0.3790062734868942, -2.383232233075464, -0.28552791871208494, -1.0230697968922553, 0.2605323918360804, -0.32880551706415045, -0.9770047797090089, -0.5353662097042836, -1.8075693671988016, 2.332280800594842, -1.003723413242869, -1.5643597434742467, 0.31092939938749264, 1.0561723799092688, 0.6504624019086136, 0.9831303580426426, 1.6043345949920151, 1.6092303758745385, 0.10042916340907931, 1.9590477366886474, -1.323107380711118, -2.2023989279704073, -0.5439793939169653, -1.6143914112610378, 0.6258569246768733, 1.0841060848329365, -0.8492411422837723},
    {-0.540914210315797, 0.2221383340793855, 0.6202295052055024, 0.7280668570327197, -1.482348164761237, 1.3721952991096058, 1.0983234944076716, -2.0157620290346774, 0.7634590965805181, -0.9339576061637446, -1.4899337078869352, -1.4712603370789865, 2.2015934320298363, -0.21560271186638566, -0.07611844868888422, 0.4706395530680261, 2.873319298910497, -3.12913582012759, -0.7537745324514749, 0.16463907604225717, -0.006796893677745914, 0.4010386035158999, 0.008045601341934478, -0.37249159605421506, -1.7319781433130763, -2.6608704614633085, 1.9731220742429159, 1.4033384605984007, 0.9317185189453, -1.8521357594878174, -0.38083707168914266, 0.06763642781186822},
    {-0.3926312138860551, 1.8158085227520622, -2.159148005871828, -4.35595877276974, -1.8939647315369836, 2.390852285368171, 1.0586597366390245, -0.34944090978366626, 1.630019135256198, 0.4395925774667721, 1.3032321520320247, -4.070044656139761, 0.8323525397728458, 1.2332690486606, -1.134805088088366, 2.1763607822521216, -3.2178316515646608, -0.04226267522685684, 3.4123323268178245, -3.4622336010041894, 0.6733107146867787, -0.696654349142465, 3.4702691164648845, 1.1276213729868099, 0.24734701822055385, -0.22930001075522188, -2.0450267728345883, 4.037442809442263, 2.8423846269820285, 3.218847070892234, -0.7701084145100237, 1.2705293573440142},
    {-2.744358518501953, -1.6594307393620806, 5.377867924066986, -0.04767710261096332, -1.3398418407851604, 0.8307704472203915, -4.281865421123789, 1.8024173881833974, -0.5231376003591237, -0.7990847934122683, 1.9388983568890408, 1.509769854248594, -3.2109899399816793, -1.6877600515940256, 3.982415567568746, -0.9718039614959756, 1.7618263002749914, -2.1432082059292905, 0.8337410827889528, 3.43991062428081, -0.04006708818959815, 4.163705568688544, -0.7977015714377975, -2.6207383901228156, -0.5758727543970695, 0.21981024148372974, 2.231655922036091, -2.099723315260213, -1.1385951281502606, -0.020090338443489075, 2.5287231316537557, 1.1195603655265758},
    {-1.0423291251707265, -1.0305692603433332, 5.909865915564533, -2.0654229277008085, -0.9402782202451065, 2.2166532714100393, -3.3748049520561545, 4.397628994731432, 1.1524189539715808, 1.5360778654213119, 3.2128232846302587, -1.1327881807261342, -3.392638804836473, -2.590108661925001, 4.387782121820375, 1.2418842583053569, 1.0339769493072104, -2.580443414686349, 1.265261957398251, -1.5093101183967796, 0.7069525238417759, -0.05141624192361303, -0.7295548846467272, -1.9537469872085322, -1.5119374821523204, 0.5753960862713073, 2.0551176274591696, -1.554466703005328, -2.668213812569939, 2.097331175320038, 0.0949136192480322, 3.7586974704805747},
    {-1.4131494534992068, -0.6960792225555443, 3.2600266576174146, -3.798036090408564, -2.2372000995425747, 5.000406545659351, -0.927735204909145, 2.8709851333096563, 3.08421535913723, 3.7536722505610163, 2.7741027000501566, -2.5506464308055468, 0.7564632773123632, 0.2528187786994012, 2.4927063344786986, 2.9555871786480177, -1.2307773014576981, -1.6795946300107014, 3.73633474433251, -2.4374907025276684, 4.317642182504068, -2.396293485481714, 1.1550816953676897, -2.6294744050432035, -2.2005720605226964, 1.646857206761832, 2.644051322735301, 2.1731389502444802, 2.53408681372201, 4.040836379561667, -1.7171893910476286, 3.4475305263266423},
    {-3.202155717176345, -0.6051516867725737, 2.945168822720349, 0.49169362676769407, 0.469352691579914, 0.7411753135184895, -3.1675996692208037, 2.8916185746916296, -0.9367144794186278, 0.5119202260421375, 3.3074421920508295, -0.4437352226071757, -3.006269716621874, 0.22384575507000962, 4.521234842568182, 0.2256827485940794, 1.6748165930272116, -1.242089896872871, -1.1307412820514766, 1.2512537202314276, 0.7722609803976174, 3.7752131236407327, -1.0172580678823058, -2.634268313878182, -0.05760524394922435, 2.0389072961264563, 2.8360709773229047, -2.066514821760937, -1.8373940975215868, -0.3771260225648258, 2.8947047845411116, 1.844446219338369},
    {-1.756031159025512, -0.830543964868753, 4.922566530103271, -0.18583258756286009, -0.8608474830537721, 1.607296387700803, -2.589417208141782, 2.2507375022580653, 0.16008877013961947, 0.7403568090958254, 2.455322812169303, 0.4724399476726585, -0.6908679786745638, 1.1294594635046789, 4.6605954463412855, 2.0501100225786266, 1.5021116826279566, -0.15148487172598074, 1.4400924728510083, 1.1463283107627842, 1.6797948239698721, 2.9389687223377483, -0.40140450394185506, -2.521115763248205, 1.2367484122961443, 2.0373214544102534, 1.9587969585501883, 1.5086097030916243, 0.25130160597669865, -0.18863393298157982, 1.0566351713729683, 0.9928110160736033},
    {-2.92146448409054, -1.7207603642494522, 2.343882826732628, 0.9043708932186386, -1.0618406568370797, -0.8860464103245698, 0.20453666027790895, 2.220120085242757, 0.06641999152109405, -1.608949760596567, 1.4360415459461093, -0.21537289668065826, 0.25258897603103103, -0.07929673199497281, 0.43786662114707514, 1.0583509191432647, 0.14831235637812024, -2.335048529602621, -1.950888549214576, -0.6401097665054437, -1.6378462776699658, 2.2727366456526434, -0.18284431269484028, -1.0751159468935836, -2.2149754209758505, 0.13820971515770322, -0.1752208064352187, -0.41368218985668215, 0.7036773989875961, 0.8421828944503262, 0.4958811179287954, 0.8256552801217172},
    {-2.9966648851058695, -1.4294365673548775, -2.3723198769267944, 1.2672339914815227, -2.5797591833374187, -3.2283292260193384, -1.5416855176566813, -2.881499133059901, -2.9848250029260397, -2.5476213444500115, -0.9518116560136131, 1.335803611625538, -2.4036109868831286, -0.4344875392338653, -1.1193473905255737, -3.161345571640893, 0.41995733623803044, -1.2178604871958365, -2.218167899236203, -1.0157801815506435, -3.118521757201219, 1.7330144618552417, 0.0050886481296694465, -2.0322490156214035, -0.7363919383403142, -1.8736022860875186, -3.446370120629938, -1.5956949971704577, -1.8798048650304258, -1.5842948093103804, -0.04514793356633461, -1.5808546918835262},
    {-2.0164794526913474, -2.020920644606899, 3.3077395185559495, 2.4469256090283333, 0.8135911019043152, -2.4485930514851284, -1.0509113272134527, -0.2607129149407297, 1.2101515575331285, 0.057451277980450965, -0.24529866816839738, 0.8601513933797426, -2.706634463674266, -2.4006337340754, 2.2204116393484634, -2.7513694673370743, 2.2130288896575245, -0.7534166951528232, -2.3764874129669247, 1.2959759296272102, -2.7317821184628905, 1.3897091329839169, -2.584506893116527, -1.7483500017347156, -1.773198942657732, -0.4921916146414362, 0.9918974633293538, -1.467785165248021, -1.478944733849084, -0.6124169036880998, -0.019471356831831804, 0.34870895606126595},
    {-4.370012740596693, -4.432714367767797, 3.3103515317562815, 1.5400876630822131, -0.9556781078037135, -3.1375122239153654, -3.035353763494083, 0.665282470362783, -0.7574225789482513, -2.643545305380625, -1.111986582670401, 0.770360556315169, -4.4435301629684005, -4.177665343237483, 1.1486805845399708, -4.158754052971632, 1.6116886343028498, -2.5685136075302584, -2.104758299818267, 1.312933248898832, -2.440327961772422, 0.5122888132690522, -2.4067498567168957, -4.404926238315003, -2.0954116086921024, -1.3859708953739687, 1.540931537086561, -4.48418510029877, -3.5254177035621344, -3.052185926317648, 1.2560999591965087, 0.9753953267758232},
    {-2.855995121936685, -2.306328013900092, 3.3192283814410213, 2.8155905060988315, 2.2601684596646576, -0.8868287742789572, -3.5341790703996856, -0.22789896971335383, 0.971738684760222, 0.18534842456664416, -0.9303280421069053, 0.9249071559112056, -3.09423711129224, -2.9359556581232265, -1.904872573402486, -0.47561714650542614, 2.0637712038791243, -0.5644230629540781, -2.2913420393939714, 0.9057721697476719, -3.128170264813654, 1.2648324650054286, -2.8484564745438914, -3.312496527631116, -0.6608910814692017, -1.9842728965590681, 2.5416760396828386, -2.1711721462227005, -1.551756765823825, -3.305577694386586, 0.2836775509437497, -0.7806528566271518},
    {-2.243429403168081, -2.9416343527017323, -0.7443048873498576, 2.7855851707331887, 1.4856445738733517, -4.91832685030026, -2.0704591899501295, -0.26480060658133103, -2.1558129072909065, -3.820779488513583, -3.2594955250033237, 2.714131499915695, -2.956754102184379, -1.4438647875529431, -1.7557353039058707, -4.701479093613695, 2.0789731567104264, 0.15243606973702875, -3.1309656061007822, 2.1097965808522825, -2.352749354109668, -0.08099090927339696, -2.5119092939493743, -3.6990002423803325, -2.0510518493949874, -0.963446084804332, -1.4401990880175624, -3.5394194469224294, -1.8254514115234701, -2.828340464839654, -1.3413909353048095, -2.005013704434812},
    {-2.105651873642321, -2.026314079547135, 2.3773762830886587, 5.635248087146376, 1.3614106743664445, -3.893343184624907, -2.6412484182422866, -1.251503401062978, -1.2420450622158734, -2.5504131115965967, -2.5541618055036155, 4.128889990998451, -0.7181270262232443, -1.361407683844518, -1.7741625885799626, -2.227252690307881, 4.085004194701993, -0.06582266329658813, -3.930021446662973, 3.9713563403985215, -2.912612285256846, 3.5768188008348045, -2.0472569853539655, -0.10673702777143554, 0.6186164232484586, 0.019987648582877392, 0.43237697916812, -3.919033812368766, -3.0826817127697894, -3.6744868145557805, 2.495353865589277, -3.0209073697858595},
    {-0.3971771824211042, -3.1368002701321194, -0.15092622151716845, 4.952651968696303, 2.39183639424743, -4.58766492557896, -2.3766934192027835, -0.7861350447761565, -3.997419061104418, -3.911756605591127, -4.26390274660593, 3.790696003629368, 0.13729560024583048, -2.0866021116713647, -4.323868949165827, -3.151277793237255, 3.664024638941846, -1.4998581261736923, -4.961876715694814, 2.2816769770782304, -3.343181049833825, 0.23762234604319885, -2.9896049058255487, -0.9539357697594657, 0.21760243740042914, -1.7169590850523617, -2.872878901531983, -3.7148097225597283, -1.464075112601356, -4.612121863522613, -0.8309249074946953, -2.687450141218142},
    {-2.1112259819414145, -5.4290912329658845, 0.8126729377992835, 2.1916923586567933, 0.6152451846801309, -3.0505215943324973, -3.1049427306073936, -0.6926276368642239, -1.9659304348476463, -3.226193216202932, -5.364394819351778, 2.5696425253423123, -1.3769030947954992, -4.014574554745768, -2.7302751977845903, -4.434679406699002, 4.160070249882728, -2.584701463858269, -2.6566853372929313, 0.9342498487277303, -3.1488632761643327, 0.05757036113895093, -4.20524458277557, -3.3850086100694847, -1.6476743317679083, -2.2385045421774303, -2.0426226188296743, -3.080144442032433, -4.037067039275476, -2.3101552180131817, -2.178527111239859, 0.16487365668378248},
    {-0.6762452500424728, -1.3653182733677987, -0.6303896629564645, 2.464993360064253, -0.22610135406944845, -4.526584061863178, -0.2546904904360906, 0.30986683152750755, -3.5223153376146112, -2.5178582389391413, -2.477296049195639, 2.0504075022255632, -1.4176252743326352, 0.6967496489193233, -3.339178260281609, -1.1006517006183127, 2.051885056748106, -0.4035540678880623, -4.7568565931306255, -0.8451497348695844, -4.124719739444548, -0.6896429883106846, -0.9295840371217697, 0.7316514854953411, -1.9689321416909198, -0.17879520868320578, -2.6289799030993253, -4.023318452255626, -3.379480145100753, -3.784614003213639, 0.8594676488279727, -1.0080223241634994},
    {-2.951654584142401, -4.138494664898266, 3.1083617303427182, 2.5766182631499244, 2.6075354667186184, -4.95182254984715, -3.6704821381766686, -0.7700531843440612, -2.1451720255438347, -2.2377248945714494, -1.4443616956124665, 3.8819975803001303, -3.0733626359786337, -2.2067533537343915, 0.7048173468955116, -4.398735176422002, 4.352753400963591, -1.7301826876041861, -5.018515627995475, 4.285453140877304, -3.316775999508671, 2.426760913019055, -2.171976547827533, -2.9505066242179225, 0.9144262095395703, -0.7015276866157849, -0.09352813726736194, -4.070269760338793, -2.7678887367293297, -4.717586460127477, 1.6470520295670552, -1.336964081649644},
    {-3.0268478746691216, -3.3260468827621215, 2.3058181694395836, 2.637935877506825, -0.5754796777059946, -2.229381248559611, -3.035015620193703, 1.4141186082153752, -2.7950703211276897, -1.766783423959472, -1.87642586291443, 2.1800272410227635, -1.6819250870949964, -0.5656020236951812, -0.04543322040692266, -2.7203756790599787, 1.854606372371858, -1.8207678749299154, -2.0893631857902477, 0.31330662984741653, -3.003314167392841, 2.0088753920283784, -3.292331269500042, -1.9514490723315066, -1.2720958293170355, -0.7768235639508183, 0.05331636974634809, -4.3241375474443435, -3.4098602408746497, -0.6197891487505641, 1.8484922941372892, 1.5592027370082764},
    {-4.481342876440792, -5.214129300521009, -5.662975447779492, 0.9119991157750529, -4.3951750709168875, -3.2588700997094047, -1.525540465589755, -4.830133892266978, -6.602737543795495, -5.3361398293433, -3.4067315312569266, -2.50528425326085, 0.21198892678805933, -6.3566423942070704, -4.243801060376611, -3.745069382236377, 0.055789882990299175, -6.420732238406367, -4.503718405137456, 0.3780390361870521, -2.1571326965951054, -4.013889910516845, -5.441082271653152, 0.13620144594162512, -5.125543355675008, -3.986672027223952, -5.8291344943492245, -1.710794790693913, -4.0345513768713355, -0.055253998152012, -4.82505065974805, -6.417397475945341},
    {-4.781539562951509, -4.3326412937515215, -2.7618142861373194, 1.3763851783817715, -3.4868707736031053, -3.026467747047339, -2.7637308015955697, -5.255812739102074, -5.063421173095179, -4.417024155909175, -2.277791763533323, -1.4536911343623287, 1.1314752344989325, -1.9796019149857962, -2.4647498704214437, -3.563422720459103, -0.2637197164259803, -5.002196260153745, -3.6947398106472287, -0.6082684006867876, -1.3415994215111722, -3.5261478125879977, -4.329366247401761, 0.13011031561070763, -4.703765786532338, -4.992434897935698, -4.777122038505953, -2.6741772463731857, -2.2569834640771407, -0.8194874650933281, -2.398411893642975, -5.731591067719465},
    {-0.08351147453588349, -1.879893781346893, -2.000386298858572, 1.555908867486835, -3.244665236965846, 0.36556286557192974, 0.9711724069292824, -3.5681331842872943, -2.262448362972822, -3.0812615082819828, -2.641049499792468, -2.736720615781948, 0.19562459066037582, 0.3395649202293489, -2.2964645258505674, 0.0035101422633182157, 0.9906933290101954, -3.0084549757024592, -1.8809866765625616, -0.5651041982829265, 0.2893085628799378, -2.4063523417956487, -0.5716131782347581, 0.5323661248335114, -3.398717857459573, -0.24864675620612142, -1.3348956909301997, 0.9142678042665602, -0.319483361186682, 0.472134519593369, -3.3468652453772947, -2.0854479910383867},
    {-0.9903858048041018, -2.857335387929884, -0.28863691725799934, 2.4491194192029773, -1.936948153791371, -0.05446882052326167, 1.5495428483507594, -0.5928369506052543, -2.2067547248544175, 0.5350972522389749, -1.5173960766247074, -3.051001753455099, 0.28295494164054824, -0.8038687460003924, -2.354337585573018, 0.4970328632586836, 0.9583789339270985, -2.3418441489668287, 0.2498162037406299, -0.1949250959848915, 0.9136673743769536, -0.32408243266710346, -1.756397792923591, 0.15862959802841822, -2.6652805424746306, -1.487320800258608, -0.4468647192411678, 1.0827836864933837, 1.290857164316726, 1.12525398887842, -2.392633396624752, -1.3159303052106415},
    {-1.8220601228906623, -0.41425862926121965, -1.6429094221501441, 3.295747769424799, 0.22707372785908161, 0.7005601858502352, -0.5332737113459102, -2.0601292069116646, -3.271113753515587, -2.8169232324044167, -1.6945405669116294, -0.7107740722637538, 0.48617220050119275, 0.4973065062486511, -2.1528765213042864, -1.090113897847081, 1.3673630615911414, 0.4005836830681923, -0.7223378022434553, 2.275175435372203, -2.381838456706452, -1.3522381765771385, -1.2358053017140416, 1.3925836406516092, 0.8278314443567408, -1.9798583420022242, -1.9358723946471974, -1.3093679425329596, -1.1266365963651181, -0.04427811985263966, -0.8648158854723054, -1.9556759908212518},
    {-1.9168767307513639, -2.2777659235562733, -2.8575214206312474, 2.423790688312909, 0.07180886066965948, -1.9427869319805624, -0.0004895800346185536, -1.7491247884773098, -0.25913217745788664, -1.5884167112066159, -0.9361729766460295, 0.9874226688010785, 1.8758099102658377, 1.4884354635159367, -0.8493799457823812, -0.6669077233769979, -0.5162800323942979, 0.17630565839127751, -2.7503082347890557, 2.0170219894895935, 1.1044478963059876, 0.510020706238048, -0.08056297957313706, -1.627823094125123, 1.5198220122597919, 0.894322958268629, -1.4105254417110027, -1.0787904930292893, -0.30645755518122, 0.7166796691210352, -1.7643856653052272, -2.9731838656851792},
    {1.4242760794423845, -1.2782978407780818, -0.06347787285486166, -0.694995089944708, 0.6053939793312703, -0.9526918338276765, -0.9688820766418554, -0.658605234968314, -0.21546173590020176, -1.4673490250877452, -1.815322728161424, -0.888510740858559, 0.34121377360863014, 1.8106775397495456, -0.7342281972738491, 1.9290073401736088, 2.958719103448607, -0.21657121832185802, -0.3618060516999882, 0.7183916559785738, 1.7004850870133361, 0.04122865820390741, -0.4392226895521345, -0.8326913979802324, -0.007044891036779808, -1.1584360504247804, -0.7019983475595095, 1.5466764427822894, 0.695172582162141, 1.3826430018963385, 0.8240128697413733, 0.4538915515718199},
    {-0.3075098795817001, -2.2433310559629804, 0.7516559527854505, 1.6553779288745663, 1.9729854348138256, 0.7273613286996073, -0.769018808097422, 2.449479460330425, -1.5601948139348438, 1.2344422679986, -0.38080750053060747, -1.4146835840806493, 0.38369024177108746, -1.2016707621773624, -1.9043429454107594, 0.3762783328155665, 2.456040803053595, -1.5832988419524936, -0.7200364183366549, 1.0888014759758067, -0.6154529217891925, -1.7177346772223576, -1.5091355223326446, 0.3149838016148607, 0.15162156682417166, 1.1437352801631577, 1.9224118111279118, -1.3562844211223084, -2.1124070657546916, 1.327901152949653, -0.3856747593677002, 0.9602142466656244},
    {-0.42151706446740667, -1.8667610128438539, -0.6596717366718569, 0.33064178067229755, -0.6049011787454277, 0.044172363115120246, 0.2903798884516145, -0.0342636744059647, -0.38808543421223896, -0.2679083713079284, -0.05776115488241587, 0.3244775729037011, 0.8196297637459354, 0.22367514985068035, -1.6419160196697833, 1.1340126905918386, 0.17674930067097874, -2.718059401195669, -2.02893449141384, 0.4234535792439599, -0.6705140234162552, -0.5407073094331905, -0.24820501780068185, 1.2192077108081574, -0.7885148286717122, -0.296160590754758, 1.3027158116724444, -1.1130462509947898, -1.5903401007357651, 1.05681426849031, 0.9673780449975743, -1.3890815575333462},
    {0.09614508308012445, 0.02190307732085441, 0.20518269342289097, 1.0735666613937909, 0.27403992121062143, -1.3611224073848793, 0.6320041709153098, -1.7652362548836493, 0.01941286780053666, -2.303461272404182, -1.0941676828442342, 1.1496029729767623, 0.608370638307628, 0.9534188562479785, 1.1653769459895256, 1.0235453131317098, -1.8802042849662286, 0.14538681748899315, -2.247256209639855, 2.1799961991391306, 1.1878710784768638, -1.3589458228311038, -1.3082245412328097, 0.35016503370774854, -2.290987034753835, -0.8656441170982506, -0.09635353582746622, 1.7415814549413728, 1.081559011618694, -2.1203522885138453, -1.252266316386894, -1.8762922485098001},
    {-0.9507127609366616, -1.0505768568621832, 1.0934822128216983, -0.02822983817537276, 1.327925946542268, 1.0573457971504872, 2.4931050552842953, -1.326006163799387, 1.746769435540984, 0.9752345168118282, -0.3475168722949115, 2.3037243994272085, 2.566885975484607, 2.011648033568656, -1.7685840446717331, -0.061375987862256814, 3.1860263096286987, -0.9749072355480566, -1.0312434712199836, -0.9451082343387144, -0.25856545978592893, -2.4656714253979226, -1.554301310581248, 0.6785832705323503, -0.2772790807179345, 1.1607336126836494, -0.1757547914586476, -0.6602170353108535, -0.08453724202054848, 1.2232807244111659, -1.4578149834201004, -1.3071212877610896},
    {-0.02011251873512279, -0.7257406273853542, 0.542308434855901, 2.2165293795888354, 0.38132047484085624, -0.5944231310167665, -0.44080175619349954, -0.9290836433888344, -2.169096820945638, 1.1132406129162928, -0.3889607458727846, -1.7064278486880773, 2.217863055852347, -0.24617423767019725, -0.4312347633847607, 0.6515971613384486, 0.8545600629883012, 0.563509444871005, -1.019523373766226, -1.2893721277543368, -1.021620579669947, -0.14053276597941228, 0.4465285607874035, -0.15311153313421694, -1.7746270859096034, 0.5465059201021051, -2.144675622105567, 0.04738533062935963, 1.4303358511876467, -1.4727559977414741, -0.3199124379658444, 1.9447648580483112},
    {-0.19178755127290392, -1.2644166859500003, 1.3894435453466827, -0.3066612165218552, 1.0211720761981635, -1.380659447578356, -1.3505656351266087, 1.565735161399499, 1.372252383110136, -2.0255511894267593, 0.8978417167166995, -0.7229725971210005, -1.692510316018634, -0.9336349507052941, 1.1323254302342949, 1.0413270954146128, 1.8519665396302216, -0.237960111797881, -2.3301265433014415, 2.764817128572347, 1.3856684662179444, 2.334048202511016, -1.494468601400324, -0.03173159379869135, 0.7347848697798824, -2.1214856146188827, 1.4176565482881531, 0.4637727801241946, -0.06149127285489468, 0.10039217777589071, 2.2695138996234148, 0.5639102365268717},
    {0.278826410468885, -1.8246868099888367, 2.2342085757084535, -0.4504059009470425, -0.051479380711604586, -1.115470482762294, -0.5101426049053067, 1.8676218821752193, 0.7800624685423335, -0.44835110331380956, 0.18026325897526657, -2.419879322510027, 0.13712217824828152, 0.3548391053851767, 1.0317571620177193, 2.26523038707274, -0.6243263860910833, -1.4772139852970456, 2.032906349656293, 1.0930473797270703, 1.515551378423891, 0.16672884955797107, -0.2370917437406528, -1.3492126487740244, -2.5469441102860775, -1.1619438259176182, 2.1338754572098266, 0.31179842134208624, -1.8739303054862015, 0.792002751197812, 0.4807507081807302, 1.4608070164094116},
    {1.7291914807853963, -0.705901193307881, 1.77741377571988, 1.5823959548433182, 0.31550853606460855, -0.6246061831262376, 0.5849789673805366, 1.749352837105895, 2.173542936986877, -0.6994062445101046, -0.5347481352636453, 2.0450178641684844, -1.2536344270650788, 1.261506922031812, -1.0106969431718464, -1.357723491008706, 0.478486081045897, 1.506242090758603, 1.1961469369449704, 2.2490922103014235, 1.0273149543151239, 2.090092197664111, 0.009830819412922458, 1.4607549921675995, -0.4617581661559043, 0.9548033119468006, 2.413511446993158, 0.8581657025516967, 1.5496282696486046, 0.33949398269696124, -1.287230328487045, -0.4114819712789899},
    {-0.37321571639404905, -2.102751947120461, -1.2776277394039657, 2.243157586268469, 0.07940638953936645, -1.9802609049616804, -2.6072476262842725, -2.1406432225112217, -0.2770243146252412, -2.1009156383160716, -0.014108405745888631, -1.233005886940296, 0.18778546844353514, -0.2224067073598183, -1.465659076458906, 0.9882240121268677, -1.4844560567529248, -2.7111841075885015, -1.6416139736994735, 2.3040009581359766, -0.951430863800842, -0.07537759970475275, -0.015804062385919932, -1.4147898205892167, -0.9819096838294227, 0.4750939797000123, 1.4614983203749738, 0.6578311967572362, -1.270863661207948, -0.528272158070957, -0.8150447792919584, -0.8661614463778938},
    {0.37224186530285375, -0.34957103680429963, -0.22525658715151736, 0.1020611889659497, 0.4285356928963447, -1.7117646521117886, -0.21179529927008037, -1.8041661810881804, 1.2338876902863574, -1.6062544519973587, 1.2138662755562297, -0.380154900161673, 0.39821468435610663, 2.0247204132698218, -0.6091766575982194, -1.158390785831214, 1.2303110368414507, -0.07285018523809964, -0.4337994067085317, 0.27680649675068814, -1.398061235751677, 0.30610011214281224, 0.21149836125735624, -0.751514283114952, 1.8318723285595824, 1.5241088058873786, 0.19157153964733858, 1.594900780295943, -0.3127608083421025, -0.6179920755099684, -1.1005153746346026, -0.5632551975337984},
    {1.3844886810420642, -0.41447664157702396, 0.08602102643542438, 2.731035088625934, -2.3034084279025757, -0.7214851617378011, -0.7659085410440281, 0.10937321245656684, 0.7348666794392624, -0.16016623996457433, 1.2409165810379592, 0.38589430312974854, 0.45436281268576545, 1.251849738834033, 0.6170501498701261, 0.18772685505749753, -0.6452941804502081, -1.8435559787620968, -1.4158331144529024, 0.2791952938933129, -2.5241571852791376, -1.6142132916400598, 1.7222481625561368, 0.8244015150889712, 2.076397859471945, -2.189203072729919, 1.7475814981236566, 1.0026237887943947, -0.5926542277779355, -1.4955111055314287, 0.5428535881538873, -2.741329127925623},
    {1.9676074880764114, 0.42966293291484653, -1.8765801257038202, 0.1711645558432235, -0.3886825041910767, 0.6104687752925912, -0.49585771449718846, -1.490296170389836, -0.8608464424432603, 1.9147285350095768, -0.7688594499487029, -0.6842497258128156, -0.1883475563262781, 0.7756621962423312, -0.9322729272584858, 0.8987507489122337, -0.8870497121049131, 1.8253483857041808, 1.1225305340109804, 0.16059267349271533, 0.9711938388593004, 0.9381848644809849, 1.638730533067512, 0.9380566464568615, 1.1060862350198692, -0.42571335974253155, 1.6786447273794762, 1.1042843149586676, 0.6639071852297543, -0.013065781816140095, -1.6424644814913503, -2.220369916260568},
    {-0.50272103621894, 1.1510905859369442, 1.2926229517394625, -1.4367859124329003, 1.1151067727427528, 0.8986675384451488, 1.7587551284293617, -1.7105066574072951, -0.6367533915192288, 2.9436018093648646, -1.1745378327959912, -2.728965422495747, 1.3721645660070123, 0.3813773131847917, -0.8563469078342404, 0.7390978012556427, -0.5381980052184515, 1.1917583039837314, -2.2262373723012003, -1.8717765503870998, 0.3939542449249204, 0.8259020612326969, -0.679052685787265, -1.0851750218287026, 0.05862856233617488, -0.9502637935538166, -1.1325838012404597, 2.6327978216612937, 1.8359764732165984, 1.6000671925759018, 0.19735077262430153, 1.1966292676364385},
    {1.4358685337166879, 1.9782613185036726, -0.43520960320843927, -0.6228018204859004, 0.24461547980679454, 2.0233236781875736, 2.2999693396344183, 0.12906332925203304, 0.410970659820363, -0.13548986539640737, 0.06693532744791117, 1.1552498036036163, -0.14029785398663513, 0.9963955277851557, -1.8486259567983647, 0.2276541270008135, 0.9606940645514519, -0.346011333811928, -2.649513983608565, -1.1148082133411408, -1.0085143638539478, 1.8280851641220022, 0.1591460325725948, 2.0825151343576436, 1.3519684823370506, -0.29924196727916097, 0.9739230043043259, 2.386335283566078, 2.529436457346189, -1.8186989383232723, -0.10845108860730891, -1.385269264894495},
    {0.19482652843185264, 0.2266728938972863, -0.13946299145089813, -0.38456449782903507, -1.200424622369543, 0.29215533655060083, -0.43938372918557683, -0.03901262802004268, -2.0399713496081873, 1.5384711257004782, -0.32193661123007755, -1.2464621450786362, 0.6909670569785831, 1.2245949827361158, 1.6243327845546736, 1.0451154486895617, -0.2710251269223564, 1.085374359965991, -1.3811495167558652, 3.159007008756398, -0.03871395057727563, 0.12728498398720153, 1.624723226290877, 1.7892285774912713, 1.5479389328681614, 1.8658820863559717, -0.2596960218810347, 1.0413371312141895, 1.3848053945336298, 2.3367332670974106, 0.9054578075290413, 1.4265970662522998},
    {0.04111727261122611, 0.9716815462352463, 1.5660066116514504, 0.7450336141181194, 0.7644132025385945, 2.2607749131583774, 0.37940715559754307, -0.4884938644107399, 1.8593559916605666, 0.22844227467913425, 0.3226517923943635, -1.3459070450016042, 0.8084609784450068, 1.9642663532091416, -0.12687845241706336, 0.13092074175965765, 1.2687914877981488, -0.6440095159887443, 1.9584674388398047, 1.6651098216005036, 1.6776719223698724, -0.2802379002086747, 1.2362198247741254, 0.2187610282243929, 0.026064838377090414, 1.1408315073636897, -0.22068005041721467, 0.8092865973390653, 1.0834985596676157, 0.44043648528868334, -0.16882341973406503, 2.6920634644240584},
    {-1.2694759783404141, -0.7414474689119251, 0.23763055420940715, -0.2830480464969445, -0.8797179080878202, 1.5336156615292094, -1.128773712111424, 1.4418102559113795, -0.730400620478236, 0.5953528631279386, -1.3965502832491308, -0.1693727397336451, -0.05198135162997132, -1.4826634452446377, 0.8007680055078502, 1.3239061254481908, 1.3953586784407763, -1.2672451303228693, 1.7236925680309363, -0.07061341907130286, 1.4186466851102189, 2.1548037764563706, -0.3472804380613315, -0.23730118504457526, 1.1590418058941407, 1.9411400303777684, -0.5752835625189716, -0.1049985295832702, 2.6929293184721654, -0.6845031025075178, 0.5928990101775038, 2.898485875887874},
    {-1.9425821575279076, -0.8069484498075303, 2.628407233349099, -1.0415388792229852, -1.5606743862807775, 1.0488735670430298, -1.6921288183661596, 0.3278959323154322, 1.0794129284641933, -0.5397874328126765, 1.786855275443583, 0.38437318145684757, 0.0723504744361698, -0.08706053712351929, 2.075209941292057, 0.03570659102257992, 0.07865314658266201, 0.17214236620273365, 0.20195505336777386, 0.23603981862494183, 0.3427112942993944, -0.9016242101179404, -1.468772452552145, -1.3087367659803668, -1.6468059661074999, 0.3393593162878106, 0.6678810355663596, -0.2617200111114608, 0.43245730492020806, -0.14362680049267149, 1.954850503332575, 0.9627548931278503},
    {1.674736852133249, -1.257511406536938, 1.394907820159578, 0.1673817990452083, 1.98347421932122, 0.1657579225508825, 0.5153377781202899, 1.3625403987364013, 0.6154425021061521, -2.0373642712905196, 1.5315851914448642, 0.8080765368127719, -1.7975277867399124, 1.830586275484365, -0.2419717254401929, -1.5301134294181384, 1.4431968662998638, -0.5076266696761754, -1.21702307882592, 0.7364735974218606, -0.38121025618650456, 1.2790335888624005, 0.4660968822911855, -1.5817394784722474, -0.4808965499972759, 0.8354112708028614, 0.6489584756685618, -1.9252169253545168, 1.5727983969115418, -2.1645942542105368, -0.6822157983091269, -1.2397920902982915},
    {0.7267939773033659, -0.6893603768418961, 0.11522645856430254, 1.3623805153087065, -2.2863703913778983, 1.9031079813362413, 0.46057158636124274, 1.7014146693957442, -2.2426875411956986, -1.6574832690723849, -0.8469656702264369, 0.6893427580016671, 1.940888970346698, -1.5441285142963206, 2.072825042564585, 1.0324421332766744, 0.4147977094301514, -2.250250763323622, 0.8908508892929389, 1.0592499877955275, 0.7182515921680986, -1.413666082104442, -2.312350546271511, -2.414079027615062, -0.35281030888983, 0.628472181887485, 0.7161372534426362, 2.1763625161847187, 2.262548511366492, -1.7558083497149328, 0.797556587194448, 0.5484076995599941},
    {2.0223406413578915, -1.603396346199124, 1.92881294687156, -0.4748561720957214, 1.6282688767041438, 0.681966197065675, 0.09076300360438035, -0.39522022798688894, 0.5202381808839764, -0.7758828842437138, -0.9754517778613696, 0.7688062789286099, -1.1248359427617807, -0.5603864524867832, -0.941494668870356, 1.1335104650584604, 3.5692674380760563, 0.3569886875097889, 0.7814261098509618, -1.1307783794659465, -1.485931025516457, 0.372479292814685, -1.8552494888399038, 0.7060139036505573, -0.84030649006279, 2.5650759076427887, 0.4223939350064826, 0.36048028551232797, 0.09910318774866099, -0.14814358705219752, 2.4611019125196134, -0.340187379111686},
    {-0.8452382854038653, 1.011294590596565, 0.7294622533383784, 1.9302115032708163, -2.2969719381745892, -0.7892450299943, -2.2371138236162804, 1.5590199151298287, 1.2082213529072579, -1.8057548045258354, 0.51534064559271, 0.9185154625375526, 0.6833481763396158, -0.8478860010016728, 0.5196463467193717, -0.8194624739889025, 1.18628161022228, -0.38515458816702414, -3.1061576642487028, 0.335376673365768, -2.8687701382283475, 1.5249161656033294, -1.0400142026916046, 2.0835959729489564, -2.118248595902784, 1.1126450417200382, 0.6983776680212532, -1.820892508484689, 0.4222055284735351, -0.5672087277795413, 2.054233356498311, -1.1450500794872631},
    {-0.7392412381032089, -1.3712047048475384, 1.224057236755963, 0.2663478793633463, 2.6898633720082463, 1.1783140490497424, -1.2406492292922533, 3.0978107534302315, -0.9002550760615566, -1.2083852865546811, 0.7292192604238071, 0.1457348353346109, 0.4600220098854412, -0.16643021060481789, 1.156449139447682, 0.5586186264712908, 1.346335166867412, 2.125823668354636, -2.0223868616299026, 3.412093890004031, -1.4664991878223645, -0.46156185520485116, -1.773463367577841, 0.12850460584425652, -0.3415451990982401, 0.3004575653878217, 3.4963364426490733, -1.935830149796999, -0.7418802864172155, 0.3471092534868322, 2.7594969842508013, -0.7412331057814366},
    {1.0191117240967378, -0.20734202937278315, 0.7980275199377921, -1.8549100803137493, -0.1520477691127712, 1.7656889309032842, 2.01336577895377, 1.889553903904469, 0.8418965283375093, 1.0380067037623735, -0.09417909747291896, 0.6573644218596415, -2.100409859448731, 1.3598202817697251, 1.7786794019281809, -0.46273315713075325, -0.7410643944927889, 0.9278584748318036, 1.4838615875104926, 1.4798295300284745, 0.7028661467499393, -0.0479527388900874, 1.4513730910436475, -0.6081977612893446, -0.3250414801002055, 0.3182672997555546, 2.61021662260907, -0.9297926413389254, 1.5562254517864738, -0.33728880942157746, 0.7903569490845948, 0.3532734788705838},
    {-1.9318029454046997, 1.2272423117224138, 1.241351709002917, 0.2718535822399572, 1.170197039416288, 1.5767499832801495, 0.4730801840529166, -0.19522364927559493, -0.5012601717176054, -1.6063123531067998, -0.0370463313519091, 0.8093099022810122, 1.6910903958718293, -0.7819223830935007, -1.4805472842378506, -1.290528348894678, 0.26966695304998217, 1.3309153781968723, -2.121406591456833, -0.7941257085525247, 0.09532972482625222, 0.02225292877989933, 0.9323080602168019, -0.28541359855283777, -0.0890168594171611, -1.1544235661100035, -1.9073915564744077, 1.5109677601117433, 1.5989070267916115, -1.243864208215991, 0.677814362075631, 2.468187515796485},
    {-0.5002931076804085, 1.4418258231725438, -1.7455596965714657, -0.15982177178717366, -0.13836611431517082, 0.9330069697104089, -2.1353504376553727, -0.07612236817025657, -1.3075901584387566, 0.5411465534341815, -1.0053452575367308, -1.4549274743842966, -0.5517119674503491, -1.5596966672894226, -0.01788726096472894, -0.9847697660203156, 0.6884765740238021, -0.3959395449298513, -1.7703168824446514, -1.351106039803457, -1.6311013185198837, -1.5271538837090144, 0.36613358166213406, 0.2757330115209161, -0.6910740520655688, 0.038117614297045445, 0.5041008457964337, 1.785095777261742, 0.2977153545897946, -1.7295150783911513, -0.16388403000011714, -0.8496971809557754},
    {-1.3755966670213922, -0.019115122436938206, 0.425913104908978, 1.1517472818900631, -0.2002877609361538, -1.46728961413171, -0.9991916649080037, -1.7535724950587366, -0.8625120497326365, 0.32854193821783784, -0.7215101635232233, 0.5246454138421264, -0.5943735473544329, -0.3098956036594229, 0.2878429209177015, 1.2620946509420214, 0.5667937919031479, 1.3396927763025306, -0.4592114314067954, -0.49197864515291545, 0.12205717519392739, -0.7547923574249069, -1.3706301971529962, 0.28848100534291027, 1.3852560948858397, 0.3633797509700276, -0.9513708395476642, -1.1277760251101707, -1.4244431096265904, -0.7437199292038749, 0.886662370115455, -2.547444918590351},
    {-1.1879321969035725, -0.3524682022284371, 0.33677237679751804, 0.18578237176017998, -0.20457558572777612, -1.0168539350423897, -1.6810311174190447, -1.0515003630591397, -1.3423737896460772, -1.5305831128938445, -1.2951939369996772, 0.8055760478916884, -0.9330695551520396, -1.8392617493658185, -0.2977109896951391, 1.0330321620631138, -1.0156134518720115, 0.3991985221512633, -0.14219602398799489, 0.8614619049841015, -1.6879024482591851, -1.6651703928221242, -1.1189569920614106, 0.6927899767312223, -0.5861517631113737, 0.6027660672985028, -1.3916711105170974, -1.247978015423207, -1.9947727381334601, -1.6322099200029137, 0.3685822605160809, 0.6845803753629067},
    {-1.3315746476704058, 0.06370773272111202, 1.4969535645516352, 1.0498054892255588, 1.1795612495198675, -0.40122430265986364, 0.9117936177572522, -0.5172668559887553, 0.19961248472415113, 1.9139488213369074, -1.1221004033729263, 0.892512787572848, -0.817121022937491, -1.5103106100335417, 0.015259318569356835, -0.3722234289425889, 0.13796653686697008, -1.7340693583460627, 1.4058031117012493, 0.13866235844945324, -0.33018245608222496, 0.043333174225334926, 0.6289999936704446, 1.3831151684575933, -0.8930014606171935, 0.026336598258964766, 0.984608468845636, -0.24977207721969866, -0.9946632990970372, 0.20321433443319945, -1.2159080156383433, 1.8142729129173234},
    {-0.5172021995077407, -0.71556083593575, -0.41942297577038584, 0.6091270944451481, 0.7368054965698998, -1.0933582152938495, 0.6004550832677115, -0.6922757642843557, -1.7019433293350883, 1.5934347537989473, -0.508209910648903, 0.5625491344188582, 0.5729273963322606, 0.22498403102886347, -0.7802343008657746, -0.6372963402280609, -0.4305433439273717, 0.5797630528519627, -0.5211128283580616, -0.45597921642817174, -0.8440997325057129, 1.1842278942039486, -1.168510846340573, 0.14947023345166258, -1.2495935472178468, 0.6077843626642447, -1.8635003041276483, -1.4843110699335316, 1.0616188692834219, 0.4109290459193239, -0.3093366756441746, 1.2004795336973497},
    {0.06800624455979912, 0.1476192515057974, -0.34281164785488083, -0.8572150194729532, -0.06228888842652676, -0.05525907952726272, 0.17287478919791713, 0.3095373447215847, -1.1607899892130844, -0.38454683023604086, -1.9710932990481125, 0.48850276740058934, 0.8999305545590172, -1.403259278654727, -0.388232114579504, -1.8161356069081107, -1.082656674347058, -2.4110050546986717, 0.9150303519659513, -2.726026765437144, -2.3433938123167515, 0.39404161496175694, 0.6999466498965861, -1.3148207998240085, 0.06987684436441696, -0.2640849056077803, -1.4231109782870093, -0.45947356101756903, 0.19426517411333535, -0.23017382188576005, -0.289245129588858, 0.29840482957277387},
    {1.7496104742457455, 0.7447166904760992, -1.9846840261722605, -0.802581346973306, -2.6326952940513797, 0.716078471253393, -1.760388338799738, -0.5215244687268127, -0.3358063173618468, 0.8508940490387263, -1.4120036204805149, 0.19186056731588272, -1.5941693387267544, 0.40156544217631895, -0.7582212050224068, -1.6523333525098893, -0.16200324248882425, -1.755846070585112, 1.0968631965475832, -2.1949779002089262, -0.5071742570942087, 1.2258118005580665, -0.6054654272944059, -0.23119540323454627, -0.7756671793850762, -0.9976350072838589, 1.539538425588823, 0.30726831047425573, -1.8032598255553096, 0.25914138685069976, 0.9295765601016389, -1.7295479311107211},
    {-1.0435846185426962, -1.1291312924411478, -0.3461610028213239, -0.5816232144079272, 0.3984126067112365, 1.763699450315404, -1.490897055182181, 1.1372517732056162, -1.2525840661238912, -0.20344355392469815, 0.6425155461928541, 0.06008649253900195, -1.1521127243542595, 1.822893333397368, -0.22797003728395665, 1.466210309932446, -1.5224232800650053, -1.4275664182900165, 1.7907809505316619, 0.6882680652994928, 0.4789676435073016, -0.7519135057966486, 0.6718285671655082, 0.9957194965236105, 0.2969065699596705, -0.6330296564291388, 1.567595163935483, 0.868007910806801, 1.1555750890306735, 1.6302392962247234, -1.6379915437893962, 1.010031270836802},
    {-1.6683316521238958, 1.582245761070277, -0.8186614749880972, -0.043890358753339395, 1.1320972834170904, 1.0802283264989987, 0.19656199146502554, -0.5736101204448163, -1.5933877818408149, 0.6479339083792285, 0.17358685708936084, -1.32541147832876, 1.2492582581924878, 2.000502477151634, -0.5154504934560157, 0.15105368333139738, -1.5219301790021749, -0.501949089922461, -0.8008932726573728, -1.0998497571454633, 0.6665018493296455, -1.0919128101832636, -0.9813268250713301, 0.3713646619102978, -0.11381295317612512, 0.5679406200884504, -1.581112315369503, 1.747262741863349, -0.6928272847847159, -0.5512506867359912, -1.882325546745433, -0.5837747719446282},
    {1.4102489932384565, 0.29091141360321693, -1.1794166194404303, 1.831989473044905, -0.08789556350727545, 0.8824114677986568, 1.6791258148031694, -0.24570950937939096, 2.353731891963343, -0.1713791376684632, 1.892104128374161, 1.1329723687860005, 0.8343754862758105, -0.45771657380118524, 0.49494738532107757, 2.5627818654885406, -0.5923126282493212, 0.8829962121232102, 0.6528247316461284, 0.6167731141827102, 2.3801910849523016, 1.0163922095314362, -0.33709146459273454, -0.7621088970127091, 2.2107837694911168, 2.1423688064428617, -1.1163653254538397, -0.7260274488466467, -0.611546404245304, 0.02630914386840226, -0.17130338076370932, -0.8119999477058826},
    {-1.2129384282021, -0.12835173684520212, 1.0122674675349717, 1.8571224889858078, 0.9000761484545471, -1.1246743741025012, 1.2031953688981643, -0.10799177342644416, 2.429343463583735, 1.2540577084077875, 0.160146450599254, 1.337617746181777, 0.7154315999452163, -1.5079097343687153, 1.434973363052338, 1.9172910312757576, -0.5741873022660894, 0.3869888018473263, 0.8996113967191545, -0.230209394392324, -0.22109963841528252, 0.5474086015531421, 0.6002566917992145, 0.9416110101070423, -0.6556447024510487, 2.603129377422204, -0.8553088551416761, -0.9010865372678968, 0.3219399885068535, 0.44812379437874583, 0.1914075506547983, 1.7439377235485083},
    {-0.47636618382010965, 1.4752724402694726, -0.1991032267966791, 1.145362514177523, 0.8758660303481097, -0.442567468569971, -0.921767018161401, 0.644756657901042, -0.663672843337516, -1.1894324797080715, 0.4531369284521629, -1.7772748855231983, 1.953170774759623, 0.529167140482227, 1.5986290399260334, -0.39730699119387364, 1.1553179670726796, 2.1206608456969915, -0.06328460019358755, 0.49165599147533634, -2.002558092756771, -0.48594804894391525, -1.1585075698573921, 1.9877013868089914, 0.8126764073556779, 0.12515539947692847, -0.36966572057206804, 1.3088684125927086, 1.1696576716294527, -0.6932235525551105, -0.37098275058545177, 1.1578487427922945},
    {-0.05856103539465239, 2.0086840038455103, 0.34996123837776216, 0.5841553162841838, 1.5481136048990867, 0.3111346590809317, 1.4470268737148093, 0.44770105812486644, 0.364555165542863, -0.1499101526992788, 0.24439351095879766, -0.18730818801331214, -0.38619906584198344, -0.3678641698720746, 1.3569821354936658, -1.7397360824244414, 1.3879435343389641, 2.4946830875513495, -0.5126191037692227, 1.9274768930843165, -1.1967209082165835, -0.7120838524583994, 2.201765749762046, 2.0441084527948985, -0.8486395392843801, -1.1971413964843813, 0.646049166585239, 1.3670355350632237, -1.0478892409967586, 0.02750191487589201, 0.36053541060180005, -1.2494150110328954},
    {0.15431267397780193, 0.3986163887476037, -1.417831609232783, 0.08351910346452293, -0.22823064803414253, 0.28520744864098896, 0.2388496785619844, -1.529906947911963, -0.5892636132824083, 0.5525377913664363, 0.7028531349038225, -0.3649393607779842, 1.342872871966832, -0.8009444601823369, 0.08782606252058842, -1.384436709518887, 0.10682570751038611, 0.4057454890179725, 1.2804062575201771, -1.5441309237703222, -1.6688908083423015, 0.6234063885009373, 1.7559567160418732, -1.5786868269018661, -0.2912867333285277, -0.5162582509035307, -0.38264980798260606, -0.3294067377291224, 0.6931968330398153, 0.7208733300455347, 1.5880340577586227, 0.7449911791319895},
    {0.07506882479294305, 0.5538400193863974, -0.20173413133613485, -1.782736941379738, 0.9474427836110029, 0.2593290202605628, 1.1256398895081816, 1.0079436037556495, 0.15290581671733403, 0.6247454335645435, -0.20278277561635674, 0.31977977061982155, 0.7412983958765699, -2.357618290868272, -1.6446323368108653, 1.647676623425533, 0.7561822510494512, -0.7331882157534281, -0.45172742072216987, -2.3313637127391984, -1.1071733518258575, 0.7940184150507323, -0.07742099734519796, -0.3556612317430706, -1.1787075420972817, 0.3346599277424286, 0.706402035061243, -1.7833046089329758, 1.5106667832158147, -1.3593915164336623, -0.18195841556580192, -0.7259933438216466},
    {1.7754440758072034, -0.1636695617163607, -0.16700139046489407, 1.1304935171635426, -1.6244319792085298, 0.3679608001171646, -1.3206735149583735, 2.1356836476686603, -1.6603173296639453, -1.2644756073862728, -0.8734929784499217, 0.23325611571251018, -1.5402402693396802, -1.9016608309945635, 1.2706463464440965, 1.058326898182374, -1.032197162186126, -0.10449403093266925, -0.3107042756786274, -0.19565311953888356, -1.0608424378683474, 0.9182698115464852, -1.13279127850568, 1.832086363515992, -0.26432010781738274, -1.1767027123163312, 1.3254432534007021, 0.30542178468394154, 0.9615293591924705, -1.24762051972579, 1.1777363499994284, -0.5565186555178058},
    {2.493264011039835, 0.9497983398971297, 1.8066605429462357, -0.89633875466352, -1.2688343980011365, -0.7229532712713649, 0.10631229168521278, -0.42101295030980024, -0.9279299656457766, 0.45933012367090686, 1.471341154695705, -1.3802760046858733, 0.13768187719292424, 0.9898174373735334, 0.5135096442329906, 2.378044911279297, 1.300854406222766, 0.8460570781945075, 2.0965533486990586, 0.7593124433095177, 1.5654207004895537, 0.6415492672827019, -0.6677661231171722, 0.45136942243185907, 0.03903929154654847, 1.0036704472761733, 0.3278800948761803, -0.7737629135951894, -0.6936072081025392, 2.58294503942547, 1.1188564196011856, 0.17295944326774595},
    {0.494341356156863, 0.4992246480457643, 0.923547350841069, -0.7965852298792652, -1.9672574280733768, -0.8532636682536299, -1.577413094765278, -1.6043717565851965, -0.7056948382174171, 0.7933142773377012, 1.2889598833843905, -2.272808090910318, 1.445885543672938, 0.44613776911125164, 0.08428641435897176, -0.9531546274589143, 0.23605302396477226, -1.6124834447425442, 1.643311345046503, 0.7447342540062281, 0.17975204564356473, -1.6884668315049054, -1.722248591599701, 1.3534858807131491, -0.016378784618958617, -2.237318138754159, 1.6176304680355753, -0.968134400850157, 0.46454978267269803, 2.1380111947519658, -0.20046881580126688, -0.4028560399371966},
    {-1.6182258852754996, 0.18690065933889682, -0.4390587211887712, -1.5366616196628533, 0.933398376125627, 0.8318852454553575, -2.058592190896088, 1.2894059643404705, -0.07743922515202864, 0.32459529539389953, -0.9539153305157997, 0.5789216773285669, 1.756567863251143, -0.5162451662492509, -0.7918608456751838, -0.16608286867885463, -1.5963501350099745, 0.6717664276790375, 0.8229244500511608, -1.2487360835315917, 1.011734954636594, -0.9270489433302795, 0.15260934615721117, 0.8182727018422667, -1.7911689483027817, -1.9000000150892278, -0.5085881160749351, -0.5735905519312453, -0.14399229581796633, -0.2779407451494848, 0.138985027990249, 0.78530748046779},
    {-0.11592911900370997, 0.32104977661475215, 0.752690316189879, -2.0297294555484644, 1.5962438948585305, -0.10575867113142817, -1.6537772360493248, 0.513623467053047, 0.8932871256291546, 0.25584545137493336, -0.20901280352154494, 1.153951612175292, -1.2467335181992363, -0.16215468602325955, 0.3059689688604153, -0.5132054881616231, -1.7172396435132968, -1.0170896328656152, 0.7089157122744935, -0.39626592799519145, 1.1945949322524294, 0.38168330984582743, 0.6197657916914242, -2.0369106019759755, -2.2541013773334337, 1.3243871374861302, -2.281541108234939, -1.9495428196151345, -0.9809251038979501, -0.06408851033900402, -0.940516276452534, 0.4890151322490965},
    {-1.090514021133405, -0.8785939208993926, 1.6375996009523575, 0.16179859889530593, 1.5399798165114749, 1.4064180778077753, 0.1664856710062161, 1.199760404980946, -0.6810159259631207, -0.5205106664557078, -1.0853107416065018, 0.7502693465836325, -0.12903690081625785, 1.7486128711834144, 1.7945669565465583, 0.9565084484807199, 1.0698519854838155, -1.0570558871863944, -0.23570855275027358, -0.4689539374757364, -1.5106298757971082, -0.23991719343189807, -0.9371216478516305, -0.11613347957723895, -0.3060530290526334, 0.3983535544019902, -0.19624535469666776, -0.5910519665868184, 0.047474609551640894, 0.2257629152617467, -1.1457370349388745, 1.7551823696228406},
    {1.5800111516515785, 1.0715051279494678, 0.9100917013795883, 0.7212748283603704, -0.5297430389326002, 0.1729541734091942, 1.8802283466132836, 1.4309842014685334, 1.3886138399390533, 0.5983296299084786, 1.6754890961898439, -1.2327590554718697, 0.8035947872937121, 0.9926046056270257, -0.5551920231450083, 1.7982566906159023, 1.4559333126082623, 2.1777223484039037, 1.1018538087805534, -1.0920401018328099, -0.039292418740957846, 0.5276599433606256, 0.7339192624737061, -0.6012380276206392, 1.6479467619056074, 2.6774067439761033, 0.20871003498984286, 1.8184551271292941, 0.7341588049150414, -1.64686799064206, 0.22456029046523163, 0.9692873181517205},
    {-0.0864744493576489, 0.27088707283942326, -0.41592298386993726, -0.5969699729896542, 0.02849357202286037, -1.832716786757409, -0.8580166577630379, -1.6568961992759677, -0.5163642095677395, -0.6838218260521993, -1.19820846805972, 1.2206896346481042, 0.21546468986805442, 0.3027050879329756, 0.0510300317596882, -1.1627438593508028, 0.985742559538617, -0.14087866166877427, -1.2303495084174634, -0.8091301055460032, 0.7635267660923456, -1.9091130953457196, 0.9044826138784176, -0.7244693117739305, -1.812755445474216, 1.8120555723568268, 0.2674106940929703, 1.1200359697659983, -1.9785536404599442, -0.47092626819702166, 1.1320813279349626, -0.0642122183149259},
    {-2.012512727214044, 0.25409700841261845, -1.06967167452486, 0.5995933869624948, 0.6502623193237891, 1.3243047184385115, -1.3244741990583468, 1.0326643659107984, -0.8682200639334976, 0.18699425666583352, -1.6417783257621978, 0.5517293775032528, 1.6932765743110332, 0.5520396175840114, 1.2345008668198083, -1.6090767588266979, -1.7254304745215299, -1.6413885049388002, -0.5931396450437553, 1.7841366914665895, -0.0017414166395209442, 0.6109045832040161, -0.7810869417364494, 1.039546094597196, -0.49953587799026705, -2.4694210010628765, 1.1406398858332827, -1.2131685031779367, -1.6096594850525654, -0.7356452157074541, -0.8002477246395789, 0.6038037570464271},
    {0.6885984680910906, -0.7713699940174058, -0.1343221894433742, 0.754858979527131, -0.5884410105773656, -0.46879456149398535, 0.941622526925344, -0.8978043805173304, 0.1997941591821144, -0.892997061421692, 0.9905521206433106, -1.975840757726871, -0.43760342782988115, 0.9932576082728184, -0.3707213704218665, -0.9648755233398225, 0.5311377156099485, -0.6006515786558465, 0.33136034455779817, -0.7107700762804967, -2.4467117337194004, -1.8823020554707612, 0.27869550225622025, 1.1757922272379413, 0.31155599204171525, -3.152682435365478, 1.281767679365068, 0.6050501617388142, -0.8414620014004874, -1.2545047200192476, -0.2880278990133204, -3.131634512581565},
    {1.2555696435377772, 1.5023892460134747, 0.23884516280639825, -1.0286367056388792, -0.9447099137338788, 0.5257764707145272, 0.954572093266086, 0.7964848481297826, 0.0625233307352882, 1.7889480804550384, 0.4695386086362501, -0.6251033441224835, 0.6110474797637027, 1.320156977747894, 1.6674855708378555, 1.672596300514066, 1.2586323005221367, 1.839143632802314, -0.5736133152688663, -0.196483237031438, 0.5406724653938084, 0.0986304077830768, -1.4110302221551938, 0.8943516835633426, -0.9475898247469084, 1.290837314558323, -0.7154889671889854, 1.378081899092993, 0.2695683300294665, 0.0439097662369562, 0.3330107469591372, 0.30824472398817593},
    {-0.29102228848440487, 0.4207110715279542, 0.48211369778045904, 0.5058469701811291, -1.6620679742217175, -1.3952719251679955, 0.8719184166398378, 1.1869694306682148, -1.5808369668025943, 0.17212835542900398, -1.5391472542763476, -0.053094072413547036, 0.015413435558604747, -0.07027195407110634, -0.31300430851581634, 1.4541062832783238, -1.9391183175308129, -0.9166969064390632, 1.6144796336784168, -2.0543176793518056, 0.38499316912784165, -0.8773887702871948, 0.3976567154760816, 0.8689457562721387, -0.5196361943711285, 1.4861688774641848, 0.777924706979906, -0.6037665007274161, -0.8060318698178688, -0.6484065975902691, -0.9470712269247659, 1.013221757549675},
    {2.1151180029301084, -1.8088351100709925, -0.2854086829720646, -0.9197034245278602, 1.4064281088961184, 0.2967745477928671, 1.200822381425035, 0.6325139487132396, 1.1175803547844512, 1.8393794550909806, 0.9234346815553484, -2.2948709087201324, 0.46335753137085833, 0.15365453660587677, -1.7113344599015539, 0.990637890062769, 0.5383879239927409, -1.7383826482740283, 0.8681285223780747, -0.7811928689685416, 0.5263157563717554, 0.1696909891837071, -1.3507735911274157, 0.5838119544487163, -0.5720399014657489, 1.9867547726326134, 1.649416645259449, 0.14818521808186313, 0.19014978272587776, -1.1894638718781243, -0.8292116754015467, 0.5323710282159917},
    {-4.726388448454295, -4.335991347074472, -4.867316615978232, 0.8565231327929997, -5.877922572953755, -4.294344053903708, -1.2426343563885796, -4.435151370906813, -6.970542061527035, -6.164665529062978, -2.6715852156177706, -2.0693071121386355, -0.0016394242858053507, -5.772565480882765, -3.85616052822099, -5.279605710642486, -1.4943331218179758, -6.0509832813145605, -2.5747154281401143, 0.19872200784287017, -3.06860301409834, -3.9854194574592072, -5.867223282673747, -0.47780580999178435, -3.6491181835508475, -3.5930449995514766, -4.412832273402883, -1.852363425327828, -4.019656251478092, -1.104244451775794, -3.270787570824875, -4.889728453124074},
    {-4.919525804778428, -3.3923266342530503, -3.3194723466804623, 0.5418011768374589, -5.330941860998857, -4.54633600144889, -3.9015045253841385, -5.471137355682022, -6.20582641796288, -5.3397930964432945, -4.038597895422361, -3.155889402528513, 1.5020848382767995, -5.152006752288725, -2.6001550417656225, -4.3183430613271385, -1.1857746050980957, -5.9042467518240915, -3.4973232686249793, -0.165490697118048, -3.371627479734346, -4.222950167871133, -5.191697161780021, -1.547931604758788, -5.895043496970853, -5.382071926997613, -4.354208920251211, -3.0198445347146237, -3.855876288523142, -2.639518449722275, -2.7958658250135278, -5.0851868855344735},
    {-1.5648858014827258, -0.7327890703001401, -1.046364986421406, 0.053603574208443645, -2.2181227975855364, 0.17161895021922885, 0.47586126313645166, -2.96045149045987, -2.095454145777099, -1.8960667997396985, -3.363557620408245, -0.7668268183665246, 1.2505472403524576, -1.655182949779118, -2.411474077109626, -2.137435540086493, -1.0895709175036121, -4.211593608186801, -2.535342222596342, 0.9442898169899328, -1.2302706883554202, -2.073172471142104, -2.1384367075250674, 0.5040295895954265, -3.526595882356136, 0.2771220138261692, -1.9684746560940598, 0.3382913121465819, -0.05620281987894188, -1.5553041411543016, -3.781467484284182, -3.2778645620322515},
    {-1.507911728434418, -1.3435574616723358, -1.6956907974491016, 1.9637875613061917, -0.5889495529636961, 1.0193390008499927, 0.8793520823775512, -0.5871264114673271, -2.0796356937867366, 0.3939476602835761, -1.751002818755047, -1.6919258059717772, 0.1765805196334487, -1.6788785644821633, -1.2599940735344468, 0.9472141837926714, -0.3389665644913773, -0.7468993573520396, -1.4207762313584797, 1.9100370944038279, -0.3742420852016805, -0.5739429612504185, -1.7463119830958345, -1.337154022521233, -1.7508102122602585, -0.6397527348018022, -0.9601997978659331, 1.8767423458912627, 0.6038971358609958, 0.3897242780027452, -0.39696789658393833, 0.32236424124313406},
    {-2.462647156642637, 0.38913695715017105, -1.4489433853539855, 1.6804825886279833, -0.8764263973147689, 0.8447844415741521, -1.7085435111534204, -2.262931684930019, -3.292917683003697, -1.2402599608136164, -2.7628272279046127, 0.2795306423712778, 0.30400474830028146, -0.3193508970036101, -0.1927817917068173, -2.5312089261598065, 1.1048586388410222, -1.5118754195596944, -1.6071296985612251, 2.8746733285514527, -1.0834752980889442, -1.615020065750944, -0.7779245429441073, 1.6541608149486495, 0.4259423515143222, -1.9600483567450073, -1.0135996847608466, -1.4249863436320365, -2.001079446854523, 0.21457638394649298, -1.72600566618395, 0.41585625443834834},
    {-1.6756678816679427, -2.2824888666896785, -1.4373490070023993, -0.8775461630490197, -0.1251618942007704, -1.6586861982930532, 0.2438359975070388, -1.9377672910976058, -1.6542927496303483, -0.27630695080070095, 0.3261411065284438, -2.288599568261531, 1.6881024927081016, -0.0752307950310223, -0.6442047664634889, -1.7621717874908034, 0.9584128259860236, -1.7618757133564587, -0.9655491032715828, 1.756136865337467, 1.5886904671075899, -1.0500145085127908, 0.16674663430826336, -2.706921379656868, 0.03610638789072468, 0.5419638766130588, -3.062787520387756, -0.031215202661605667, -0.9896223787260083, 0.985911240677534, -2.9120281503951144, -1.3802179480720573},
    {1.082180339658208, -0.8325133628500351, 2.044894953070136, -1.281705122370006, 0.2243360012087954, -1.0392746292283852, -1.1813762641184768, 1.114908729471463, -1.182737940874859, -2.00158087538088, 0.25252781858279777, -1.9876521134371632, 0.013764400265202635, 1.130306725489957, 0.5925404718830387, 1.7902517156543152, 2.3258409765937937, -1.2468162136243353, -0.8504409025768359, 1.5894864074694504, 0.28888352417973656, 1.5255691388525305, -1.0763935973603251, -1.4892888064739043, -0.11821474140948685, 0.10892369586172314, 0.1353236292642868, 0.28910528346694003, -1.4092728422242402, -0.4189920486841319, 1.3675366367899857, 1.0126555050114254},
    {0.2465224941715598, -3.0810058007467664, 0.553377786473431, 0.737519341063895, 0.622812086483315, -1.418314098088395, -1.0422279803651384, 2.078275890902595, -1.9967978409244516, 0.40092884805246704, -0.5631430360547488, 0.04018402075455153, 0.8216095896138601, -1.2870067818398185, -2.0093756209092573, 0.6496768341399459, -0.013288886048713786, -1.7572503453747126, -1.5640259581002613, 0.5699038461368899, 0.06779462945329713, 0.11910555339203527, -2.7336677785426895, -0.7032330492494111, -0.07742298749267995, 0.8169003759721695, 1.049188444287063, -0.9776608049182214, -1.7386114936800012, -0.14411178829350055, -0.29176264259347684, 1.373254956786865},
    {-1.398896440736594, -1.5878105001008587, -1.6763254243563201, -0.31280157659157315, -2.0987272507649015, -2.1610624271830057, 0.16004360140335597, -0.8229922696290931, -3.143867729160308, -3.2100935573728573, 0.49833979540282825, -2.13758287593265, 0.878913306129847, -1.6364013962901884, -0.06625199764830779, -0.14507954170524756, -1.948515561616377, -2.24885675585161, -2.4365632611919494, 0.028039017456930757, 0.6563270836148436, -2.4315956684287583, -2.9917876710493174, -1.5751994514946566, -2.639253203220136, -0.048754205784849736, 0.9043857309551571, 0.7443102255922794, -0.6192317582344508, 1.542737917884133, 0.622765587657055, -2.6132518543930425},
    {-1.5075283411871574, 0.45619461053382854, -0.5458579887522077, -0.010086849311996335, -1.7421164031902936, -0.21635372997722607, -0.33417684636989353, -0.8509628159667394, 0.6111922024293205, -2.1379341667568967, 1.098196669935273, -0.5180537450607683, -0.23900711615447542, -0.7979151708147589, -0.763955568189858, -1.1054477511678351, -2.4416410189633986, 1.0011911399929443, -1.1025916746842424, 0.5020842991169611, -0.05837487076584618, -0.5307524978795308, -0.21407825152769708, -1.1804031792032215, -2.0443494524823023, 0.25928916586200695, 1.245622484858275, 1.1621641129113807, 1.8004723580193118, -1.6740547365589244, -2.101222758465092, -1.1821730559891683},
    {-0.9424389211406892, -1.704769894439733, -1.8438707432698949, 0.2583541584254878, 1.1293295201853455, 0.4218609304931041, 2.2059854719714758, -1.852730343275556, 1.5647325528578762, -1.302448618056257, 0.6796285588600947, 1.643604376234272, 2.6811330844970476, 0.8293317879060608, -0.4658682648907033, -0.10843362665902924, 1.6795146654133435, -1.2376725263034634, -1.115812835061128, -0.6856411077062726, -1.1312526072996325, -2.739331366371546, -1.8273567724843767, -0.3613815161912871, -0.8628797821372637, -0.3268091357222336, -1.6176972681669701, 0.34402916358524244, 0.7884018935164661, 0.38346281707396995, -1.2003814060711595, -0.3260793181257922},
    {-1.498042560685487, -1.5456499055207802, -0.42520870619456086, 2.460781023825607, 1.6808179489310435, -0.6363396268461796, -0.7446729645964241, 0.8337206972029075, -2.5525963157943194, 0.7672571280858956, -1.6641132795221218, 0.04167440297555869, 0.8944651774496981, -1.1807069507171408, 0.7302491878930353, 0.5124969158565746, 0.14300420328915953, -1.056561587256383, -0.21186514172781126, 0.21602252277782166, -1.6626646706415766, 0.7680011840766027, 1.487086696660305, 0.6887904277002138, -1.121309334612814, -0.07534960978475762, -1.5244112936257586, 0.042897830813055815, -0.7865521440540231, -2.2467884476936186, -0.1288162931724122, 1.4199000323176854},
    {-0.2777161764636267, -2.547265616407857, 0.16833435066190705, -0.360546676695184, -0.8443791081210896, -2.0408152037478353, -1.680719910781023, -0.16962305810498102, -0.035170546546908536, -1.964515824648567, -1.9199069817255063, -0.8640783931588985, -0.5355844768135571, -0.8241805679366965, -0.3476673965855422, 0.5476048286850412, -0.33532696552589825, -0.30952631155889454, -1.5960096461973674, 0.4529861743363117, 1.0428324020657749, -0.07013239136002006, -2.276797782932865, 0.5376616236596075, -1.1762851764373083, -2.446039267122468, 1.0262795443833792, 0.5319514788502482, -0.6258932981717887, -0.7852775064837505, -0.005757630722780295, -0.182921778518639},
    {1.1756081681674155, -1.499972422685685, 0.9362073556040746, -1.8214621472070534, 0.8518555560565216, -0.674016574302814, -1.987527220479008, -0.3634667149978288, -1.6950893984568138, -1.621431159061616, -0.8744857839321852, -1.2266682930227568, 1.2316291194295874, 0.32568396938671873, -1.4352629953239397, 1.7561083542222908, -0.36424220242462635, -2.128836898081808, 0.4017303046390814, 1.1975989175664967, -1.1247624738672277, -0.14928916672310166, -1.6498713975908734, -0.9175005213514564, -2.752601348749858, 0.12650260978399794, 2.131056498300021, 0.03424174820789166, -1.484938622518911, 1.2430863068615512, 0.7925491987394181, -0.4298019611019353},
    {-0.05641627071819057, -2.09037593797115, 0.9502513363158904, -1.0256517675415118, -1.1362927504763034, 0.46905149139249036, 0.9609644007718455, 2.0991814544191305, 0.7399541872701355, -0.7020609855105664, -1.592918809731826, 1.52492139433629, -0.831428329670412, -1.9115129176115988, -0.8832676389387791, -0.8853840296648483, -1.126620236064388, 0.02582802800615051, 0.4742080084585333, 1.403606891964859, 0.9726551117016995, 1.5479935410917005, -2.0694347276556853, -1.3105520830956743, -2.1524293484108226, 1.7971878664838707, 0.7821832596401461, 0.9399863051841143, 1.8213312459681996, -0.8137304462640754, -1.6115054101533623, -0.07925996783912755},
    {-0.6698890332850391, -0.6862878469598817, -1.4750763183456248, 0.5575944220511289, -1.6093394118181343, -0.026424582301737724, -1.0953925231362716, -1.7672121112131538, -0.05168276354559206, -2.9314830570446526, -2.107434471653068, -1.7962150327271265, -0.023354481994574513, 0.6808538298390139, 0.7607496073302653, -0.21025987753142816, -1.0683341598355474, -2.4483565218582655, -0.2687911272202214, 1.7350719803191483, -0.6947720030393713, -1.990515236341477, -1.9191276170619198, -0.790343461146529, -0.6407808675791629, 1.3119871870761124, 0.16700434833629732, -0.16871685111527115, -1.992169480532533, -1.2192097163515052, -0.5744588983518432, -0.3394776935063055},
    {-1.9103175682446358, -0.5428812815845325, -0.02173315190155613, 0.524188526563499, -0.5447007363073986, -1.3117395310136446, -1.6880896674314136, -0.9410286409244752, -0.3272739464318965, -0.5438063583912643, 0.38875523671841405, -1.4496453821245896, 0.14926494893908632, 0.20021985688840369, -2.450063129330179, -3.2103229544290874, 0.3316940588032474, -1.1769309881145793, -0.37517610549559727, -0.09755248723584761, -1.3129057853327954, 0.48420407605641747, -1.4867524129387115, -2.793857094990007, 0.7271338076552608, 0.8275452493203638, -1.7475179888767878, -0.2629045789164696, -1.015829029766258, -0.2595650991987594, -2.033798286576013, 0.5719691478620439},
    {-0.7249837061717489, -1.339022498412693, 0.3934697863150558, 2.7898037896689427, -1.69441268014843, -1.722130316753323, 0.142056902803971, -1.1061503361622569, 1.6980100666650353, -1.3514687930547822, -0.8211973448545821, 1.0836774299659224, 1.4242467007732684, 0.15724713332416485, 0.754901943295606, 1.1737668753401094, -0.3504574017467352, -2.259446309266423, -1.2667897350531985, 1.1404401426591582, -2.3549004550817902, -1.888305209239905, -1.1964493116289951, -0.06875079670124717, 1.342565448290887, -1.4854094046409956, 1.6601692630331686, -0.15119128602061543, -1.1078139659774622, 1.2294700244746313, 1.1214191022680073, -2.036829926647831},
    {1.3607121069092196, -0.1194658662354697, -0.9236526620392101, 1.0829107923995966, 0.4746532305571806, 0.5129824256620874, -1.2547928475125343, -0.9856610650622826, 0.5546045176172325, 1.3663960141033507, -1.705784477537254, -0.9006868407751321, 0.8338488139346458, -0.049000923503896704, -0.33297151159641064, -0.45644219893891685, -0.8492956244103771, 1.5371530194235687, 1.6029190875502364, 1.979835385712221, -0.9063385019177739, -1.2682495387067028, 0.49137257429400644, 1.918214923324672, 0.2767777903007107, -1.2276871781424354, 1.159569274642975, -1.1337929771419442, 1.181708993409539, -1.019219824628599, -0.2968292267368373, -1.425489862305926},
    {-1.827070519058162, 1.351982971086926, -1.56444951575933, -0.11221657478391789, -0.706163777744952, -1.6905419857415367, 1.634704690774841, -3.0783519588683634, -2.0734792049278914, 1.791864124764237, -0.8503833162055473, -3.057460426684911, 0.2919299222624785, 1.4234565185166228, -1.6341793450048108, -1.2519668663218555, 0.6739009694844862, -1.4019834150452584, -2.5987660577430725, -1.7097221931492435, -0.47968120834507816, -1.6573390529274885, -1.8793040498301692, -1.1769703018248199, -0.0677347769549895, 0.8618564620636084, -1.0314349121662783, -0.35809367760471444, 0.6333267028063463, 1.4713465035219013, -1.081269492953306, 0.5888535106443602},
    {0.12799294652500226, -0.11391603796154734, -1.796228299458558, -0.8411729203045584, 0.34497062995779626, 0.8068940075527475, 1.4169026123457293, -1.8895710294619703, -1.2257572079553576, 0.6895741775700418, -0.25859044553580335, 0.18696937740694528, -0.8978383155685525, -0.09792506831901186, -2.626536781890861, 0.5675090020438123, 1.4653069681718303, 1.6472724193868338, -1.9371463305153085, -0.9057268931481479, -1.3839824158255614, 0.9156578615315636, 0.739032835135798, 1.7844123119544462, 1.8178340012571905, -1.9522152415255754, -0.7388268089469846, -0.02220138744734624, 2.0724175782223466, -0.950809916418847, 1.3756346778167772, -2.3283585744272877},
    {2.013280573340752, 0.647137099046873, -0.2622924816862803, 0.12383617456429587, 0.06321770186804868, 0.3853203571916578, -0.12010312670432378, 0.9035264948779685, -1.9258443789279902, 1.0967063914037978, 0.9122253191260157, -0.39317391874424745, 1.0587910794192734, 1.63051334070442, -0.15466447421256888, -1.0772962450686219, 0.6670333467032692, -0.7074424206415374, -0.5798124588227237, 1.6689416543243099, 0.7052729263768982, 0.25119573524961214, 0.2266354436603689, 2.060213276748505, 0.8623367787374606, 0.5293878139610324, -0.29305498582134426, 2.656139401057707, 1.5443585327317564, 1.9078129181154857, 1.850177299281942, 0.7514646092809518},
    {-0.19985381033228689, 1.0700631019702584, -0.7273823013422765, -0.96234215108319, -1.3479305843701463, 2.3276302516826632, 1.1320660357426888, 0.36813872514852714, 0.37066076524758546, -1.2006340561123685, 0.4754012100178119, -2.0455025077715754, 2.3953709766893647, 0.7743869493654206, -0.5639438949023758, -1.3996258351694681, 0.621201002817878, -1.3171382545412123, 0.24149071045818174, 1.4093475343749762, 0.681480329607541, -1.0703332088426558, -1.0976109699567136, 0.8831642798884395, -0.8496864692689837, 1.2357616456595606, 0.7468699650637931, 1.467721346182922, 1.779340889868701, -1.5548643969851892, 0.46374803005297743, 2.5208875390395327},
    {-0.12024064076100183, 0.9061083451215448, 0.5705136730791885, -0.7693333638109247, 0.14265419369611218, 0.7456808540661565, 0.02259606476416326, 1.8162357066896504, -0.3558511639286506, 1.5656916679371191, -0.4287272357925161, -0.3992093910069984, -0.8534124791679494, -1.7718798851206623, -1.4695472103947178, 0.9377185102464053, -0.8400383110855725, -2.6182375380171434, 0.3822725185557369, -1.069456051144357, -0.747839166133974, 0.7799654589703836, -1.0904542144689915, -0.9749299161959586, -1.1830318711410754, 0.12823982813603108, 0.6407154091971149, -0.725482977903443, 2.0381024007422397, -0.9058136078396696, -0.7574468563598723, 1.906791821045412},
    {0.28034866131177627, -1.264814155961987, 1.2388433719984469, -2.65620026555171, -0.5784167411508726, 1.4677519857423504, -1.4833694610752874, 1.2945967591820668, -1.7013618013042533, -1.0904754216655175, -0.30651992132534045, 0.6595656955231576, -0.9229132752514757, -1.6090020705269659, -0.24921581350076952, -1.7680849262292073, 0.5369424153953526, -2.523110238199575, -1.5058608177637172, 0.6714864888113843, -2.0904261152356405, -1.7942628262320095, -2.699879508214359, 0.2814739996881676, -0.9064096225829372, 0.9745391724152483, 1.4237664527320006, -1.4402161313860424, 1.123809079395137, -2.3866971219839312, 0.14833428234595267, -1.6271645102863592},
    {1.4509616110057562, -1.1676093296144838, 0.9755717220083812, -1.0698808298087807, 1.6208452808535774, -1.0057179274792838, -0.35940676978447367, -0.7627819772274778, 0.1640192457214726, -2.1178208748187872, 0.9460007564888893, -0.0080560640974773, -0.4453603216467847, 1.8808989218045935, 0.11621202065182762, 0.5934125478035571, 1.511811773303529, -1.6130406835780209, 0.8184909557366032, 1.5312361466173807, 0.6322047254248366, 0.43458075403405433, -0.9922051803455652, 0.44714977680910756, 1.1417568785143677, 1.780642737387636, 0.039927974181343674, -1.88506659469619, 0.7655976965582162, -2.3086522547573107, -0.23537661664007864, -0.1542417116158823},
    {-0.8114000496970406, -0.18949024140902965, 0.36921558928373316, -0.6551210478965072, -2.788535004862087, 0.3213717479985738, 0.4735422221512004, -0.5075379628842925, -1.9303928816552207, -0.9672936340046918, -1.3046984766267906, -2.0631174755603414, 0.6913754711375139, -1.1210536780919234, 1.7972305797109478, 1.488202203631323, -1.1816815036878907, -1.349988814728166, 0.3054898445268712, -0.6452171260991167, 1.1961526650237075, -1.8915788036632102, -2.3750673327899094, -2.1570653725906777, 0.38905392492234164, -0.6252620350400628, -0.9102279886579849, 1.5481682208341183, 1.5680975665045391, -1.9716003715732353, 0.8276403959310762, -1.9569184870338137},
    {2.0327787312526713, 0.4208500954820434, 1.2803902461686338, -0.48424354491661364, 2.2528357688530285, 0.5785864014403423, 0.043244994806614964, 0.894649592708075, 1.5075387043758306, -1.3516620295513877, -1.6587463643408582, 1.7027837161869093, -1.1776024727469945, -0.49983875166196906, -1.243313763472151, 0.09913849499045031, 2.6442523979107957, 0.012505308716587265, -1.3794229003999767, 0.33709367317409616, -0.0027071013247157625, -1.6006249825373693, -0.439765750041494, -0.8784374334019848, -0.2322465079282713, 2.276801766336509, -1.2642521676528857, 1.974383101102593, -1.1753023192098386, -0.46461889810284496, 1.9725272354530825, -0.1464044553352182},
    {0.07794966629331522, 0.4071168176515829, -1.4736106274474274, -0.4770589801008679, -2.702456252351722, 0.5930097382696987, -1.2434468430644379, -0.32492107754624505, -0.28535677985282887, -1.4970764586300016, 0.42713278362559853, 1.301085001867236, -0.5700977913535199, -0.7013697698612976, 1.4530988457401621, -1.460282662711439, 0.5573288945258078, 0.2455117866056149, -2.2078149687733593, 1.5046500819429602, -2.0625375765901803, 1.030169726946595, 0.08694302242506574, 1.2855506000888595, -1.7415617702243917, -0.9791617309898554, 1.9588892067666646, -1.1730968433621587, -0.6371848959452693, -2.0683354555947964, 1.4761928199765362, -0.6073568904605506},
    {-0.815870691307961, -1.4957265572537215, 0.395739280343963, 0.6254171598493232, 2.1063797947874487, -0.6858567574823239, 0.0932755809011005, 2.419000266949071, -0.18103850266420504, -0.37074307762395003, -1.2027125936132406, -1.8069147202170035, 0.8220943384900695, -0.3710904594052633, 1.1620192989303704, -0.9096221202013263, 0.7444223345623155, -0.31485845004234336, -1.4393666699755345, 2.4623895277918217, -1.7685760185010093, 0.36257574670563186, -1.1212593834336455, -1.266646604392115, -0.3059076485809426, -1.076618238431558, 2.8362365337510616, -1.3419873885655775, 0.5031817084425743, -1.6383926887317073, 0.6461020120365991, -0.29176561057081074}
};

static const float b1[32] = {8.063343207978463, 8.098615694942147, 8.218556151624368, 8.14987823883259, 8.075008695764927, 8.116681160574403, 7.0495971339172385, 8.343120985073881, 8.382900594120018, 7.94335483268099, 8.084461134432171, 8.068639509300956, 6.819209317180704, 8.40801526300441, 8.137778015408104, 8.320783521601196, 8.25660891432965, 8.64331665036144, 8.129009936633596, 8.035851017976846, 7.970831389493799, 8.043381459475563, 7.516072962217275, 8.12386872288573, 8.300027495763624, 8.47025130262414, 8.458221891308161, 8.023260404465642, 7.806363761221897, 8.310988566768208, 7.9599178060123315, 8.46862968245835};

static const float w2[32][16] = {
    {4.912337761225693, 6.858231706571278, 6.434705388963627, 5.004102228020589, 5.960966769651652, 6.631051267751617, 6.216062038376063, 0.4716511139152292, 6.5996274750422526, 6.511193893228367, 5.400767149207316, 5.58273883929664, 7.221953013583437, 6.234841874972784, 5.712888057891132, 5.772240011402771},
    {4.025158818631857, 6.76647202049876, 7.198601478713711, 5.411424452792102, 5.496449709721986, 6.150610153542626, 5.781897097921712, 0.5388037148425935, 7.54022767595549, 6.474881565573755, 5.377002603814882, 6.052274179779995, 6.386756946684039, 7.323777396662397, 6.983434385351265, 6.56477120095074},
    {5.075254918007557, 5.817717748829941, 6.56242269447767, 6.1438534104813725, 6.047108418473736, 6.33191928264841, 6.36347037298477, -0.16829762928819647, 6.824100093523719, 6.2191908540307566, 5.970612152607279, 6.6375928023473, 7.112531737511084, 7.834703681160426, 6.782362729833827, 7.1128839430592015},
    {4.4297315246195454, 5.161612658289106, 6.4458288922246805, 6.112574129572862, 6.318413126706825, 6.4881441386667005, 6.416577083085596, -0.5005201012902688, 6.683519167332735, 7.589923645029748, 6.8759226033483545, 6.890173724469308, 7.75873058617981, 7.535848797366317, 6.144765742429944, 7.426225270468993},
    {4.490169125752981, 5.5667835073241925, 6.330188930669772, 5.623661167563477, 5.84799898917257, 6.5835709242455716, 6.619412868705481, -0.9338538596577524, 5.9470568339751075, 7.301786059996995, 5.458338833121011, 5.946652962550664, 6.274032445373287, 7.348554908897502, 6.73443160640922, 7.475421904144829},
    {3.869315836525282, 6.244355444247442, 5.755744314859577, 5.946558853314165, 5.709802054513916, 6.178242707169642, 6.173986078031391, 0.3217346876595465, 6.985718490112548, 7.134183882010722, 5.3366421980163725, 6.522954178268622, 7.192027263260564, 6.705592425417895, 6.9407670123850425, 6.288684781211865},
    {4.3443496555120165, 5.362995934668755, 5.907794225672612, 6.248983505332737, 6.180776456358969, 6.827603349259559, 6.654850420969573, -1.2144473658049166, 6.609766170962109, 6.191564911303379, 6.478483259709405, 5.330411489888876, 5.750123272514383, 5.9252439459266, 6.862808751152827, 6.045711444075958},
    {4.517623729786385, 6.759939679073106, 7.32841843550919, 6.8156919900445825, 5.606083726122921, 5.940048730661929, 5.835140153400684, 0.5654882839005383, 6.018059847248973, 7.117190864792007, 6.024837717178512, 6.072692095403249, 7.34180350216923, 7.037963369019075, 6.30674538819003, 8.019613641437365},
    {4.321642374421864, 5.736651692261123, 6.223724760246124, 6.270389245877997, 5.858726256370858, 6.633520513082119, 6.688454099124958, -0.025221829694944617, 7.78750252314589, 7.0193648354130485, 5.653300354508166, 5.510912139265539, 6.809705641908649, 6.232639254525547, 5.907644448899956, 7.268638945443999},
    {4.28272062038651, 6.6448845571029045, 7.138338160365095, 6.86149449963966, 5.555344654417151, 5.911856087937667, 6.56847318842778, -0.7306539499012283, 7.1735935179396995, 7.276369754090001, 5.621023595216863, 5.968205946604344, 7.3233251824379035, 5.906834586102795, 7.114947913410545, 6.778171850509679},
    {5.152977307525478, 6.604446641026538, 6.930709526619676, 6.888329099657099, 6.877415182708183, 7.228490958965769, 6.069715516025485, -0.35111738169687684, 7.162470128588856, 7.272593241809837, 6.968650765204718, 6.272402436473948, 7.1887903705006435, 6.806947670267263, 7.059827214940637, 6.293954838196649},
    {3.775704271991963, 6.507758233521726, 6.798566032093108, 6.237863055006573, 6.626361927596587, 6.258347539446272, 6.225060261047329, 0.07829090259292082, 5.804946678818328, 6.372637976255068, 5.469955884918585, 6.426489935323592, 7.0186144588953265, 7.081628946358601, 5.93724058738996, 6.8344413747697175},
    {5.221868001282349, 6.499645864798259, 6.7163490018311505, 4.89414212705908, 5.1382423147805305, 6.066303100546654, 5.664713936687946, -0.09432038766081123, 5.548095947798663, 5.9354636537586645, 5.90363542216066, 5.546341291100512, 5.802834907069737, 5.702001834026155, 5.51191684383926, 5.634298325251278},
    {5.446073707004869, 5.891175623684763, 7.478954282221023, 6.266905529893038, 6.3375457021230375, 6.653276588593589, 5.418873974406293, 0.22421313751510183, 6.230398640724547, 6.264383030565891, 5.905197680872738, 6.5652215023505445, 7.028290075547449, 6.1459395769650635, 7.023648468161481, 7.7089007997896815},
    {5.978977145069339, 5.710800794451827, 5.9619156094622925, 7.182413271638452, 5.505182359581163, 6.6106960682936124, 6.928171380106716, -0.9163064175207916, 6.390326640369696, 7.366427570498853, 5.709418303181681, 6.59221522493628, 7.467888497917537, 6.802771894572412, 7.535200425392154, 6.921523119624498},
    {4.9717211109126005, 6.105265266001215, 6.642937532860162, 5.8442479946608055, 7.053538849913526, 5.909981466148107, 6.816775978335486, 0.31745631084229614, 6.960068120279895, 6.715092995588348, 6.733409971779592, 5.634362066747907, 7.896361011725978, 7.702834463610214, 6.141776999469643, 6.864535129569794},
    {4.6896903739672275, 5.659131385345688, 7.145083138192754, 6.33057478216432, 6.425072366104541, 6.70412022305932, 5.588346511926564, 0.3540850463992158, 5.652586121900858, 7.385056026548592, 5.6991851353879595, 5.547968508343826, 7.658488262252503, 7.200569024499937, 5.80584955768345, 6.052779089611061},
    {5.278826850479065, 5.804119547093259, 5.826850484411337, 6.0300265120743815, 6.299148291652565, 5.881570838391998, 5.781439682529384, -0.6875795945070395, 7.142274309009323, 6.622441453311723, 6.626103521704218, 5.62047465341987, 7.146648644229676, 6.3943190740791405, 6.065917291932946, 6.971008400702186},
    {5.161162641270454, 5.658364704491076, 6.685650272104934, 6.185127779248065, 6.565422020732658, 5.67941086062653, 5.388662967849712, -0.44445068408897875, 5.692112087587168, 5.6517865270601115, 5.610300284354707, 5.4410738861184775, 6.953053597258622, 7.235854425761742, 5.682141645009984, 6.835275214689294},
    {4.20408233474379, 6.376309501471913, 7.336087935698288, 6.2956796312344245, 6.470770195703814, 7.118563024799486, 6.831886511591861, -0.16262463937242597, 7.539032868127356, 6.157051118595933, 7.187449852651448, 5.9757130789397435, 7.055930318585382, 7.437105028951071, 5.728591947127866, 5.949322596100848},
    {4.283423449089357, 5.553191196072464, 5.562765132881004, 6.228357767155093, 6.906831473714864, 6.496871891701949, 5.296884725478004, -0.8859392058188068, 6.867318008929263, 7.199464430002391, 6.138130722588803, 6.572868062630251, 5.920472972576774, 5.991613228233661, 6.5368069202891315, 6.52878318945379},
    {4.2796219548590155, 5.355615479507569, 7.229057843817228, 6.350344171273783, 5.774711346880058, 7.82907390569784, 6.58541348713964, -0.2332588422412404, 6.522751794520236, 7.49034741027534, 6.1110975267841345, 6.3334118856388715, 7.01921865965421, 6.463858929322934, 7.382680205884883, 6.470507195155935},
    {3.932414427357336, 6.461708080972613, 6.44834973315425, 6.356199077487045, 5.453781192327315, 6.850084072307474, 6.719700599493317, 0.5940113182472453, 5.796721044862276, 6.342413222281593, 6.444650607053561, 5.645677132365241, 5.924014968778988, 6.3515383786850155, 5.321387695212284, 7.037305275806839},
    {3.9924703505676353, 6.203857522572352, 5.763021692416606, 6.969358920634716, 5.687967737580926, 7.301532234392964, 5.775227064188769, -1.2575242665618909, 6.7585207241290055, 6.206731421225635, 6.895696367683029, 6.74715378493263, 6.726413412805761, 7.151859609192361, 7.308368633748147, 6.43443605581386},
    {4.429791398568032, 5.587560703974109, 6.763931445961309, 6.374573821130278, 5.998777466030024, 6.919137609007096, 6.812296147785787, 0.32912127504294236, 7.768278695943066, 6.612511382671407, 6.144598977482054, 6.770543000758866, 7.12499764886785, 7.218145169964296, 6.539767714771308, 7.0623952603338},
    {5.866323497196181, 6.7242958604371115, 6.650885438288472, 5.599851795354645, 6.159352270975913, 7.624084162150326, 6.105054002574477, -0.06976725142644824, 6.227758599869859, 7.397438797507517, 7.374811557651578, 5.3656073755733145, 7.504718462114274, 7.2754583987464345, 6.299871696533424, 7.192009564342534},
    {5.184469497800974, 5.933470292829229, 6.674094320719421, 5.979609575520226, 6.447173074162959, 7.168752083163408, 5.894114158302021, -0.44662845955399244, 6.48660489032529, 7.348448850356686, 6.990035216958843, 5.547075268896235, 6.683191711995314, 6.69974452114864, 7.002138844405642, 6.6074841383782035},
    {5.397174984159002, 6.172938808427697, 7.163138633091297, 6.309914419591648, 5.466051260418561, 7.4287135988906545, 5.221538797884128, -0.1987558179861908, 6.833054278292809, 6.966919005485592, 6.133623324346796, 6.250563835077661, 6.5777224742587865, 6.290813475852081, 5.600084543867567, 6.668260839991699},
    {4.477768919805343, 5.53317266300875, 7.410783714974127, 6.559484519814794, 5.277669096487809, 7.395469610077699, 6.8443780672434364, -0.673102725149421, 6.8433935057775885, 5.9492975342833025, 6.3159888503959465, 5.515291558470855, 6.366665225724809, 7.225298210385328, 6.714200482450927, 6.534459392283453},
    {5.456732505166944, 6.107841894096472, 5.581900658228155, 5.039485404352506, 5.171735903599321, 7.1378938675492645, 5.899639489684174, -1.1060860129241294, 6.740676950388217, 6.971247246855116, 5.7738346514584995, 6.346246708480908, 6.549112350542947, 5.619492756696987, 5.29689760907751, 7.4520026199466205},
    {4.761765108292172, 6.6972882257974, 7.436141970441179, 7.014867646710921, 7.354057969503971, 7.7546000972591385, 7.173051080689372, -0.934934897417235, 7.336024622342761, 6.186758656277518, 6.699785811789756, 6.818946566575548, 6.401877145935382, 7.592437334908342, 7.106125764677371, 7.707099645368346},
    {4.115096718973668, 6.038999056589366, 6.615384629470166, 6.067839566710953, 5.485748261025472, 6.690164068595962, 6.330633001787076, -0.4546235796129261, 7.633176804702139, 5.9310559534364256, 6.582247171593943, 6.098522754026267, 7.470454553881222, 7.673264357473862, 6.602524587357644, 6.722143966024223}
};

static const float b2[16] = {5.700178363958013, 6.671625058753591, 6.841992884088393, 6.598817260790733, 6.635090650808743, 7.137813855585918, 6.372173439500252, -0.4566630710185007, 7.247462808664264, 6.941361729730059, 7.168655612771254, 6.714286187421956, 7.267842574553836, 7.14258726181537, 6.912640356405229, 7.203003947317236};

static const float w3[16][12] = {
    {-3.4355073815147614, -2.7753803887655044, -3.0618709410438694, -3.1590076145794974, -3.483334588705529, -3.545061243253336, -4.4789315162817775, -2.7845529346153852, -3.0606140481647617, -4.230522887086376, -4.285674147021823, -2.691000404039505},
    {-4.055181292929863, -4.867958497537464, -3.7887132521100892, -3.903850658033962, -4.606591276569966, -5.276175347418987, -4.613828973512312, -4.977503214137528, -5.199956257002, -4.479273829795325, -4.123825510477241, -3.502615813069211},
    {-4.637401772824721, -6.199056373170417, -5.970764022804093, -4.2377492675431245, -5.442583185837651, -4.157635493817667, -5.498272732185074, -4.928385400311397, -4.049445819822366, -4.985305745876623, -4.587836641624252, -5.181642152022219},
    {-4.345678669091281, -4.319875734243949, -4.942149449720083, -4.636178917353069, -4.45002529281793, -3.472092095456871, -3.8420617349326363, -4.643330890400978, -3.687270771081579, -4.07596274921638, -5.691508762008743, -5.292963888219941},
    {-4.246583753636827, -3.9698789746033856, -4.29722467644398, -4.578025405863289, -4.4392285981671495, -4.880444856240907, -4.492920876667226, -4.943986462471061, -4.779864566888596, -3.710074008775144, -4.695906777180605, -4.228683459286114},
    {-5.188141548625163, -4.659592827125226, -5.5342389254547175, -5.202569664993094, -4.966066099277181, -5.326346783015864, -4.017729001247588, -4.171154191175633, -5.672748393899139, -5.467763603827423, -4.3513876876117354, -5.188291153547645},
    {-3.718217050087519, -4.7510417552744375, -4.076396249369455, -4.2161734865210265, -4.638314945450487, -5.587120524439296, -5.700066100801277, -4.427562735422808, -5.03359762386439, -4.798197218230278, -3.697820114693179, -4.122712244252334},
    {-0.027723482068877193, 0.4708312767135759, 0.208931526894843, 0.5841689041573241, 0.5383344683554577, 0.7368588023628699, -0.32298068599899793, -0.4436493168006693, -0.4024536136366977, 0.5930651209464503, -0.3964721392972061, 0.24988362334373307},
    {-5.348755302627211, -5.461752867761009, -4.605827949891073, -4.77801771986572, -4.062471656543959, -4.24914938348918, -5.792105988016104, -4.4564734154157355, -5.150284650290883, -4.233140733545266, -5.904787758864597, -5.293800845111551},
    {-5.144977867137804, -4.243745312726679, -4.8140790303702525, -5.90077181743464, -5.054776922358539, -5.0824310802408625, -4.248601372744025, -5.523378880984494, -4.017554741063389, -4.969500525766555, -4.1163871618935906, -5.203047099467792},
    {-4.50346493023697, -4.465599560678943, -3.6242581905111884, -4.627852334391769, -4.5027220998352675, -4.257163128590256, -3.7061410170736946, -4.577665652010371, -4.408477140029987, -4.474448141174399, -4.200402742413847, -5.000984200896543},
    {-4.9941572682014606, -4.352490769859081, -5.152788637103971, -4.370904257962469, -4.859275632276764, -4.0873381249558856, -4.726125487738589, -4.6206399752563225, -3.493118357260489, -3.7937204623576974, -3.7149072367556117, -5.130365289231679},
    {-4.215720949752637, -5.385762607319147, -5.517410408463343, -5.356450548333018, -3.84208594302064, -5.350438901511757, -5.617428301282435, -5.687507433578293, -5.424781383014442, -4.687184075081415, -4.877852581505095, -4.601701321951087},
    {-5.817888294673314, -4.190605283362837, -5.226505845352317, -5.112235384625292, -4.994435143094555, -4.950608688833281, -4.257259287926644, -4.067093197057572, -4.373097778951053, -5.511469359175602, -5.601115094922662, -4.725546851026472},
    {-4.609117004015676, -4.142518099588551, -4.344023735659454, -4.792841387175638, -5.032861076683319, -5.219954941692862, -5.014362708364092, -4.859985425329888, -5.431732465489893, -4.92427359439633, -4.385205280468254, -5.113492867022518},
    {-5.394564694469391, -5.695156297410054, -4.578593306603968, -4.635930208769851, -5.415944997845025, -4.4210970193473225, -4.090831334700184, -4.954445349970201, -5.8453909444445316, -5.440812488634189, -5.571354481386285, -4.292453959304757}
};

static const float b3[12] = {-3.4794155032889424, -2.8587437695017615, -3.3055337512409975, -3.000423723494112, -3.3018460626077846, -3.29936955965678, -3.602100604667072, -3.5425740423416108, -2.9217935621841344, -3.7997758872488685, -2.791536122475088, -3.2754631744458167};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
