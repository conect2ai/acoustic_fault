#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.0896798493406619, -4.348916953739698, -1.9549025089818326, -1.758086533923816, -0.4758831247870361, -0.8444335429377846, -2.7419602976953734, -4.183279262606572, -2.191385598398395, -2.0746631991627296, 1.129198181803506, -4.225311327769642, 1.2544873504850793, 2.0601314495909846, 1.586809991676698, -3.6093265772863674, 0.08848110447554998, 0.492834547756965, -3.379996546248196, 0.6876216986915807, 1.7620044965624067, -0.3279848130270155, 2.900704512792774, -2.800950660711413, -0.6735714406469876, 1.039287558773152, -0.16760349303654112, 0.4709960784858159, -1.593495434040486, 3.1578005425475117, -2.6637704188481752, -2.808114054276936},
    {-0.2664601179095108, 1.1682701554207544, -2.2006737316253786, -0.25906068094126367, -1.4663545620923288, -0.7921834111104519, 0.7480336540500984, 1.2988329089670667, 1.8561486834489223, 2.4742008868582324, 0.46943127444259397, 1.1781491886322266, -2.138456157215501, -1.4519670534923272, -0.9371945323020128, -0.3570056671550028, -0.5024131872497624, -2.0470825711157024, 2.2181826574105554, -3.4026702055292546, -2.146386786152472, -2.896958285381395, -1.5034377029294401, 1.595933315039045, 1.5388798381939202, -3.1828080831624193, -1.0129726329473643, -2.181904187758566, -1.5567958578991123, -1.0702675964217543, -1.5765093114824147, -0.5570937519396663},
    {5.17580718830302, 2.125803103438461, 4.1045618231475185, 4.666405861594806, 2.9840809032343043, 3.9940985221303644, 2.77804443267919, 1.2166424490125718, 3.026564948923879, 0.162312369180519, -0.48170995977945846, 4.14782194581128, 1.2506591842737647, 2.892296134289818, 1.7441442901666582, 4.21117247315606, 5.457761235171751, 2.3793835628054003, 4.33445294212326, 2.1168077801287475, 1.9707157127191974, 4.662229920657609, 0.6869995559018897, 0.2718261436821766, 1.3685806367649258, 3.545405842431634, 1.0718135167718061, 1.465364477238457, 4.506243482588539, 1.9090550808355402, 3.1244356215799267, 4.127092546485282},
    {0.4674914524125429, -0.7547409283535618, 2.974732647921461, 4.00530240323356, 0.6250165312649999, 1.6766982859422401, 2.0266260076018963, -0.03894537022533127, 1.2808472066078371, 2.584244702992648, 2.5223805651021456, 2.210365353712112, 3.351837696124036, -0.30100978268621303, 0.7335544656391046, 2.2589569188196403, 4.351779976993551, 1.1981428263657161, 1.5842463456565556, 4.27110068646068, 2.9513310967804958, 5.522757276109671, 0.6085077177569583, 3.1490372532532778, 2.0682708944003547, 5.009577460509501, 2.805297171414203, 1.1502361856814114, 4.4237155467649, 3.405307728337056, 4.219688471299678, 0.5788582224987073},
    {5.056332018973034, 1.5253387479334444, 1.8808012899532873, 2.584904011090117, 3.5632039487060663, 4.42517891842305, 4.281466672267459, 2.8094280802961666, 0.3937633315016574, -1.1568882319979037, -1.2642006888985076, 3.985770187831502, -0.1112699576130305, 0.8408025102218255, 1.2628236834840392, 4.918288753452194, 1.2299591375798844, 2.67363528296732, 3.686660530502112, 1.725604870413451, -0.6924643686709783, 3.2067435014805072, -1.8536343081065025, 0.5912882328668686, 1.185357084000678, 0.6635710518626402, 2.675905630432715, -1.7131241598888245, 1.3295239260704053, -0.8668324453831779, 3.1910623399039606, 4.022675300523747},
    {5.109995725535772, 3.4237508031791024, 2.604945065005209, 5.81806418722586, 4.516523793606247, 4.474303987529313, 5.7324637152392555, 4.4651837118675735, 0.9078161725794136, -2.091734106512099, -2.2767568378292014, 5.089648957341921, 1.8747267329812198, 1.1478631845019904, 0.09791556319394731, 5.614773044593731, 2.250999282594612, 1.478729796666168, 4.724753384806816, 2.2566485408062076, -1.3293399396014673, 3.7018659495252644, -3.1321793817595176, 0.8115760705855466, -1.7385910698923088, 0.6474894410946046, 1.3419820133026406, -0.25540317339662477, 4.0211617390421255, -0.6376291200733316, 1.126635407120276, 5.126817651154875},
    {4.981253013220559, 3.4152762785764468, 2.6324743642213644, 3.868496905345329, 4.205988247584399, 3.631242397601076, 5.40149421184428, 5.597551022213255, 1.227814236834862, -1.7570680825720817, 0.41833410613026434, 4.695361710371683, 2.265074805644878, 0.4760563339114012, 1.9271909814986317, 5.037084436395411, 3.8567250500365193, 1.0004967734001715, 3.9761993816131866, 2.2832035074547345, 0.6348682773339159, 4.206384965750686, -2.8871404611409166, 1.7843147046112267, 0.1107936956284156, 3.2838647208233946, 0.560881849893938, -0.6998141420137668, 4.90894622701948, -0.0946754804774198, 2.555447741408059, 3.330156948826797},
    {1.713828464741015, 0.1995352298456622, 2.530084439482585, 0.1692619882157209, 1.4760620760759098, 0.8737858132913028, 3.0683567233313913, 2.1977520669450916, 1.6780018144664661, -0.5331674882517408, 0.38318964769360225, 2.7350875881652925, 0.9636150593271108, -0.15843856468911963, 0.3257343694832137, 1.4542602200228378, 0.2727786156076221, -0.47819370432952557, 3.784160936592726, 1.7964385332060204, 2.224995422936274, 0.1655481560954856, 0.0627864173881495, 1.685905484727283, 2.591752571354644, -0.6306564610938972, 1.6511261268236768, -0.2234836978490663, 1.7759988058382863, 0.6562773730556158, 3.129301251225544, 1.437595385747833},
    {2.4145582754967663, 1.4716496058550512, 2.8142744342751804, 0.793069543982911, 1.1726413930676278, -0.42999802267082, 1.1898142314790356, 1.4352285634486446, 1.8589782076143013, 1.6648158409425646, -1.2466994027572795, 1.333828428602548, 1.146830308992465, 0.808547486439056, 0.3211534103320107, 2.6336952066320234, 0.09891062780475957, 2.218212076419391, 1.7980767003216072, -0.6410487753459687, -0.8544658729240414, 0.8908990366366883, 0.6283157184454459, -0.9164116323705332, -0.5032025237007082, -1.9683897122308636, 0.6807894042115445, -2.133370654690356, -0.0362208874445176, 1.270352584596431, 0.4784462279128149, 1.6260648803130975},
    {-2.540149442019375, -1.0283323605014, -3.6435500090629938, -2.9235595331774844, -2.9015118718262114, -1.2716965254243213, -0.8279132567612664, -0.90547943907255, -2.366055993965298, -1.7170151130199114, 1.4386044118495458, -1.22457874472857, -2.873480229864325, -0.7814539159590062, -1.252940069842829, -2.8783527385869507, -4.27314670613372, -0.8144067797301772, 0.579129170640702, -5.684799727683467, -0.9799699626919625, -4.34186136060612, -2.638047350122258, 1.9342656626939787, -0.12350148263457451, -4.32621798673935, -4.581481695665577, 0.8876004936930734, -4.105370414542024, -3.814743155764175, -3.2214549216947685, -0.3122204344644479},
    {-1.3756791202780485, 1.589529074210425, -1.6289040236979917, 1.5521479354714982, -2.0211172067639365, -0.7785988621146513, -0.0834561012901986, -0.8311653756181127, -1.0551765049226995, 1.0066000622522226, 1.8910945573240796, 0.9851202350465643, 1.6527749036659316, -2.113787116695806, 0.5015209509019498, -0.10848291910744882, -1.7851747142120216, 0.32105807257271735, 0.20168751909767677, -2.704510738264883, 0.1400230060339249, 1.220980675301141, -2.385329517441363, 2.3567665154359614, 0.9877600786333204, 0.1880146087942366, -2.502517911917155, 2.178665555676923, 1.529614957255584, -1.4774391627823995, 0.09826665764598254, 0.5817772531390517},
    {-1.9098372504554593, -0.9868309584779714, -0.3735806238429577, 0.40756291232308434, -2.285542991234274, -2.560901299881509, -1.938325015665293, -0.8280429478285967, 1.6797900152396483, 1.921992687708909, -0.8099318480040001, -0.843335798987273, -1.7607259730628644, 0.8887609530050319, 0.296444967776686, -2.0370498494228895, 0.1210409222925807, 0.973107451169769, -0.4531802454051813, -0.12305257707614248, 0.8547426418532045, 0.9319321464518255, 1.1058545646225255, -0.8393854375171909, 1.1033577321998957, -0.7593762436495919, -1.344639032682255, 0.3012126487064175, -0.23579562780633995, 0.9126578534348565, -0.6822135080877259, -0.2154316422580439},
    {2.014312540736475, 2.6193359582295352, 1.621243230419972, 1.1296941940474552, 1.2687154201466293, 1.1400450598938496, 1.1627303721031095, 0.31641591488513, 2.104245727651335, -0.3320410101472175, -0.36165004418876867, 2.4860565934085184, -2.311214150045141, -0.26925898786154767, 0.9231615447008001, 1.931573839135195, -0.3738705126417536, -1.0322815829370071, 2.564709439577905, -1.8001259794503335, -0.5708886070843284, -1.7805510513589866, -0.6708462905113614, 0.7278364181499267, 0.5049575879272787, -0.2611851977988439, -2.4626406715460405, -2.317230964993341, 0.5035688053741134, -1.4306172693677282, -1.8784213410234112, 2.9428305986115877},
    {-2.1181338967733936, 1.6646910802107107, -0.048742944529291954, 3.68258755563689, -2.62891971891336, -0.6129051085717983, -2.693240404133299, -0.9211733213464968, 1.8196922538065943, 2.6626404413239504, 0.49208898729110523, -0.5728917560336152, 2.9612808414097835, -2.3734682576051855, -0.5028758760021808, -1.6941399409252813, -0.05584872645231935, -0.8042575185901367, -1.8616537352338065, 1.6449506630438153, -1.4883523136113144, 2.6551586239687572, -1.1107983797693486, 1.9814004521616229, -1.9293004124717232, 1.8993666692410247, 1.8882468093824407, 1.3827486071348287, 2.623988598949519, 0.4133325773952275, 2.1051543500727177, -3.7803626216507897},
    {-2.3403551479032774, 1.760403752162436, 1.519221335900601, 2.1839456232330607, 0.5318512790594191, 0.8294029986304727, -0.5171737372745796, -1.396232187226421, 1.707357332003721, 0.4644131790354456, -1.813266944906947, -1.354295169600275, 3.7148541611428145, -1.3760365747508065, 0.09130494619230224, -1.1505774292020723, 0.158631492655141, -1.7437497794299515, -2.123163835821756, 4.0301799811256345, -1.0372120970293064, 4.771673732814256, -0.6582436391083386, -0.6010801490609818, -2.4266223153107447, 1.8575451938375562, 2.5724458417723293, -0.7662981688554344, 3.3682858924178984, 1.4586137621503459, -0.34907393133362463, -3.6069636323862118},
    {-1.74607295101487, 3.7717043094906435, 0.09583452769800098, -0.04501154530142568, 1.192063954340079, -1.2403894492537868, -0.11576238925864762, -0.6102909777570188, 1.1329876501009932, 1.496086578079629, -2.452318618416147, -1.222208063150431, -1.0145994548791542, -1.513025032190357, -0.9046209217235477, -0.15438430692064736, -3.222751659455652, -0.4604859692298721, -2.3434114013695413, 1.0957359914430214, -3.661654032969161, 1.2930314212738083, 0.8499683031183948, -2.0165685395733854, -3.0569222999985586, 0.5130574291527337, 2.238580244948774, -1.9700272770639746, 2.318886760654091, 0.10483220260810527, -1.1228485848886316, -3.012585202966196},
    {-1.9853929759574422, 1.3764391601740702, -0.612993079384654, 3.0317319755811414, -2.173240382258367, -0.4133109802122407, -0.352711266239548, 1.5266488826960214, 0.0875034212441457, 1.9502434646528313, 1.379557116010522, 0.6112331769851301, 2.510997816140524, -2.9866146081364335, 0.3861141950049341, -1.7564147286038443, 0.18111515811457796, -2.3480833111594994, -2.2288832816610835, 1.9401083136182644, 1.4443868480406805, 2.9716342580691903, -2.402397548618031, 1.6793786131054207, -1.461555169223776, 2.585783660380341, 4.091248369781937, 2.065583957509486, 4.646412439290584, 1.7621089661504044, 1.7232402590687503, -3.5919368035159436},
    {-1.1733919905552794, 2.0221483202818384, -0.1610932010331788, 2.8153653326598413, -1.2165592323878145, 0.9755545964502407, -0.9530643759996367, 1.4691582995956631, 0.7048751501158907, -0.4259138813738164, 0.3062558795723122, -0.02302836643005473, -0.3160602774791372, -0.1357528864796408, 1.0956329129678972, 0.8739975044219733, 1.1465232197956414, 0.6819799210394023, -0.1812641722656111, -0.13171696108790812, -0.7233421344693812, 1.178557386361942, -2.895734802705608, -0.01582478889241293, -3.2117104612571725, 1.8194570900114322, 1.0780991971952223, -0.8297872082306614, 2.864207876174384, 0.5863385461736138, 0.3220939877098191, -2.662411803769405},
    {-1.2914821118373356, 1.7894395706050557, 1.5949693589188354, -0.8279361923378478, -1.098364034382535, 1.5228744424790315, 0.9640485031214565, -0.08653804562105066, 2.418927655047129, 1.2735801049076534, 0.5789336530375535, 1.0241645102599297, 1.332404693403799, 2.3098752238409213, -1.0447956822708926, -0.703365254891832, 2.89364351008087, -1.6183026764005275, -1.0510320557974593, 0.9925928492679535, 0.07884508407462731, 2.27178483486161, -0.11341195376837887, 1.6473525677670728, -1.5560708144088693, 3.0402880961920866, 3.1701669030542794, -0.6061520142564393, 0.871150706883178, 0.6303008570293097, 0.5432927414527934, -1.2682829029885228},
    {-2.2447373937034065, 0.8012011119648583, -0.4748019539072787, -0.4912340219936951, -0.9872854363750214, 0.3220134298933881, -1.1676169416529096, 1.111815019858191, 0.3822809023573205, 2.0279272909614185, 3.000078853470697, -2.3164696517368872, 1.8755582522025067, 0.34558250020682707, 2.718515556221666, -1.7101505912472437, 3.908969145000372, -1.6091162326013502, -0.04135501881281737, 0.22979165558494577, 2.8217067135244824, 3.5032137117569753, 0.9513022965276398, 4.3089137489787355, 3.2540871043353423, 3.231821892218593, 3.3634822097482306, 1.798279691582687, 0.827107290376328, 1.821035949647226, 1.9507846948707526, -1.5250288170007833},
    {-0.5975104492622713, -0.07164404882443519, 0.9684902372429592, -1.5474177155882332, -2.174162789831303, -1.7827255979238217, -3.074368027730139, 0.027430770768372234, 1.279186421329501, 2.793130032926751, 2.9333091574954917, -3.5279205059804983, 2.6012881944962265, -1.1998083329104403, 1.7363330506970167, -1.7384061289740638, 2.947888871953455, -3.226236030414103, -2.492160902520359, 3.9039525432396647, -0.007946923689291684, 3.0680706942046307, 1.5645869872494422, 0.2070241922612633, 1.5473905107579957, 4.351816135849217, 3.8583745571931063, 0.8301660780011072, 2.615080822649945, 2.7369263564025794, 1.319218223562568, -2.405679909072904},
    {-4.1241929342079695, -0.12094974071321422, -2.736579445428714, -0.6009824956122074, -3.639454531832167, -3.008998821141061, -4.0329954672392025, -0.9413805549564286, -1.2221166630087557, 2.5528581672678294, 3.145206815698038, -3.8928365256498267, 2.7139283078063166, -2.0346993797729644, -0.6402376966055625, -2.3480555596135324, -0.2692621802565939, -2.6909527075770154, -4.037124534429141, 0.6831126259144331, -0.3449825819307922, 2.02103233593685, 0.072366444131348, 2.693135118583541, 0.4884953100577503, 3.4256403258248733, 1.722612982826344, 2.688548754772055, 0.9200364715624078, -0.20797784241875084, 2.7708731885787703, -4.929935069632636},
    {-2.1935219958821843, -1.0731195245414775, -1.5790735673531624, 0.20611223394037617, -2.1722955617932613, -2.8004207612793888, -3.7070965548701165, -0.2933118589079141, 1.6576815362334614, 1.6385688572019528, 2.10301122624019, -3.4473296562977276, 1.7550262194699158, 0.10671997732516268, 1.0534406165630799, -2.016799029298623, 2.1372194492557077, -3.3508197926603125, -3.659484340173121, 1.7884840563235938, 0.6581794815997949, 3.3726105870247847, 1.7238594888099785, 2.311020322015288, 2.2035099280254107, 3.1292155608702443, 3.594339405248782, 1.842368103416046, 2.0476716847485132, 3.831612978650212, 2.179947735781039, -2.6476371774098637},
    {-3.5670230267862766, -1.9909416688214223, -3.9972014999205583, -2.5443911540003494, -2.647286354242725, -3.2900441634253794, -3.9613305653617594, -0.41687848076696515, -1.6659809973875448, -0.11688906721322861, 3.226595488227262, -2.2112914886420985, -0.271714571763102, 0.8864474142161379, 1.6807123605773755, -1.6903796663779638, 1.6596742426968367, -2.608737678744878, -0.28004496594953104, 0.2821213843732381, 3.326187028170408, -0.518268362045142, 2.100514508508325, 1.5411861737082746, 2.580333472627119, 1.5442057303101229, -0.021177347285297157, 1.5506891236902318, -2.70447824116222, 0.7370430941791044, 2.8278818616332297, -0.9187964651226509},
    {-1.4030112182185115, -2.4554063687260275, -1.5605588240250565, 1.1212615167332334, -2.186549749324912, -1.1243450922198133, -1.7797145277273294, 0.25676682224835823, -0.520273776442019, 1.122415425594662, 5.636856852972389, -1.917656727780097, 1.6023866979622774, 1.7561598987735478, 3.018087776697405, -0.28528784706515337, 4.168211551817585, 0.1208005129865789, -0.7448396453340369, 0.27979071947545514, 5.038363727824834, 3.5689939901891194, 0.9928959394859733, 3.753005940857696, 3.9316011022762227, 4.481738585699997, 2.66816969798987, 3.91131803203114, 0.8692535628812235, 2.573936971015614, 2.7905375606859995, 0.3342208282652574},
    {-0.5202148249756003, -3.680551059525565, -2.148758170585994, -2.713332544179047, -2.052283408493493, -1.2266550095561808, -2.361396165327907, -2.827387203761865, 1.0232120793917483, -0.10564466957661725, 5.527154105048824, -3.049322503284714, 1.2290088936910732, 1.8570827779077228, 3.7360224508440933, -0.541244989917565, 3.1371245483665997, -0.5365805030749734, -1.7764040067318947, 0.9539337651918949, 4.297699201575765, 1.5838651707336011, 2.670629303974992, 3.145491802706917, 2.890058513821258, 3.4764104152836004, 0.3994146176473517, 4.68650177638647, 0.405131226906894, 4.012599913812479, 3.447017737485209, 0.36520018591155795},
    {-4.459643870824172, -3.924673365395866, -3.998232554161067, -3.8183147958540715, -4.743534147132684, -4.0458298786551365, -4.4087245310742125, -2.852468336226631, -1.6861250214776515, 1.6075634813034114, 3.894136124310128, -4.772611290288127, 0.5623318714021115, -1.5044352516955215, 0.9497456071098823, -5.40555801458146, -0.9907339023576931, -1.8260879271980106, -5.162575237141942, -1.9278882134264674, 2.089791238252951, 0.05088300035620415, 0.2715111382544228, 0.256533164546933, 2.7424946845030425, 0.7581508226857693, 0.6849044767598981, 2.7588866336709814, -1.0173520731481855, 0.7609032539836881, 1.4368688667681215, -3.4768375738074755},
    {1.581929467501095, 0.4082001874076629, 0.9247872102731858, -2.174582085838155, 1.9541356596024493, 1.5943043880537178, -0.7357177488938506, -1.385254779527003, 1.90284908329132, -1.690173155140459, 4.706809614122801, 0.18000274599812083, 1.5504235134503352, 3.4025695407204513, 4.220237040774879, 0.5306089903756137, 3.7449674716695798, 0.2962035284247507, 1.1631385211012362, 1.7737574438523664, 2.082363629412132, -0.05258968246966244, 0.7995674006960786, 1.215875962066466, 3.8307363465478788, 3.3541706857769564, 1.025415190710385, 1.1026318131329733, -0.635541338405743, 0.6220449549088447, 3.6266442361435742, 3.347822868716623},
    {-3.2934653355242784, -3.609981807636742, -3.0531723086187474, 0.022644027034056973, -4.0073180853086905, -3.472501308824637, -3.3190529453123725, -1.003991853467816, -0.026578752671224636, 0.8496404941879714, 4.496784091632879, -1.7180786670538764, 2.5491527325332677, 0.8742634324627362, 2.8059325513207902, -2.712874558987806, 1.4059550212220586, -2.070581857213106, -3.119725923797921, -0.38384560692804626, 3.1888999618479885, 0.5255261506695588, -1.5580184541415902, 3.1512701775904404, 2.5452797426405556, 4.219443742087688, 1.7380486113839313, 3.919651850887947, 1.3013558927339042, 1.9311860343992817, 3.997288638787951, -2.007847373572127},
    {-1.9070037410567586, 0.4325383109438804, -0.982412961164072, 0.5353001637811208, -2.8760734755787682, -0.7148917665862837, -2.6319596417660565, -1.0891328732194996, -1.0599473760182465, -2.3141213630386015, 1.1007293130002964, -1.6163555062799466, 1.1194437137393487, -0.3387613902461233, 0.7968360424768238, 0.1602545569708462, 1.091660334577476, -2.9441896326986106, -0.344941931264209, -0.3873268645967665, -1.3655298496777613, -0.2781510898999571, -2.952050445112568, -0.6444414787738602, 1.9897457829203633, 1.2796141457447388, 0.4509658487679676, 1.8283983360768448, 1.6615221230237798, 0.24053859910358324, 2.1956729566056263, -0.4602749810716848},
    {-5.648123173657036, -5.131711174951202, -4.579140770211801, -3.2684891094068846, -5.78939313236135, -1.1988470930175312, -2.075595526364753, -2.042065067798785, -5.9820052196329305, -1.9160658294142925, 2.4823854336329534, -5.524584890833935, 2.322800265913389, -0.11410340245645399, 1.1632094046406125, -3.818589001889981, 0.7114853592708129, -2.185056321397121, -5.4977928094003, -1.8886365621353651, 2.10774104927518, -3.3456380032038915, 1.25777294569849, 1.0313167521847197, -0.6791383451072158, 1.07372305889185, -1.373935180832553, 0.8214276996097093, -2.8423331635314026, 2.40115800802703, -1.6509215584540493, -2.4819030314483856},
    {-2.7602326941200515, -4.954057766814643, -1.450083779533955, -0.8735182632449286, -4.423858682397732, -2.862900620987442, -1.7993972091153947, -4.983487547237534, -2.1715489058126054, -0.23070547220478116, 2.8728646719137854, -4.548833691771071, 4.328137618264409, 0.38040775793708037, 3.02883062577686, -4.420622667384347, 3.2380128957697356, -2.052988119909912, -3.9585407921267626, -0.33314455358828593, 4.378183476993574, 0.3274944978995721, 3.5951242080925248, 0.7754237221181052, 1.7655806182681473, 3.695904688630553, 1.8925844083389687, 2.1437616017463217, 0.6890393798275785, 4.027248828072832, 0.9787537188718564, -2.730093261293009},
    {-0.4059129965296294, -3.3665435585834005, -0.9013533232989686, -3.085360100929591, -1.76027716301873, -0.46247364437673016, -0.48752240285633985, -1.0625937515298338, -1.9412850057733708, -2.5499343594480885, 0.20797665183576455, -3.4994250690478923, 2.075695796999921, -0.08237820652577021, -0.6254473603528352, -1.6346164973219293, 1.7449575965889712, 0.19239809052651458, -2.5669752481559076, 0.18219647879252768, 1.9575015281676311, -0.5527746975745176, 1.1267257604502563, -0.35410742765485403, -3.1992929347836716, 2.3132894107582325, -2.4887379624234427, 3.486576124256054, -0.9641413764867749, 0.3649603016614986, -3.78616847115688, -1.2790786457257173},
    {-1.8792442011750015, -4.27758921049398, -1.198428987345136, -0.18190452166605683, -0.7993942551665907, -1.4535782939652282, 0.5051654329814791, -2.1857386138382324, -2.5745237538048484, -2.4212086565752595, -0.379774216852331, -2.7844302361465307, 1.6080069005698965, 2.069274500344401, 2.0570014256075324, -0.6873558383221324, 1.1012769257041537, -0.958993111953686, 0.40935072193953026, -1.5819310516576166, 2.450866287730451, -1.2719848341568598, 0.7059171592842081, -2.4784239237602166, -1.8125907822936485, 1.0833957687941682, -2.56211903832349, 3.4017112354979844, -0.1555739559165626, 2.1404203653389553, -2.715711183968381, -0.6524677111964922},
    {0.2850491273940801, -3.4703360769882248, -1.8846649428358007, -0.25416586527274326, -2.583631284756815, -1.1018755086543883, 0.55649576691955, -1.4845469423711528, -2.614913209778384, -0.4910999481512437, 1.7643700627190113, -0.25705500499307316, 1.474292100928486, 2.786391627786315, 0.6337879331362334, 0.3986659113183756, 1.3817265934360352, 0.5671937551233645, -1.3879444399202536, 1.4065398136768719, 2.4640600074304944, -1.0422798706325704, 3.2987451419317737, -0.8308355613122463, -2.0705100638913896, 1.6131588306941957, -2.173032122092643, 3.3094268355960605, -1.5825377254990678, 1.4662488914196934, -0.4031997048241394, 1.0129217986767105},
    {-1.3235973269654386, -2.537875939469127, -0.08755161073918859, 2.5078174907815165, -1.546916550153465, 0.9167605807566881, -0.04436640186044726, -1.7606956641820253, -1.790783112322404, 1.134012519690962, 1.362088787440544, -2.157535388743433, 1.9637826933369351, 1.6698530172152264, 1.858615734852681, 1.0896914012081014, -0.41773186200859136, 1.6630607600531817, 0.028832437634851858, -1.6616358233316768, 0.39281886213470263, -0.8844690031364109, 0.2202200520059184, 1.5129489517958872, 0.6586820345392308, -0.03814841100499306, -2.8822629136104916, 4.0706746056665795, -0.4036296758456731, 0.1322154681621283, -0.7534741021459557, -1.0981624551491314},
    {1.2002472232602794, -2.8470918117010857, 0.13947948771520044, -0.5735173700579334, -1.556426186550688, -1.9750548614977226, -0.8850255160213389, 0.20593543427584293, -0.06895217175608655, -1.3623600263102587, -1.1959458783324795, 0.1220540164109395, -1.5797758258839976, -0.19399516425590996, 1.7671128068868727, -0.3418721353485311, 2.391010390286047, -0.9928600993986961, -1.3554427414672563, -1.13529629423244, 0.8129932502965895, -0.39989986041208625, 1.131326005187676, 0.34123872557538354, -0.19480447298479392, -0.5482803542829946, -1.2417197123607262, 1.849182392989888, -0.027627998035386285, -1.6860438706712708, -1.8258490651641277, 0.997092866958797},
    {-0.8657417295781438, -0.605874412424849, 0.04680226863117966, 1.680912113297066, -0.2602092216214805, 0.6169409613140908, -2.695911645524744, -1.3720479808105526, 0.2955733591839936, -1.668636800058037, -1.252527182959781, -0.570554755207231, -1.436494235445072, 0.3845226951274474, -1.5365689323521, -0.1462166998592762, 0.5733518558789462, 2.3657735592109184, -2.0137915569500455, 0.8674530458873106, 1.3342012704521442, -0.3775264030339786, -0.9214603156878436, -0.35757772672981875, 0.9702649849656361, 0.2130436861277486, 0.4981936758566118, 1.4407075325358463, 1.2820696234011804, 2.7844502172397134, -1.1294329520314277, 0.2758727100420382},
    {-0.48878839567171983, -0.65504822146528, -1.763933919951058, 1.5051701619619444, -2.823722210997151, -1.4693806959961557, -1.7139241558978282, -1.669530455706586, -0.42250464035314556, -0.5155147992100221, -0.5231322826451286, -1.5524672630908718, 0.3392683957472412, 1.297270753674997, -1.3350578097553132, -1.610396805039279, -0.5257708187787213, -2.1362348322923843, -1.734950896445311, -0.9655305630865116, 1.0166255136479847, 0.44771003597114156, 1.5225255506812037, -1.7417425152084771, 0.6536821831114139, 1.1679082195948132, -0.6247639127227943, 3.420013410778615, 0.6387509017532446, 3.0409568222793193, 2.32009978380266, 0.6511797509166445},
    {1.1677998146501782, -0.9757156400205195, -0.27928904003942284, 1.587246090933478, -0.5604995877191253, -0.5287971665787823, -1.607247246195136, -0.5408534293910142, 0.5419613621844432, 1.777087476887826, 1.897785944932268, -1.5250034050680195, 2.3787113703359912, 1.508743182891023, 2.5949150803877585, -0.8684415685277981, -0.2292320822200076, -0.6055820155621152, 1.0567561348704004, 0.47320994142720263, 2.3762868399622548, -1.1573292712827377, -1.2339037742303973, -0.2500638573439412, 0.3465581364083576, 2.1277143313205373, -1.0326352048175442, -0.3268600025033377, 0.8363749501445252, 0.270949533949264, 0.09769094665602304, -0.5640673699110231},
    {-0.047327924989221934, -1.1337522023848634, 1.3858398818031754, 0.042732679980007904, -0.15528285591070895, -1.006280921055905, -0.009258032049296852, -1.6250708975929173, -0.7836070438402081, -0.855144869489627, -0.7225543781275945, -0.5449422903064598, -2.346671349520248, 1.5360391480287583, 1.6195529370195758, -1.041326661103539, 0.9336313893783578, 1.4481440497465303, -0.3244953771077964, 0.26035330114535515, 2.2158991494721105, -1.9394936925695248, -0.1944700188788488, -0.03809125016319528, 1.6517217800995905, 0.5159047688363609, -0.07857560399438299, -0.45095946893779276, -0.690865023676014, -0.9816922758925956, -0.8765170181117472, 0.724135164098478},
    {-0.40102692205366886, -0.2393906528966288, 1.2730636713131036, 0.34106080371224784, -0.4163779749752045, 0.5315035303894758, -0.9383693892580248, -1.775875958909227, 1.6197362289899626, -0.05425060496860599, 0.23990719487858536, -2.431191672085123, -0.8836422445347687, 2.5952104432536607, -1.4957179567736394, -0.21339102359400522, -0.0436524048839271, -0.44499464152881946, 1.6766352493647816, -1.8575882359901772, 2.0447819851913382, -1.3772560430513232, 2.2880420192382775, 0.7129156930192453, 1.4554679568244848, 1.3282638963112545, 0.5953728230202374, 1.8003720636058924, 0.7444659992551825, -0.3374972092262688, 2.1368228003150804, -0.1648720565484868},
    {-0.22737421781940292, -0.31552825473718477, -1.1555967615274352, 2.4434380564055878, -1.032816234797198, -0.4768378609358409, -0.645429522853892, 0.6948126360707123, 0.9999586084945296, 1.4279810171618952, -1.857399389509359, 0.4004092581431025, 0.004137405663600347, -1.292128646022349, -2.259002494870442, -1.4680629896620854, -0.18049798791222493, 1.2437510554028206, 0.38513409704024654, -0.39492091898003867, -1.0185302264222083, -1.1838720412305286, 1.7859132145746426, -0.111660936520541, 0.8142794694635551, 0.17483191510537657, -0.8146967242041713, 1.480330857865702, -1.8436972515390435, -0.9889291443117455, 1.476504893072842, -2.356109511157547},
    {-0.71107760083579, 1.0537214739479344, 1.3215225278280776, -1.2645041602618234, -0.4557052950769977, -2.3457180322725875, 0.044057810633041795, -1.880405798376467, 0.005022014364491577, 1.3705067948476721, 1.3583165892629232, -1.8608011626038539, 0.28686844279850043, 2.7280860918498506, -0.3771012061604179, -2.177111267898058, 0.20804031619519486, 1.3758374587969868, -0.505942428216119, 1.1719559210031594, 2.3098339609541925, 1.6010349991819635, -0.1866814072293514, 1.4351679920608287, -1.2177849936652374, -0.9856368424573333, 1.8443079298635403, -0.6581608940109485, 1.5216087239807967, 1.7476069029816195, 1.1792213155271756, -0.5712916107527961},
    {-0.027473055895604167, -0.7644666558736642, 2.0427390693925904, -1.1805872662903754, -0.3263323546353397, -1.1171565013113094, -1.6675839310351834, 0.8857159032660393, -1.9699694710646813, 0.8990272254056492, 1.0910026799369537, -1.4390162682777836, -1.1375111320210085, 1.7466117361395526, -1.967860327891738, 0.6213632137362629, 0.24069089005784833, 1.7689275487264724, 2.2608873280153294, -0.08236692742782616, 1.1610473971188764, 0.19451189310629086, 0.42858556020194655, -0.7072565624803019, 1.6269573691023085, -1.3945173806170748, -0.5297065012393588, 1.2753589241873189, 0.7320061587643526, 1.2863195739107787, 0.32488744841685957, 1.5000011979360914},
    {0.13248239486866073, -1.7729625782759546, -0.09256820914086805, -0.6496183052285195, -0.8896584974339926, -1.8369487097690869, 0.2496937739417823, -1.417341403120765, -1.882058546848792, 0.5371851002264943, -0.5899473103479407, 0.833906879757505, 0.5696128198070649, 0.4079515467486652, 0.7286154397511792, -0.38466096722357523, 1.9046853368126981, -1.1118528837024875, 1.7377065397583282, -2.863890630111148, 1.3408577949071168, 0.9075575759890726, 0.8708955768986888, 0.9532577830738951, 0.6517356351578899, 0.8821518080612085, -0.9687953447472408, 2.0625801940377597, -0.36364447015118795, 0.4898767285876461, -0.8190526874088003, 1.9296191127220323},
    {-0.12449410217290843, -1.2802369127452118, -0.6377881048374928, 0.3912792283113448, -1.1767948474581755, -0.7161301515558413, 0.9901357564022095, -0.9040926268330439, 1.8679897244667787, 3.2501353966448794, 1.2647733631590374, -0.3285840295510655, -0.3340782855215702, -1.097198165787027, 1.470764410805284, -0.8200413847120019, -1.1719140161448316, 1.0303812310340525, 1.6332044681108944, 1.8636463811887485, 0.029069645542427167, 0.5425440296775166, 0.6993240249358161, -0.8091164653103841, 0.25357654237549837, 0.7058160536649715, 2.885410771758308, 0.21211530860003588, 0.171007822539089, 1.0344757705988812, 0.9111426286212022, -0.9678680090757699},
    {-0.9630497920444223, -0.49551146124367174, 1.9926645036817157, -1.1016740189914886, 0.2956767607100564, 1.2790963501579968, -0.030321363582080117, -1.9703148799783732, 0.6651777086368775, 0.9206042406465041, -0.7171484288592948, 0.20831673022651848, -2.8814053437564056, -1.4094306013031597, 1.4083479661229845, 1.0761133360536974, 0.9818596475567655, -1.461813001965193, 0.6301504314925034, -0.08103234880239235, 1.1079785429499802, 0.9427126943672214, -0.19470160258552963, -1.7820931170527357, 1.8044890117776569, -0.7879056226627609, -2.221476127180291, 0.73099652610616, 0.9911815279927086, -0.5184085929669772, -2.441936082565152, -0.42905818422696573},
    {1.6203380049682796, 1.1951130362043847, -0.6703830268586021, 1.5762654101656557, 0.7573366998300197, 0.7544044826690326, 0.028908568069972662, 1.292571160678555, -1.7391872808963076, -1.4677967692185816, -0.9439969740112903, -0.9867725436619146, -2.277108745686816, -1.3891899382546622, -2.534042679386254, 1.9805984072598604, -0.4842905799362691, 0.44019219091068945, 1.5200433548798105, -0.6851730953806983, -1.7839477895421179, 1.899136465390994, 2.2599272572511904, -1.4260147596966186, -1.257971079985106, -0.3160365283339836, -0.27780731175848267, 0.770365613895076, -1.104674065386874, 2.344603345324277, -0.46674230271070555, 2.027926601367416},
    {0.8679360293980501, -0.39508312638449217, -0.10213228752804587, 2.057805987132058, 0.7106976724581571, 1.141388383132031, 2.0114056120281862, -0.467458529554191, -0.03127409881183063, 2.8951589563378426, 0.4917592516949849, 1.411549248650133, -1.5765967198632165, 2.78551530458748, -1.0007678936819426, 0.6588206186788906, 3.137980821146695, 0.0653175477278697, 2.2233289513802794, 0.12900482081328202, 2.499126972348911, 0.6353149409417724, -1.2588643993475408, -0.21419715735946057, 3.0994967592812883, -0.31489874430933956, -0.6046262859513574, 0.32113157911055756, 2.925997056558395, -0.8102610228632144, -0.32719113163125524, 1.4731074095323948},
    {1.6202921976751656, -0.1039157727497072, 1.0950709076293694, -1.0223420821013862, -0.0845115364868423, -0.5362560864469368, 2.293124008737869, -0.9042655930116548, -1.4052981507605833, 0.8389728104572187, -0.8454316558911368, 1.2457567327195265, -1.6026747918156417, 2.4029725060956255, 0.15713176257214906, -0.7521847285778849, 2.089672000163279, -1.006840320945614, 0.9102268837288215, 0.6587852838671453, 0.6874549874035394, -0.597773894231325, -1.1324613612919034, -1.6808227301078076, -1.909894675222658, -0.050628734762254324, -0.4613283372761143, 1.9088394008130969, -0.7109589937543909, 2.6927377587073518, -2.4690223139362284, 2.0638121367666744},
    {1.3002519014361262, -0.7691850583429048, 1.5770614032946537, -0.4242619909007353, -1.8281728910958785, -0.2158046342991907, 2.067535023774106, -0.9589548434415609, 1.6230333052364934, -0.3754666979305184, -1.1374829841868592, 1.657153717680176, -1.156284736331937, -1.0704788189124448, 2.1673806006099774, 2.5190304843768163, 0.9345957975450573, 0.4728456434566024, 1.3865794981230546, -0.5041941475121067, 0.9476441565226089, 1.647680527936533, -1.4970387302366284, 1.0064681522451484, -1.0980108976096044, -0.5135701683188904, -2.0863165714963268, -0.9414796817593455, 1.251993339834526, 0.7075292153502682, 1.4398403016492087, 2.071389425407443},
    {0.3877761640634565, -1.3432049812087379, 2.0270310624091845, 0.8574946627839931, -1.3589861754287993, 1.6810785350937825, 1.29831548581861, 0.1917142961200134, -1.2248557329667389, 2.635130286319468, -0.8199603893654528, 1.276510398677265, 0.8636665954028265, 0.3573890801908271, 2.909086162173895, 1.377708700242102, 0.29058212201323746, 2.5511020780871623, 2.478705078822064, -0.5623935507884198, -0.8526140342403667, 1.5397025944214164, 0.7624742979956983, -1.3738612726267128, 0.491682663414714, 0.6082767149891952, 0.34430085115947406, 2.2826633569908354, 1.1386059019752044, -0.13216068797142624, 1.1601766824627682, -0.057399780316585616},
    {-1.2491638688958606, -0.5942674488831594, 1.3018193158506823, -0.04658032122229034, -2.4197396295279945, -1.799614352277126, -0.8087254118572341, -2.6636279294717555, 2.8243144539612626, 1.0915738369749708, 0.7774477673352437, 2.2665479838891285, 0.8041058277152283, 1.5848690754590737, 1.3516580645413752, 0.6874108176375407, 1.0071923447970204, -0.8537725109795378, -0.7420931415581105, -2.47286542041263, 2.059100721335324, 0.05111836497222532, 0.5078942123206308, 1.9427357075999607, 0.6527198969048491, -0.32953838317585854, -0.3547468503155878, -0.815097994276088, 1.5575702549865247, 0.1689721027041783, -0.44365638314079764, -0.5944055100134815},
    {1.236505684148109, -1.7945018942408486, 1.9058688195260336, -1.6910754520738476, -1.3810037902899093, -1.5790387431950188, 0.13383450768765945, -2.258317177186371, -0.7112241889369744, 1.0832025871942066, -2.10350859131512, 0.8138375597252028, 1.7047308970375021, -0.1472519781228043, 0.01862631045327861, -0.8199280770048852, 0.6507454612227881, -0.610426305996688, 0.15382834339485116, -0.7727296259793938, -2.3460285198052904, 2.4540300201196383, 0.6767362663453298, 0.6934417386366852, -3.042320397544629, 0.7509467590851661, 0.3278415090215406, -2.447886654877818, 1.2737663773602044, 1.7667501658494715, 1.1667894505552265, -1.0152160222995363},
    {1.090163004664462, 0.988227788014569, 1.2053161849055736, -1.0789904753403983, -0.08521264964234052, -1.4781495505486177, -0.6327029261459718, -0.6574089806153562, -0.25173271403312075, -0.9857024079692321, -0.31543329921256036, 0.0051186937536742945, 1.3948001050678083, -1.7767149505519089, -1.3203804429504509, 1.2659289492324353, 1.2833131714071533, 0.8426249117833001, 0.30498786393092653, 1.93437347889977, -1.0508066948072494, -1.4231249587912904, 0.21563998337849027, 1.011281322220325, 3.038455941061997, 0.32841190307407014, -0.4079298606083956, -0.2539046435669595, 0.23273648485415419, -1.7562541447399216, -1.3519950334616133, 0.8322164975544905},
    {-2.853639189094828, -1.4032096079878997, 0.4434426911552403, -0.40032082367411687, -1.1623520151654025, -0.8688257708893398, -1.0139323902643813, 0.0688214120298788, -0.42309584794035154, -0.2357966754349745, -1.4079183356973215, -1.1907680701104992, -0.981151388848387, -2.9802407524040793, -1.97162233467873, -1.3198445233289702, 0.8540994957025136, 0.5523581895853202, -0.45997319917485885, -2.17824799524774, 0.3006546770509578, 0.7662503610088297, 0.2963546336682414, 1.7258656115766322, 0.04761430879215802, 0.24065096471739367, -0.1963291734121935, 1.5574572574864138, -1.8560816335181405, 2.037968875140393, -1.3513962196493523, -0.8790997167738145},
    {0.13936439708054132, 0.45949336927336704, 1.715825716800165, -0.3233077385950563, -1.4488804753450744, -0.3613891495449798, 0.3023967349440078, -1.7107730347855088, 2.8251184198582395, 2.941352950459064, 1.339789747098057, 1.2746466987648064, -0.1938931813571638, -1.030424492503174, 1.4850158858107387, 0.5017398071291969, 1.5464336380544366, -0.49613613477366425, -0.7090561550681483, -0.9973541440293696, 1.9543186038735005, 2.6527414495759474, -1.4390325437194937, 0.6869378010252883, 0.3042899226767615, 2.3929492987971472, 1.0950473681971529, -0.536463192745655, 0.7396480497307347, -0.6839373013974196, 1.4108443012777419, -1.2884706225400404},
    {-1.7792995968462304, -1.730184657613658, 1.5597194364086744, 1.3576057441410063, -1.9959131878067349, -1.3529153703841, -0.8725169230292109, 0.7440541636738492, 0.4177979935188646, 3.2083038821895995, 0.8638350243691039, 0.9470937777972227, 0.0609612309221495, 1.42392056731581, 0.21096642225181983, 0.9477150066043943, 2.5221723350407257, 0.8190030770933745, 1.0493874339359763, -0.3178599280759224, 0.5617163460224968, 0.39705384346727535, 0.14188029460278384, 2.163054993411159, 1.51574898535962, 3.0148312346551855, 1.5726519625557773, 2.601670885388379, 0.5239925193003924, 0.6961703110710107, 0.5774698928435815, 0.7120875897725778},
    {1.6729607394762667, 1.3076502639506298, -0.654072704078365, -0.07245760619008285, -0.9618688781354864, -1.63795960036959, -0.10474436922308288, 1.7292736582402757, -0.4298814933587501, 1.1575812531984928, 0.050404488112126326, 1.0612116071329003, -0.15352622339650968, -0.5558802489325664, -0.22114521530689302, 1.2322547090240927, -1.1308716553581188, -0.8506251719907081, -1.6134823238801905, -2.3592186027775766, 0.9360680502311657, 0.4065895284292784, -1.730362592723731, 1.4998596104784285, -1.6907955137647321, 1.4920769044381654, -1.3823836639373537, -0.35824060469259744, -0.868695812911815, 0.9717803073919331, 0.0936789816083255, 1.1231547733595615},
    {0.3462515580897506, -1.4147538995969022, 1.3819806533289831, 1.1808662500566778, 1.8789057937230207, 1.384761477954609, -0.9436664828133621, 0.17503751217327373, 1.6714754315687201, -1.882801272138801, -1.224477071289725, 1.2502329253767803, 0.6869371641731499, 1.884171280994997, 1.1501887169241454, -0.8634425088201703, -0.47093626749339174, -1.0242346166231975, 0.03688028969942339, 0.35838465577936596, 0.7918784356353046, 0.011107156154215394, 1.5584621010687711, 0.4371268320140867, -0.7242741086871621, -0.9736982175520753, -0.08425982670011885, -0.008082344506507683, -0.11062526309436692, -1.2140127265053735, 0.9123921673095542, 0.7452995531625386},
    {-0.7293196072338255, 0.1410390905147519, 1.125712982654431, -1.6489785943428052, -1.2501235388216583, -1.0967038364037511, -0.6277494582425704, -0.9771282976984127, -1.282653600430339, -1.6791404632194113, 0.06304544884088578, 0.6341958649996737, -0.9846580588805787, 1.5179186431832496, 0.2308936505219729, -0.2703035997756401, 0.5387738167060676, 2.1521963012128187, 1.761419743485205, 2.360260121913365, -0.3894183501858119, -0.18588243417625092, -1.7847839066714488, -2.372688483028133, -0.8607218133761905, 0.26278762124902766, -0.5560393895115109, 0.22645812446270994, 0.20202761642843114, 0.6313055944328024, -0.6099493434649744, 1.5742856258915623},
    {-0.32828986459335985, 0.3083493681129269, -1.0619012462747444, 1.2405290690354371, -1.6773056046370758, -0.7031803488029849, -0.08958369136194337, -0.8619637805137871, -0.11253650465735093, 2.304018254350938, 1.0882291979409917, -1.3286167811320533, 1.0644388865418732, -1.4535460981224388, -1.001218379986112, 0.4694056596211508, 0.24983263755590748, -0.278322461858056, -0.6021399712838955, -0.6135386541209569, -0.9890589239122953, 1.8052054524185441, -1.7332883187009525, -1.5784557402886064, -0.4418149316735838, 1.2207001589198165, 1.5659694388360434, 0.3645933984220519, -1.2746821159810464, 1.1887534011301835, -2.1183085312231693, -0.005648047184602925},
    {-0.30751497065673133, 1.9851693015062513, -0.56637288037849, 0.28927406711858433, 0.5042710963155154, -0.3031048834754239, 0.14673594172758117, 0.25263417764902263, -0.35004009348892046, 1.547574701513303, -0.8776183994545518, 0.13338000536375422, -0.312325342313233, -0.5796702052652267, -0.2829541082555725, 1.1873356530719834, 0.6748019570796399, -1.6707723579651832, -0.8410481756506817, -2.2696555639982554, 0.10081693454195217, 1.7356786065468874, -1.7220077290955988, 1.903378626084735, -0.17152153227072778, 1.1936130884996958, -1.120712333886098, -0.9441168585490646, -1.5520854637239814, 1.0086570757028728, -1.6849705033996303, 1.2317594364436792},
    {0.749749737407696, 1.3544211144817242, -0.09035133489656202, -0.6758061832687052, 0.40360108633516867, -1.899574019231735, 0.07520970259242814, -1.1393277190800717, -0.9769666641517526, 1.818940046522328, 0.9391516505761103, 0.6956139753133713, 0.8421130908294361, -0.6197331787253021, -0.9263499117111326, -0.18459530042787997, 1.1583867096270362, -2.308547488525155, -0.7693174714463669, -2.575571869686414, -1.2447591935273592, -0.6862815308926022, 1.5437420456530935, -0.952776476619907, 0.07869162493771079, -1.8032084272388162, -1.2896291456750766, -2.3360078880997914, -1.255376900068296, 2.0858039474137837, -0.8641063807277609, -2.042406262571205},
    {1.6269691102539532, -0.531726596264473, -0.9035157787007194, 1.5546286472013682, -0.5488307653289223, -1.1931266462926318, 1.4919295170944027, -0.05627351192751971, 2.066800560296014, 1.903183450211697, 2.5301778577537326, 1.6259394957752626, -0.5811088559934433, -1.2774467794451487, 1.4464420660148407, -1.6095717119504682, -0.406804672578627, -0.20308091546836743, -0.8844063620835677, -2.0446613298838194, -0.875461320795834, -0.4313086905853122, 0.5211825470819994, -0.8270611944585887, 1.578996046812782, 1.0446013462908998, 0.3444752997049913, -1.2228143095141235, -0.7107769264298514, 1.4578625155868963, 1.1175606627616714, -0.9371650041302999},
    {-0.5760953517841679, -0.7498835534199574, -1.4408736163001437, -0.7214340785792409, -0.9513298917069453, 1.0443053930907096, 0.6593583879880907, -0.43207863212970493, -0.6933510098940264, -0.8223619737995516, 1.0734639449756431, 1.406658169020588, -0.10692343722450749, 1.3384233870622002, 2.075690924272836, -1.8830122113045173, -0.9304556332400788, 0.29528243196800136, -1.4588150360404102, -1.8964870364599946, 1.7764814473211183, -0.7122795742199698, 1.5304983980492746, 2.1613392606737194, 3.0334622807710945, -0.8087058799213801, 1.8722415353862378, 1.8563377910005727, -0.4546903266721215, 0.28315953367590097, 0.09088509439089408, 0.9071053287785007},
    {-1.1201791028168344, -1.1528242757552938, -1.099605073336476, -0.18982598649156132, -0.2781311193039171, -0.5496328217437257, 0.9484893436293241, -0.16084845545335236, -1.800388814331595, 0.684664036385763, -0.25181486160620353, -2.292164770832076, 1.0413539175226494, -1.7807213681124867, -1.4815532116377672, -0.19612975290175683, -2.3695389061446903, 0.1251423320468147, -1.3787077951426499, -0.9425545409738453, -0.17220102902401527, -1.3317012379813975, 0.546160385355187, 2.12262052871024, 1.5574644547849055, 0.6843327069693464, 0.11195279240174764, 0.7349309676506393, -0.1197296083342916, 0.7157865615774456, 1.1879174530376182, 0.039919203306687856},
    {0.2587860861875134, -1.4320024503130344, -0.7190749912885798, 0.43503780915354573, 1.2571233134992617, 1.0998568509533968, -0.8436404328677827, -0.06784041873303742, 0.24701037303581805, 1.339835422839647, 0.21979092527069613, -0.1471410504625781, -1.6247381007988833, -0.4981006711956117, 0.6966692345474985, 1.040294090473021, -1.300095950428878, -1.175300877633288, -1.0050423284305896, 0.5655209302568464, 0.3978901401270862, 0.39261730943605183, 0.395440152385319, 1.1375505909750505, -1.0958382732447278, -0.15317753831701458, 0.6263415147696314, 0.8912425414456897, 1.5018527504148056, -1.4833517726767758, -0.785575910337357, 0.10204994130654904},
    {0.6633105735299045, -0.6977842435703705, 0.18194011957116843, -0.27562014896513787, -0.39248889802546644, 1.2226679830847422, -0.4885394990891162, -1.7063710976585362, 0.2182937649941775, 1.095260681635893, -0.7174192450324997, 0.4254144483841389, -0.7835765907609593, 0.05689703519897428, -0.035845809038698925, 1.2723032430889454, 0.7469961331900369, 1.718881314858976, 0.3598403451257497, 1.3598533137115747, -0.9410578047764069, 0.8794708671822399, -0.9535815225969597, 0.0306184575743217, -1.4475348408308921, -1.2262008764886088, -0.468195506519831, 0.27460685529972007, 1.1908109127190238, -0.7204194871612755, 0.8070856532605131, -2.1469768562308955},
    {-1.395980806084879, -0.04635411540970861, 0.14812278326333647, -0.6719634255486308, 0.5048790772051859, 0.22269903891395837, -1.5903783483034446, -0.09826978540918652, -1.59872415323023, 0.3866239808832617, -1.0466776739700479, -0.5528555493091059, -1.1887960830691677, 0.03985305955211899, -1.2747878879958008, -0.7722262366395548, 1.5950704741264912, -0.050116384557141146, 1.2547455912047014, 1.4380672897106201, -0.47087217415644356, -1.3194206079158382, 1.0456541869128904, 0.5963194623571172, -1.501657316314821, -1.1425836515146999, -1.4358743521837476, 0.14470555950253733, 1.5578223526895352, -1.9946072965390529, 1.1628354983925007, 0.9788217891929551},
    {-0.3146631455484241, 0.7174765975184136, 0.12254837308377034, -0.2844925437268646, -0.933028663887148, -0.9404146932044468, -0.015949635884365165, -1.8416127616225042, -2.1707695381700596, -1.7045324057870797, 1.084147548560474, 1.6713713792760014, -1.4953227706943335, -1.5012638735331332, 1.632935132792621, -0.908228296371887, 0.74166984195316, 0.409233593082152, 0.708888103152034, 0.33587242868499934, 2.455974736782769, -1.9914554150635826, 1.1477805291236647, 1.9168893422451676, 1.77191127207545, -0.2696993034046366, -0.8093003901873509, -0.1505440684777039, 0.03423164719284277, 0.49477146104863695, 1.280146705066935, 2.4209618772043022},
    {-0.3726839012247951, 1.3165897732378897, 1.1331311007315403, -1.6166643911403231, 0.9673255228318237, -1.929831924707393, 0.9758981838975854, -0.30951156535605756, -1.2638499460984571, -1.0651828728935628, 0.9319664735134021, -1.4296710905911507, -2.3518292317832876, -0.9352444084030596, 0.986410679871426, -0.029030294672965154, -0.3197769092773491, -1.005470701124019, -0.10662478388258033, -0.5146898436066702, 1.3167028902227136, -1.2405274596899372, -0.9777691910953026, 0.9824615809748286, 1.3799517905970033, 0.2541735682228386, 0.3462475877672473, -0.5478419518170031, -0.6363682353021936, -0.3855154828341093, -1.3816180279439816, 0.1987216823398335},
    {0.23990707621459859, 1.5412225391873515, -1.2646834321990514, 1.2680987902194136, -1.162726843355142, -0.6311109820507946, 0.28294781860621165, 1.137224891227076, 2.404719324160198, -0.6418882366519555, -0.44696960042566564, -1.298546795654896, 0.9154337738349703, 0.7876550801447351, -0.9388051567231139, -0.6598258836654324, -0.5202368949051865, -0.26583805251300474, -0.2377358826299467, -0.9641804120475356, -0.6380863714713607, 1.0863638366077601, -2.2496077779084076, -0.3216712957293614, -0.6732362300594684, -0.5210819736905699, -0.4603643180993996, -0.9678588246281506, 0.9415047825880675, -0.8277659529156329, 0.41746969217550245, -1.7076839438355231},
    {-0.3950445744994916, 0.9843908281253144, 1.2848894262733561, 0.8696407752823978, -1.6146962483869929, -0.486790137994155, 0.9977232697911779, 2.3888992720269244, -0.0666828080770592, -1.1597253220207107, -0.9635104985363209, -1.034634652030667, 1.8599994150829933, 1.907300999555704, -1.174069481734398, 1.2364275157402431, 0.23501821838557047, -1.4052921516870989, -0.38687364414399444, 0.27259130879805504, -2.1988008450660805, 1.1282248866423312, -0.12390471550472541, -1.8680354277872364, -0.5504677799718332, 2.3867236111872154, 0.7993822876862375, 0.6718310486615303, 1.33105637571787, 1.3323321954320881, -0.5503745380963033, -0.13921707792973748},
    {-1.170753519777799, 0.5159686904467365, 1.6448727432687495, 1.1229095964709324, 0.5844567826377592, 0.37598699363322974, 1.3884008679757787, 1.5960684584059281, -1.4498948607311792, -1.8365254677881018, -2.064335741299376, 0.742206017182946, -1.3106846381658561, 0.1228545687857564, 0.3725048860958872, 1.546481950436089, 0.11337443053322956, 0.5169993532131423, 1.1916161047892189, -1.1802074873408797, -1.4693620621241446, 1.9038118753696263, 1.4901043037883603, -2.7999121906446467, -1.066352571670499, 1.6319920635241205, -0.7497806052800363, 1.1543602410038756, 1.3087913272755054, -0.3576566428672473, 0.5881049223121725, 1.248425325814779},
    {-0.3238363409047785, 0.05168114003172095, 0.03584288608621402, -1.3394904933716651, -0.926185422098517, 1.792752963254731, -1.5080035799457214, 0.579295864692321, -0.5762006893493371, -0.009265776447046868, -0.30011105609278976, 1.5693098710878135, -0.995962545332518, -0.9666442195328504, 1.5502103344674005, 0.9541262502037431, -0.1482773947792244, 1.1973472076582623, 1.6373275887189547, -0.3140215800795281, 1.2538498231498163, -0.8286760617678669, 1.844678733262774, -0.5364271149939921, 0.31131698825525483, 0.14606486545717345, 1.0884656962047965, -0.14554930939516825, 0.878593658799133, 1.3023376966192952, 0.9856186849105044, -0.21901767683508297},
    {-1.0856265197867963, -0.8504201568696788, 1.1032768709411198, -0.9270908896099442, 0.8763310776072117, -0.18888851360115402, -1.2633372350976344, -1.2968874155939685, 1.5115696619053975, 0.6695068356227862, 1.9048709317338088, 0.7688698287065641, 2.006912035331256, 2.0960210065670926, -0.14015220477048282, -0.5915524687077458, 2.1438538984027953, 2.4896758829824854, -1.1246277194933851, -1.630847958060136, 1.4654483565634113, 0.022920568860187316, 2.0020052873564604, 1.5477141993434733, 0.25559922316295897, 1.5055033328019958, -0.6154544392695427, -0.49155578631331076, 1.3302490696951856, -0.8462325658406764, 2.1155024625375036, 1.0965442444794546},
    {1.418643033215746, 1.1573862847038552, -0.9772647634110699, -0.6570108217044427, 0.8584638716987968, 2.1198162430502143, 1.0856656248937042, 1.7352938966897875, 0.6065254550010023, -0.7604088624471872, 1.2840239144439511, 1.158229059913222, 1.9185907373534181, -0.17448350816743557, -2.132893084908327, 1.0026609924968621, -0.03748376162248012, 0.3253105760637356, -0.25905516094427083, -0.08276019006674, 1.9402040708128954, 0.937715235105849, -0.8148263488365451, 1.481217827954163, -1.547438355967625, -0.5435377172663024, 0.09723424429224167, -0.3045435036706888, 0.10257180300917972, -1.7797885685486776, 1.6974234969579884, 1.539820567868852},
    {0.5519497383201205, -1.00722591137831, -1.0641369004557506, -1.5050600895078714, -1.295794608808201, -1.5016778726158164, 0.3680716714255689, 0.060406637267880696, -1.2253025857391868, 0.33271317279685814, -0.6328628623794227, -1.4746217676288953, 0.8093937435802416, 0.5301853347278874, -0.21170400242906354, -0.2288910405605832, 1.2180144011497964, -2.3897185323965116, 0.6785195533470014, 0.4529490276232151, -1.322876935836446, 0.17890245936483454, -1.6718026961637213, -0.22685552310213364, -0.24978941968314125, -1.6408641036534888, -0.9523015333414243, -0.8647724895599169, -1.6550125831630083, -1.8958396852653137, -1.071911325454546, -1.4919745554214539},
    {-1.522332196462447, 0.2808223686736431, 0.8253144927505921, -1.793966847906962, 0.2734383277201231, -2.166618382100169, 0.3405235957102977, 0.16486302731230432, -0.8549759741156086, 0.6816171446189575, -0.2688869391536127, -0.9065938682962724, 1.0086296668213008, -0.7793105867992886, -0.9879141402480384, 1.1585000062174617, 1.252119319210061, -1.7315856526648934, -1.6882562889796362, 1.1056745662437628, -0.8663835502467985, -1.4137679562959367, -0.9658796237953221, 0.5631092464523016, -1.0387514557157387, -0.3904733292769802, 1.2677207448077648, 0.17407716520757635, -1.911061922101409, 0.18014393487707006, -1.4101372140410362, -0.0935309415715176},
    {0.7728795387807115, -1.5770554497266878, -0.5810591062863288, 0.8995319096033578, -0.7440593728756908, -0.8142342839331818, -0.5052704571480757, 0.896732434398854, -0.3167686916000141, -0.0967627278557428, -0.711332193224934, 0.9850617804484587, 1.8370630216558648, -1.188082132963761, -0.2875256616537014, 0.44441595281109236, 0.6934370546060924, -1.2245648551542394, -0.05563740709296838, 0.8247318079050542, -0.8068569288967546, -0.00040556040287586474, 1.7227545786611917, 0.231192178478429, -0.08758165244475552, -1.1555432914112427, 0.22219560058368845, -0.6882529119014497, -0.1921602372573223, 0.9374495736862131, 0.8046536406961655, 0.25200299398088544},
    {0.6477659201196861, -0.44048706128431586, -1.4927476849392438, 0.021976174838831478, -0.46895608838778624, -1.7091624141600377, -0.38266423524432047, -1.1297526462859138, -0.8927944312338624, -1.1795206860549443, 0.30003204940588807, 1.0721695360702361, -1.369493107906368, -2.010056010523884, -0.3823658058880198, -1.4144466313129374, -0.8623250985550965, 0.6463178925189698, 0.4032328759818875, 1.325488766453194, -1.1947127077635302, -1.2740710641312727, 1.8056523684657664, -2.2675438857246752, 1.3632051505562273, -0.3882666446213489, -0.29990951036702135, 1.1143074585460075, -0.009401504721068588, -1.0745504502804577, 1.600686777245507, -1.1075751702263832},
    {0.016660879290956013, 1.7837269563239702, 1.354904604976921, -1.5047460761837645, -1.5748028478598384, -2.047641757348617, 1.3332247877129761, -0.7773219884041168, -1.9688757859720625, -1.7884911403307413, 1.5316627802614142, -0.10547721495169561, -1.8362233878688883, 0.19966756678044062, -1.6484941335366492, 0.6686571850207419, -1.187485613148371, 1.7968561584362275, -1.212367393401542, -0.559149788903805, -1.0474654371886176, -0.45732247357088823, 0.5228118749119731, -1.306636563658978, -0.6737563513256343, 0.3970716501946331, -0.274591587097633, -0.39257946293192636, -1.4831860540946336, 0.24279979682270797, 1.2863232907542896, -0.7793102929739784},
    {-1.2098991980585343, 0.2977715481104405, -0.464635659766378, 0.3542928336132168, -0.5662246402503324, -0.21694835871436652, -2.138044343433694, -0.3075478237713962, -0.4231761285439007, 0.0465228371904176, 1.2140771155903056, -1.0011665949444908, -1.215345594459722, -1.1077185753708856, -2.3381417119655645, -0.667429411619743, 0.8541826326680667, 1.0315050560588586, -0.40107623239616796, 1.572084642501107, 0.6367951544518984, -1.4591353431475478, 1.094676815312096, -0.22645717422481004, -0.7162805791475629, -0.9391395229918097, -1.2284248270948328, -0.9398183470019502, -0.2681791311047751, -0.346160981496969, 1.7367542448078523, -0.8398878612845477},
    {0.06973911026910666, 0.04101481759724834, -1.1128705819713038, 1.8095186888701935, -1.6408006027041862, -0.8425589547991202, -1.6826631474772074, 0.3178957362370685, -0.7098681524173139, -1.220635562579621, -0.13307904546041424, -1.249711024145846, -0.8343280699384397, 1.500779662730093, 0.8144156238800746, -0.9191478423602344, -1.6035847165856025, -1.643803578592564, 0.018296550971609513, 0.8359909543862999, 0.8427146203629522, -0.4300629725356854, 0.8654695356143366, -1.6271875419592818, 1.6160906893422826, -0.25574467906438036, -1.6422531741516546, 1.6739927835642587, 0.7294195726550751, 0.4714485888603105, -0.06993352918926354, 0.04007395354163079},
    {-1.4272533989322145, -1.864738578579176, -1.397866548813378, -1.4470271623753899, -0.3607784514831943, 0.045921234943925617, -1.818873712864725, 0.9044810705506292, -1.8288471689894754, 1.3466511349135715, -1.2329563105110368, -0.43443096257531555, 1.4056195328891132, 0.5962224242611844, 1.0064062771815612, 1.0861495692223717, -0.2985894755330704, -1.3000970309460826, -1.7759239643958946, -0.5339769564671052, -0.5650638202201302, 0.9001366017270559, -1.0374468736730835, 0.868105624585602, -1.4876388147865234, -0.3541284654912919, -0.3074868293517982, -1.0581280977406788, -2.5781956585458414, -0.6246802077442011, -1.713093651163772, 0.09507379218831771},
    {-1.41795545136042, 1.8335517293908445, -1.2191937789631502, -0.4488940697056743, -0.6199871105040505, 1.608595984181802, 1.4175036129868335, -0.022957689144462758, -1.6964337285268603, 0.06751369253429712, 1.9788978454168122, 0.7551791769917324, 1.145490018899776, 1.7536101320010151, -2.1494703992840773, 1.0014610505913792, -0.6131229501926317, 0.20920461113049854, -1.1400632309731615, 1.156616895460787, 1.340388305583299, -0.4295597291205016, -2.244417980816701, 0.05684000089317673, -0.5799339628076726, 1.7292202298026396, 1.2811697469766081, 0.6741318753146188, -1.2428163732281505, 0.741539714239941, -0.6418691984181896, -0.28166233711668986},
    {-1.3526329054075827, 0.9547387412794383, -1.2776068796576674, -0.9114485235766665, 1.287247242357476, 0.4705276280137141, -0.3218164994292534, -2.5181071560956734, -1.527893114193081, 0.2044841236324442, 1.33725648358129, -0.7419455161580938, -2.1584094162343193, 1.1618478935782364, 0.6280031478108663, -2.506061580708807, 1.0865221442646873, -0.827721482367256, -0.16328027769258047, -1.1594946233721652, -0.11546574111894829, -1.4638343509537979, 0.7242717550420011, 1.8600550299968792, -1.3272709497743278, 0.8797665185720778, 0.5743746823135449, 0.1906858789126864, -0.9217605709187549, -1.056475625194486, -1.0545455659046714, -0.5708105778050425},
    {0.9382512485303267, -0.5510538295951987, -1.0797891818941658, -1.9829082868396595, 0.959844410828065, 0.9172850470514404, -1.3035995336177097, 0.6271760478848908, -0.23647032310147031, 1.0596658259085479, 0.6004136716539916, -1.9162362233745471, -0.9579042970087989, -1.4733776292473806, -0.45676348987699494, -0.6584264203035278, 1.0085528306557645, 0.1431904302630632, 1.26733046834283, -2.23264462259171, -0.2368771805533424, 0.353349033057801, 1.0637556433383388, 1.770956912538731, -1.2182871629978773, -0.03716146449137253, -1.3086946727839677, 1.2397923400852218, -0.4075286196206474, -0.17734315980314558, 0.7424663179751425, -1.1987883884893782},
    {-4.654484463130762, -4.583903623099581, -3.383363159707967, -1.2737291538548992, -6.429494743222647, -2.034643037985223, -1.7001396278723757, -1.5937149152134193, -2.719767463638968, -0.9123150724221437, 1.5043970842214698, -4.6292821003099, 2.7579822390393174, -2.2106305920140956, 0.024336693067680354, -4.573096148376259, 0.437496694962509, -2.044757109839111, -4.292636183302484, -3.1442077248799993, 3.060133498075156, -2.7549792141421325, 0.4063984250851157, 1.9476151515320088, 0.8735337357436269, 0.8110153521892555, -1.3105125467743561, 2.0307106418063583, -2.491869244609331, 1.8485367321722632, 0.533662351003517, -2.613048844255586},
    {-4.658685166951978, -4.772115817690378, -4.129101987594333, -1.810848696900558, -4.91473476844634, -3.050225252619029, -4.02231495790231, -4.950526979851191, -0.5924655767656752, 0.29131218167689454, 3.509414988422104, -5.215114375043862, 3.7093242047110833, 0.018817389447578537, 2.7902277172985848, -4.369959911713242, 1.461950872852519, -2.827011406055438, -3.90195296014752, 0.0627955797102179, 4.439087707883123, 1.0958812459309504, 2.9760239855997765, 3.3484009867858227, 2.605224569716485, 3.1113058796309834, 2.200182244917409, 4.284591613920968, 1.418950932643831, 1.6621693576134464, 2.491761027857029, -3.123699688929271},
    {-1.0999272150748554, -2.549073057039252, -2.3650420434806234, -2.5514588927083666, -0.8136460108305034, -0.9381584869197158, -1.2298000151851773, -0.4561444286893669, -3.473172716942674, -1.8656961715587193, 1.9802860604167882, -1.7340824408486675, 1.9561410774474772, -0.19635058479953918, -0.6341837803227204, -1.0656218118021885, -0.15087186624661716, 0.7984507704888578, -2.3099933395414367, 0.44415093440195086, 1.7129386590277584, -3.1793400660414397, 0.463939143003593, 0.5856844594102022, -1.872437919642132, 1.8089401581665576, -0.4172434728626583, 3.0275242469339325, -1.0091545763460128, 0.8400733836212374, -3.2334650999373147, -2.25876116454282},
    {-2.123407426405934, -3.425890436461689, 0.3821840874341137, -2.2046646532502807, -2.633440137145094, -2.0830439382055395, 0.856196833697528, -0.5955043531032204, -3.434057189173351, -1.766979964464648, 1.419592579117796, -1.2691049571341577, 0.12312982233753585, 0.5243858437675444, 0.36336140058695204, 0.8092283219059503, -0.9277506126861599, -1.132916026581007, 0.09842351699571834, 0.16963033553693724, 1.657482248073805, -2.5190143388991184, 1.286700958785292, -2.7471536989647776, -1.2343675700315277, -0.6432255943447045, -1.026720947678398, 3.2932759200366104, -2.0692561955653606, 1.457451151024397, -0.03597255684326741, 1.4489979932457657},
    {-1.8205787316593618, -2.0387232095994157, -2.086793034953247, -0.8337270809475332, -1.8479724161748667, -1.0209512411256507, 1.2140488020617586, -0.8018280169237191, -1.7675071329666876, -1.1092455006233573, 0.3092423418680072, 0.1650786879960523, 1.6686574947747195, 1.814153014435726, 1.32304756065846, -0.1685404973487873, 0.6078196953246787, -0.7953574990966223, -0.25898715789538, 0.9678660217462307, 0.3907875934199003, 0.29003637440132185, 2.7178233865736057, 0.8379236130909438, -2.9447738372877783, -0.14167259106479893, -2.9243176663018304, 2.686569030137691, -2.8132030727218944, 1.134407229815148, -1.936205201795321, 0.08029213029794437},
    {-2.351221783680138, -1.7107484559060349, -2.3289229151554713, 1.9479214508894314, -1.2571435475912187, 1.0317492971805997, -2.346354531124393, -2.316603585237686, -1.9474021726419477, 1.2656040918454559, 1.2636480211215, -2.8378477387861074, -0.17677380302474552, -1.3793831544588437, 1.3123299838386806, 0.7971077437825946, -1.1142453370403183, 0.9553108153871663, -0.15443885237205154, -1.4544606720395081, 0.4124429441054493, -2.0697684866008523, 1.1252653641407688, 1.5683741665834756, 1.1060103230828404, -1.6542380447735618, -3.900301701179896, 3.286028856541652, -0.7551196765072248, -0.28141202407045984, -1.1896963778753105, -2.073583291593478},
    {-0.36194642993098564, -1.3233423514373184, -1.4163148306873186, 0.9932012124406077, -0.35496677088350087, -2.324124536112862, -1.0248897197352884, 0.7874672975140082, 0.6976062940610389, -2.372214528672622, -0.434243534330071, 0.9167083374756477, -1.2145030669784236, -1.3601121761623651, 1.2152250584835416, 0.0703415219968246, 2.340870302663743, -0.08937577800345074, -2.0101346429769875, -2.031059052944494, 2.1627910257669205, -0.1409172567470178, -0.6186311494726074, 0.25129221389734724, -1.3309118341872364, 1.542144232291899, -0.3478249898938015, 0.1222304429662016, -1.2165230111889176, -0.9299975230839646, -0.4305375704973911, -0.9794389809631986},
    {-0.17994167454500662, -2.206143321702869, -0.19818492340998448, 0.8065570341654491, 0.481390619843834, -0.8876750029464926, -3.2700815348650045, -1.0214849147680638, 0.17860621113816688, 1.0729032604886664, -0.9533914272299355, -0.5483340962513309, -1.626424306422347, 0.19457456851358806, -1.253220684069796, 0.1768566164280669, 0.9739824202776967, 1.7498394150717405, -1.0671190234439722, -1.1822125353218467, 0.5890552479393437, -0.6905269695021378, -0.4765862610700604, -0.19661788128301852, 1.086094763237766, 1.0143105444602272, -1.3249026226733467, 0.5027161575458495, 0.02926013411868031, 2.429860142668862, -1.1234080340506987, 0.6537974110929742},
    {-2.942904148072372, -0.25331519767113636, -2.2036204486238065, 1.3071511875414434, -3.8562167150636717, -0.19391875284099605, -3.0212633235187725, -1.0083195141460364, -1.5298110767088529, -0.4343902067249974, -0.8376511176704166, -2.3780222540166926, 0.09756920918088233, -1.9305398066712085, -1.648006473024612, -1.3034335856681936, -0.07658724075767102, -3.160659870311669, -1.455970827495548, -1.2888960158991216, 2.6093925697465683, 1.7279379749906185, 2.0479334092758106, -1.21608357513168, -0.9426427954243293, 1.6135322189736918, -0.17739023135669102, 2.959901951901265, 1.2032467441516597, 1.8868521766972928, 2.4288630696830884, -0.08012681595082387},
    {0.516823245186697, -1.5605708734683628, 1.2593543820001913, 0.13025246148978045, -0.8447637340765043, 0.7438628094551066, -1.186592203562546, 0.2069427052089796, 0.6545555241223344, 2.08218661718735, -0.13840317876440825, -0.6794867789099889, 1.3005170301117708, -0.45382728621206525, 2.6710464331354107, -1.1362215953035697, -0.2528604939764238, -1.356816127259957, 1.1549516650243379, -1.2726865733681307, 1.9396298603746376, -1.4998210327517354, -2.0043562755431235, 0.6869490873764097, -1.5651702889328365, 0.7335055131241571, -1.5769722848590997, 0.7899269009112351, 1.857260224378462, 0.8628269918934984, 0.4362853558393987, -0.2353810522769979},
    {-0.05786915133228464, -1.786000850998424, 1.4414606219810535, 0.49126087707767013, 0.6698472765029039, -1.3440984199453094, 1.131008434365702, -1.424471474184049, -2.043057543823912, 0.6802780633335809, -1.350747446253671, -0.33980837707642036, -1.7224937551308839, 1.0173775202986346, 1.5841436885782116, 0.2800076633982051, 1.2235207074071894, -0.4409606161852288, 0.6960081430992269, -1.0713692632118266, 0.736888741673266, 0.10786083707577257, 0.48092061226421123, -1.1259915899227388, 2.0433619528221665, 1.261338449261009, 0.3348945642759462, 0.9634697939481921, -1.455488634559065, 1.030131155618133, -1.7083870262580152, 1.9063751731202472},
    {-1.7450258609701528, 0.2878714821828187, 2.053565857498349, 0.9056224961510282, 0.29836648873722654, -0.5267153662961792, -0.8159974127196957, -0.7270123990677932, 2.0074687164038045, 0.9299740129414403, 1.5876501134695709, -2.374502466521439, 0.7204797910549323, 2.1659582402301516, -1.1718119899416566, -0.5133870820813882, 0.1240912688442813, -1.441515541696672, 1.2537152928124826, -1.3735885922957833, 1.4306330947462595, -0.9003366852555315, 2.495782706323864, 0.8153259434715648, -0.7449958712382055, 2.4360305052075675, 1.148788710992678, 2.6279539800904463, -0.9515539164591116, 1.991448799353806, 2.194476484868898, -1.252418644675166},
    {-1.7926494230097063, -0.389961159134676, -0.023287893527383984, 3.0362386272955413, -0.8399427054932136, 0.21925291076884895, -1.215841156368772, 1.4193412760681174, 1.0291728619593306, -0.18119092990164817, -1.5931531615090624, -0.7729327486625518, -0.7364116433279577, -0.5270782138848767, -0.5401107550807314, -1.0828964699035866, -0.9093760059260516, 1.5706508991898627, 0.024990448889430153, -2.421309028343263, 0.15247958257437522, -0.8150632555809463, 0.9945331274613327, 0.8988583080515379, -0.87716287012506, 1.2088225105595143, -1.8180618181698402, 0.5689057357473412, -1.8337211811633576, -1.0701001725191257, 0.12661225495867987, -1.8470256845133},
    {-0.923141704116804, 1.153867849601772, -1.2405218219118794, -0.3283278076338227, -0.6426525960136962, -1.7974246382971129, -0.06225704029446722, -1.561274735748529, -1.1005738997795826, -0.22998841276772283, -0.7734634220156924, -0.04491824101587885, -1.0791598183037259, 1.2458840428717568, -0.3169694206649649, -1.9390921971064974, -0.495838087437727, 1.781842582818883, -0.4670758546891927, -1.1925325209234583, 2.3707930058266684, 0.8586825567680532, 1.1662234377000513, 0.9829241992884173, -0.3759802918175946, -0.3358829888926032, 2.0904083523579553, -0.5413352806854675, 0.9586725310875974, 1.5442686265582966, 1.965254147839816, 0.7984034274648178},
    {-0.555701598630068, -0.2679819334984914, 0.16919631695750442, -0.09886060234396771, -0.20437847609643012, -2.688134871651756, -0.2994947367966934, -0.12246439127720722, -2.655476942766395, 0.6251708537441273, 0.21495646834344792, -2.2967540738461505, 0.33934927926179276, 0.5533018327143346, -2.4877014380355598, 0.900970030055878, -0.1775123031194017, 1.1068166585975292, 1.0044575152882012, -0.04059531513348988, -0.11125647199084139, 0.8174297396687892, 0.05877486526108189, -0.6743487032416888, -0.00256975765028973, -1.8377868115592528, -2.265201817754731, 0.016899141476088713, -0.699638964218526, -0.4508097181012082, -0.6566091137203153, 0.27356232521299845},
    {-1.92362199465599, 0.41722119356216364, -1.0787637720030705, -0.5583351552811955, -1.5175990485577915, -2.6904810467174176, -0.5041081523962998, -0.24947017334070506, -1.462580451409022, -1.6121433492046255, -1.4263357694042569, -0.3710422085780125, 2.025915924098178, -1.0987082810876923, 0.7976668540688021, -0.34999240991717273, -1.030687436670975, -1.7227495911527175, 1.2636289118975812, -2.799324642611835, 0.90925003503516, 0.48168271247102096, -1.4055768492591978, 0.5037427956981493, -0.8849179613768454, -0.3128534649009779, -0.34498360981550025, 0.057842484166343335, -2.180039065525225, 0.5515049403608261, -0.3596680701413805, 0.2795470633366278},
    {-0.945370537460736, -1.5114190420012843, -0.6732330320797784, 0.35480835311860687, -0.47646806599958824, 0.5298594123570898, -0.09975896359006074, -2.3818876089175416, -1.3034408995716265, 2.7116496989285466, 1.1659461014255283, -2.303002032243861, -1.3419390341220627, -1.7527897751468626, -0.7193469724059879, -1.794723505034692, -2.2378924827622035, 1.4296397382289785, 0.9083772581593009, 0.8317434816634566, 0.018493623400655496, 1.3456206698029363, -0.8547271494568139, 0.8738693098204636, 0.3792722955601793, 1.0253570509809955, 1.949174657995072, 1.4944284102123138, -0.012418580108648412, -0.575070941246937, -0.9724700671339312, -2.1675356816442863},
    {-1.9072174904452985, 0.23627396381754104, 0.09400841412200565, 0.18399974683911885, -1.4104273985770872, -0.980413705916756, 0.5131567538352914, -3.28627230508143, -0.808918758038815, 0.20628054564393344, -0.89524388693398, -2.117349766892074, -3.0359290752698342, 0.1571100094047067, -0.4528209248518794, 1.266741127755985, 0.9237832366177146, -2.970631999529813, -1.8729184965219963, -2.2392736404808233, 0.1159658052067118, -0.9269981071853272, -1.5692318524308708, 0.12630923990577989, -0.6406184664595931, -1.7296122685760633, -2.1088500623343354, 0.0408337524568633, 0.6371858028616318, -0.8935228657592551, -2.6540180770099537, 0.4589325932213357},
    {-0.6191776773195331, -0.1937717078317938, 0.7480911966465309, 0.7389730522962124, -0.8912294473539749, -0.33070677822943867, -1.7260186845495231, -1.0696991648529985, -3.362943679684603, -2.4314107523063164, -1.3434754801917805, -1.3910956743600282, -1.5353145981737482, -2.6513498878448054, -1.2243246473755596, 1.658424944814823, 0.7625006389345139, 0.4913993239086784, 0.2316174756744499, -2.2573840565731076, -0.013693678702706808, 1.211782110088205, 2.414286189623576, -1.1656638029567443, -0.9621452669473193, 1.5071359992825883, -0.24065015354295738, 1.1540997683814285, 0.6319400813137594, 2.1209091972756005, -0.8287477128046425, 1.071916940628903},
    {0.05166274348053356, 1.128400535183524, -0.9132965541716835, 0.3755492344673973, 0.8338071388604262, -1.618621474640308, -0.07778983250740883, -1.87943167133393, 0.9799168595421854, 1.3144307424678716, 0.04582495428045829, 0.49092810202721815, -0.566682630217348, 2.100446688887973, 0.18315492025893898, 1.075313876985069, 2.595210957930719, -0.2259852461650898, 1.171023928915855, -0.8084450923451583, 2.234464506284054, 1.5947695190287838, -1.8156950897475141, -1.16549754314245, 2.602833867159256, -1.5914077983894612, -1.0486114073692612, 0.03472161620521549, 1.550570926300492, -0.9527605403222036, -0.6887962911117523, 0.9156820551183419},
    {-1.5842405834472084, -2.182280065910588, 0.9591060892673446, -0.7305339957937274, -1.4815839905426484, 0.03572127160847262, 1.4425656686207102, -3.1520142671366282, -2.2793201578780122, 1.3236437417881686, -0.6305185697857052, -0.1954103692454243, -1.8951164412729316, 0.4263835156501054, -1.4169880705330486, 0.41657457146482535, 1.4700748128443808, -1.5454053288126899, 0.42741298290390844, -2.4938765387499884, 1.2931050622336415, 0.3349168639294345, 1.2923661222605791, 0.4909638568344211, -0.2894326859391716, -0.6334678307584882, -2.50001451596048, 0.7687812667218187, -1.9823388115396214, 1.9040372904635703, -2.7221550756681903, -0.3925707076102147},
    {0.011642926871932257, -1.3671557175566884, 0.04820314195657205, -0.711824641446207, -2.161366989310691, -0.46852905081732893, 2.0147642337328793, -0.18330347535415767, 0.008311881940734197, 0.08490216922715811, -1.1441393245875222, -0.7673838481641018, 1.5359630301393283, -1.0736253879430646, 2.787290610297122, 2.060917709454207, 0.5034411478319236, 1.4459594729202239, 2.4238461406222283, -1.5258959974393236, 2.0977871656960785, 1.5364493477336487, -0.5464083139853967, 2.6389650421937767, 1.1645460297702184, 0.3226324106230618, -0.41074354873998126, -0.29160665060588703, 1.897314654420697, -0.07241314732965164, 2.3888452563899563, 1.5068965980716458},
    {-0.5167066193782294, -1.1047094062555536, 0.14335750332900463, -0.16374712505173036, -1.836868085802391, -0.6917466188870173, -0.8753763451568917, 1.2410970417852092, -0.6588374072952066, 0.8141531165584945, -0.07519444889660153, 0.18846203350758348, -0.21401466934715221, 0.7483454769048461, 1.4323658808594846, -0.0036466325504717493, -0.6236455254787286, 2.5488482171493696, 2.0809314699809462, 0.3601561444350218, -1.4542452096791727, 1.1983114830870039, -1.0084107272177676, -0.9754821120877509, -0.8818633071154807, -1.430265628798819, -1.339291699381686, 1.8078976234814648, -1.0011029233853352, 1.4335522019192435, 1.293578174644385, 1.0653294361763128},
    {-1.496536139088704, -0.6589704667100774, -0.015090687128778554, -0.9103515082335552, -2.293264533730528, 0.9089420406255645, -0.20641054609491397, -2.582680986956697, 2.1186512609083956, 2.449372340090714, 1.577266825030916, 1.9425809327011747, 1.424391403328066, 0.48769745919391094, -0.3765737798393491, 1.873311432059239, 0.3897310201749657, 0.27863519581088697, -1.1632018280492544, -2.2261905743914587, 1.5467221356058636, 1.804697499591761, 0.9336132865182843, 0.48254237405493755, 0.8493014592561265, -0.018929799819449387, 1.6556966139910776, -0.41515361005249884, -0.019271109674650205, 0.6758358272223611, 1.0929251185213995, 0.8531031364575571},
    {-0.12044101408096623, -2.517431847575204, 1.6930617554963883, -2.350982411846984, -1.8197543907717002, -2.38667261575628, 0.29477110783285704, -1.8894017932743554, -0.6724202374193844, -0.8573105877669674, -2.1739517752028283, -1.517083263702391, -0.012787596482476437, 0.5148732036123941, -1.178323147231808, -0.7441238914379371, 1.1246631031396106, -0.8778183157855388, -0.15849419167242135, -0.4898406833310085, -1.1974451941915614, 1.1286269191771134, -1.8253976469670683, -1.062256924345084, -3.0579719235612792, 0.21443650904792322, -0.3659828597850027, -1.2777879077922762, -1.3991969695677833, 1.365811777897987, -0.32619481623628765, -0.15804934832796938},
    {0.6590716472494663, -1.5118779410627494, -0.5365476400922496, 0.8968437738899238, -0.017786036972141872, -0.4250204922467645, -1.6833847419704489, 0.923636662973355, 0.4063347730114837, -0.3269758295314725, 0.9353849095343602, -0.20657197902688612, 0.7738003250492828, -1.8736323945044924, 0.5980866061001341, -0.8782705044762191, -0.47679512961272885, 1.8926936546848898, 1.583090800518431, 1.151808847226321, 0.7194019376460631, -0.9675475841916972, 0.9997466326955503, 0.48070980186087564, 2.365521948790788, -0.30735619233780026, -0.9553458110757252, 1.3788927369882564, -0.7891640838028403, -1.0516973433670234, -1.029175123539493, 1.3877740363654307},
    {-2.4234609768422803, -2.08264516259174, 1.2079103018617396, 0.11792532755632247, -1.2444448565510258, -2.4955407435273753, 0.7885198927884834, -1.1707404096233895, 0.43844316246573733, 0.24753874628870517, -1.366183979814815, -0.3665379435417162, -0.3126282035718326, -2.8425311906954134, 0.6028048188902626, -0.006611777904904914, 0.7453376195005228, -0.980412118266615, -0.91383472104612, -2.848830750186335, -1.3756961064831421, -1.2740141293083338, 1.7405290922547787, 0.4548507498371508, -0.7734691226006084, 1.0483601566207539, 1.4573530580177136, 2.4775783894713, -2.6595640303884753, 2.492033821553219, -1.0098121902086887, -1.7178696903818083},
    {1.1338588128851996, -0.14534461416399092, -0.3631365489209623, -0.7625731572661518, -1.1877895400306469, -0.9791751564009731, 0.5277299116978476, -1.916173041283723, 2.105607934949757, -0.13310412321349607, 1.3339394218786482, 0.3598382055891134, -0.11763633029832811, -2.304844664867458, 2.515341754981033, 0.588652922174883, 0.26874537827389255, -1.530434564878099, -1.5534743683973484, 0.08551034331891384, 2.2366695572629545, 2.1996646700080107, -0.3814336142176094, -1.126307908338821, 0.5511071179274754, 1.855035692013537, 1.5791097653562258, 1.6020643067091047, 1.6633276283544323, -1.164636714228367, 0.8161557850412205, 0.6150200883453029},
    {-1.6531840853975408, 0.43124064263524525, 2.5923174262604043, 2.550603122925811, -2.47382005347943, 0.22166500751466417, -1.5111130022900598, -0.015768205473418964, 1.481767238272471, 1.71498744093939, 0.3360373337694375, 0.6667747924633031, 1.2513870460712937, 1.634417414444637, -0.6383074820684231, -0.7463643994003055, 2.966168302384694, -0.5148900172674287, -0.6863402668937932, -1.0521159184567421, 2.7820021862895477, -0.1399080485186503, 2.72756704943373, 0.7140145750782849, 1.3888408216359578, 2.9868422200820843, 0.9731236264105986, 0.8563819297927885, -0.41338011801120317, 1.1836159569312905, -0.19525062900819082, -0.8760975035529392},
    {1.598158976382633, 0.165198977742809, 0.2529707667277696, 0.527000930326476, -1.80129018502987, -0.8317981374976537, -0.8977751004877114, 1.1299866724164733, 0.3828343771670907, 0.8053575837079745, -1.6992133104769376, 1.142583959757604, -1.8974068766727736, -0.4136485024090223, -1.0256035857772163, 0.6245472597634708, -2.014046673140153, -0.9554114602361449, -0.9342618835834958, -2.7271026550059094, 1.7711326055353334, -0.7829752922407747, -2.6661453729378946, -0.7290202606902083, -1.8471716496200987, -1.2747915843511548, -2.0412110332336613, 1.8973191485674126, -1.0073518132347605, 1.0995345213825003, -1.4290342860013032, 1.197471580019898}
};

static const float b1[32] = {7.924105849251169, 7.818311585835101, 8.12502580639681, 7.89807390736297, 8.187651516771126, 7.822819746114827, 8.224269443031044, 7.988020336235144, 8.084194377649432, 8.120215752078312, 7.573898560053405, 8.276598707511083, 7.412292537308442, 8.152774237294146, 7.906106174365555, 8.45296563660012, 8.278920403983408, 8.16909531096793, 8.078925564980008, 8.192002618426699, 8.218467143183744, 8.081388976580813, 8.299000098354236, 8.508823083099891, 8.11306108047021, 8.148185892720932, 7.4797531598367515, 8.234590867162613, 8.165053060800824, 8.180699990478779, 8.24678321589404, 8.017565515533255};

static const float w2[32][16] = {
    {5.564754744548536, 5.6153197999051265, 6.374177018316999, 5.976802277010632, -0.1062063512814375, 6.4194642890920575, 3.024815342466262, 5.008346203549647, 6.912635861646394, 5.479958787566446, 4.762240985236302, 6.146753577003908, 7.443182101221832, 6.1891966918473305, 7.287255115735477, 4.931986778720782},
    {6.4477888003479675, 4.160732564673637, 6.247459460307275, 5.499551868622488, -0.8844767424607881, 7.400485067529033, 2.885241127559978, 4.905130421569147, 6.312320763727446, 4.36584482562136, 5.047911834796618, 6.791459618818614, 6.139742581574527, 7.402035617134049, 6.689289923663972, 5.049331225802603},
    {5.071382414373891, 5.564868176314054, 5.9121444987217435, 5.291450733147015, 0.2619386841132976, 6.69976407880198, 3.215643086285776, 4.9394959976907895, 6.099288571962951, 4.266575040091564, 6.421714853241726, 6.124821043529889, 6.526569295915516, 7.81817532700575, 6.005591527808507, 5.156005079649666},
    {6.478213064817554, 5.935996889067221, 6.8666777455816375, 6.3457493427050125, -0.1472019715718924, 6.839327804655074, 2.779384669352711, 6.275669702291762, 7.4418554463042, 4.512375764256754, 5.5577319498991065, 7.091252529069128, 6.674742145494938, 6.132625167882718, 6.6616918440567705, 5.353844861369487},
    {5.484389624835122, 4.741026469487414, 6.679028561262148, 5.718246080797605, 0.27354603720867454, 6.6295232253065866, 2.8315554471408526, 5.329687067543743, 6.982814100956168, 4.801119111411844, 4.304473080324907, 6.3207183337786015, 6.669996903841531, 7.144192954563441, 6.477408173402819, 5.127875534449527},
    {6.396843302494449, 5.052500821872199, 7.121191755960355, 6.325436624794147, 0.07061939729472674, 6.012195179095823, 2.772949939925536, 5.32677489341232, 6.021683898915634, 5.003102034782509, 4.478789442956118, 6.662949237551402, 7.032095316041393, 7.818201054994438, 7.195493858817327, 4.3582284722503735},
    {5.69099160495492, 5.6085301462178005, 6.266314573024416, 6.476867841871449, -0.960330139340016, 5.891906704820376, 2.006875294578022, 5.49965786456641, 6.060395144249505, 4.886034555688994, 5.93616488627654, 6.381088848178875, 6.623986587170138, 7.875851119457549, 6.7216833490766374, 4.30702452172252},
    {5.922365772186949, 4.589722439116802, 6.65503249773657, 6.025221831608716, 0.0007508579703923698, 7.1716856203419335, 3.2591286615400064, 5.090223532482776, 6.76553151247894, 5.683746915509341, 6.0422524669999085, 6.763435340686621, 7.544338460310953, 7.304438267321148, 6.66821978538291, 4.444095524131717},
    {6.102521379674287, 5.39158292460008, 7.371771551739018, 5.514569935831018, -0.8954024118771036, 6.175729323464311, 2.2670023861895623, 5.527373021651143, 6.292114885863508, 5.606909912482297, 5.192486227017213, 6.094978796484452, 6.432579431662879, 6.870321159806548, 6.802412628245784, 4.811910931868257},
    {6.028799510502741, 5.574282527511496, 5.83358905081811, 5.565039997693636, 0.3523672358311183, 6.242321966478901, 2.4256478050656605, 6.307776027231842, 6.624989721766335, 4.115235795966194, 5.214340111135651, 6.882601461533741, 7.417674739578057, 6.139758245574359, 5.429501233765788, 4.651643653338898},
    {5.269729375077787, 4.543707285105362, 5.648883111157542, 5.9864838946792664, -0.0693394327358198, 6.694890245560972, 2.2433136780644216, 5.0400339324258825, 5.732772909709663, 4.589545947046873, 4.344153353952012, 5.3069130630635515, 5.630538333627615, 7.099263934758738, 6.809197687332408, 4.452065026871497},
    {5.120503036720664, 4.387398935012631, 6.59480897935838, 5.314597214940379, 0.16294168157176295, 6.752667251573139, 2.7325766696405966, 5.779362935150059, 7.552983879285999, 5.326867982068476, 4.799279856560853, 6.8402860158845264, 7.644990643971991, 6.374101809516807, 6.808464652571306, 6.040642465822614},
    {5.967510406068155, 4.17854440247416, 6.933774810166422, 5.768742602993933, 0.5041052169451776, 6.326050893630285, 2.8759286644105795, 5.722703806589475, 6.138330142425985, 4.110521405854821, 5.284777069111971, 6.977406293192917, 5.856696882741502, 6.465609321356086, 6.953529032950606, 4.456344758014192},
    {4.906696070320391, 4.2146211764771, 6.673648356209948, 5.866897324055304, 0.009071008325403638, 5.6178086433279715, 3.176617703875453, 4.749796809679176, 6.570005239431657, 4.742828701002346, 6.146033423085911, 6.223773325129842, 7.4880452131951305, 6.21115673333808, 7.033866826541258, 5.174175013863077},
    {5.940871554283513, 4.335794121941543, 6.096843551082994, 5.153935921847389, -0.5205188846557015, 6.737036709236323, 3.6598452557127374, 5.5639173066473955, 6.519080494627407, 4.584954615557156, 5.3816485448610765, 6.741050929885381, 6.845674459582114, 5.70406403811023, 5.629719715045213, 5.069077886632091},
    {5.601573084510167, 4.652395897707424, 7.495553606792649, 4.948672474828059, 0.37814980165861695, 6.267086940784816, 3.758064136085607, 5.109350593633476, 7.573639161420535, 5.130054816835287, 5.368924730523156, 5.732262796001572, 6.672339010376744, 6.891040085383291, 7.3822384349400725, 4.580300009073413},
    {6.187419266458902, 4.245464457343498, 7.526692698203422, 4.986092506942654, -0.6900762873807015, 5.804837486486698, 1.891449425637871, 4.842478840839328, 6.436422791188992, 4.430126883248202, 5.0898652780668, 5.251081588177763, 7.023101402803792, 5.867813765196335, 6.045911744326199, 5.838914875784727},
    {5.8506995473241465, 4.3686380001279925, 7.00430317796941, 5.555848738961127, -0.786893415244151, 5.395579039850891, 3.066250759119429, 5.166440233352545, 6.233014034533918, 4.835194623981201, 4.601800455169141, 6.194022488075493, 6.200537307540693, 6.653143525873337, 5.646924791072856, 4.124291034337277},
    {5.562149505951845, 4.324970045396184, 6.835560608622203, 5.884416570610097, 0.5672184342561362, 6.165050063838436, 2.8088826203695123, 4.956987883497773, 6.958679595568418, 4.8106565415834295, 4.688738525744814, 6.2123305799009145, 6.170686684338159, 6.956126306263263, 7.376549117011127, 5.50145303897608},
    {5.78897080575281, 4.661239145852359, 5.56931690214196, 5.212924855946146, -1.053773853234153, 6.6185043700654935, 3.11050865324049, 5.920266265629886, 7.376505889708268, 4.084906435614736, 5.1532294221009245, 5.86347432755006, 7.291459822020323, 5.993755056442517, 5.988738993855848, 5.241637912163954},
    {5.581385311365817, 5.242711049022913, 5.6526809421187885, 4.582206280165469, -0.7550136001525978, 5.541367444711507, 2.7134142403030377, 5.05810359688425, 7.056590485881705, 4.267481233958334, 4.845698267450536, 6.420811061214266, 6.166172454884224, 5.824556000839722, 5.346916826153039, 3.9326812727618634},
    {6.3541256943365685, 5.76490963170715, 6.780694310433646, 5.858302563395523, -1.026451265909887, 5.991006913096676, 2.470349938377906, 5.708932784798007, 7.875514445836382, 5.723309611845825, 4.296489106286838, 6.578596599474843, 7.622427243156313, 6.448412835893753, 6.984708113579254, 5.6431299750116235},
    {4.6910078102674095, 4.976067682509142, 6.582223585933902, 5.454700069102728, -0.5596308330058483, 5.925902706980314, 2.8481571538540966, 4.595438251404242, 5.944048476093963, 3.7844722467074607, 4.531245657654468, 5.91454941886135, 7.179141941402739, 6.19358430675516, 5.537499739199813, 4.996047979127391},
    {4.557099276896556, 4.239364635934792, 5.656935928271964, 5.603453930778926, -0.5015215860521924, 6.371846441434506, 3.403687739253716, 5.7416622528485926, 7.290027956429569, 5.567766789838515, 5.065199560174815, 5.342169783448075, 7.107583938100113, 5.830680423026504, 5.557550250397812, 4.842044144435693},
    {5.109996248079605, 4.4280295441390365, 6.2597643930646285, 5.198574769890412, 0.6284849244680357, 5.473777933056286, 2.3027747893888746, 6.154296078500951, 6.497633929810046, 4.294626912639979, 5.625431237129748, 5.557666251290705, 7.298759716646691, 6.522603572262336, 6.646509032972039, 4.317209230517913},
    {5.161848845578424, 5.602724941039895, 6.898611149799154, 4.575311213066879, 0.5589773819286087, 6.192444548914499, 2.2182957437328215, 6.36938327537331, 7.171032508695099, 4.887314301283878, 4.5584172691156235, 6.96703433309107, 7.534591014474355, 6.146930042971924, 6.335202311072246, 4.925963597140533},
    {5.704279493470987, 4.051130481865933, 6.611409716548192, 5.576134038756467, 0.15215930458074117, 5.309063912774444, 3.515504381673666, 6.246770077605227, 6.517675369809736, 5.700966290351424, 4.926156821106699, 5.7542847723468125, 5.974158559907266, 6.183020414502154, 6.307266382484512, 5.28858633194734},
    {5.172839486772445, 3.926453861923152, 5.719138207864331, 4.648498063821746, -0.9311328044331691, 5.622209287275564, 2.098562586057358, 4.356627927037571, 7.446149768222009, 4.809767236407603, 4.936101408000036, 4.8958319043110246, 6.433991967096672, 6.869491089601922, 6.29171875661035, 5.308064499234101},
    {5.131096533963971, 4.076672452733914, 7.114713648563778, 5.8916111508150255, -0.7655349686806152, 7.1887487871880325, 1.9126340772509267, 5.938834922352369, 6.782337725161841, 4.855782263656662, 6.120455622234653, 6.552427035640497, 6.468820311927471, 6.770698657804698, 6.3617927516684905, 5.29202679151241},
    {4.930414249638542, 4.549001247101144, 5.825313508438367, 5.601604966268937, -0.7494896625568461, 6.8417680904018505, 2.659729357570527, 5.470234925285471, 6.307698468279048, 4.9528237059159395, 5.41924193976274, 5.182035175351279, 7.494418728279207, 6.597629636118596, 6.560856104895393, 5.66524246833599},
    {5.831445352893597, 4.2599615181402655, 6.73831853177951, 5.243038711156032, -0.08856793491795913, 5.908138227931314, 2.2764342218041853, 5.658664471282692, 6.608665761285511, 4.506322126457195, 5.206209376614192, 5.780564478061866, 6.602791614038079, 6.684751969820317, 7.112061152812971, 4.6568246794755215},
    {6.50034686416342, 5.932695327361749, 6.729703410637369, 6.428123661748822, -1.2327675875814856, 6.6770976105302005, 2.510894641263043, 6.1609690013578735, 6.626322358420974, 5.486130368320789, 5.360364274612696, 6.539835457233083, 6.098726180992856, 7.7570471378289145, 6.690287779414924, 5.108715042043567}
};

static const float b2[16] = {6.098872822565321, 5.65841378298341, 6.977288342567985, 6.124422436781422, -0.3427550610853597, 6.719991640434839, 3.5247728140958166, 6.256980215147613, 7.219112211594653, 5.514272615632557, 5.928495079361262, 6.651246182187455, 7.10592595733352, 7.15872908715837, 6.709265565298722, 5.567996738522377};

static const float w3[16][12] = {
    {-3.6749670091750364, -4.538027334327614, -3.6958865821183267, -4.5312517593253645, -3.977122690985582, -4.53744455156635, -4.223484258704248, -3.521981105855382, -4.946131055453879, -4.792803682278575, -3.453121174148608, -4.543881609972637},
    {-4.447830365891263, -4.091053498073291, -4.707194622697008, -2.9536840922245466, -3.0941602519151754, -3.2562251456906064, -3.942677871288501, -3.025186217178522, -3.3874534950267323, -3.2490035222102116, -4.415704671985477, -3.190206237271214},
    {-5.352465234216001, -4.9925442056277305, -5.54001591792373, -4.8717916523892955, -4.518689010063754, -4.205063446976532, -4.345357859837412, -5.349061160350654, -5.494251372782319, -5.1622111371675565, -4.784411424699633, -3.8828851762012833},
    {-3.341849697538842, -3.526308019312503, -4.584310459246164, -4.3005947227179595, -3.814992679396998, -3.6934410162196407, -5.216665118337524, -4.161357475611363, -3.548039728023582, -4.629690535267518, -3.7705832203760283, -3.5936712972346285},
    {0.6730645157295183, -0.4727730451319866, 0.6564104451564711, -0.12311764247418128, 0.24104524078049933, 0.6818826571836991, 0.7389015661357603, 0.6889285208359273, 0.12839893615839856, 0.23733361921001278, -0.16321913072482291, -0.4006677299279731},
    {-3.4985287513312286, -4.044363127601197, -5.374960212504951, -4.3743043179526975, -5.321348914681202, -4.631622335923234, -4.810714273906705, -5.5952401715042495, -5.110672883411536, -5.58737172612743, -4.482694290161754, -5.618284107609953},
    {-3.0347179270819575, -1.6320767368040925, -1.8101013353909605, -1.685239426895711, -2.7717816721682476, -2.5141489662078147, -2.0893701921145715, -1.5625395209609945, -3.371111125971128, -1.8243013972975404, -2.283726815184252, -3.423894274472627},
    {-4.971164126585609, -3.9638586376146074, -4.083290345867585, -4.42461210412614, -3.2692216633219138, -3.9780246114224083, -3.8389042703783125, -4.4941899136707155, -4.665505026059426, -3.94420052986744, -3.5517447430368008, -4.206599657875326},
    {-4.2034611382835445, -5.365940599808073, -4.769141042666275, -5.4673974859929215, -5.75368180364378, -5.6725520608064235, -5.651855106075715, -6.321786799087317, -4.831511197015403, -5.332784230243107, -5.745531982194774, -5.551514299974328},
    {-2.907841592605638, -3.509244378670331, -2.91181328195854, -3.9913950334553934, -3.709425854817825, -3.0588083476646446, -4.055467318405418, -3.913398993190158, -3.5261015972129277, -3.3011124742318247, -3.358044191869647, -3.6748461220510746},
    {-3.4489210040677443, -3.5868450119940865, -3.8602935500337714, -4.5738889007883, -4.236008403136964, -3.1953363740254623, -3.96361164398735, -4.066003644413667, -3.8209575064568035, -3.5394615508489915, -3.072920326938555, -4.433175925416671},
    {-5.0471382221970735, -4.602559715802706, -5.105990416757453, -5.295861113012976, -4.695354884700055, -4.788207107691231, -4.004791979969946, -4.053668102053319, -3.9661653481649455, -3.7126810197850655, -5.640697764850429, -5.357964651856257},
    {-5.884584240995815, -4.956723284709819, -4.731021450638229, -5.635811876152027, -5.011467284921271, -5.642977717645389, -5.366307253264933, -4.322985827365875, -5.357811104499647, -5.421333063613566, -5.025409396326093, -5.177242303333393},
    {-5.245588964974746, -6.2995931604913284, -5.9365791650833915, -4.806003319784631, -4.675154771837739, -5.598024683476994, -4.501949670088589, -4.442281246777223, -5.411674866367951, -4.966232501467813, -5.868715018556062, -4.511522558998146},
    {-5.76063459833554, -4.9080362156001, -3.928958469811701, -4.153807828562118, -5.200624639567466, -5.518445688399133, -5.481367687448775, -5.125758183027164, -4.439644744959577, -5.244428500190341, -4.361217583365764, -4.806118200290353},
    {-4.0292062560654935, -4.0898726574427435, -3.1833554956494647, -3.0993660424904035, -4.707783985039001, -3.900069246180821, -2.973488711396807, -4.1615053806400235, -3.0490475498339613, -3.208400126553816, -4.623354918522956, -3.1571241782157973}
};

static const float b3[12] = {-3.028206428047907, -3.1339128014469595, -2.989259564756024, -2.945703093089833, -3.4818923832324176, -3.2567552064835996, -3.419060871353769, -2.268588606616579, -3.416974119014763, -3.4794182995781897, -2.9068948384690825, -3.461458245561504};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
