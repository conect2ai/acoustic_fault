#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.5234390527658564, -0.4828908831500812, -0.5721066938702652, 0.6778475413243842, -0.6816351413366062, 0.04765578421208298, 0.13706229668508021, -0.5811796936696689, -0.15658515366670034, -0.3045067073323758, -0.4344025039449249, -0.1685650114274154, -0.6487490598542728, -0.6876571573445285, -0.6504238736131168, -0.6225904149945413, 0.5190432953094999, 0.36739366242302113, -0.9502095236922493, 0.6744428755212448, 0.43900375171843986, -0.135317449943381, -0.3919111824411352, 0.36181301788011, -0.2953453078574208, 0.3116642880839869, -0.4856146291027199, 0.5760996349770188, -0.7772689536112353, -0.2046781863264746, -0.3492345624201231, -0.5302356217063194, -0.679032805044944, 0.535317585507841, -0.2678180106845707, -0.23278945147827523, -0.2826230796815975, -0.33335585974933557, -0.28558582382146125, -0.7091386725407718, 0.6668479281123845, -0.3484604048322468, -0.47582910142497814, -0.5698766850071658, -0.6017115299773464, 0.4278441295625113, -0.5342392531591821, -0.3573191288199207, 0.10788612349016395, -0.38235619328784054, -0.783325604060565, -0.44693875386857224, 0.19585875765132507, 0.6882892684689699, -0.3580214416591786, 0.007391321185460785, -0.5394685200279893, -0.6018596161145296, -0.1978627489201396, -0.6104087494809038, -0.5177498801795075, -0.78127325050573, -0.40044675213994035, -0.6945109803753965},
    {-0.3881791059188236, -0.5211351201344193, -0.5244034222736708, 0.7198021043143313, -0.6635338791695369, 0.5639654089675824, -0.1424503141968809, -0.7097584783566482, -0.48955415420120296, -0.766158923776655, -0.604797770604185, -0.49220184100573305, -0.7809396270522223, -0.6344496104851931, -0.6471291166890968, -0.346100632492791, 0.4200616199347225, 0.6010094373745041, -0.7846945109823459, -0.38030832301322104, -0.06922555988519195, -0.607177253071234, -0.6307719109062517, 0.8315978732869127, 0.0279446496354541, 0.04224491336099523, -0.026158505331702088, 0.4841924039630302, -0.9810931033865105, 0.0506545623872047, -0.2335157000502213, -0.7886719688719644, -0.7975160617241707, 0.6525982936725944, -0.7055137002514249, -0.9076073518881822, -0.4588032624725565, -0.7709624932837555, -0.8129378868563012, -0.3718947226614816, 0.42622993172806317, -0.5323359097086423, -0.5901170604356937, -0.9821910403380125, -0.6902749690935861, 0.3738124108462791, -0.2845416530893065, -0.717190530749031, 0.2820759849115765, -0.7646281770107471, -0.40012702378379034, -0.7220316342217247, 0.381693817551052, 0.6867809554881353, -0.24096125534138646, 0.4911762539810878, -0.6120075207604074, -0.4944373684091488, 0.09020854565781722, -0.4285195563985798, -0.4451278829866964, -0.48270053876457536, -0.632110200122807, -0.4643582855438481},
    {-0.3612854604657549, -0.43722610528381983, -0.41332662974302603, 0.9166643299238378, -0.5628176932598302, 0.7794789103795574, 0.2962919038757252, -0.6151373295695417, -0.557234478318857, -0.4003813330328671, -0.6931580157776139, -0.47431480743245485, -0.6713346441699841, -0.6261611892466985, -0.5226478828793254, -0.3823570783229246, 0.5254497810069279, 0.6576527320777054, -0.7804905329041323, 0.5848342476397949, 0.7129668922949276, -0.6186401131161725, -0.2919986255471047, 0.6392901670439162, -0.10867689677500705, 0.33165037789680474, 0.10035817118193971, 0.7202622543749503, -0.624932945194521, -0.153446200047833, -0.49547064819872977, -0.3863763306731577, -0.6820801112433202, 1.017190990898734, -0.716453548642022, -0.7852792114938444, -0.5347516069800412, -0.3597363125381762, -0.7499071682839494, -0.7483679468171812, 0.6471808144131501, -0.38700537114180383, -0.4003389009497261, -0.6187623806761872, -0.6526383148873229, 0.9751889146962381, -0.20890950253052748, -0.6767652528124111, 0.25524405411284046, -0.44006901296056977, -0.47180202669420385, -0.7433685712813474, 0.5153150054075762, 0.9986097730090545, -0.5663352954699968, 0.5462456424479705, -0.6642877757005122, -0.7561488488226674, -0.19848771485779892, -0.25416162132422726, -0.6097173097382337, -0.7771045469118031, -0.6710340918308304, -0.3938154811310451},
    {-0.4120003318999544, -0.7339728526014085, -1.1131436376857369, 0.7697618271615687, -0.6290741312387019, 0.5560202584376409, 0.04615527406916304, -0.6997127755732333, -0.7952146071416745, -0.5215270949531905, -0.6878008031331354, -0.5413293915747772, -0.6902782493529728, -0.922270352579091, -0.7066470099032065, -0.6577034567398193, 0.6091872132042843, 0.9009697411555116, -0.6746088926040873, 0.5495395294082623, 0.6157457785901846, -0.35861524286657054, -0.5262326392419165, 0.5408322772532115, -0.2720858039738401, 0.487093861425829, -0.3677337631952327, 0.9952384979047922, -0.6848818484563646, -0.4799582523326977, -0.5847635307119816, -0.7692421810842357, -0.5358433366459207, 0.7005007152802121, -0.53788816229722, -0.8860864716706766, -0.6132422044700404, -0.7361860614631008, -0.6362398986292812, -0.7223874500432762, 0.9420985741881113, -0.39028053828532816, -0.5596464505966531, -0.8493398601528037, -0.7500468199970153, 0.7819862045300059, -0.4236423459497577, -0.8991488755758391, 0.1967041491583747, -0.5840204585454081, -0.7247880550294445, -0.6977076342374531, 0.3074140181326353, 0.9793498862988678, -0.6540633449946385, 0.7362706811560465, -0.6750199707368547, -0.5751928355518562, -0.030241382121577225, -0.5738252083414567, -0.8608377065135008, -0.6910489134908848, -0.8631863986623232, -0.9010514185039633},
    {-0.5084594670446075, -0.7054240498195112, -0.8355185897620209, 0.5885549258828537, -0.86909983988603, 0.6726438725086445, 0.2990849049182162, -0.7801579991073019, -0.6372704894868575, -0.5780726125265679, -1.0279409741156589, -0.5047128767885696, -0.8875850180975453, -0.7383351902960732, -0.8305014662244871, -0.6606018152288007, 0.3676007260883145, 0.47341349650812337, -0.7368997165531002, 0.6876574540985801, 0.5131463309835942, -0.9493185879872256, -0.2729414539383238, 0.7340478999151863, -0.362579713278129, 0.5866764294194594, -0.2803249356177295, 0.35135967414292457, -0.7741525148901532, -0.6024622236970083, -0.6653519595835442, -0.9860441391776787, -0.6949626795783134, 0.2676984587630373, -0.9166086555194554, -0.652263687717619, -0.8851884345401316, -0.7197342183044548, -0.6841305781437179, -0.7295515206778646, 0.6185699660751035, -0.5144498251571121, -0.4958012872183803, -0.6447631157202081, -0.8892807139534356, 0.22966705325146122, -0.7963312577140867, -0.9978305427943182, 0.38048500823153636, -0.3595896248068721, -0.704627050369892, -0.6864435148966508, 0.18733985467979328, 0.6525442890965474, -0.6586257755891187, 0.22754217140206984, -0.789038670024635, -1.0178816309007424, -0.35653712362378015, -0.7111941536910809, -0.5391729208921949, -0.6077070630347745, -0.8775373160228094, -0.8501397595195193},
    {-0.41159398287109406, -0.8473223200015316, -0.525259315942713, 0.22440188824525756, -0.880518213138314, 0.5191540341637151, 0.44015143649566985, -0.467092595527577, -0.7106279937968959, -0.8541383036074868, -0.7754959746571777, -0.9828206870054743, -0.9281630423407392, -0.7433169870714655, -0.6717749860588189, -0.4704346030420352, 0.13945347881709386, 0.5742723484642975, -0.6903102111657266, 0.6455513185485006, 0.2729001973133476, -0.5675879290747887, -0.30356868596163833, 0.5034224872865926, -0.48565719684158326, 0.34061067941896855, -0.5101672040473935, 0.1469213735779024, -0.6927579542607126, -0.44764257332315943, -0.923724676543684, -0.915087300815363, -0.5094144201210182, 0.27244117173329774, -0.41201666400477543, -0.6345190532313623, -0.8169462464925196, -0.6249258898283278, -0.5211521010032766, -0.9555099726185371, 0.6346255887680267, -0.36471031069779164, -0.6049394658428103, -0.5728946118486715, -0.9205859189518655, 0.33515866951058426, -0.9513835249275548, -0.793219987266447, -0.20662230089190864, -0.6483644236296144, -0.6772658228114483, -0.513435993381906, -0.12273668287320895, 1.0651003007053044, -0.625367510991341, 0.14795436255017125, -0.6550618816875505, -0.6442403778239407, -0.44736095208700694, -0.7820802058711344, -0.8109508223456094, -0.6697698847542966, -0.697498903163229, -0.6107533732020867},
    {-0.2928133275897443, -0.6008731503190284, -0.5521661581272628, -0.3144454468705765, -0.8229795433858789, 0.2293772414652446, 0.24754080014551688, -0.6592839700230292, -0.7912734346271727, -0.8839042589744606, -0.8825318490635311, -0.5850281071220016, -0.7590272878667064, -0.6486695934076376, -0.7744169401570821, -0.6580554836099753, 0.1571690590914093, 0.19009601017579206, -0.9900940276482775, 0.3352977333411997, 0.23868349973513772, -0.6048822586998296, -0.48266672882177775, 0.47250418685681156, -0.5507326090782947, 0.49301583464858256, -0.5453134785363007, -0.2403259704219702, -0.7154438039644614, -0.3400097602418052, -0.5663381396117622, -0.5588477630068365, -0.7156292182816649, -0.007528070196200768, -0.7198365479617369, -0.5088244138336492, -0.968849278600901, -0.9184114377527063, -0.4259279984976894, -0.8140469038201956, 0.47881992090837855, -0.5199658575636369, -0.567481608284772, -0.8767342250486496, -0.7011645266658367, -0.28496520529938807, -0.9016584532197537, -0.9807657644957558, -0.17979698812803183, -0.5866571163130416, -0.5190456325400367, -0.5638621379492074, -0.16389603445181244, 0.6753260732459011, -0.6745348360459985, 0.08920869858103764, -0.8646603999935891, -0.8973501793236557, -0.8704652337105908, -0.5231560413019164, -0.657599522325418, -0.556272482123785, -0.8448052708641096, -0.8320605876479311},
    {-0.6603274426747342, -0.7714921260240106, -0.7885547579030774, 0.22770079284212633, -0.7598893314700025, 0.24896972367961315, 0.15676224252757512, -0.7150606346566372, -0.6742376641784436, -0.5870089133553935, -0.692868482674755, -0.8877433816648551, -0.8798037115669975, -0.5850841276621885, -0.6722513116694101, -0.5018878773104818, -0.20430558422440806, 0.5220721041698205, -1.0621976551573415, 0.4968032153161383, 0.34250351375654, -0.7730139066329593, -0.2782897700317632, 0.4551165880427682, -0.5420765713712649, 0.27101948221862576, -0.5307976095539517, 0.29023319875378406, -0.79219482633693, -0.5113319077264946, -0.7052811871784278, -0.8673514195505788, -0.7314516570303219, -0.0517043938973353, -0.7029193546942166, -0.768201998998192, -0.8082921172966647, -0.7136637822999277, -0.361972775380274, -0.761868637149935, 0.5523194644509476, -0.820567947072595, -0.43183318112843627, -0.910986884767815, -0.9311357309914063, 0.27721372796144256, -0.6832890297841882, -0.819962814163095, -0.22008667271297128, -0.7873786494560402, -0.8616793646950681, -0.6743959284787918, -0.12680386944135064, 0.7859068668535555, -0.8786424044474613, 0.03872856531537028, -0.7321375760954771, -0.76401426170111, -0.3588337690102597, -0.492570840517886, -0.7190154402243075, -0.9534903520930752, -0.9318254386411183, -0.5594509280756471},
    {-0.5105774999948814, -0.8185263528811656, -0.8615862005334478, 0.29855230130246097, -0.8561603079350434, 0.32478890663134724, 0.10803789345496634, -0.7826089498218274, -0.35552586121318674, -1.1400941879591735, -0.7023282742816733, -0.6889621645608615, -0.710367359295774, -0.7992522407850537, -0.7946796598665454, -0.7810609421922255, 0.23083100983161853, 0.705569345732178, -0.9460617589297273, 0.7324178900686673, 0.21292191630633975, -0.5285956624179687, -0.42558483518477486, 0.5918136866234401, -0.3551165508123168, 0.5739132396952756, -0.39311381516660393, 0.2026545558857825, -0.6277357441129444, -0.5092851293160717, -0.7849769779357147, -0.6608134414338209, -0.73451390672839, 0.36341621144137937, -0.7364063717142154, -0.7705218488943948, -0.6097376646985283, -0.6038635662639339, -0.3704122791989505, -0.6481181029726232, 0.49440977671675607, -0.719016696857209, -0.3737185256870547, -0.697623847367724, -0.7697292395949396, 0.21786647051738336, -0.796551241654256, -0.8905197922321803, -0.23905475265182147, -0.9933445506587503, -0.8832525968735505, -0.7514399423644662, 0.35298574495357543, 0.7146394294762002, -0.6330971793836206, 0.07680138155680384, -0.45904057059713677, -0.9467728578405097, -0.4077235587414404, -0.4459784158156217, -0.8673925696922393, -0.7206171938965118, -1.1018359203404313, -0.8157271322480101},
    {-0.49067098345320526, -0.8190985384735874, -0.7158065622563803, 0.7118828371791083, -0.771177914418984, 0.7983178378169875, 0.24774571896804867, -0.8479110237070469, -0.46939778231657975, -0.6670084937090222, -0.8750031254808379, -0.7539579709438442, -0.675731351327458, -0.7714729063180937, -0.8199203607705142, -0.4706594543822118, 0.30638334861136757, 0.815041501051001, -0.9209731504053719, 0.4051035984134406, 0.013841046892553513, -0.8202674619149997, -0.6379614785341751, 0.6696649060367411, -0.3099911313599612, 0.43586330178149696, -0.4560721589041127, 0.2794758066084565, -0.8516906677870746, -0.4970224308758798, -0.5291186155665591, -0.8441871295472844, -0.8084095836026685, 0.5916597620782892, -0.7456860277208027, -0.6130036303354606, -0.6644089193010273, -0.5633005765841204, -0.48758577292203564, -0.6838155148897271, 0.6035480629017201, -0.7329136949291631, -0.7506949060345924, -0.7405920940649449, -0.8915494792175555, 0.6468599478417785, -0.8732777842620166, -0.5180210544102983, -0.06967428128513244, -0.731782509675431, -0.6733343904551846, -0.7310554207868237, 0.28597386235665706, 0.9148165512043571, -0.6676989363803743, 0.19170965774558188, -0.9305120294348801, -0.7164954078562695, -0.4160106877823999, -0.466384386488015, -0.7642898440076926, -0.739043753318845, -0.7081456325244753, -0.945419706137559},
    {-0.30837423734704533, -0.5415615706388113, -0.8199832082828616, 0.6845036239365103, -0.6140921811956946, 0.45549376764821087, -0.040208848800531695, -0.8047247200211857, -0.814871928902664, -0.3939993311857071, -0.8198194738194224, -0.6791897046210845, -0.5226038854794162, -0.5859359828631663, -0.6510983353869102, -0.6072074785732252, 0.10208925811051238, 0.6829356589072442, -0.9360287378507632, 0.12733778078028102, 0.18425334449222353, -0.8084613550980769, -0.38148273220132983, 0.8727413273239757, -0.3159217127853301, -0.1392852621281209, -0.20109407104003585, 0.20880780359558415, -0.7023996440105205, -0.33219268127032037, -0.5374162112644424, -0.9121886311914903, -0.6848142182153081, 0.23781898311876057, -0.9528185345928647, -0.6618603462148042, -0.499668563626904, -0.8337613002908882, -0.6852413244448222, -0.7931718859397588, 0.32932154007113873, -0.6222344740022707, -0.48683323205571005, -0.6080848754449067, -0.8645879711412421, 0.4409775407879348, -0.7320675962887, -0.781810315059088, -0.026611219430389105, -0.8336808327661746, -0.5939374681182379, -0.5222758132914826, 0.36713043865590345, 0.46837663856351724, -0.762037989641145, -0.012627070506943654, -0.6461087619490186, -0.8578812533849791, -0.22148672935816502, -0.5759976187645839, -0.81989104734218, -0.9310586415003538, -0.3703207713462915, -0.7538496151107751},
    {-0.4118748002453925, -0.713833313616303, -0.5432829653782445, 0.27858967792579337, -0.43096053510498933, 0.6869938091513543, 0.06736261084127679, -0.6565646284390649, -0.8847361546476604, -0.46965528217409047, -0.6865371146621465, -0.6786744629101101, -0.8793887035672491, -0.6759632011428995, -0.6955671220318139, -0.5144440630986806, 0.22684820194973973, 0.4830760486228952, -0.6885270130178278, 0.5366478120427918, 0.6821799593830876, -0.588294510446646, -0.6431578673206475, 0.6635752987314811, -0.4211070737642484, 0.019587800069043752, -0.042194917739836295, 0.4039143666758017, -0.9031195679904773, -0.2080053522854598, -0.4397411606511251, -0.5468989018261756, -0.5434767898973911, 0.2497396447916348, -0.9135016043497518, -0.7074558897003702, -0.5852462020302145, -0.39957653704504337, -0.5401363712053086, -0.9189152209184802, -0.11933809538395523, -0.5424721093753176, -0.3947774069925825, -0.704156133810481, -0.6903412446581081, 0.5935005804074648, -0.6859688150410133, -0.46621535982609386, -0.02933032015057444, -0.6751374471584964, -0.7677105439099885, -0.8385725446327809, 0.2543160160266625, 0.3441301773343326, -0.8755356269201743, -0.029778075082571905, -0.7651340958030438, -0.6278422345518553, -0.17703568793482907, -0.4650655685649559, -0.6879696674482456, -0.6777917714718406, -0.8510727278669209, -0.7655749866526509},
    {-0.24965199692585685, -0.7623117485437069, -0.6335915272895126, 0.45815199072202084, -0.5970332048412681, 0.7927021396951498, 0.10470829751609573, -0.8137964217044958, -0.5304698074163844, -0.6288948932460665, -0.6158015879316233, -0.732767952989527, -0.8403426859971485, -0.7945415309093834, -0.8197056742276755, -0.6526397747457513, 0.27214466658965925, 0.5796679413233278, -0.8850771440987033, 0.06726339594540352, 0.34520955645500223, -0.6272454593113265, -0.7242300553431535, 0.6935867217353912, -0.3591635731187729, 0.30576338391640645, -0.29587085974520644, 0.5421085332559437, -0.776411497987863, -0.2687986581534353, -0.4046782863010972, -0.7644455322655987, -0.909271006869707, 0.32963704203282074, -0.6878670013307938, -0.6515580127587364, -0.5845194945996767, -0.5493732444841444, -0.719066138545049, -0.766801817376672, 0.28847604374522395, -0.5554503567604364, -0.506506780142664, -0.751282154828567, -0.8864128173684165, 0.19032314789996588, -0.5845035826825703, -0.8061608912816279, -0.13073229680078832, -0.6852195952541972, -0.6104656160943217, -0.938890318963234, 0.667408791317363, 0.5167935202299969, -0.7472362813257041, -0.171541049282891, -0.8018633323055337, -0.609513062065832, -0.13812488270948425, -0.3679758744570947, -0.7936799592102398, -0.7030151077830196, -0.7744867845498964, -0.7926733732978708},
    {-0.27064369114992426, -0.6737688378456067, -0.4884149794684205, 0.5217523505888862, -0.2918602078510411, 0.6039603610165246, 0.04875314991366505, -0.7764385271735567, -0.39378985648602227, -0.18222463662346747, -0.9599286419198131, -0.9443985786845063, -0.6796463041951748, -0.9512263733093419, -0.5688861915448978, -0.2767103481931307, 0.358263258644808, 0.58090389075439, -0.7821184705443441, 0.16632881789436116, 0.31532498418064847, -0.6017097832801305, -0.4345590199675235, 0.6596804716445822, -0.6547564032518393, 0.3740766020099546, -0.13408696291112415, 0.4918781492351673, -0.8805894859361623, -0.081282926942743, -0.6769540217481748, -0.8025292374450639, -0.8443216794016524, 0.25223000035313303, -0.8762841621592421, -0.6495319374935442, -0.8150860118841217, -0.8321438574230764, -0.7311925834373051, -0.6750090369199371, 0.33780767588446964, -0.3880357719483577, -0.6901722352306845, -0.7631120695952766, -1.009413186834503, 0.15230455026674286, -0.5122160119691197, -0.656497686179272, 0.1641272871460032, -0.6913485048225326, -0.6522233318142883, -0.4303529494446274, 0.415150557433912, 0.4386804582447546, -0.7201111674618477, -0.01654847266743637, -0.7366477345750025, -0.7581209463297017, -0.3265524742488314, -0.36378670514638606, -0.5856798501539664, -0.8819587025161153, -0.954853618856371, -0.6206039379520655},
    {-0.21382976182965413, -0.741022603616647, -0.9015665601503744, 0.6125465829548151, -0.6039322192263236, 0.6143601375195101, 0.12216911247298774, -0.7163487925014151, -0.544230105671905, -0.5668868355828135, -0.5682925747445144, -0.8845743741290354, -0.6149680976646557, -0.8066864862671951, -0.4263587971908453, -0.5627218763501697, 0.3118797411167207, 0.6364154405180427, -1.0096266495477733, 0.43413053726203193, 0.21512459703802025, -0.7232574888729858, -0.5767111536830838, 0.5858812495129033, -0.34063822837568125, 0.10424319439325738, -0.040839947590611485, 0.8198713063144675, -0.688968006257331, -0.5147449558903122, -0.6435694108936595, -0.8571419694414153, -0.7329843877175405, 0.551669507023807, -0.8221382419311851, -0.7420433969328177, -0.799589702763218, -0.6503250776284965, -0.5441460297829345, -0.7656098957091061, 0.14060844979317108, -0.7170978370376441, -0.5555605539644732, -0.8079385568485283, -0.794177235700468, 0.5031262783907217, -0.6682247399556259, -0.8501694214562857, 0.04186017425636204, -0.77804353885269, -0.5912905945124668, -1.038011666884632, 0.31631874007559835, 0.7727817979481846, -0.6083837219220374, 0.1611143857470514, -0.542806910591444, -0.9459677008854724, -0.06104775856000389, -0.2236655564726693, -0.6311336347729608, -0.8130280576251349, -1.1135531806208872, -0.6723240164351572},
    {-0.3597899637053336, -0.7203292590997392, -0.7945572292628736, 0.6624222443881329, -0.527141827951655, 0.6419497995820326, 0.06583336302596626, -0.6993511384791979, -0.6862257243157934, -0.6654363341198181, -0.6761265084943785, -0.5978095150819733, -0.8772888296157126, -0.8129047266386661, -0.6262551639059446, -0.36697605612623163, 0.020101396190933096, 0.6034678703550493, -0.7206813804094839, 0.6132312057376411, 0.30311081728741585, -0.8564545385860328, -0.5138541679276291, 0.8017522440168533, -0.10285304994212385, 0.0926820343101803, -0.32761124619129134, 0.4899455044301219, -0.6871766132899292, -0.011806011532671603, -0.661527702596491, -0.686303900741861, -0.7990052727886882, 0.7212828319308829, -0.93975531491829, -0.8476417330066843, -0.5355167609730775, -0.7888553007464935, -0.4609588528102605, -0.701326372592289, 0.40048787472859626, -0.6926542607731657, -0.41807021338256756, -0.7569560029618021, -1.0482851032395235, 0.784635060556035, -0.5570616746973693, -0.7494762278630311, 0.09054631977432093, -0.5220021982973057, -0.5892885401985475, -0.46282803832271296, 0.27754435218222695, 0.5165395126575174, -0.4251684623880664, 0.24920574522116537, -0.7348825906713198, -0.8168151937986212, -0.12429105877316958, -0.480083296318733, -0.3870596191669776, -0.8620584123160087, -0.5007643672973566, -0.5817409247618449},
    {-0.5502716407567628, -0.8852169317541804, -0.607223125243941, 1.1087127441871585, -0.6460628258780013, 0.870601296637248, 0.4912177458543942, -0.9499851343018383, -0.7306087646671504, -0.38962427516100606, -0.6011483697776442, -0.8971104776682784, -0.7414858132004084, -0.7696798853669434, -0.6250013718868752, -0.6869150969861362, 0.5299184565526398, 0.6608352581248083, -0.758132017731253, 0.8147607536846887, 0.620341751755315, -0.47900140588706225, -0.2762280295486664, 0.6185165351751705, 0.07432356405750055, 0.6042182472725188, -0.09920337927765126, 0.6683692413352257, -0.8431054954017418, -0.15158722224827023, -0.877070118508155, -0.7679411786069706, -0.7977793018569984, 0.6615526681673902, -0.6962916429383549, -0.3654552764934526, -0.7688002953680535, -0.57245570806531, -0.70390736052891, -0.7951677233415304, 0.5057131915077496, -0.5367283817331353, -0.4162315129588472, -0.6420670871748118, -1.0496722931361326, 0.765505973484054, -0.36054201973884115, -0.3929467014536411, 0.14787920983862685, -0.531430278782047, -0.49458106370363203, -0.6692241511770364, 0.5955172834004754, 0.7894622933147307, -0.567211535901552, 0.26255951347210515, -0.5729858455575184, -0.5325407401131252, 0.10843450478114008, -0.6739793179970297, -0.4740979251629953, -0.7740831563282473, -0.8136143026869059, -0.504710744508294},
    {-0.36936171460926776, -0.6014328769390241, -1.055167668012337, 1.1485930502220918, -0.5042521069308499, 0.9282864168105655, 0.5031774839064709, -0.9068775584156238, -0.6931552446928948, -0.2372867485587368, -0.6335613653971173, -0.845169277337075, -0.7881576392918438, -0.8689938900495362, -0.6383179386483814, -0.4576568419409371, 0.8676443737453083, 0.7646969025950163, -0.662555083869557, 0.6822551341758382, 0.6007588745141389, -0.628168373765845, -0.6145070696739738, 0.8074759560976847, 0.11046860035442829, 0.6037057258810212, 0.11225178355782775, 0.6753855410106144, -0.4660067231237829, -0.23698857068025309, -0.4301744546236188, -0.6174847331159465, -0.4028761256344353, 0.8482976912048659, -0.8204285107786536, -0.4895161061431652, -0.6360411602274338, -0.6732353030464063, -0.7255598969473949, -0.652538885008897, 0.6097228144854318, -0.30655890555924836, -0.3861228194723009, -0.7111913440225334, -0.5692180366205373, 0.7728069353977972, -0.6738570981421922, -0.7946580466000427, 0.42711035832160477, -0.5255044073562699, -0.6550599997954157, -0.5753717097445858, 0.7949546321927415, 0.6172710091849822, -0.827777760183622, 0.12976631014345655, -0.6824633201553215, -0.7092755152808088, -0.3921363043303019, -0.27345465286581844, -0.43026457930707257, -0.7790622297000702, -0.5815442975056582, -0.5597601717966427},
    {-0.4053516585455607, -0.6148419987185579, -0.9715661392339554, 0.7170096498780668, -0.5844626106935565, 0.9108463007726378, 0.4003268853799884, -0.6530521159143325, -0.4738717434511417, -0.48411026308513916, -0.43796968576641176, -0.5594579080067345, -0.6134038637864004, -0.9269717212028057, -0.7209263672934763, -0.6357767851969943, 0.9005260622776066, 0.8700432183157933, -0.8943849544668034, 0.5537980486462072, 0.8628561376416277, -0.2014981934787314, -0.4527289631862102, 0.7845562652034708, -0.18428581208010097, 0.4143113905429176, -0.07506301378446367, 0.807310528138911, -0.6529020678309023, 0.06409907112769521, -0.5741297110806022, -0.5658485012363992, -0.7915634188750165, 0.6834918236730376, -0.7355049424011105, -0.4562437922161514, -0.6206275415907505, -0.4463977803200892, -0.5666934710707601, -0.5557049301546, 0.7438855519460309, -0.5593063259415827, -0.4354089933851713, -0.5438289470948218, -0.7286191677424647, 0.7659463186764565, -0.4493594314711725, -0.7075886403660755, 0.10410797653715186, -0.48563618242147283, -0.5185638673204528, -0.7109392785555649, 0.6241750809599583, 0.7538712563336372, -0.42624063037475934, 0.06602019618172511, -0.7072907055449339, -0.6429065052107373, -0.330076897828727, -0.22177887619604333, -0.27778062660482444, -0.7181019156556193, -0.5441745776200865, -0.6290951901209482},
    {-0.3902695294024725, -0.4490442220602731, -0.627223657690297, 0.6093152440528218, -0.5517590104252798, 0.4900044864758516, 0.3260278387103437, -0.8181859009393008, -0.36144450837614883, -0.3389749961845874, -0.7731811713567853, -0.5467392284614899, -0.9288383789470723, -0.7107842702471484, -0.78784170593649, -0.5806009897744735, 0.7477968748026407, 0.48347896795987766, -1.0158061690663922, 0.8265813865890502, 0.5894047085409359, -0.4739705378763717, -0.5742240791881044, 0.7823692425192789, -0.34097636364986905, 0.7299258562597549, -0.16655890100280737, 0.7298178822950556, -0.5921678997691942, -0.12940058998174456, -0.6519290532611867, -0.8028479898279836, -0.7804951174828467, 0.6323891544353027, -0.6134423193231923, -0.7741641442246613, -0.6326990829843204, -0.6116326589296336, -0.5082231772965088, -0.5203643718268882, 0.8727097403496177, -0.4696268069516267, -0.5841442843251743, -0.6819555015547841, -0.7640939886609104, 0.9034611724445059, -0.5261888764433569, -0.6904482202547312, -0.040905580702728504, -0.7337944847852067, -0.9268100174286996, -0.7331052459907736, 0.4649320162444028, 0.5833869689368085, -0.5675226059012504, 0.17391380703171302, -0.7924945485723756, -0.8959691335601239, -0.21223121563091665, -0.5124016427110166, -0.8061026521420153, -0.8821270138371263, -0.7729584416120658, -0.5472712693736609},
    {-0.10434844111207134, -0.5470549595849002, -0.7709923045538629, 0.7033249484606716, -0.38271888130879156, 0.5429149199193519, 0.42011218908288706, -0.5008012824979301, -0.3393258191425996, -0.33844770528982654, -0.7939110538841594, -0.605679187093109, -0.7702551262695956, -0.7324114558565709, -0.8057000354455501, -0.6653257187929138, 0.6726023395607922, 0.7949342996043094, -0.920676459245121, 0.6722306638473373, 0.48486214347750356, -0.7574887927256604, -0.4301699434816464, 0.716714117146458, -0.1824902318435678, 0.44894047037132845, -0.155314628422302, 0.6912037819632241, -0.8044175995113209, 0.20881412281008122, -0.3269583511811829, -0.6259791538162309, -0.5312711264327391, 0.7021966520037017, -0.8691548866395152, -0.8708068641194247, -0.5858870439226915, -0.6333218815156102, -0.5355741275825362, -0.8015693402701934, 0.47197650851192086, -0.578573062428912, -0.2805363383914513, -0.8546945576950848, -0.9878095469477859, 0.6218394567965141, -0.4915857481281775, -0.7627294939120749, 0.33836712267526303, -0.7575130312847385, -0.49485182215038415, -0.6739740495544531, 0.3765856669860289, 0.7015990076150271, -0.5058979705820373, 0.19969703276838854, -0.8476528370098648, -0.723077800415958, 0.007264974636687457, -0.3690038905061963, -0.49790955854060986, -0.7267737377810404, -0.7391001659088731, -0.575334410196739},
    {-0.21632161140383907, -0.27096944208282275, -0.9850881951335545, 0.7215774996212867, -0.2724013257067651, 0.7858749505535473, 0.7075261628687984, -0.9363055434837665, -0.39594414709334186, -0.43647007127621923, -0.5571005235267497, -0.5610142497842207, -0.9389202706633529, -1.0791056420544762, -0.6387125420513318, -0.6541659386928644, 0.9145794623851956, 1.0148873934813745, -0.9130225854268842, 0.7889928194588814, 0.7924681382799692, -0.532352634731928, -0.31213211708335764, 0.7617424740995635, 0.16928800107335876, 0.7305461966513023, -0.18401539465615063, 0.8444200924062903, -0.9128385296426332, 0.2020767781730885, -0.27592961463202237, -0.8453396268287862, -0.5812468644914992, 0.7758821436436878, -0.7615111789563065, -0.6014920717433935, -0.29528650507763754, -0.41726370667044455, -0.6147838599695936, -0.5143522802702124, 0.8248387491686267, -0.40510512361965223, -0.5477168392002352, -0.7896790964033893, -0.934888172838841, 1.1818414669553674, -0.31813287235663035, -0.5124170885798636, 0.4565485433825363, -0.4784454313221649, -0.5233912405101389, -0.7831985530970054, 0.7342838476882186, 1.0305524759799556, -0.2814910038264937, 0.2234817589622035, -0.6070651228752374, -0.7113895681612054, -0.16235390439047118, -0.13204050609755957, -0.5488479241317274, -0.6412145302084927, -0.645473109431674, -0.3396870234892186},
    {-0.2673682094154465, -0.4100686685379143, -0.7102872017420214, 0.750426291634056, -0.4497183159734369, 0.8853758884398365, 0.6717317040637514, -0.6195822712682952, -0.48233333945139734, -0.208584693020762, -0.2574836524329404, -0.5594259732232573, -0.9334592965081161, -0.8757337763863347, -0.4823174421513712, -0.46889174727371075, 0.6833807931710781, 0.6456912499645244, -0.7724499285764241, 0.686206058721785, 0.8325316724494716, -0.4820758604112936, -0.2596643604481877, 0.8086127836539319, 0.1545040857883192, 0.47994401616127463, 0.002101251519557052, 0.9890274726912488, -0.6702586700486693, -0.07362768365444336, -0.33863927477310607, -0.6897558070505643, -0.5348352113034733, 0.475015803219715, -0.36962740790121346, -0.8309330394816302, -0.28948305053316004, -0.3084500340343211, -0.6347043272329528, -0.6778693067995211, 0.6644602512701048, -0.473103515904566, -0.5301404145707584, -0.9153676258848701, -0.6697605139558481, 1.1777925966517278, -0.15520998290010626, -0.760904648987795, 0.40039427772983344, -0.48035063347950846, -0.5613112165691625, -0.5231159995424456, 0.35678467806644704, 0.6297662005905358, -0.556299865674038, 0.3033961119703924, -0.567586144682564, -0.9383510236840004, -0.051717416972931654, -0.21152295371005858, -0.4884175650778965, -0.8068184943731285, -0.646170827016101, -0.4827929966080536},
    {-0.24592279420897406, -0.4709616201787518, -0.7775697896628317, 0.7053072704821859, -0.8249778131928079, 0.648462289530714, 0.17235336929927103, -0.6026632239482432, -0.4708876748976811, -0.29675564916955866, -0.41758639051373553, -0.7372531205234653, -0.6895762295055238, -0.6422449320171819, -0.8381488138675943, -0.5474730710348027, 0.6560914546695659, 0.7052089183591402, -0.7417894974753748, 0.5014678576732473, 0.6671354831662846, -0.40693959665083373, -0.3583433334574469, 0.7849925153673931, -0.05122658245316797, 0.5214698775586436, 0.08845734491386707, 0.7522048476367791, -0.7277343912991789, -0.2665322436101762, -0.27672091615435135, -0.6941486563834096, -0.8118727727307484, 0.9181307290950337, -0.5132851531769671, -0.7598472604386325, -0.4372448459911329, -0.6065639229899509, -0.7623905426377208, -0.8359625489790279, 0.36165754485275764, -0.3668878193992146, -0.5061026711537615, -0.8449707075120035, -0.7346342979438185, 0.872607115934752, -0.23546552142298843, -0.5775646366702522, 0.4498764107497743, -0.8095537015060749, -0.6610492485150056, -0.8398761653618142, 0.5953355897500718, 0.737413003207373, -0.27103656098628043, 0.24830472490339148, -0.5079202329291715, -0.863447165592097, -0.054307578119846454, -0.4579785604308857, -0.30808941494189857, -0.6773214047159642, -0.8879191304006068, -0.5808883544108424},
    {-0.22341219004435536, -0.5774760797296494, -0.7791278065562022, 0.7055478503799921, -0.13550465640099277, 0.9950141218156259, 0.49743633089444955, -0.6777646650356289, -0.35676642878057463, -0.5173095945141429, -0.6446969784213323, -0.7610058557023823, -0.7598428943371226, -0.9062839940927631, -0.513189016688222, -0.4390091151672835, 0.6333314178333994, 0.6470412439176294, -0.5937274104497006, 0.6544252110210779, 0.40780907255041116, -0.44818962651284494, -0.5360836706627734, 0.7610533939147625, 0.04548669992863237, 0.5971021398313285, -0.05300707567544948, 0.8492134839785627, -0.9895266154681082, -0.22883488149392894, -0.5134228308215832, -0.8237961698425188, -0.8568157960432616, 0.7426893033915327, -0.7002167245283568, -0.7675028169877195, -0.5172644310637753, -0.5083130394442512, -0.6985416513362568, -0.5905669381712911, 0.48226290345194484, -0.5718242233389724, -0.4466714135082513, -0.9084339173693444, -0.9890757533415742, 0.8375778706688409, -0.2651531566336547, -0.6805739738340402, 0.4675407966055524, -0.5415222461973667, -0.5831575689778946, -0.4912660955309957, 0.7633402169411617, 0.7042598353804653, -0.5866411218884652, 0.48509655199961393, -0.6644244076286373, -0.6510483217316695, 0.05949954095536127, -0.3326869101755653, -0.5122988956421842, -0.7075872976229356, -0.7094706004190879, -0.5374310816307597},
    {-0.4830530163310299, -0.3457100776586943, -0.6607941384797491, 0.7184875608823426, -0.6099872173143608, 0.8006638632377819, 0.5216087002624603, -0.7500766132563823, -0.3974702294342582, -0.34075446730584324, -0.8299821500255035, -0.7082245980758702, -0.7817025169787951, -0.8441540641302683, -0.40333780804851743, -0.25727721007173565, 0.7400238563712438, 0.6133799907454153, -0.9733892712646955, 0.5124179017908659, 0.7770529827807398, -0.345347655226556, -0.2848795168976759, 0.6199531839506448, -0.22339694203671068, 0.5055113965766747, -0.14417952698702538, 0.8224893033264025, -0.6145465964557747, 0.3070065501783288, -0.38872024551963213, -0.698406822504853, -0.7851575380460643, 0.49101881541962256, -0.5237252571047819, -0.7123000347781869, -0.4027333754754855, -0.555275744112688, -0.5361733704635245, -0.7240141470325401, 0.5665637059111518, -0.37710952060909125, -0.8722526882905081, -0.6699337581657738, -0.820080451519766, 0.5694596506371881, -0.16850272372602282, -0.8595571288116969, 0.1403407933323421, -0.5054242586472107, -0.5235649667676379, -0.43887732343900815, 0.3604386808348119, 0.7852052562961538, -0.231750241987707, 0.26750571184809674, -0.6676960389777252, -0.6337948444586625, 0.3331196063274776, -0.20196529145686173, -0.2783893068811681, -0.6805699624514775, -0.8103151557401412, -0.5727079002135853},
    {-0.43967016232636336, -0.4118604637478327, -0.764206115332905, 0.8414270443997925, -0.2807053977249836, 0.7279183992371318, 0.4669846547955568, -0.7924831096985756, -0.6717729230412348, -0.3935438633437236, -0.5612320924549887, -0.6600186680459189, -0.8061140470109625, -0.6178857088752528, -0.7144478816688286, -0.6536483470242213, 0.5653041912876768, 0.9777168015443641, -0.4164061516953189, 0.7755542984017727, 0.48060391451146367, -0.4066330503906187, -0.502093720524976, 0.847683529047671, 0.02281218847856874, 0.8831650467353803, -0.1234360397523208, 0.7609505761429998, -0.7607725503662777, 0.060321547476231245, -0.309764332159875, -0.8087584313724975, -0.7554481825983017, 0.8195173940967209, -0.6710872975096859, -0.7345964891663781, -0.4917955107749367, -0.35747200777653143, -0.7001310196691612, -0.5703227934091819, 0.5613805623858633, -0.39657743976285603, -0.6389324427118821, -0.9822717127479168, -0.9902163520227604, 0.8219393651548754, -0.3481681737890419, -0.7829043803481543, 0.10153879215088436, -0.64960857197518, -0.5652405769000335, -0.6625422005914945, 0.6424279967347396, 0.6008405771679769, -0.4491824741016933, 0.3228522457464134, -0.978015802385427, -0.8460628174358751, -0.04641828753565357, -0.3989160256639611, -0.49927997334082097, -0.5927559557072823, -0.4425367866450368, -0.45677567950487363},
    {-0.36302451638454164, -0.5216785733113011, -0.7231120041403947, 0.7125997843311227, -0.29843982344175857, 0.8443616617737925, 0.6893430385689905, -0.5795971762742389, -0.499129583207343, -0.3113474894640264, -0.4919351693079464, -0.37027172737697667, -0.9635619260346228, -0.6077297896882248, -0.62694822821775, -0.4796372257888236, 0.6220650358275375, 0.3532743343344071, -0.864673411381408, 0.642580677599272, 0.6921011039622277, -0.40770916508898614, -0.1934564849767242, 1.0653376142051243, 0.0075664781333725705, 0.5099608835897478, 0.05850128023131598, 0.9620306989943705, -0.8462016504843253, -0.004646177964947264, -0.34370633486978336, -0.7368157735030316, -0.9921794511438454, 0.48759650682797845, -0.9479172002923323, -0.852903443500426, -0.5445563600790182, -0.5979439524451057, -0.7076378960460485, -0.3512592656722103, 0.5545521791824103, -0.6510421595874385, -0.3895627080981468, -0.9387661974332813, -0.6065788423901266, 0.699110829506853, -0.33930713857652084, -0.8220961556082781, 0.41509142842842045, -0.7534125900008692, -0.6238814883706483, -0.6082796215112707, 0.7212037917376608, 0.9238362288371326, -0.6147202882384281, 0.14555562176808814, -0.538262507125085, -0.7430928132737885, -0.01267463998045768, -0.19957114610396956, -0.5439233216770649, -0.6822691482247475, -0.9291523923799343, -0.6037468780479844},
    {-0.46519560872770577, -0.21521099883308906, -0.6829383399036008, 0.9500352575305899, -0.45214061707978803, 0.8507210217302658, 0.3792006640470795, -0.47050078896274083, -0.4724234174728216, -0.5165730073445648, -0.5943852489609687, -0.5176716372601142, -0.6452116306308116, -0.8897742637234313, -0.48659795909818215, -0.59102427071477, 0.5833029534162876, 0.6476030253194307, -0.6963018003156825, 0.5904653850784163, 0.46377554450252306, -0.4334298229465036, -0.6068510201925332, 0.40052673467974786, -0.23876129298138782, 0.5061379884145869, 0.22810418626120194, 0.5640928222937567, -0.4983612113425661, 0.26927396952148314, -0.4529599966533698, -0.7451937616458554, -1.138846791929944, 0.7620139846204421, -0.9051175972842238, -0.7318950879634505, -0.35897064708349535, -0.5392250189183444, -0.661203795368014, -0.4590681951868223, 0.594930049971418, -0.3015683192208243, -0.7548549457715101, -0.712546214040176, -0.8604727841341813, 0.7651569136565778, -0.2437239418724705, -0.5931707872504457, 0.47722973394050194, -0.6460049461891749, -0.669687635297266, -0.6383807028302126, 0.7874466330882808, 0.628078500800252, -0.4423604268642735, 0.3779657254230901, -0.41613825540976174, -0.7201378052401994, 0.2832858357919546, -0.14667447070967296, -0.45656421839792166, -0.7545508548329495, -0.7958308445810415, -0.5321203580246794},
    {-0.37737426663313356, -0.49299138305676904, -0.8136464864750478, 0.8418669862849302, -0.07951089076832843, 0.8136132570977684, 0.3387013662290847, -0.6313008538453765, -0.5391750506646772, -0.23830030213451414, -0.5737134311282226, -0.6338700992771525, -0.6196254436502004, -0.742168886582656, -0.62888256600111, -0.34290542895854126, 0.7497246501623229, 0.6104263382965939, -0.9018220767519312, 0.4225958652534383, 0.8030427325865221, -0.4876582040180137, -0.5516484668528725, 0.6610791839554357, -0.10478718699464284, 0.5053682565016674, 0.16913242291393732, 0.8134235419240715, -0.828086466192862, -0.23393394905068987, -0.43079844521645466, -0.5661791850870531, -0.8590526265364672, 0.852161351416365, -0.755397867744362, -0.7754373042708422, -0.21906997120013819, -0.4968508859839677, -0.6172763212995637, -0.6777534723397565, 0.6283813921210145, -0.2552650485880584, -0.6171033872155723, -0.8485603716803395, -0.9554186634012177, 0.7701932218191078, -0.18658753412290355, -0.8378694227495704, -0.04114178972161809, -0.676619947293736, -0.3572368244577109, -0.6988104199020752, 0.6138506883420203, 0.6214073540341566, -0.3381183001771942, 0.26479181018985, -0.6023372793861107, -0.72473742643718, 0.1644904827675021, -0.22856404343071043, -0.5575410404413612, -0.7175676226821533, -0.6848902312259428, -0.36312805913461005},
    {-0.07239278784242273, 0.03642509745817816, 0.2905748998996958, -0.45720068221613663, 0.3895134790268421, 0.052580506679068925, 0.3398299589853998, 0.5125036194541208, 0.2840338673401902, -0.404249622826922, 0.6534326090368305, 0.24704717251998506, 0.14399830873561775, 0.4799101547686354, 0.3112377688522458, 0.30571369643502255, -0.46377369796319806, -0.01181853890930285, 0.1429657454518867, -0.187327339321287, -0.12255141426562766, -0.09275398087358151, -0.038349131616466935, 0.06512065822400319, -0.12187847916208393, -0.09290257428032223, 0.20191626358414116, -0.3519795093787088, 0.6558736612135325, 0.014910895929293627, -0.40790643086609135, 0.30865943107364735, 0.22584312985557395, -0.14869385651194636, 0.45687887815112144, 0.2665771816967686, 0.3139711838354, 0.5188939054875915, 0.13793640706170263, -0.22768981689337672, 0.08689927971986117, -0.3120700721507731, 0.15050620927966374, 0.2713840417796616, 0.3482364386341775, -0.4920350990056914, -0.16678709985415519, 0.6489397862620621, -0.378777834207526, 0.3481592436446105, -0.0838507076175889, 0.6978565394618678, -0.27437846851197906, -0.20520291515052966, -0.06189350177039558, -0.6026667338605891, 0.10562430239100026, 0.3390815067118076, -0.43788715982191945, 0.29157331186288, -0.4468326059364986, 0.5268987615778902, 0.24680014311153112, 0.010418754683166939},
    {-0.6518876702960475, -0.5578948973091191, -0.6979375790295689, 0.04748630178862651, -0.7607874098018486, -0.15789898623576462, -0.2840568045901494, -0.5359335314805841, -0.18699667607811618, -0.6249250533839954, -0.44492274912038154, -0.380600845503435, -0.3111340408870842, -0.8153715439963147, -0.5587736317131669, -0.28056923820140034, 0.05638667883229507, -0.016661734753663792, -0.7355979922546088, 0.20000409820170337, 0.007598945400669668, -0.7166560083551081, -0.49688313137169177, -0.006472643458945138, -0.04036979056051963, -0.260893515557761, -0.5863121606132369, 0.05011473238255474, -0.5598322608186169, -0.4812227268348039, -0.16789405431546592, -0.6709668462560746, -0.6220793936621751, -0.10972611287090653, -0.9358576230052295, -0.6957399973264089, -0.6506810327970829, -0.5431887206878452, -0.26417201960453895, -0.5039551537203927, 0.017719821249264286, -0.15743803467642298, -0.34735823009257766, -0.20600197291835765, -0.7608889794582373, 0.06697066982044086, -0.5839098125173272, -0.7367115240858078, 0.35375172366811897, -0.512563517113375, -0.5223752128920447, -0.6204316525866705, -0.07991233112355754, 0.3107877726651955, -0.5153021081954238, 0.06457286654795646, -0.45341504999565535, -0.3475538156570688, -0.3798523403749434, -0.6174939462273362, -0.6908269536553843, -0.6855503179185279, -0.5958287228580773, -0.5984216682328176},
    {-0.3823306990424577, -0.4452961616622405, -0.5029134809707803, -0.3939109867264571, -0.38859485063009713, -0.2725070845925282, 0.5061578706082273, -0.2003129940117781, -0.15542551145291386, -0.6587228742007691, -0.4723924482619516, -0.32017339170877623, -0.03445553116559304, -0.34191492630346876, -0.20025934774849344, -0.856331694354329, -0.25627035544297694, 0.03939372368914912, -0.19460373103357106, 0.37033665594855836, 0.2088535093454506, -0.3962513312209665, -0.24196715558836165, -0.559468529950694, -0.521349362247924, -0.20605272824087542, -0.446686657204287, -0.20014985489680995, -0.3851401181006566, -0.4018879337782994, -0.6837307811798763, -0.5005106148786849, -0.1819728231456858, -0.6372967205163659, -0.5879918184709758, 0.048145610610270256, -0.668062898427518, 0.2583638697719913, -0.058879883142085934, -0.4215242324900487, -0.015823306722109878, -0.2755987453443138, -0.16089411989598096, 0.05815096240600588, -0.22666659128321393, -0.5303410861150416, -0.5379353314827612, -0.14449360644641943, -0.5008708412885601, -0.15983574253186078, -0.5180191428380985, 0.025953348742435944, -0.2355372846531599, -0.13794770608908472, -0.24574627612964978, -0.31964850079753826, -0.4526266126701705, -0.06112856438963257, -0.7089394392283537, -0.42874690844796154, -0.7478265597166851, -0.26930385226378817, -0.3788243053158943, -0.6765252941293546},
    {-0.43287639551252827, -0.46199772690870133, -0.11476699076462284, -0.22374213024301995, -0.1874240484671072, -0.2395621470659185, -0.2292592187966753, -0.2838682067471494, -0.2778348977926374, -0.2694734412240933, -0.4648137564439852, -0.4333522917073755, -0.03264574734021153, -0.301263276012857, -0.08562589580736468, -0.5067747601610146, -0.18752792525003967, 0.17631130251829166, -0.4644944192361894, 0.013213163457272002, 0.22763278042624555, 0.18243730478118528, -0.022438351658057236, -0.2067588774919743, -0.311470892779768, -0.3664126808290731, -0.3280818602832857, -0.1440634004589108, -0.24493267339650848, -0.47349503858449044, -0.417452783493853, -0.28474259371973415, -0.4914124870310874, -0.31370983915422235, -0.5495709480524577, -0.1385160209046907, -0.21274348297177312, -0.03483004240625459, 0.035162376376795756, -0.1557277366629348, 0.09265326477489146, -0.058951458540555446, -0.09061108498237083, -0.1202862461739302, -0.43105776103218035, -0.3741365558822016, -0.2898675797636532, -0.14267618644083138, -0.4095850372897783, -0.40275512258042645, -0.43443029830344904, -0.016985675040592972, -0.23262842208378717, 0.013542745274731536, -0.3163647174585365, -0.5200976956495332, 0.18584048227432445, -0.11961823170965084, -0.27902456813133514, -0.5947611062102564, -0.5100177583512793, -0.6713693078255879, -0.5074044319670108, -0.25085103302608364},
    {-0.6071554424179554, -0.670515594414555, -0.40183002739360146, -0.3133584363610992, -0.4713064729479646, -0.0445572513317044, -0.39266421428668247, -0.36074429372929867, -0.48619249505184986, -0.47285097908694085, -0.54731027113876, -0.3679032619491278, -0.4744962017468434, -0.29609100820461953, -0.6206340698760817, -0.4805064149300241, -0.13941730394236285, 0.0810197260975337, -0.7836383009080351, -0.007016173029920782, 0.25888527805109945, -0.4092781718425037, -0.3142694064839389, -0.29620010329134766, -0.4292214838582305, -0.16991861189368912, -0.11734732391191238, -0.11009042861080078, -0.46799613668575635, -0.5381406149028691, -0.43665640630663616, -0.4047818895597321, -0.23727749897348516, -0.5956565495520226, -0.6434521063356798, -0.22522075817638326, -0.7611591153883557, -0.26585769413599764, -0.08286824731222042, -0.5928109979224396, 0.3505572773035098, -0.3889531558107088, -0.4846627939182612, -0.67151172109349, -0.6791342960440523, -0.007545324021150634, -0.5675135670577922, -0.5036708808500522, -0.4211616762367382, -0.4138697363741167, -0.553305206217975, -0.4729914099878385, -0.2063411124439132, 0.3272543415699067, -0.7985707396886083, -0.19637024342629966, -0.5910235125899828, -0.27042805021761435, -0.29256867929693525, -0.6613831164754446, -0.9313539945523424, -0.6612800180409708, -0.3039589098480123, -0.3230042695932121},
    {-0.508301274612002, -0.7019830937945547, -0.4858045041874122, -0.25011506616670687, -0.732923220642867, -0.3178394332568233, -0.7806205832932783, -0.38931745618048813, -0.3477172202402745, -0.5878027727322723, -0.5495281537057803, -0.5266863491200124, -0.41143434913760885, -0.2743892354603372, -0.35268666255924536, -0.5032024696602575, -0.3225576326160689, 0.0636613958563742, -0.5703839084877899, 0.16138644516715817, 0.27822541932889805, -0.4134942166935307, 0.0017606396374557777, -0.4004867532134003, -0.5431833817011651, 0.1205898206033915, -0.6623487129332427, -0.48488031719222296, -0.23885938792773878, -0.7991293363371924, -0.7223911973965174, -0.6380741991353613, -0.14658187313350984, -0.45593049312478195, -0.31731892738559647, -0.19967553205018834, -0.5803366258535292, -0.2560485400611039, 0.03279360263403735, -0.32680982249866825, 0.27826170936516265, -0.1585810932179794, -0.47642344407395604, -0.35469459491545074, -0.7406563495878129, -0.502132178557714, -0.608087830463773, -0.5670156139985884, -0.18104689292717777, -0.6903621152579053, -0.5335683874228881, -0.6488396265286082, -0.09812154861534762, 0.41333197460793436, -0.4276433844423321, -0.4342795579410804, -0.46702058750661474, -0.18394020421099933, -0.6330797650315302, -0.5292530813705174, -0.5945022363424737, -0.6731811488158492, -0.6488254259941003, -0.4191669489853949},
    {-0.691519043243567, -0.7400634593797359, -0.7092289108714231, -0.45276774011910037, -0.879556226405117, -0.29195573725194185, -0.53192702412388, -0.5131852093105026, -0.5050788948571581, -0.7493043988565503, -0.7658161410940533, -0.544977129847029, -0.33374024651971457, -0.5422964861599621, -0.6721153082853498, -0.6652465633079307, -0.6377750357365868, -0.3176092858452499, -0.6425269260312666, 0.2752659673453316, 0.24355219059340077, -0.5950769935462626, -0.27082220066291096, -0.3027883696532801, -0.6770302523076794, -0.13238154966802942, -0.46689318529682355, -0.25818239094236534, -0.5023641104779875, -0.5325836481425422, -0.5630761085299641, -0.4462062560846915, -0.4018757961266912, -0.3749210634400594, -0.5991608024034846, -0.4488167921752448, -0.9047311690192844, -0.6367449154911404, -0.3382566100525337, -0.456396432211529, 0.3106484931551266, -0.49933374946075876, -0.22680468539345872, -0.6649855586674208, -0.7968184093302287, -0.16104325427294758, -0.4978463706089268, -0.5678349585583776, -0.6546623023845395, -0.5979924582259128, -0.7304807820224687, -0.5953882200798652, -0.1441025515475982, 0.23062614710016596, -0.49184248453748175, -0.21615274854248015, -0.2094622895389499, -0.24836816043183785, -0.8409725257558736, -0.6173289163784869, -0.7533324823374473, -0.715990409030428, -0.6685464068583729, -0.6475510833359871},
    {-0.6865739284873857, -0.9865572569451666, -0.02539619051974012, -0.34942795729968157, -0.8054831376726966, -0.07476399554318576, -0.5530339245268836, -0.49446084718109046, -0.4936599398857121, -0.564906888202807, -0.6551481654281334, -0.2991812624022354, -0.580349882362651, -0.2793957580938639, -0.4608243544207251, -0.5451973537359701, -0.13103317446367949, -0.21033179927207987, -0.788929008285499, 0.08600046910606586, -0.1999738185859282, -0.6287890172262425, -0.16403041334450566, -0.3686603847976578, -0.5639413227518719, -0.3073147316535376, -0.39374058645188065, -0.3618515848334093, -0.3989927239812633, -0.9929871002645934, -0.7250441622225222, -0.5125633062043833, -0.2145628264753085, -0.6656663063826896, -0.6297783604649353, -0.20635843429787756, -0.6933159710275755, -0.44853522787960426, -0.1386978192292244, -0.26762606188376054, 0.0015531755186195856, -0.5180942310441746, -0.37914872502905983, -0.43392640533146043, -0.6451482955996409, -0.4345004152040426, -0.7705136350540343, -0.27291713157463215, -0.7503766541711635, -0.2780282853174538, -0.6062872837308614, -0.5405075876817722, -0.5025178229245754, 0.02920925754730616, -0.4713795849011905, -0.321736572587181, -0.5462990635801396, -0.4169677772893426, -0.7722186140766316, -0.4207992817318025, -0.8073932003134103, -0.9827382354511995, -0.875876030580107, -0.5236771568331575},
    {-0.558187501291535, -0.6346539793929179, -0.47910801873776815, -0.05033003391841743, -0.7409802079222123, 0.10518004136242176, -0.5338392094082764, -0.633245517208983, -0.5824275051795361, -0.5302311707775016, -0.3214334801272113, -0.42502976537586906, -0.19092981694519723, -0.5421346808449847, -0.6916309610997535, -0.6821307596836248, -0.09407732406753526, 0.28392802398367245, -0.6796759799996249, 0.23494051028583726, 0.21919388534670467, -0.5290513264785328, -0.47169840914513356, -0.14984904044809094, -0.5227090802288734, -0.04857481175277576, -0.44040997353706984, -0.1669997642094146, -0.19547741446199654, -0.8335013311254257, -0.6030279056407075, -0.6046315179320451, -0.22216536925813518, -0.40448559889831254, -0.5724384206252952, -0.14007041297164452, -0.7887274943282881, -0.014026524702957099, 0.004401044315455701, -0.5495864516976285, 0.05700463267091373, -0.4113858451639342, -0.5227099294164983, -0.5263974189982056, -0.4037282377045509, -0.20137940222925466, -0.7258458677374748, -0.5517018127718193, -0.30305585871343727, -0.7644132132783596, -0.7591975096835024, -0.30165940134539776, -0.4940930830459628, 0.4069203378473536, -0.37833018213804565, -0.17923232146186985, -0.6345005751205866, -0.5844783079011763, -0.4959063623159496, -0.465542696073487, -0.5304248580922946, -0.4481666165888997, -0.8364383783454326, -0.3590931314171476},
    {-0.5967960174571479, -0.6141756369449484, -0.5934330580749699, -0.4253258274460049, -0.5740627765799003, -0.09891795479175071, -0.2690385003185783, -0.444216504981745, -0.7125784093465497, -0.5359545730102726, -0.5905694893658393, -0.4187583576011197, -0.39711725694864386, -0.5220045042373537, -0.3626310410820909, -0.47262434060308484, -0.3766820163943925, 0.5053256247949232, -0.7097274089435197, 0.3044841687348839, 0.38816815418471556, -0.6794472828789359, -0.8074634921546917, -0.30623109769646145, -0.8688814887360219, -0.04221111339636166, -0.5011949775473753, -0.22564731952243985, -0.4569312580806171, -0.7489884432201325, -0.637308822638024, -0.7542007828257256, -0.5283102074773883, -0.3249538181069264, -0.6479219450662181, -0.19937517885231437, -0.6416386251402633, 0.06312580826943553, -0.09821408871438563, -0.48855607883810115, 0.20003472143388956, -0.5065313159580563, -0.5921241654116505, -0.7313278317139887, -0.3665116604811458, -0.45797647611713266, -0.6621964138252207, -0.3458247668562346, -0.21156414812000976, -0.8397522027619253, -0.7783135213565519, -0.38936839291216574, -0.5961681917781441, 0.45121572018091655, -0.5618168236139477, -0.3721933818433748, -0.383664382413813, -0.38192473183518105, -0.38682567266018086, -0.87693612713402, -0.3836993672636622, -0.7445720071611628, -0.595116993782783, -0.7256614815361533},
    {-0.3640120910219268, -0.7853313393370797, -0.6225439752129139, -0.6892571125166946, -0.6756534390451231, -0.02649221498483108, -0.5893125223624729, -0.48778642370259734, -0.34237638106116297, -0.7493458441297572, -0.3248818848142608, -0.4015088326832549, -0.4033325528232944, -0.4725857265817607, -0.5646468046434522, -0.6067951493803627, -0.48613684355324804, 0.28444304992503894, -0.8879129391696345, -0.03183122800366214, -0.00458921517984327, -0.5932181904049342, -0.7196509884889417, -0.04109342262764797, -0.635643894509916, -0.5194627851965203, -0.2322573118784816, -0.24946442539672978, -0.20833849926818726, -0.8881417582709792, -0.6924944083973806, -0.38343206171555266, -0.567450660064405, -0.45983178924921664, -0.3770242788272014, -0.20049487683159606, -0.5408838317951071, -0.27981941197899635, -0.052059627065977374, -0.7438950322374869, -0.01663532149688583, -0.5905390387121812, -0.531762913659247, -0.6861522671720288, -0.4880647754850384, -0.44537495787682424, -0.8143347946114268, -0.14685251492549592, -0.5209450937769574, -0.45056018986328217, -0.6791757840764595, -0.5347375638567143, -0.6115020548428748, 0.04668486410587839, -0.4587927761831668, -0.1716198485156557, -0.8097951298554544, -0.30228698646634494, -0.27241849831918064, -0.4710483251006332, -0.5681538650516514, -0.6755793995091887, -0.40011119432943587, -0.747393339952016},
    {-0.6849409000915141, -0.8160761391809862, -0.3325594042479164, -0.5281595521317409, -0.7077164750183974, -0.17339189333850116, -0.3676930166576319, -0.3768198558195621, -0.4821663986825514, -0.6893999208400864, -0.6070666912083449, -0.48601718167608415, -0.381478692483374, -0.3525259385505156, -0.1858225082460223, -0.7761867503408025, -0.24865189629405793, -0.08247632043795976, -0.5488339082155769, 0.5802810778354471, 0.21689305117430357, -0.48808890520647286, -0.5208281252260042, -0.371768775330122, -0.5945069786151298, -0.13708997697356856, -0.34725920723307674, -0.10591333206136859, -0.3999293638368797, -0.6766139239843927, -0.7627592176013563, -0.6835885762295897, -0.6057444454367056, -0.4173429280744921, -0.583472255285974, -0.025186285828901322, -0.573620090459992, -0.30719036811900885, -0.08829756771118606, -0.5102164129046153, 0.4114666982277966, -0.5727708351073862, -0.30414747352439464, -0.28591965237418476, -0.7410179959071518, -0.3475823536856568, -0.5199182786968903, -0.3372460242171719, -0.47288228397020754, -0.5947141705899229, -0.6300168064383034, -0.5805675117642409, -0.7673399713999434, 0.3420143225864701, -0.2563751483953057, -0.5153830209783931, -0.6814969951216238, -0.45152211490748273, -0.8632969130103644, -0.6336744442870617, -0.6645874973183655, -0.6399065639353119, -0.31606067244453956, -0.622286933496751},
    {-0.39000551331497835, -0.4677702868232999, -0.47222124444583613, -0.3182134228811387, -0.5563153888648278, -0.27710201497904846, -0.25885869395083594, -0.47956724403413264, -0.6357839400396663, -0.7492640905412155, -0.8441936294799213, -0.6259526449431194, -0.5444543972842121, -0.8094024170580356, -0.4172287395373213, -0.820508995520775, -0.33799331208951666, 0.14705650742703194, -0.5403045698721113, 0.3287964100751813, 0.27395363115680627, -0.7023382601125048, -0.7787232088520649, -0.6410614570239455, -0.6890145718454822, -0.3294360290949243, -0.4391030148525662, -0.4428427680063673, -0.42676618152745877, -0.444758689311667, -0.6003054002873262, -0.7386192635200489, -0.6271477970673887, -0.2787830468509954, -0.5718733127442795, -0.315206874351159, -1.1125130596656954, -0.1963766924285204, -0.28598599302930877, -1.0711095259281869, 0.21676530095610158, -0.7719376820171983, -0.5177595498170992, -0.7078388867483878, -0.6154244320395416, -0.5024896489058769, -0.4653420771232501, -0.3413736831933803, -0.6553125610617542, -0.8273817067279801, -0.6940520557132389, -0.5556092522624421, -0.6786292764194696, 0.19984402970413226, -0.47178859775839616, -0.41439518959572036, -0.7187480554384741, -0.5640081843918895, -0.7962402059966011, -0.7218121077480036, -0.6052357869119115, -0.7647537791013186, -0.7656355286391177, -0.9542241148057938},
    {-0.638387926494013, -0.7548402363682363, -0.7776524592590947, -0.4409151894700371, -0.5231302651144404, -0.46404811742108076, -0.5713524134844117, -0.6256554155017008, -0.7039501659589943, -0.9626694049970107, -0.733987428890749, -0.4835638691201794, -0.6163144836742648, -0.5645014495071751, -0.543680289337676, -0.8362509875496207, -0.32762147532983527, 0.0867223991227131, -0.8385365670557627, 0.13125576620603716, 0.32274874682369276, -0.8733850150906594, -0.5048869450615274, -0.5942858908794634, -0.6462118488584544, -0.3351684399032101, -0.5612682435117671, -0.18452586355149067, -0.4113289495377249, -0.8695188052222417, -0.7587485202170496, -0.5703406158821925, -0.5534296747692442, -0.4189867924355488, -0.4512750008756545, -0.07777332334120396, -0.7030374063638248, -0.0059650353402114316, -0.07094663643602996, -0.6599672256200992, 0.08921511243151738, -0.6242673279788519, -0.350704411157735, -0.7456894697532497, -0.7204147202458505, -0.3067326758623461, -0.4252467233789054, -0.41237508687682983, -0.5088225058400633, -0.521246006365004, -0.748761245094222, -0.7752064687908113, -0.4304395107678244, 0.22487348193718049, -0.7750695448081797, -0.6824371904110724, -0.6944322032113713, -0.5118126268808281, -0.5985251854041526, -0.5106430685363135, -0.8493319234135231, -0.5252046333703467, -0.6739849402669722, -0.9794163028514826},
    {-0.6973275760541583, -0.40719110267291736, -0.6743029112699379, -0.45489530953414803, -0.7449726242587842, -0.3747007828142125, -0.22804850661152307, -0.5929249369877961, -0.6420347008211774, -0.8530558282005937, -0.43627437043805056, -0.7548991503250504, -0.08217214116744569, -0.033880696068895454, -0.4379694063754626, -0.7708822818191305, -0.4632201453647681, 0.13012009153127158, -0.6080425382356023, 0.3453394520256917, 0.3104583032689311, -0.6162232161385749, -0.3470854412014295, -0.4281985721356721, -0.5936826240248875, -0.14325136380662612, -0.5518582625425047, -0.596815334875896, -0.40094816888665175, -0.7706634439907464, -0.6514191261310863, -0.541911338195025, -0.4369721422184855, -0.5442437312153827, -0.6076948054746547, 0.0863292927025147, -0.9751379006368851, -0.2392841131656253, 0.03254001957520721, -0.7024655690264883, 0.2672430561744879, -0.49029666665348676, -0.41964849681924243, -0.6590504607877234, -0.8117195893716816, -0.6716030219683521, -0.851847763606865, -0.24380528821909642, -0.4918213771302187, -0.3793182926169366, -0.8500100688855219, -0.5365174127778567, -0.5741057578275892, 0.17690734237016972, -0.7732789406448376, -0.7343582416517913, -0.756398234854039, -0.29163797958496646, -0.6274802420146733, -0.7448316275454406, -0.615945826116608, -0.7967002359456704, -0.6158659856070582, -0.4179510528618164},
    {-0.5263449591759247, -0.6283108085678872, -0.2018339181822671, -0.4009268936008422, -0.5331586003928637, -0.24907537626417492, 0.0866854986008295, -0.6555182170411413, -0.2234178683605517, -0.8296446613734986, -0.7251550685311652, -0.6092783411800584, -0.41127247444353576, -0.47686360626549534, -0.6046091332877004, -0.5477098370611967, -0.6228336443836235, -0.10488861482010028, -0.7880314230402996, 0.07897199088304906, 0.337937461451976, -0.33664974886647364, -0.5789617327284261, -0.43699614646151713, -0.7679252438070244, -0.06160273351164587, -0.5012432977261566, -0.5336408201481764, -0.5727095743822738, -0.7401477237491697, -0.690087294169292, -0.3527805528010755, -0.5240946841408238, -0.48216064591712976, -0.4719545691291015, 0.04296248485957384, -0.5269799987932008, -0.6319921688020075, 0.0475428112454489, -0.7586498305195802, 0.22172195493260288, -0.6593530009491432, -0.3661526796260626, -0.5966567128267566, -0.5250701492550217, -0.3844496938939208, -0.5654782484257054, -0.7253958593226251, -0.7917933746276798, -0.6523256618581948, -0.7547986437081463, -0.6967494610880268, -0.4269740844605759, 0.4505682558567858, -0.6651678396726879, -0.31977032623251883, -0.5153298521716188, -0.06859176894039261, -0.8833650020455797, -0.7530038906171366, -0.7251702121198021, -0.6114009170493186, -0.43366806387282464, -0.8195695023114784},
    {-0.706998568586231, -0.48715947526646797, -0.7859829139539354, -0.24696047611250563, -0.6927838657749923, -0.443950661602842, -0.26972346964145544, -0.5689907368227454, -0.670841110222389, -0.604907398222897, -0.6128465346610518, -0.5942263847870273, -0.20962483040157628, -0.10758294335404045, -0.25786934504614534, -0.8485517180583252, -0.25827374106230694, -0.1722061891861175, -0.4730188937472972, 0.29595185101856203, -0.11650689425915764, -0.6222017545497182, -0.26202563306885884, -0.3140241865470033, -0.6022511208816022, -0.031796083508170155, -0.5325976911019913, -0.05734675699275919, -0.7695207471225577, -0.8433064394999239, -0.5670854135283121, -0.5443071947672993, -0.6179156103440001, -0.25127957590817374, -0.5268378738766071, -0.09927158323389942, -0.6084098578614234, -0.47595554569049514, -0.22950626273963465, -0.4235592452230848, 0.1369898114109031, -0.6643600381494985, -0.5343878564393232, -0.542563829097323, -0.6805874814146722, -0.28359427458817027, -0.44416861656482043, -0.42366305057499176, -0.5875999034618833, -0.6628633141813749, -0.5068777949546258, -0.5758073251340706, -0.4350601533906831, 0.19022620816631397, -0.547728509719519, -0.3460946215341188, -0.5177806505097946, -0.22147260504302604, -0.6729748092951946, -0.6406070766434261, -0.660442191915265, -0.5513414556981268, -0.5060738787681447, -0.6909411211863608},
    {-0.4519147764121713, -0.7126257921709591, -0.4331424208070522, -0.45074322881514806, -0.8216720548868877, -0.09454023341275127, -0.21559131160366302, -0.41434664384717323, -0.5822056166508134, -0.5217727013723498, -0.6445907899433257, -0.5652602692775227, -0.43242874465506825, -0.5309257055439139, -0.5697010122431686, -0.8993464112199002, -0.3481424504482143, 0.22361717610175644, -0.42101077038546636, 0.45117671942920273, 0.2393091597917738, -0.23266710572298882, -0.4281902023405824, -0.42718904489269227, -0.4031545084506527, 0.08714431837177246, -0.6396235279348, -0.20023760057007883, -0.5935417204052301, -0.5623038684969943, -0.764622451894028, -0.6014658319018966, -0.7319281557355819, -0.6006967093648317, -0.4652360652430279, 0.01465372945012083, -0.39433182508151016, -0.07124016373421903, -0.06270486797900982, -0.44098617667653195, 0.46043464079615565, -0.4039116661128116, -0.45535229226971946, -0.5310670945239733, -0.5887212186742136, -0.3755107747549615, -0.67175106794982, -0.4859101860135879, -0.5407728920953951, -0.6706880475253445, -0.6314510132925262, -0.2825156736261589, -0.3767509011310609, 0.21731177639790739, -0.31518613053656375, -0.45057154253821263, -0.5039873004946155, -0.2251175874490724, -0.6097937662961096, -0.8695358639829365, -0.4972217754875373, -0.7833133048658161, -0.6743750012936199, -0.5834335035200202},
    {-0.40833725000599413, -0.6204234501776575, -0.576032037445014, -0.31624616547129125, -0.7911670079483508, -0.3932735533477179, -0.14302654460489708, -0.36810764468364465, -0.7677062804047812, -0.7820971075653694, -0.5128299406946457, -0.5439669198751298, -0.5348761949510233, -0.3041494141552527, -0.48512582305406476, -0.8136909309321493, -0.30651391618193, -0.07047421369467267, -0.45922966677933363, 0.27061916609342795, 0.22293431239338724, -0.4385700341387272, -0.24151364915649587, -0.7869999493619413, -0.9181203339517346, -0.27977156398219927, -0.677064853895079, -0.17986808959978648, -0.31806688781058506, -0.7611549933002726, -0.8664735816715762, -0.31710549463648224, -0.4923947639854794, -0.7123774695778278, -0.5179171991979393, 0.36688000079200883, -0.7223152590170968, -0.08757919083183371, -0.025510140915955003, -0.6396700157760806, 0.058135579829398966, -0.46791604007739124, -0.505730401609677, -0.24565568571757865, -0.511552621957967, -0.6398575410232138, -0.6152999364934602, -0.35887002220222003, -0.09478855547021177, -0.42666829874613577, -0.739146920581326, -0.4456246704822924, -0.3615429688551342, 0.10237812635221967, -0.36483622261879495, -0.42339647419041004, -0.5076269756011799, -0.1963004797900921, -0.8161827290501465, -0.6376670399596678, -0.8564209937053384, -0.6036950167582738, -0.47936395435999635, -0.4482607534720369},
    {-0.7518755532096468, -0.6294581727211843, -0.5625377810989879, -0.5121545879656477, -0.822057956271694, -0.6563959854366636, -0.33637181006652295, -0.5044512629402146, -0.788869187218968, -0.6232517969872697, -0.8486106264485992, -0.7686266817548998, -0.4684545071922625, -0.3405133046883169, -0.6359813570826104, -0.643809974556078, -0.4443645281256472, -0.03910920805206175, -0.547872781707638, 0.29447149502865944, 0.2258964197203511, -0.7055794417143904, -0.32816470203360065, -0.42796872829226373, -0.869049466594103, -0.29792099527031835, -0.37145222317477367, -0.2257336237343443, -0.343967139428557, -0.7848457634552733, -0.7383700409536283, -0.6801234368036508, -0.740801105023066, -0.42963579130131524, -0.5002123014628532, -0.16678639504588996, -0.8309125207406524, -0.28439266879480324, 0.02351518137656766, -0.7622621436382472, 0.29671822619201904, -0.6196129850137104, -0.603351067300181, -0.5068309471978998, -0.6794302084732263, -0.963051472988834, -0.34534650875517536, -0.5650397365585889, -0.6531257807353593, -0.5995309157588087, -0.9502340131774764, -0.6619792020521638, -0.5548326553207626, 0.1112119827825766, -0.4802193361634993, -0.4124290619078544, -0.5257525512830231, -0.5185007054956025, -0.7940262663547715, -0.9447527141457225, -0.9200813236933277, -0.5440011158068366, -0.7378616304822898, -0.4948956788234328},
    {-0.6966231858603641, -0.7044544010593592, -0.5644399397478079, -0.7510171785654173, -0.58714060470544, -0.15566088642904705, -0.2862892652296938, -0.4116574204934014, -0.5601201514596614, -0.7479226473345782, -0.7253863232416495, -0.5059145015712353, -0.6870388977255666, -0.6466925324752286, -0.6780197355035811, -0.7237315984577686, -0.38173552206405487, 0.15267164989505724, -0.5577422342544763, 0.10140636357449563, 0.31655390916512355, -0.6749061020551819, -0.3263054283443162, -0.14965351581104647, -1.03152399623716, -0.1455688081386034, -0.8209940550750943, -0.5163950919438921, -0.5050529836577001, -0.9136209898067402, -0.5961135243651493, -0.5663558831405854, -0.6366608238313992, -0.33594934121218156, -0.584243571620153, -0.48580976809289733, -0.6978006965618974, -0.45291109188605394, -0.3441518075967929, -0.7542208508501118, 0.24456292336384947, -0.6873069029196144, -0.5375324071790215, -0.545040829682853, -0.6790137618105446, -0.5872166112714927, -0.5823240136436307, -0.7649619729939385, -0.8149942481878525, -0.8711959855317022, -0.5346495393442399, -0.6705129633385113, -0.42481625739944384, 0.4021455369912583, -0.6120846157235224, -0.4417032856222851, -0.5087765570998021, -0.44015884682844775, -0.8454225004748549, -0.838398634666858, -0.8444236809077607, -0.4851512143727407, -0.505056921021952, -0.7818091713177063},
    {-0.6123700494767066, -0.6378227511763331, -0.9695193327012923, -0.25394798879255304, -0.841405979641741, -0.10393841084468333, 0.23472552123239912, -0.601941035893816, -0.5597406283114403, -0.8945968387167623, -0.7816814881747367, -0.575021542787251, -0.32919329188965224, -0.5403123636309024, -0.681220170897934, -0.7227449609196922, 0.028554197286307835, 0.305566332146973, -0.872288966333428, 0.4960849625012568, 0.3428062141208855, -0.39825611008545675, -0.22436548761314767, -0.04311740635752096, -0.8002274191940341, 0.2613333196796792, -0.736193204610207, -0.16863427605719047, -0.5385220576042493, -0.9515264127303245, -0.4537199050628275, -0.7750984236105762, -0.4871001474722949, -0.6370798433668181, -0.6254017564422347, -0.19652155901908028, -0.8043291433683739, -0.08195498666696055, -0.19316832521615734, -0.7169693997599247, 0.47646130985522633, -0.5416698259468222, -0.566231366845987, -0.6596197730977511, -0.45012494470068626, -0.3617088212770062, -0.6870763262763244, -0.6131317851008592, -0.5125538420112437, -0.5615031376868594, -0.8991604616183451, -0.3084253213394435, -0.5644561796881318, 0.559924744839474, -0.3804138714119377, -0.31685856587132316, -0.43299007040083276, -0.4872655928199787, -0.8446160939679722, -0.7188836251512203, -0.6552147554182688, -0.5347302115619653, -0.6738957351084296, -0.9549252033559285},
    {-0.5213286219368051, -0.9212322241934999, -0.5659115856769055, -0.3435464335827184, -0.8473301759944292, -0.218502121257879, 0.40745335332120375, -0.34080940593181913, -0.3957565133134307, -0.7839317831631336, -0.40126817850502017, -0.5878765388932969, -0.5262672350238313, 0.36720969801224984, -0.3261811301462581, -0.5808191841480299, 0.14344995696128618, 0.39709876384222753, -0.5301865543599998, 0.7234356421685942, 0.6178993983878263, -0.47505484960126143, -0.10644817159126704, -0.4688576931079809, -0.7634987808115117, 0.07684785019044016, -0.8129835841727374, -0.539805547746513, -0.549599203969104, -0.732767939087903, -0.7661966314092229, -0.5646663934066967, -0.20181837694973107, -0.6161547426766062, 0.09922554821418159, 0.43555465169131224, -0.6619643177912738, -0.015977843132622644, 0.3282781886710881, -0.47724299396556513, 0.23428343472451554, -0.4281581348071343, -0.38131757308127984, -0.31840551108220455, -0.0463441465107607, -0.9819050358920414, -0.5754601236279462, -0.07269751238080313, -0.6116283986165365, 0.07610365540822324, -0.7846037311653645, 0.15426698219692492, -0.7907831512074801, 0.756479974707478, -0.47367325370454477, -0.4249100446529316, -0.309474575303644, -0.1496581279877578, -0.6097691101687188, -0.47727797465523086, -0.7438702202198312, -0.2615896479409061, -0.17532491487604607, -0.7506035016083148},
    {-0.5817322004979026, -0.4697802293435039, -0.7574806829736906, -0.5355558084075587, -0.9020362751733932, -0.5014018776791268, 0.3398087883433326, -0.43443548082116856, -0.39600834659050377, -0.8299186724033586, -0.7373617948229816, -0.7829096874349746, -0.23716240967554073, -0.17370358055964766, -0.40455728674589897, -0.7046002087251819, -0.38446602172864697, -0.07696721996970222, -0.5602841222647094, 0.230713084971209, 0.2984528761897833, -0.4996064287779543, -0.35831624526108274, -0.675109382875917, -0.8444168463311796, -0.1378622414239857, -0.5532485090365132, -0.5638605628706768, -0.3752324263073433, -0.8149061711293437, -0.6945330546591805, -0.9274628307379523, -0.29388510612887764, -0.7413402994987509, -0.27390854707118023, 0.14516951435128791, -0.7761677720615763, 0.009207112971515455, 0.04994495473656882, -0.45519778967718594, 0.505527367972979, -0.4558855037000435, -0.5809672438142007, -0.6537331443683733, -0.36922875594234406, -0.8186658166750846, -0.48589719290307404, -0.20174226134068146, -0.5240995554159968, -0.35171777609354987, -0.6099029373298692, -0.020838689540438455, -0.5246851419129148, 0.20878880497476082, -0.4892760335110895, -0.2238780771577315, -0.6406786613983072, -0.025152937515966707, -0.6177370608080845, -0.5640988016832398, -0.9178554173320822, -0.381542787270312, -0.5490628887964107, -0.8441821631600063},
    {-0.6150071322499306, -0.8826543114951423, -0.7349737757865081, -0.6837663457063625, -0.5235135901988701, -0.37000939378228165, -0.3188755685978544, -0.3919401779717994, -0.3848351606112033, -0.9452293178295672, -0.8327869122082708, -0.6554925734106257, -0.6684780980832351, -0.26377125726468553, -0.5132688140566202, -0.6209391683777246, -0.317503123035098, -0.0881758498337332, -0.8881325619188388, 0.20838259207765958, -0.04602787445872175, -0.3266569609118166, -0.44128231509554894, -0.5480155689610062, -0.7778441972859413, -0.0932571715488664, -0.44978879265553806, -0.40910762121933314, -0.3282168248827069, -0.8714908297263522, -0.7028490677922137, -0.48627196825385754, -0.536541092313619, -0.8202913082784871, -0.6188603342576754, -0.19205483518058147, -0.4934974763209677, -0.3012799677861814, -0.1934485209868047, -0.5244521287889008, 0.2338342014489062, -0.47189419798270943, -0.6394869803803964, -0.8204478090574677, -0.7085348500588471, -0.7207241783970931, -0.5076672641164015, -0.38930721694966214, -0.6828840439251259, -0.4812519503064382, -1.0125261987027836, -0.40934138854397173, -0.4862802839730316, -0.02174139738314886, -0.475871508335218, -0.19966819926241325, -0.5064918563045094, -0.41862998737443285, -0.7916947039437495, -0.7281754713844343, -1.0745558659422967, -0.4655860230387429, -0.5776035317228267, -0.802875493904872},
    {-0.8417688885921298, -0.5321149700141236, -0.46591385951666237, -0.5494445785655921, -0.6681313125181084, -0.25388981197427535, 0.17343227900443278, -0.2689844515803791, -0.35110148706994654, -0.7500659131845612, -0.6313037852728829, -0.599312876851939, -0.22476903307802482, 0.05661844793209192, -0.17973068837054082, -0.9681707018399878, -0.15599671851495966, 0.023961195013702107, -0.6762485278880216, 0.3295596900504872, -0.04340750639105877, -0.39641188359850216, -0.47435890046544, -0.4868803760019939, -1.03927991456355, -0.22384526787290954, -0.6218556014856897, -0.39994153138109284, -0.4503243601467131, -0.6602012974584125, -0.9261934697762693, -0.6410676462111429, -0.37200809975335514, -0.525285741597585, -0.045756881265869624, 0.23249504769695328, -0.5296594501207686, 0.035560817895009644, 0.2888435173499761, -0.47479894069443906, 0.335053284335699, -0.7082950544696202, -0.5795897469243751, -0.4241909051138555, -0.17649719773930106, -0.7700998953109875, -0.8248375366539454, -0.19748093840275188, -0.8489915838330734, 0.017177434691114664, -0.810950747615716, 0.056870184731736, -0.2384253170813688, 0.22911571736319525, -0.530586712766239, -0.6029886033613091, -0.5145460083052429, -0.051099777568899364, -0.5792104246477822, -0.5528832740561485, -0.5810102725946894, -0.4969281838029082, -0.33062143786542714, -0.61411118118072},
    {-0.6170779620739256, -0.7061954229203431, -0.5172181986148262, -0.40663703794851724, -0.826291504600978, -0.29321196410191164, 0.4464535974721985, -0.5447793425062514, -0.6473005006048776, -0.7668938557220001, -0.6055633067039609, -0.4612057627420176, -0.38534551743740997, -0.05017662685174713, -0.23747663264444238, -0.7273670960257966, -0.31188267349586146, 0.01173099447118784, -0.39911616844605813, 0.42249404522684947, 0.36830749387124906, -0.5865206695763228, -0.34623884316773157, -0.41525153556131655, -0.9314111643126136, 0.08240324280341535, -0.7755743244730537, -0.47016589281395277, -0.562081550555782, -0.6341623267829194, -0.6785897273031057, -0.38093385055421997, -0.2460781856095648, -0.4736156977250089, -0.33277080432099904, 0.14683690358778342, -0.8259730014939369, -0.007841310745533197, -0.21432442834756227, -0.9055729017558306, 0.6205730896868065, -0.5466488493653396, -0.6851425679468301, -0.4745846977138329, -0.17114784214033085, -0.6677473685269713, -0.5703170239893093, -0.6520303446732926, -0.637299051755717, -0.3100748816256683, -0.795124473024147, -0.335145280615268, -0.46488657045868303, 0.28412492681741497, -0.5452613895541893, -0.3341207935913663, -0.3144595835699273, -0.038742150889798835, -0.6686055957900751, -0.5681040181214019, -0.4405410504874971, -0.3726118278674656, -0.5250367899359845, -0.7862319043006673},
    {-0.6466831365644669, -0.5278416533765551, -0.5931719412374394, -0.5247495835255215, -0.7632274610388095, -0.403890093587269, 0.07696994155711412, -0.6480841459161093, -0.6362485229216837, -0.7278342717217896, -0.7434597248422301, -0.7232985632799588, -0.2533688059916628, -0.5003866716991149, -0.47539801629541284, -0.7730889729290131, -0.40393587306123385, -0.04143979488917635, -0.8511208990734493, 0.13770783593523964, 0.2991746509956096, -0.47895183416898757, -0.7452279553283675, -0.4307314494991552, -0.756233753256085, 0.036830657606691894, -0.6221446541495075, -0.6251249102737886, -0.5542318553035478, -0.9240094062375618, -0.7653262459936857, -0.589772025488598, -0.41398908341437374, -0.5274891120034483, -0.2757402637664546, 0.168191609013877, -0.6950874440638338, -0.22324051468399692, 0.1614903001234081, -0.5441976235655429, 0.2896479022897098, -0.6768876083373899, -0.3049387339484127, -0.4951081578213722, -0.4589835286286134, -0.6114935977575734, -0.8119252464606967, -0.28602432960217455, -0.7629025321514702, -0.34535901179343276, -0.8822455786842684, -0.34103952733333964, -0.4764131749537933, 0.1410996949531952, -1.035272799069309, -0.5416646543447832, -0.47776859429016116, -0.12064490740729795, -0.7061863675330606, -0.7277040414516079, -0.7643681498072981, -0.2611497598277402, -0.524975809929229, -0.6648142814593632},
    {-0.4581791307197641, -0.640529613614451, -0.6712432045342828, -0.5614083056636658, -0.7464259395164846, -0.513765419959518, 0.3033096436737048, -0.437618771469135, -0.7418784883655161, -0.900874602490707, -0.7966176008355247, -0.5338071617312427, -0.35893150883992636, -0.006279886909206965, -0.442076413339463, -0.7283722849534958, -0.3328480427146608, -0.1991940233197713, -0.9786261226870034, 0.5909892104128964, 0.38465178069312017, -0.6021904237140452, -0.647294193357927, -0.6314164398227655, -0.718115189515068, 0.05673896629084325, -0.6488174502682117, -0.5744512845784012, -0.36645702983730044, -0.7795797081295263, -0.9356873253238028, -0.8094602061518335, -0.5374780893773009, -0.7345072596740932, -0.4206396960842491, 0.2535019928360584, -0.7843605686476546, -0.09321512138517252, 0.1734899232163319, -0.6492524147392424, 0.3930492208685619, -0.6144911450374423, -0.75679951466385, -0.5362505965190995, -0.5839111070852111, -0.5233606590203811, -0.8266664966760578, -0.20366223114494064, -0.8102830406375966, -0.15013807130568943, -0.7425590931747574, -0.2053925178438107, -0.682311242263675, 0.02480758240446516, -0.7278086407834439, -0.5673827484840198, -0.5646218477426139, -0.23990541789452294, -0.8934905008432394, -0.8286526689330734, -0.5782981822282245, -0.7414865806353743, -0.31207212766362247, -0.8439713500101382},
    {-0.6464162100239293, -0.6834347788827448, -0.46850275265154767, -0.4080818355757958, -0.698108412167687, -0.01465658346320547, 0.5045424391316885, -0.37518088101540203, -0.436375608673423, -0.8759629334340941, -0.5491232995174453, -0.48075730312619175, -0.18679058968959503, -0.2728775398848539, -0.6179997652145869, -0.7268483290453432, -0.10082203694218715, -0.0469139901979562, -0.4896751758905826, 0.5364058532974573, 0.4678054969075152, -0.556165849168272, -0.512178489432077, -0.8907717759911616, -0.9223656098746518, -0.021384617892457762, -0.5574900712787351, -0.4464904521799929, -0.3259466181876617, -0.6802225565816894, -0.7464947612625336, -0.2699673746088736, -0.48171712235789904, -0.7919426599724232, -0.18173793031615235, 0.14992280368300617, -0.7843102569620866, 0.12748890109481478, -0.04150323960344431, -0.4811579072845082, 0.376773574634603, -0.8452851785212981, -0.49204008483664663, -0.5191777508103673, -0.37147899076498886, -0.6255039341998393, -0.9367202440061814, -0.1165046395717784, -0.6345883111537937, -0.2826991293623293, -0.9409263995384274, -0.06705382940959786, -0.5429261413019191, 0.17531617981311412, -0.46630765924313394, -0.6070979379076427, -0.5832145906541691, -0.21284548363675648, -0.6927243476118516, -0.4539691297612417, -0.7574175864075086, -0.3768617066566625, -0.4609122329028889, -0.7902268621726605},
    {0.3081166100707112, 0.5283770024450448, 0.7297168745728254, 0.20534208306288707, 0.5062944071640781, 0.4081911602317156, 0.7547186169363878, 0.14500213027401967, 0.4108715379857737, 0.1799895723880705, -0.23962939902027003, -0.6698138445835475, 0.35372322692564556, 0.45658122889458347, 0.05728618867135542, 0.36878626404867304, -0.29463571641822456, 0.5303681772208242, -0.3077892394775442, -0.2577675891431846, -0.20434383452102714, 0.4407037725872329, 0.46854906189532713, 0.22644612647419005, -0.7406710859650899, -0.6675326993474426, -0.256515514199444, -0.32538169845293613, -0.13333989906153915, -0.43115747091558676, 0.3905694612401961, 0.04583437252084865, 0.46498890837003704, -0.3615377776040591, 0.008851621533656776, -0.017295310743837417, 0.08311588171744524, -0.40761229335618193, 0.4675895815063695, -0.16848323127895076, -0.48868731011246164, 0.06801838984636412, 0.4930681042424463, 0.06365418018489352, 0.20054164564000046, 0.09903004882562268, -0.046071898327947766, -0.4158131690050473, -0.24339568797122685, 0.7207472233717792, 0.11213095715949163, -0.035661273663593625, 0.28378580613634075, -0.09996437389229337, 0.32698447684553594, 0.31187543964447806, 0.4497144598321315, 0.11697990692414274, -0.01322555495265227, 0.24550459065504954, -0.5873165871795639, -0.1728084892129916, 0.01769372470797551, -0.25333114037231674},
    {0.09383965511470715, 0.5963849312219163, 0.4715591607551553, 0.2542095118171395, 0.13688957351904749, 0.22264291491248273, 0.30088531553007986, 0.49745693482636144, 0.6222847333382011, 0.17683952260414557, -0.1684762323642444, -0.462952532922584, 0.6286100102235413, 0.2659362742353781, 0.3423506089452043, 0.37736372271652313, -0.5315337426305995, -0.0006423797589586688, -0.018545586446525226, -0.1709908472173763, -0.37704439740210527, 0.7901014560923612, 0.7147986590014227, 0.3483958243736273, -0.6358490301479716, -0.8209706060660922, -0.4207998883587787, -0.048310755969752844, -0.38278450484026366, -0.27957184480296615, 0.32828153454575437, 0.4893236664892574, 0.6206630717428447, -0.255007812430712, -0.4399704396953741, 0.014368439016811457, 0.23255172308377883, -0.41850087485100074, 0.5872780283080928, -0.0729385505340658, -0.4282046642659736, 0.5858799239258111, 0.4921167671038142, 0.27309513960744786, 0.601985932947793, -0.13472231639041676, -0.07913030377050577, -0.28888761921043, -0.8312137829837831, 0.326843553878741, 0.39112532232948527, 0.2535488053729268, 0.3735860960891774, -0.2740818959045488, 0.4546341936041714, 0.7106785011140739, 0.4984510086637715, 0.08044051022573956, -0.03905117072061803, 0.6660254739321555, -0.5023599842229873, 0.08793088244947847, -0.3746312423778608, -0.075995437770422},
    {0.5569950785361651, 0.41251323480604035, 0.5208529887229386, -0.366752276633689, -0.38660259920475654, 0.3246129305275704, 0.5431533650167908, 0.42463128929691346, 0.595782881624664, 0.30422948996345467, -0.32323808504054546, -0.25946078455717636, 0.3033958594485902, 0.4886659006840071, 0.4559780177889651, 0.45796291103322423, -0.7680366114509395, 0.2192326550431471, 0.1235448062253387, -0.08743820080197287, -0.4598387835654148, 0.6828624648425983, 0.853311022607247, 0.028469985192969508, -0.36908256565256775, -0.7972275817428833, -0.47737276074089174, -0.3071912850560051, -0.37935418746121524, -0.25873251710849715, 0.29950946732827216, 0.17083150706456496, 0.5322817787020863, -0.2399371340144606, -0.028596884031610162, -0.2770850866587721, 0.11799420129239502, -0.688036431144145, 0.7838526362259899, -0.21063502670563178, -0.304347337634668, 0.46332634978530574, 0.7284689759992162, 0.7053887246270916, 0.5829893966376882, -0.15091386002667256, -0.14719726803873295, -0.24276126410423823, -0.18323509387573717, 0.5453695609444169, 0.2984903328302757, 0.09331359038297408, 0.4052480229194951, -0.2868944330259902, 0.6120966502751501, 0.7610300009235162, 0.6036957495838822, 0.4487489183751047, 0.5050005697309248, 0.6207246540800094, -0.026208170176364752, 0.09609995175439943, 0.011432669586037641, -0.3586134346534183},
    {0.6274501359312147, 0.7639079846071386, 0.20984364295227487, 0.16090010832966944, 0.10229961422201904, 0.43242175144316897, 0.2694905808364124, 0.5955233875278536, 0.5309132010328871, 0.3198737322746336, -0.17254094464015815, -0.34891125788802363, 0.371623654816074, 0.45296853158456424, 0.5058681219152898, 0.17141236075817773, -0.5032166114447086, 0.4101714208106575, 0.13474255229810475, -0.5285883624176907, -0.37746867765638153, 0.7030602319749699, 0.5609146626559874, 0.3916912371596761, -0.15283783962218678, -0.6672181557365388, -0.541655295838575, 0.1380305584551436, -0.4880352900885774, -0.32852218797132027, 0.62990471805619, 0.15953908067385536, 0.3650274340348411, -0.5260270846142213, -0.21903061483979208, 0.05567275069839942, -0.017030892906985118, -0.9515863140401797, 0.611548633067731, -0.6699568619694712, -0.41408212350093354, 0.5260985969549109, 0.3651015423536536, 0.536609606932063, 0.3240374272936092, -0.14673213369552027, -0.30601836391541304, -0.20150234871919703, -0.7787607888380418, 0.5493702300274254, 0.2760388025835565, 0.06428755641233493, 0.4254913212323818, -0.5195226011920779, 0.6361757780883236, 0.5077778541215167, 0.5149859492894099, 0.417638892415533, 0.6096692126726566, 0.6063481878524762, 0.12083251596786414, 0.23779836419867115, 0.20874234656566454, -0.14027891132445536},
    {0.5335055117344143, 0.5750555519963495, 0.5552898465477193, 0.14875407485960868, 0.26304729386318454, 0.09700681569635157, 0.4633350379605296, 0.5706548132737074, 0.7467272953389817, 0.3796959519922915, -0.44882584189623864, -0.22096360522567834, 0.4087524607753501, 0.29967137767842944, 0.5840510663796623, 0.27170781369757074, -0.43330099341012834, 0.10636743296152748, -0.037322386986329635, -0.32476487854502756, -0.3131795002886059, 0.501795197820193, 0.9272226192840608, 0.2925454145496288, -0.42001583635132456, -0.5098099584041272, -0.32617491915149266, -0.3549310163123676, -0.3171325036131559, -0.5936528802964889, 0.6070147369764203, 0.22464876379151125, 0.38174631934508696, -0.2687570316619619, -0.16934433895272052, -0.46465697511854337, -0.18539489515203852, -0.39435291588500415, 0.6978380907682501, -0.43425713214974015, -0.1941980332587269, 0.36149825660204354, 0.4612257600499446, 0.748653947194934, 0.4229570371681125, -0.1202414969206438, -0.1693180223405076, -0.0929501303288481, -0.5335413694184956, 0.40854069624516115, 0.5059029939098407, 0.27493561261518445, 0.741687992003799, -0.4086204307776848, 0.40341354283628955, 0.7230373385904497, 0.6371743541856779, 0.11515199453890715, 0.5922111409079347, 0.7137336225322932, 0.20021326204046944, 0.2032816341742343, 0.44247028652467735, -0.13283255266211683},
    {0.5833910461837177, 0.45483585650386305, 0.43937310847074657, 0.31022647782548285, -0.01346518635789056, 0.5239478685843827, 0.6560770412753736, 0.3259253843933913, 0.6240389555700646, 0.23976680409236575, -0.10151058430706694, -0.19212262003932884, 0.6274056308402566, 0.41492903182694246, 0.5120344675105596, 0.5070602661732083, -0.8756199618791449, 0.13575422063534864, -0.17942923054563278, -0.48254490956460805, -0.497861167421907, 0.6903664318175724, 0.6426308364093307, 0.16192839683128255, -0.7416031759016244, -0.8404174262864081, -0.4206351721945554, -0.17158737824778747, -0.5750645340760798, -0.4668101668538512, 0.503857340797698, -0.10875346782107656, 0.3344727834301464, -0.2778327444104287, -0.3805586457877312, -0.17484863268940035, -0.2911180555166747, -0.6637838967195931, 0.44374528989517575, -0.6498227728551192, -0.46263353647218336, 0.544477053952268, 0.43762146660249407, 0.5589812318451156, 0.37207717663005824, 0.3178518665191525, -0.3667290075333963, -0.6445525967625191, -0.7432903818382324, 0.553172255795977, 0.3840288752423516, 0.4698270814222855, 0.7066212485885767, -0.2468684979393985, 0.4580797496296121, 0.5842285750615807, 0.39657549588828445, 0.13985634623288798, 0.4338134326741315, 0.4647976150757273, -0.10381124470838535, -0.017011456384778374, 0.39719703150304003, -0.16908929978650786},
    {0.3918407582797715, 0.6081561341911901, 0.39905802926205397, -0.018387584539674012, -0.03668158447297292, 0.4302775416212433, 0.658485048945797, 0.3155736045929846, 0.7602467403277244, 0.27429165576501197, -0.046147844971454396, -0.6312354741876062, 0.23243736191377026, 0.6535472406797339, 0.5246609777701854, 0.40714409214057107, -0.823028522346914, -0.3347811088327093, -0.3654356181051745, -0.4829462925453627, -0.3492205196481055, 0.6857306210618762, 0.9582693981520228, -0.061560428774202196, -0.672104574895857, -0.6580621209331232, -0.6618423351859104, -0.385496537987584, -0.6666874811730915, -0.6677239155320949, 0.3844285140220433, 0.2287584784298996, 0.5065509819227297, -0.5575546054593868, -0.4784808380712208, 0.1399199990765606, -0.2793760236796068, -0.8618135211665909, 0.5939851972080566, -0.47935887707122027, -0.5109968584488125, 0.5796574133447839, 0.5761216152130254, 0.533180322162465, 0.324049872263589, -0.3416249735495866, -0.11601850375849364, -0.4466135934102769, -0.42709761429669385, 0.45056266871935063, 0.33435294096796675, 0.21110112871646675, 0.6891038752338927, -0.25582762176843166, 0.5551469875800398, 0.5107429487916096, 0.4381850699971221, 0.27336196624793757, 0.2852908432603111, 0.464192569682012, -0.1117451236631227, 0.0365404345087034, 0.1750871258940622, -0.24988535974422846},
    {0.6215323647194758, 0.5500300181020382, 0.42867421697987756, 0.31474375087921214, -0.03350830942946952, 0.5195889543882287, 0.8805855850167348, 0.24626406529995004, 0.7775433148012113, 0.38147781449094526, -0.05428535378272712, -0.3350262082261617, 0.5086435273570435, 0.1023011438066251, 0.29614472058798963, 0.5377083876082089, -0.7281905345966395, 0.17943997993534172, -0.26022446482561956, -0.501487336239337, -0.9590542178193849, 0.7462179818054804, 0.7674834823355402, -0.27049702675358767, -0.5615128216097592, -0.6088117105976899, -0.6866641337950454, -0.25624466721545053, -0.569098280605241, -0.6255465029536672, 0.3714578385513358, 0.4467303542530049, 0.3503918183123609, -0.3393245806860403, -0.3436584757770571, -0.10437908729124248, 0.21405340115618848, -0.31349166311568866, 0.6732809739311011, -0.3113063822545552, -0.5127643238943603, 0.4179180765822332, 0.6035580171826758, 0.3947267365490927, 0.571236937372581, -0.22558527437894405, -0.05932479915863884, -0.6972408741269013, -0.6018033356855262, 0.5421262748861824, 0.634684292279718, 0.21736448784817947, 0.33448914498032817, -0.24068383639274304, 0.7613361565286084, 0.654621894028659, 0.9361480541964634, 0.025938967723314686, 0.3750785989909928, 0.4812535716647813, 0.03158321886449973, 0.17858082781583773, -0.03738366151236553, -0.190217108862114},
    {0.6974662802273929, 0.48203700746869554, 0.5834160657671817, -0.09944442125850216, 0.13798135745453247, 0.21025910232274608, 0.7569254893357714, 0.5422395298788215, 0.524218139689022, 0.3462132337514478, -0.49685293217292786, -0.6140949807561702, 0.40286550421713674, 0.463199840229837, 0.13576615865431493, 0.12843121810136818, -0.63280789489892, 0.5083008426362531, -0.12721555713737706, -0.49920094841440554, -0.6843305920978362, 0.6953334680644642, 0.7823415593783085, 0.001905476811518991, -0.23745332793967222, -0.5646780196552886, -0.3753355085899371, -0.1422441178919242, -0.5967428680231787, -0.17036952652819928, 0.4794909784350641, 0.07321510896047403, 0.5014699704354528, -0.22704353976708383, -0.19804630811266405, -0.3506191988109599, 0.3022965321241307, -0.7119935498862489, 0.6470607151016111, -0.18102913015808192, -0.5649425276980875, 0.7230319852204359, 0.47998249933377735, 0.3198905980715123, 0.46003380364579766, -0.14182360502492147, -0.3889306599388623, -0.5381710271634433, -0.6372957185248002, 0.4411359798831279, 0.35136984302500135, 0.3264973126057567, 0.0705945479442951, -0.5864420731687559, 0.39849290455171316, 0.9328146037787028, 0.46974030772857356, -0.22396977031555143, 0.8193101858382703, 0.7386552441905755, 0.13671714214577305, 0.2776907710033986, -0.07115227222301797, -0.22854483160803826},
    {0.6598088343197126, 0.5096228220355441, 0.5263594945360826, 0.009959010830069812, 0.052441178568838925, 0.5957974853793112, 0.82944864007128, 0.6537125025179968, 0.4261004401058712, 0.4097896102255925, -0.5229970136973275, -0.026704633205217845, 0.2628853967145994, 0.4520575517785231, 0.055051318221828766, 0.32488077469005566, -0.7150253674011119, 0.8729577588245022, -0.5355672388721596, -0.5188974483589115, -0.6787426638503651, 0.6985922628844343, 0.7063024208644584, 0.011647087298643187, -0.4420289317787597, -1.0039672129102641, -0.62595574202474, -0.1307958318987358, -0.45711825009367135, 0.05195063888552408, 0.32494963160809665, 0.27684521819019003, 0.6679936858627833, -0.3233399055921668, -0.017953291802941182, -0.4079927718480748, -0.08106070275904896, -0.6259863817583673, 0.5993401186536004, -0.06718249739913194, -0.5803061787421773, 0.5518939142717502, 0.5554613260038538, 0.7626626468304136, 0.2314779867135045, -0.3663167360202663, -0.22092983726123855, -0.24852403004061763, -0.5358742717479613, 0.5513694108827418, 0.4164626456105604, 0.5863719425576638, 0.11907356679651769, -0.2622357498276222, 0.3082791097167784, 0.3870492504808587, 0.5796966903965929, 0.3503877085131408, 0.7340220469764079, 0.8367567228637595, -0.16648308290225342, 0.1991203129914006, 0.237242305557029, -0.08883124390835208},
    {0.6830956512409324, 0.6854815768915982, 0.5464607980205362, 0.09893394656052648, 0.1988155095817149, 0.4971178435378765, 0.508005044221848, 0.39271200996187783, 0.5141646335649044, 0.30209791481156684, -0.35626633984764455, -0.15259182303257163, 0.22760671577691688, 0.16522160484850515, 0.26530000289070077, 0.3968546122119104, -0.5397490407999521, 0.7458445293734197, -0.6940170740654056, -0.43506686393144234, -0.4721356837628244, 0.5410387721124883, 0.5351412945832013, 0.1184080909812378, -0.28365976173167784, -0.8198070252900225, -0.4400998378707647, -0.3298968490420169, -0.3805419282501384, -0.40219608155311454, 0.4125473416831735, 0.45610998099367717, 0.6738793136036729, 0.10869463569909817, -0.272135864371767, -0.11021435521629067, 0.11551612682771653, -0.597209024073122, 0.38248889722676066, -0.220665926968509, -0.4671557887371575, 0.48390105006557077, 0.5022994555428024, 0.6302448340264354, 0.33292145298668885, 0.06866263146441222, -0.1729047150023983, 0.022061816099876955, -0.37884903757742194, 0.4735478454089887, 0.3804130551351798, 0.1038635449921841, 0.31928300655307396, -0.3490065417384575, 0.1679713404606103, 0.539522818735481, 0.7958668398555943, 0.060049839697258627, 0.38130866747422865, 0.5506424842115215, -0.049664370317268065, 0.2197081866330978, 0.05194695386137513, -0.2765156797006748},
    {0.7515586063533566, 0.3060279292578979, 0.33527834599684775, 0.42974535600383235, 0.13580208629025797, 0.42160456574196753, 0.4625598939242663, 0.7071311192173961, 0.7963349230823129, 0.3870192263671731, -0.4541377447897159, -0.4936609989919686, 0.5063087990936105, 0.44149144722653705, 0.3043753201432561, 0.5201705007705847, -0.3910564131771741, 0.7516310310871467, -0.5551386183392385, -0.5492443945679119, -0.4288511954629621, 0.6096856949132603, 0.757312878866462, 0.3636365125918261, -0.5125516587563, -1.063520198055754, -0.4100337421400689, -0.3617943921708548, -0.7215642276223454, -0.3999653286626222, 0.49239714634137016, 0.4115959765354828, 0.8131294013999757, -0.3404711356009832, -0.1464933210701205, 0.005946496873634565, -0.05061972842835701, -0.4089647941013186, 0.5524306829742308, -0.039639851074547185, -0.5168449337843011, 0.4104936222308227, 0.31554835971811224, 0.6929867634204957, 0.5786456372721763, 0.08894884282094682, -0.303460650779173, -0.1761609168380008, -0.3337609527130831, 0.37926806505743893, 0.3667320929958282, 0.329609540511517, 0.42587486031833244, -0.16179407578847144, 0.30569636037749576, 0.6414162330848523, 0.5994148054826317, 0.17517697438183782, 0.5826627609326893, 0.6737482807557452, -0.2539149694478799, 0.22260864769776376, 0.2314271448901311, 0.041064740574574266},
    {0.7402292846797331, 0.9415963983232919, 0.4989869288971104, 0.015555389948214907, 0.1140098498276162, 0.5075870224719766, 0.7076627518963677, 0.5458166417181393, 0.6087429147668848, 0.3731284044032844, -0.3936088576351353, -0.16118894614520887, 0.28751661701472475, 0.47413433024548224, 0.4462599289032474, 0.486393114436511, -0.5653534529028147, 0.6664125303818144, -0.6059245822808546, -0.314442295233541, -0.3496786708898098, 0.9002299459900582, 0.6591826025234528, 0.3080672964048608, -0.17648735618336578, -0.668582903157545, -0.5343203922345244, -0.3375425890772125, -0.462183721198383, -0.4646891649660311, 0.21971979901708658, 0.6177430690355624, 0.7069188378897683, -0.26230618496677194, -0.1829752497047696, -0.1569837953542704, 0.2752189877308777, -0.5023242043906598, 0.3817267155722082, -0.6327817121727246, -0.5832149096647323, 0.4665501475258028, 0.5913123615324322, 0.5677302708731273, 0.6607141740178045, -0.13821777128885696, -0.3147301568085985, -0.3310612423784722, -0.27190856639359884, 0.3516837635327901, 0.31071040191025545, 0.24976279046881514, 0.6083843045431893, -0.3152956516379166, 0.7502550891774293, 0.6407524235398269, 0.6183777203927594, 0.2331756121949446, 0.3963128729255023, 0.6343427009076303, -0.4416807712697764, 0.1831857580270417, 0.13053814706262767, -0.25524136117521257},
    {0.6448153218584327, 0.8478298256602967, 0.626261086630154, 0.06366443609443527, 0.30174587393811764, 0.642335581049167, 0.5126416037566519, 0.5609711948248443, 1.0029754942800349, 0.4826725978447816, -0.3343328108212818, -0.3759549693053219, 0.2331144086744481, 0.4222455214580503, 0.4490677611405668, 0.5400801584878177, -0.7194028679074032, 0.7486141830411248, -0.3009256932185424, -0.35230997993045426, -0.7035747747781003, 0.8145930429516842, 0.6060375545573008, -0.013078610465367435, -0.2654461894827509, -0.6127738712549007, -0.4449429798702601, -0.25369166399729115, -0.34184501486435026, -0.582997110028799, 0.5291628287880331, 0.69345886519468, 0.6672076606306746, -0.10596948399018254, -0.10701039731861275, 0.023284979009799797, 0.06974423812880601, -0.34737116948793956, 0.49228614408323973, -0.4955881930455561, -0.4535481417475829, 0.7149805412083271, 0.48491415476660943, 0.8361115456338433, 0.8360012281398692, -0.04590236798278432, -0.3072108036600389, -0.16859738745648029, -0.2143987087888192, 0.5869247702396151, 0.30687033923857937, 0.339790527706359, 0.3533012616656326, -0.3056331899841096, 0.22840145917561164, 0.7962868311309877, 0.7542185527473494, 0.19006752817559835, 0.45443444655371645, 0.5082753901072926, -0.5609016036974794, 0.4232215767807625, 0.24105282500408606, -0.3801649538889964},
    {0.6181422289959774, 0.7664271021910318, 0.682088487253996, 0.14853883826409012, -0.011486423823346586, 0.5474332395847608, 0.5077381168079491, 0.132782746655579, 0.679684158242103, 0.12458128875398172, -0.4473294229637099, -0.37275183501915915, 0.17196542704267437, 0.2598562406572833, 0.39065171924254843, 0.21873414936533817, -0.7393028293372632, 0.3699290053601789, -0.24303984451530325, -0.08601930722825107, -0.47557268342943343, 0.8237003801053273, 0.48018633066497063, -0.04351687307822315, -0.6508209289594341, -0.914068967708773, -0.3754972287081715, -0.08629771452997641, -0.6068328612389795, -0.41474789188003003, 0.4413546417930068, 0.2861338767994864, 0.4262347950075802, -0.7129545138332591, -0.22905328395949331, -0.1074479076946752, 0.07901218104052607, -0.393332183917253, 0.32632388095518505, -0.8401723357534425, -0.5364057128912587, 0.3599285165951037, 0.44286126021111616, 0.6560359630387538, 0.3804862607784871, 0.01233376174682146, -0.4352695137443863, -0.07447153377917962, -0.2572782368605731, 0.3925620542353091, 0.3115451778616532, 0.2764807713157579, 0.3206049654358938, -0.3343972455684258, 0.4842678733210408, 0.6427863608556154, 0.7253531830776726, 0.002226337219446483, 0.7225463128192978, 0.6471003655311697, -0.31630780195205727, 0.623911358690327, 0.007130574010568711, -0.35423335369837045},
    {0.7821720113669237, 0.586846867233787, 0.6774372481282878, 0.23578846368584463, -0.22436668461541992, 0.2801290101652749, 0.5965266471826571, 0.1034934169093379, 0.5865535249167453, 0.531443526988277, -0.33868978901606245, -0.7785809535055422, 0.23978982838552054, 0.32595821833723987, 0.1639697024648442, 0.45738801205528257, -0.7684304515738025, 0.5926767776705483, -0.39818317980603923, -0.5334863726337961, -0.5664410709280048, 0.6640025148641622, 0.7242370420131882, -0.0046552526059470715, -0.38619603071175285, -0.6738123364061251, -0.8029953294696205, -0.23023169448420164, -0.2634901549454443, -0.5115345291089659, 0.6111356919274069, 0.02940069126255572, 0.6426603314524802, -0.48149849083976326, -0.22585290427024704, 0.11611398176962519, 0.31075710683204316, -0.8719024446222791, 0.4248009900575858, -0.828281129408958, -0.2953113298483124, 0.36670908131929253, 0.4747326608615033, 0.8732603836059263, 0.5081484277620525, -0.09761472199960275, -0.5546479194843486, -0.4835445911014451, -0.7212543129133479, 0.6963490760766883, 0.09427508333253648, 0.1280928441948166, 0.6436775961575799, -0.3129051742817508, 0.4143665552074868, 0.4777188956225773, 0.8034634288037428, 0.06801953613758198, 0.12595738683623575, 0.4888747688429897, -0.11394258200105808, 0.2838421570059555, -0.26717061714794443, -0.2593939159027683},
    {0.46178281429223184, 0.2859463320727314, 0.3170995860788963, 0.3019064101753336, 0.02652485581121261, 0.19337726018403475, 0.16287532774823152, 0.2936208360597241, 0.5248992156929835, 0.09988583855268245, -0.4780466740325037, -0.3234460966529184, 0.5313450601559073, 0.06035990567064805, 0.33060284697645514, 0.28193588055102015, -0.6617158694369983, 0.5063047281211591, -0.12618415207263617, -0.3113513703805028, -0.518047883210335, 0.4820893457323322, 0.5145061835308133, 0.16227354416943096, 0.04696612838246274, -0.4016206368855633, -0.5600262031137206, -0.3204387741874595, -0.5448453869315145, -0.6894471209581029, 0.34775045835671137, 0.06113118542000622, 0.6377131727539671, -0.44586270979932435, 0.11059575189785621, -0.0729630167633042, 0.22732565304196833, -0.39138786391484215, 0.7445783626528519, -0.45920149037720365, -0.44274956077914507, 0.36771076522914836, 0.5667185236594408, 0.5712472131343284, 0.7021631867526772, 0.13408306161327008, -0.6441694956490379, -0.3279521473990773, -0.5285891546009645, 0.4784493837022403, 0.5589124183494892, 0.1261527085624522, 0.2241990343183665, -0.06413213343481788, 0.5197116382663562, 0.19642357232341465, 0.6378685433551514, 0.09473270351260982, 0.13871764250170157, 0.6005985714070684, -0.32229905953993365, 0.15706106431269093, 0.08306313454689845, -0.40244491034524477},
    {0.5984600848407309, 0.6402425787376119, 0.46331392400664023, 0.026779080654149426, -0.05474110666908994, 0.020912952257358668, 0.5908858393371921, 0.2719849597167446, 0.6816162046593204, 0.2616583355743119, -0.480655903336795, -0.4858568944738005, 0.4868809362516974, 0.3049451362208897, 0.525633660100466, 0.27776159039756043, -0.5914629208673268, 0.23513672979833147, -0.5114827801276848, -0.2626838987576958, -0.5325701751829808, 0.7738104419399172, 0.6200687848127695, -0.4596893872794299, -0.5792282764390333, -0.6088705106772598, -0.5199083507233019, -0.3808901506645579, -0.5571546477434559, -0.762207243026994, 0.6840056193188914, 0.19382085560623674, 0.6127289866804224, -0.2932139714526168, -0.056344552269759283, -0.2555267154810895, 0.560245018560678, -0.562729362105438, 0.6633181738646549, -0.6368007287521203, -0.47287903146260013, 0.8540424965897172, 0.20946270435584788, 0.6323162834689694, 0.7686210571759042, -0.1670474130102541, -0.5672161443262911, -0.06335515496505584, -0.45759998000564467, 0.37515651505350683, 0.11992934224496614, 0.299576224107516, 0.24574837602667188, -0.26302728050805185, 0.4815247316211335, 0.3672800199466782, 0.8083550893240613, 0.0817968982655861, 0.24960867229629893, 0.4937706890359034, -0.5208917459445368, 0.3780906875152922, 0.1423017185598767, -0.4574322851022822},
    {0.6745289459907143, 0.6879482558858488, 0.476906720715571, 0.21286482133328644, 0.09668835134576291, 0.4902243841003546, 0.5903205574781343, 0.5366950950423258, 0.5909622133596752, 0.6647588219277187, -0.6416893187683029, -0.6143615228710293, 0.3876428319273443, 0.39336774022968835, 0.6304032110556873, 0.5468368501351503, -0.5562754863607686, 0.25442639726967214, -0.28991941936382964, -0.7531173296234254, -0.6343684614830053, 0.6129084610226181, 0.737095131706487, -0.30255210456807635, -0.5515573027290723, -0.7385543319460682, -0.5287868143666554, -0.08080742197981068, -0.4562056778095179, -0.6096817068852296, 0.524510500364779, 0.3856650379325749, 0.37376483293382873, -0.2275036895178883, 0.12208829001070465, -0.06175364914543408, 0.45777715531212065, -0.4026061135372323, 0.8092002329070397, -0.5556227903200577, -0.5369745022979088, 0.5050337620103588, 0.39646761488732396, 0.8930780845034882, 0.4179845340668813, -0.043740195445784884, -0.6123496827617897, -0.42474716478132735, -0.21544971827211096, 0.669835254117178, 0.23567160878131435, 0.36385998991120394, 0.520527883898744, -0.12134922872366165, 0.5549041115027212, 0.48656403628739536, 0.5558335523416583, 0.26396594272207535, 0.37397999291559125, 0.7399515903714341, -0.019186614851046863, 0.3983396966829285, 0.2883454731460938, -0.1449204673936788},
    {0.7070861714358638, 0.34497618232596783, 0.7818688317186226, -0.06009397988729557, 0.12302871541174505, 0.5423358653540312, 0.4360368909158772, 0.6841135782587463, 0.8326922752141988, 0.2552857143749799, -0.45398934217274667, -0.5182255523147364, 0.4294274298268342, 0.6728352766475033, 0.5163442076872391, 0.3238735900038815, -0.4599143256798123, 0.7445406180725112, -0.18406897932201655, -0.30455227237559146, -0.48383765526297634, 0.5953827274172053, 0.7025885655028445, 0.5425141104490836, -0.2720767795364275, -0.7044609512779368, -0.8285171410957753, -0.3124851321280945, -0.4042456556935719, -0.24034170039071553, 0.5497241673056206, 0.2602833191595714, 0.7425216588808851, -0.1917325305408867, -0.11841392619243077, 0.38261368983491223, 0.5106482000009074, -0.32961754250094494, 0.6777651316695726, -0.40447774051193885, -0.0999668411552901, 0.4603907165678896, 0.42696992407074663, 0.5266457044143538, 0.6557433983055284, 0.238800269632438, -0.5709212508418322, -0.3561849390060198, -0.44431686750325006, 0.6141588361949436, 0.49903424346576764, 0.04826250087568947, 0.35204010303435596, 0.1009629681379758, 0.4600215498202538, 0.7397349271839307, 0.6381956600072662, 0.28242699968534124, 0.3959709288906234, 0.4018643750923389, -0.02037440827552368, 0.4343557663079431, 0.10205224193105286, -0.3625041481399084},
    {0.9681561752183581, 0.693013390104659, 0.31999475093995633, 0.275917344970775, -0.054715988547460015, 0.17269433876537404, 0.2477501277989162, 0.6456178393901927, 0.7033966034108906, 0.4271182118760638, -0.5895462965168476, -0.2083823620197931, 0.6396748894671035, 0.35236779007739866, 0.4022177272945555, 0.3439680580306186, -0.6639186401437028, 0.4948599524467774, -0.27772491720111114, -0.7116061565381717, -0.36562813915706904, 0.866971822535699, 0.9264959125547918, 0.07546535454680946, -0.45029821935480097, -0.6789529788622123, -0.18959562090404142, -0.018428750545302193, -0.2577381694459151, -0.6062663149644638, 0.3753336291777685, 0.43230075534660917, 0.6131718079070531, -0.3754820386950251, -0.07367216423924064, -0.05335982103411041, 0.37140146238500854, -0.3990533292130448, 0.5036737151757951, -0.5242144174556803, -0.5879194644461694, 0.29021819150756784, 0.34657985438374267, 0.6404852474246813, 0.6341456816671472, 0.10283041290309329, -0.24109003478116758, -0.5091131067246699, -0.34891980862267247, 0.7726848934408326, 0.30775301193243165, -0.15890784921871565, 0.8340189446023923, -0.24993294929523752, 0.5448810376549139, 0.3173212343271495, 0.735485220210905, 0.4097405160405392, 0.5158300774432191, 0.5939975721697162, -0.20353325293577365, 0.3261687911432966, 0.13299729591114234, -0.5529444921916564},
    {0.653923200991953, 0.8272756977793325, 0.5818890591267829, 0.3589726059073026, 0.00724797676606282, 0.3779085155793175, 0.5562266973182619, 0.47330477022979434, 0.7613731906591911, 0.43491140587781973, -0.36681091718669784, 0.015594116538092336, 0.11295933300255831, 0.38790014980441373, 0.6475627073614041, 0.5022620447831793, -0.5447361797606636, 0.6278102771365408, -0.2074529800929004, -0.5573362247209022, -0.4610912122640491, 0.8703082355868133, 0.6993912317352516, 0.39393316796144306, -0.4693969503593767, -0.7944879008729795, -0.47502747648049765, -0.2743954995126628, -0.7489758565327839, -0.1730185746016458, 0.31734568806774577, 0.14830546386257562, 0.5939512679912914, -0.2502886606082993, 0.0010132700926633786, -0.13908055475166425, 0.5663453410400703, -0.3341001683660643, 0.7194258887555078, -0.5154962364785297, -0.36533613394136993, 0.47914135074094916, 0.5547929873114097, 0.5352327897739326, 0.5802650624487619, -0.019441437808083748, -0.5478330616263457, -0.5088827731642062, -0.2986174780321783, 0.6700838195450463, 0.6417603420371267, -0.10327545064320573, 0.7634904584094686, -0.14666007894849042, 0.3365715488253934, 0.39795060055004283, 0.40892760488199836, 0.3517596198603362, 0.3886338945038919, 0.5795030275641595, 0.02187465753981729, 0.4033617691806571, 0.11630105444650622, -0.45174386369194},
    {0.6264535354623465, 0.710451557094816, 0.4951196027840696, 0.284308484368396, -0.12435843810049267, 0.5629855103613256, 0.5583712704034011, 0.4396196331345649, 0.8729808877323944, 0.4818102988478833, -0.475237261848192, -0.4245801744202034, 0.37719322767816704, 0.38453959477795807, 0.5744254535480009, 0.6486030117201509, -0.6339469894217993, 0.6155965722891549, -0.3905326253705232, -0.5206732778002457, -0.6239812986552481, 0.7775972962049743, 0.9367346510829602, 0.002850853721059085, -0.4187868278475279, -0.550563712746808, -0.71690258572643, -0.3233179192429637, -0.8031798140987253, -0.34030768990628085, 0.5466406300582014, 0.3478397954847245, 0.8787302015830709, -0.41439406337612356, 0.14729503644007494, 0.06718974078864962, 0.5725754317641697, -0.48094429591069743, 0.7876811399765072, -0.5137080670041997, -0.6341414425606223, 0.6176176325245838, 0.6312389906637558, 0.7362002261048385, 0.7097781062575805, -0.10714121042605958, -0.2880662099094637, -0.14976352723168648, -0.4821618916742116, 0.8481651727386663, 0.3416586583076815, 0.13383840818161755, 0.5736526511456839, 0.04907183079751265, 0.3423446882647943, 0.39606764172333964, 0.7447058217470504, 0.12274339195346953, 0.41726932318418253, 1.0233610904574149, -0.18905548107239473, 0.623561275150501, 0.28499079986294973, -0.6243861985246997},
    {0.7406412866806338, 0.5054006590267619, 0.5830598745562542, 0.19270590577322444, -0.16490685358991433, 0.5002139317336327, 0.4683830801120078, 0.46925016099476924, 0.8472051928199762, 0.6008677372975579, -0.5108632395084808, -0.21811851555000739, 0.39507804926251583, 0.37709374399328877, 0.4294511966092, 0.6358435416423963, -0.8368775700199853, 0.23918841482290143, -0.43012940830961555, -0.5812467403879892, -0.40520181597144195, 0.9604241914850559, 1.0496948439908058, -0.03056438962770793, -0.6373058287804374, -0.8416262114453716, -0.32294784536407567, -0.43613014826007124, -0.672515188465558, -0.7459146080952068, 0.4689417095430734, 0.3462628209469744, 0.5839464213709443, -0.4124688954473304, -0.27379181795432983, -0.04876236278038694, 0.5844396543002611, -0.925152327732343, 0.6060065520754125, -0.32506874189234186, -0.4164844101754928, 0.37720618657201066, 0.6604702957320803, 0.6032354204852629, 0.594726518350288, 0.06330809568841964, -0.2228208844539646, -0.5537680746507652, -0.6652135387898622, 0.7415335635607802, 0.5817623600356702, -0.14773952854540742, 0.6407018949125263, -0.20245142254228893, 0.7137102256319903, 0.6590128501390925, 0.7441712746109694, 0.22301174608532817, 0.4857846279521165, 0.52990411566744, -0.48743510757106207, 0.2809134604510656, 0.2954762463131597, -0.22494068304137965},
    {0.552074724246124, 0.6344536294825389, 0.5094409754674586, 0.19664963856653936, -0.20382100310665544, 0.5012930778109896, 0.724265814172668, 0.3173834726391654, 0.8666544943443809, 0.4349417040983682, -0.4913625530146555, -0.5248400468493941, 0.16977760433532502, 0.3090549412311077, 0.34327227420990297, 0.29654254801653934, -0.6003326059350544, 0.646995298727083, -0.4755110481895602, -0.5402071158913626, -0.4534395496860732, 0.5959235448880015, 0.6749592546422915, 0.16714884684098336, -0.3175958314355011, -0.9325309431588699, -0.5083603202619554, -0.4081023028004935, -0.2500144533665144, -0.7356060257592284, 0.04818524117161644, 0.3851561982705136, 0.5888024813260563, -0.2187976316764228, -0.15010351585045317, -0.12795094351828168, 0.36362300934108954, -0.5238107860555841, 0.7090007761771353, -0.48201164274306946, -0.616926869319427, 0.5092613515102602, 0.6039790387952707, 0.6885605017451732, 0.6579436979953658, -0.09309622470677781, -0.25661197833678234, -0.6389160262605872, -0.19497720357220855, 0.439131338376652, 0.5205397270054851, 0.1766346496237304, 0.6336795816597229, -0.330329897602342, 0.617995344334251, 0.859207955108898, 0.42858067223910673, 0.3370549422164953, 0.4014018954199417, 0.6215022698576055, -0.09522773524976347, 0.2509316881871853, 0.2079397411149183, -0.3397361311747834},
    {0.6768417550124906, 0.6375183159489982, 0.44092641421931356, 0.2817838290197406, -0.15850554205955955, 0.5176696625747251, 0.5357931389971897, 0.30999984707448125, 0.852798595402769, 0.44915126923949955, -0.6217393817725945, -0.6392921311757946, 0.1372760293939467, 0.26143409692389624, 0.4565115472620206, 0.5162267743875184, -0.8062807784259332, 0.17392958273580084, -0.4751465597491266, -0.5365470749177351, -0.6934849286820393, 0.5520970236145535, 0.6531360519202293, -0.3379012136132397, -0.41102591596390653, -0.8887288205839826, -0.5565050871984918, -0.5981836687609632, -0.5967111433354716, -0.7785020900923841, 0.33642806994871555, 0.2883927372873738, 0.752751303928534, -0.2968335801333964, -0.05656361750916226, -0.2473446787430279, 0.3368589853607905, -0.710298881831196, 0.8471125691613406, -0.7262509965144942, -0.5400299412716351, 0.5288270232139116, 0.41564773328835747, 0.5865755826692569, 0.6537035469555211, -0.13591346786088265, -0.6856398418298913, -0.4846310933500422, -0.5030434985331181, 0.6057224402688665, 0.5907192988157912, -0.029599810758453044, 0.13183746611900685, -0.30991653970622685, 0.771689362893095, 0.35233043550317467, 0.5375151064959754, 0.44167789706966726, 0.48361145020523216, 0.6375373613222786, -0.4130945500195643, 0.38498987422144565, -0.050421906400989855, -0.3984202501727077},
    {0.7369750255960774, 0.7177307031532418, 0.6762790464658464, 0.20824941704518327, -0.1312739992596251, 0.6117849686191927, 0.43655242407031786, 0.45939724528338444, 0.6701284112995121, 0.28486146228363296, -0.5185630129877283, -0.44854122619468184, 0.3564468278374427, 0.2844747501417014, 0.42427777186821486, 0.5958485375043521, -0.8865708915594834, 0.6161295227215576, -0.4705883059362981, -0.5297557993570434, -0.4761733545348196, 0.7282715477066674, 0.6021741539210829, 0.20476938469615558, -0.3992499061924997, -0.7152729907561713, -0.6841840628658946, -0.3591668944246629, -0.4953008845602132, -0.6907459178063521, 0.4360362499992501, 0.32770247243955897, 0.5248012433331437, -0.34252821223799995, -0.3889117358517878, -0.07503165626859797, 0.5699489694361977, -0.667852752536274, 0.7756483645094883, -0.6505172795376815, -0.5651226837561472, 0.46223043738301206, 0.5287059193019737, 0.3896899436282276, 0.46315442524056644, -0.08027373449012379, -0.7450289366270867, -0.32211171522297993, -0.6055400532755176, 0.7484834098737926, 0.4933891460029249, 0.20889533189117152, 0.39645605918971144, -0.1239937704178244, 0.3426922036848913, 0.5926192043922156, 0.741719115413905, 0.30394272643097203, 0.2581071073063009, 0.8403913212104298, -0.5069567894547267, 0.45862029808771204, 0.1087682987246459, -0.2741659963051336},
    {0.5091651012422709, 1.0664724238594359, 0.6513416055589053, 0.3591238692803785, 0.07756210839654033, 0.38092292610186007, 0.3912257673314819, 0.7419755851077183, 0.8637400430847632, 0.402777896303311, -0.5597299475869258, -0.3665987639609322, 0.22534158576425312, 0.44028577589768503, 0.5833066121161278, 0.4791493873728435, -0.6303455936507681, 0.6874140856058959, -0.0028809834760829263, -0.1863640915839488, -0.3757493816260453, 0.899850312862505, 0.5901877170416943, -0.08496606749344457, -0.07614671900379828, -0.594954329010738, -0.6277332901610285, -0.46924739369806306, -0.6823925746618738, -0.9211085887095903, 0.4084346831118438, 0.4592549335716291, 0.5608166144287364, -0.6325986801733793, -0.10413185198628803, -0.17541513067931222, 0.5037730993928746, -0.750404093395294, 0.5810784668960827, -0.6511104145565911, -0.5752498324576435, 0.6438494328452079, 0.43216153897056503, 0.5474395690798367, 0.6270912668740294, 0.03182756576196574, -0.6511502478461568, -0.3167697822542763, -0.39339703177212465, 0.7457554745703981, 0.3509744832878102, 0.01843592382008157, 0.8364149724699814, -0.10620053545596193, 0.6675185047659868, 0.4317647459350007, 0.7589305636562794, 0.2868697978990367, 0.34395862076406186, 0.6669468692797597, -0.1233608739472618, 0.6777904181387003, 0.1119458516601119, -0.509292373845881},
    {0.6568887771474687, 1.0121232979418409, 0.8156856951415727, 0.24997191287000742, -0.14802745133270548, 0.8180353914556072, 0.7073358128966075, 0.487199781794264, 0.5902461406572146, 0.1598021739827238, -0.573985834012926, -0.449100292505919, 0.5775746652739798, 0.706543929470397, 0.5128170103151455, 0.45881827901403077, -0.7973119632950341, 0.5051736004143944, -0.3304438632863191, -0.4265271901786392, -0.5485849536758092, 0.776818199349009, 0.9515283075683789, -0.25156935814767656, -0.3736595922869318, -0.9216204426097929, -0.7492203040608743, -0.7295626598426305, -0.8261421815081426, -0.8529817444145987, 0.5745873055760687, 0.11812687202069676, 0.6576373236838969, -0.2960137597529627, -0.2799310393556367, 0.15715036798486431, 0.50857784204838, -0.7508828600054819, 0.8725186472685664, -0.8102190859366575, -0.5362705376877621, 0.6295247273501807, 0.5781702309988771, 0.6250225500592153, 0.4503667519535035, -0.025512428459471943, -0.7397196921977177, -0.570587136544449, -0.3472302935195093, 0.5411649951395968, 0.13517839117774924, 0.07974732119530761, 0.35608244476037026, -0.20174360040081013, 0.5060122094619234, 0.5696710864597336, 0.9837046047963783, 0.16758923221780514, -0.09764645441169964, 0.6333797197099996, -0.18997720345489594, 0.26534513794672554, 0.22039400790606734, -0.5471233698305891},
    {0.6913612139199469, 0.38100953557661094, 0.5450702885636936, 0.13049232321531978, -0.21540169203241052, 0.8229252556180866, 0.39307544543848516, 0.8023621430477617, 0.8603860438738556, 0.35806054499009876, -0.4423654921398505, -0.5392579200958614, 0.5486279451948213, 0.6226383503886399, 0.5420479054475196, 0.20103188194397623, -0.5598626957618243, 0.6465744852332653, -0.8191815830831405, -0.2892904742429801, -0.650310034659411, 0.8884662892772724, 0.8423811509790219, 0.17207096452459442, -0.3495392820560905, -1.11150201066675, -0.43687166072126754, -0.7041773920265136, -0.7181727109690794, -0.7602289757768443, 0.20049571936999994, 0.1335006601162618, 0.6352261068815076, -0.5236053895040973, -0.31907088275600043, 0.10408831041018501, 0.3614935025946879, -0.7871153611428067, 0.7280880156114113, -0.4406268229859174, -0.5691206462292312, 0.5461987425976091, 0.382547335430745, 0.22995482534450834, 0.4989191030486985, -0.35738219523604964, -0.7911230552926432, -0.34349769041281963, -0.2489302133980575, 0.7139472411701762, 0.15792423741417588, -0.07209898798812062, 0.35739691487582137, -0.1960707888086283, 0.40577531201329575, 0.8989743442666704, 0.9044863745927236, 0.14572086101880985, 0.33747437440012923, 0.8482096015545614, -0.3953289779531707, 0.5985655232159482, 0.43836485312433776, -0.47499283104782675},
    {0.5532971771116454, 0.37260451687688506, 0.06636719013673954, -0.3778799618327684, 0.008057469081088897, 0.07042872429188249, 0.4654888989400118, 0.4271311518713563, 0.2901755357403567, -0.09939871044399548, 0.61207371953454, 0.21953227166445924, 0.41326112572915286, 0.6714449636778704, 0.3971304746729823, 0.08436704221642159, -0.2390359659280604, 0.10741273461059393, 0.34425527347935014, 0.20103857251417676, -0.09783624528920651, 0.31878978018700765, -0.11288795271772101, -0.4019452760054416, -0.4257965995813977, 0.11895933202806283, 0.033856102473977585, -0.6438360071522972, 0.2279954754390784, -0.10710081210337588, -0.47895566132879336, 0.59372227762199, 0.40531647295644335, -0.26810071046769485, 0.45462540929346, 0.438972067610386, 0.021168757540050275, 0.3562380472161571, 0.437630201054647, -0.22518585964130985, 0.22528281445826903, -0.45128227174049157, 0.03339194243869445, 0.4890954898371771, 0.5418884683277349, -0.5764697126671536, -0.3540061593059521, 0.47744989192270265, -0.49644033433055773, 0.5937915874024795, -0.01696345872797784, 0.5656711567397016, -0.5334652599072345, -0.6178083017758078, 0.026544923213948343, -0.03704321993523035, 0.16167449886854485, 0.5866062594545532, -0.447324702653083, 0.22183153036066794, -0.2024694998806623, 0.40852855478910105, 0.3286499382271162, -0.18984387359986965},
    {0.03732923754438119, 0.13732363007126153, 0.13434401567240065, -0.006160834448857174, -0.485328849418187, -0.18248973784324748, -0.00542329336948895, -0.030275652777238343, 0.2555325555499377, -0.24416282598572814, 0.26140265689022774, -0.19705891525602245, -0.16136942150507605, -0.05111847503283471, 0.1796329155097176, -0.03397438656140826, 0.07779511209032781, -0.4899067563028485, 0.2985336453501155, 0.1688644258861746, 0.3506644661003156, -0.2278657505659392, 0.24330196558679343, -0.311734404449565, -0.11394880835415479, -0.3535208093017019, -0.3829944081395813, 0.17997452219919222, 0.025855110930633984, -0.2495829054708968, -0.26191315869462334, 0.06406465934112453, -0.16253248324952527, -0.3926143959488926, -0.08136333700783892, -0.29803750289984976, -0.4581884734684507, 0.010340453943779616, 0.2436207461367061, -0.20959712583664095, -0.06288357506735574, -0.032901781836711774, -0.004520120379886951, -0.033644426555965674, -0.067943427099256, -0.20365408565968074, -0.3338459867769946, 0.05390144276078855, 0.35876577388255726, -0.16018418080797558, -0.1965232967902304, 0.3318267286621698, -0.22037024227616, -0.02714538682929647, -0.15544173259680547, 0.08166252514737166, -0.34339324020096856, 0.14067661298537787, -0.6991262689891165, -0.06253045471848538, -0.45104529656698994, 0.3122989071579311, -0.10779272570638576, -0.2525977655833718},
    {-0.24938918395564036, -0.2582658997974183, -0.37773803982983556, -0.4997413426945689, -0.6059651954728492, -0.041389911100361824, -0.03690427254420066, -0.1198498597187004, -0.33599831608283354, -0.7179418500269159, 0.07469246982432247, -0.5646206919793726, -0.16166293986716607, 0.12520756645030798, -0.3459588686736871, -0.7239970203540538, -0.47100975503570086, -0.11411973867580945, -0.4478774753202112, 0.3973512572959332, 0.3965962295429935, -0.5037160512423592, -0.2554981120223246, -0.13536524988063867, -0.7729734904611222, 0.06748212049288922, -0.07967073497124914, -0.45071684590877625, -0.12935418043002345, -0.3810142705632143, -0.6369483402485787, -0.45367192481544344, -0.24276542667164244, -0.7050070075582243, -0.04308007465006837, 0.09877004520795717, -0.5166937768830921, -0.05785518225349365, 0.3176270591438039, -0.6326044279790634, 0.1577546956029203, -0.6583717570455164, -0.05840851256165976, -0.02210658177736127, -0.11525977509677256, -0.5876493293924986, -0.6043671748166234, -0.010984204067321104, -0.4834232225541285, -0.3077389755817427, -0.9026141483645151, 0.03737543734197, -0.2052171549066008, 0.010852952214056216, -0.2203678447926768, -0.544338746023159, -0.20052516561595737, -0.10312673805043038, -0.7440762550538191, -0.02881443019731651, -0.44874744226228935, -0.1888433380608948, -0.41241885224423575, -0.7662235475423194},
    {-0.16497233695738295, -0.41550582413514225, -0.30165826820987324, -0.22978165935676245, -0.12950872577879924, -0.06939445038343402, -0.3207458053724438, 0.09418614591279315, 0.029943491763711676, -0.38930745685418405, -0.170678387702941, -0.024619459522347228, -0.09378722211499499, 0.08849647361494102, -0.13238550827504628, -0.5112561199791743, -0.4343767735189909, -0.39612897594861285, -0.04166460183104308, 0.494226795215162, 0.23638991627077088, -0.10477843094066083, 0.08482623554855048, -0.3061218820576864, -0.6629905023734728, -0.5773911761207327, -0.20575163978617722, -0.14596261001117458, -0.1423131351731675, -0.5681162113325987, -0.6755611625618885, -0.5237986416719482, 0.16156313042917844, -0.7717695944202069, 0.09460758751674404, 0.09532609426762328, -0.5043856881836258, -0.020554601991959947, -0.03691313559980972, -0.05777497978451451, -0.0028181958660375398, -0.25967595248470976, 0.04782031370894083, -0.22184760472540446, -0.07963905684080039, -0.38646668322342287, -0.6742804519839394, 0.16964039316114296, -0.5773595990587984, -0.026034766146471596, -0.37639843193118505, 0.0073254697774389746, -0.380741076158234, -0.21201833349082752, -0.28712978555692353, -0.5256038703768545, -0.29935736702748383, -0.022498362481879097, -0.506271778721177, -0.44947932494111076, -0.8115534265131616, -0.500091013383395, -0.12494793290040285, -0.32031998097274667},
    {-0.43005957589397664, -0.4140665700818614, -0.383394861657165, -0.08747819684447246, -0.588880302212861, -0.30548817293907393, -0.06653911593438928, -0.45624507992858615, -0.3634933070224253, -0.4692994835289227, -0.4402639391858137, -0.4006849823004676, -0.29098502737357634, -0.435402716560704, -0.4106655341149289, -0.4836835265864654, -0.2649511051081446, -0.01643093420333502, -0.6040168932398122, 0.3307491279450009, 0.2469914355394835, -0.3301391208447922, -0.05836195287798876, -0.08583376587652657, -0.4180783266627508, -0.2233269812941104, -0.2919179078765285, -0.45648851650192646, -0.5303117152814241, -0.695908630234845, -0.24602976443180383, -0.5364648268536313, -0.2220440215158249, -0.5471671080955651, -0.32950176497231776, -0.17678569011249948, -0.7107892935699529, -0.3550833292155359, 0.12480226507302931, -0.5870955053561511, 0.26015298943983345, 0.012169092321918465, -0.42154317037107814, -0.11390086209501267, -0.5017599666373699, -0.1723932861144942, -0.6323380528410539, -0.2673392595777772, -0.3513517284341879, -0.12930149955267703, -0.709904829978733, -0.3289438622022875, -0.12911943096554676, 0.44009071407983086, -0.43738275925168935, 0.021934015059743843, -0.3661836376635306, -0.32931779605499656, -0.7242840353101533, -0.574542131025168, -0.6965710118872981, -0.695862332640374, -0.4806585500833066, -0.507005620799518},
    {-0.5213639412284855, -0.34113702836199106, -0.08447091234972946, -0.031374087317138796, -0.5861277101162052, -0.1320055164449566, -0.4673915285756706, -0.2351557119003148, -0.21932001942709353, -0.4307847158351272, -0.6310780459364073, -0.5599980168596352, -0.442675709881779, -0.22359737499731427, -0.346108050998028, -0.5128588750477108, -0.14278023626846062, 0.05844974590586223, -0.2871186038703518, 0.2105992260998304, 0.14151111927703675, -0.011479085862336215, -0.043713000644280436, -0.14065745817007133, -0.06558306133258957, -0.12723398525495505, -0.2354768169184062, -0.1658816939030619, -0.2616175706877932, -0.6067502347066502, -0.49050045112711027, -0.19277862976120033, -0.09283776745753226, -0.30619795929235405, -0.4187627211422322, -0.18153123638292554, -0.5910011419626828, 0.04677810864629484, -0.14752506180227626, -0.1343522659729523, 0.19559297256875022, -0.09628170566814523, -0.19263560411721534, -0.12617870551941193, -0.5935349740525002, -0.39119492203191436, -0.39500320406447553, -0.5387543613450216, -0.042658230103074804, -0.6418033591618948, -0.22676765562691872, -0.4114051262625522, -0.01680805922314585, 0.4738734312644074, -0.3253952545276673, 0.06610292760966002, -0.10486194209849357, -0.005922105776412366, -0.3567378338114054, -0.5216271154552435, -0.44395606148687666, -0.4832499553102489, -0.5307627737811996, -0.609471738480936},
    {-0.6529915440449955, -0.4998747055751525, -0.300864863477494, -0.16648245890679306, -0.43618164861851916, 0.05896446719659474, -0.46036755252045675, -0.379935096349078, -0.011031665884834374, -0.5326077223720446, -0.5436686949481976, -0.23166494248646452, -0.44817008367355304, -0.2605230503524899, -0.29327868086734626, -0.27779460318218296, -0.179071587678452, 0.046151945846179536, -0.5249797144594044, 0.24552803361673675, -0.006131014940265098, -0.454877900396983, -0.2809964252860759, -0.04181119657175877, -0.6420512139009863, -0.05398695604240293, -0.2140975549650669, -0.17015535948417745, -0.6236420994675672, -0.38673335045652546, -0.4467479007507746, -0.30257923583218493, -0.2471267632027644, -0.4736398225799989, -0.3451139274973495, -0.007711434824632311, -0.5865834481098944, -0.21914176193782542, -0.46550670473677386, -0.34550609132178944, 0.09670851520860002, -0.09775594642539541, -0.23373212661828036, -0.5477903869504526, -0.4312437365512616, -0.35332478639675224, -0.4815725994579121, -0.4257365926100253, -0.46212628885939655, -0.4084382668010875, -0.4844521679295837, -0.5054380134497275, -0.1488699176734072, 0.3494228862839713, -0.6059706813917011, 0.15579944246413957, -0.21399743217715628, -0.23132818891424795, -0.7318033095900398, -0.5781367788052217, -0.5862095167959078, -0.4465524156580077, -0.21917603898912902, -0.3412194161393168},
    {-0.4685938025234869, -0.624860119299986, -0.3494829729332767, -0.3472299534085028, -0.42539193859987695, 0.029132553028987488, -0.31880674157612293, -0.21714582988202644, -0.625850130742786, -0.4914105059591352, -0.507519605121229, 0.02635683833378312, -0.40402545512356064, -0.04914835224627348, -0.02698681737351376, -0.467788456660944, 0.04376566528618185, -0.040653533681352966, -0.573154372637963, 0.14070186232590115, 0.00839095368992295, -0.2959389637120272, -0.18326589744367686, -0.4268508084788337, -0.347429362152892, -0.036232303541221506, -0.19529666763310424, -0.32993079977275275, -0.2650548865270991, -0.928093053678244, -0.5174061779483204, -0.3021099426238977, -0.16198951664297118, -0.6315570363873345, -0.6528636289271492, -0.08953560160019983, -0.6878529074567966, -0.22407788084221128, -0.22666235604331922, -0.48596911896866263, 0.1408670294382615, -0.2384652254859943, -0.3516971640090646, -0.4260987790260221, -0.3058078247885666, -0.27856913222839086, -0.34666400778512113, -0.4315244820059207, -0.3663917742158345, -0.256294246569965, -0.5970717962705868, -0.5213774710849856, -0.357458595849201, 0.35965792234257726, -0.45183920144703754, -0.35929273114170235, -0.27027687013911517, -0.45694951142437296, -0.5784914787924793, -0.280461622753391, -0.5340936132716191, -0.7736260654751249, -0.5344001778083038, -0.29228608420337165},
    {-0.49801722710395946, -0.21421969660561543, -0.29721952747794445, -0.11396834038678974, -0.7077034387575265, -0.026447340802871127, -0.24648900541433663, -0.42659078134639833, -0.807974748283007, -0.8515754154533344, -0.3616496180704335, -0.24076947730506346, -0.03587655606280359, -0.18007157979818536, -0.13022068899709566, -0.542268849013073, -0.12435890700744894, 0.10756434316706891, -0.2795617128266548, 0.4729352159782622, 0.418207537705899, -0.27858992741732436, -0.6489126170416533, 0.08167411206256095, -0.19484475090798006, -0.0897964459091216, -0.3928120133168366, -0.10213376078274593, -0.25855998078842646, -0.5961821636467544, -0.3571152073360012, -0.5489103113388796, -0.3288820390396423, -0.4257495360490422, -0.30521511361183595, -0.12132439063949405, -0.3622380911348274, -0.04311286352632256, 0.13376132963044274, -0.41696039956926495, 0.443774890742745, -0.28248811002729185, -0.274284141737448, -0.302066595477452, -0.2568694853153134, -0.41361696424732347, -0.3400591200190482, -0.4563203920316489, -0.1863126261147097, -0.1020556671374873, -0.6927470575009119, -0.3108024890234396, -0.26055152740116266, 0.11256119558870051, -0.21754724905058626, -0.2042456090406731, -0.3022029026801874, -0.32585222112415263, -0.48578097397752906, -0.5008770963395152, 0.04808544144795038, -0.4160637432673574, -0.1985219861905613, -0.47635043859466564},
    {-0.5081724229631353, -0.6457576799069137, -0.6692815891011256, -0.3654508399349068, -0.5912994638000627, -0.02623655719693877, 0.22033697776758354, -0.20093080543911757, -0.3043645784693025, -0.8413236066840379, -0.11728474250491638, -0.33146546016500633, -0.25235923526334164, -0.08292903465468672, -0.5624108814969456, -0.4522682169294284, -0.19765593343842414, 0.2025371206613846, -0.5754586700345871, 0.38545668406251027, 0.463016300746959, -0.606662884825077, -0.4538036815298116, -0.35861846271604025, -0.6459279075864586, -0.0014702352656152157, -0.6577771827752171, -0.3492152370281179, -0.17065254429116306, -0.22205290035972855, -0.5796301254429438, -0.44454413888691185, -0.2614855403180061, -0.5145859749239038, -0.322557781057199, 0.05929362270719648, -0.7088243357162299, 0.03765568380136488, -0.0023274453272825774, -0.4085633644859738, 0.3981235791620702, -0.3421946880488418, -0.6090601966402185, -0.7658603915317049, -0.4367948684057936, -0.28665271498557787, -0.5247017846699168, -0.25362825352251234, -0.26418068031776376, -0.4948006236146032, -0.5993101969318831, -0.27727412090565706, -0.3853417090278615, 0.6632197425482185, -0.5650170697387897, -0.05562569118567964, -0.7501750084078651, -0.15116798408812424, -0.3734552124566083, -0.35540953227783856, -0.5506365278978085, -0.6784836170115416, -0.49126674808141374, -0.47421251351323185},
    {-0.4154555334065617, -0.45913200402067816, -0.2558670258356941, -0.24988963979639686, -0.41941155444277234, 0.2844870240792473, -0.4194043890212353, -0.16973491465374338, -0.15632283951881557, -0.5120730208282694, -0.16144190460615188, -0.08156943454766208, -0.14714195979471464, -0.008769263586590175, -0.16036147463901365, -0.3754742568966117, -0.2306963735428751, -0.07453332891293558, -0.508115873743523, 0.26173678128687433, 0.08003432938880706, -0.3307625679910887, -0.18912407261094075, 0.061931200212684875, -0.6473070361576909, -0.06608687317954251, -0.09831829803071658, -0.3555436008554823, -0.3277284354140714, -0.4255665896816825, -0.5498771832820377, 0.09856641709081895, 0.17922938253159587, -0.8026248651634139, -0.25857514570764534, -0.22641555758947599, -0.5788626844243919, -0.07580995946184543, 0.08022918795375816, -0.6595446947983259, 0.0414375486646464, -0.1818332969930625, -0.1521973932625152, -0.3617704675903995, -0.36868282130304736, -0.5148484464642603, -0.664393185650479, 0.1461544949148953, -0.3764455562095172, -0.3002040556705603, -0.19791100787521604, -0.08553885428320714, -0.5030184041106096, 0.25930568208525456, -0.381220283556781, 0.08058046308223238, -0.5145553743302118, -0.3024578198296132, -0.4036922115381954, -0.2927506562609743, -0.5144917963256412, -0.25247794456828404, -0.22999455529793994, -0.31605897041271813},
    {-0.7223672878207068, -0.41526130032821407, 0.23043977375117655, -0.19628303759349577, -0.29207196127175616, 0.08569596981577167, -0.309225519908837, -0.4206658375171049, -0.17818784117291955, -0.6138380845684903, -0.4584923331093796, 0.09463867999937275, -0.13125822367198925, -0.11972671714310888, -0.555806878656885, -0.20040398637220427, -0.09867178769884229, -0.025104372618051148, -0.67160271785446, 0.5620690991242085, -0.0022806917148393275, -0.43701972456821175, -0.4684409609668594, -0.121253515934708, -0.836680510818013, 0.25108782923449263, -0.3019507189064177, -0.46488239375491364, -0.33490556824748813, -0.684701279694261, -0.6785727565114666, -0.18773129242398745, -0.1725908992936866, -0.41292962152376134, -0.3374448148503296, 0.019912488911313333, -0.4410642305105366, -0.2741741111783918, -0.17528507636989954, -0.4061707653410216, 0.5329227083204507, -0.32008204750398606, -0.16646048862499935, -0.43544914464799134, 0.02764106935662416, -0.4382522220487003, -0.35912702800767365, -0.33754885095447945, -0.2184617860283398, -0.5105045885093388, -0.6193500774795613, -0.21274199143895234, -0.6278377068055739, 0.18002801946063807, -0.5487924464886241, -0.2718436147687305, -0.3359727473630024, -0.3987739661043055, -0.859744329038247, -0.47372983624149045, -0.43623554888859944, -0.09237085348457422, -0.3141293240847427, -0.4686352746583091},
    {-0.37936037886667295, -0.5092264256707791, -0.09629010220305202, -0.19740882936312854, -0.5693050612091377, -0.1469665115104734, -0.34436924884295284, -0.30970221482207233, -0.28573868190182206, -0.5303715986720245, -0.6467767688253774, -0.32024789990374397, -0.25638964072140275, -0.31086028019882855, -0.29146953566463896, -0.4637842957945268, -0.1298621977601525, -0.10449414052988837, -0.4524847710204081, 0.28231333978921064, 0.3088312246845187, -0.5970424059318395, -0.40411312163573776, -0.2489105558882284, -0.46358165623756126, 0.0367752491530441, -0.08361477169639031, -0.4905872351130225, -0.004656970624812581, -0.32592960923528735, -0.6311017321901966, -0.5022239312083228, -0.3156448793830864, -0.5587688101330428, -0.2970899300478241, 0.12679538638567064, -0.7200266947127498, -0.3937747412973745, 0.0751055473919618, -0.2944397739055701, 0.19981161218912005, -0.5355726357282967, -0.5652038318058896, -0.21524153552956266, -0.37814352331218803, -0.5843081671201934, -0.692949401354406, -0.24050591201426283, -0.14900167784355278, -0.3985140607768466, -0.46917653001092546, -0.498894701606333, -0.512400088992976, 0.014193365990111083, -0.40555533290316026, -0.551914371958819, -0.3117481876806924, 0.04553091595072659, -0.684008152740779, -0.19573064376855462, -0.5972345338750622, -0.21037384004524756, -0.43377225200657327, -0.4859328843005537},
    {-0.6347294219086913, -0.38229815571861464, -0.2793208523165892, -0.24581116157605393, -0.5000163476814286, -0.39318572953122555, -0.042258485158984865, -0.4867700991485071, -0.5041236024009922, -0.8376077982263371, -0.6290526273136509, -0.3347800359813851, -0.03989726490444711, -0.08359440504663188, -0.5621882076212795, -0.6289662017476959, -0.22955803919356907, 0.1801525452226973, -0.2626369640190255, 0.3220757578217187, 0.3392991517187747, -0.48652385776140833, -0.36502979776992334, -0.3532326522943583, -0.39709577202105506, -0.010363120423812367, -0.1511961605887586, -0.44460735607001134, 0.20279118047964856, -0.21687440575230882, -0.5482839444824417, -0.4675589281243917, -0.3669325052880791, -0.3369248296563461, -0.5133410392234901, -0.07964116057901377, -0.6983537239475397, 0.20820041885030888, 0.10044896770034481, -0.21460811273024918, 0.324493554859369, -0.3540934094646649, -0.3566640121748795, -0.031144528326495183, -0.3879124355298527, -0.35964222660995615, -0.5847555534109419, -0.38656718687955605, -0.6480660634075555, -0.2792702886133712, -0.865522620905339, -0.1506640406075419, -0.10514603649008063, 0.17710189965710427, -0.6130289288368221, -0.4952502322572053, -0.3896562909942297, -0.0133150870276919, -1.067882266296751, -0.4493938983496333, -0.8616713973222089, -0.34838748140337267, -0.8790586830533448, -0.619633078306498},
    {-0.5427089547434211, -0.453287011507176, -0.42174742537303117, -0.5787364102786305, -0.5801412761439405, -0.4479703602839316, -0.13047623825707605, -0.4549975683518502, -0.2750084314371465, -0.9189087575820732, -0.5306692889927008, -0.12560303675083317, -0.055638618835804315, 0.05921936781336099, -0.4824124697826205, -0.595658363455665, -0.051547279509516014, 0.04414197720338864, -0.38980347350258265, 0.4627262824646692, 0.5326885400975614, -0.2931894248291145, 0.01399171416367825, -0.6321217354501043, -0.646394130966177, 0.38478060579113543, -0.15153979820735666, -0.5376881494362751, 0.06208432702348765, -0.4559009571525537, -0.678621685687479, -0.5981855461438865, -0.1079409895203989, -0.3060549289635659, -0.1791941480151528, 0.34688857180864396, -0.555480724399602, 0.00791688856527053, 0.1849627653898088, -0.3719886281301083, 0.48714051336024977, -0.22213365609233676, -0.5146066948834047, -0.09327039044177851, -0.20314543715526232, -0.7278936355127209, -0.4422210231206516, -0.3011069769359128, -0.3743752900913064, 0.10075308000531655, -0.5639128170609825, -0.1894624073293376, -0.5231538983770172, 0.3238612453861971, -0.586512604235174, -0.32127980975052406, -0.5428685241767345, 0.00965912864157223, -0.8090489873940898, -0.3966936102348348, -0.6792368957323723, -0.13585483544307791, -0.5373419347462649, -0.6432808904851715},
    {-0.734320117160207, -0.4635988861823631, -0.20576257969493314, -0.2126126145036622, -0.7202451391502628, -0.47765795152950136, 0.03808411109965891, -0.006983358108536488, -0.2762522577973989, -0.8302417988286933, -0.4602016211043048, -0.7905496494440049, -0.34105789577936857, 0.06285335087722548, -0.1310776890890983, -0.3846215645982271, -0.4783457684332027, 0.16944689485990166, -0.23611102265365405, 0.3061189576897605, 0.29419225051098397, -0.16542271168273104, -0.09306577325653037, -0.2209709204603484, -0.6362547051202241, -0.11456489100636005, -0.7278837816074092, -0.5835738586682593, -0.07485901683664761, -0.7724129606669845, -0.7720979709043988, -0.2726358354206523, -0.29682283005380516, -0.5443799859858424, -0.2146622973290216, 0.0921887026258438, -0.38412164979165225, -0.28816833115950197, 0.14654659170478257, -0.6318955035366429, 0.2840491246129991, -0.7403351295713075, -0.1431631624886842, -0.5444328798923916, -0.14573211401379357, -0.6554793309132004, -0.6908774854937962, -0.8059671343803674, -0.6000979122692641, -0.2495611289942243, -0.42337728944363207, -0.12763509632546033, -0.5877630501398862, 0.280415839652346, -0.326220133841255, -0.22702507808228373, -0.42123646162048856, 0.024818888241282963, -0.4372186383616624, -0.26313208361250423, -0.5167397099520358, -0.42795409871200624, -0.3562926675000081, -0.6443336719707486},
    {-0.6826909413765027, -0.8257841914332894, -0.8558784095982704, -0.37007846676695955, -0.46050810893632066, -0.4119297631863249, -0.43682440736746775, -0.36004874378643775, -0.47388619321759795, -0.5556508752239507, -0.5761535296003584, -0.4032931146096383, -0.38895476890772346, -0.22878357276414693, -0.4641903147482664, -0.7648678349942136, -0.36242135041149154, -0.06370325079971038, -0.26163546945631233, 0.37931715173788483, 0.2957249651115836, -0.29631596081255823, -0.059863704270760904, -0.3055993830610996, -0.570633795342597, 0.011395648242081842, -0.4863297735500345, -0.3525284119310134, -0.14694039177513785, -0.6188451934608962, -0.5524280369217847, -0.24898232876519624, -0.5579754926492252, -0.3729594671544378, -0.2461391281283591, 0.389221360622515, -0.3996449607749313, -0.17717026000242414, -0.32052069439984665, -0.3962059954642828, 0.2201645912801027, -0.6228031811511217, -0.48894794729423335, -0.30746826411949996, -0.516269451094255, -0.7950247937358317, -0.7019350719696495, -0.32420246737550396, -0.5001308694151336, -0.32676503569668136, -0.571366979006073, -0.4780351135260452, 0.024462144128518104, 0.1995464035593246, -0.2544710241890758, -0.5030324428466759, -0.1430049976062001, -0.22702419150370398, -0.5519379391277761, -0.6876048373071546, -0.9440269058246408, -0.17602327483608338, -0.26985337389554304, -0.7230497616283482},
    {-0.5015366178189268, -0.7808753150001971, -0.3598920268820313, -0.5363884690913829, -0.6945654369346147, -0.25742220193810894, 0.5366444057223154, -0.35352886830111324, -0.4534218528683908, -0.684228644682719, -0.5817510288703243, -0.4706321304907448, -0.11871940886515688, -0.015875554686466422, -0.2805481918243031, -0.5990942746732631, -0.14434597403798796, 0.3000872482280911, -0.18521654567568097, 0.4331763466677043, 0.4720571768535945, -0.2550029730072253, 0.05899007044035553, -0.6240712000442507, -0.544358233957445, 0.009444207632912741, -0.36540273228670844, -0.20480347964758727, 0.0003621946958203412, -0.5848915190089875, -0.6598602478671021, -0.7012404474370834, -0.463557067898173, -0.653602497728077, -0.04669436523304064, 0.3565199320541082, -0.4179564856119091, 0.16038181312091612, 0.08452365996687884, -0.452547790606391, 0.2631174037883651, -0.5871235508353193, -0.5205024328441235, -0.14952275462938544, -0.2567121403411655, -0.5760326304542404, -0.5660958579690551, 0.006054919190505587, -0.6311632822182731, -0.018313395868027604, -0.7348189405419818, -0.04557947518404863, -0.2963098033459384, 0.12299294652898196, -0.45690348650321266, -0.33130849588891254, -0.32289086799707595, 0.14504793054774817, -0.8002789100189223, -0.5955584717302013, -0.30762852959036546, 0.12352139299630328, -0.38252557316552627, -0.6540245521521381},
    {-0.30302107025524644, -0.44865345996420913, -0.40137411211129614, -0.5328187024332531, -0.5851829333140594, -0.2965010151758394, 0.31696963295214725, 0.0005551306025098619, -0.3962981942670752, -0.64467206572846, -0.355464531199522, -0.3609146416493842, -0.0810137312832829, 0.2954436800045893, -0.16704486173614677, -0.6596117785249973, -5.4705836317365924e-05, 0.1856924244404807, -0.20117787685355476, 0.4054115306838184, 0.23739558358487872, -0.3095018819523769, -0.07992245080083353, -0.40491211116604253, -0.65745255244975, 0.3077967217645491, -0.5277910085644061, -0.5788244484760302, -0.2590051211651274, -0.8036504153810791, -0.42041396714954377, -0.49028066964244477, -0.11944318638584568, -0.5516924721213431, -0.018003843932776157, 0.5043649393439216, -0.43828384014503124, 0.2932516128213217, 0.16382972947930652, -0.5426847345570988, 0.279576057438374, -0.5641435945031247, -0.369060766603893, -0.2016198653995995, 0.18581288658250553, -0.6801072330832447, -0.5331739446317444, -0.24391819022058603, -0.48163633093033276, -0.04976048264689387, -0.5797429795760156, -0.1537988495254681, -0.629367150807041, 0.14968134014782986, -0.39610040232323557, -0.6549373227787291, 0.30472871788736505, 0.6046676625190338, -0.47443598117120106, -0.29944816048962, -0.6273896586607401, 0.05194796618267375, -0.0929933058712834, -0.5781658598771519},
    {-0.4466299454564118, -0.559461361572034, -0.45264521535955504, -0.4657503868308259, -0.6689270616357262, -0.38258472360182394, -0.4264121455392377, -0.2313560488672617, -0.09214256289941833, -0.7248960631054737, -0.598163702102821, -0.6979615352018455, -0.14308329989381288, 0.03114623742030239, -0.21097496044202976, -0.7681340251806315, -0.36324558337234825, 0.06772644462673807, -0.39488772411034523, 0.2876235752294357, -0.16361903360276478, -0.27206904813815364, -0.36587596609876694, -0.5145379223859848, -0.4905137035507549, 0.01438797071425293, -0.8086504178012114, -0.6267965090612054, 0.06048066865649525, -0.4758282738932477, -0.8104498515635927, -0.5480756838725989, 0.004933543751808505, -0.5163000583647428, 0.19920179021322984, 0.40349550164139336, -0.6575422606907915, -0.04839341748993643, 0.32141032085174737, -0.4916481515791128, 0.18073773163190193, -0.7528023498195828, -0.36339094944648576, -0.37940205457513626, -0.09331241043946993, -0.3211478575681227, -0.5580020600026342, -0.2415228294878218, -0.8637018533200543, -0.20860480159401623, -0.7050056655820859, -0.06717276023023974, -0.580857618569584, 0.2919417430496219, -0.5642255683798812, -0.44798700600872066, -0.04302089745225862, -0.1270621855589512, -0.699228940165545, -0.6232831749946411, -0.6350215601882881, -0.20311358523415457, -0.5869923913339501, -0.623215073341261},
    {-0.5854609838567048, -0.6791989846204929, -0.43764293210843513, -0.7502586723390128, -0.5880625163815469, -0.23434112612926492, 0.3029279216850542, -0.18047791428512386, -0.3144799782912841, -0.8409055211059488, -0.5887686633492232, -0.29960316880790067, -0.19570360291380057, -0.013525106845716874, -0.20134530053789074, -0.737782641775682, -0.25653544060196765, 0.28750829097656455, -0.5390876669513258, 0.22292756065072972, -0.06484070584368823, -0.5104682942684069, -0.512242934156372, -0.5376721691091249, -0.5585629942395649, -0.1307624417446851, -0.7227715263963644, -0.6519538119041051, -0.22624051071924434, -0.4171718632619307, -0.6772960106922328, -0.44996442257121166, -0.37768487032703, -0.5243702195436531, 0.21582028833867195, 0.2874699870445478, -0.5923180281505382, -0.04023416368100653, 0.42319805511441255, -0.5836192524200476, 0.19241675192069904, -0.33135158703442724, -0.4294179400013189, -0.3141426229702365, -0.06597530735712134, -0.773643934412229, -0.6773559617449089, -0.1388186067577874, -0.5108610542342491, -0.5067066366503253, -0.9155327897579632, -0.07766483338703495, -0.7257757867187102, 0.4659320439862907, -0.36179136971400255, -0.4048113858471429, -0.19815781112297035, 0.09766141359349495, -0.4908854763057719, -0.43129503201426916, -0.7442133541745165, -0.09419216959578464, -0.3682430912910017, -0.8748569112480732},
    {-0.6856462376187821, -0.558782729228782, -0.7370524742922351, -0.5562489383410899, -0.6704236989014145, -0.7177738724049832, 0.538569190455599, -0.10957565665532994, -0.35522865712205365, -0.9509474906294351, -0.4671555030755881, -0.27731735462852264, -0.3093225231681844, 0.23525988774837708, -0.27772889095559533, -0.5605331580652513, -0.20070664194428545, -0.21311690909720768, 0.016030133623831565, 0.5926484279610217, 0.3440315697429382, -0.2395066010863295, -0.0036134200220039724, -0.6096243003905214, -0.8289971852589286, 0.6023650491175645, -0.764145756461268, -0.4989870109623456, -0.13219455515725884, -0.6729579311240532, -0.9455523835880177, -0.5651072964936769, 0.30612739757694296, -0.39642903219525866, 0.24864022806186503, 0.6753759687835803, -0.9050401490141173, 0.03447405153661221, 0.7123021738115454, -0.3558409810162457, 0.42732300387413097, -0.39932433837739895, -0.2477065255010788, 0.0063235189560466405, 0.2887836475107679, -1.1679840833706217, -0.9734826308322369, 0.027475924967435433, -0.7386704864710664, 0.26799308493630586, -0.9903109403753232, 0.3157832031899545, -0.21911477058369058, 0.25122474676735085, -0.2936229330048436, -0.6873369441165221, -0.41552450878117386, 0.2054438459070588, -0.6172149031099123, -0.5975780593590585, -0.4149616690233644, -0.19227593070572072, -0.1398755943721033, -0.8697287942649906},
    {-0.1321319741654995, -0.48817315494755337, -0.5012287106668434, -0.8770868100434382, -0.8323494162976031, -0.46583310849316667, 0.4870887975625185, 0.29998948896657285, -0.0757969118810542, -0.8651766455396244, -0.19320569862573803, -0.26388581970021024, 0.11816875797515076, 0.6425469807652898, -0.049949090589488425, -0.5891123856214664, -0.0915153147714582, -0.3151894019088404, 0.2099178966903858, 0.5153169369216131, 0.6563141157920358, -0.062078947039152364, -0.004745909985960678, -0.7584098725839059, -0.6302029508853805, 0.4924831484347309, -0.5865582440272338, -0.7155922343290894, 0.3821854068843422, -0.6031151257019572, -0.7275373522271736, -0.47059990002384694, 0.1328032429068331, -0.6808826420398666, 0.6925393680149642, 0.7681565824294488, -0.6437653130588451, 0.44428980597859374, 0.7547230603015245, -0.28584885630839657, 0.45328958666340763, -0.7360816284310534, -0.22946383110203017, 0.1841801834883559, 0.47249694440957596, -0.928866462511781, -0.898934747361373, 0.23579371813165373, -0.6859321723163783, 0.38148295964255163, -0.7623479496695297, 0.5399486174728766, -0.6113084648767246, 0.23034452084516496, -0.8598264941165652, -0.49658450061420434, -0.5313067893145987, 0.443794433413715, -0.7542359907293434, -0.6166404555033083, -0.42297121013904837, -0.008954831135427376, 0.1418075898353758, -1.1541576145040462},
    {-0.5749938657689992, -0.4989531950496343, -0.35947794161020175, -0.7026992305234174, -0.4550402242491592, -0.51944083236542, 0.5327650697474399, 0.08723404616069894, -0.32640663635315537, -0.9694051518198035, -0.599732505726351, -0.3254097570640776, 0.06736605453954236, 0.4191555223657122, -0.18086202411124094, -0.6015469043729899, -0.10632995159279553, -0.241527299013571, -0.08558574009322578, 0.34609455647277676, 0.29999269756452807, -0.25719008252122905, -0.20134447584663273, -0.775486320746303, -0.6765067490421256, 0.3507779818395168, -0.7602011167777667, -0.6155945891733027, -0.014191992206853311, -0.6171167980122638, -0.711615167979867, -0.46926214751194767, 0.17773236716895907, -0.6157994921539922, 0.2836760557956951, 0.5686416702810325, -0.5459082665992756, 0.603964834161457, 0.6376401515064466, -0.24993222288415623, 0.4856483148966702, -0.76566904724579, -0.7588142253480222, 0.017514343181068613, 0.1951590984660019, -0.9784145009507375, -0.7810313739910186, 0.1548053973447566, -0.6098365917683594, 0.26238960856913285, -0.6205759778151002, 0.537324592815585, -0.4305141048587958, 0.17112567476652224, -0.37762247217128797, -0.5565582604039624, -0.10266786487034303, 0.30397547863915797, -0.5546740631107676, -0.2568223003584636, -0.47489160050444407, 0.06717035282638104, 0.28784258689994047, -0.8967440738263388},
    {-0.5111362366359787, -0.6053773463923239, -0.6930844817721057, -0.5792365281985105, -0.8529323359169535, -0.28677256043328536, 0.17645819568339316, -0.22930816732703224, -0.427570686451035, -0.9887994974361941, -0.4582830436720033, -0.7326412868787504, -0.24349540881929715, 0.29781988415912575, -0.24599029566863717, -0.5517688802994888, -0.10129777263262833, -0.16540596376960542, -0.43359755155786844, 0.6531446329543519, 0.24471299686357975, -0.26297417496422115, -0.15209982579414283, -0.3657070037197652, -1.0467152541848939, -0.14635611719338038, -0.6772977968801855, -0.5186470988809664, -0.022178966224062912, -0.6468745569668484, -0.7552089858502046, -0.38105133869284497, -0.03391839219545046, -0.3214339529757514, 0.24596504036813913, 0.25828710321865345, -0.7183644319106334, 0.06199377562707734, 0.4977859299583893, -0.49154960744823395, 0.1399975757155214, -0.6979292960522753, -0.4534891098260954, -0.13138089849987084, 0.006652400013728432, -0.9405338506373304, -0.8636458644528585, -0.14732210353935032, -0.6283316930232485, -0.24233040141449236, -0.8296546649470047, -0.09668063945286028, -0.5868804612874268, 0.005151377219030102, -0.5096993570534153, -0.6729937826351351, -0.45305808644708967, -0.19821935123064297, -1.0465376011356398, -0.4905384534084578, -0.6781769175285404, -0.3087840203276248, -0.19346492271947852, -0.8688742410866702},
    {-0.6625136882739405, -0.4601301202729914, -0.33275583247525325, -0.7222314634140478, -0.8860094765045438, -0.14724606402406068, 0.7628178446488355, 0.1765234727309318, -0.14552269019854444, -0.8596695986192922, -0.9841779622128629, -0.5744224647529843, 0.19162360998712472, 0.5961315023410833, -0.09792466314902233, -0.733927921517759, -0.18570748593908362, -0.44024840221597755, -0.23619273121250053, 0.4894380989821231, 0.3740450330932621, -0.16129593525176183, -0.14916980542493963, -0.3565549466653155, -1.1127883265016134, 0.4227854378661371, -0.5781902327058939, -0.6087007553532199, -0.05012975300131599, -0.6546555993526432, -0.7576963482927126, -0.029057688992500937, 0.1734021934899081, -0.5819976822536757, 0.3148771336758947, 0.6611984558519718, -0.9245127340347283, 0.3049452513549153, 0.4668532172794321, -0.4018690397667174, 0.29089157859042186, -0.523089060546149, -0.31874314249667507, 0.07768956883255251, 0.36710085260782754, -0.8841900079259442, -0.7725003725829767, 0.2521406270804202, -0.9817268554556463, 0.3378311570671625, -0.7174613202710811, 0.437153518154441, -0.6118574473048561, 0.058774083925954915, -0.44466003644585195, -0.34416231538817743, -0.08668427267421586, 0.5551479923119277, -0.7289546349912471, -0.6081712996613324, -0.4505159645501439, -0.040502061949520024, 0.10780086113224197, -0.7271671165899822},
    {-0.5986175465256711, -0.42358173080086786, -0.2206133378061341, -0.6557908861991797, -0.9154110854454144, -0.48417887913625196, 0.6755630243159332, 0.24096413060254515, -0.375963830142587, -1.0185928730905642, -0.5187889211466564, -0.5113969628998895, 0.4468276200073249, 0.48827385206489327, 0.03204361639897542, -0.7039747635176618, -0.11294025506212144, 0.055587293022941076, -0.019562750750182007, 0.5758578048463595, 0.6679908646144829, -0.22283558563025957, -0.504534034424175, -0.6952579498231917, -0.963190682314628, 0.6276987683812165, -0.6006099700021302, -0.9622783085799597, 0.017953349592997356, -0.6403941944086827, -0.932473715747916, -0.2999944385007555, 0.11774331658700667, -0.7970269124452685, 0.220784484186642, 0.7024150882019415, -0.53580734788671, 0.4219634876177057, 0.381227389545505, -0.7276968128196765, 0.2312210348603057, -0.6497490881166424, -0.5173683817451846, -0.03012724297067487, 0.41464378694525217, -1.0347368890808042, -0.7416101381816569, 0.4011654152654408, -0.7576362669053385, 0.7424763193308564, -0.8108775415682479, 0.4096164419642623, -0.698945252193837, 0.1020180101465829, -0.17390872840966878, -0.52879705084337, -0.4072823367998858, 0.5292668982292239, -0.6385289380787672, -0.3759328378252381, -0.5675045835943612, 0.2359079243130077, 0.11609919949447926, -0.7453457704686487},
    {-0.3652217787861055, -0.9491644310173077, -0.2670454673969723, -0.8120028993633869, -0.6911399973540547, -0.4949016532559688, 0.6881595150503707, -0.1661348738184188, -0.5110582315239158, -0.9773586870831074, -0.48876632391795305, -0.3901396834377792, -0.06320701523327363, 0.24878796451284757, -0.2648009469959809, -0.6500776297845671, -0.33128705460944113, -0.224310884189818, -0.08162938627401141, 0.5483976912129418, 0.6315298160022449, -0.062031891005841416, -0.14488953868223162, -0.7479618252289402, -0.8818286430195834, 0.5122474051544672, -0.6567098900204064, -0.8366935128677107, -0.12334712322418818, -0.6026971905136611, -0.61782219496965, -0.34221656436585596, 0.19988725494593015, -0.7948567285498281, 0.4762707665203617, 0.6351532718387013, -0.5925150023904572, 0.10479217401644916, 0.23470723807490082, -0.6975615967394837, 0.3185553494007674, -0.6504636980018991, -0.3791810804302289, 0.0860017711018472, 0.2609171419739507, -0.8201978934884335, -1.0304995053870065, 0.32547137999252496, -0.6303251698156612, 0.11883220805690563, -0.7449535653422867, 0.09595554051807899, -0.5178279555947336, 0.10753783987676402, -0.6268408205200859, -0.548912731193035, -0.5166582677255144, 0.47359898505354014, -0.5469580170160074, -0.593972408235743, -0.6101559595335655, -0.22905732970982198, -0.24658925896866307, -0.7173002980321502},
    {-0.19942433169578835, -0.6015433236171587, -0.456207209207974, -0.8916712894200636, -0.7009673611400853, -0.2611092553549276, 0.6502134687363506, 0.10731871067590744, -0.3938261949634752, -0.7160547918078057, -0.5620150250418727, -0.27642227964429783, 0.4126531187119785, 0.49478973563270134, -0.08669033665667032, -0.98265927752129, -0.19506892398320413, -0.0570168177230662, -0.2137852897488172, 0.5582367151773718, 0.28732332544788286, -0.27580627811487207, -0.04385027373073134, -0.7755489412796407, -0.8960142604339463, 0.3422286366765485, -0.6207883997457122, -0.7069333189977877, -0.12041773944968046, -0.5974673738231865, -0.9671923635516733, -0.5334499263188005, 0.09028338472237835, -0.796869246343508, 0.33007289105056753, 0.7087325892848912, -0.6268241237460327, 0.38869830494350294, 0.14822307642753516, -0.1741045915539596, 0.4172995589372814, -0.5806290353197154, -0.2746361543128175, -0.08720565883025631, 0.19154226854324963, -0.8417061604155727, -0.7431727041309124, 0.11143313315828646, -0.7118842562529215, 0.42923563372216644, -0.8021580763122729, 0.4264311871684984, -0.7386490210093012, -0.14523672958818745, -0.6850993645725687, -0.38834490118056175, -0.08508064199210374, 0.5891888442590802, -0.8174007342470265, -0.41409863359115584, -0.6933619483388876, 0.14453984458357083, 0.049734683530699465, -0.8272395366978061},
    {-0.6436984349934773, -0.5211169227595173, -0.30378764058241925, -0.7974928868810753, -0.8909294339646723, -0.36486840661890463, 0.6021499006426263, 0.20606418574562754, -0.30093673839699964, -1.095660278882177, -0.46158370342056454, -0.007273833041988648, 0.06962762904403695, 0.42846124935606045, -0.033953381275069035, -0.5767536864209525, -0.20908760956432443, -0.021713520431644973, 0.11524150310454315, 0.45871105846158094, 0.5025407906142573, -0.04367491963489179, -0.14018892721228424, -0.8608238041616293, -0.7184281747562876, 0.4023839134649155, -0.7168224361348577, -0.5996848089598871, 0.27365469843051776, -0.5359301768670531, -0.8404265753538753, -0.1778411317682459, 0.2181591971111878, -0.6379997750496996, 0.6633209144939174, 0.9330132642213093, -0.4908548925039626, 0.286870696164803, 0.43028762589395136, -0.5177841345473804, 0.5268793609358601, -0.5038480856029737, -0.5663525018505747, 0.42070465632107806, 0.17399399668040827, -1.2155632636104614, -0.8888093351496772, 0.3571139643711775, -0.565706946932683, 0.20136820193920713, -0.6781529934433375, 0.5395139078921231, -0.6398971631713574, -0.0974926580825235, -0.47317778148520495, -0.5819274015971689, -0.4445571470438685, 0.31893653968096497, -0.5910753401559244, -0.3975446647461448, -0.287988772134115, 0.02368849533275416, 0.19136480699986516, -0.7460235552928465}
};

static const float b1[64] = {0.8838453826364512, 0.940024899282589, 0.9278761958060275, 0.9741182858885844, 0.8895436602730807, 1.0084451711044287, 0.9867368347320191, 0.8005767281374367, 0.966173791203595, 0.9614474737372788, 0.9163199475930001, 0.8914276729558794, 0.8972729879563415, 0.9360029239045404, 0.7325821285889517, 0.8660582742921312, 0.9307884268909108, 0.9188625107999333, 1.0096468497533109, 0.7915452615737942, 0.7100629198564344, 0.9214022316292216, 1.0011775537828818, 0.8710145811371004, 0.9841751740000175, 1.0898904670312202, 0.8610264346972019, 0.8672362290514293, 0.9107402135082333, 1.0118155269336053, 0.8866440088427866, 0.8648597116189108, 0.9161372092008498, 0.8371302924670946, 0.8732113159051723, 0.9994790001911006, 0.947560195092815, 0.9450990079572956, 0.9525331621297594, 0.9984582410470583, 0.5767568447421441, 0.7718165656374035, 0.6058877274702062, 0.9188510764670045, 0.9904112315370777, 1.054232440885355, 0.9991915245667115, 0.9879251902347724, 0.8980693571082456, 0.8715634167472682, 0.9462391849166261, 0.7921384573694275, 0.8704128415820601, 0.9079770837383351, 0.7917553247025317, 0.8771320052916322, 0.9350582762560508, 0.8287454187853388, 0.9757695744365824, 0.9673170189065621, 0.9535344869101491, 0.8879402102127296, 0.8711084462460549, 0.9489480911084722};

static const float w2[64][32] = {
    {0.48902542231092694, 0.46422609243088636, 0.5951600205768802, 0.9265704934444913, 0.9574253669317353, 0.48005290171771875, 0.928077104196331, 0.9971991607203767, 0.5519685619789091, 1.1624022002793335, 0.828590178704544, 0.9433906097862291, 0.7974676045861803, 0.7880768158128304, 0.9364393345087297, -0.04521716023714893, 0.8605521626413659, 0.8927542359885049, 0.13052381342445807, 0.5087736328263833, 1.0816005134880566, 0.1821664256795977, 0.16683763823456443, 0.7983276836653354, 0.46771592408375734, 0.21966850168800042, 0.4137580725435717, 0.46917796337147255, 0.8929124048467163, 0.6020795735288883, 0.292640293138444, 0.03137927919366537},
    {1.2712037508903267, 0.8270210126015282, 0.47179329892272265, 0.687049305131494, 0.7990858247089349, 0.22048521017189027, 0.8083330573823188, 0.9922826849764593, 0.8178769025873355, 0.792725467880889, 0.7219345143931903, 0.5423198528383548, 0.598983514887744, 0.9084116804536645, 1.09459090045079, -0.18472165371147953, 0.9940993047529596, 0.9252193244273471, 0.04467333974010591, 0.43644642730720873, 1.0757799197702302, 0.27556591768380695, -0.05077449821879178, 0.8335983791798868, 0.7167619041463782, 0.29196614449494146, 0.7608377073190502, 0.8188157892177592, 0.8852344432100796, 0.4914684198703504, -0.0880731575811826, -0.05563644473802402},
    {0.796762660005892, 0.8978181090227241, 0.6924070592601478, 0.8594869181883346, 0.643244915625423, 0.28460540055133104, 0.5871142588714607, 0.8064590052479866, 0.6637849094858912, 0.6123148472545425, 0.6490261094960497, 0.8687594119839092, 0.8434837652304623, 0.5096625124499732, 0.8623610343716646, -0.22556203070928418, 1.014912285585614, 0.8889320140635948, -0.16004272229268238, 0.5879096479639537, 0.7927426207773673, -0.11623202721088834, -0.3586477699477036, 0.6745064961814224, 0.5116470953002671, 0.4145227891643958, 0.784882630489838, 0.7972731323485148, 0.7245195824809241, 0.5065633312042402, 0.21436732784138254, 0.1310518761273813},
    {1.2478517250632624, 1.1321249466707117, 0.6580948753043026, 0.9575785150557486, 0.660600963014001, 0.34085905495499075, 1.0184091796382722, 0.8159237365753361, 0.7762719228443287, 0.8895743922517958, 0.47731923374047835, 0.7234214791447645, 0.9472324111449348, 0.45166281911331135, 0.6524961229131293, 0.02134710695041257, 0.911243323964168, 1.070825631423367, -0.2585220242583277, 0.28776963719797366, 1.0492895023876874, -0.0404223064450046, 0.18577940100760254, 0.8465718173996886, 0.886457719152233, 0.43078559813979833, 1.056996736837805, 0.6172328865237644, 0.7772080361341899, 0.8140448190423162, 0.39558366805286665, -0.2559325452667293},
    {0.6911779165631192, 0.8623905490449902, 0.7917910196509834, 1.0363085476594485, 0.9265422947944987, 0.07194039021189352, 0.8180300115224065, 0.8023038010900898, 0.97512685919594, 0.889856954190933, 0.6117877477827689, 0.9812735960775669, 0.48817975088485915, 0.550206238671499, 0.7740746589782855, 0.08455567292768547, 1.0563224634667174, 0.8574361777606221, 0.10886608571082106, 0.5058793931018, 0.8516938958032685, -0.11180740414416934, -0.10030246814003323, 0.7562101066649228, 0.23485195050279406, 0.24249304489170356, 0.7054639940569105, 0.7837442003917038, 0.8471991697794097, 0.5828224156324151, 0.025079620083713342, -0.005141052137884646},
    {0.7466788927900083, 0.9855422709615035, 0.8611868626160188, 0.4949806896488868, 0.4723276034918227, 0.3773025197906847, 1.0166864314501993, 0.9374163319745445, 1.0904876283604739, 0.7406114891643203, 1.1013296336205731, 0.8648027849500615, 1.0156794807928669, 0.9358731090667667, 1.1094243713175231, -0.14846657419356174, 1.1845342489591546, 0.9160459042010655, 0.1324738601714307, 0.804016337630654, 0.9912263089122433, 0.1106331091422162, -0.18253143902894983, 0.5337178607849693, 0.8108085215804539, 0.5230531465472467, 0.6420911733580584, 0.9352811204821246, 0.6890674211472059, 0.6750435750092652, 0.35543727855666457, -0.08027028286502466},
    {0.7389785720218877, 0.9161190648586585, 1.0356458776528237, 0.8028620214399712, 0.6885227031970445, 0.06221080605117663, 0.9918757764304178, 0.7644407790322834, 0.9495441898764653, 1.0095922648504376, 0.9488780787036577, 0.8730651527103543, 0.7703278014246159, 1.037570274659218, 1.0960083702365928, -0.04291377121734674, 0.467630572972497, 0.9515786693059121, 0.09650478039877819, 0.837790369753268, 1.0872210632976131, -0.10444557773915104, -0.08166021461747716, 0.6293413636413842, 0.9909127794316138, 0.1712844761060806, 1.0056683924330303, 0.6121336426273021, 0.9657052152080068, 0.7760764870257505, 0.1776481838472548, -0.029157762405553598},
    {0.7454929382783598, 1.1320683830196703, 0.9659033335689831, 0.4120617905915415, 0.9808455249105941, 0.2105332730724507, 0.6292015493407965, 0.5169236887465304, 0.7670897680109522, 1.0426990824433435, 0.9465318243724141, 0.8704621530538673, 0.7116465335555138, 0.7987148169750614, 0.5800496342030171, 0.1728360003624131, 1.0127841443758467, 0.8505787329249398, 0.1199236203287815, 0.7106227192785963, 1.0027403248430151, -0.07356480548615774, 0.05522060573986038, 0.5714957279132934, 0.5269730433308353, 0.19885132375854156, 0.8434189463870201, 0.8286394616777525, 0.9130822786006113, 0.503678438717455, 0.1856899318482176, -0.005023421755548557},
    {0.8164437472725979, 0.6871245141931712, 0.5740053318144414, 1.0268367457166347, 1.0268949799489169, 0.15203846450136163, 0.8644267997745864, 0.6975734762140194, 0.7405686761970979, 0.7271595169916099, 1.0494495235188588, 0.9743873520451826, 0.7056981319665111, 0.4916139721044188, 1.0739536112565748, -0.17421250781634795, 0.8332028091382963, 0.8919598129427063, -0.1705129097129049, 0.623178295580409, 1.0613094904604006, -0.44046512058682774, -0.09974050446224493, 0.6729136879604055, 0.5212623204189006, 0.21092855346034864, 0.39971265939571027, 0.4898619352949769, 0.43447674753496923, 0.573558418983384, 0.2377823126905165, -0.12189390445437263},
    {0.46905479753023593, 0.959148494812582, 0.42975084715299877, 0.6834949093218102, 0.9801616345263819, 0.2718866694184846, 1.101030057656601, 0.883405893603745, 1.0266797152865417, 0.7789184397208142, 0.7201527761896516, 0.9932653472828352, 0.6846468926558803, 0.74831417656149, 0.9644990784436481, -0.06940299679786194, 0.92261573747051, 0.8685036357628151, 0.15828563621722203, 0.46573197429977575, 1.0625394418187906, -0.0397125492188147, 0.2309480039815529, 0.7147698928849747, 0.37301605740127514, 0.13328902171543533, 0.5048619958080401, 0.2554833736788203, 0.9429927796518767, 0.4746028583853267, -0.11476005212657828, -0.15670723091612923},
    {0.7175697951545236, 1.1891303496892776, 0.5584848343385209, 0.6674630606563831, 0.8084633942018441, 0.02427721424415768, 1.0426118394163244, 0.8896467002783777, 0.7473377970680093, 0.6750983055386228, 0.9630902541477423, 0.8653733056743589, 0.7297524987343056, 0.7751650338683646, 1.291357179582615, -0.2129037044363112, 0.833475850874759, 0.8903202027252543, -0.1954238589339351, 0.3245965753590754, 0.6762400828870084, 0.2217478554194823, -0.14499418784082233, 0.8030145913148533, 0.6394968702923601, 0.04784810977584719, 0.4117001351731849, 0.8919869781232261, 0.6197683139355129, 0.5136289078565305, 0.2932736719305025, -0.039532394107903004},
    {0.9292828094673509, 0.5910015860822366, 0.7786729496227315, 0.6323017442192773, 0.6570153846841144, -0.12876455079474142, 1.0357854368806847, 0.6688965587841916, 0.8402223162231828, 1.166323062429539, 0.632360431759674, 0.9403796545027328, 1.0417779852207658, 0.7010387074525708, 1.0676310461672682, -0.10983484657506924, 0.7193127417541753, 0.982202876690913, 0.2364247332026129, 0.5415137377449697, 1.0555796595817204, -0.12120063547422388, 0.2378724832335542, 0.9361145425981877, 0.6746701304313015, 0.37103616226541924, 0.9087678321952726, 1.0620278300861408, 0.8212722209678017, 0.6158273837071594, 0.20846308105517136, -0.0535483433110845},
    {0.6505845292587835, 0.8992288716503489, 0.5900608140479957, 0.8751158490196104, 1.1339220666904672, 0.2178592704510269, 0.6784113189202504, 1.0234411842986884, 0.8310350307532706, 0.8859255244087348, 0.8373856965603783, 0.5897842033590651, 0.7878261326094425, 0.7771025397518687, 0.9945156914649429, 0.10393148015788008, 1.1046519151419465, 0.6582706256251294, -0.14071867937977003, 0.9874850576961207, 0.6163866479047541, 0.048503312279111505, -0.22857493135538962, 0.6722518814770909, 0.8838745198066886, 0.4496442893613115, 0.4345055300391585, 0.6986611451403573, 0.9135530790998605, 0.5785195465395507, -0.22820500338815353, -0.20721826451730857},
    {0.7920271560720096, 0.905541149727353, 0.7991285652717713, 0.60082767828383, 0.8747708343319189, 0.0756760993673575, 0.8334940582530935, 1.0161058035919646, 0.4702912046570829, 0.5219468851208839, 0.5637886891545228, 0.8522638566434536, 0.5495428513212949, 0.8551102246395027, 0.7177037366345964, -0.24632865565478393, 0.7283861751510411, 0.9427182799450826, 0.23067222589170766, 0.6143829904214227, 1.0337427075758616, 0.020287433066291726, -0.026598424615273654, 0.8836342074605853, 0.817387164767567, 0.1842967342227328, 0.7207631856669863, 0.7489597745105961, 0.9530453378898276, 0.2970435567251385, -0.16488802074318987, -0.21030234778381937},
    {0.6745629993453155, 0.6157699731871163, 0.6374899378257133, 0.6784325340246914, 0.7915060792978447, 0.0520344756611608, 0.5903496878229353, 0.7317720477033836, 0.5311729161788709, 0.7546485766677237, 0.9128708694801729, 1.0108538063239465, 0.8961394286939849, 0.5114464636337775, 0.6561925590034252, 0.3347125398304505, 0.8829087642416872, 1.2254047622558495, -0.13555516063257536, 0.814397532793823, 0.6629946383671099, -0.0910712814135997, 0.11117303950284597, 0.6085862065485864, 0.8076063034449462, 0.5710785284487608, 0.7795199029823165, 0.19617781596776326, 0.45522183523382315, 0.5261077562221845, 0.050659203661962804, -0.06042608805879225},
    {0.5871761507630783, 0.5482865409454915, 0.44955737449196037, 0.7080840083588461, 0.8555232594443559, 0.11871312530042463, 0.4772646229919078, 0.6278101155792079, 0.780682226277718, 0.5958259230249263, 0.30050833332694754, 1.0636568242290267, 0.788172452509427, 0.7215977408859815, 0.9570421198257311, 0.08545261535257334, 0.8434190908092737, 1.2227947173318412, -0.08580784017055383, 0.6616599820875492, 0.9764353243782268, -0.16094754934271302, -0.036102190472734656, 0.7138939885567416, 0.49251506888570684, 0.5413689766882771, 1.0651886517525508, 0.9197156263959854, 0.7721244563145196, 0.5095644217193864, 0.18454505307218663, 0.0992037582186918},
    {0.7993202413904986, 0.6813218541849348, 0.6977712601378293, 0.8238411696363724, 0.6666982886295274, 0.5089111982459325, 0.7822612445292361, 0.7726344416745639, 0.9580301770058334, 0.8461410793961629, 0.6241545060320736, 0.7131144759610468, 0.8031620455466916, 0.6833108812363013, 1.1996427022713854, 0.08683642146059563, 1.023166119582554, 1.1798324718311524, -0.09294404821945376, 0.9533302283819589, 1.063303939554049, -0.06054392022722579, 0.01821089160627717, 0.6938468527750362, 0.6900073305020552, 0.3224595046650734, 0.5936027731755018, 0.7403122065186701, 0.5969977560115112, 0.7392044920940255, 0.056954666527896304, -0.32136887104703327},
    {0.8564751534504776, 0.8857662874453177, 0.7656656398205122, 0.7804967912547601, 0.9011911741741399, 0.18567479618273583, 0.6955056739117287, 0.6965329563750127, 0.9792174471438443, 0.6262117195220535, 0.9097916374823068, 0.824939553245454, 0.9683883281616759, 0.9594417165371303, 0.6099132201704894, -0.01832141091211456, 1.060218014493919, 0.9738100551666099, -0.13767245181309265, 0.7620763428862231, 1.015513096355099, 0.011454211782711493, -0.04461852489429937, 0.8008996253897198, 0.5809655587232428, 0.3062880567406352, 0.6831355551295666, 0.7419242973610755, 0.9484228797014347, 0.5505417873105533, -0.24648061808226132, -0.21946192685517493},
    {0.8304287292883585, 0.8044275420149058, 0.20534443442126724, 0.8550056424617215, 0.7526521117257238, 0.2894194887413546, 1.0124864083925964, 0.9011145088950531, 0.6792528802245991, 0.6430407303909769, 0.7966554792632744, 0.8527652164205282, 0.8363109558140813, 0.5570568669812934, 0.7138065544914842, -0.0009901065413950663, 1.0237435606989511, 0.9896078818999107, -0.050285260143323775, 0.7716481263353289, 1.370708134943952, -0.1009982664924682, 0.07179044403385217, 0.6119437208347247, 0.966887016662295, 0.5436019627097313, 0.7563203127794742, 0.6303181447361758, 1.1873777730084034, 0.3522175109791264, 0.0029228349542833876, -0.0686857436804052},
    {0.6630190003181656, 0.798327670408589, 0.7904540404139058, 0.9328029810441337, 0.8464471834121553, 0.35908304700679955, 0.903331317892259, 0.7228507488216355, 0.5951182607448047, 0.7136398342043966, 0.8351156638480138, 0.8228882567813383, 0.7345650429780882, 1.135717992669407, 0.8143220166577966, -0.08621642119770936, 0.9478015684284793, 0.8401389911530937, -0.16445303410287412, 0.9057249396954392, 1.0114990202450516, -0.2372179597827517, -0.08016936390846645, 0.716518204107429, 0.5023577969554742, 0.43425474991453233, 0.7713872710636077, 0.5980150393114726, 0.5457028177647378, 0.5958999803101795, 0.33041101933285066, -0.12583994625222963},
    {0.7014073482766864, 0.4792651426299509, 0.5958175412114269, 0.8848300572536035, 0.3713912413033809, 0.24198472215262706, 0.9452671376389106, 0.7784546630380704, 0.9151859323876048, 0.49778161386128345, 0.6478139839532776, 0.7113369291275077, 0.6754048531413187, 0.7680858571333676, 0.8097451156464054, 0.06485670185055872, 0.9045153376224735, 1.1981141150829344, 0.0509005229403792, 0.8438085633297627, 1.0213554521480677, -0.016350333795255297, -0.34065753081936984, 0.7719235318955349, 0.6566550204358736, 0.3958592250759473, 1.0377419474235958, 1.0988592922566258, 0.5998983099689604, 0.6812299359469994, 0.012894856118029673, -0.10739505535074531},
    {0.905618714175508, 1.0677007777046146, 0.4395734211650986, 0.7416834324431665, 0.7999445288532286, 0.17138368956793187, 0.955134866723438, 0.7538618126847951, 0.37591140390222616, 0.8134626914206758, 0.7994655463512407, 0.7927699075368103, 0.6150210143379142, 0.25624443574290096, 0.7803432514731982, 0.31815973431252664, 1.0616903454376663, 0.6314947152433324, -0.4236733509805812, 0.6914940295158586, 0.856547165771636, 0.005786506884355788, -0.04239783700759448, 0.8187240263633692, 0.8617482851257812, 0.23628971974410073, 0.43244084674890126, 0.806104616226077, 1.1107997524389015, 0.7023116845834396, -0.046831387590801556, 0.1499297933617025},
    {0.7332938402671547, 0.784340169740447, 0.4604367602533769, 0.5887796925346985, 0.7927690972764169, 0.23042755466509485, 0.857194177298228, 0.5761731832424638, 0.8187721467040938, 0.6599501456841225, 0.9579042820969802, 0.6353940820303522, 0.4498386159747871, 0.34389589717512953, 0.7960749938473874, 0.07122690676776351, 0.6582130784965612, 0.7925479599918723, -0.013704339163866057, 0.7651140048040788, 1.239455720396897, -0.139729919587912, -0.013507506967246063, 0.9225633233320124, 0.5052158005700762, 0.24702538016624986, 0.6326248076633898, 0.6904328176473533, 0.9765514933823999, 0.19188237857078574, -0.23749182954795997, -0.20890606309238025},
    {0.8171602526724513, 0.8179613718169056, 0.6662664904685962, 0.8158635111765352, 0.8126454055292455, 0.26715181000555954, 0.8589178943610194, 1.131583128610382, 1.0790807026679905, 0.6810606697493597, 0.862420231435197, 0.53886709175529, 0.8165240509325657, 0.5099387394423277, 0.9271147162375815, -0.13501047684168083, 0.7333923344118624, 1.1188685349726337, -0.1293019275521759, 0.9012071564560474, 0.6009043216754882, 0.18278528763004806, -0.11153907908816067, 0.630667737641879, 0.35230662113965483, 0.6405291052571198, 0.7239953955752726, 0.7702474702621426, 0.8542018829784742, 0.506025899756076, 0.01772692403799232, 0.1929438815314686},
    {0.8242022261339528, 0.8205755565292944, 0.6069829688051508, 1.0041272109712471, 0.9556768772440469, 0.07718617825654542, 0.9240170951496705, 0.9656672626222523, 0.9692151464018174, 0.8066953638816075, 0.541116623600083, 0.6201435180941273, 1.0146983869484312, 0.6883537541406285, 0.8819711285885833, -0.037276035457486936, 0.9968042808331956, 0.8984055120885532, -0.2118961578099663, 0.67958785014373, 1.0897224386528352, 0.07299808624942253, -0.26583699221316787, 0.3783085415829395, 0.6848199350608427, 0.02540660645138418, 0.8521398104320651, 0.6965033887424715, 0.7616058931853845, 0.5554892271599003, 0.10911756954458081, 0.1933434523244477},
    {0.6804772372542216, 0.38867834262369383, 0.9386445104734239, 0.6266999593948045, 1.305249830961926, 0.03378247822325096, 1.128576356977877, 0.864228021986567, 0.9409058291516739, 1.020480017928067, 0.6192965569333421, 0.9428760746083286, 0.6845899315748132, 1.0770648270100187, 1.0987395715972175, 0.024772023052667774, 0.7433293232696861, 1.1148810076414821, -0.10865526761511039, 0.6221624066666867, 1.1881292753227772, -0.2151722885634069, -0.2663333328200665, 0.7506756081149526, 0.5488236591865973, 0.2628651896826699, 0.7674230105948571, 0.6442020120125815, 0.9101951511709038, 0.6591067176284137, 0.14561921834275796, -0.02222896427433442},
    {1.0032471745046994, 0.775469952355897, 0.7882866656854172, 0.863837223942857, 0.8371470514804659, 0.25295634716443205, 0.8091929450549736, 0.9564673635961255, 1.0464033049466606, 0.5738030726930465, 0.6578407661863089, 0.8922276376313723, 0.9226837088930507, 0.8204848717469735, 0.6169235176404939, 0.08586302875323319, 0.9535995756108824, 1.0717264211087474, -0.041214922319178615, 0.8202396297296349, 1.0102281507081137, -0.10714701538933018, 0.23479857983767688, 0.9170963324280678, 0.9420500551706483, 0.6122747463946759, 0.7696351012975423, 1.006036281754553, 1.2286516781591799, 0.8385372027687928, 0.015089213610036225, 0.2101698993872593},
    {1.0688339166488445, 0.6847991609119826, 0.46434542498174697, 0.8124812633051913, 0.7287180055900541, 0.42282417459750743, 0.8007717932980648, 0.7069939049688768, 0.4482964134512293, 0.6414194004483382, 0.7198659244363658, 0.9510134617860435, 0.8030404854527076, 0.5597703749235524, 0.5701521626244844, 0.21897594342032442, 1.050808007066445, 1.0775038585999364, 0.2545662141793202, 0.5873203810461495, 1.0977339005677778, -0.009771900920054945, -0.09547355000042507, 0.5721346341863013, 0.8232143942682256, 0.4798063124403157, 0.8315031607269898, 0.9328865457565481, 0.7777504637185795, 0.8048674123107902, -0.11095409580297995, -0.0834967810688699},
    {0.7836560681790703, 0.7584050204449635, 0.8900937428728505, 1.015763823272825, 1.0389141276247436, 0.4480765381545466, 0.9317876874080127, 0.5016079285926651, 0.7558114434718026, 0.9078711078990915, 0.7398388179847574, 0.9857774893117274, 0.9418626632159568, 0.3294539268429601, 1.0012803999253517, 0.015495658156652044, 0.693565375105022, 0.9355764523949334, -0.18901190360027811, 0.7681097747298222, 0.7500781004638108, -0.2050634736831927, 0.09626164977769376, 1.0402287302338136, 0.8512127720653309, 0.33751725000711325, 1.0552996870084497, 0.7853354017631462, 1.0986201427853626, 0.7161341282107492, 0.10445347458326952, 0.0007042425928715212},
    {0.7119304624324683, 1.0715881222219934, 0.7114099718383254, 0.5026247456558111, 0.9253058856279728, 0.21019283679810452, 0.8510383090886119, 1.1451413738198937, 1.0049709709105907, 0.8217224546510377, 0.9435916191298647, 0.795599768127251, 0.43406121215053317, 1.0341852658847177, 1.0184592219883708, -0.3905471957420583, 0.7509630401886812, 1.149150067149865, -0.07626985997843991, 0.5927254657283314, 1.022784627936553, -0.25426497070099985, -0.04500268509203037, 0.6592094230695081, 0.7261588787437304, 0.2555591489457206, 0.9219962002481298, 0.7694496920318245, 1.0794516588369087, 0.5776633457164848, 0.0793268118172822, -0.010682898270979088},
    {0.75132091086693, 1.0113102743487319, 0.4771374257879465, 0.7180536854543829, 1.090435430215493, 0.6017985128786902, 0.8379083856640569, 0.7918523727095828, 1.038210144680363, 0.6865741770286771, 0.7001795619412273, 0.8475211840626983, 0.9303388765162135, 0.5033046880772386, 1.0184191125021487, 0.10421467338862064, 0.861698553815627, 0.8462099678618414, 0.1500444292227562, 0.8260076441125276, 1.2732590952651772, -0.2797802318916429, -0.17216966533603645, 0.96060491865949, 0.8929000067261335, 0.252735908305358, 0.7976348583519948, 0.8857025914033353, 0.8383050964204166, 0.5234059854363585, 0.14007693867262314, 0.15178917153131638},
    {0.6624021645287127, 0.6481333463939027, 0.6162266431562942, 0.8343998074882809, 0.9998524734686345, 0.07034773470003616, 1.1138276492243757, 0.7198307374190602, 0.6186010478420042, 0.9608920249506864, 0.8054214927973777, 0.8789238959344708, 0.7081556369356201, 0.6786778015569848, 0.3575961627547891, 0.16024302762083747, 1.1491387505281172, 0.9945425952983289, -0.05071691580964253, 0.8716216790227549, 1.0344232508253635, -0.06368861384353805, -0.21743340455610147, 0.36597142665069826, 0.7359389243926163, 0.3850768422381696, 0.7194793323129077, 0.8525268754865682, 0.9495276687715807, 0.3732044873836054, 0.013195819541968403, 0.12380111917038569},
    {1.0366478726713664, 1.2572538839099487, 0.7624566882085133, 0.7358535902558558, 0.8514728772989706, 0.28535571855740444, 1.0369886987511134, 0.8235673509691805, 0.8499379197307506, 1.0696912048988112, 0.9232209932169511, 0.9564937787731961, 0.8369249189773766, 0.5254177092392031, 1.2475117474527098, -0.0874918900563676, 1.1084244119648705, 0.5398644723634336, 0.14464011702795104, 0.8117436270343961, 0.9239192796469128, 0.063949636323927, 0.018748378694676934, 0.5136520748914419, 0.47196467020401645, 0.39009328288858347, 0.8109720365503865, 0.588635630074132, 0.88511919964614, 0.6582675958074312, 0.13723410206565193, 0.10560874222239766},
    {0.8627919074034749, 0.9275825451750584, 0.628689522226529, 0.7673182643480876, 0.8806510095267762, 0.3754422423807859, 0.8658093247982526, 0.6569641026251773, 0.8954257920457572, 0.8590271513389022, 0.7598329469142159, 1.1076865800128148, 0.8830087217908341, 0.8001162198070447, 0.8070059116494589, -0.26440695108682566, 0.8227320055183655, 1.1203921552269216, 0.15733543754554594, 0.6581901869897251, 0.8772130387333398, 0.2578674049965868, -0.038622471869701414, 0.7339220930785244, 0.7233328965797914, 0.5972622504218345, 0.7430173851327234, 0.8773682359930297, 0.6890730833941923, 0.5820520828833853, 0.21704981651618266, 0.119542548365573},
    {1.030779975214165, 0.6775015630118636, 0.5741906194004706, 0.8063725335672943, 1.1041843002464513, 0.08828637347648295, 0.7560338020185017, 0.526196741059663, 0.6159843073986871, 1.2858605557012939, 0.738117487946542, 0.5506155597854359, 0.8317722445923159, 0.6997084541190648, 1.1210328257091557, -0.08365830805171125, 0.9418580505930841, 0.9274792147848555, -0.14188186499395083, 0.8713509132143271, 0.8321377305632299, 0.08606743954862055, -0.18641042283105186, 1.0728978439081531, 0.6982656211368166, 0.6397732980853622, 1.1536350842236762, 0.6851904894334727, 0.7711907746029408, 0.3569864880725951, 0.2520082227715657, -0.21767553662723757},
    {0.9279241781132764, 0.6059813901117608, 0.9261175260343901, 0.9324509003251978, 1.239238833149535, 0.3938218199590477, 1.2869217684201941, 0.7425241619550876, 0.5612177765510239, 0.77443505104817, 0.845295500539583, 0.5980226545817385, 1.0306419255444559, 0.6903162717206942, 0.8455722774121476, -0.008439129662303065, 1.0629161077194373, 0.39602550161854555, 0.010057798100156013, 0.5124265255564029, 0.8758161886920172, -0.20630679446986774, 0.14891050977184572, 1.1413130587672982, 0.6699093479283259, 0.34735281368552123, 0.5770615450892889, 0.5932799002971337, 0.8794785997552977, 0.5942977850081735, 0.23274839733474526, -0.05364245994633077},
    {0.9527766792579155, 1.03521792816148, 0.6084640664314368, 0.6136928776759563, 1.102145960808569, 0.747052025133617, 1.263660829303621, 0.9895730609042487, 0.5968381114718455, 0.8804986807408179, 0.8784629969025283, 0.6534213060047306, 0.6424478928078239, 0.7201469881132219, 0.9059651133545478, -0.17726466523480847, 0.978899166685862, 0.9489222797977236, -0.3368916789670156, 0.41295221020682, 0.7901860415966848, -0.37254437408776575, -0.14054452507937645, 0.8180345462281453, 0.6036357284904843, 0.39277913860123603, 0.7447598031987132, 0.6493287436958786, 0.8650311238673806, 0.8417803007901832, 0.13464474896309056, -0.1211792715225693},
    {0.6948001240553999, 0.8724913389035484, 0.7668235071762578, 0.8135601898502954, 0.85224017545837, 0.3052583190240252, 0.9206533987902648, 0.9260222824699791, 0.9871858569354929, 0.4702785118379972, 0.7642582101764216, 0.8679269938003423, 0.570214091466498, 0.5450503456190784, 1.1623136779566967, 0.19906768393595167, 0.804754718150147, 0.565033706791579, -0.1525591388096518, 0.5692012989691081, 0.7631392249002762, 0.006838484656765217, 0.13091212550116924, 0.9555629450430143, 0.5837516858278625, 0.37127161444154916, 0.8006277124668271, 0.761295210830807, 1.2035654203561728, 0.6899608792527838, -0.14804612390464833, -0.2614711948074916},
    {0.30653861563015733, 0.7477303605290752, 0.6792158610877205, 0.6275387763194253, 0.9638571284331531, 0.3736685634151754, 0.8692954879572704, 0.9169487224804044, 0.850566998649646, 0.7309145921480555, 0.9099407521736158, 0.9570831316104166, 0.6696009814714035, 0.5242988458844566, 0.999403215015245, -0.19692626257267348, 0.6020611054554105, 0.703662937193774, -0.24254568325001058, 0.9858808692048862, 0.6491236044481895, -0.03286594959399439, -0.1720880322535737, 0.6935116125905946, 0.5359724982012076, 0.22124129325395636, 0.46630388199856904, 0.5633853567538346, 0.9229103442456995, 0.38963592156946675, 0.18117811009871937, -0.12180034572279501},
    {0.8239340715582398, 0.7451187546746777, 0.8551973719651317, 0.8639062917096908, 0.9930909050634078, 0.19323041723449838, 0.8915087520906577, 0.848291904469859, 0.682601229069812, 0.9379844699306555, 0.5477257264338761, 0.7556637222486415, 1.0402057127985993, 0.39736810969001235, 0.8810137777508019, 0.04905896310514216, 0.8007683825688363, 1.168439027319241, -0.0022955850208944304, 0.8463295978851016, 1.0630695340048462, 0.15917840466242886, -0.20717635503564794, 0.8746518223650076, 0.6191727710009932, 0.6384672825877851, 0.8252221314178614, 0.7488705344639257, 1.1048341806551594, 0.7152657898624121, 0.14251210973834716, -0.36084985272133663},
    {0.5471413677375947, 0.9904502222848556, 1.016154977010313, 0.9258424058356344, 0.6276333596207182, 0.20889923439411404, 0.7381789759594507, 0.9540304225779738, 1.006907860869552, 0.7591654687463257, 0.8666446255030498, 0.63022750178211, 0.5455557170639206, 0.9445935060397451, 0.49192521309631676, -0.11844287932636836, 0.7841985197753901, 0.5867951252345999, 0.13904093868380268, 0.6947883282128716, 0.8139999933717023, 0.14254078183648206, -0.00041720867352091994, 0.4439705439005877, 0.4613998392253722, 0.40235868956141946, 0.6806207714725839, 1.1291242171688083, 0.9179545142359145, 1.0170126163912407, 0.35773525317281746, 0.11239671611244623},
    {0.8231907576092694, 1.037331072490408, 0.8850435730876117, 0.707290589269815, 0.6744894576812173, 0.35597290567260476, 0.944064862892143, 0.7828896465354678, 0.9103699843528353, 0.6569253380580032, 0.7375801231233469, 1.1333375250357598, 0.5295520987893361, 0.3792474569859687, 0.9384573564321901, -0.2516464186503895, 0.4972598662331819, 0.7540279879156957, -0.21542255052919895, 0.47624315819662133, 0.7145935664320334, -0.18145013187964798, 0.2915637345268129, 0.5990732322924841, 0.6521411421667496, 0.5281040851186709, 0.7919109900082021, 1.0890437257844214, 0.7429166625061447, 0.6512872621576281, 0.04503993290310123, 0.2101255931892247},
    {0.8776327506940066, 0.9499159221225149, 0.44644853618069685, 0.8469762237644456, 0.5417250299821711, 0.3871303680574071, 0.8181948272305719, 0.906559552986929, 0.9200012207173133, 0.8265052353721059, 0.8142765841602289, 0.6957155417527047, 0.7900724704185046, 0.7778707749878149, 0.6661418052941955, 0.33468029564532054, 0.8154104794386771, 0.48879858041978624, 0.07542353231054474, 0.4666390451253612, 0.6521974255818934, 0.2981142209165712, -0.020864700211381502, 0.6926754420564124, 0.5160706214615062, 0.15142912910682396, 0.9914304147211358, 0.9167059708888545, 0.8100146154647294, 0.9588414788761597, -0.20909073275536594, 0.04422942764141313},
    {0.5392275390784715, 0.8170503231618677, 0.6381789324819209, 0.6771710706081715, 0.7103038233551577, 0.12162422840863245, 0.9625361076591834, 0.6755539454370243, 0.7766349445737845, 0.7212882537368871, 0.5578045150930111, 0.9015148589104836, 0.3904080887136835, 0.49238803212864846, 0.9244769864583973, -0.12881494708006208, 0.6402203772665495, 0.7516798240068459, -0.07747673556828977, 0.6666916960329897, 1.0345289129221487, -0.043665804164108674, -0.20953548240831477, 0.8229620975487166, 0.4309601439626705, 0.13978119541021058, 0.848727243147548, 0.6902107714931796, 0.8946595520678267, 0.6183258544570227, -0.05600391536357746, -0.0175611557103118},
    {0.8380044740177504, 0.5740395059276145, 0.601908333091992, 0.15237950601957992, 0.8883815896795485, 0.43972935450618916, 0.8153169167672387, 0.8306869497436443, 0.8806027827036931, 0.6658928938247803, 1.1874191584828462, 0.9094978005244168, 0.9370688382163389, 0.5141213905454384, 1.2250961319957068, -0.10018555519059807, 1.013337588867873, 1.1379784500927865, -0.19367041530916093, 0.4188510787529086, 0.9578484948965105, 0.054561894819557824, -0.08174579062151746, 0.9105844151906624, 0.8250359987933318, 0.08466358523788324, 0.8109764357768392, 0.486730938664302, 0.9891636647775609, 0.587480596233729, 0.31315648878792457, -0.10889689104876694},
    {0.7833437412514467, 0.9498925781067911, 0.5721910017802962, 0.8578265757204686, 1.1399987031193937, 0.15427463110653605, 0.6864418635395794, 0.7039797120245008, 0.753952889330011, 0.712320442967303, 0.6504447866600516, 0.6296617433746202, 0.9565921915076732, 0.6063777448689259, 0.943576940721185, -0.12067732994445453, 0.8596718768565418, 0.9062756034672901, -0.025224581530151863, 0.5522454740411367, 1.0209658662759566, -0.14791731008254239, 0.0001648492963472942, 0.6023857501757675, 0.5631572619008876, 0.6345873114701074, 0.8570848007416229, 0.8877500774303705, 0.9725114029584478, 0.7671629609138669, 0.05413885686974629, -0.1705390119609846},
    {0.7189016107801849, 0.9792384052559068, 0.6307115328514464, 1.0080468883218634, 0.953580045935248, 0.3836109752539167, 0.9124561058656402, 0.6483482558843239, 0.7173290208070341, 0.560453112509596, 0.8781294113425979, 1.181041822199857, 0.8642422877088514, 0.4852649833116075, 1.102732931913145, -0.22480850005530048, 0.8105319350968858, 0.998513063359438, 0.05510699961171964, 0.4769599123329205, 1.3072286399068165, -0.10797540163005118, -0.19364419888235904, 0.7878168530122258, 0.5134002308299723, 0.763403543813549, 0.968988936668315, 0.5292098688839864, 0.6928028265385073, 0.5461289343888104, 0.012327422239533458, -0.07920706627802797},
    {0.7514130358773821, 0.9378209876700577, 0.37415976022910286, 0.8369884137189958, 1.200591141298336, 0.47308750803837124, 0.802261941148043, 0.6658301856392425, 0.6150985074651001, 0.7496811420515679, 0.8707787311789218, 0.9868556101347081, 1.142795376699389, 0.7027777637521128, 1.0545399519819998, -0.02109771444931329, 0.7979515256047054, 0.9832475912323665, -0.12346074257008718, 0.28177618928822945, 1.039857171108899, -0.037764854898931284, -0.02812505639485181, 0.9383374525835999, 1.0432244480486896, 0.4370358991549106, 0.6646781274106001, 0.6558904306932618, 1.0114531085205491, 0.6457218604582576, 0.03945160284021688, 0.055864571858249334},
    {0.7936048358861563, 0.8378109733169282, 0.49580578322133373, 0.618676176648749, 0.7695160800540524, 0.13151453000165378, 0.5290485012834739, 0.8106603127906395, 0.8454278629541345, 0.6288690675577553, 0.7388685522660197, 0.8369921067494244, 0.6253257727056131, 0.7470348424416793, 1.0393341600289532, -0.11707544427658952, 0.5310631582633039, 1.0462928527073903, 0.17552597983356197, 0.7460661818708526, 1.085232908782024, -0.11819928166861805, -0.32762504638090195, 0.6933446482842586, 0.6222638049587033, 0.5282377439829271, 0.9831308206907777, 0.9751038479942707, 0.640858124781688, 0.9240438672396745, 0.22907576119974427, -0.25415395681397696},
    {0.5281634870119059, 0.8933493595255374, 0.8088098991625954, 0.7644645137724293, 0.47557447708705053, 0.03205206345758864, 1.0105621452106832, 0.7230027162410294, 0.4285529762901116, 0.9849829965404301, 0.7697631249160883, 0.643179501006791, 1.0942585743080084, 0.5249028881065501, 0.9059037812169074, -0.19340476756260308, 1.0337831377832183, 0.6705678273681557, 0.045765450750860505, 0.6584346152212222, 0.8741089759365287, -0.015056099024948243, -0.16043188027852567, 0.9721656832187906, 0.6120986006662824, 0.3023907972943027, 0.5763183790700513, 0.8419261967724463, 0.8697095762808527, 0.37345671782346795, -0.020917273118603804, -0.07849965028702574},
    {0.3670055411619479, 0.5864121377970702, 0.6720844793000458, 0.6355944943512201, 0.900199297499602, 0.06960242144497067, 0.789461463180765, 0.9745575878860736, 0.6123670957490365, 0.9228180888149817, 0.6892707589685427, 1.3561282973566091, 0.9681080922253461, 0.5814882179887266, 1.0135053135464767, -0.10291995535597845, 0.8172924269666038, 0.9777262514479632, 0.02561371284509354, 0.31161619466031143, 1.2042933498597284, 0.09363661796393236, 0.12578099925417782, 0.7506586571806715, 0.47712164375179655, 0.46572711116242516, 0.8887929240098433, 0.557349581595769, 0.849287213929504, 0.5411571467127181, 0.21419541200840925, -0.10963668171185399},
    {0.6426990762950525, 0.6831847431380476, 0.6031264188645389, 0.5312142707637562, 0.7118111410365529, 0.05261147064426961, 0.7074827942384093, 0.6123270748477643, 0.6406720253391792, 1.013993457441717, 0.8583991720810245, 0.7191501146085854, 0.896036864191753, 0.5016514451740925, 0.7206209032265141, 0.017451919465584123, 1.0199128394990722, 0.8756046771781686, -0.23482216698445507, 0.7980168591859157, 0.9809335170312458, -0.03186600146835122, 0.22239973471330518, 0.9881932719160137, 0.6743921212239246, 0.35742364270652727, 0.8492205411460277, 0.6730891872218376, 0.8412248876727153, 0.23426180155478898, -0.07946486107533521, -0.16635063612113504},
    {1.0360256360625257, 1.1214146043832987, 0.5992642759101636, 0.9707155190597513, 1.0899513071498426, 0.07379453619824337, 0.752852915413114, 0.7815387487150881, 0.6363901761464326, 1.0587066247903483, 0.8399896480039052, 0.7767496247753182, 0.727423517248925, 0.5834679388629981, 0.6496841690369735, -0.09688323577709171, 0.8320897559602166, 0.965365605986023, 0.03735021663507437, 0.6439557407123828, 0.8898527609222531, -0.009437565445489977, -0.06375306844912525, 0.9375349031865788, 0.6023028871505622, 0.3814831678066156, 0.5658419245516613, 0.8076675414269547, 0.8322238229782055, 0.5726310051957498, 0.13361417806563386, 0.023749165088411347},
    {0.9076693870341148, 0.5846944749564812, 0.592076426712713, 0.562444816746167, 0.9521064842639871, 0.4739061587230163, 0.8748956088681636, 0.8429065462310632, 0.8319425566175829, 0.6330219420827633, 0.8897566857071396, 0.787566112904783, 1.0314829946805075, 0.7495928752128183, 1.145321060829399, 0.2428135896342709, 0.6658452448268816, 0.8229066399556292, -0.20942518679319796, 1.0404150147545659, 0.7583800362183172, -0.10297897902933655, 0.0787273309463144, 0.7614508739990298, 0.3476937571349847, 0.5110084136390854, 0.6207998554298824, 0.740355532670428, 0.6747079605097944, 0.4039317196729318, 0.41190294852214177, 0.14389072343709047},
    {0.9095085408422701, 1.0526045741207548, 0.6742818123954376, 0.85842850507696, 1.0315343895307958, 0.36238953088456616, 0.7535428754644247, 0.557868797375497, 0.35389051362983476, 0.7103891456666299, 0.4643919322194557, 0.8115199139785705, 0.7523603573762805, 0.7452848908947647, 0.9628009872651021, 0.1315970198912941, 0.7389085926621534, 0.7600456529411523, -0.06265586185486478, 0.6210012500617612, 0.8060642948314066, -0.07161662105108982, -0.25550028415446824, 0.911487449688095, 0.6739641118559658, 0.3605394994761126, 1.0240221586120806, 0.9846872334954637, 0.30538625692783405, 0.8468749848076337, -0.0979500675162538, -0.3251516993981339},
    {1.128899756395676, 0.8326906786446194, 0.8093687915944656, 0.8163911184892029, 0.9019732428930943, 0.7073738240813826, 0.629477142321741, 1.0420007150394819, 0.952400126051175, 0.8240028232254394, 0.8966936819239792, 0.8046403469174881, 0.8578720252575145, 0.683081208047238, 1.0955802419504383, 0.026722548822793415, 1.1688705172308094, 1.0643179990753056, -0.11738102900840665, 0.538436297667387, 0.843063963140043, -0.2561390281560923, 0.4266529156125627, 0.4911779562433764, 0.7480081285960878, 0.38143327301888014, 0.6394837922675688, 0.8548366199198304, 0.6590078188875286, 0.44550564289608907, -0.14674676861306568, -0.07932507870086514},
    {0.8176800687265453, 1.1291143303865128, 0.8643519958734723, 0.3877480184110019, 0.9784889900329412, -0.14263834634238992, 0.5090884662986311, 1.0217799413951496, 0.3757766473046192, 0.6748380528797435, 0.7360528593509813, 0.8659950656331966, 1.0253355919457152, 0.7813261819045499, 1.0208160567472353, -0.003253349471430752, 1.083844625150396, 0.9544668661448302, 0.023124249640966855, 0.44817089554630046, 0.8437765407506818, 0.04657126926373189, 0.31017450638617305, 0.7541842988691719, 0.49408704716528806, 0.2195969877138833, 0.8063316533767122, 0.5550613473908592, 0.8669306462769573, 0.3523080457494057, 0.10932330100936703, -0.19889888116434012},
    {0.8902465477559429, 0.8217739749944649, 0.6713090485840425, 0.6049365988577466, 0.9899235913120669, 0.30480318271265894, 0.6504900633348918, 0.7040240562368546, 0.8456297816692087, 0.7926546442321685, 0.7196500535188806, 0.8852420406476539, 1.0057234694163357, 0.6394933896117676, 0.7665610980116446, 0.011195471480550273, 0.9517449824347932, 0.9080348565853836, 0.05745726907133358, 0.5037466593285466, 0.6959092458307479, 0.20425014093142344, -0.009547589921324448, 0.6566834828396598, 0.7169945480695296, -0.015295598816334584, 0.860907891913102, 0.8356503790557311, 1.0025683100506873, 0.5736050402003615, 0.001950216713784249, -0.15795692271832149},
    {1.131141486953707, 1.022465585209168, 0.5267411808382322, 1.01976555754429, 0.9855231156204186, 0.1093829297983201, 0.7985538839132241, 0.6556960699266773, 0.7688527773230642, 0.8534424905362614, 0.9484867827953851, 1.0123820251952032, 0.7308964455187112, 0.6702652715478463, 0.9914205987582484, -0.18238793452604543, 1.1129833161811735, 0.7990264953350608, -0.10723716601856298, 0.7235902356092544, 0.8739139200584358, -0.03972867691068569, -0.3339971522249245, 0.9071945384665007, 0.6709031079119191, 0.34174412105610114, 0.7369023314704178, 0.697709230558967, 0.674526550213354, 0.4195543488572251, 0.3523569021945121, -0.005240702103786315},
    {1.0665480554937385, 0.9554133175158779, 0.6916165430452891, 0.9300658577355644, 0.8590806206655279, 0.18537425531080215, 1.0521825825140154, 0.7636247376304883, 0.9377753377817691, 0.7414649791894633, 0.5802105600080004, 0.8356838369737848, 0.6268875072293861, 0.35078987857930466, 1.1149380921995384, 0.1345417327711774, 0.5979963521654503, 0.7774005146972277, -0.3629283145079972, 0.6461991861676466, 0.8170385628920153, -0.06748416086393784, 0.16856980738513624, 0.8264666662967439, 0.8432674189459932, 0.5271666313064719, 0.6746588923064651, 0.38818810366245693, 0.8077915913622205, 0.5053519787806718, -0.22279106923728884, -0.09588635211151993},
    {0.6710365075671816, 1.1593435547209874, 0.694315216917996, 0.7313953571718877, 0.8559290896832795, 0.3026613224155236, 0.9556577773129319, 0.6175284180611209, 0.9352127568658085, 0.5214809047232785, 0.7613337150243644, 0.9016205360593242, 0.49913129911783355, 0.5372557888279331, 0.9374412577924962, -0.03163261026905421, 0.5914529541798416, 0.9818076767272998, -0.39609066068417115, 0.5051333023712261, 0.9565507936109213, 0.00860250605533621, -0.002725801682607093, 0.8315017751082264, 0.9147218512505625, 0.3684651518447283, 0.9176052645363072, 0.7782437937717296, 1.053823114558176, 0.754715371003572, 0.08058736900737348, -0.007768215385551054},
    {0.7287316194467989, 0.9910293594224957, 0.5510904062171003, 0.8563195971771204, 0.8699610387486858, 0.26727024860070264, 0.8086999685880839, 1.0396184457788489, 0.5349728665482496, 0.8342307841165637, 0.8347234832683237, 0.8819321091520286, 0.5435705862972829, 0.9037066011853272, 1.2587670685726633, 0.17474213681790274, 0.9438647478882325, 0.611553821035608, 0.24627907507331784, 0.8127086256148344, 0.8958877682688275, -0.10754026753260029, 0.013601906662576081, 0.9594598843086616, 0.7887949808210621, 0.34246998660346295, 0.6159335255022949, 0.8639360716652328, 0.9351216391674728, 0.6667106762101898, -0.007383852668961695, 0.20868435490116857},
    {0.7582582546433917, 1.0375836611780371, 0.6221987197687456, 0.5525458990376665, 0.7488415963877301, 0.35499958422843303, 0.7758822403446872, 0.9653976017125868, 0.5578697902247538, 0.8191015643358839, 0.32697144270581086, 0.748739904915346, 0.6854118310925813, 0.4315700038695492, 0.9622616208959546, -0.004877433920057122, 0.8317304979122079, 0.8703979649846294, -0.06761121147277373, 0.8454791609725624, 0.9231404373136535, 0.02956082346977378, 0.049553047802716105, 0.822418677580509, 0.382522342969347, 0.24411261308959, 0.5235211615994231, 0.7918252365164838, 0.9895264950299363, 0.6782042105208768, -0.021698010737895027, 0.16727926361810844},
    {0.9600001071735399, 0.3974661568520797, 0.4754271811573122, 1.0293926154920119, 0.9304302371466617, 0.0688815832828358, 0.8949377737957472, 0.9007209205687459, 0.7470191035475285, 0.6119219798786637, 0.5965282598035331, 0.7431475153177931, 0.7155911773897824, 0.6179894737715462, 1.070261028488245, 0.20549073477443247, 0.5446214908884187, 1.1888398548589898, -0.28501056267786484, 0.5110229471462314, 0.6987970132560598, -0.0967138973662145, 0.07015743898662723, 0.6201659777811417, 0.5414555974416387, 0.10446811618817893, 1.1517281264072667, 0.5203972695101752, 1.0813158808977732, 0.8097363164915857, -0.1690200880093626, 0.23542995092500313}
};

static const float b2[32] = {0.7901635188248346, 0.8400433421367238, 0.7267756560675497, 0.7930514052670594, 0.8559280118365745, 0.3089594249222522, 0.8489383052499208, 0.7787938827157938, 0.8572931622005658, 0.722639555695838, 0.7703975574599569, 0.8835867989406022, 0.7961111255815194, 0.7058353841640052, 0.8961411319295917, -0.058356113473676884, 0.8468923758532548, 0.8913418885961879, -0.11238195986742162, 0.6484408003596582, 0.9027966035590791, -0.06877174218772314, -0.047048700523079925, 0.7514504072750019, 0.6690123294598563, 0.4742760753034077, 0.725836918647864, 0.6929052950831271, 0.8531826392428838, 0.5746639546359658, 0.20119368704737492, -0.08732892875616659};

static const float w3[32][16] = {
    {0.9182997604631845, 0.5123996351074412, 0.08866632789090356, 0.6291347499939687, 0.799101207091124, -0.21608661500093387, 0.20426386211690237, 1.4171985468168051, -0.0540415790603001, 0.1646223829832872, 0.1559809283150177, 0.3054434455111028, 0.8412957840361462, 0.04793882625358818, -0.3417196642031801, 0.460996824926896},
    {0.3664285406107841, 0.14243152660843064, -0.41627874414198945, 0.23188868170844837, 0.514482662631738, -0.10188574243736326, -0.252399168393887, 1.01177024626895, 0.06662462945552353, 0.05899702534871431, -0.4369741783741099, 0.16771975298917202, 0.8477944677597328, 0.29475995985810066, -0.38164140507481503, 0.9389515653620657},
    {0.7191623588527996, -0.14956119436820925, -0.0807463569422825, 0.353113682914427, 0.5275570268738268, 0.176209412219129, -0.1177020560951433, 1.4011698225046478, -0.3202290200698773, 0.06175864942878419, 0.44159719941926806, 0.15923846106509773, 0.9240059548236692, 0.5859118209286318, -0.19191144920678577, 0.5439816105263483},
    {1.151650637689452, -0.08493998356260717, 0.13656991777542327, 0.32354893705313964, 0.8897942025512349, 0.22668152487638307, -0.08012831755066627, 0.9527291874656292, 0.02129165500748407, -0.1291718857996218, -0.3131694909610847, -0.09374913980309188, 0.927595008672995, -0.08312082004295518, 0.14305550731909109, 0.7306515845791568},
    {0.7246855394351235, -0.18773279121929723, -0.24706601449844673, 0.33354551105003244, 0.8560818413605502, -0.27214660186625156, 0.29698462616288385, 1.3779318372310863, 0.06592961514532952, 0.19663533356077645, -0.4433975570214578, 0.2150447466305758, 1.1874422200900476, 0.12951629068054155, 0.02996029737310858, 0.9291425698914436},
    {0.02078304592857025, -0.11298534177619736, 0.5551724418993352, 0.752546417785898, 0.5169104407495638, 0.0023442583116510167, -0.3596141258374084, 0.4882320491677509, -0.18688827391152277, 0.06651235051708279, -0.4901569323611914, -0.1514761702899406, 0.33070566824322256, 0.06243368511503267, -0.28462423184309954, 0.3323208419361638},
    {0.5010879402216116, 0.11447632700154671, 0.0034965589393315677, -0.1630560909379342, 0.5943039123970759, 0.33984701313723975, -0.4637007336161033, 0.9965623149976065, -0.37868243813173813, -0.25220425640912914, 0.4749479116713566, -0.2741405457578662, 0.9504337725221348, -0.11910661004130925, -0.4506793691299863, 1.3525218480679095},
    {0.6326357866198324, -0.5293085594591309, 0.06750050660358978, 0.5121357273471929, 1.3560499656832086, -0.24394574487326437, 0.08017304931612977, 1.0528788802422164, -0.1438438185451505, -0.19441239100802982, -0.5368710739090086, -0.18369831995350647, 0.6610671020964652, -0.49730689022217966, 0.06394537852959291, 0.425978546079798},
    {0.8772201309138374, -0.199659956342157, -0.36202308828721597, 0.23262199083052673, 1.009222581175966, -0.024550956800467812, -0.04493924564739243, 0.8687131295176177, -0.17916154299269468, -0.10900399318085734, -0.029498247873089932, -0.13439662057051083, 0.7878085273573999, -0.34370121739856174, 0.3114077503822969, 1.2628762616167546},
    {1.0531657162272026, -0.018714426208595206, 0.371890711357155, 0.5379925513887217, 0.6618237516965932, 0.04493897034675167, -0.34146419477400936, 0.7915541935705652, -0.5005176247488722, 0.07565249856395731, -0.20571416365437872, -0.2672844055411725, 1.2806827796621796, 0.048516236846465305, 0.024950385766909798, 1.23313750130622},
    {0.9832779398583268, 0.14291804196184407, 0.22387679010516406, 0.16148042489485895, 1.1015821400954684, 0.32900962097187664, -0.048518011824715296, 0.9422641534795827, 0.003246613478319546, -0.09142243399848986, -0.08303083318925285, 0.03873187198053163, 0.49168125408487573, -0.3642697482909492, -0.05371733324602494, 1.139713548046718},
    {0.9280841587566959, -0.14694924641362087, 0.038672143004281345, 0.16188900774030573, 0.876579858180284, -0.24164480502034974, -0.02908090025657332, 1.1484981768544102, -0.26348790288340385, 0.06329669822032837, -0.014869659603669207, -0.34054037357311345, 0.7698099362938767, 0.07482202171073342, 0.03377995865827067, 0.5924406992132616},
    {0.8846071907373906, 0.17306281256628, -0.06853990284160102, 0.5842155004582675, 0.9153573842600585, -0.37214211869638, -0.05419137826585988, 0.8738441611884568, 0.32658630917349685, -0.4310597651461939, -0.008445278934386093, -0.07012273820278211, 0.8958054799577255, -0.19062122537418466, 0.5820705753979751, 0.7875384359616101},
    {1.0298966049636193, 0.11282180159865242, 0.40395757367160373, 0.2610582721761895, 1.1166303932380024, -0.1621307143776201, 0.21199931136167421, 1.0631917287628705, 0.015411165944914873, 0.17127750033392564, -0.19439580638790124, -0.16640687078803884, 1.0009011754533528, 0.261131734153733, -0.04953325088713525, 0.5569369180893695},
    {0.680109042760952, 0.17473250717342523, -0.2261915175494094, 0.2509928724511946, 1.3241530251453963, -0.21837916115124323, -0.06825418905751825, 1.1560962391842697, 0.03349515859525717, 0.07056613894978349, 0.1498617147351517, -0.35332744866550253, 0.693466932801444, -0.42990238814877973, -0.3164470945071275, 1.1840359205823585},
    {0.2173042181769286, -0.1537086626652913, -0.18435954329040427, -0.19227628667090121, 0.12613192269849, -0.025242079943606752, 0.019444500115832552, -0.14245498762287073, -0.10766010398255159, 0.17834305749277568, 0.3429263237809128, 0.5545535987543434, 0.18778549440743314, 0.14207406303444037, -0.3017879134630416, -0.043240270060910545},
    {1.2196208352931337, 0.002254153205401642, -0.1581291582462224, -0.2685970655321606, 0.9204557195417294, -0.11479312210450394, 0.1325193657754326, 0.968358823382377, -0.29180594721851466, 0.18019938679995928, 0.11359481997258596, 0.06383631465767356, 1.056186710201609, -0.05611328031012675, 0.11721819019403015, 1.1962115735072225},
    {0.8345341101231806, -0.5330002672765031, -0.04358907547549782, 0.3288824046376843, 1.1835623583998616, 0.06638922719274479, 0.016732653499288354, 1.1338593605886451, -0.41335804191997366, -0.37284775732194586, -0.04887779279465242, 0.07214772612130012, 0.908405820025352, 0.07547691514810824, -0.028747330661061547, 0.9782766911960301},
    {-0.027089647144323062, 0.07687658034842022, 0.022637396472268884, -0.16138332517123474, -0.18071388192981985, -0.006650105310708377, 0.044382352806698985, -0.11812494532113227, 0.29325679864313803, -0.03842228481692442, -0.2205317980948655, -0.08328747157200096, -0.17005282520081938, 0.13693722115472132, -0.09569050496858238, 0.0860966313050683},
    {1.0449902672301068, -0.2197220693877092, 0.3359826983717156, 0.21773453099880472, 0.8322025862684006, 0.2917150075333393, 0.09950216304542973, 0.6843198368064581, 0.5136080005675584, 0.5896075967047687, -0.15345800670576215, -0.5721129115506061, 1.0300925947004742, 0.12957259982184016, 0.018036112632283854, 0.9838990500957129},
    {0.37712341703832974, -0.3286620003144815, -0.06555395427707762, 0.4034938279475904, 0.8378456892094862, 0.025552526440901432, -0.024416852121338418, 1.2385880998625007, -0.4217095156709543, -0.20084282759954875, -0.4759439209561528, -0.3943318142046298, 0.6447595014215828, 0.12231576547149473, 0.08733496575827399, 1.0688764141600242},
    {-0.28620701541473315, -0.5226097970153615, -0.16669950247399537, -0.0036450365375214197, -0.2975576506580577, -0.15000159740926786, 0.20248391437579724, -0.043633303849784595, -0.03820459760550356, -0.15763404753045712, -0.09095778041812319, -0.17560240078569864, -0.26649354691079674, 0.11442112765021735, -0.46528936793294373, -0.20104642407091547},
    {-0.2591459030243328, 0.27828288409854374, 0.31583825835793466, 0.3726627824943011, 0.15642339220301435, 0.6670197136465794, -0.14198972121865525, -0.2550072072494074, -0.09780049250311079, 0.09336386222350336, -0.3864324494513869, 0.2769935276543536, 0.1742667806480693, -0.1935289394649726, -0.229009376924574, 0.11241038189195693},
    {0.6230953632081369, 0.13570690394753895, -0.051249082772286715, 0.3294347056361868, 0.8333837240149922, -0.06663606628117487, -0.47345148786669966, 0.962846737078318, -0.5826994633117767, 0.33020419087005776, 0.6358118928614698, 0.04482548096073843, 0.9280515648702123, 0.016149862482874734, 0.552578334795825, 0.8146263005254891},
    {0.5874479500570524, 0.19027153180099532, 0.14978632084269802, 0.11520008186251905, 0.912091201484243, -0.1627539015851539, -0.24581171979699798, 0.6115344715486465, 0.30553099289603564, -0.16683659931213485, -0.17602943790127573, 0.04028974513209655, 0.9208866279899628, -0.0385813272561548, -0.3028671167547024, 0.655185355316541},
    {0.4353000769134875, -0.021807928432154667, 0.26875765720830236, 0.08424486402222699, 0.22806264596469258, 0.06418805249282226, -0.32985041518025804, 0.48176143597081905, 0.32210609065844736, 0.03540167629662357, 0.03641371838516508, 0.08536005551338743, 0.7192606179316691, -0.16128970467070355, -0.3705174695701519, 0.7921844746573079},
    {0.781709370823035, -0.11446546604503763, -0.20284302374194108, 0.08371868825368212, 0.720082891084599, -0.24863966623614017, 0.18624941468992176, 0.9604668498390663, -0.027471628342527206, 0.4404216543746282, 0.0074799024230082665, 0.34165082753003134, 1.2552914418014194, 0.30277580044149816, -0.1359977929261942, 0.5200369420078171},
    {0.869837439243265, -0.12918104900154964, -0.32208268391706935, 0.5906920234981575, 1.2172608047509095, 0.15011844229972274, 0.33178275633545085, 0.6547720124571963, -0.2630556292714036, 0.13619145912527533, -0.13425826935093793, -0.12402178015453044, 0.8262430838837728, -0.3049527096788102, 0.2226735463357666, 0.8365595353957509},
    {0.8504573032216246, -0.275268271009568, -0.24461397432577783, -0.0985102133406524, 0.8499788674458367, -0.051671861288434345, -0.3446739795933977, 1.1896149470791937, -0.21518921725308574, -0.39127843214698144, 0.0071233024057378936, -0.2860499667352813, 0.960559024255753, 0.07429745432331392, -0.3605155859292375, 0.8305113882176748},
    {1.0168527363751656, -0.15869791134479833, 0.13644466348372883, 0.10573874555360997, 0.27261713609726274, -0.46624712149051084, -0.1397636674221761, 0.9489209866649673, -0.04289521433508437, 0.08507854929196991, -0.13730392428852134, 0.1749344628893475, 0.7952913332066899, -0.07051961266249009, 0.22976081328116887, 0.6784569608238027},
    {0.21628945980208386, -0.3390014534254155, -0.08781840279849759, 0.1381407426188167, 0.5454946840686472, -0.030396653735274493, 0.27700657249441646, 0.3276271074257027, 0.1369372693945553, 0.10768413153395322, -0.06342569519182774, 0.11932713164808942, 0.009800630453515612, -0.25283187242854305, 0.2832243913274579, 0.20385526054042893},
    {0.052395177166286756, 0.12489029599408102, 0.32799710919649117, -0.061682379023498934, 0.009750500953526541, 0.36347460281085986, -0.06253650759447753, -0.048585917563913235, -0.043182244794519146, -0.022679346367615906, -0.3881723710085214, 0.10858434574884704, 0.038031504690831226, 0.03280271449984241, 0.19081303362928126, -0.5085193656012659}
};

static const float b3[16] = {0.5164436739980953, -0.0047403247340289684, -0.028019822721750104, 0.24124182247474055, 0.6242383001620532, -0.030568596487024438, -0.02643722003011221, 0.6864759272443403, -0.03524526310527603, -0.027129245558444228, -0.02626316657710175, -0.025351498913665203, 0.6789854354797161, -0.051314361653053434, -0.01699346094952187, 0.6925305301054236};

static const float w4[16][12] = {
    {-0.6632586790167604, -0.8141631967764735, -0.28185121155864296, -0.5833162262441288, -0.49621415758310605, -0.4024402602553161, -0.23692323765045312, -0.6381320179480782, -0.46661078419077334, 0.042820976877667276, -0.7006957599611563, -1.0961176306016396},
    {0.2560728406452912, 0.7941021921944872, 0.09618385982672592, -0.046674905000984236, -0.447371499360372, 0.07447713686065269, -0.06662517747620261, -0.4713752732458874, -0.07565983544441665, -0.0367330646686466, -0.2011252263022888, -0.7351510824279286},
    {-0.19395431566444363, 0.1918636141980483, 0.3977795589277827, 0.4917660756968529, -0.166899350582775, 0.05310069660235487, 0.08333621305166941, 0.0828161061447469, -0.38907559113201595, 0.5352843328332417, 0.03723681714164448, -0.2605192067061171},
    {-0.16591680476223153, -0.6812206001147318, -0.6939243767582768, -0.9981883366219844, -0.5342262780221431, -0.8953494500911304, -0.29332302395492293, 0.072677514779692, -0.5600512122518266, -0.400122440988121, -0.5956902378972697, 0.2102528480979556},
    {-0.9769538127505221, -0.2713071425082162, -0.6794731036886167, -0.310917408241573, -1.142488352943191, -1.3358318011259844, -1.2759457170151602, -0.8353880707028646, -1.0150916465092727, -0.736672609839041, 0.16487846312230797, -0.3368193432766937},
    {-0.8004630952911547, 0.06397117478370382, 0.13792906149927847, -0.05572286955102816, -0.8533210249960431, 0.37954350290102656, -0.12357934378282845, -0.16016231578810747, 0.3484018195084573, 0.2662266284979813, -0.19632562617122157, 0.33074122810988155},
    {0.11801817936634529, 0.05873542807314879, 0.04417083799335402, -0.0008092628733603399, 0.049124706175825365, 0.3937697380051103, 0.3291351259675, 0.34156240717682307, 0.30981268840508713, -0.31609771534402475, -0.2659729522578166, -0.021627999606260967},
    {-0.6142269336186448, -1.2267124453752454, -1.0616452952168112, -0.17701455610971742, -0.8953709558544125, -0.8115297429696869, -0.6075775083839542, -1.093525276513844, -0.7691777991844655, -0.9129260569890615, -0.9851598773461554, -0.9011947990481123},
    {0.09606052816813455, -0.03758003116043108, 0.08774277946757994, -0.07128248300234646, 0.28848126560859033, -0.13812013307196125, -0.010511718208346092, 0.2614178315065971, 0.1260895429586838, 0.664450049122875, -0.05853789732960272, 0.0598373106394217},
    {-0.2057434151513056, -0.6066302148482002, -0.318297987038713, 0.19690454879962999, 0.14877551176545045, -0.37623600538169294, -0.046707784310864, 0.08718949589805426, 0.06660297789089374, -0.03558645636714304, -0.026463056297030333, 0.728105233171156},
    {-0.25690149681016494, 0.3815437961264471, -0.40818595446510997, 0.05859036637778854, -0.16191517141472356, -0.6646265626451364, 0.4015658580641989, -0.10595042242029112, 0.04956011995454171, 0.07609566325719783, -0.7853210145313944, -0.4080924037447717},
    {0.24803433003049025, 0.2987604633736102, 0.03376887702981413, 0.38823066052254207, -0.011667641563591504, 0.0386543511135234, 0.49984092072707953, -0.0024651216913805446, -0.024983222068573414, -0.19583710704751942, -0.08182808922994508, -0.3884953540416126},
    {-0.5168970853384599, -0.9494217919710252, -0.8683539741223221, -1.2943652477061294, -0.7032514880456023, -0.2772222720085937, -0.9164635567214734, -0.6036615191251845, -1.028661193245763, -1.56627901609873, -0.9982313497976836, -0.8088273725946753},
    {-0.5353465105294094, 0.03212309391657127, 1.2560499716503823, 0.3205245983655825, -0.178608981784039, -0.7834085155189191, 0.021397673999033303, -0.35087878098079445, 0.20305925207416053, 0.08232408632674408, 0.033420889326147764, 0.10425051331032584},
    {0.3022877794507737, -0.2298394965202063, -0.02330930813807336, -0.3522485603254776, -0.04738854064991807, -0.11621174690550182, 0.4077650717716586, -0.20119924119975807, 0.03473136759358882, -0.06576254687551963, 0.33796150906816, 0.242313195987298},
    {-1.1483367061925258, -0.3183541135822788, -0.6761048031943223, -1.3035250403964276, -0.4091105804155076, -0.8272536068379424, -0.7246030145828328, -0.709659581574638, -0.396725568125774, -0.49334192949703404, -1.1396482063416737, -0.7574067903094219}
};

static const float b4[12] = {-0.2082777231014071, -0.34532350894749203, -0.3221241459762726, -0.1933573199617095, -0.16937222564318516, -0.29388369445079177, -0.370822222656038, -0.4336620228521483, -0.3296543485064572, -0.2496931102621747, -0.20766234215626506, -0.32606098954500995};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
