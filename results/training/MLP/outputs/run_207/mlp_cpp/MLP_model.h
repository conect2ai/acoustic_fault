#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.59791449490885, -1.2806974383701664, 2.937531364651218, -1.5365480211266067, 3.36076813742163, -0.35835833835374065, -1.0451302569229846, 3.46207847167823, -1.7441810859586233, -0.33985324418813656, -0.19923287888021002, -0.9217040174351188, 3.288168846867044, -0.5717740437875983, 1.336654173482384, 0.18091859220708803, -0.36030651726777513, -0.07251189789606205, -0.09498357800293233, -0.4471099932595136, -0.8211924568039279, 2.2791731730358262, 3.2802797654027223, 3.0917464527397933, -0.8468798949847294, -2.1408053724859237, 3.0043638859125354, 0.10493104342312318, -0.39151033658846984, 3.047883948239456, -0.3523771471485564, -1.644337368064586},
    {0.38738011106847703, -1.5923007615940823, 2.8621744509925726, -2.1691751389531, 3.4822417750374064, -1.2224444674940835, -0.6893478477467965, 3.3328932026218956, -3.024228291395626, -0.507455705716522, -0.9546885945655669, -1.2386118630576766, 3.4388418388835, -0.4368254843372838, 1.2782698096619038, -0.5559369172699697, -0.9626247271515451, -0.4458924483909032, -0.4591780161663364, -0.9300003633931978, -0.5633637222161418, 1.2592218836775588, 2.757487400433412, 2.84444622253227, -1.2933797970865952, -3.8911038472276256, 1.9153784290508435, -0.6114763250842725, -2.8541926758226484, 3.628050169828886, -0.9582384238996974, -2.6544816254313233},
    {1.2875330410319898, -1.534431516368613, 3.72993052588438, -2.147524802386335, 4.100776891690642, -1.4980906246876835, -1.222702104270414, 3.8862952674671303, -2.4414483951514727, -1.1301095422397804, -1.3966330703996293, -0.9315154353047124, 4.119193713171935, -0.5160811004399055, 1.1421787504094636, -1.0488702257738405, -1.3390784924154961, -0.8453957022609279, -0.8885556533475603, -1.3004518959698534, -1.1644363296317124, 3.021128535703575, 3.643173635634151, 3.676989706152613, -2.0755594164235043, -2.513890077771378, 2.6077602706301737, -1.1240314277753736, -1.16618121191844, 3.9184724701251317, -1.6283124864415301, -1.71644326718745},
    {-0.5538603155577868, -3.2175523279458536, 2.908685041375354, -3.4348503512141035, 3.4450741734538264, -3.0818020641891115, -3.0367363365945743, 3.3065030027863496, -3.58315539210207, -2.7288764361924835, -2.996516937794379, -2.918692736359379, 3.908607228111738, -2.607516586612007, -0.7572795899467575, -2.9888885266641827, -2.811853352120758, -2.6417076993004853, -2.893687317984605, -2.9236099727410845, -3.101918713479854, 1.1792366670546746, 2.8822114166287878, 2.947869292052957, -3.222737013483923, -3.793372607699432, 1.9244260304397103, -2.8427138619765553, -3.1393709851711256, 3.248694659462382, -2.899554850407039, -3.2890223833621524},
    {-0.7092605108362622, -3.304012823820052, 2.437650958780477, -3.933738745538465, 2.267867418243745, -3.515912292451315, -3.7272966141712223, 2.3925606435908398, -3.5759097677774316, -3.3425222009441935, -3.365820264931273, -3.0783835042942584, 2.523459543690283, -2.995454940212812, -1.6643001924968963, -3.7837831904209698, -3.3483628074116045, -2.857097407903949, -3.4899619366281986, -3.419184154471405, -4.006176408119871, 1.4920188541190416, 2.446614946782828, 2.4316905099510535, -3.850435166068627, -3.155886487079231, 1.6000888976650383, -3.508964028954666, -2.7640932743371214, 2.124387900127702, -3.7697870359049857, -4.001408148696853},
    {-0.5318788041265472, -3.4666225826181085, 2.135082133343698, -3.776188356280629, 1.4371214818702387, -3.3806168672604158, -3.7749030655459976, 1.485368048966777, -3.5401941321738395, -3.4893208810323837, -3.616088302145681, -2.983313792938157, 2.0401087323234575, -3.2556801742171078, -1.9290061170679698, -3.489124245584061, -3.465175553147876, -3.2085973735353863, -3.4582136491741893, -3.480309037337889, -3.7313203061186138, 1.2547200826579752, 1.5819990408726625, 1.8912761485882237, -3.7462055496785873, -2.267391694520058, 1.142324307429733, -3.5317278763483517, -2.5345141600821033, 1.2303189171147146, -3.618480475660906, -3.539704543379401},
    {-0.8455358396369098, -3.29978437379612, 1.8821273026831706, -3.8477867072015375, 0.9593651673619463, -3.3861603286265387, -3.5167897169980034, 1.13072412827361, -3.4745507263137188, -3.0573343927121326, -3.32193770594132, -2.811572598909089, 1.7287460137399147, -3.0557395625103703, -1.8693013258695477, -3.465371692620951, -3.628163609937873, -2.8120771296747313, -3.2278623356116705, -3.5138210759146085, -3.3302294722598815, 1.1146807495733402, 1.7514165360496208, 1.928466517006648, -3.5617220488012453, -2.7899855515957994, 0.9782570346152056, -3.4478807840424164, -2.8111304076623935, 1.1988777654385037, -3.68883012319154, -3.434752025622941},
    {-1.2378945024909336, -3.323369139016204, 2.046666603208393, -3.979989030091485, 1.297638013643235, -3.692830082588547, -3.42335599571694, 1.3756931539688397, -3.8717552144081764, -3.75262282436037, -3.8294990246905414, -3.235710674476872, 1.5357247263121045, -3.5014921171565843, -2.0852529490520895, -3.5777656014060417, -3.639404064372849, -3.3134726767532703, -3.6150155818975946, -3.578488555645089, -3.8532687831469676, 0.8357744485119588, 1.9883662800178126, 1.8222675052855544, -3.8801761727720825, -3.3187672950819564, 0.8677114719371838, -3.9027751708560703, -3.2113835467771463, 1.0097794029847882, -3.9449980501398705, -3.7725041604122858},
    {-1.3463040716681096, -3.4709491718992442, 1.3051463946476785, -3.9411143342704213, 1.7267024139473548, -3.5935810188449038, -3.6345919870859817, 1.5286954413140548, -4.322016904429645, -3.5602412438914466, -3.531972389026658, -3.524947018780382, 1.9661444532468384, -3.3505990121354, -1.737818948358676, -3.5281040782284805, -3.5432173983058055, -3.4096456231902845, -3.592186453939344, -3.7054661758333856, -3.685026201637401, 0.09399571686201043, 2.025845399970298, 1.7055756081454394, -3.8513050468182777, -3.7608932353578366, 0.7447000293036727, -3.6874075062873857, -3.3386587469054225, 1.7032943404186314, -3.6654218948780177, -3.991555981737675},
    {-1.1053539278947155, -3.7272122659683427, 1.8297765533263064, -3.7791274382012343, 2.56640198582268, -3.5524445462174223, -2.96500030061915, 2.7467612947988287, -4.450942677891297, -3.0018979815009414, -3.203034311772878, -2.905175044109529, 2.779269365222283, -2.8904194898892333, -1.0633028356004786, -3.5537342828455496, -3.0082776739508885, -3.0308926432791106, -3.252475481032116, -3.603034944164322, -3.244380286836106, 0.3158807383640026, 2.1581044566287013, 1.8937219162173813, -3.77344453338188, -4.339028192750869, 1.298474340285861, -3.504879842242274, -3.8731338787077347, 2.741415193926163, -3.2237854813142635, -3.8657936630720116},
    {-1.7015613870935475, -3.33812579783309, 0.9164277280122828, -3.664663241755397, 2.5383529790828567, -3.0805062382285286, -2.7529932245912927, 1.776479369706569, -3.909203989543238, -3.1799775092005014, -2.9792060273170886, -3.1843524131976926, 1.906911245784701, -2.7653112647839238, -1.1854974650998258, -3.166612484406436, -3.403416608097461, -2.773484761087433, -3.0559436251864, -3.013430451379049, -3.0113265237105047, -0.6350613849582305, 0.6808837664416377, 1.0796240298756885, -3.5015887841070628, -4.412615908451155, 0.4514678334173616, -3.3493140957829577, -4.177807363477174, 2.3791549936271563, -3.293421957082915, -3.9334123095988707},
    {-1.9935243837896621, -3.584502999293585, 0.7030468101128046, -3.5515894300733772, 1.8891128307139702, -3.4245208358550476, -3.17605287931339, 1.3182603879385555, -4.2467400287883725, -3.473390297841064, -3.426039866874859, -2.999061274579678, 1.590104198704626, -3.20762754986854, -1.9054032374662333, -3.5647571084527936, -3.2294387801511077, -2.9837879254841453, -3.4713948595942177, -3.4384293320592683, -3.4632228819743767, -0.3365560430535132, 0.6929325815583018, 0.6644685372816919, -3.5018613729680332, -4.057232387630917, 0.5046969490708451, -3.066316785748503, -3.946903621970541, 1.7773023435393596, -3.351231732273324, -3.7171066224278335},
    {-1.5033196473818347, -3.2371291738908274, 1.0617590679965294, -3.6418643102430637, 2.457637791770106, -3.2054405291318497, -2.9740936353280754, 1.489469684098757, -3.7941997125900744, -3.5296014282811563, -3.3578719000480506, -2.9180798667202033, 1.978216676639156, -2.815831847339, -2.059160633342129, -3.394583779746075, -3.1151906815811667, -3.224497999882045, -3.125424067658636, -3.503161080852901, -2.669768146125803, 0.12711417174265802, 1.3462340983935484, 1.0682133365300637, -3.540010757650565, -4.032353580816496, 0.5089430231301635, -3.3521187119158893, -3.518498377923988, 2.572658121092328, -3.332512175883698, -3.6228667315141094},
    {-1.2266513592180308, -3.3188950281094116, 1.0861467629652193, -3.6927231561561182, 2.5338716898691556, -3.5635974591488426, -2.9428426579436904, 1.1815982584185367, -4.3629608101972455, -3.555317754373725, -3.696132342633077, -2.64812296547476, 2.1349590941880527, -2.378065157547877, -1.6849947607966569, -3.313558632637254, -3.171672757486374, -2.9336911740596054, -3.0578014409904726, -3.433280856305829, -2.8576770220193923, 0.04806215634405971, 0.8921045837779639, 1.1171165612057712, -3.378613340831176, -4.190535341035406, 0.3160747910196093, -3.28412081510946, -3.9940949497734137, 2.286373068296744, -3.4681826397105833, -3.9764507176657933},
    {-1.159458589043778, -3.031648330781921, 2.1178030936476735, -3.57963647680495, 3.015996537933271, -3.1920352689163747, -2.770875091946602, 2.2063283305470427, -3.900503878405514, -3.2404618171241792, -3.4871537154386685, -2.7410560141063653, 2.791538665305663, -2.7270563673704817, -1.2723478539168753, -3.074575016643068, -3.070682705314464, -2.528019926091348, -2.925779523159391, -3.551194660040956, -2.883655611247265, 0.5435752064787653, 2.079985937809452, 1.7539245611067877, -3.39982759506389, -3.738757869925037, 0.9041750457615686, -2.9280854103570597, -3.599138774000669, 2.705966700375599, -3.3172803097916015, -3.6245748365103485},
    {-0.6198049219874507, -3.073890695304489, 2.4649261069934867, -3.654987680996682, 3.1187069355000023, -3.399519967763189, -2.7441971863959584, 2.6972294445813123, -4.052992221280842, -3.250130173628586, -3.425412694926128, -2.6421332044366435, 3.0126990174140027, -2.5000193616385364, -1.007271915684277, -3.1695653197391005, -3.1469513803665854, -2.8423783104245004, -2.8990697934989123, -3.338720314706741, -3.0939174602256463, 1.278754175480575, 2.8029757294773696, 2.618067119517133, -3.611676019064083, -3.882082071616745, 1.6923821824644993, -3.457571712842999, -3.6283773015965517, 2.9510889822801034, -3.3182394875911045, -3.486088088021108},
    {-0.37293402148048344, -2.8422538155383466, 3.1100945592673885, -3.474648610064853, 3.595678165782726, -3.187948372396406, -2.596619049599631, 3.0112022516898467, -4.011225143589404, -2.7837980826058977, -2.93340799485641, -2.5352090474249347, 3.9204219352570107, -2.40949225200107, -0.8852498773605654, -3.003613316576857, -2.8352250038256956, -2.490949354358379, -2.7175688210620605, -3.0209415993465445, -2.9912984296888308, 1.672658009061981, 3.212693646478351, 3.1135258696082384, -3.508016211077133, -3.4529510181788616, 2.01977320006272, -3.00446755716046, -3.249283831316579, 3.482609954048864, -3.1295505848206724, -3.369382909654665},
    {0.2277918094442497, -2.143517545343228, 3.7113723245865784, -2.7241118611472515, 4.271952868065788, -2.456510306894031, -1.780067655213527, 3.7899223650104603, -3.3077664880303197, -2.0622660513803166, -2.4142657226309296, -1.9680206819221915, 4.493835323575932, -1.4007659137778696, 0.014451231022512409, -2.1517021988603853, -2.266031553212649, -1.711537778543479, -2.0731527927089175, -2.398942120666199, -2.041299020394667, 2.7808577083623427, 3.824989683128264, 3.595584951323726, -2.5505971620804955, -3.350500658734759, 3.1395015313737584, -1.7422356538492898, -2.1225048321145965, 3.842936001226238, -2.311034138137524, -2.866128687524024},
    {0.18780924965866605, -1.9586043264645736, 3.7556719270135925, -2.8315514600066325, 4.0251007622168675, -2.5124779797825694, -2.015500752181007, 3.29370283732833, -3.243857571545061, -2.4198165582917444, -2.6665439689928863, -1.6523872776301136, 4.172669519764563, -1.5315469065778085, -0.560232747534563, -2.5170348669373275, -2.097246048972996, -2.1596758480272, -2.2802528210245163, -2.380155214811707, -2.4148201359714325, 2.604038468194375, 3.7184785775427054, 3.402068209199704, -2.7218883817828563, -2.85185393092732, 2.730958628310823, -2.250408535405136, -1.4882426821881762, 3.4606455028292307, -2.631129259116923, -2.557932132567651},
    {-0.14649780709862475, -2.582216254510708, 3.069017029291309, -3.202267331277034, 3.7838381805638517, -3.069818827637061, -2.4419953903815994, 2.966615173684703, -3.5531349090114253, -2.7507357613150516, -2.905254273935597, -2.097183732275552, 3.7697277484308374, -1.8940315467929014, -1.1409498918806555, -3.120088532113966, -2.9719654420661183, -2.688767917581914, -2.7247115342008654, -2.780470664590344, -2.8668801239066424, 2.0280378014616938, 3.470243553288796, 3.3509711972467917, -2.9575921906164884, -3.433662248718495, 2.396873469825567, -2.7093695114976972, -2.291925211484911, 3.856195444015792, -2.7873878133584826, -2.940334524124045},
    {-0.5638430651269001, -2.9034454787769257, 3.06470476879486, -3.4543056318765006, 3.8830400807583025, -3.012537959079216, -2.246897800788321, 3.2609280322510967, -4.1948654410991075, -2.7488038226418174, -2.821695713029426, -2.340161912833994, 3.6966354604551626, -1.9437290688832345, -1.0190644968424871, -3.0088397530027087, -3.1834321629115543, -2.73639429113039, -2.9649958866507347, -2.9624445370539902, -2.808207922665057, 1.4191872013334155, 3.303558504860521, 2.9399862399149104, -3.2862436252858456, -3.9788904237023623, 1.900990064942907, -2.7780525808304626, -3.654686477425933, 3.7119723665597584, -3.1923250972010613, -3.5591467148334655},
    {0.10755368852608717, -2.221416970142498, 3.7638093928096765, -2.91270393752259, 4.570393797528644, -2.23279586356479, -1.6982069464919405, 4.117146191218409, -3.5904290481726977, -2.1458901312728003, -2.2623783817334804, -1.7047319461917327, 4.286112085527406, -1.4493697155474612, 0.08764473767617645, -1.9188707662771347, -2.233009357028303, -1.534209126213876, -1.8177859412475605, -2.1735621399138783, -1.906704370387974, 2.692509942949767, 3.8670195868140627, 3.738701585779169, -2.7176458617433443, -3.794494816025789, 2.902354322280246, -1.9736574302180043, -2.5832139643104175, 4.245891795580299, -2.0749561186144643, -2.931932112958534},
    {0.4050184470532292, -1.9319915648253525, 4.053608826676941, -2.4128547393742514, 4.7532890142006785, -1.7652162278510837, -1.0999480908785735, 4.112759248320035, -3.0704205599977876, -1.4315703276531258, -1.458920186853037, -1.6702193222167645, 4.440865747484495, -0.8646370775627098, 0.8388947295855542, -1.3190483818518928, -1.0549219206524285, -0.7912252292246542, -1.0712771955515334, -1.7155643005173047, -1.0783894332718185, 2.552718360201906, 3.7563317971762817, 4.013863187737116, -2.072824514160621, -3.3942109326333774, 3.547472297667212, -1.3208253467100306, -2.121375765869172, 4.492196255455422, -1.1919716014457589, -2.5957285875317266},
    {-0.006907128087100909, -2.2276525589879292, 3.5249056424699137, -2.947585235297766, 4.2644461585990125, -2.155370330889432, -1.836432471757138, 3.719577683738747, -3.3431561460790755, -1.8836112914235976, -2.2832108930271624, -1.9614702013322505, 4.258389049028556, -1.4709989066108418, 0.2335890220157823, -2.156148773911343, -1.906179150885471, -1.716429664783456, -1.9649812633499286, -2.2211281826622593, -1.8312124166832184, 1.8947955704788872, 3.731459001591752, 3.710312718359213, -2.6270564715742326, -3.532881024038269, 3.03385971992655, -1.9312255455940075, -2.893227635783425, 4.341543721521656, -1.8822211419029025, -3.1614299202677243},
    {-0.3398596950654579, -2.7177761166756063, 3.0320862625484355, -2.946087183047588, 4.15148565788994, -2.654856973383904, -1.8454876976022885, 3.709935050502239, -3.776324350659738, -2.377098714251752, -2.4992548122084766, -2.256323699547143, 3.9379792562001144, -1.4833004526365274, -0.10933252776250317, -2.651308322682828, -2.364588777692566, -1.9176260602191684, -2.274701080740126, -2.6927023941078314, -1.9245557477132527, 1.2351236147695912, 3.022989369680347, 3.0834999430983876, -2.650553561254132, -3.8459051290746764, 2.0478470005261613, -2.0685574553565553, -3.5050985874401897, 3.986168132172112, -2.402606744291068, -3.2980084376793437},
    {-0.08172066406494535, -2.3139628372374204, 3.1675292495633185, -2.7518569084065114, 4.131482374458915, -2.296418821625984, -2.0263996877584884, 3.5682852243857357, -3.2566567575348984, -2.135486831313984, -2.500093826487749, -1.8907077713661802, 4.03672756066548, -1.5452855093468167, -0.3166490179792912, -2.0961472497728346, -1.897959741539955, -1.684716900546019, -2.2698302124802234, -2.3423223962327318, -2.0268559730827427, 1.9452372482343914, 3.581743550484549, 3.5641973602188397, -2.5503945736290032, -3.6515381383268104, 2.4862916000052744, -2.0603066020128473, -2.7941538751815713, 3.859905303712545, -2.422688181900972, -2.5643793127136543},
    {0.2502870710216945, -2.4056367231228766, 3.7684579061565366, -2.6337931024468815, 4.1164826598788, -2.232562649708736, -1.9415817981004255, 3.8662578713960682, -3.2392329254526993, -2.043549080108906, -2.1210145452465587, -1.9372890116660884, 4.424081771785747, -1.4112781039702726, -0.08605864841773378, -2.042276380684786, -2.287314147367739, -1.710221797866281, -2.06544372153365, -2.2972003927068556, -2.0402342530278683, 2.2026294140611586, 3.945791057280628, 3.672306589438739, -2.5305083749549495, -3.5981732218886164, 2.6936129073353787, -1.8692553471130768, -2.795639654917982, 4.21078692593143, -2.105478649342219, -2.717563202234633},
    {0.14521799499929203, -2.606569571981301, 3.798458251376503, -3.0882983875602084, 4.210485110399057, -2.5007196397145965, -2.0697636090532137, 3.967216575522967, -3.7640036112351027, -2.184451594835569, -2.497960832797349, -2.1093779501148635, 4.179562743988975, -1.6705082508001328, 0.22562791118356224, -2.0337016919862867, -2.168338741558119, -1.6709138111731525, -2.051597432134887, -2.3170369324027007, -2.232353964142373, 2.1486665490975803, 3.5463517777303237, 4.024182637769433, -2.710861189398296, -3.6914851005073634, 2.577051036763042, -2.279853464508934, -3.029607428364108, 4.298579226176373, -2.4795870892677803, -3.072713740026357},
    {0.048998517202891716, -2.202456367538647, 3.2448322515026966, -2.918203534552148, 4.303869759022839, -2.5023324346534337, -1.7138116115479076, 3.70409404166835, -3.360249151581127, -2.1174331499271757, -1.9114088706174936, -1.6881232129840948, 3.924395184420289, -1.4109759769014891, 0.22701462427534796, -2.0617354509732655, -2.155327204285675, -1.646087000079585, -1.9654138329019792, -2.071027096203193, -1.4774000806600784, 1.5943237408166215, 3.292999714253037, 3.46787406323891, -2.501044473446971, -3.8676011785172397, 2.1967931215224237, -1.8459856921651268, -3.2245085753935445, 4.207941534918265, -2.0472290432708817, -2.9524867146466134},
    {-0.12553709833203489, -2.6866182158070235, 3.186977685135424, -3.119884592888435, 4.040398495084763, -2.1115330905920704, -1.6590359906595882, 3.733517599410969, -3.5092862580595923, -2.1750393238778036, -2.1640175311858787, -1.8304261860798503, 4.179992618740487, -1.3896200630061861, 0.22827816344035534, -1.724808059244242, -1.9261361236314858, -1.6723904746371492, -1.851356435319101, -2.1350732891016824, -1.6356139835936807, 1.6028258286623198, 3.5321420758055804, 3.2590662876215286, -2.562686742210941, -4.3213164041726735, 2.2604921399652325, -1.8741900049396347, -3.3664025829158275, 3.7244037584917864, -1.998216203907551, -3.2687169817838573},
    {-0.026929009022638006, 1.187978834684619, 0.21973003893829773, 1.6573178633277763, -1.609675452421032, 0.8816673609047425, 0.7654462634335311, -0.7955966772359848, 1.2288690229089967, 1.0101838771228973, 0.7471918430487642, 1.009146997954056, -1.23933589489939, 0.9214163934933315, -0.5600276810919165, 0.8964389206675945, 1.2560877616843176, 0.3438173503929233, 0.7731661042442222, 0.7798748124638816, 1.0367122322651467, 1.1197349210981495, -0.3553734370542167, 0.5854905966705719, 1.618366291745279, 1.8919442427585926, 0.6644764639639502, 1.1475797940800163, 1.3459278552531264, -1.3567523580004697, 0.987617013320552, 1.6449183307808368},
    {-0.16373919938996492, -1.7812436234262077, 1.1626678304687248, -1.8045945585988936, 2.1585162504231694, -0.9950048988335655, -1.249676466643403, 1.6843737586050151, -2.5784057759237826, -0.19151910728309784, 0.035045822407128516, -1.6330002659116867, 1.8355680306892799, -1.2018147408657096, 0.557088436420131, -0.10646458715353568, -0.6746849186872241, 0.17628437053661375, -0.2366180246023999, -0.5644714693940477, -1.141617347568691, 0.176973525229681, 1.198040269670361, 1.5340102328828729, -1.200224868104202, -3.0361486056220173, 1.577903514609937, -0.6184801587404537, -2.037046244387743, 1.6614421704573856, -0.3784975727013438, -2.2257570157404225},
    {-2.2854548145069806, -1.5892596141485928, -0.7952396311154994, -1.3861773573465908, -2.3134350688007235, -1.9020753824295988, -2.5724425898218173, -2.838159787119058, -0.4517057450404516, -2.3300982407548894, -2.2738012337684523, -1.6431669481821163, -1.877278417250183, -2.4506624056390813, -3.232137593250828, -2.37740009066029, -2.3966442785587785, -2.1471831102715324, -2.547055871440353, -2.1068300672655984, -2.79769889552256, 0.4941092748420083, -1.2543701154466955, -0.9073776022876134, -2.2885669611253876, 0.4616617075596876, -0.5316670958008239, -1.9877787816169998, 0.39229059948917533, -3.31841940637598, -2.1703063515490286, -1.154850790566276},
    {-3.085755422853031, -3.073506192376022, -1.978219283773669, -2.073472905880594, -2.0338703473923045, -2.189633403307793, -3.159752418467295, -2.292566615667998, -1.7351076690781508, -2.630222637407097, -2.4957698045679617, -2.577146015993306, -2.2111995547755794, -2.9319901954198104, -2.8524670343787992, -2.504191292107908, -2.27006590483845, -2.5137271272771238, -2.647816690587201, -1.9850800142307823, -2.7097323966158906, -1.625701049944486, -1.7544159463148, -1.5461558704760288, -2.512700244924203, -1.9585478594469095, -1.2237862655217067, -2.490667242803833, -1.7754432145629964, -2.379807552657808, -2.529132608056446, -2.843242861998567},
    {-2.8660014401970906, -2.809193654898253, -0.5662122964032246, -2.770387418617735, -0.36981065501928423, -2.550350602849804, -2.9174652886857095, -1.2727887114113745, -2.5192715672621593, -2.664773949119768, -2.508036454310051, -2.8184982616660044, -0.5723677038572929, -2.5562846295114405, -2.502451850371839, -2.9435569506927672, -2.958797573164596, -2.586640273372744, -2.836581283548731, -2.41184831638887, -2.9483919588096907, -0.023000040463573453, -0.5957039554097733, -0.7864330694093817, -2.9259197420067977, -2.6797276425079533, -0.22275802561978056, -3.0455941315896013, -1.999943601878712, -1.2707572221040369, -2.798226150948776, -2.987797510036237},
    {-2.414906639944963, -2.594349659873199, -0.826138310235412, -2.530835033415754, -0.9047877526366315, -2.3621594631642933, -2.7946282476377657, -1.1684491909250727, -2.1873939378761187, -2.804239642508958, -2.035188689235217, -2.9761098005692395, -0.5682706462762417, -2.6643201867240442, -2.184426001064161, -2.279971558873907, -2.4934450484359822, -2.4499052438709, -2.8394415511540627, -2.268707457118277, -2.57291535606791, -0.05723557760583863, -0.72340594860739, -0.774530400145614, -2.5235591634204484, -1.714332994210164, -0.1256377433540902, -2.4809013146972885, -1.3848165747089927, -1.0538837824713676, -2.554309636097669, -2.5283239459327564},
    {-2.4698973333157133, -2.674946466826983, -0.5495683738005698, -2.355434748707259, -0.5721967860458486, -2.258371908323117, -2.7482054148797763, -1.1722429785581538, -2.147785424909954, -2.2985534849126408, -2.3121938024896704, -2.5290650218943624, -0.5705078631299482, -2.949635333507601, -2.394728432209238, -2.2618462200462384, -2.441651775140673, -2.3406459003612308, -2.91796575479809, -2.372843517176912, -2.629526470289392, -0.061346333410664644, -0.948615730271442, -0.9904895665667551, -2.237712005496899, -1.9014554616426367, 0.1015311024444236, -2.467121788902899, -1.4942042615933135, -0.9030735065142166, -2.518414612942259, -2.413257193014807},
    {-2.6471589595689773, -2.7635591413020704, -0.5774947380752208, -2.390779200719242, -0.20701864505385145, -2.2300375212814916, -2.748695552815234, -1.1826170608122866, -2.513240857810736, -2.265890234822575, -2.191897894357637, -2.5197329112111135, -0.16122185504706385, -2.45756296534136, -2.30163789465579, -1.9318355920381303, -2.2566047908572076, -2.121483314356786, -2.182718897610262, -2.3123350216205734, -2.5797116926764923, -0.3144762381315376, -0.9429883394058537, -0.5173706182705089, -2.295830456349806, -2.03662545947992, -0.4025539727196575, -2.391503353779497, -1.382024804738896, -1.049070746843318, -2.3736241140396084, -2.759113285040594},
    {-2.9667963981027703, -3.2602912622724274, -1.1766164334938976, -2.2404196657514803, -0.9019233754020065, -2.3959630202001416, -3.1320701550611654, -1.2177211574975926, -2.460449141815617, -2.606328978651362, -2.317014883925428, -2.6020117196711166, -0.6262993310487327, -2.7229027037854188, -2.499658764714707, -2.2821000843372157, -2.7090698930725834, -2.577898129509304, -2.7731830263006647, -2.2773968492054575, -3.0319097427630526, -0.19405532010845378, -0.5582981787762269, -0.9430496740138918, -2.7520359206039915, -2.3429511794541904, 0.2022243044690714, -3.0887607381503033, -1.54753857436965, -1.5832296003524788, -2.447658754736953, -2.8122489813077496},
    {-2.4560985810383413, -2.830025931953257, -0.31843459437737864, -2.617668774079583, -0.5600196755034564, -2.808005284535077, -2.9680990687953437, -0.7742611899705389, -2.3934871476996378, -2.8482301683410984, -2.611680024334352, -2.1972874150631228, -0.009028732807414057, -2.3810422501742026, -2.7084938698523535, -2.725519254573782, -2.756002792909839, -2.635430022127482, -2.5702660705740836, -2.5694338093530664, -3.0543084279461654, 0.6661309958211993, -0.090828953156529, -0.012009457385065418, -2.680689329618958, -1.7868201015596787, 0.08625119514977209, -2.800585866711154, -1.1925453608632988, -1.4688987814305967, -2.6407055785848703, -2.510527444344644},
    {-2.8774512002444896, -2.184299101008213, -1.1711695923258891, -2.2241808432595893, -1.447879781676053, -2.033109952306429, -2.490221677869096, -1.9487613584253929, -1.7547384246945081, -2.4549626170462613, -2.501669486955471, -1.6773286837155683, -1.3065153522811015, -2.399600607820002, -2.850269769832021, -2.3759405208109374, -2.568272477769263, -2.438771021126494, -2.581231351214647, -2.336392998532889, -2.4377679043707627, -0.05209539378109774, -1.569296056318374, -1.511948594552224, -2.4889688674013533, -1.5798044609170143, -1.1640715850756214, -2.0329070734969914, -1.4273947122441377, -1.93821399893801, -2.4718243060094913, -2.1297898071383354},
    {-2.90408287427603, -2.926459251432759, -1.2115022903590231, -2.80657913046025, -1.2518077066468545, -2.6288033575408765, -2.936799911861393, -1.8639346463831887, -2.3935312857000195, -2.7848236674138507, -2.677212668205325, -2.6338423347760123, -1.3981591168225738, -3.0314835067723895, -3.3481582273848822, -2.6152722704821882, -2.725239387103206, -2.6421038122135787, -3.046114379925717, -2.9857870022892063, -3.000730540933855, -0.012631732098452166, -0.9596678706906504, -1.0043703553953935, -2.6610791803997675, -2.127021088252751, -0.160129195633856, -2.7102905049866863, -1.4203867013288323, -1.9278056351657906, -2.8955818398566184, -3.0453430456692088},
    {-3.2846722101401182, -3.2230229233135512, -1.3829817680216725, -3.0145007330810727, -1.3001351541052677, -3.01821223171202, -3.6480569660624234, -2.099979739423293, -2.5716874299794292, -3.3531677634080523, -3.169527763519198, -2.7400244930223563, -0.833930910424881, -3.204843299435142, -3.3414101639517715, -2.925909392268272, -2.9905102103404277, -3.174789261618253, -3.2179983128827407, -2.9190205904210753, -3.3911031324059104, -0.028777819577880684, -1.052622608792865, -0.8313860604741099, -3.0284826348010614, -2.2034726372530926, -0.42462382225333445, -3.1261414515115655, -1.8111933236271576, -1.651823718549961, -2.9586372632073434, -3.2237040768310643},
    {-2.8503817013767554, -2.8112161887877423, -1.1522105724835987, -2.7674534729333238, -1.5632775389606026, -2.7145894422798387, -3.5225177421712557, -2.2681515333491604, -2.4059180175335504, -3.127287401935911, -2.942714888011755, -2.554583612898648, -1.4588551030714407, -2.9149535290358157, -3.4906744954416675, -3.0578513346567613, -2.899530874963131, -2.9545520293269267, -3.077859029565212, -2.9315750241852405, -3.26758065997132, -0.6678762521326297, -1.1092838625183514, -1.0205050701222256, -3.0341660561667445, -2.142054828255937, -0.6344583800122491, -3.206944604737686, -1.8364098024006152, -2.2949997916295333, -2.6373465878763667, -2.7268241555418014},
    {-2.8626331256091753, -2.662461058710724, -0.1866511113965011, -2.6537195132060183, -1.4063498840186481, -2.8681842079487074, -2.722515210298392, -1.429209324124141, -1.9683998253134276, -2.9243470657036603, -2.9444838015544987, -2.66704959602183, -0.720375722990348, -2.651495834275713, -3.202482032418996, -2.792846536614128, -3.1248257925207747, -3.0407723066714394, -3.0912024607019606, -2.8244249104003885, -3.104741261946301, 0.42882676793776453, -0.3363558312327036, -0.06368759009986587, -2.8592267089826966, -1.2685817642730406, -0.2080036977185689, -2.8560142108768436, -0.8633253091273478, -2.1948121255245803, -3.0203972886713086, -2.8329549497616453},
    {-2.95969562343983, -2.8461859565668846, -0.6733107904715703, -2.2100895109522436, -1.8944584647024534, -2.600575703930343, -3.215038525772992, -1.6861182823157614, -1.791673856263184, -2.4589860900564515, -2.6149464100122644, -3.0730287034232546, -1.3503785871093816, -3.0965061184677785, -2.676718557062602, -2.1101418242527497, -2.432416195616629, -2.792238101607911, -2.7302004779458535, -2.274322023083895, -3.073334990010197, 0.1811480069798225, -0.8263558998870416, -0.5771758716994609, -2.3262813007506873, -1.2998966532388512, -0.30248961753766523, -2.3217590934393866, -0.639134956834879, -2.4892974947713906, -2.393275611354368, -2.3107109930735956},
    {-3.052831082404999, -2.7570090136280774, -0.860217150474677, -2.550640173372075, -0.9434462906444956, -2.562474925182245, -2.816934389844588, -1.6185314872429333, -2.113956630991604, -2.789038426777433, -2.422199007793254, -2.669575316414847, -1.0163245031884531, -3.096614314464915, -3.022896809391522, -2.61735433928489, -2.5672542681276775, -2.8254044437790666, -2.842012177522705, -2.8038636378605637, -2.9908950031373296, -0.23985132497175415, -0.40608487077281213, -0.9965630395509711, -2.6592071668366253, -2.0257662399684033, -0.5769829259884407, -2.5991624080397058, -1.2653646938247916, -2.086869493347732, -2.5630827957157516, -2.638490747053937},
    {-2.576043527143025, -2.225422051883916, 0.33620982905323, -1.6044637779436743, -0.3586319064961722, -1.8582732289284567, -2.2926202685936694, -0.38805323257898783, -2.1059833252782094, -1.7130746311341793, -1.8669545224273452, -2.323239720645593, -0.12954911002262887, -2.638742742998306, -1.4851993286406784, -1.8405119280544813, -1.9344933991799456, -1.9002224462564954, -1.5880198184674381, -2.1253427700218537, -2.2142381040277423, 0.20433457732148352, 0.5443858032870246, 0.6293018193117105, -2.163037468055014, -1.7872975671673488, 0.7960700155334278, -1.9468251138854145, -0.7601393867993335, -0.9652784554671267, -1.856801495218835, -2.000385097753593},
    {-3.2635017717838903, -2.7879823627482954, -1.2995523839274332, -2.0538338877454767, -1.9780074178004945, -2.3351283785699772, -2.9575376769129416, -2.6818317480690883, -1.7859086476298025, -2.8219417535897673, -2.4609680606690247, -2.6845678558036403, -1.5678465128224144, -3.1235137866445313, -2.9423024278646266, -2.4980466716345497, -2.6790131882237502, -2.318877592664576, -2.5207220752796418, -2.3318103780241404, -2.998190639477182, -0.2565363040897426, -1.1880573427888044, -1.3257954891234984, -2.3795578347209747, -1.1251165803905026, -0.32910198232828164, -2.6689449808821473, -0.3101368202197163, -3.1483405984441686, -2.549671253361069, -2.573344724257078},
    {-3.5294450025318267, -3.008852117883894, -1.2777974702948136, -2.8033055583595146, -1.966811488309613, -2.588197434169962, -3.563083248146016, -2.694039975565389, -2.3094121454072964, -3.22850927400582, -3.164780054725753, -3.1523782882497375, -1.6925335574250275, -3.193532998426835, -3.562871328922128, -3.2195403246266716, -3.2348226923732395, -2.986720594670627, -3.2912947098954906, -2.9752701287867214, -3.6068711608623656, -0.0639385245796635, -1.083102271184104, -1.2027416452354982, -2.873455588699945, -1.499380348652669, -0.559762791207026, -3.2753816360327686, -1.1850513700459038, -2.6413939551880694, -3.0489218676173473, -3.1151011408112605},
    {-3.5055888250142693, -3.7744525081266755, -1.4998665704520753, -3.2132684837029326, -2.252524428555796, -3.1840975608901063, -4.115341782846471, -2.695216890410066, -2.794430171572117, -3.657280386455207, -3.467983324546817, -3.4431508165469316, -1.8596640367166766, -3.480983392301786, -3.3629943710435444, -3.499886710122652, -3.5411573549400432, -3.33628332269495, -3.6952233808533244, -3.6344757373983514, -3.776317617037693, -0.9961230035543316, -1.3514036887810235, -1.673349144852593, -3.3995343446455055, -2.5059403603863952, -0.9225348538738362, -3.470201968834327, -2.1023457413461117, -2.9573392255340294, -3.2443450532112643, -3.8011191421236497},
    {-2.1946433419354987, -2.7289533347482946, 1.090274652692308, -2.306589700484186, 0.08364152678503715, -2.4686986657232364, -3.156146831018567, 0.730598037909794, -1.4723061181907737, -2.143125617650152, -2.1219562620639456, -2.8031127236277076, 0.8403124568107185, -2.869296471052337, -2.5951013096330486, -2.38067096950267, -2.4528210409850617, -2.425237667699844, -2.375946930791801, -2.3588631079691997, -3.0841812217698292, 1.849907043343723, 1.6359170813616293, 1.6342800970229332, -2.544853751169569, -0.8883979923864724, 1.8319760533981917, -2.0922776995791246, -0.11107330654105023, -0.9687164370004208, -2.343728009429891, -2.333017602324864},
    {-2.1302095097424165, -1.8518322602600368, 1.8004834983110645, -1.0435330272999679, -0.9277473584187814, -1.2089249779109659, -2.650067618971067, 0.14720738724618151, 0.1684836894286296, -1.4030078458831303, -1.502414145879782, -1.74158559102033, 0.0782135517531405, -2.5747060912626587, -2.065787120923456, -1.6924396201538021, -1.2513960183162498, -1.681115719835256, -1.758817749263639, -1.6557925110170149, -2.6597576012725113, 2.3849246058408617, 1.671151863828006, 1.688107363626897, -1.070442858731317, 1.5978741543532071, 1.9813939744815234, -1.3991907507133952, 1.5631327167873117, -2.3303317811690567, -1.7475314192591023, -0.8086102937250894},
    {-3.340466938102725, -2.7584187496247523, 0.2836757219146801, -2.0715264517013217, -2.6928433640665945, -2.567335317294128, -3.318562712803656, -2.161628421374936, -0.9767456189504278, -2.594803683509219, -2.771565252782986, -2.515317176336619, -1.6840963816983734, -3.4037649591028867, -3.5781693035984774, -2.805315585804181, -2.555751563706252, -2.9099949352847427, -2.912868371632055, -3.2091339696699035, -3.4336887226111372, 1.1289405814278748, -0.22338619389888953, -0.19061520466764012, -2.164130018507171, 0.9084455543438444, 0.8346626441260698, -2.7664673856125925, 0.7232814104504387, -3.3825878468913935, -2.5737275758465863, -1.8164497445190542},
    {-3.4897571235634977, -3.183885611329038, -0.4844109764128953, -2.9980776040038455, -1.7447432202225401, -3.3263198016268154, -3.595333673379933, -2.5178518931182956, -2.270633501754641, -3.07668051573739, -3.212553508441752, -3.3085294574846205, -1.2513945364860322, -3.592728298902998, -3.358191923160539, -3.0987358329963697, -3.1561458987049895, -3.1681296775789876, -3.1944207826197673, -3.2137616536414466, -3.5683531530820294, -0.16625537059230916, -0.9595947344259086, -0.8613467010899044, -2.836460585148491, -1.2290086088030807, -0.6577723245573129, -3.2526409816515978, -0.991866708771772, -3.0340726727687697, -3.1614426883952698, -2.7427735637183988},
    {-3.148550798470479, -1.9830116985690067, -0.21253196271654717, -1.4976796560858134, -2.9481431683476202, -1.915712470559654, -3.2312629716859558, -2.000828846273071, -0.5861291198624791, -2.2992574894930473, -1.9698189822819487, -2.724851769095574, -2.3440608422667197, -3.1630238238621926, -3.321512596032122, -2.600986853934812, -2.1891086188977695, -2.496633580962628, -2.6433635233542736, -2.626058594880401, -2.738129981087383, 0.6926761753402418, -0.2757561362393038, -0.1325933043864914, -1.8123458809690725, 0.6332476226225935, 1.0544481499923244, -2.461785495800924, 0.8815643751159625, -3.772663593166001, -2.0605904112501086, -1.3597242218305654},
    {-2.7233051449961048, -2.4014964786982875, 0.6474012075674576, -1.4710147712253654, -1.7106879983492815, -1.7600790973540918, -3.1953706501431274, -0.9730138365852202, -0.8048075346017922, -2.0853446919209184, -2.047077412298121, -2.2098083640849144, -0.9399344280357135, -2.4787917406868623, -3.178768453853906, -2.165693507619854, -2.117268765994979, -2.6503500518358334, -2.5671630469365123, -2.1827202169706967, -3.0032431091343317, 1.6319081133414626, 0.981107960862278, 0.6288622597065059, -1.5106375729562638, 0.388733973515715, 1.5207058669301976, -2.077556147095353, 0.47845822433834145, -2.9053773109299597, -1.9490215324926585, -1.4669281418290745},
    {-2.9939644638188003, -2.844444569036677, 0.4322817634946937, -1.725398182024284, -2.2399919933865173, -2.1377751543444097, -3.1808461716112904, -1.400880498561021, -1.5448290686453907, -2.7793558938029594, -1.9399030301281543, -2.6774152589648397, -1.0470083062511157, -2.9039033962219714, -3.2465690374981393, -2.751611150973978, -2.179675259892569, -2.7157473014694977, -2.9495723903667854, -2.7362387655166325, -2.8647244840466772, 0.6519086946441152, 0.4944965826189002, 0.6294982755637466, -1.9209732906850534, -0.2842511979595219, 1.0383209249120433, -2.13922981193478, -0.04193668511518156, -2.8777077156909874, -2.2622458653338877, -2.1079470980564916},
    {-2.9231723595193486, -2.5653650165652433, 0.5028315476863444, -1.7619400568270016, -2.0918627140349466, -2.1105581301517224, -3.385160546556312, -1.1869874166938503, -1.0412677803666925, -2.5035793281617873, -2.1449418810802885, -2.3488497296271773, -0.9003065500459608, -3.1977192844630076, -3.3475623447243286, -2.7041045048303975, -2.187435003653034, -2.710896850901332, -2.6844705194440466, -2.5152495659050675, -3.086711191112201, 1.3703641596341642, 0.39306953125280136, 0.5159587298147418, -1.8933688573796035, 0.6227954596959112, 1.1388172017175453, -2.3268975823510094, 0.4060088278378891, -3.0543894258025555, -2.4685588238476464, -1.6220712092093847},
    {-3.0108869353360643, -2.203039868429164, 1.1333886231680383, -1.2753023576251101, -2.09003837134967, -1.7740908716743586, -2.931509327268611, -0.42502535857828483, -0.7109017868220839, -2.0335766845775103, -1.7685415642979527, -2.434344861729798, -1.1073406939981865, -2.7750949444222854, -2.7725860314216955, -2.2438017968348105, -1.867421988491449, -2.433296828259951, -2.2972474578059834, -2.222757103955713, -2.603295622401445, 1.7015418968119094, 1.2726477934587028, 1.303684657586946, -1.6464082437441094, 0.6534517558080157, 1.5916577765391497, -1.6500583684354386, 0.6210246403539676, -2.7705022680991025, -1.8085494547929948, -0.9819566361700953},
    {-2.309755649285115, -1.4423469947977081, -2.4038090053597094, 0.6897438633085379, -0.39864891003077524, 1.283525516553913, -1.0011299192411407, 1.4735609502703069, 0.6742046414958454, 1.2579376900778998, 1.2800053528164113, -1.7734966300434951, -1.365049442098752, -1.841361751600331, 1.598938109919135, 1.2618169072810086, 1.5425991316343712, 1.4949590388551581, 1.237975453835563, 1.545258005540504, 0.6752740470395876, -1.876755507942087, 0.8991001740475971, 0.8944643540576261, 0.7886491314918562, -0.6544311078018662, 1.5986511038913676, 0.8622110965830604, -1.2215424281312925, 0.019381986325097102, 1.4093385954761337, -1.6582262845760047},
    {-1.787228518233027, -1.6309616714659105, -1.9796918736904245, 0.7679697260330883, 0.44229245609930606, 1.641578647538312, -1.139096554529121, 1.558119466466248, 1.262050616899042, 1.6894857282284619, 1.6829759869441965, -1.2419525511437242, -0.8792979986662319, -1.7098674723601792, 1.878265569907634, 1.6153760863901456, 1.6295808407043137, 1.9213338922384928, 1.593929958592844, 1.6044338545242143, 0.8259519054327786, -1.8376340934625812, 1.602025538150311, 1.6482927215480458, 1.132059156341837, 0.15250583456799355, 2.2619305551906916, 1.4231620275447483, -1.644930805384663, 0.6093884161652641, 1.7267894537423685, -0.8060170841497802},
    {-2.22781218054505, -2.0709812473331057, -2.6832634745286157, 1.7279365488847283, -0.5163124433762529, 2.1343834783738407, -1.1510586548657806, 1.365178745406408, 1.723876154013375, 2.2777589753445597, 2.2409279083984357, -2.036848574730253, -1.4831923226196333, -2.0164429403795037, 1.9294107516108547, 2.0729037183981975, 2.298917643278535, 2.2600014070458077, 2.194347739274988, 1.9332669449535393, 0.7560671733899959, -2.3624175661945648, 1.8570762651867887, 1.7084412818743757, 1.6954735309958264, -0.04417543393942414, 2.7193180847843177, 1.8674152201506233, -1.6738997064765706, -0.23238316477663556, 2.3029670281853107, -1.4078299213217909},
    {-2.173313371434798, -2.2818567738808277, -2.549105523510158, 1.325748429331415, 0.16882202196687193, 1.8622322620720557, -1.4176137746022157, 1.7042764829032127, 1.3261279251282865, 2.0924079750264295, 2.120437452895824, -2.5671548414155194, -1.5889664047864158, -2.65413229358337, 2.216933259525447, 1.6438127022127156, 2.214859272793201, 2.0498796915812107, 2.0849988207861605, 1.6849679468808347, 0.8854668356683292, -2.6694885646243516, 1.7279856171093662, 2.029918652591356, 1.7534586240242775, -0.6174592980654862, 2.5198603207333172, 1.8202796642309576, -2.2709853434842664, 0.07898365587671545, 2.1005044235258126, -1.975536548776999},
    {-2.025464033446643, -1.9119238532105054, -2.3359300147673467, 0.9932898242897239, -0.3426551913684628, 2.186954410475992, -1.162621337477678, 1.7274049715490218, 1.5732021333249995, 1.9794461860542822, 1.977162173121114, -2.8741336720399344, -1.3528733030673865, -2.208985101857891, 2.172998601482635, 1.6310932890624281, 2.058211993372631, 2.137275206065721, 1.9023449527773253, 1.6739978586690747, 1.1812338174406367, -2.7586197156479817, 1.6691697897268278, 1.640266564960054, 1.3854581277422378, -0.13036393018509054, 2.305100614897966, 1.526694010355072, -2.4280115325173592, 0.26596092260785575, 1.8543808355301308, -2.1133921808692797},
    {-2.1836248214900182, -1.8261672449477027, -2.469670918441451, 1.6059857723498847, -0.21338336165983146, 2.4500322197151125, -1.2748908306787115, 1.6732710894464478, 1.8487503769553093, 2.1680601927734955, 2.4123931092919033, -2.5402268472872205, -1.002432729512262, -2.0733610066950514, 2.1809368192756677, 1.7915800213625743, 1.5992876478348517, 2.2018379601895166, 2.2737028720020755, 2.0639562762296597, 1.3785993744374119, -2.6189399406573535, 1.65386437734582, 2.05917884752229, 1.6485660851188457, 0.21175905412945395, 2.671862674450351, 2.169590210625933, -2.5110754257322796, 0.15846857990219154, 1.8228104248911676, -1.5663032470728324},
    {-2.370669674555262, -1.9310601149643019, -2.6489371674058133, 1.3916255603912993, -0.3564681666890832, 2.165042692698542, -1.295285138506142, 1.5866413308726064, 1.8473234386226247, 1.9347452546861725, 2.203436931852726, -2.69072151275681, -1.527408063074739, -2.394820705943868, 1.998462878735486, 1.7671832695215033, 1.9049979714072112, 1.9713488426188865, 2.0590197708370734, 1.9887261872892013, 1.0564843980269565, -3.0643160889617254, 1.4006897164755154, 1.9835127264998103, 1.9583811350889193, 0.24570731122477663, 2.70236693719023, 1.8694525401487334, -2.4263009559477857, 0.008456549495806938, 1.5849580886612067, -1.6203059632602097},
    {-2.1872264656230804, -1.8842641068033696, -2.92987327583354, 1.7330805327009648, -0.11531740594701571, 2.1874769369392926, -1.1393903615740624, 1.7907852468690653, 1.545722444001609, 1.9931013805513795, 2.25395149014459, -2.496141366417695, -1.3285416626432471, -2.4710309031805724, 2.1994053538662963, 2.0639189977049157, 2.2383304874928367, 2.33575189527035, 2.0438062252673843, 1.750996252154277, 1.4314394315943217, -3.1075854456298364, 1.5033852084857002, 1.9868583710348922, 2.0264342730277445, -0.426501351904452, 2.6581833373541297, 1.8494538257915607, -2.436220002424793, 0.10061397702350013, 1.7613601954711515, -1.8660390696895237},
    {-2.4561864146774535, -2.776235299010654, -3.1054950887975536, 1.950263509948253, -0.40682292967302347, 2.2735703065890744, -1.5800085189169988, 2.060305022709461, 1.3895395294908244, 2.0687066681191197, 2.145571863036279, -2.661687364943807, -1.4133957672858053, -2.406380979318396, 2.0836077487850027, 2.0245758538210414, 2.3786562166622804, 2.304509475747038, 1.9272964961973704, 2.223253092290078, 1.3983938726497078, -2.9633449162699845, 1.7616597341728024, 1.8336869324450467, 2.0102712658808883, -0.37985423370411464, 2.3136674173089267, 1.884476686862097, -2.954284107628015, 0.2756555059940587, 2.1266249629207814, -2.455047907019349},
    {-2.4647401344897326, -2.2923060733255176, -3.2293652370346035, 2.052468296656928, -0.23675236811209507, 2.375736903362617, -1.7426073359035255, 2.303634130240514, 1.6645998490708105, 2.208120925244705, 2.7062211042061204, -2.6454661917068303, -1.2966564759944965, -2.317292698479113, 2.033811214817632, 2.0998761389666463, 2.284309794329495, 2.6733632946566988, 2.194817248782254, 2.239246761268807, 1.3952291105165, -3.0837240860857627, 1.6437462692951494, 1.9721920818877325, 2.1298894168070177, 0.09130102197970218, 2.91595215641226, 2.034529241190735, -2.3242256923414457, 0.2653728698624673, 2.129923435590766, -2.1644879545821083},
    {-1.958902778862213, -1.6238531654702455, -2.5317361113570027, 1.7628902417954178, -0.04364763523776538, 2.264683478593541, -1.1827423750975783, 1.9059930739025686, 1.6604002562559736, 1.9037871278579317, 2.2452569483440676, -2.3458425810084256, -1.3003321793860882, -1.9974451374692506, 2.071192252721554, 2.108367319308437, 2.4772049472065607, 2.584220229404575, 2.0434654286431115, 2.322107278802858, 1.0860713993096618, -2.6815546168264155, 1.7631961626946238, 1.6952440514339753, 1.746390556703352, -0.05756367629190963, 2.6352281040403316, 2.1373482257093137, -1.8638149459094668, 0.17210968170513968, 2.0010098344409823, -1.3178978558072012},
    {-2.300757834685724, -2.000667466386668, -2.873459880666428, 1.842716641567331, -0.061163456273991564, 2.693341971234242, -1.2486121865040325, 2.092887197857091, 1.8913147705236906, 2.231256136828462, 2.31855549557998, -3.0243919608781007, -1.3194512029533012, -2.49966488646715, 2.1210405097590805, 2.2881285991919427, 2.625876303326837, 2.9681799883454727, 2.4770885684717565, 2.3864112361483962, 1.6198840731159883, -3.39684801119307, 1.8126380869517416, 1.9638654854095452, 2.1716355583997156, -0.0978444802313231, 2.719983599889367, 2.2623905110260356, -2.3194481800694424, 0.22134113059926125, 2.2935615132742155, -2.1277850638318307},
    {-2.672040697323348, -2.4133724726000088, -3.319262354221641, 2.03216064607956, -0.1527738250172805, 2.8015717983839243, -1.3588702318639667, 2.1344873915947535, 1.9509235440585893, 2.296158989291239, 2.5571947401857464, -3.023469623764104, -1.5765114790351609, -2.535830632904256, 2.3249473659676925, 2.5207835083294388, 2.649521423419241, 2.6604488927536445, 2.3790733979449206, 2.5047985107674338, 1.5750353796663041, -3.227666323158328, 1.8173549878349438, 1.6354747542239303, 2.262167202102348, -0.5235027968832213, 2.8860592785746633, 2.3860856893435423, -2.5573988851833285, 0.2735298843231877, 2.7279808900767386, -2.1871240416633437},
    {-2.3888466604788103, -2.204068537507331, -3.10322022567345, 1.8523570639348266, 0.09647057437716383, 2.5301538248068622, -1.4242629019109918, 2.142238966590132, 1.9949293014720224, 2.297228701406619, 2.7226967497579704, -2.3344394691805954, -1.4719111078848823, -2.101169760470824, 2.2482999848366454, 2.332543604635502, 2.4501764747925394, 2.7052154890051963, 2.424923131920891, 2.4512868609653453, 1.442471746433009, -3.084421164829185, 1.9873382260919032, 1.7013687229477112, 2.5476605677060635, -0.42755103228434616, 2.7303060760211535, 2.184141835752211, -1.9929502112840622, 0.16115900791101728, 2.402154072452454, -1.784707524082992},
    {-2.6945575098972574, -2.1466976726242684, -2.6855396583267526, 1.820153216638799, -0.7215810691525378, 2.0831876279571264, -1.3498159639770557, 2.099115882974298, 1.9001221513875843, 1.8902553623116223, 2.581092574854724, -2.5760016278492133, -1.7466695725838726, -2.316539723666296, 2.208722712918306, 1.9415175026355136, 2.3763362300546222, 2.5852855971051025, 2.3451944960487863, 2.628174915683528, 1.281177163709418, -2.9171502731797894, 1.673100421380729, 1.2237564719558014, 1.9974409194149056, -0.3669087594780747, 2.2523991205727727, 1.2988060084351185, -2.186568438914076, -0.2502602908836067, 2.2445231448109886, -1.9317768798461934},
    {-2.7323742782023817, -2.3635704585121147, -2.7549635721744945, 1.6440841738465777, -0.6239751699453793, 2.1477391958641583, -1.6268472763001665, 2.3090118070238823, 1.3542669798149323, 2.3876840714651104, 2.348579170036859, -2.9194767610902006, -1.5527184182475784, -2.375228810817261, 2.1520897659948317, 2.043461438347494, 2.4975684923088703, 2.092425788758507, 2.2765145975389713, 2.384724969459677, 0.8293179448027521, -2.7476394017358183, 1.9226037443227915, 1.535631997278761, 2.1076997528793373, 0.15860802421822706, 2.497739522769584, 1.7687281552196867, -2.4926020829220343, 0.06681304348085042, 2.420425315577623, -2.404274149127093},
    {-2.3764035164014756, -2.695537159728681, -2.4346392579567766, 2.0543701276741917, -0.08192097006455734, 2.4278851985451393, -1.5295478580446462, 2.7473108780166076, 1.5205716670569724, 2.633583602647058, 2.434958343081682, -3.030586464322397, -1.2498255643972969, -2.322875870195299, 2.414371700024882, 2.298837645429451, 2.7811932693611747, 2.3927229798055736, 2.195309989349047, 2.36835541972528, 1.2624821316117605, -3.0329357555816543, 2.1428197960901767, 2.052853594252183, 2.4701694593116192, -0.3948509200216235, 2.8054873893119145, 2.074212312386682, -2.5699198726572554, 0.7737352095214681, 2.6406201096115876, -2.2542726037633534},
    {-2.856036436954929, -2.3721941160243105, -2.7993974889545004, 2.041499115617757, -0.06050113792597276, 2.4791302375839988, -1.154536468150572, 2.1849733506784914, 1.794784842677618, 2.461142634863041, 2.6774906387287016, -2.6795335580000383, -1.5694094916162538, -2.606339954259796, 2.571908389367577, 2.4490056169775256, 3.037658856720597, 2.619095216740992, 2.5400119344906944, 2.4235716503394684, 1.4061663182015618, -3.0000018166461477, 2.070977575171449, 1.9743182254293519, 2.209220517310898, -0.10156721434558404, 2.779524296040732, 2.337477259745663, -1.942883858484611, 0.3506458163287751, 2.638711151838121, -1.7789384103204695},
    {-3.0157911148667824, -2.5121043016949467, -2.7291343522278715, 1.7267790750006635, -0.6839673267952877, 2.382840643472138, -1.415670011801951, 2.0888889712349243, 1.8318435561005408, 2.383736372961222, 2.5123816008415116, -2.71930940397996, -1.8671204640121866, -2.4982441074978277, 2.2898953452757915, 2.3308679175846496, 2.8750413787074627, 2.5461059000446253, 2.586670159943407, 2.349981890146216, 0.6386110227771035, -2.9376977552520214, 1.9244187243200772, 2.4179071421225498, 2.2747037987040692, 0.002865445181883992, 2.721902853789138, 2.144846359802699, -1.9006276014426071, -0.4362530311630253, 2.055970264478381, -1.597836023997625},
    {-2.7121113122592235, -2.4647833197237494, -2.927577275514014, 2.0993745440810123, -0.5452209551795344, 2.5778796244321014, -1.3758196522820743, 2.238047370139439, 1.9124092573742753, 2.5246203708621686, 2.8440791393372327, -2.827792748308781, -1.9450543160536409, -2.3443305969938097, 2.718874608057234, 2.5206638619566997, 2.7581661026546933, 2.479477142147064, 2.4409367483885487, 2.4156928564471936, 1.0978577436214225, -2.820306545026706, 1.8285602289442262, 2.377764161317663, 2.539245250222132, -0.06514502004499415, 2.6089727556615085, 2.7854106250767807, -2.2670233023988016, -0.07840907023925384, 2.586403533628235, -1.8675886759124922},
    {-2.712223264264728, -2.39833228465224, -2.909228959123202, 2.3398987379052536, 0.059988898254727197, 2.3036545615620154, -1.8316722223117416, 2.6382752702809196, 1.8662067940173768, 2.550707852496083, 2.562407416222373, -2.7640970141295313, -1.8066019495950778, -2.739468054603253, 2.668621686262556, 2.245405298448462, 2.5228403156850283, 2.804910940511848, 2.436982686187557, 2.433859985446748, 1.022730646935465, -3.2398539749104773, 1.9486286279348688, 2.416832727531942, 2.5816014823083075, -0.41494738930052466, 2.681881600722071, 2.301657674714245, -2.511175549061412, 0.2443062568834077, 2.6729951714884415, -1.930001036731882},
    {-2.4325636000555075, -2.6897889524130343, -2.7304739166250256, 2.1641436111656014, -0.19275841672248423, 2.6419519813830146, -1.6350164351489413, 2.8207444807197857, 2.1053602450919495, 2.5764437348019373, 2.7958208097580317, -2.905382700405792, -1.9615156357291044, -2.5223545074840454, 2.795419581547099, 3.0197025374704114, 3.1448537038227737, 2.9633264245901816, 2.7939985425560305, 2.771819773445745, 1.2388125063704105, -3.038166931038741, 2.3566187789866597, 2.5420377695526306, 2.7325046443968235, 0.2043899986705157, 3.002307850113542, 2.428931739390454, -2.415899757279228, 0.6805477351559116, 2.603644521809844, -1.380402809000696},
    {-3.1879617943302514, -2.6844502698670936, -3.218486512979427, 2.317816179955322, -0.941843537348463, 2.710338088486144, -1.4571230402764885, 2.4253951092132553, 2.069142874586478, 2.7886874345327626, 2.976564636830012, -3.1150936286796136, -2.408517773736275, -2.8701487883703147, 2.554510634909996, 3.139802406726173, 3.099241677484016, 2.84562622565866, 2.677657325314078, 2.79991280648983, 0.9964134616353618, -3.329952202845691, 1.9609924577917168, 2.074324561771613, 2.762359571615983, 0.09507009139408173, 2.532130105868265, 2.4335224345508246, -1.6512270220616168, -0.3029818241249089, 2.879458015873462, -1.9600594938217537},
    {-3.159354880409495, -2.458937863917393, -3.022343403624912, 1.9614004165572974, -0.6472307647310601, 2.660793442717909, -1.837979820661337, 2.3253209253918707, 1.7432546109219793, 2.7820081151791136, 2.8026621305537742, -3.1321143481445683, -2.418576048463998, -3.1969293854763206, 2.721004887735868, 2.8509392258528914, 2.9712109633234287, 3.0557544015319413, 2.6720650793880347, 2.7659371945292475, 0.8622567761724074, -3.262048485396505, 1.7513183514401038, 1.889212340667749, 2.4421030121670726, -0.34036577696323095, 2.8140229383078963, 2.337808948430616, -2.3987063458740314, 0.06026708719044998, 2.806996233331702, -2.6795980484837725},
    {-2.9369465920273705, -3.150486195996066, -3.1281003224548325, 1.7832917963694153, -0.0272281631907853, 2.823668583128943, -1.818898957339283, 2.5868559847365087, 1.632664465106272, 2.6238676464223145, 2.882895618193909, -3.389338955298047, -1.8825612933918459, -3.0772243126754546, 2.9787596153249267, 2.664674133511986, 2.8095913526897633, 2.974188053825673, 2.8082154349340422, 2.4531859118488493, 0.7659335946360497, -3.2879556363995843, 2.1231453095027075, 2.266906939886735, 2.515341088304727, -0.5943862615286625, 3.089242399956741, 2.624547329566057, -2.704352713621475, 0.34430124560194125, 2.8993463734041756, -2.652560615577048},
    {-3.1619539806137085, -2.9031147108247772, -3.287105055286084, 1.8257251483551673, -0.6693094516202962, 2.603513964384144, -2.0112947597060074, 2.507796283576103, 1.5113723988476842, 2.800098246840395, 2.850523617935471, -3.390288315861772, -2.0440333642110597, -3.2922609645742344, 2.9300032442277506, 2.9716385470849853, 2.9385377052556487, 2.8811904310906122, 3.023610904220453, 2.69738637956873, 1.1261051352099758, -3.4411829587247547, 2.0621630958837573, 2.373169552182593, 2.4656498548658408, -0.43045657256079234, 3.0716168106449686, 2.7536436994862417, -2.658627999538339, -0.15467524056566534, 2.852790281696717, -2.576417256542634},
    {-3.186214473713049, -2.866522523812325, -3.491363414369742, 2.299257449501849, -0.6918586482767669, 2.9317160304503833, -1.8372839276950832, 2.5585599640379035, 2.030202009750552, 2.94819005592843, 3.1151206424863918, -3.065662518591657, -2.019593169992059, -2.848446970406225, 2.968408689759389, 2.7409052926401802, 3.100184890055215, 2.874013822115075, 2.8241398932287325, 3.075052131291982, 1.0104089618517014, -3.358574839858705, 2.042127486175911, 2.3781131899293704, 2.6982650289521026, -0.30648142139092127, 3.0007244770120742, 2.5737746543789264, -2.074905130896013, 0.0178262455188887, 2.7567301135503155, -2.134818409004706},
    {-3.3390373536374356, -3.0038294310751885, -2.9480950711777174, 1.8185725394114776, -0.838904325638167, 2.2355739427643018, -1.8484107842789341, 2.622103559688956, 1.7116996896951784, 2.605171821040123, 3.1925359655913264, -3.10255064574493, -2.2354841268487697, -3.087806715262103, 2.8966343016475617, 2.6920272855328293, 2.6092390751809327, 2.6526371730623155, 2.7784050764116355, 2.293031963850482, 0.7923182863077141, -3.0376041167509333, 2.000919400604549, 2.269210536572092, 2.4482561943776924, -0.42615254529583185, 2.7771946459032844, 2.3219743822206493, -2.192654408103029, -0.0753681042043556, 2.4990195660821426, -2.4667568222790224},
    {-3.341281084545857, -2.9832746994482915, -3.18235110269564, 2.3063550486825743, -0.7203136517443458, 2.603645113218786, -2.2126334053592327, 2.3852312256219896, 1.6007362394480364, 2.6322988640824962, 2.890174709450095, -3.0326116997736206, -2.3900899738866563, -3.0809812761782487, 2.748751599323996, 2.5611400034247307, 2.764618525524552, 2.8529930669294408, 2.748955938740329, 2.3414212030651775, 0.7470821501644825, -3.1120367279852466, 2.143953076947636, 2.352590105232061, 2.6388528983293513, -0.349135638799762, 2.916368756617265, 2.3080199802367782, -2.2052203530236048, -0.2875000849204411, 2.619805711659148, -2.697031449789989},
    {-3.306972102114752, -2.9491596021164526, -3.1451525521665378, 1.8995458271135972, -0.7718344240871411, 2.680935558311606, -1.9467489785254062, 2.4278623034454623, 1.5372474826619835, 2.4814602804482444, 3.033006383260807, -3.346995519068341, -2.269776838059011, -3.1073123103626084, 2.756279787999574, 2.630796779280535, 3.026867101318737, 2.85481348754268, 2.859803084351285, 2.545795405019845, 0.9025117665318685, -3.2680617539370767, 1.7784308475993817, 2.6154175124602825, 2.6204946082583964, -0.4475157416340653, 2.7261857814218304, 2.4036978084121805, -2.282483453405849, 0.10471633201815614, 2.5464334908731416, -2.735489874720913},
    {-0.664114808841749, 1.0854813733761282, -0.4791636346636653, 1.323657675681714, -3.1103211622701736, 0.4196908260451013, 0.035267603705224755, -2.6368012140444557, 1.7483619439808473, 0.5388618738345275, 0.21930060949466615, 0.8734867694351707, -2.33756678659291, 0.37229477078614776, -1.718713167449552, -0.08549409896195775, 0.13299729069870406, -0.5330804858255961, 0.3853386186283051, 0.23789200903800087, 0.006225339201549568, 0.9934884895960081, -0.7970604994122192, -0.11920099616632125, 1.056678696502548, 2.50806043606125, 0.36766369719606234, 0.12560989957762525, 1.7770020094639623, -2.841051378450905, 0.5071920810097715, 2.0179866360906535},
    {-0.340277253409832, -0.7446979783976928, -0.1400919533826715, -0.007714448044782817, -0.12227153929690852, 0.019558635928888252, -0.6744390285775543, -0.48256046775600475, 0.1520575340317716, -0.3397657139598779, 0.41691690402744247, -0.29549992331068003, 0.25482986064927304, -1.057774131056208, -0.6820504319560236, 0.09371881565517036, -0.5419046765508531, 0.018360225729352038, -0.40211515594788755, 0.31954086070136806, -0.769557070232389, 0.10385456758270199, -0.6794529810601424, -0.43011670585996703, -0.2186325519198478, 0.32356559221707726, 0.547023883440916, -0.5839564413946007, 0.07584102888187687, -0.7702989567691817, -0.18971330118132568, -0.24976214784912076},
    {-1.698399559050341, -1.0428090638247776, -0.10276692334164259, -1.2650640346562887, -2.566253491361868, -2.0872889324152646, -2.0985177440067875, -1.8420863351156216, -0.23538710309948863, -2.2157711544001972, -1.9541136387863132, -0.7209314254566562, -1.735535424086758, -1.5725993664234346, -3.0870501462191715, -1.981768750988577, -2.3307840873732277, -2.560669399361787, -2.1738648674672696, -1.9640298427529674, -2.445974852273345, 0.688825275872648, -0.7559378463444776, -0.8532445298692363, -1.6997482101668304, 0.7073880246737607, -0.5794312102020595, -1.9834129295640157, 0.629407562018086, -2.88072311699503, -2.003605049927317, -0.5641567709935037},
    {-2.2681375532643138, -2.1957043626022354, -1.3037046594264252, -1.8259913884372843, -2.3725638993832727, -1.7733705879451773, -2.362896552673775, -1.9876064114618488, -0.7298784569775518, -2.0982726051755876, -1.884986349011909, -2.0411401908203133, -2.329208598796405, -1.9780016480462392, -2.454973820273233, -2.3409086802509833, -1.892103174528751, -2.153494894858946, -2.267692867132257, -1.7253615522712715, -2.6878613814428562, -0.7700065245477878, -1.3838816383885757, -0.9649495071257027, -1.7593910829023391, -0.5585742820442551, -0.6898002990059281, -2.0896142175526538, -0.8372009293144904, -2.8001405672598834, -2.1533114690310238, -2.109208438558944},
    {-2.160770516565794, -2.8480968936239734, -0.06491503636839431, -2.288368349159327, -0.8083346470145173, -2.0481182041432553, -3.0031439633023846, -0.39520689069139686, -1.5014397819020342, -2.3951141943897216, -2.105422702298504, -2.717779791649278, -0.38234192241882364, -2.5562478860523585, -2.051011374805658, -2.523267889777279, -2.232223429013493, -2.499813930866175, -2.323625778580419, -2.177656306387853, -2.6418791049291954, 0.28368766827001163, -0.1331889075572355, -0.1326506758282723, -2.152074727831422, -0.9677584787336074, 0.32663535579126624, -2.489946858310265, -1.455315896930435, -1.2159050233277935, -2.455900647568114, -2.368404660187069},
    {-1.8594769236338111, -1.9706871286844703, -0.18625633018249946, -1.950816978032281, -0.3254965890460944, -1.733554942001765, -2.2018768198505496, -0.6237389285872983, -1.6357205597563178, -2.2238003279662193, -1.819219883726157, -2.168937637350057, -0.44015456958722554, -2.1822970881890993, -1.4031864168636918, -1.5890205148509156, -1.687150933834307, -1.843182829885613, -1.9860736515487918, -1.5038335097216633, -2.2317948326663863, 0.2772867484302689, -0.2833448469768436, -0.3637049265075488, -2.0381218052511683, -0.891795133132923, 0.32438222749791373, -2.163297907585929, -0.7804386194809876, -0.7325093754343168, -1.9329307270297882, -1.8841193384626511},
    {-2.2352236313798035, -2.027056734303458, -0.5577899303117989, -1.6218319915055408, -0.8556635135079822, -1.944031572113389, -2.088246399424646, -1.0554185510718868, -1.3132613256289127, -1.7365006498001412, -1.782566683310344, -2.562131009797134, -0.6337982427890819, -2.3119260860974378, -2.026354540520945, -1.707076881628975, -1.889438524656455, -1.5692606715968571, -2.1679963844878056, -1.5989829771859485, -2.0058368068394645, 0.21370984736533052, -0.8238097406546886, -0.2596572845833116, -1.7011283736360747, -0.9408255600144554, 0.434114546596834, -2.114158547472806, -1.4296928268330116, -1.1494494900679426, -1.8718338609942275, -2.0364225103381055},
    {-2.2773596803971543, -2.0441534753966373, -0.3969802293328919, -1.1155449719333925, -0.3247807255213527, -1.3145739722497705, -1.7771062692716482, -0.94644112959405, -1.530877247259846, -1.702675525861904, -1.36388228410104, -1.5450330708763074, -0.0045764660521006514, -2.1243430011793776, -1.6801290460613552, -1.4000873597887988, -1.5203705103331118, -1.5722403500859605, -1.6003477554927572, -1.3930016416014552, -1.8390002044849336, 0.4084577911308641, -0.39817326351680854, 0.16868970475744555, -1.2420561518287878, -1.0496363741190438, 0.041144669649742484, -1.6786488124347134, -0.9484367527159324, -1.1820590315685218, -1.8084432944491022, -1.8150527761164346},
    {-2.3569238981943044, -2.5977343587610386, -0.7781322474468017, -1.9680888177793852, -1.2669080366677172, -1.570016285621756, -2.2797211751086683, -0.971877611019085, -1.7792332402957707, -1.9310550018793076, -1.3243798494898689, -2.1580507352211447, -0.4859309293330592, -2.1758096910297704, -1.6856925683587125, -1.6908750613577923, -1.9022602468928689, -2.0766337486628084, -1.7800580831590815, -2.087044647064831, -2.250910217110323, -0.22025741348690267, -0.3374591351392692, -0.5837923339566188, -1.5927903587727017, -1.1854529070332196, 0.3158663592904999, -2.5156228474112523, -1.2228187747005208, -1.4717640698272947, -1.718545146916205, -2.2386711795278704},
    {-2.070200625095082, -1.919629364511132, 0.466078176913505, -1.8923607951840955, -0.9507845763487953, -1.6401573218268346, -2.345019164254007, -0.5147470738847943, -1.5577359761465424, -2.0558186518067476, -2.0231114468246805, -1.1941152804343025, -0.4797992187466125, -1.2935417245419722, -1.833669144545735, -1.8059757450102643, -1.8881657674926111, -2.0587604629507843, -2.3953857560052585, -2.0258065587062504, -2.2183908757966533, 0.9266139219815405, 0.4373099619651456, 0.16605809211352932, -1.849889198520375, -0.4609839021766099, 0.6502444940407097, -1.8913275035242056, -0.041000591222283896, -1.4484326659800228, -1.5983687245058786, -1.4982733115618547},
    {-2.1121072225497604, -1.2570796948387906, -0.8514915378310378, -1.1836099164202396, -1.7310486349265626, -1.2442131926098166, -1.826073976569112, -1.4418613394411712, -0.4151155855456407, -1.8216089343842696, -1.3542262306826087, -0.5554651014319443, -1.2261003490986815, -1.4590105438004692, -2.0729012282164563, -1.4443972797697548, -1.5300801050226525, -1.3761962810000523, -1.7566615513261645, -1.4681490108665454, -1.6951785654122888, 0.5432327411794046, -0.920988028441361, -0.795101550669647, -1.4598143474852243, -0.021351016626884985, -0.6798710058405981, -1.0587675786942095, -0.31932253775948477, -1.76848906679841, -1.17832383096825, -0.923287956948345},
    {-2.3512307469286746, -1.917815299099146, -0.6834119230978342, -1.5427162647096568, -1.515912239972088, -1.741398407992671, -2.0471259523702128, -1.44549608353005, -0.944752677875921, -1.5503624164971082, -1.7170298368035168, -1.7141707209933186, -0.9000366223296868, -1.7479597193304195, -2.687545028343202, -1.8218719414246756, -1.8312597006500804, -2.0513572028757117, -1.9002182295391759, -1.8870034701819, -1.9288911399109328, 0.9505745745808262, -0.22150822717336258, -0.3147630910651067, -1.3666437625114256, -0.05740896794880017, -0.07016386240772875, -1.664193443545455, -0.18159456270732746, -1.8901291335249588, -1.8085275632071398, -1.5620425439414218},
    {-2.227854816795811, -1.7290680723308822, -0.5099873921075202, -1.0183564464225539, -1.1740953850412224, -1.633185528706024, -2.350003039734344, -1.650914340806678, -1.111737655029058, -1.7436894973134447, -1.9394715760789891, -1.6961482473643559, -1.249041152331952, -1.9040513169582807, -2.6720514556176416, -1.3104545429974541, -1.8299210582578478, -1.8214712636249804, -2.221039677401163, -1.8500247978648399, -1.6516181326729973, 0.519999450658233, -0.06385931606312575, 0.00598708601581885, -1.1380878322504866, -0.2014299051947911, 0.34164330707431245, -1.4775105704915337, -0.10227778809965038, -1.8442280582100956, -1.5105891773213689, -1.4366752073141094},
    {-2.1890758366625183, -1.4388384941439565, -0.4060211540456028, -1.0644540559356521, -1.5867484931924591, -1.7472221385794195, -2.27269633962658, -1.7124642111010182, -0.6387953679986218, -1.9284966352981208, -1.9437028956905884, -1.4432272783873712, -0.7085294367036262, -1.5636458579820098, -2.5570865394524485, -1.58184225810924, -1.6018036073764088, -1.3633470401647638, -1.6685007579965532, -1.7746334834188315, -1.8127904131076495, 0.4377901797908533, -0.6459465530006043, -0.37183514208845714, -1.5353126214455812, 0.2170518382014133, 0.23386032842360818, -1.6922078283588748, 0.13374955226781504, -2.2266238528006763, -1.5272143377331906, -0.8900501416783303},
    {-2.0749850273708437, -1.1218731689449317, 0.22916390409555, -1.8512843317365757, -1.9195354918976553, -2.011276420552356, -2.15668587197256, -1.1750078737202572, -0.6600903348764315, -2.208251321343175, -1.8863588803286784, -1.503476514275297, -0.7220435662288883, -2.112882129413575, -2.6487134834658264, -2.233804895335926, -1.9809829533859886, -2.0845597365279023, -2.2744798941320328, -2.153886865834595, -2.650439330916591, 1.0389667641250728, 0.07556416212229415, 0.36335070070061454, -1.6312154063430708, 0.9504744913207939, 0.543538388786481, -1.7939129444740025, 0.9397898327205891, -2.1735848857546376, -2.135733662076496, -0.7803153772844044},
    {-2.106547709821689, -1.651506038337215, -0.11629730217868746, -0.791676439694136, -2.108794134828762, -1.1636299836049677, -2.3466397595807313, -1.0709889944781463, -0.24617912341273304, -1.583165136097762, -1.01079932114242, -1.7456336763746516, -1.162324015141398, -2.409346591012809, -1.9081558525115967, -1.3728887656945201, -1.3348578260672972, -1.711124166894524, -1.7429535702744179, -1.3266902330839954, -2.3960388518108875, 0.5453733028332147, -0.014856577134968898, 0.1723629426305895, -1.3963873503828814, 0.6231221876414812, 0.6050312726860066, -0.7741708562901316, 0.6070290560128921, -2.4420964131127914, -1.2773294063178555, -1.206143855878721},
    {-2.4920791612437236, -1.7495687446938564, -0.37316873208132517, -1.617243588841157, -1.8715286187537399, -2.029049546473999, -2.3905632916851283, -1.5410128106049112, -0.8331220153105464, -1.8748175057101701, -2.215190480538014, -2.165403756933902, -1.3656320314806296, -2.6082065580987934, -2.506699759601846, -2.3056971370929507, -2.1396701882463143, -2.300648263229566, -2.5162272769523653, -2.196796054740143, -2.728318583432077, 0.31417483828630227, -0.482247837948806, -0.8274508333142845, -1.5944583108667465, 0.00668307794865381, 0.08537503700720994, -1.7826757666034763, 0.5817944183093902, -2.604288090425599, -1.9751840952773732, -1.7387625867242156},
    {-2.6776832798985253, -2.093707849645808, 0.39450871236636076, -0.6452874050358077, -1.962077056656407, -1.7280543373872637, -2.398819170529198, -1.1501732801199307, -0.5249870845724027, -1.330351585017049, -1.4260421880194383, -1.829230163851549, -1.181270842969889, -2.5699326762995764, -2.3159532542289627, -2.062808068137494, -1.2570793378403382, -2.0849504103089673, -1.8790907811993944, -1.9942523230924134, -2.6176792222371827, 0.8999133568957159, 0.08229046137349995, 0.3212881873825755, -1.54707499509119, 0.715650787577639, 0.8544964675726334, -1.9789159846987205, 0.8954056677827479, -2.6008645314044854, -1.5488225542638825, -0.7675491528707878},
    {-2.547791560959818, -1.8549052368373473, -0.3253465443545401, -1.0140872811657655, -2.529662809138903, -1.6378943560140922, -2.591203841219533, -1.8529773986039144, -0.3141482463728621, -1.9910781942111815, -1.6176982749806739, -1.7160825508447115, -1.9819008948343413, -2.3502756297408927, -2.737245888794672, -1.938112117975264, -1.5049494682219353, -1.868391194727776, -1.7989936572730707, -1.6313374216380097, -2.3413409297584935, 0.7316149352586765, -0.3805568334204851, -0.3781425623074646, -1.2801123041151934, 1.0917704116300309, 0.2905187416194714, -1.6649151537698044, 0.5691547705780757, -3.170841036185547, -1.575939016977686, -0.8002452700300458},
    {-2.71860016412258, -2.2463932001814033, -0.8353187451106149, -1.6039608123402789, -2.291184814673018, -1.9102783129288594, -2.7432835949001584, -2.045508583153211, -0.5641130736129975, -2.3927151998993446, -2.3299580865502625, -1.7769351727459735, -1.7805803929582498, -2.393700739438891, -3.318737901452695, -2.1396995798265595, -2.171942571308104, -2.1967947967448658, -2.591833928305404, -2.3132791459437456, -2.9880256738995805, 0.24280704068176126, -0.6061248690690588, -0.6570771308908582, -1.6950117334200767, 0.6401498499938989, -0.03497721616973915, -2.5526938408945177, 0.288182593301396, -2.827519693096397, -2.2924539953891507, -1.6229959106486918},
    {-2.9918983547884888, -2.320258636720979, -0.44459572165207445, -1.2748564841715198, -2.7631302391908985, -1.997375748799098, -3.511620584400449, -2.2369684554457656, -0.17709428435422797, -2.5818386702396197, -2.0932155906723025, -2.2335079163201437, -1.7354177978692542, -2.956319139832172, -3.04239650365889, -2.338391651195739, -2.393778874149028, -2.6083428931693176, -2.6495181025921877, -2.615582443814444, -2.9932656264627044, 0.7580210702764867, -0.35776258269273603, -0.2765583577457089, -1.9340961120892624, 1.0342969787044753, 0.5461464547241697, -2.1416249624128367, 1.024126058335039, -3.691245633146823, -2.2803548967823977, -1.5217861155930614},
    {-2.28762957705016, -1.3793257907714083, 1.4011659900008302, -0.5456448538896916, -3.556935704224274, -1.2576945894963902, -2.9472241452184575, -1.605541002283205, 0.83685636202256, -1.8180185731387783, -1.306928675391131, -1.7089504496150123, -1.3990913583760072, -2.543050151511108, -3.2700090677605655, -2.023515049119239, -1.4246882475489957, -2.0145983588713796, -2.0203004074707156, -1.7527434832394981, -2.9931796457636266, 2.204113946562822, 0.8654909461882793, 1.059503098472955, -1.1055600717773886, 2.3912746277947017, 1.8001220610214193, -1.2043203923939245, 2.0772836327064743, -4.154650802235325, -1.7045152429143176, 0.25388724202420765},
    {-1.8346537903677376, -0.2889540170086818, 1.1499991664434772, 0.7932804850084262, -4.042100634757603, -0.6336776267644922, -2.1265786493778185, -1.1996504549300995, 1.8735465675042662, -1.2168538891730458, -0.5428743960195961, -0.6560431180215541, -1.7043874639462842, -1.7656380427427802, -2.906945391742258, -1.160967629942952, -0.6693881863944053, -1.400683107964655, -1.3795590218706935, -0.9221673175992768, -2.2901798215713844, 2.417479636297203, 1.0016015142345318, 1.0603210184214753, -0.10041374796168762, 3.3647460941522884, 1.9387910847805818, -0.7354021833262109, 3.115134596183782, -4.298059579878962, -0.9826004303654549, 1.3488768078423536},
    {-2.576869524837787, -1.150824403108896, 0.2374687193251005, -0.21548885871532056, -4.028925278767413, -1.5383848146388441, -2.6816272607803957, -2.256842266718171, 1.185407191629493, -1.9142784096885983, -1.4598546802168262, -1.3554967867455185, -2.2768592646527734, -2.3504133698969323, -3.2050472305289723, -2.054948276141865, -1.4956223530155346, -2.2589426858956907, -2.1058429401353496, -1.8166772470470598, -2.6255463499574274, 1.8251361506806927, 0.18291656740821108, 0.28842824583334503, -1.0107382402903327, 3.032738028999235, 1.0728245188157635, -1.652761074892478, 2.2855847076498526, -4.582693126045308, -1.5606328323182974, 0.7769894455340618},
    {-3.176460433228259, -2.282716575653289, -0.6525880747923818, -1.34916848168767, -3.275334571270229, -2.1007910262713767, -3.104501752146293, -2.6463172129084986, -0.4788917407706111, -2.078089174402697, -2.0252293077717476, -2.1417703807605712, -2.445887942269255, -3.0178035105114747, -3.3639981544342747, -2.4444570499964082, -2.3074520411152015, -2.6696836359369636, -2.6176262052124715, -2.407329085578811, -2.987342902213281, 0.5660595526055651, -0.45985520918216305, -0.5471133555244914, -1.4747387623513124, 1.3984696204113343, 0.2773580696179129, -2.201277507606933, 1.0093190961818783, -3.9174703213447293, -2.279052948031133, -1.1399749099954182},
    {-2.5250029327158416, -1.1687457680037818, 0.2600888204745319, 0.025912240713811967, -3.8741638227579323, -0.7465423640262017, -2.640155201999875, -2.380097573249721, 1.2514026814971535, -1.5249420603136323, -1.1794648563633383, -1.3507735998119783, -2.6199401947795895, -2.387473549795966, -2.9343511936106053, -1.7096682238868097, -0.7332323336925618, -1.9124658154650083, -1.8129230580209865, -1.3171946849854694, -2.228349895728662, 1.8897878369038446, 0.4384861863952809, 0.1668500271928988, -0.24357318366546024, 2.8194781999497467, 1.4279664887635433, -1.2661985737534558, 2.278047555194204, -4.511560902441767, -1.3427419020301585, 0.5385240144769569},
    {-2.2025491234511616, -0.765894684467374, 0.9707613536454538, 0.3741622286532643, -3.706876089394193, -1.0109442890298652, -2.702415280887373, -2.0486715753611477, 1.3667306749781267, -1.7493460014290518, -1.1482155829277894, -0.7780420944886929, -2.1352852877651296, -1.7839699505024684, -3.3336044400956446, -1.7674958475596076, -1.058839201399385, -1.8485512644331972, -1.8162328819783373, -1.2776704309985265, -2.1896478518708555, 2.2146170523795203, 0.5850749217386112, 0.4458439445341784, -0.11152196854120376, 2.9246222098069237, 1.6483369746274548, -1.3422568511797957, 2.141723140639107, -4.461959611095172, -1.0616915472552924, 1.006263850190972},
    {-2.4216499870887493, -1.4053621820387883, 0.4364185994569249, 0.18477768947018097, -3.8312897825233057, -0.8179899291008813, -2.682359912190115, -1.9865445161064377, 1.0886579669835328, -1.677666535795514, -1.0617803429395576, -1.2477978781998385, -1.8828921084479273, -2.3042604291987963, -3.278696687730737, -2.007368913582831, -1.4002071962844593, -2.358745906623176, -2.450517785812943, -1.7555999747450486, -2.2878716039295663, 1.8452443640141107, 0.5464778755902362, 0.7930750932986191, -0.5408100132315673, 2.9313797027704562, 1.4600427612301334, -1.0757310471727517, 2.232997038508608, -4.198475829883725, -1.3324405499442062, 0.5481550609426777},
    {-2.6158722820198066, -1.179164796264256, 0.7771131776220993, -0.0822801308439284, -3.8307030062694465, -0.8911261244868232, -2.9845895295398797, -2.167411271246417, 1.3120057461909864, -1.622566936617861, -1.2801741443916859, -1.1270614332056814, -2.315440023423318, -2.1409573471477072, -3.3242281708041506, -1.8899862487054637, -1.2817552736961355, -1.9887173719757871, -2.0652528959779217, -1.6436102027963633, -2.7148467880042464, 1.6294000873991574, 0.22937053111788752, 0.2663860721277842, -0.5519727444732316, 2.8594145081625535, 1.5419671087420108, -0.7477975862717633, 2.172268155790222, -4.373837122098953, -1.6899855310025298, 0.5872367195140973},
    {-2.2588733892155135, -0.8326584079849576, 0.8513559081627663, 0.5709923666879267, -3.9852982216807438, -0.570605129651751, -2.3615764422215983, -2.1663837782356317, 1.6746838810662932, -1.2462520350653852, -0.8401836616663383, -0.7113047114586416, -2.4404019660703655, -2.034023409565152, -3.130696972673337, -1.7161918968644583, -0.8855956726730035, -1.7492972685901964, -1.7850283264691027, -1.5135329297211948, -2.295530219290716, 2.052060123002954, 0.6374862265308368, 0.7497418520984696, -0.06673649408123758, 3.229650147761683, 1.6885711069845395, -0.7194885259845181, 2.4878426936720297, -4.285382241504295, -1.2846852693931863, 0.7724413402253446}
};

static const float b1[32] = {5.455653264758591, 5.2851632130801685, 5.386384290367674, 4.856999391285238, 4.987018080669521, 4.889985650207019, 5.203088608727589, 5.181627704997718, 5.105722179273409, 5.018768133122121, 5.004189883667811, 5.233709552284337, 5.022736318863532, 5.313263234843825, 5.18487012693712, 5.081278197213977, 4.986949896742934, 4.958808634552671, 5.026389183118388, 4.961058268757677, 5.062502009931864, 5.3168449097493236, 4.991748972031724, 5.067917420928331, 4.956921441241286, 5.019149013156771, 4.980162525749241, 4.945038461219079, 5.322102879113769, 5.265507421258626, 4.946488993561869, 5.171322545206092};

static const float w2[32][16] = {
    {5.185296321903468, 4.596704214587409, -0.22919581819201415, 4.869216738921759, 4.731814424032173, 4.433465307105569, 5.466552734756367, 5.102939944213652, 4.680845308810085, 5.040758559188537, 4.867226373096977, 4.911087531061879, 4.9501324861628, 4.231133653195074, 4.9613220511710185, 4.29832361324886},
    {4.33930028255909, 3.9145474461959693, 0.024487394294551226, 4.427011527194623, 4.925252895078436, 4.633982239605376, 4.657467634563231, 4.711916628748148, 4.18930679997678, 4.607568113486295, 4.122956255999999, 4.922688470527087, 4.192891174550061, 3.5197917641692746, 4.40232773144723, 3.647660234682224},
    {4.267525927330863, 4.1542481408390834, -0.03251924468305594, 4.142905576077166, 4.426025156861659, 4.929272452944067, 4.373017737544844, 4.576748403642564, 4.128389103607881, 4.679212936128869, 4.68085359718605, 4.778244584499269, 4.55837147885806, 3.9232434641870735, 4.0679912808169805, 3.3840509466273923},
    {3.937714200148562, 3.9513003830274767, -0.19767322166566226, 4.489435066184187, 4.542160893241521, 4.333540987351377, 4.5151463809493295, 3.9275206839845778, 4.573403738725064, 4.426121264043845, 4.138077042609221, 4.70493981762067, 4.1089876969772945, 3.4275394505264862, 4.282743605076179, 3.9589861714870946},
    {4.716347002195437, 4.660542567313053, 0.4294593084673193, 4.762822300517998, 4.9110037115556775, 4.705697336230105, 4.738107072857662, 4.740245438593161, 4.5819964247553555, 5.059695077024532, 4.5156061914240615, 5.019619383468391, 4.558162754948731, 4.339211401465522, 4.401369069614556, 3.841173849210496},
    {4.389286137350161, 4.614752736269816, 0.0947857029012725, 4.260651111728517, 4.383420505033956, 4.270531481837939, 4.505959665435024, 4.474117921599076, 4.066137277456845, 4.244894158912192, 4.399773882136704, 4.933774337664413, 3.9010797066300382, 3.256412594497, 4.346512854922572, 3.530076046720735},
    {4.5632368727591395, 4.6738197377009625, -0.38600379108508737, 4.420021023800642, 4.541549656693059, 4.156037957713213, 4.627797681043695, 4.032121954305877, 4.506937070602602, 4.671672057999608, 4.187278950648935, 4.242640347916735, 4.439052102653183, 3.7828040999181756, 4.084139361145768, 4.089534585844762},
    {4.866595619188169, 4.694498946632048, -0.11299721158820195, 4.570436262620247, 4.77628969869585, 4.711155826157371, 4.688860398141517, 4.84102756100035, 4.27996014146154, 4.8823309148882625, 4.661207367796494, 4.483090319469835, 5.008763261196528, 4.205554145870871, 4.653945416496381, 3.581307876403891},
    {4.0583599696796835, 3.9091881602163947, 0.19716751443044217, 3.9230867100571087, 4.164178582361612, 4.342354665270473, 4.33040561039562, 4.266094983390315, 4.229131668677626, 4.203604317766214, 4.1791199384091655, 4.59558129068786, 3.9906696469968437, 3.40603480686989, 3.779311053805457, 3.5251066584372137},
    {4.199640563668346, 3.9643015212550528, -0.233594895264919, 4.404186199852557, 4.196775188573409, 4.425803543956286, 4.178672762923524, 4.617204027665241, 4.366299430431207, 4.8103388381316945, 3.912527903614502, 4.687636410557952, 3.5639413593026377, 3.8931072122011323, 3.863438163148003, 2.7409584017523447},
    {4.122785686698303, 4.321299395632963, -0.2961036275113173, 4.590322122281663, 4.085740458520189, 4.36421698748745, 4.127279811093916, 4.213301265803294, 4.380593654440456, 4.138174358147952, 3.7445424691906077, 4.149878641697095, 4.1304502671250365, 3.5774017991496625, 4.385972058056617, 3.4627585625760764},
    {4.657425541364462, 4.8269875096367745, 0.12111588638257972, 4.58804720230807, 5.137188472469743, 4.307360665398801, 4.731106819804196, 5.13172680736365, 4.424959930662664, 4.422878495510277, 4.925677474342162, 4.666938181326916, 4.878087838987808, 3.5979147032409013, 4.458343288490693, 3.5555265731088603},
    {4.703203863584537, 4.711238267942721, -0.4913040348862951, 4.555670149644483, 4.94784429069134, 4.41797835050831, 4.698202166635029, 4.402147243947751, 4.398591933625993, 5.106434954805593, 4.735915497975537, 5.261033306174596, 4.62138676683268, 4.229183491285504, 4.67599289697003, 3.605341022459959},
    {4.539113545534484, 4.278298778643265, 0.310034103737642, 4.479362943289984, 4.450228815226542, 5.078499002497402, 4.736599808136629, 4.99581677528716, 4.102247618818095, 4.8395574932586305, 3.934117817069501, 4.768716098187593, 4.7172246539343545, 4.284275839045781, 4.4610249359426, 3.698584845243066},
    {4.521435517027897, 4.735426608687597, -0.11386562368090741, 4.495944601326433, 4.493404394126581, 4.417356300179619, 4.510301571299064, 4.655408012388676, 4.828043478338101, 4.898840988492909, 4.390179960281504, 4.463779756912425, 4.135836839057664, 3.753359051416235, 4.267342999159281, 3.654301837381682},
    {3.942647327193812, 4.169315280298082, -0.7647729705574607, 4.372653210016402, 4.144700922951282, 4.203001927953175, 4.132685553577072, 4.031322481226462, 4.848909503351997, 4.4231367626868465, 4.23806040607805, 4.3873556351176255, 3.9768376786561483, 3.7578847066775585, 4.305828439095807, 2.9115496726111787},
    {4.369842840999752, 4.256691047034096, -0.052702042002780135, 4.510909335788444, 4.226505992811967, 4.092381915641682, 3.9847891692554156, 4.5599414620012935, 4.5325915358264375, 4.1748670806120876, 3.8984729803030387, 4.245929054418851, 4.158678384811539, 3.629676115958388, 4.4822323933034, 3.3021159666866837},
    {4.5905650688073285, 4.053590457072511, 0.3006760581632385, 4.5054718696142535, 4.123971721995555, 4.374079031152497, 4.902151298313195, 4.49971811259802, 4.45923927415373, 4.1585512723751, 4.18827430680642, 4.251039881971984, 4.045834988708955, 3.552954352347463, 4.446835167757651, 3.674403048240647},
    {4.234182216820175, 4.372322838249183, -0.3365853482127634, 4.5382435448957965, 4.226151786260728, 4.290846465600927, 4.56306144202002, 4.4267695400420255, 4.399965252742993, 4.364998971221401, 4.34220952691851, 4.047670033790443, 3.6179960262233486, 3.4803326707089908, 4.072480660900751, 3.2509596796294664},
    {4.307917128408848, 4.579461778916912, -0.07606602765400333, 4.698916292092363, 4.319824021127196, 3.9723079436731337, 4.503868562509409, 4.382601386281751, 4.349353216273132, 4.392190739375975, 4.019768345684334, 4.542330894489773, 4.081406583952641, 3.3144184483796835, 3.713650024831018, 3.335513069321722},
    {4.418579934058956, 4.414599620812516, 0.1887627733477223, 4.771498184239343, 4.0745529568346015, 4.057501915393981, 4.409684965317876, 4.3108280564906165, 4.555509861450227, 4.461986266148232, 4.31880949786758, 4.01137988305203, 3.9634643655001365, 3.6651315855308044, 4.202116114990969, 3.365786543094039},
    {3.9667771018343094, 4.037615389249444, -0.06063440474970975, 4.0810309680519845, 3.9663725090673267, 4.6879765615763205, 4.011706052006929, 4.693073703959142, 3.8782551722714733, 4.5393359550146135, 4.235454548520486, 4.604806098209698, 4.858817184760334, 3.7427006846022284, 4.24576035397011, 3.341627279420643},
    {4.291911578367195, 4.987645509952015, -0.6216406032944453, 4.749747468151942, 4.849245113224175, 4.7918667700572, 5.230350338348337, 5.154179635203496, 4.267207425133352, 4.8552115307469235, 5.307966718642213, 4.449485352076343, 4.368712360237336, 4.18805038774827, 5.332489063579479, 3.9060924884202346},
    {4.181198476654424, 4.713486570883656, 0.011631618954387366, 4.969164697152257, 4.880141385897462, 4.930290532321573, 4.777978628477542, 5.02359500726892, 4.415280912657731, 4.6785201382323, 4.790880247363579, 4.496206813200487, 4.740803249702144, 3.848409696617087, 5.115405739755208, 3.6263142558332495},
    {4.007021660979286, 4.280676148827082, -0.3700249753480374, 4.747052301270131, 4.397262383434201, 4.306504701452786, 4.2756937273418245, 3.9856351668379917, 4.563745825178629, 3.7470429041324413, 4.384242491696971, 4.4200021490510855, 4.173757181528134, 3.20572666148172, 4.053247626562205, 3.3091167059624085},
    {4.6981509397254015, 4.487081886842971, -0.24466560672284898, 4.559899950166927, 4.572200343963307, 4.376791045806411, 4.393849132905032, 4.262648352333284, 4.435671429340008, 4.20103353127847, 4.645566122823083, 4.553972324442724, 4.9587289828088075, 3.8435074766390267, 4.6210958830098585, 3.7979400638063425},
    {4.000472706488587, 4.638793585285046, 0.005244738124496983, 4.098646428473775, 4.092190100288434, 4.129997373556826, 5.026676647645277, 4.475531065629422, 4.619792517231814, 4.554421703032314, 4.503925774466349, 4.442168462912684, 4.5686410697731406, 4.44347515651044, 4.454263667679826, 3.3677694875242112},
    {4.533795860556782, 4.180113535177781, 0.02468289172130977, 4.638204318052488, 4.599614944357758, 4.665572316904163, 4.426598194214198, 4.468012150349228, 4.277401669267442, 4.452633906873068, 4.140700419269994, 4.800684698344396, 4.720124668110387, 3.8109127353919674, 3.956669211098905, 3.460649070285687},
    {4.67439106553115, 4.565744987191497, -0.3967244010069502, 4.604962086766653, 4.576852172149244, 4.895721710320066, 4.134996719663756, 4.743391915583713, 4.636288897321674, 4.220810098998043, 4.701884925828101, 4.747744775004343, 4.779864239051582, 4.030535100163259, 4.58248212603399, 3.686721771613108},
    {4.631271657732431, 4.7162269597946365, -0.0844419903844431, 4.501810455837511, 4.549887421600206, 4.832353583255555, 5.1743803212891155, 5.1524538516759195, 4.884344240550283, 4.837655048842395, 4.878350603433843, 4.722124361019419, 4.883702597210842, 4.046891551319122, 4.728390802177817, 4.030436262575902},
    {4.159016871267555, 4.3369710917115665, 0.042841817283194306, 4.580805363065778, 4.184915375003451, 4.549773625987548, 4.0716673375149846, 4.336482026538367, 4.1825596097138105, 4.300527494512398, 3.849260078840956, 3.9966461903587325, 4.18358079451583, 3.530627745063527, 4.094736740910758, 3.818424159571661},
    {4.333526686198762, 4.4014582887702804, -0.3422857320291995, 4.4042609098171965, 4.304897392801685, 4.606284139095645, 4.73541712895847, 4.447359184869432, 4.276669541400918, 4.816791236178054, 4.284310911462551, 4.529702239469904, 4.332503992217846, 3.755556113869747, 4.2886999423653265, 4.0657746298150235}
};

static const float b2[16] = {3.90610152725188, 4.314498347527069, -0.07011358657806033, 4.317605447630066, 4.439141192835509, 4.091257494259289, 4.342329865204305, 4.2471585527133815, 3.9330823300805178, 4.1887068704792165, 4.2621676207761485, 4.267627922892159, 4.124661499872591, 4.169403605102706, 4.221464003279287, 4.017045940739791};

static const float w3[16][12] = {
    {-3.6459229072549406, -4.268091861323809, -3.4531436192719447, -3.5408676455007457, -3.386919429114358, -2.9664411341241577, -3.6865035777225788, -3.657549747183702, -3.7626716224985435, -3.3712760394030843, -3.7130786255894788, -2.907872264790559},
    {-2.666344563838932, -3.268150036976695, -2.979758242830686, -3.10253134939634, -3.471232201937741, -3.6632679002165824, -3.8139843780643243, -3.6675726390129983, -3.49850643015196, -2.838770103765463, -3.409696969345927, -3.233598217937772},
    {0.01745801645737664, -0.07047550246931891, 0.3815765067828378, -0.1426547714508649, 0.26969387084582236, -0.5034915677961185, 0.3743286288182128, 0.6721453055618303, 0.18412437817732163, -0.38761292219962695, -0.14650247045838516, -0.09373921860940582},
    {-3.0971417196977455, -3.2415949332753464, -2.8724263620356054, -2.910253465614841, -3.194034669723605, -3.2488111290825192, -4.078455958517215, -3.469011137411499, -3.090558621307078, -3.453945777911698, -3.2335135852535313, -3.2121849367918847},
    {-3.348433625274618, -3.6436618628545703, -3.191644334035511, -3.5761493056958487, -3.1310990030518586, -3.253928962800487, -3.4757717722052446, -3.3564835993597284, -3.6306293158713756, -3.4147455143451744, -2.8928455373691113, -3.4414505045120247},
    {-3.8328535411927125, -3.5546399374358417, -3.55011998428114, -2.7201518507889997, -3.4679505702353115, -3.1224347375763934, -2.729435830141989, -3.7448295986470232, -3.6207355334964144, -3.4400019231386647, -3.833952150750254, -3.880593006443381},
    {-3.8246527438582847, -2.990591152341202, -3.3962699494059163, -4.23566403264838, -3.669190991422269, -3.83892917656296, -3.4194075625238693, -3.2307571415530805, -2.7431384462368715, -2.935999796023796, -3.4840097225948017, -3.578853949240923},
    {-3.4619823548155004, -3.0896449025223447, -3.7187205776072068, -3.2513082262133564, -4.012174178117094, -3.5463969703117906, -3.0442859833706697, -3.0224151436587525, -3.6207781901656766, -3.0489440951009428, -3.3602645412084344, -3.3514224959847327},
    {-3.160727439081977, -3.156821339418178, -3.836009980127916, -3.6460614515676926, -3.1485432397308455, -3.3996170426737558, -3.101472174939016, -3.590698718274475, -3.0155641514435305, -3.6845131646518414, -3.1496800830692466, -3.542063814454978},
    {-3.4509649965575213, -3.532427832083729, -3.4716875995889294, -3.5818842974724268, -3.355906563585718, -3.9262973328406408, -3.156571488752871, -3.170330139152864, -3.543024825152017, -3.27228643075, -3.0648303176564062, -2.9847387290949365},
    {-3.4755362600712183, -3.577663287249755, -3.2495961594580725, -3.195107797000691, -3.3346233290982177, -3.289634678898353, -3.1142391327640078, -2.8506818826428173, -2.7900049287354407, -4.389223186132569, -3.798803481277742, -3.189252407275381},
    {-3.4874291348797244, -3.2135267862027788, -3.347813280345849, -2.9966335394492254, -3.407062258559293, -2.6872623902932027, -3.3917371485786507, -3.2908699912240347, -3.886791023140802, -3.6059568790116203, -3.121562248121148, -3.353670754401418},
    {-3.1370786574051337, -2.9095396817055765, -3.6200865397144275, -3.9269161705371696, -3.3623861289586015, -4.007186634462449, -3.5745515339665936, -4.124428301728064, -3.259424767988155, -3.015324841673621, -3.4900075415736787, -3.0818094580201825},
    {-3.376800059001116, -2.8717475629734643, -2.375609846868654, -2.683910712836935, -2.4119082499023152, -2.218327316828498, -2.8401377132980534, -3.219067953628782, -2.8907367474958603, -2.9383239869529194, -2.9990886741049536, -2.8354098758240975},
    {-2.8627300529309236, -3.472525031824422, -3.7331617518554894, -3.2604376118591136, -3.2071036560790263, -3.3548637231540246, -2.4002198650927413, -2.844444691960286, -3.6999807841392114, -3.226762095463604, -2.7645059585228884, -3.667757797717898},
    {-2.5515473247628075, -2.347161496596945, -2.468138696586349, -2.68951888578479, -2.6607905295521426, -2.7155339526595124, -3.8128811732860166, -2.024265993816477, -2.365842936931249, -2.7388854168565007, -3.2597391849722435, -3.253599484691309}
};

static const float b3[12] = {-1.9258685288460138, -1.8533524755411435, -1.336930249375999, -1.9135865630215942, -2.0019988071150827, -1.6560342748162977, -1.2769115608383896, -1.380884425226301, -1.5031213165657649, -1.4413006817958844, -1.8141300180755198, -1.6114090236539524};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
