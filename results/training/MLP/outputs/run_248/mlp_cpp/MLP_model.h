#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.6337353637521768, 2.2212172684136777, 3.7956064364584026, 4.061463752137677, 4.309714646431464, 4.467488482675962, 0.19258110661372457, 3.0191112640088655, 1.3494478489283919, 3.877895649376499, 3.9110038046177173, 4.950395429809924, 2.7242505349557677, 4.660982174571963, 3.6567843283213977, 2.1370692671639455},
    {-1.581555557815331, -0.8725084891932983, -0.9353355922396109, -0.10501913746489501, 2.4991919718413436, 2.9298663963016014, 0.9332463454475631, -1.3447230727609067, -2.148737777521253, 2.0681184301088402, -3.497703602650889, -0.7137413976277212, 0.3102180551797389, 0.4605255639402768, -0.21651394491338874, 3.046150904382488},
    {-4.179889475818413, -2.3280741352006142, -2.1995418766066823, -1.9045269947519714, 0.13760876564000066, 3.9317986815991715, 0.7832669227457534, -0.37524158851067724, -2.425502195662172, 1.851741205467923, -3.615352574779146, -1.1746732168962173, -1.8762947377687982, 0.8679544997672607, -2.267089091734155, 3.164660514099711},
    {-4.668321542230786, -1.6411235104525612, -2.1265381511695423, -3.502284552221899, 0.2898693068759889, 4.307839853888913, -1.7995877198356691, -2.4955510435543387, -2.5747862197748685, 1.2704606138298786, -2.7726119980474726, -1.409127713770111, -3.407680540310144, -0.7357171309374037, -1.6507749201258093, 3.160605795061579},
    {-5.5160526312415215, -4.9067456638611455, -1.8630330173589946, -3.166157334656287, -3.155527254542047, 3.870434221481277, -1.326160865299538, -1.3297396184949193, -5.08369573311538, 0.5621245304420732, -3.883949066188304, -2.4736067761306195, -4.518105182325309, -2.3446594479535254, -3.8800303513052268, 1.661027069908201},
    {-6.58556217532237, -5.470371193864331, -0.8039064906993617, -4.352809846836158, -2.510100909986575, 4.423782713132197, -1.398010252561514, -2.0633094790046322, -4.858131796165158, -0.8916582435960243, -3.2424865438305326, -2.6882119850522406, -4.410846221635532, -1.1001646476492, -4.958168697714492, 0.7352192087687053},
    {-5.62400627901832, -5.597033410742993, -1.4182630279360506, -2.6916342603272065, -2.2011238791232577, 2.8102510078132794, -0.9475559186416086, -2.275787624168796, -4.954712899224652, 0.4211813687151663, -3.4791621974069633, -3.240656944317323, -4.726343391777276, -0.9927012147166323, -3.413528666216071, 0.3976574857052323},
    {-4.527199056241771, -5.309386535734969, -2.902773694933472, -3.148012644490192, -3.2461359181019502, 3.5521376817738566, -2.6025694418211405, -2.947741233074698, -3.9142545378099145, -0.7709251812849666, -4.282887827061412, -5.05041473554463, -3.548391289435022, -4.094002960192936, -5.072442823077355, -0.49703286008135433},
    {-5.909846392055936, -4.571277059569589, -2.6057783340204956, -5.080647137879781, -2.3101505154962076, 4.149768871298036, -2.327620365690363, -3.240991440734102, -3.720263059778726, -1.04698518414326, -5.220391833849723, -3.078802672835985, -5.075133790343093, -3.8938874148480282, -3.7433057418198636, -0.2875963935291522},
    {-5.023779018020325, -3.953241548697092, -1.6014986234016633, -3.66047491960111, -0.7263160905034027, 4.291528851211747, -1.058347137574062, -3.2304292625869135, -3.7903714492062184, -0.8019392549042228, -4.672094129434761, -3.9671934079214006, -3.908196041910472, -3.073584603085014, -4.390856885267298, 0.8199494897836466},
    {-4.609433069043649, -2.2953304691668963, -3.069619819098508, -2.974037070034183, -0.9580562379969254, 4.224000945016509, 0.2560641608371465, -1.6555320610625786, -3.001250220014783, 0.23026855636970733, -3.784089439573047, -4.101953906780116, -2.9981173377959203, -1.6486635177777207, -3.787891821553528, 0.9280145086302911},
    {-5.211465047831567, -3.59091819187478, -4.21077471644818, -5.164994314328302, -3.6190376669541013, 2.5099530779877175, -2.458667545939434, -3.351202735379618, -4.76728670145036, -1.1776805267266415, -4.699006222350829, -4.09884767970775, -3.9099605487068048, -3.9333075778919646, -3.668175941853552, -1.7426406481476264},
    {-5.533500284390506, -4.204393470476488, -3.831232713844626, -4.965441934629138, -3.5616670883842754, 2.9022232936496457, -3.540268209557874, -5.094686019596717, -4.434387917234707, -1.4166118938698693, -5.0237836688555575, -5.018732539809499, -3.7668084316278505, -4.951216533828059, -3.6315223421855998, -2.7407360446549722},
    {-4.527867963189979, -5.719344135385894, -5.0636495137873805, -4.575957224644921, -4.909221440685328, 0.9013413925856609, -2.1824668599481982, -3.815176443441608, -3.624227367626865, -1.3944008976470903, -5.88880863705308, -5.6902548897976795, -5.374482230453186, -5.235801099829705, -4.127583120910741, -1.4437311628770657},
    {-5.17007437894166, -4.787743371393791, -4.408704900884237, -3.371877183342157, -3.582018256157577, 2.1794661381103495, -3.319623462116149, -4.6188482164848965, -3.481762025117032, -0.9388111900479014, -6.185912147957891, -5.847018295140098, -3.2013080883041014, -4.229095738714357, -3.996412992040488, 0.06276025070090101},
    {-5.6697433297285365, -5.907209012435576, -3.035462713807117, -4.628304660988521, -2.362381473814878, 3.8252426828506683, -1.85650486687125, -4.151282118359425, -4.280115070466963, -1.2026234886639393, -6.154739309736864, -5.36557998444039, -4.764383856490097, -4.207442123728605, -5.0282194061490015, -0.1491423743985944},
    {-4.191171315331423, -5.1404373018128915, -2.339076192771144, -5.246353243149056, -3.1608824684424257, 4.8263197061424785, -2.923730572127222, -3.924465518119857, -3.8020218852016385, 0.2285350399071071, -5.377853246251907, -5.4474411583729365, -3.075067138299081, -3.2615850673654045, -4.298769031041471, 0.3197780513017685},
    {-3.915612114661329, -2.9722760570252906, -3.496222857151749, -3.062440645892016, -2.5314343966071737, 4.155860999705054, -2.4036203391240663, -2.0158558820979415, -2.216417846303306, 1.5776903584003283, -3.486868236547753, -3.593059379382418, -3.0752227822356852, -2.919343267256162, -2.3374926330991856, 1.6513375708502822},
    {-5.577672914665562, -4.422453315810431, -3.101112788122, -3.045984080858973, -3.035260037228799, 5.237343174375137, -2.2419336524663085, -3.361627273782791, -1.7088525939911936, 0.703563962742905, -4.201774122825801, -3.5232643427859847, -4.318195575497165, -2.673145136114702, -4.237345775232937, 0.671191342950527},
    {-4.8457594196477105, -4.107331434028606, -3.033788464974718, -4.547269886998584, -3.660011782319579, 4.4388999343815, -1.8665678302618083, -3.698319181150268, -3.1874837350736644, -0.47958761250509563, -4.93330828823444, -5.056353531392836, -4.845265228988473, -3.6260270862797994, -3.9597241844256934, -0.3105816417276055},
    {-5.601505629135718, -4.713127995590228, -3.185230527896675, -3.500781669511237, -1.4450432167269984, 4.221599811555368, -2.9014324630287027, -2.203500272614895, -3.57970946099383, 0.12287029161685142, -5.214136069844937, -4.35005087471504, -4.308729227898519, -4.637692298266601, -3.9391194035613957, -0.7457039172534345},
    {-3.659374987533919, -1.152805690755768, -3.6501027359074376, -0.8731657956823138, 0.4130133555443223, 5.809591781344873, -0.9265087670244624, -1.2716830776523298, -2.1051687521927285, 2.1845389977035308, -3.2620336495545765, -1.7688747215756722, -1.9920563347280686, -1.4317901985337722, -2.462381440661301, 1.5121884856807806},
    {-3.3691983855813694, -0.9363394357090358, -0.9699803163410256, -0.6088699254298653, 1.636136715936673, 6.2432165075539485, -0.8955286707823581, 0.055643059951275456, -0.9460942975445638, 2.579027141687076, -2.8813003650246936, -0.23900820874244882, -1.764811463038415, -0.5328225835891834, -0.5299807231890055, 1.886088407125707},
    {-3.78818507715637, -3.085588954799285, -3.978677604544471, -3.273056214138, -1.583625239800417, 5.002210883943348, -0.9404901199361678, -1.8635120471965239, -2.2969633090445423, 0.9725979947076976, -2.954963682985302, -2.1528218902104426, -2.638368235797946, -2.732513082956319, -1.366275985587397, 2.1199740692427853},
    {-4.214984230130474, -3.7551122763547062, -3.2515390881544675, -4.226041932226847, -0.406364612095602, 4.757413610644862, -2.208468341633923, -3.400994949205015, -2.497571877100371, 1.1502269148878828, -3.58017418047245, -3.940285447445769, -3.539534942473571, -3.3276208684914286, -3.634290469558004, 0.12685727936751331},
    {-4.493164722411935, -3.9444250218431627, -2.1870038660394187, -4.379749605100951, -1.9861068117513199, 4.840734742457607, -2.0474027494158684, -1.2149470596349732, -3.582655802498471, -0.21928994837460075, -4.355630684333937, -2.8623348610958073, -4.510833984809942, -2.9647860112867384, -1.4843436379911414, -1.1883414129502428},
    {-3.872301839387298, -3.388435604841869, -3.627853896967717, -3.677562529023641, -0.28577730632390924, 5.596680928583134, -1.4045739097787506, -2.4533466177597085, -2.2556462612684225, 0.8331105998319411, -3.8465151423059347, -3.454887560462497, -3.1614651309489137, -2.3083721288545136, -2.364203310154621, 1.0809575339053592},
    {-5.550743535093977, -3.5162102535444952, -2.988529298700191, -2.609102663094663, -0.8391779983977968, 6.091293129128924, -1.0828966999310559, -2.340761263957009, -3.339834355132963, 2.1981820480255223, -3.868363694395386, -2.7934179316760694, -4.141263485802649, -1.9818906360863604, -2.952218337328971, 0.5584965769513363},
    {-3.8180260317349655, -4.29236325125549, -2.7554956969835382, -4.120458940169965, -0.8343462304175909, 4.8187116199285445, -1.0063675993573886, -1.0533799304419311, -3.3538901495108195, 1.657503044708742, -4.039791499962137, -4.705306965363181, -3.385363073891478, -3.1863942284949482, -2.2000524633127005, -0.10851156825122714},
    {-4.685232754344278, -3.3749679310983915, -3.5786107607602857, -4.580508286215002, -0.49048049617580475, 4.3197456662072655, -0.8571561953425716, -2.6795528600166065, -2.6186206989603074, 0.10427212452450806, -5.466928367585936, -3.863138876589998, -4.522204881639283, -2.4739676981067507, -2.5488148476039685, 0.07810379726536004},
    {-2.4891805891944965, -2.6624676157419622, -2.0639269605557917, -2.047690437952378, -2.238174345878235, -0.6484608237912904, -1.5507167937360458, -0.263791736774821, -1.3975938370911583, -1.4123169563848417, -2.0923838534809795, -2.7462065597982823, -3.6101001297546613, 0.8685552290235903, -2.5409587883427096, -2.5597515812391127},
    {-0.49245038418222636, -0.034111018037036374, 0.7577796407311177, -0.749421830816628, 1.362929803918193, 3.2471066650321516, 1.35553575502457, 1.440958328239681, 0.6496721151144831, 2.6240117364042126, 0.9156432490272752, 2.469312667346719, -0.31048193479490016, 3.115599191199525, 0.38800106156795533, 2.8699835974899126},
    {-1.8217504140814753, -2.188506712265016, -1.6953604225648766, -1.846614834681855, -3.169901736946733, -0.14266596014817334, -2.654000291052773, -1.3111061037800575, -2.9455753822086885, -2.1086632214251204, -0.4531202270914169, -2.14361572018633, -1.5209685528616326, -1.390270893899803, -2.3448158896569242, -1.7154460249103445},
    {-0.22056846647205433, -1.5564716277476212, -1.956615815241277, -1.604356424431772, -2.698462039425222, -1.3529220872418377, -2.466051930482487, -1.8403390778399595, -2.40798984806931, -2.390329175850761, -2.0965128145290683, -1.4089625714812148, -2.8158979063305685, -2.7597899875609397, -0.7200747598775565, -3.3686697644668846},
    {-3.226258206844257, -2.4980021596171706, -0.688976842523051, -3.9914423544584854, -3.1089855801218875, 0.29375412444155075, -1.4514296419337336, -1.3377030849288614, -2.614227102294167, -1.8144804601299558, -3.258555593358505, -1.3194333099117406, -4.446150001478466, -1.2750669440391416, -1.6998417380262507, -0.8888548400454154},
    {-3.360866183472911, -2.7468225180125607, -0.2870688210101104, -3.1670523214992357, -2.0918197937324865, 0.859389144339574, -2.2616918129719985, -1.5206754524256025, -3.6402867521737736, -0.6803147379520931, -1.7931326772753158, -1.7104386917222734, -2.7805001130775175, -0.6032742645532706, -2.5117399221685512, -1.667063662414572},
    {-1.9189629874478331, -3.269866738288703, -0.6942085862027443, -3.4444057290271157, -2.701446454864904, 1.016324434648848, -2.695562528042834, -2.189505417362592, -2.28713972049407, -0.7546123737393721, -2.8435176506934394, -3.0548382873740247, -1.710133703397774, -1.7076857621358368, -2.4377024891488768, -0.5441949122200944},
    {-2.6010778218752146, -3.107607461572785, -3.5317683267599054, -3.5876107307703253, -2.433693782865375, -1.105023005065456, -3.464968605975907, -3.0418011345706315, -2.795386000936405, -1.6287488215778856, -2.491684647199745, -4.098084030460608, -2.8851259168714622, -3.6908415685579152, -3.1616392145761343, -1.0803556689115954},
    {-1.2063948975992884, -2.1464948420584036, -0.06470706873599567, -1.534697493443852, -2.1344873165029794, 0.8131594240212145, -2.2026349061401516, -2.587994267069984, -1.3696153569731144, -2.1238558384648636, -1.252368141661468, -1.9888558143159107, -2.4816749041234636, -1.6909937200970524, -2.0554559516500968, 0.27361003166236275},
    {-3.294581503929721, -3.8202942595240814, -2.115898648933084, -3.822336943851774, -1.95356774411607, -0.06002678193311003, -3.104509233157692, -3.5909940966554075, -2.565922336357565, -2.6008513466109724, -2.1057162132163745, -3.6086656305259748, -3.177148623399683, -2.6602016172833975, -4.445120272827428, -0.9925946265845753},
    {-1.2887870071283019, -0.9487617611516953, -0.7142797358343947, -1.1508720355858713, -3.016650670385017, 0.444506027538808, -2.4162951299376676, -1.8166163619661952, -2.7297471435626552, -2.642346592362374, -2.170342994169518, -1.1008225883823965, -2.6628121562881986, -1.7606834266571196, -2.4990147019650646, -1.273266009900912},
    {-2.214013537204559, -1.7667132636618332, -0.7102870665232053, -1.2617554829032671, -3.069528780494457, 0.11730509937016984, -1.1776189135739838, -2.975599262506191, -3.0604578967903984, -3.176851327174043, -1.812959751881308, -2.2737096867648927, -2.701350875394151, -3.4055008104449276, -3.072100351523821, -1.103358537947833},
    {-2.0562146456740145, -2.940273509179547, -1.9305008347405923, -2.5938823628125243, -1.773439194567763, 0.2571186220382581, -2.7546001815006456, -2.3938607322613032, -2.1872375149572627, -2.920147613729212, -3.12670816497072, -2.3832493842966045, -3.180379011216566, -3.1374526449124076, -2.65787149151472, 0.212763786597183},
    {-2.386984242147126, -3.277347427413039, -2.141177319021003, -2.7088043075233252, -3.7590411987150225, 0.5833089629574489, -2.301649233580443, -3.9565713195384604, -3.7434175915132473, -1.7853996533635657, -3.117806594150847, -3.040181069570573, -4.348043034832664, -3.116259830826182, -2.8562104732670455, 0.2685347882901019},
    {-2.9080260812230434, -3.255140983292123, -1.112399338157637, -2.6069527176402687, -3.0025360879342955, 1.271956474999977, -2.7606777473313167, -1.2552775666422242, -2.954765553058205, -1.2732010851593643, -0.9596695743376584, -1.7544985594462645, -3.8023917320277705, -1.993119766304306, -2.5520017091686076, -1.8469497892996765},
    {-4.411308289934466, -3.27959389779797, -1.1045176649702086, -3.23159976536803, -4.247631325346206, 0.1347283119023134, -3.38698982000846, -3.417555889553645, -3.791905117928722, -2.3829739349374064, -2.04241976011433, -2.475373069682514, -3.4765173279903956, -3.541543496791783, -4.02119421798352, -1.9963430799106887},
    {-3.2737314081430515, -2.60610039919282, -0.5068330675135044, -2.098967407432345, -3.4132888871962925, 0.7702878274646117, -3.5762707930105195, -1.4694042851946256, -1.6511295632416323, -1.5964255221146175, -0.4482242389216393, -1.5974775949511084, -1.8473002640942042, -2.5726758465030417, -3.0927217877505884, -0.5656986738206956},
    {-1.7864600634705845, -1.786105729779634, -0.796466901160824, -1.7006023785647162, -1.866240267164216, 1.227148865360543, -1.7500406684713476, -1.5607358382142666, -0.8196107264235195, -1.165437535684789, -1.0986067891595217, -0.7945607054056951, -2.1188801645533486, -1.6584303049802602, -2.718066593504988, -1.18235265586013},
    {-3.688579577890897, -3.497363156477533, -2.275834756491773, -3.690529739918381, -3.6534697668831804, -0.6295067350335685, -1.9636596036461813, -3.0766866406212006, -2.4067216268111964, -3.8160392110560593, -1.3719743463532332, -2.176147335444977, -3.1599015348952104, -2.129336054203977, -3.565728024753837, -2.4513560529537983},
    {-4.626679723348082, -3.6657404721379585, -1.4653179848160103, -3.83883323817205, -4.298793093956679, -1.127234970098949, -2.4118899194327033, -2.8331804317498186, -4.37399750826817, -3.3640084674445547, -1.9181230683042139, -2.619952419419672, -3.8187274228322985, -3.4048879572940867, -3.7757865440633576, -1.3141628592292525},
    {-4.3267197561626505, -3.884222173109936, -2.4125424699526197, -4.857312988702111, -4.519220975777983, -0.46178042958090804, -3.5728625551855884, -2.972807921817664, -3.580671498723709, -4.246535843186552, -2.8868755926986354, -3.385760851626813, -4.075259896525375, -2.6564916414280044, -5.109775307087681, -1.4334698989153327},
    {-3.1315354651407095, -1.846078391974604, 1.55634932985709, -1.5125858830788557, -2.7097768326611797, 3.2528455571662884, -2.172144332382097, 0.3217439793459946, -3.7963701160300745, 0.5779584396984474, 0.6698596392192793, 1.4698565103118941, -3.1785830378506548, 0.655050368355598, -2.282828753724862, -0.813507317857597},
    {-0.49687939082003685, 0.03470604224392654, 2.4039617174211703, -0.04455161095164026, -2.282887844049491, 2.6810829339970175, -1.362353517651539, 0.684298915315627, -2.1681924192409014, 1.5856824947325072, 3.5167647008726632, 2.022939411150802, -1.308452342459098, 3.2193800056779867, -1.0978083576541249, 0.0038411354455886023},
    {-3.077452614361546, -2.68058235093626, 0.12370427110423224, -3.017797764773011, -4.669032795886235, -0.3010366385393977, -2.3050390830222685, -1.2948433315593901, -3.2583724956223348, -2.6925520950377075, 0.4470348616649738, -1.3242385937697183, -3.3938455597497303, -1.2634291567771372, -2.5098020520187942, -2.873165808704379},
    {-3.179133439963738, -3.9118212890770283, -1.6422953113907557, -4.365879160093357, -4.484346947875022, -0.6172145247352474, -2.9745587514991843, -3.432896896345253, -3.1768321552847683, -4.015531579773908, -2.3605265787492216, -4.00563709911495, -4.257981622372723, -3.4486052467103385, -4.8107206916577265, -3.229897112023532},
    {-2.0270896916163013, -1.5543713353093733, 0.6692045182242417, -1.118285841304272, -3.142295241066226, -0.11076273919975616, -3.200379176200964, -1.6998462066272628, -2.1517347007536474, -1.7614650107417382, 0.2947371246166325, 0.8882312985303009, -2.4012646101954167, 0.9588795313743526, -2.2110964948711875, -2.9634168466660733},
    {-3.3973606842479187, -2.5690055916985886, -0.9119684933975157, -2.941075712731736, -4.582847523280363, 1.4290408621405977, -2.34788643005262, -1.6235852557444848, -3.7890610797906397, -1.3953420612225866, 1.1525021571546001, -0.45815006003075437, -3.619701811573165, -0.43364441565805795, -1.4717166074183352, -0.9840224974050328},
    {-4.352664857283764, -5.02328597401512, -1.5289773493037493, -3.091373161224446, -3.5854004165182225, 0.5683901078373426, -3.0478956785553977, -1.6705835930324944, -3.4270483865622694, -3.537847323087576, -0.706872922073252, -3.016058341893294, -3.3430029409685407, -2.7987515601533293, -3.6839344674793946, -1.50147554995288},
    {-3.42471997469087, -3.1676392093574024, -1.2237893095580465, -3.186660627943047, -4.859686500711034, 1.105446656032478, -4.607292187988233, -1.7649569849445796, -2.695346439162653, -1.4574438305442927, 0.04521702793900746, -0.5686123875339583, -2.8702856521328126, -1.0002601221790963, -3.6364189458320215, -3.2503975422877818},
    {-3.9162758356344387, -3.6492351087438464, -0.4735522715224221, -3.706235429344484, -4.8206949715340635, 0.4939466786730487, -3.909198886497927, -1.7427750524350687, -2.802107386017352, -2.0078602116248954, 0.633394974471959, -2.6820662717714447, -3.555501652368248, -1.4438651486302088, -4.062728635037111, -3.8527937743240805},
    {-1.3261509948381718, -1.995891470464565, 2.1595325652550885, -2.862443489285521, -2.4298476357097787, 0.07991786580944726, -1.7929544002710671, 2.3738362459785853, -1.0560639270570624, 2.774178365540212, -0.1722618334806416, 1.0227284353312691, -2.4803010714924376, 2.7591162476789233, 2.8110522348949774, -4.128356575935574},
    {-2.1790085196360582, -1.3278498550429243, 2.3843994365610097, -1.9793951766154267, -2.0223624941425675, 0.09841931647377793, -2.22335421395754, 1.9131075604944765, -1.93199656583091, 3.044030503746084, -0.13962714115029795, 3.09877385264721, -3.1014632722138953, 3.8540686001391165, 2.6136163437205018, -2.706289495968351},
    {-1.199250301331364, -2.228285711636275, 2.0467413790508227, -2.8537084027626594, -3.356304075995408, 0.9791297826336688, -3.2114999447152055, 2.5876248765281264, -1.9695330857298754, 3.0095570396959923, 1.9868359314566055, 1.706199565160211, -2.1556306510544103, 2.3037113805279743, 2.1312907561064574, -3.3379699523119633},
    {-1.4081493085676449, -1.7229952148762913, 3.0217860016098737, -3.740621890245361, -2.5798419805535224, 0.8655620739389304, -3.603459334013333, 1.850338882024551, -0.7405127122891576, 3.5263357500335357, 1.1141069635619905, 1.6228138395625167, -1.8516536621789612, 2.1642185868356885, 1.3013110166868072, -2.452607380834713},
    {-0.6121830681885967, -1.0173986887496238, 2.343955301441773, -3.445341274744787, -2.0754615985464944, 1.2624493734734492, -1.9964231817076514, 2.4216178643215205, -0.5641647718870034, 3.1060862093072727, 0.8812188533453119, 0.9354732696510301, -1.7051944275989015, 2.0009363004375453, 1.9594578510806158, -2.5563128706652485},
    {-1.8331118191856655, -1.9959321746455085, 1.661540018622163, -4.061546961873622, -2.1697578368361565, -0.5685706340270963, -3.5167901178233767, 2.866220847410122, -0.8822554066857413, 3.344192593725453, 1.0775362689429762, 1.378866864945547, -3.4710194095548546, 3.1533775741344923, 2.363268605254605, -3.64283993728753},
    {-3.3042379896180223, -1.7859129865127403, 2.860064648459849, -3.8484188139229283, -3.7840031028618926, 0.5367494624861574, -2.206426214205366, 2.06712691507329, -1.9756144023587587, 3.0688057685435504, 1.0664876649983634, 2.852025676600206, -2.79525424004091, 3.553738485220376, 2.305140894509156, -4.642006253520697},
    {-3.54787099023494, -2.9479796440632504, 1.345148279133352, -3.799072774161446, -2.0074863235457707, 0.3807346670741391, -2.6144332124936027, 2.905656159432758, -3.022122081759241, 2.921167362222924, 1.2725190702237066, 2.2310887072202643, -4.037434770572084, 3.271330769698277, 1.458884561804295, -3.4482203852937054},
    {-3.260063956888782, -1.6296672940686026, 2.931015985960377, -4.136925215684939, -3.1160950715897946, -0.2064712174242641, -2.2991296678082014, 3.2285921129077817, -1.729290793808962, 2.439116703911601, 1.9065910802587083, 3.467967505981469, -2.7466461895309418, 4.081773659857453, 2.315330775827289, -3.9398382616988137},
    {-1.4892447265382176, -1.6824405254036414, 3.9271142812548407, -4.487124724985636, -3.3546332896575906, 1.6223563736498243, -2.70150083235856, 2.6242801887757885, -1.166296372860663, 4.243302394261055, 1.6475012127902653, 4.54805330465979, -3.5267796318359705, 4.666609562246459, 3.467862736177063, -3.531080946777371},
    {-2.2971041139784663, -1.7728459670621308, 3.207885812047632, -2.3430591101033773, -1.697605815167124, 1.8032681576833496, -2.8626046698059553, 4.262772300973352, -1.9662364516192494, 4.380468682420991, 1.724711172350417, 2.927225560684445, -2.806290348253661, 4.766225579713071, 3.621360966751957, -3.471335277702994},
    {-2.2954423305085765, -2.162461899539614, 2.6948462942939657, -1.8019472148377675, -2.557812489223991, 1.1834720128653837, -1.6120876942585158, 3.490313856040292, -3.0185272256073516, 4.550544912649636, 1.5959058223714004, 2.4920160175433823, -1.4490144310587938, 3.122558645412516, 2.6288419110550407, -2.7080403540060005},
    {-1.6226257579004169, -2.548778808929521, 1.9060095384338371, -4.25128832088436, -2.5111554540155567, 0.29583722616661773, -2.1226939301780288, 2.804602085406144, -2.4965973977137255, 2.7841799884194365, 1.533644698991371, 2.2797388540010712, -3.41668421503164, 2.5747537893669814, 3.6065244248932493, -2.945959961964972},
    {-2.8597318491554535, -2.4522369304861904, 2.3371235012393674, -2.691567128068966, -2.9846266155246113, -0.13197010101608753, -3.050230601269324, 3.5681614803532713, -3.0767254978538903, 3.787990351235549, 2.256691616794846, 2.7259885086910614, -3.4906614171244885, 3.494358503170462, 2.3508286894223764, -4.512270584247472},
    {-3.197561932728385, -2.769711717457839, 2.9959546796675105, -3.5412924602847076, -3.6348259012841435, 0.42849806085419306, -3.6519202091523932, 3.6792504904892995, -2.960822137333582, 3.453890662999085, 2.3513704105432995, 3.021212731073961, -2.540925806925787, 4.329258713901768, 2.729277813990506, -5.5311778977312605},
    {-2.1776549484449816, -2.8109881019911223, 2.1497570901152727, -4.377521238845479, -2.7429057117029747, 0.703824404289154, -3.400123707732231, 4.015107511362601, -2.7049102044329985, 2.2514988031948184, 2.153435758368971, 2.8163307512628473, -2.8799203922007948, 2.913912400651608, 1.7657829589887428, -4.341466407099386},
    {-1.828087400496622, -0.8968653311259077, 3.4666053134477224, -2.0709837447672803, -3.5917744869956225, 1.5858490227524837, -2.798407686703608, 3.507432644438982, -2.9606950971307735, 4.325146205343793, 2.419111606111784, 2.5446526426955414, -2.3060212841827803, 2.8403825706234613, 3.3386694791738623, -4.268386909900533},
    {-0.8825349794402642, -1.8197844982699074, 3.5976182159981556, -2.863780233505237, -2.005702097703373, 1.3829726058202458, -3.5585593182168753, 3.3727414093440964, -0.8929396979644202, 2.878880366666418, 1.9121053184060388, 4.135661535188646, -2.0491607931616764, 4.092722507288678, 3.3156904720073705, -4.413333962803664},
    {-0.7288607043161438, -2.7696725011854233, 3.2814872995216406, -3.6253822404071694, -3.4436028201433877, 1.4024101254881087, -4.349240950575486, 4.313457628643673, -1.121783364453896, 3.3479219655922385, 1.483028710251374, 2.1302286754582824, -1.7651689169381115, 3.4777709591094985, 2.9437276899066034, -4.000720306623089},
    {-1.391615532888468, -1.5134170944506136, 2.915669994524045, -1.9957990029634358, -2.3824983970752776, 1.3988626636776886, -3.4169275287997043, 4.270438347970474, -2.2832298381457554, 4.203421131100858, 1.6839418814742089, 2.4483984366750815, -1.7140914245326233, 4.634089578318532, 2.89677640981043, -3.78032606252632},
    {-2.1122056964240334, -2.622287155545117, 3.39454243089514, -3.057331580258935, -3.177228160998331, 0.30096270029534816, -2.9366602594801097, 2.644089514826083, -1.6903488905943682, 4.507756646302413, 1.133171671578388, 2.3363184257232206, -2.444076686192988, 4.432164960910742, 2.825718851028825, -5.318112761160872},
    {-0.5940129549015348, -1.9649305094751615, 3.9771420024543493, -3.256313295122102, -3.224120089545092, 1.565045651216217, -4.318965465617426, 4.054156091249242, -0.9084969745855541, 4.254708435209136, 2.6499808487468774, 3.5949140912112183, -2.8156070440665424, 5.113986827341346, 3.957626646449873, -5.127820447087661},
    {-0.7310276904635773, -0.4486150253067659, 4.697764739530441, -3.468124198266433, -3.7555185185809674, 2.5447921872211285, -3.6391339991654403, 5.193035383579466, -0.8700546715332983, 5.309982661206474, 3.1213757546145087, 4.055236390396655, -2.4541703139043043, 5.047939628559939, 3.574003274828228, -5.12237188895228},
    {-1.6315135957892237, -0.8170520620250712, 4.176964941408145, -4.228515363679097, -3.622579255538578, 2.181990904002953, -2.94087978600188, 5.47799371969222, -0.8851666170918645, 4.931074499842787, 3.0596712988291146, 4.3234149645464655, -2.899268062388826, 4.844491390481566, 4.413837445701987, -5.493048721851382},
    {-1.9143440084044812, -0.4607137793874614, 4.847337117793161, -3.7943506383009065, -3.066967735332202, 1.97107912358421, -2.692466566428076, 5.008011231738823, -2.1877355627071586, 5.3936529253983885, 2.2476778795678993, 4.084895113140105, -2.754282477959401, 5.494576932504629, 4.296780825091106, -5.168288499114337},
    {-0.06996049833841188, -0.412906842596754, 4.277737971104074, -3.8830481227244205, -2.6574047468631097, 0.48357976572852457, -3.409089341353217, 4.76103631992556, -0.5321453679711697, 4.845800683011234, 1.9519116332545974, 3.792674021530757, -2.7336072646226026, 4.193456406751264, 4.59618207545606, -5.487180214921716},
    {-1.5473999810945394, -0.12066246047784371, 4.892293691314742, -3.739664052528376, -3.5230058582768202, 1.1520353344279584, -3.8370987394497718, 4.2460346506296105, -1.5169017517980934, 4.6842345851288165, 2.9045185715872903, 3.460616420517792, -3.3673519464904795, 5.376477030446149, 4.410896990961829, -4.9955951482259024},
    {-0.655996830533902, -1.468287025480258, 3.5980702127110584, -2.479846456356296, -4.346992017745217, 0.7327951841354399, -3.803281229902567, 3.9208936732439006, -2.6706260056633937, 4.465541870482934, 2.403253409124568, 4.307226904298124, -2.9454806137373977, 4.16736740269602, 2.3410906509060134, -4.301071059730264},
    {-1.8800478916153052, -1.0876926543484804, 3.976556673955056, -4.179161144831853, -3.2782081040118345, 1.4397761891833398, -4.397394221295503, 3.872362132039051, -2.055329337153505, 5.3913862460532815, 1.767010062309732, 4.259166490264244, -3.2901134076054737, 5.6530475056516964, 2.2704449911924303, -4.284980725345576},
    {-2.0437550155962265, -1.3394845905483885, 3.6849036992397806, -2.7329090472545694, -2.9199785213400276, 1.8519329367854427, -2.7518748745256683, 3.907846473849858, -2.299768925755409, 3.7130977238858334, 2.643102445035339, 3.5733702416340094, -2.476068932704734, 3.9465059564229867, 2.853243978899234, -5.263837762770925},
    {-1.963508521798388, -2.461415867195475, -1.965171462029714, -2.1729005735866105, -1.282238016819957, -2.4039710387765747, -1.5688024957933753, -0.48415774289579466, -1.7947282623031948, -3.306631681745502, 1.0003484559375722, -3.353590392284879, -2.5334285326506456, -0.3415232529203142, -0.24415372465895574, -3.5827536728331824},
    {0.29402468558058925, 1.4712540952623343, 1.239700997598018, 0.970674779563602, -0.4224402166136505, 3.2965491150191024, 0.25187657609359, 1.9727619917438668, 0.8868233303453512, 2.502911818775477, 1.0551783136325044, 2.7928042208258694, 2.7243619635300744, 2.32383958737664, 0.6907926037077057, 1.6166964873742369},
    {-0.49811506946561207, -2.4349163585738935, -0.34750350469064145, -2.7213181390121406, -2.5628628461494314, -0.7053572625350452, -2.286703023579447, -0.7897038937803871, -1.463228074322718, -1.414003621452261, -0.6061521065806489, -1.5198794444960713, -2.515500950122321, -2.0128363331150028, -1.807999820515202, -3.147286674534587},
    {-1.3760671402284033, -3.443227699643443, -1.1142035360405675, -2.821402503421723, -2.3511802348191067, -0.3960338958564421, -3.3330250979065954, -0.3306873009701848, -2.2888552685839483, -0.8878064222662074, -0.4167098417800144, -2.1799500531744007, -2.0148056149827163, -2.224035357608293, -1.1019324504357295, -1.4358630068914484},
    {-1.8473982676664304, -2.4551494419901148, -0.5992865776626349, -3.458515241085373, -2.8942714006119683, 0.14685094997261727, -2.734612559545247, -1.279179187867725, -2.417000312260432, -1.086399564546472, -0.9656677465258415, 0.20496166519533052, -1.939197288790697, -0.32065714348507846, -1.4405181420141866, -0.34301668037174154},
    {-2.8589535422918195, -2.445325248550979, -0.6111150011041013, -1.363456482335767, -1.7353993377774353, 1.6526102072269635, -1.5294586485224178, -0.549205086829449, -2.4624738124017567, -1.7038710269329813, -1.6448170389870274, -0.27712302907263364, -2.780391636040989, -1.3590616786700342, -1.3810741612784796, 0.2682383682384737},
    {-1.4533598019965237, -2.811097318731607, -1.4329554184778424, -2.3367351107574295, -0.9672529514532702, 1.0599649726095048, -2.6792908042805244, -2.0527797501904663, -1.794838707943194, -1.1806981815127973, -1.55859096169724, -2.9660870823634213, -1.6879229505201283, -1.308666024110745, -3.013282944267624, -0.3627954691027745},
    {-2.0907644149677878, -2.4511839023470916, -1.8805874912918839, -2.738590500278899, -1.1080570437133352, -0.5557629645060287, -0.9680599418847295, -1.2401191057765235, -1.2989180620254193, -2.908321908214727, -0.6224035817216813, -2.7730527244353413, -0.5997472993870652, -3.4962897670412714, -2.4389884142632683, 0.18329576553272425},
    {-1.323398649649823, -0.7059617848507513, -1.4922520133871238, -1.3148351347047542, -2.231048496114896, 0.012412901988147517, -1.7226280398892821, -1.4422410586204644, -2.7496208676878773, -0.4519338725967497, -0.98143392731963, -0.8454133228642374, -1.6715584990813144, -1.9149133041722544, -2.1900080579280545, 0.5657063585312497},
    {-2.1765102137176706, -2.6156780942991293, -0.18745473475074903, -1.6290375622554232, -2.7765685807970746, 2.0832690121636053, -0.8520433501936939, -2.1027929309648994, -1.4275191824123987, -2.505005714921853, -1.2334949854824382, -1.0066073470894927, -1.8547906997451988, -1.723953860608928, -3.001889890992517, -0.22597727360281986},
    {-0.27410568073036984, -0.3179092819795705, -0.19413163826591923, -1.1125015076966418, -2.0640744618998847, 0.09927447198099823, -1.5293390193187644, -0.186529291960335, -0.7781884546677551, -1.0900735634512597, -0.40819696811253553, -1.1827228072273683, -2.0458046821305227, 0.4648436059335273, -0.8333495933854522, -0.5710297444084483},
    {-2.254084635565725, -2.782726941352569, -1.867661215039843, -1.8346528368968489, -2.7015978552635658, -0.6606383783459304, -1.091456655951374, -1.6326908791986725, -2.3657467120472977, -2.069652663650636, -2.201863343968052, -0.7506381280646687, -2.9537153644424756, -0.9708219000573483, -1.2556218581657803, -0.5261011895762516},
    {-1.7992854550038766, -2.9528622274271075, -0.8224753047080877, -1.6919891112218832, -0.899396641776296, 0.5811408301452289, -0.14660038265758277, -1.429885897113071, -0.3771335715248334, -2.860654045550115, -0.9188078265349571, -2.424573386535947, -0.5876346047620695, -0.6543132473696872, -1.2258961342433432, 1.256155150024012},
    {-1.8895653202233251, -1.0455517135839578, 0.667973169753973, -0.6564409651814328, -1.4230088457172396, -0.08463885606499176, -1.3297047880056625, -0.7411231828113826, -1.1561612154562415, -1.5384526052095395, 0.25771142812901143, -0.1410845340563537, -1.6570738483363372, -0.20506092932894857, -1.7503865870621762, 1.112779579980539},
    {-2.7655979291723845, -1.7878461450777212, 0.21345471215792436, -2.3202196956385297, -3.997330698812025, -0.15223665237297632, -1.3767596806155378, -0.5815751198234267, -3.1122309973360927, -0.328394458260792, 0.7844971857214098, 0.5524416433964695, -2.0705061160724205, 0.7255778060309239, -2.479207603789027, -0.4407584944580744},
    {-3.100591025904476, -3.9753522078033083, -0.7347327404998546, -2.5085965824124474, -2.8868132035200023, 0.8524933279035207, -2.3533138420726494, -1.9093346369746378, -3.1854896256788208, -1.8421386092494236, 0.0014321475457626976, -0.12827875436917335, -2.7325860673535716, -0.3037450446216738, -2.068820823705491, -1.5330317660962367},
    {-0.8167886045043826, -2.68061145919004, -0.8039461697091715, -1.9168649264613205, -2.1182839843682797, 0.49272436683042553, -3.3497319997518313, -1.593298322250997, -2.6197600660805183, -1.7578090733793361, -0.3330356648370588, -1.33049743881826, -1.3155340036551313, -1.220500830953474, -1.0013690469059409, -1.2002040387334172},
    {-1.9773191640657526, -2.1848396048908967, -0.16573415644151718, -1.0288657544880644, -2.170406701634436, 0.5562124866775974, -3.48374540817926, -1.0258601205073128, -2.7051952898976452, -1.195345800626766, -0.10023970492287074, -0.15931436129611629, -1.4122720480863193, -0.33771695481948394, -1.6926954830033851, -0.9434736037140387},
    {-0.3675289930670221, -1.6446574380920902, 0.6905728814233449, -1.7180173666667782, -4.0346508354324175, 0.36185812607991463, -2.882727026932814, -1.2038843516955897, -2.8093751235915176, -2.6145128288306765, 0.9624357009339237, 0.9826427506637148, -1.122503481974815, -1.19487115541782, -1.2765016164236938, -1.6052499326933065},
    {-2.1971564220617728, -3.3995920275565403, -0.17298044783433902, -3.2589591354028293, -3.6642101062459487, 0.18415719393355748, -2.817862483406766, -3.200957639051682, -2.5330837190223914, -2.6005764433786145, -0.32208590916530244, -0.9546863161386235, -3.131841091987573, -1.8447860691680076, -3.4126638957459643, -0.26072813420658164},
    {-1.7242050363018082, -2.184174831286223, -1.4043949940744112, -1.7853733618803769, -3.7038670288467666, -1.4327288915523655, -3.4614908371034128, -3.3425915575847185, -3.505572838839208, -3.903065239171146, -0.5576261909330211, -2.92944639737607, -3.0480309599363578, -3.0193422315659313, -2.5885611931997614, -0.46674821638692726},
    {-1.0135642875619661, -2.1730032029635855, 1.5423291987074566, -1.4867251862838364, -3.8545175652898767, 0.8328435440210364, -2.8052189685712077, -0.173585735393384, -2.1517274565661832, -0.6474331043308533, 2.0095479741207187, 1.3697873325298142, -2.054857697015073, 1.7601895309166593, -0.8499591458624974, -1.7292920473909053},
    {0.8246376439977449, 0.5747014477225876, 2.6112815510015035, 0.020768854745568825, -3.100650813465894, 0.693933524991725, -2.6672006299367093, -0.30065345541568245, -0.6574774195939235, -0.8849615677349943, 3.5998504625063172, 1.5690163872771996, -0.3984808541737499, 2.1047371299388886, -0.8565961824813182, -2.8831671890577617},
    {-0.17330980164633125, -2.1258925217167364, 1.3297170822459017, -1.1980239831567077, -3.8137364568309375, -0.6286093371485483, -3.498132736762448, -1.2598583149870037, -2.4292831791543263, -1.7104095532501966, 2.1413363967800425, -0.7646861841258754, -1.782992493732851, -0.9104972659610817, -1.5044353922733917, -2.493144024593231},
    {-2.70533058658892, -2.544057555432664, -0.5383155537845093, -3.4107231186840994, -3.877123525844813, -0.5924739653062581, -3.5748862376211923, -1.7287967460296447, -2.9054183125836954, -1.9828521603544091, 0.04798706991332835, -2.071005835522588, -3.4184885990835907, -1.6727610774603732, -2.8542105542022407, -1.9769211150813646},
    {0.6584628266364261, -0.5661614361898465, 1.6215765849178054, -0.7763395917553697, -4.22245107381031, 0.8066565107473853, -2.5482961926241536, 0.6287382242495363, -2.2187181080690066, -0.13061301969634861, 2.393371971795696, 1.2295444630310493, -1.5452000987187176, 1.5357258846847386, -1.644570821584538, -2.0718947483102683},
    {-1.1516142740758648, -2.2032846424964614, 1.4977163953875203, -1.3962473757188256, -4.355202198090296, 0.7436689469630318, -2.4347009672714006, -0.9930175230808145, -3.7924323956070176, -0.8322401244255253, 2.777975245914618, 0.24906910594973414, -2.5741561037506555, 1.1216663943432994, -3.0435139091788237, -2.047488546111527},
    {-1.829398508743567, -3.333784027329599, -0.5978074786570835, -2.125249796368232, -5.092337345455674, -0.6083488334582754, -3.174383617269932, -2.287843124402776, -2.445073864665656, -3.779148398043683, 2.0820590460422266, -0.40030597662779216, -3.2508758788883743, -0.7871378522315906, -2.8867983906919807, -1.8134073639980406},
    {-1.9544564045451074, -2.019580683745838, 0.6719079018655792, -2.5616195491626335, -3.960983502386667, -0.571035750646117, -2.8039696406910206, -1.9945698757391357, -2.578220344105748, -2.9231305920071327, 1.7906247259097987, 0.8008819010636863, -2.869933245564272, 0.8416322297538353, -3.259056768246676, -2.0297668460697715},
    {-1.8891889861727231, -2.957900334196272, -0.07294502297601949, -1.4801631699540039, -3.536855901578032, -2.1027926920756577, -4.355115718912708, -2.248949568542622, -3.3139269538070857, -3.2564189376509742, 2.834161084470562, -0.8205938587459037, -1.61673671946643, -0.5951140300797256, -3.334031707628484, -2.584937585110987}
};

static const float b1[16] = {6.859202253599696, 7.020057609220915, 5.838765720534666, 7.21138464011085, 7.12876053225481, 6.464097776844158, 5.989680058778518, 6.953519005002619, 6.976042404370329, 7.162964974556574, 6.441209066007666, 7.196372577136664, 6.98840265752319, 6.942155021081993, 7.125608675906353, 7.014478887869776};

static const float w2[16][12] = {
    {-3.1501772283889973, -2.4348325298923377, -3.826209829788777, -2.674536171730165, -2.5131501965125644, -3.3541058116509714, -2.9442130935842883, -1.9792506907061695, -3.947021703037423, -2.4111942743310224, -2.9707930936131004, -3.691924411078099},
    {-3.762384375166144, -3.3051097396781963, -2.730329491447346, -3.4628722236543106, -3.1805811880251924, -3.4893285424669283, -4.279714400173885, -3.9640672494482216, -2.8533446852561704, -2.6583172447521806, -3.7558153705004025, -2.5666057091101657},
    {-3.5585292680123337, -3.2220164558928346, -4.135387230084558, -2.7691349558345286, -3.9328398953672536, -3.190701238079796, -2.8071742998793527, -2.6894171127174413, -2.678490794035785, -2.98008312939682, -3.5641517318350866, -2.8843621950668936},
    {-2.7445561107421357, -3.837941675907146, -3.47841286668863, -3.6224081537575032, -3.885948971650248, -2.9541123057828194, -3.024720359674968, -3.5158481240307338, -2.748200352682265, -3.7111258967842997, -2.8637728826248625, -3.5513354119407543},
    {-3.8846604659899215, -4.192442004113093, -4.197410018058185, -3.944379530114859, -3.322196629509186, -3.416629054734081, -2.995771718480719, -3.606082256354886, -4.423605256225028, -2.4791649582682234, -4.5393625578902554, -3.542660978073223},
    {-3.981746047040272, -3.454883165543702, -4.2124616971692825, -4.110649723707197, -3.9976977167408734, -3.805789041015924, -4.053957520482816, -3.570868145300309, -3.4850553920790257, -4.0929690397334655, -3.630017138162535, -4.115976570799246},
    {-3.1212917390241883, -2.623346682064036, -3.356143013329745, -2.4351815857385475, -3.030778506095778, -3.6823162968146046, -3.196177882506945, -2.2463312789484045, -3.298534977281393, -3.295979715358656, -2.119266977412575, -3.3532520259514706},
    {-2.6451297609978712, -4.372279136000295, -3.1424090267185334, -2.5961098121601043, -3.1446635711425106, -4.380347900282332, -4.148363291239803, -4.850838002216361, -4.52642639530728, -3.370821126666867, -3.529912878428797, -4.162390631725107},
    {-2.5102612375040865, -4.381754718819126, -2.8838882083416224, -3.5827812885802737, -3.7415506511315844, -3.7555045789288792, -2.665169709189842, -3.3504118481015506, -3.141102004401874, -4.095391817156799, -2.690828214245565, -3.514758030951289},
    {-4.418126588212607, -4.112704717908675, -3.9500438590012443, -4.514732553132049, -4.541881886597876, -4.296313999623331, -3.0015076979008772, -3.378534267062336, -4.142290340256288, -4.060039369953587, -4.533543757503534, -3.27461218049385},
    {-3.363355874027486, -2.9748145477472505, -3.7629479155056136, -4.1845184017160975, -3.560242528104212, -2.8117479312495766, -3.1462826065479437, -2.8885749777453533, -2.646999012253763, -4.211778575247686, -2.710539148046942, -3.2569777715189887},
    {-3.1519244043548027, -3.60113656952064, -3.14799618277236, -3.5503510024786507, -3.543402641415125, -4.085355298434639, -3.328875091770453, -4.264897146595993, -4.49986361620229, -3.0503196717462195, -4.7164394436022805, -3.8193271757494465},
    {-3.5221175943291096, -2.2156948591509726, -2.459621150187131, -2.567155790004527, -2.9694061250514268, -2.6213256632468362, -3.86835971224683, -4.110422475439521, -3.086174947005732, -3.7448370884228774, -3.935779850124853, -2.877057076625618},
    {-4.066423105704285, -3.4177313555708513, -3.5853343904180788, -3.630110859098529, -2.9906662349182627, -3.333122145425778, -4.5594267583465244, -4.072651314427771, -3.2468029228499318, -3.7317858097855146, -2.6332332893041754, -3.5175381632907086},
    {-3.7212823026585746, -3.3945532112557832, -3.4963285582093278, -3.941223334185447, -3.518778691876188, -2.597191668982369, -3.842753678460574, -3.581581499945128, -3.1451181481326285, -3.894224689519501, -3.376883836466969, -4.013462682278081},
    {-4.006686670047383, -4.018118788510009, -3.5955202585808816, -4.1457195926724975, -3.84889930342668, -3.8118406499270865, -3.923146218399052, -4.0078967065626, -3.5950971123716475, -4.095440622607533, -3.9326756806621277, -3.586294840789781}
};

static const float b2[12] = {-4.552704883290903, -4.357329090363537, -3.018605654973115, -4.139275578238893, -4.460347336710673, -3.566255131176602, -3.399740896940913, -4.091970656033535, -3.640125901775716, -3.4705240897343463, -2.969953430725559, -4.340125314922386};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
