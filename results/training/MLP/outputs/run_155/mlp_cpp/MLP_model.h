#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {2.912327166120877, -0.9945537746771866, 1.0097218377821224, 1.148828102729264, -1.155834682662103, 0.5613868525127494, -1.2171405203763381, 1.4033176631152666, -0.5642075091549552, 0.2609426410379594, -0.9587830619273734, -0.37261441835926445, 1.1634392131388027, 0.08112015438432085, 2.2956753162776335, 1.3392642572068856, -1.4465376512564103, -0.208521775879291, -2.3050865038226283, -0.30167068926277274, 0.014153653006492534, 0.7021803840688624, -1.015185142521361, -2.412942325355826, 0.890005357856254, 1.12096413593218, 0.5172790810096436, 0.6299975802390125, -1.4029768133416012, 1.4142040195367418, 0.809231208003572, 1.121063435978748, 1.6097317892048408, 0.5038917372330741, 1.5144082550492024, -0.4746056304781764, 0.3916119929542238, 0.7146065342056382, -0.8949561846725447, 1.9154752464741365, -0.4036451445546975, 0.43857575170723506, 2.6159384382988096, 2.258980486271375, -0.6727638491440885, 0.8451419122253161, 0.38897157083297507, 0.7602477065133167, -1.6852489529028658, -2.446593653616287, -1.3795640256435666, -1.6559075617899262, -0.6526232340168048, -0.7631654462860811, 1.0533147881962575, -1.7730476673420577, -0.6237801162359575, 0.2106349037824116, -1.3188914561510823, -0.9872818139940109, -0.7226576686144288, -0.6355776160340794, 0.6877581440353687, 0.6770631755406095},
    {0.93631082159304, 0.6068389525726323, -0.06972910025329632, 1.2511228461344204, -1.3647405330210054, 0.25719727140088805, -1.1657092051361655, 0.27608171338094534, -0.8582853837013984, -0.48616977429670666, 1.7802995665245787, 0.4536197610618856, 1.3590705016916491, -0.12340902768418707, -1.6938814531190372, -1.396381298018576, -0.5663297443113828, -1.0813814458314994, -0.9649424090925449, 1.3730364752029915, -0.6760027464650536, -0.9752489988811844, -0.20214588788077137, 0.4489214692523881, -2.0713473465067085, -0.42139148763653567, 0.6972329239991367, 0.14289649495001291, 1.3003121154057509, -1.2363258236598798, 0.30451521363688444, -0.15733021575989006, -0.393269781338387, 0.3175144750915992, 1.3111874277105544, -1.6811226855792523, -0.7451403236624453, -0.5321946715186304, 1.9077882519034626, 2.395429778863713, 0.42506100040299155, 0.51630792931101, 0.7752712617828713, -1.5179652579035174, 0.23162065888207908, -0.8852779212867743, -0.472506251301075, 0.17432706165053652, -0.718410821761511, -0.32061420019748943, 0.29157125564526903, -0.5087561925574239, -0.3560122599994091, -0.6204198011345772, -1.1031698202115874, 0.6272599591385027, -0.6100313994019043, 1.195659831426684, 0.20738215788375594, 1.1944774531116513, -0.2595702573474703, 0.12153425880401844, -0.07269412838559748, 0.6512589527391734},
    {1.2121492333287356, -0.7430378372755606, -2.3667984576454817, -1.529200122336788, -0.9346757905503883, 0.6345490169527966, -0.00421045278157213, 0.3395610680576948, -2.221480822713226, -0.1418142120041741, -0.07185469911771286, 1.9627271733303406, -0.9458184383467595, 0.7540228047092551, -0.7209649334931614, -0.4781239480642993, -0.8252177158770959, -0.11888616809349886, 0.45581013579963436, 0.38531223145189614, -1.2598817929339956, -1.7595768117370019, 0.3026454621759559, -0.9295266857978687, -2.604073605564783, 2.2302723088760446, -3.3123659716867766, -0.5885115096904567, -0.35595769101707075, -1.1337134225439802, -0.7984848851321423, -0.24207774540838906, -0.28921255121853284, -0.7761995405516171, -0.2644189064059661, -0.3329942824848175, -2.0070130327697653, 0.2052364812749991, 0.45309708332750837, -0.9006428761356252, -0.8623271484012616, -1.518415102395171, -1.3145117384125224, 0.823008121792122, -0.24043458398369308, -0.4527828497932435, 0.6063430246445396, 0.8096281436638293, -0.37449637554862547, 0.5048914286669334, -0.7669942242641694, 0.6504851233134018, -0.32984480669120836, 0.2758094346622024, -1.8296761045723857, 1.4965011728986481, -0.7093150027059439, -3.339710540792568, 0.4099199396229272, -0.21296925357791135, 0.8489608605610354, -1.3785442623986848, -1.7449804467733105, -0.25236936570693247},
    {-0.7108321528363635, -0.9978958896453641, 0.4968598811566229, -1.9587302629255265, 0.8528073060224518, -0.8529994466739257, -0.5712083339270198, 0.9178803094703447, -1.1058343359909122, 0.8128582926902101, -1.0111769679661837, 1.535564163548631, -2.0991382923791613, 0.4937662672678807, 0.444925507526935, -1.2080959531739286, 0.12436190217507026, 1.1085088270314498, -1.1940099313443353, -0.7377090944009917, -1.0872425763646292, -0.8323973432568071, -0.588963868214778, 1.550566580488703, -0.48883109212912906, 0.9223242664593782, -0.14638034719887374, 1.2808049354156654, 0.5687133944149237, 1.2362204426885226, -1.7062037258898615, 0.9127871894323609, 1.4709316980475715, -0.034727424664692, 1.2590459226331123, -0.12418227598789829, 0.9494397208843837, 0.17849350868447156, -0.7937174485436038, -0.4237794488248686, -1.613002380780298, -0.3057067013685869, -1.0517729083018228, 0.2987032571447069, -0.05833313724688706, 0.7800975298501452, 0.26382084882665774, 0.5415992206577876, -1.6105595410812645, 0.08123824183897604, -0.6259967020381817, 0.4665703065720061, 0.7571741767241895, 0.3791213867201793, -0.8238646334600934, 0.1845867518231417, 0.13190334910460239, -0.9279090939679878, -0.46401708335489034, -0.18447066629411657, 0.5389120192436095, -0.37994472723545514, -0.9615176852306537, 0.7390715714478365},
    {-0.27559126179989546, 1.6494222891055823, -0.9420733849784749, 0.24055004059694116, 1.0730871549751106, -0.269582424003368, 0.2594824117721038, 1.1620832948926894, -0.8499431492778623, 1.1305939829801215, 0.5891579020238471, -0.9628350656442014, -0.20076918192069748, -0.010787218062283308, 0.3875868241915411, 0.4439623040422439, 2.1120760910803873, -1.0817526580389114, -0.4090824172066084, 0.8087110658813255, 1.0234165659711882, 0.1254194815851945, 0.7093837657047549, 1.1705396181903087, -0.5662059505198849, -0.29345060194296824, 0.9763697880150516, 0.2909956186130478, -1.3671278590840021, 1.4520009373934288, -1.9090124333795435, 2.280603072538983, 0.6192373842097572, 0.6218044681562699, -0.7737074598626351, 0.865723296263717, 0.9327344773127741, -1.1679752183831962, 0.1115412918837726, -0.2522432959286025, -2.192130243996702, -0.9785237114169556, -0.0914268665673052, -0.030406390448340204, -1.3176983958604584, 0.8224333428373908, -2.29522293537356, -0.22202919387469877, 0.8718506609667375, -1.460679461865655, -1.4414308230714719, -1.1630138113518087, 0.17213514298758945, 1.9732871127943503, -0.8758667229919702, 1.2514874472845174, 1.0875082421942723, -2.71516456757615, 0.3682774587647661, 0.41959557185209495, 0.49814947452771985, -2.9531494194009404, 2.1666785867374285, -0.61806795731888},
    {-0.7513352108027994, 0.13245980745210123, -0.7643851124161304, -0.5574299339676683, 0.14125169404700705, 0.3658487073055247, 0.7144700614934755, -0.06748763551424529, 0.8173071399164235, -0.07482708830027285, -0.2155622806743545, -0.8556920864357243, 1.3372696758791616, -0.9519790028307125, -1.4521124764118807, 2.8613080321754882, 0.935196831316709, 0.17753511002117953, 2.261073817441031, -1.1310187273597192, -0.9720612328841602, -0.04936117716212051, -0.017091219559806813, 2.1561830023617894, 1.6732712152600857, 0.5522680678694911, 1.8729489138620623, 0.4453938751928535, 2.529500751491548, 2.5111763148671713, -1.9963526587435025, -0.3012292039770053, 0.5039825541092477, 0.18008290355137432, 1.6249531832663726, -0.3106786773371581, 0.3609391600364428, -0.6824155168953449, 0.9247719178121088, -0.6306736079554179, 0.43158255650470323, 2.0177967725267845, -1.3066330838009992, -0.44953551745294074, 0.8124986291680287, 0.44573889440725817, 0.013255353646967985, -1.0920971299718822, 0.8320193546013233, 1.1283481377249176, 0.1624719930772011, -0.1639059394063036, -0.26275148381005764, -0.2716463437583806, -2.1262164176952885, 0.7763761768288504, 0.25272102467192287, -0.7595731063724165, 2.9020089697093545, 1.9951500147407015, -1.5817860009483977, -0.913154056185234, -1.4575253206853822, -0.6553927905238686},
    {0.7399618334800252, 0.4886964474308762, 0.1552124906971369, 0.17028588446751397, 1.8129717156203573, 0.44638332597182073, -0.2110570666806279, 1.2002532973942117, -1.748622574279533, -0.35909850045981767, 0.36566840097254766, 1.691769328287376, -0.819750624377526, 0.6614543093896516, 1.213481188456159, -1.6866988433310086, 1.8668526115209567, 0.3433204788823616, 2.0107626669412157, -1.2806761783715268, 0.8785610720646869, 0.9904894977776326, 0.43274926949496134, 0.7532658604871311, 0.209985958779694, 0.7399549994790414, 1.7730181611548308, 0.341629796830719, 2.394546070506075, -0.5713655351832208, 0.06830953068101636, 1.706729393435315, 2.5448478146955464, 0.7523650378890259, 0.05499706840104498, 0.9663386853428069, -0.9823496769640725, 2.168775219497251, -0.34457411912097363, 0.22266029898435022, -2.287402289809023, 1.6871842207239018, -0.2566119666909078, -2.024595448577075, -2.33484588672697, 0.505475681765212, 0.5298091080477275, 1.2521635134568765, 1.4277738352928768, 1.0126694469634092, -2.178574733807295, 1.1125951794686748, -1.051470460357851, 0.8720208473211474, 0.33026085429686225, 1.2444282770903379, -0.6822515411088509, 1.7439139501163865, -0.7077904304563295, 1.1388914834648867, -1.0088864795122532, -0.17940937772263316, -1.635152782170826, 1.6671110945817396},
    {-0.9321011131225693, 0.20702364795879502, -1.6861970636512833, 0.7151439762491147, 0.1503518877856655, -0.12451041475450195, 0.439455337883838, -1.16024265045595, 0.5580370192173919, 0.19312531228724725, 1.091516917512029, 3.0627430865650713, -0.17029105264311972, 0.7763910385998902, -1.0458862453563234, 1.1203559429137138, 0.6271888787822998, 1.4783500064290127, -1.4614868728662784, 0.8672867226627444, 0.2830878739689122, -2.609061481827564, -0.3445235808040235, -0.21400127555306553, -0.5315930198699242, 0.020118835915706304, 0.9523377119626606, -0.19038108691924083, 1.274412330438, 0.6725909470873291, 1.3414184852112674, 1.5192537796911927, -1.511139696647605, 1.6158799615956787, -1.3526426036466757, -1.8868065091673858, -1.270417681446809, -0.32855445488901125, 2.8822018497695883, 0.7782301014989714, -1.178029785399823, -1.6094189536040797, -1.4937866603301673, -0.16994310680593766, 0.548630488367773, -2.2435392992531744, 0.5596733429403083, -0.584956676710648, 1.7192035526165301, -0.09841244468113147, 1.5025129932570587, -0.6212700087246246, 0.35153594761119605, 0.4935898028701504, -1.731915898732323, -1.1717507540030503, -2.3689983984226504, 0.14242181438474397, 2.0138996384064622, 0.25480276200225055, -1.825513119526244, 1.181150610463904, 2.790014124172487, -0.33047433173824786},
    {-0.8436376919423824, -0.21345633476848586, -0.2707308969891122, -0.13136126798768882, 1.4170292880554403, 0.1435574589271897, 1.4510991247582996, -0.05790589592413284, -2.410234261300466, 1.0225599307886934, 0.2143474613070877, 0.15593019539921696, 1.8541237854279344, 0.3312389834149211, -3.1160562184993545, 0.25640729014978, 0.7087180084464773, 2.2477498446590407, 0.003869646459620927, 0.11275038226177882, -1.09942856253899, 0.9867514384473876, 0.610135102507255, 0.5332757239860292, 0.5673766070427931, 1.0305644446697804, -0.17277041995426645, 1.2305312704425881, -2.0808116670501, 0.6552900768958589, -0.4980513904059213, -0.8147654676103244, -0.06154989689674895, 2.0701748622322604, 2.0314132999088175, -0.5566280288739313, 1.904614040570974, 0.8726853271401815, -0.5697618092640324, 1.4711832700470353, -1.143651663696627, 2.3116847491166634, -0.2512626881263494, 1.519085721417796, 1.1496632926667438, 0.5457746870019909, -1.0021641379631956, -0.5001714206541337, 0.7674787777730262, 0.6108032048016554, 0.856455457737382, -0.10614952613755636, 0.9907502961189676, -1.2108065112457158, 0.9865161758530153, 1.4654962500920983, -0.39614066701334616, -0.7119068040572217, -0.07701906683775402, 1.0909356558217445, -0.05387128769467028, 1.709802638959825, -0.9703337019657391, -0.7706580292243018},
    {0.33486387501062553, -0.541739355108983, -0.471637295057904, -0.5344358652834507, 1.761968489447396, 0.09360019739795657, 0.8475714524805633, 0.5217757350466378, 0.4134171644380801, 0.45763520959250525, -1.0521659441842937, -0.5850785492057172, -0.6023107934108637, -0.23331079385817205, -1.4465956960055881, -1.4809790197065178, 0.0169443338639627, 0.3340681346948779, 0.23849465931834485, 0.5739165291060577, -0.3348550604661443, 0.9210530282715035, -1.4060813535449213, 0.06412832534793714, -0.16821561136965296, 0.7658621055045118, 1.135642827341518, 0.13606627430858395, 0.06360207151089421, -0.62736800897544, 0.9434147451565336, 1.0630586328583371, -1.0908383409516642, -0.6216959860484355, 0.11758412760295436, 0.20018943153156796, 2.040667035749701, -1.1282223773954843, -1.248799587779698, -2.4270566326253715, 0.3110399928607294, 2.115599160243999, -1.3277372157529377, 0.7748297219455582, -1.5530538808595982, 0.2662298375930965, 1.3713965425457828, -0.40064924342361297, -0.9068432437539652, 0.46182450607974374, 0.5293755590335544, 1.7840460435052043, 0.6740349809742555, 2.904239601267327, 1.3376322362083415, 0.3681167637017325, -0.03335104923216909, 1.308411439758175, -0.5215989416871415, -0.27238365838129225, 1.2134813069118022, -1.738453868143471, 0.2695937011249679, 0.48390032389962395},
    {0.7298832011586427, -0.8743579508152036, -1.4468022527183215, -1.5643677804057174, 1.3379964688141062, -1.171459029673315, -0.47448392238955195, -0.3140188549702159, 1.1447917359963478, 0.7221414520166445, 0.0626973310705975, -0.9551831969758268, -0.9298404988461134, 0.17284251754579955, -2.031867438812717, -1.3728160182864682, 0.571606087723413, 3.146513298355278, 0.43770217952641166, -0.6344535947255633, -1.4149233186534789, -0.284770317429282, -0.659824943818977, -1.1383915306136345, -0.8964814988164196, 0.7359357858206768, 1.0691915173531021, 1.14735187503946, 0.23410465441505882, 0.8877508018702195, 1.0322152130550242, 2.5084315892402214, 0.30795322373927464, -1.493431210987026, 0.17999535728857158, -0.8767652018789884, -0.7902184088694482, 1.574288638449728, 0.1386786810676095, -1.7114836176767865, 0.10946607267525513, 0.5177705353210156, -0.48684023890864997, -0.3630691783687149, 0.5606329799208398, 0.36207826452784275, 0.683786122316174, 0.627022142352981, 0.4376204380974828, 0.55228668878115, -0.21441629875156992, 0.841646465401201, -1.862320261092519, 1.4865005342245403, 0.7293152507608631, -2.0191221622777777, -0.6635606376838095, -2.2896416973617963, 0.41368287162926787, 0.9882736503270829, 0.3613905665907886, -0.029873349776136683, -0.7716793930244759, -0.6229263504048328},
    {-2.0119427822219076, -1.3431986131198155, -1.3269511489337837, -2.6033104717218136, -0.3997427863775171, 0.617660564158303, -1.4352544593634375, 0.7061219701982285, -0.3915730189452018, 0.12551865838334145, -1.3768740099830055, -1.0541229885352243, -0.7523372278388266, 0.13424743407247774, -1.249746498351918, 0.25575091396089367, 0.8690689429308284, -0.8231838496690584, -0.9321716207560494, 1.2428678215490352, -0.9789371650324502, 0.12682400038922062, 1.5734927614948317, -0.7862225543097539, 1.7180550466291218, -1.055673176194485, -0.07082801494446711, 1.2017482530124068, -2.024454430172635, 0.5218124258859542, 1.292502276482307, -1.7995226897923753, 0.7906560192970946, -1.0182786100643137, 1.0567430019206778, 0.9743931040616757, 0.42969421337023, -1.2152810683641695, -0.4432413289907789, -1.2082036402645093, -1.0198205324896552, -0.7767658908591016, -0.21690794919806303, 1.304505605557795, -1.624159403473293, -0.40802595232982797, 1.0913280368938687, 1.2907720797127975, 1.5963600024341922, 0.4009313855485063, 0.7462452711747835, -2.0457391164770073, 0.25895499087185403, -0.7915586110531506, 1.5070530611390383, -1.0185490621358884, -1.945009029535022, -1.502914758674644, -0.22897550725462537, 0.6870899084814659, -0.5887415752603848, -0.12588317356743123, 1.2765382458189072, 1.9223739420508903},
    {-1.352486386023336, -1.7917536083199788, 0.1365665727548144, 3.0942331781258434, 0.431021547885854, 1.6255916175523075, -0.5592266645358387, 0.41102569877719686, -0.09738541799195878, -0.24718029947244038, 2.0369013436303254, -1.2820713674690225, 0.16758974943473018, -1.714342812155798, 1.4903943528701369, -1.0730396653495722, -1.367235114322419, 0.1700431884975751, -0.41924112904265476, 0.4645705993911078, -0.10110943238640559, -0.4476433241385756, -0.6216093143794236, -1.5296677719271643, -2.0129899821004447, -1.9575587083283013, 0.6906541957414556, -0.8721800020788834, 1.7991952195549916, 0.42828592655066733, -1.4650568195606204, 1.3155043851662658, 2.1666061230188802, 1.2412963994464916, -0.8145352115908348, -0.024138139705276816, 0.13853340618150844, 0.5041861250628689, -0.6528635576686116, 0.8853002902032837, -0.27309169782037657, 0.9668962736457403, 0.24406357181813965, 1.2689292839961372, 0.8254814787039274, -1.3240569954227366, 0.9009536212915661, 0.004018917130689778, -0.5269518612803769, -0.8305977728988219, -0.35727136763808465, -1.0664931171158638, -0.7744699602317041, -0.05663946788033427, 1.2682967297684762, 1.464049110353935, -0.6317964147779431, -0.5689777294549226, -0.633074494984598, -0.882778183935075, 0.3870776867405479, 0.6807603203972115, -0.13336786601006848, -2.6266759092389282},
    {-0.7807671284500836, 2.458621882493527, -1.4426784846666552, 1.5444841587394142, -0.8689762456069321, -0.10832643225137914, 1.113128987939776, 1.1290203593149428, -0.009166869140972445, 0.6338332068402864, -1.0529700392007089, -0.25827801149175605, -0.49762379500456794, 0.6823712129064678, 1.007299976278261, -0.10401312283486505, -0.9673204427523093, -0.6828390985902469, 2.1788661526915583, 1.9131796768188793, -0.02775143599290462, -0.32300868692821727, -0.6885453097876983, 1.0510170550268303, 1.1737566265317951, -0.8441469456798188, 0.9274472595977904, -1.077763915107827, -0.4721474284580187, 1.4642540791838405, -1.8901182465933282, 1.0096714231567874, 2.871469078560709, -1.2955316485952468, 2.0240926872220557, 1.7953287285873811, 0.11925567723288251, 2.3205500930866205, 0.9130210083449664, -1.697734729976348, 1.6858589865505504, -0.6713685998081254, 0.02888979097505653, 0.4188765758078701, 0.9034212477709491, 0.18078706366472136, -0.10501383890771267, -1.513357531385598, -2.1559439491137056, -0.5259394832105303, -0.8096270856334892, -0.2504858137770984, 0.38727891930288916, -0.9570769651377549, -1.1836414977193255, -0.9952389494117714, 2.176670103781876, 0.18869194614592955, 1.6157854736519008, 2.124935751735157, 0.917933789253946, 1.2178891250538226, -0.7665888263928963, 2.193250199588381},
    {2.279019838657927, 0.37718568404184444, -0.49179232521319344, 0.4355880827425486, 0.1054834600353962, 0.014428296217435022, 0.4388361266163988, -1.5603783974858016, -0.24937773590333656, -2.8591905589192677, 0.21478472462400727, -0.34709347529987533, 0.5691322881342586, -0.16093111299097265, -0.8917552889032487, 0.3116986739815374, 1.5907039877828713, -0.37193072644551933, 0.41148830691271104, 1.3466852639915492, 0.11435250259823265, 1.2581668692500845, 1.1730982486714616, 1.6258891197177054, 0.46618840941703016, -0.040863931610201416, 1.2473548017877796, 0.9495151747751421, 0.5278693655261582, -0.4020806185016651, -0.26467695466671065, -0.7049504908374236, 0.48977032519570285, -0.2530693902648097, 0.1337825096717071, -0.8443081001982584, -1.2729914589727913, 1.2846177186557692, -0.43466961739583243, -0.40263505383879095, -0.15040282367818972, -0.9797940985280023, 0.4535710632147567, 0.675939808024202, 1.3056464467729587, -0.24296703842949605, -0.8335595660863844, -0.4124222778699039, 1.526377284607767, 1.5307306614356855, -1.5045656899599436, -0.9826025620395739, -0.36067138183583547, -1.1510728659053828, 0.5087437256948237, -1.6298452267473662, 0.029119965605466928, -0.5676613542304527, -0.1466748866338038, -0.2755004547958426, -1.636183307748657, -0.41151560108188534, 0.9452319652019799, 0.5940194828644999},
    {0.3576974684173265, -0.5684046277610947, -0.20523517937205973, 2.241889874968325, 0.2835018194208166, 0.10812789870059752, -0.3739786874746742, -0.3028771673140114, 2.501617917513768, -1.7951430561296002, -0.649342243114817, -0.04053852036562987, -1.142068183387525, -1.3462908281613097, 1.2057104839300175, 1.2704834007527919, 0.9008639610406469, 0.01894458254979095, -1.1819358739020063, 0.025347133930840305, 1.2720355818015767, 0.29947936216077786, 2.0904918399228647, -0.7470950123212053, -0.252749926663131, 0.8082762658830968, -1.2527677784530005, 0.9367569079497571, -2.451247081372303, 0.2518459543124375, 0.34167812255704016, -0.3026106789302645, 0.6689657369995218, 0.11106751261439447, 0.3337197034270315, -1.1853562866186098, 1.6963593498290137, 0.4336691737600189, -0.13990832547672918, 0.23561776421342892, -1.061970275590785, 2.2424263829915954, 2.800205247288006, 1.1062083799488895, 1.0926503164973311, 0.5272372840023062, -1.2555050671609695, 3.1615975431529475, -1.0734163576259397, -0.43281646158019427, -1.2226769314094583, -0.2574592562055101, -1.4928921768420762, -1.1040684059323798, -0.5912934789185912, -0.2210821202874129, -1.4642864249528158, -1.3211167411899254, 1.3833777047151998, -2.431991526845753, -0.409412812153505, -0.7857890014210346, 1.6756392195663439, -0.7884270720166094},
    {-0.32827625138340444, 0.554873753522996, -1.1905808595091352, 1.7809272879906475, -0.015560224555000132, 1.2228798264427643, -1.1392737385086438, -0.6554004285316314, -0.22323739208101884, -1.591784595122147, 1.0409905530616932, 0.7298648435696222, 0.8018264440544532, 1.1923834748943718, -0.9189469768820595, 0.9794745115972795, 0.9808437347826002, -0.4000468620623347, 0.7146561899415944, 1.2638309048139607, -0.6625395428522225, -0.501518371586803, 0.2093464718825858, 1.018726535595375, 1.2510126091682114, 1.6885045719109946, -0.11983423874865315, 0.1351359687950265, 0.19361241245905877, -0.10286927781201112, 0.10722842855622501, 0.49737720204464936, 1.6041990246707243, -1.4075626649206978, -0.5794067543294984, -0.8542370816620322, -0.24313795964450538, 1.0315947526082827, 0.9190912841124246, -2.076589875157852, -0.45105704549046366, 2.1046959367145317, -1.4108951179688505, -0.4716672237846897, 1.185185105325014, 0.6906723421496921, -0.6625561533859096, 0.8172560414048006, 1.6068994939956152, 0.15142538430598892, -0.6048271903084022, 0.29683535445775344, 0.6314974279715175, 1.5433221946384292, 0.38028574999845677, -0.44430093010079275, 0.8111697333009533, 0.6794809282819113, 0.861424549476349, 0.18962651118685975, 0.1707489195307564, 1.709402633409894, 2.2100503895921433, -0.39477495617632924},
    {0.6698002751398507, 1.5113429015690454, -1.1022161411725888, -1.018028378516878, -0.4117637579702717, -0.2771881585720702, -1.2564403637331372, 1.3979293243350732, 0.9457749297251192, -1.0173063781759337, 0.9972852162550983, -0.14538938457576303, 0.10009592117538879, 0.12556366761503185, -0.6922579572097148, 0.8292316012305648, 0.8551452271193526, -2.918532517335834, 2.9635809925557446, -1.5065949956846434, -0.3725546462820013, -0.9336016833744502, 0.4349815206608488, 1.6529835547673015, -0.30656342353439375, 0.5261477542478794, -1.1402559474194136, -2.288267027331396, 2.742946402571493, 0.9169485573763205, 0.25291223840064725, 0.07181482150681924, 1.1564615734738366, 0.1333038532040102, 0.6897012346880725, -0.6689684936852266, -1.7050705426428316, 1.1499951914950848, -0.5809633075219641, -1.9827424920540089, 2.1147595011837588, 0.644496454236672, 1.014823186558708, 0.28431021456418154, 1.9362584810137005, 0.5182161860479721, -0.5704189269146515, 1.5721626726561186, 2.018449035390668, -1.0241843342133483, -0.4600533952336595, 1.361981876553874, 0.602095206328654, -1.5091877941865037, 0.26794460303619216, -1.830393719318686, 1.1988482353689922, -1.259340592452095, -3.2287807367871624, 0.38843586713465333, -1.1283001476432792, 0.25228634399681976, 1.8282314149964003, -2.278390929047527},
    {-0.8327429688820245, -1.2166273288818, -2.3511472300245306, -1.2673443421756845, -0.5100701825021081, -2.2637014689110075, -0.5754076781372304, -1.2375355209387524, -0.19043125401082894, -0.997081356012022, -0.6521027066046715, 2.5262853638456555, 0.019740928822267467, -0.947558628992394, -2.2044275595488556, 2.9618527466801754, -0.2886428677529797, -0.052081237014531524, -1.7630142668687452, 1.3290275056897853, 1.1580132699182593, -2.106630979999736, 0.8165069943312832, -1.3619689241719481, -0.06984898211932905, -1.2445255501838863, -1.19048132518753, 1.6366599280244123, 0.194179074065672, 0.45333329184753046, -1.3120555781477525, 2.4358255585981636, 0.4750321864234306, 2.3281716556907144, -0.052029744456811265, -1.1461470201957167, 0.18918714706145018, -0.8430488256642769, 3.121181808687617, -0.05341503954459892, 0.878189473450797, -0.26183868145920947, 0.00945696839885705, 1.7534355545111007, -1.5942779726589236, 0.30850515708524673, 0.5694890753510591, 1.5772806894574636, 0.8449627125477229, 1.5574840484642007, -0.5742556419978169, -0.25020607006931106, 0.5936642931741665, 1.2844509025620956, 0.7016014183643148, -0.8833875462977339, -0.41293098073465406, -1.5025918864321253, 0.775526931164642, -0.3169287614610065, 0.7254798924101995, 0.5755779913833903, 0.7801241014647226, -0.21832342072934618},
    {0.8635542362124293, 2.9559097426930947, 0.7571361346677099, 0.4580990072925448, -0.023815354133828345, -1.0075288915130942, 0.06930823972114886, -1.051286463574547, 0.549265226591419, -0.6688937126421166, 0.8229486710597184, 0.366928765681777, -0.7156137319187468, -0.5086072557985942, 0.4224344160814608, -0.7134265100917303, -0.3881816719556425, -1.1593908856683786, -1.7252503459698612, -1.6863206713178738, 0.6132272482754425, 1.9631955221638016, -0.28312122129511413, 0.8124815089318963, -1.415925609420136, -1.1486622449136223, 0.950250132729884, -1.3490512385892046, -0.21408334078388572, -0.984654641682641, -2.2722384060718466, 1.0582886709231343, -0.36981991824649196, 1.3638241418627222, -0.660593244658109, 1.2472183698282044, -1.3644488277505982, 0.7229742809888612, -0.7368440934064701, 0.15107515789497972, 0.21430339182464728, 0.6569870457880584, 0.44202011856080003, 1.0937931197836668, -0.7720061461552876, 0.1767102776791893, 0.3768677395736361, -0.2290325374545406, -0.28452654283467477, -0.379557221639349, 1.4598686928550348, -0.0746093605640684, -1.0870418738606864, 0.6256408221103271, 1.0716647196759674, 0.6451763828520046, -0.08666939584037972, 2.849285301974158, 1.9048643571644246, 0.9233101268021514, 0.8788246839661231, 2.495197524545086, -0.5837345118136353, 0.7884549994403997},
    {1.2282253464157036, 0.23439060662788672, 2.1279061458592623, 0.07843582401871622, -2.2367840038465374, -1.5221750789689643, 0.09385134074270161, 0.08102696138939224, -0.8264464787166415, -0.24222120732415994, -0.224193900183768, -0.21978509743634989, 0.7509205530190206, 0.8194868620625523, 1.2877314521405119, 0.8918125830571352, 1.0127276272795134, -1.2574747752353954, -3.776693433051462, 0.7605283035221034, 0.7627722467941263, -0.9331139974079292, 0.9149161309610442, -0.5093560895024306, 2.593769353119149, 0.597146939968552, 0.195122790573176, -0.08668786945615899, -0.8285138538060876, 0.3357177552654018, 0.3394611191709875, 0.5652553229221916, 1.0795451146694448, -0.33625869059455393, 0.18931971194327668, -0.9359899341199965, -1.490035339596064, 1.0620722482253482, -1.9906526550997226, -1.44709585810173, 0.4300044864191087, -1.7440693041820263, -0.49347962552306807, 2.960329437735708, -0.049059771770720406, 0.5420366449862491, 1.3257113841097175, 0.3577603022051353, -0.9067577492667556, 0.11591763912682433, -0.5171481659752167, -0.09324284752756852, 0.5174464668281048, 2.159743227141471, -1.413987976406223, 0.035449980457383144, 0.1824101845354793, -0.4793993098824392, 0.6554511661682407, 0.9667363858589637, 1.4017955533048627, 0.6989393952675689, -1.469601814316949, -0.3880265424391894},
    {-1.9369266227325135, 1.2049182429164607, -2.95471342178728, 0.31408929404477126, 1.0104934949396847, -2.256528322790374, 0.8081447613827709, 0.45624062076808664, 1.0253053027880918, -0.6771742141703293, -1.1011665515860563, 0.48484723032298094, -0.21046826104271962, 1.8406318979281422, -0.5601040263355388, 0.8818442332337229, 1.8116701428523854, 0.4375069567905849, 0.3145903227014229, -0.5770684070911566, 2.5326873777674543, 0.597646339174362, 0.7286956544987173, 2.305179944264436, -0.5827691581255668, -0.12007335522195874, 0.38527512299853794, -1.3197399524394062, -0.4247668653599429, -1.8597614939245874, 2.8655135078272607, 1.2636724944358722, 1.2623230246328467, -0.8481037246826872, -0.3935498818419399, -0.8108146512606307, -0.0694842497886877, 1.4289641502195989, 0.2120847626995461, 0.8147523269862121, 1.5467077826555373, -0.16383261624674886, 1.179196882658449, -1.7158848858849027, 0.36709910660778106, 1.0222611834623867, 0.8715857201642422, -1.3955276618031573, -0.34922431387032904, 0.8950172952940612, -2.2473376036917516, 0.2883118773207627, 0.7480707524116925, 1.0342038685273345, -1.0392341686401074, -0.7467392894036767, 0.8276439332483386, 1.3530667762790891, -1.579225544716133, 1.5723048217534565, -0.08486162664931446, -1.360490974287256, 1.9965012856655053, -1.030036102401192},
    {-0.32433931772164776, 0.8442364607494699, -1.1517529009776701, -0.06828781181548851, -0.30004886641709844, 0.24166684415790407, -0.747182051461605, -2.183675407108297, 0.29209028341284293, 0.5793859011036958, 1.0348376495499683, -0.8335673169851854, 0.9130148212017144, 2.4011552966881293, -1.4861256048207145, -0.6953040087868689, 1.596523428450312, -0.07241903624478424, -2.207504410368123, 2.9888888428371065, 0.6868079145880571, 0.8319986175151595, -1.551005803430376, -1.9024493393087039, 0.7733778360187717, 0.4031196291203968, 0.06669675827538814, -0.9814448304648185, 0.529798075284455, -1.2552165832652296, 0.7584468787413235, -0.615966824267156, 0.7037882428236395, -2.346606959423591, -1.790296515049205, -0.6769262413519298, -0.29792067501796626, 0.09145772579958882, -1.8857358094058116, -0.4307781477476545, 0.4715749598806209, -2.6295775544130784, 2.0462350573970647, 0.7973709858992969, 1.0279711921463444, -1.611587905821455, 1.3280312684521123, 0.12970494185193052, -0.19365506616432704, 2.404386723389618, -1.3145842152185676, 0.06700285792740943, -0.875007578724655, -1.3687140020023107, 0.905385644629604, -0.8487155293933188, 0.3124353676605003, -1.4978612909306412, 0.18150531965505012, 0.491972555630967, 0.4044493227271603, 1.0544227005643514, 2.030434484344663, 2.0108684672430086},
    {0.3321681123221939, 0.3470075686004406, 1.6754718241621185, -0.1091530292747877, -0.7503941200059496, -1.4345213893755018, 3.53509634582589, 0.09868919121746478, -0.6734616490258661, -0.9454048335720769, 0.7882051831620334, 1.4377380960939061, -0.08963247767188023, 1.2817421120629158, -1.4104316683215037, 1.5967305860949108, -1.307733127452761, -1.0488070248287302, -0.6811300587237774, 3.9888896045781195, 1.3789818564943483, 1.820890373783373, -3.24786954546727, 0.7212960293387995, -1.17323550363804, -0.0640490725578953, 0.254889876177975, -1.4979657012276764, -2.10053805257974, -0.6105805496365194, -0.11262763984961488, -1.232838440831787, 0.37550926403097895, -0.6176770395338643, -0.4104049917316371, 0.09850996486199368, -0.0649751663030874, 2.3781665685327815, -3.47859402444996, -0.011558774512592665, 0.9737131419513007, -1.417583905679577, -1.146822645084194, 0.02922910301138908, 1.784599675920185, -0.5235392897499604, 0.25865296337310195, -0.0913573395266773, 0.7606684358372753, 3.109983350196904, -1.2440038032076346, -1.597522584171435, -1.3621822368218597, 1.4219085348402616, 0.5878122043011293, 0.7118722456400275, 1.7619477804808616, 1.1648510348957104, 0.5661714219971427, 0.730438224959643, 0.7822428530103608, -0.25854906256569316, 0.27147652202117684, -0.6104998653198022},
    {-0.6184565390861897, -0.18966111068223673, 1.5925965287931612, -0.12118813836496523, 0.038765728656035704, -1.3418707153129799, -1.7791438029668498, 2.9316481294063954, -0.19319259160576663, -0.7180208848563392, -2.1442720713309833, 2.6968473454514394, -1.7083987017539057, 1.2094062484367134, -1.221490018498958, 0.6940552059313656, -1.3183220756660596, -0.3896451167499354, -0.2709189119989713, -0.12433374955573441, 0.6365538189310593, -0.40270266758511897, -2.7513055618128646, 0.4194203862231914, -0.21818118646781776, 2.9166818320432517, -2.4698219609639667, -1.8033138312089316, -1.3199482806666762, 0.7238234623265943, 0.9347271861364387, 1.2755863339836386, 0.6715428740096291, -1.012271477823691, -0.06262063851691681, 1.7329301941165072, -1.075283326548856, -0.3980203724238032, -1.7474670604892002, -0.1997918303440566, 0.31267237176579943, -0.9331574262297313, 0.5222588023585688, -1.8553737485240658, 0.3581948499479732, -0.6534206625656651, -0.8274946466959026, 1.9534717231609258, -1.4034395021739967, -0.3802586812448245, 0.21524017204394544, 0.07756275542426898, 1.0873436753088126, 0.5899620622158332, -0.02398942581471105, -1.2926923297793393, -0.0395002036847893, -0.24231552174818607, -0.6629391731483018, 2.372843640054753, 0.2039336365352865, -0.09032736053461232, 0.9985888947820272, 1.8085636637061382},
    {0.8773380745271867, 2.0025878182692414, 2.661521771509591, -2.7086464082692565, -0.5485135033284471, -1.5753291140433388, -0.9104149430844612, 0.47546770199875715, -2.182981945565552, -0.15307547891964687, 0.5414929629866997, 1.2558821640969142, -0.018186788191168438, -0.06866912213981924, -1.0778139999003038, 0.17907266457812984, -0.5310180449594406, -0.7308502773824347, -0.15513186005884508, 0.4679472718831414, -1.215137338127664, -0.4173893210280796, 0.7838097968987366, -0.7225156597578241, -0.11024744837677558, 2.7976311831638045, -0.5785457190619724, 1.0744074228445373, -0.8639529223140378, -0.46574984949246284, -0.5355163531815527, 1.287478619511523, 0.6053257028586004, 2.1024770940522997, 0.1996773279691118, -0.8010092306107803, 1.2870016798814552, 2.492703354137094, 0.3093794581803436, 1.103531676750801, 0.26096019635566037, -0.7054931658883734, -1.5083566714889087, 1.1257312221358091, -0.9109735752114415, 0.5907474937437067, -0.4793827713988231, -3.2930827904793887, -0.6198691836485182, 0.07937298827857363, -0.8222869666378572, -0.8434673376180736, -1.3140416904106378, 1.7560633620015957, -0.25959094380577863, -0.5994718381415356, -1.1450583910084258, -0.10789496789979978, -0.22638103072806556, 0.2743303777185276, -0.05049068201393819, -0.5564000398054513, -0.08254026586538593, 1.9549884681170682},
    {-0.8298620711120269, 0.9530954878229443, 0.4917049445438588, 2.1324705656575644, 0.16617277837177885, 0.75955884762671, 1.6228296355541327, 1.9833466275748928, -0.7176208735102476, 0.5145441395606886, 0.24729256007456754, 1.0606601553824884, 1.0252342024665324, 1.7710326785249393, -0.3797653925698171, -1.8665425585768092, 0.17177245211211165, -0.5322668163498714, -0.5085720094445834, 0.9136520594925684, -0.16831358737735472, 1.046858048642372, -2.297499388551781, 1.8204289885892162, 0.6218737349393946, 3.588844322696392, 0.4121661374662282, -0.2191060367191385, -2.6704494590370706, -0.8357332766405965, 2.2196442148041324, 0.5772843580094631, -0.23101679146111948, 0.9750425165037516, -0.3820100576481519, -0.3872281519057195, -0.8684469168071576, 0.7853372267172224, -0.544653063007751, 2.6069281275843053, 1.086446921681307, -2.8959036208410858, 1.2793715969497856, 2.6005923239723705, 1.3382061585550047, -0.9453796934327057, -1.3578250422955098, -1.150926879690062, 0.7779485367321555, 0.9710013269854959, -1.7711381384869738, 0.05815434531330009, 0.250148671584433, 0.6785831006943756, 0.0016512254848384473, -0.057796341296806775, 0.5372640051292324, -0.4637417470948392, -1.3543118215661667, -0.8901135112127908, 0.6442324694128436, 1.09644220394604, 0.5082415167102629, 0.5692992963784942},
    {0.3142171849344083, 0.22899150056990347, 2.4560882473234558, 1.815913067956195, 0.9792999037243659, 0.4518837556039899, 0.4196216521142899, 0.4006588310345779, 0.08705704185489693, -1.652719001435835, 0.18554473938294538, -0.4934902170090656, -2.1615837935849886, 1.03541565381549, -0.834819212621305, -2.0792926926410975, -0.978366203486075, 0.6627134231175259, 0.7985210984873587, -1.9080095810909032, 0.6448433629408847, 0.4976061758745307, -1.43601937276894, 0.5374039568805091, 0.6360631469714735, -0.4209565878182423, -0.14814679071085254, -0.941295529615371, -0.8150315122625509, -1.658841945208825, -0.7342717140733626, -1.460941904505535, 0.4813766825538223, -0.541826616375941, 1.1846679922010506, -0.9117067356402859, -0.8088812931398229, 0.14793881646852314, 0.265379229127803, 0.20471558232613218, 0.5585911718466925, -1.377289658150309, -1.3199302212546447, 0.3855459393310051, 2.146195242689513, -1.6567803644161812, -1.2917867430165462, -1.2437834714378688, 0.6540182824847648, -0.1707355497488582, 0.748551813818165, 1.7782774478183394, 0.4126313636039103, 0.3849735375614724, 0.5623277014473752, -0.7762697205233149, 1.1275984205847245, 0.46698321735874937, 1.4892620184108967, 0.23694765639770435, 0.16954134020948136, -0.5309405693983716, 0.7608840043441608, 0.6633958131692332},
    {-0.05227754572998977, 0.34116743271675487, -0.8925024043826498, 0.8306056572622393, 1.2509044153586673, -1.141767819510583, 1.7057329403453638, -0.015835502911976523, -2.7795379790037527, -2.00687957357024, -2.3245265346337964, 1.6353420799310463, 0.16291045349024635, 1.7588059865957668, -2.229626825840332, 0.34200483061449694, 0.001501419068827071, -0.2300000717911117, 1.6437466963152954, 0.94762222792831, 0.7541824661947149, 0.16946613088353193, -0.2848969120111482, 0.49615653315620967, 1.958556594468045, -0.6510422380067242, -0.6652955126107932, 0.9101408592790301, -1.0128341493086181, -0.6452362682466566, 0.7071165340963468, -0.35577844757168825, 0.982356858226952, -2.114649266854661, 1.7117454744547438, 0.48133467918074047, -0.9087773612889054, 1.8796095824615455, -0.23954783981953656, 0.013800893010743344, -0.7899948350542423, 1.3027794998135398, 0.27109516329868416, -0.8052538755174686, 0.6752727736363223, -0.8186896350777235, 1.4973355076033108, -0.19063093119633684, -0.435263552846067, 1.3399303651695367, -0.8775454506730258, 0.43019671024160794, 0.5110282951988051, -0.33507259682404966, 0.34086779444118004, -0.9161613937648491, 0.30000923720602873, 0.4386055179472741, 0.6824242697384264, 0.3430299891704699, -0.7137279467978856, 0.27098225354445227, -0.4125287942500523, 2.1883982313580215},
    {-0.34660008588170726, -1.3107896177656535, -0.10988060895158268, -1.6217697691573254, -0.10745085097502925, -1.138112117945126, 0.02495171356188394, 0.2759352749863567, -1.2882795822034383, -1.178426265042331, -0.054211327921213824, 1.0131368326540522, 0.7864075012122945, 0.6126902972342642, 1.3064086249897875, -0.5421978278674937, 2.2466783829150243, -1.8337337692114277, -1.8640051369299722, -0.816835285267399, 0.6713250810367135, 0.6127323388339033, 0.7646289401763343, 2.5981585092161117, -0.193021254108861, -0.07213151804647051, -0.2794129848397019, -1.272913159541852, -0.9544088213246209, 2.548184373309317, 0.7464778974610359, 0.40716256629283815, 1.3136339701928985, 0.23414764036516703, 1.30206307822151, 0.8683199035466529, -1.9300837848516732, 0.5720763339862138, 0.8537983331872455, -3.518981032373534, 0.4724860213199924, 0.5211856598149642, 1.115756520002151, 0.41940600713685366, 2.2065542308267894, 1.0900351936821944, -0.06772535615992985, -0.5652417845998572, 0.946732208105569, -0.1792850247771276, -1.5733415885670523, 0.6032916907571972, -0.7299226815094771, 1.4013332760393575, 1.6847809556960291, 0.07713599056903155, 0.6238289728914141, -1.7337045567933007, 1.0014355104757608, -0.7518746544823018, -0.6185005038053869, -0.04071660425589073, 1.9485201114650927, -1.8424255988814398},
    {-1.5115800830472055, 2.2785430017517, 0.007262865657007348, -0.020674529503029986, -0.3760193315794555, -1.8073224184116337, 0.17603362086579766, -1.0536196777352407, -0.09881960991220379, -2.3108467396487518, 1.766103182099675, -1.2843778952153788, 1.5351036048320037, 0.04539278419973769, -0.5877416307975041, 1.0571846984534587, -0.12310916383752685, -0.8810410183944327, -0.3140678866120377, -1.330981019447826, -0.11538491905344267, -0.5034674535745013, -1.3199199126786667, -1.0528133762371703, -1.215242375918443, -1.043133219403007, -1.6487155943946301, -1.072484797218812, -1.1543816938385991, 2.0565726242580533, 1.0892060906472805, 0.4530661924165231, 0.48010800633972905, -1.2825217515928422, 0.7935575264866739, 1.1962137319264814, -2.1061684683682786, -0.6080751737475953, 1.259010727869534, 0.7266098748638841, -1.3930464267450586, -0.2951808503520182, -0.6453219186616806, 0.5321887305929492, 1.3464878810237966, -0.21803269499877284, 0.9612274426419042, 0.2773589827967428, -0.2645346047600064, 1.6882760603334166, -0.22385290653312354, 0.6212594444844421, -2.132080483971278, -1.1884928885399677, 0.2658376540085392, -1.040863135974655, 0.31543068754797704, 0.6793793233888682, -0.7289797007354498, -1.990652127879679, 1.6263901723602552, 0.5304361263136168, 0.2474541011481631, -0.5585535152459312},
    {2.2291363239293696, -0.03712067455086826, 0.3184188925485845, -0.859176333513519, -0.6676568208551883, -0.00990826318464074, -0.4167039002288736, 0.20323972146584277, -2.357722482308118, -1.2168918730892535, 1.7744490459473357, -0.12407086396937615, -0.7510981361564039, 0.4379417649549331, 0.494769106084789, -0.2368838247071104, 1.7238880696628036, 0.6045160544956163, -0.3067220691872677, 0.121164663639186, 1.4905461102639546, -0.4476838337695739, -1.753644807127492, 1.5554296755751542, -0.27122221500854987, 0.6580784896375347, -0.35682501666643207, -0.5616426882613835, -1.7746990117540302, -0.11450909570236806, 0.4958157956688483, -0.8644158431715085, 0.06644093287767303, 1.0341381327696328, -1.6172136523943208, -0.05865495647501665, -1.1006166253428407, 0.09852455911129962, -0.07007324951800578, 0.32288434903607166, -0.23173399775104583, -1.1526258573832457, 1.826769066424196, -1.1286886733583874, -0.038171196103449816, -0.0326204982266345, 1.668540599074921, 0.01538177829524327, -2.184495460755652, 0.2779938891979129, -0.5513924232591585, 0.4613528445456611, 0.39672226834514773, 1.5008651322747162, -0.6125566807227292, -0.16196788585114902, 0.06178097567546784, -0.9434892975392619, -1.057359427415284, 3.1429428765112033, -0.8661564975007571, 0.6497697884335576, -0.0007340871645376231, 1.0996163040385805},
    {0.05345807208908225, 0.059267914369659586, 0.5580019607173287, 0.7781283834583039, -1.0818630009065047, 1.6077087958577634, 0.840714615468595, -0.8415986300588965, -1.9223502279336195, -0.611061366887455, 0.6022957288329982, -0.8843802667621711, -1.0582249380410516, 1.445765272135496, -0.5998288580700676, 0.8366259916184325, -1.642351027856561, -0.9613011445766813, -0.43769152505030645, -0.5741453440194839, -1.1509743886157657, 2.345444340577388, -0.0025984543257284477, -0.35192334877952075, -0.622056050181689, -0.12047613901415875, 0.3726529103336001, -2.104684396467769, -0.36447247770644364, -1.2113784737343891, 0.6531556037884735, -0.18510947005969935, 0.413526168265441, 0.30875327399359465, 0.2963480154405016, 0.4936332272151101, 0.12151323458093934, 0.36415638129928884, 1.0032332782919318, -0.6576368551972888, 0.278561565422002, -0.37212214908827634, 0.2947970995870491, -0.28426994578852444, 0.29866371466640673, -0.9522696395908778, 1.230248366417409, 3.26454537230157, -1.777383946625018, -1.0605746093010702, -0.27339020261289915, 0.4562831274648383, -0.8014175073941872, 1.5605201850121628, -0.16997007513485712, 0.7233827131850521, -1.2729775690518825, 0.7639993084137096, -0.13903985014960998, 0.278131312000022, 0.08738222113111843, -1.159233019756313, -0.08735254740189137, -0.34143483430060734},
    {0.20844923832871964, -1.201166353422187, 1.5601446780008739, 0.5094709271203975, 0.3917670917938117, -1.3378474328192038, 1.3419488417199659, 0.27403018855961936, 0.8094427382998741, 0.17564035143218118, 0.03299363149310583, -1.9256608393648393, -1.8326516555001617, -0.8510307949971603, 2.3692360170562123, 0.36767621747875445, -1.7321013818993, 0.4134654749227481, -0.4250177536154844, 0.32897648017592845, 0.9790025988318326, -0.791418397759251, -1.374974159024558, -0.39593895335164825, 0.0865031567993052, 0.4471293208306923, -1.9165121142549066, -1.3224861576622249, 0.023903631263431986, -0.12664675755334148, -0.43695050567755717, 0.7508824678277649, 1.2695256437852194, -1.2887915739927218, 0.8347582056978763, -0.8742199467679578, -0.03767732726176186, 0.8121494580555713, 2.7242525191850526, 1.3311861511988357, -0.83681183771404, -2.412324055252805, -1.840931395028876, 1.1091577426448047, -0.19159694753536832, -0.6970262699701132, 0.470859469646291, -0.7713251661583409, 0.362125574340232, 0.10292172133592999, 0.5129827575658895, 1.2468907797968443, 1.409896487237793, 1.5096229892322592, -0.23711639315793137, -0.6164615614758951, -1.0776808961219007, 0.28568441909923586, -0.6209464712666445, 1.3051248006435479, -0.1920473650294252, 1.3482462715354662, 1.2517824459471167, 0.5113032166450865},
    {-1.070243699581309, -1.417302889899428, -0.3555407063025632, 1.4268714373605276, 1.0303031389862722, -0.8160664111481858, 0.1597146247374499, -0.5258074340676895, -1.5817355127919313, -0.8063489369223452, 1.3711678486351577, -0.16540870480638342, 1.2295837437530446, 2.167044215617446, -0.11563701280224983, -1.5127010665075198, 1.5686728043738458, -0.9765428675308139, -2.3341634282927846, -0.3538737152019916, -0.3420851874100086, 0.24085195771375228, 0.15163137325583903, -1.5725112617788746, -0.8014506061819944, 0.02071797131334051, -0.7580095803705665, -0.14769830402910802, 0.696791795687934, -0.3825348085946992, 0.20790997170922135, 0.21845947001608773, 0.1708557307673632, -0.0026209239688667362, -0.3804551440846206, 0.5509160647846689, 0.33126413384025516, 0.09348472992336888, -0.8055459939446117, -2.3691397432792463, -1.48207201382033, -1.361154521626879, -0.8211381314881953, 0.2027085374900411, -2.9108579051660532, 0.3530008040701756, -1.9978187868211401, 1.0281627836360434, 0.05040354198694128, -1.573080950729939, -2.1179354358525964, -1.170575518506914, -1.4725061857699289, 1.5284293041435053, 0.09006252471584225, -0.06761345562864773, -1.2440164360568593, 0.9741296147215491, 0.3857324636901039, -0.45266968466752017, 1.3896335963677788, -3.9975610375604496, 0.8512208018381647, -0.5707571046680511},
    {-1.5982915300700118, 0.7791877649881336, -0.20036030957352524, -1.8620008278240816, 0.17116773552917994, 0.9574724988413655, -1.1593398494238134, -1.080225194711094, -1.4028023361359114, 0.2157452428725153, -0.3973884572916042, -0.398919391186972, 1.4924148690284238, -0.43416700503290395, 2.0003654803152457, 1.4417258936451802, 0.8352456545466834, -0.8330504075892062, 0.7113791658219555, -1.3070837849010928, -1.5028830263593285, 0.8469600270825662, 0.8338603966859417, -1.5632221583907486, 0.6400129305040421, 1.8292829236770733, 1.5065127883597762, -0.8489088310260348, 0.5793249619032068, 0.815171450912739, -0.4769429499080462, -1.750477639649024, 0.6533474394916496, -1.3174249612596505, 1.1181784217825448, 1.811750146851829, -1.5145417742535234, -2.4378309711797965, -4.232570703191712, 0.30205056297618355, -0.4613808314094618, 0.5065327768225368, 1.426490038967676, 0.027865745877426094, -2.029481136374316, 1.420842427945604, -0.042279052279991625, -0.9209584605375521, 0.2526369710440664, -1.2145550403035303, -0.52342542932391, -0.05249154568130706, -0.6170595556313943, 0.8297886863618441, 1.7346866189497867, -0.3233339426006811, 0.5219864253810487, -0.2338487748563412, -1.2676338903914854, 1.2214463250938241, -2.050731316183707, -1.5717080747960743, 0.24032612914577955, 0.8634766885301667},
    {0.7691741711227815, 0.4800058095198416, -1.085815577155418, -0.4191383681555431, 0.7462279509421876, 2.194142967270195, -0.8146904716600805, -0.8769270617153709, -1.6908387310170703, 1.6721982057574778, -1.166831602891922, 0.11224290966545293, -0.3228868928236625, 1.8327196537832002, 1.3142549404407284, 0.512376680930789, -0.4532947476565427, 1.1124200598254552, 0.4117463821831248, 0.5122546852386405, -2.885418135559286, -1.859809063888727, -1.0977588810357715, 1.277762637114412, 0.7871616827146873, 0.6277636709691058, 0.2174369078968664, -0.9757121460045358, 1.6708877609337511, -1.043366887945891, 2.098294132005549, 1.3139381452092314, 0.5777908666246052, -1.100988032340371, 0.3866766393781289, 0.5814598165772783, -1.485536800521977, 0.263598568492328, 0.648026324955257, 0.2137518136874585, 0.026341535713422348, 0.6415533377329166, -0.13994912068943385, 0.6217696737031289, 0.2673428499855664, 0.0516232863969253, 1.126652456454737, -1.054594313048896, -0.7591247651142744, -0.5860921768579421, -1.7377927847965384, -1.762079523510352, -0.7081268306797718, -0.44147940891556064, -0.6490682834138958, 0.1267808165048309, -2.1644430591012496, -2.178841256810041, 0.6934197945447743, -1.1944259123716598, -1.829703871349172, 0.22218793010883725, 1.8260904448443072, -0.9004481883198803},
    {-1.5498684982619675, 0.3702607512940604, -0.16640560494692033, -0.8002451695712818, -1.9332848525795914, 2.515515396598077, 0.63787043916228, -0.238982751301974, 0.16772653771873744, 0.676707251171534, 0.3357955420886966, -1.383880681351404, -0.21683343142388983, 0.49638545325974776, -0.16492804994644247, 1.9069329413834688, 0.48149665921082807, 1.0057443726573994, -1.5722585965297047, 0.05752434698795891, -0.23411614581123025, 1.0210534742018258, -2.877538472943292, 0.08736784997310987, 0.25045865891866276, -0.9350774399971504, -1.0268180878202748, -1.7240865165278527, 0.21252247780210082, -0.5775723966561103, 0.4897336108347674, -0.1822844950282876, -0.8717461885931886, -1.8120675115778884, 1.0830353519016287, -0.9933221681259171, 0.16751336374806738, -0.45165748429494484, 1.1861523831730785, 0.2775905512023658, -0.7738179515773459, -1.2993862416369932, 3.337335147408842, -0.1130020696768471, 0.1349044857136055, -1.0732855225110647, -0.025882277402118136, -0.5119182239168362, -2.2347753142253115, -0.11307339851438808, 2.583532257186159, 1.8633359410996098, -0.9155323900675684, -0.1366454403158479, 0.08005557932896941, 0.3319109817761738, 0.18496604560758392, -1.4714324825115273, 1.1190956966759864, 0.09622805666176011, 0.9199929207820997, -1.490341973963501, 0.6802436807415191, 1.408877479912824},
    {0.07752623296590275, -2.106872188531379, -0.6564039503712834, 0.8675345515556587, -2.44579665457282, -0.5657524774760899, -0.43983255728832316, -0.4630452832671725, -0.4036261521753358, 1.5956456956628702, 0.1828092804349684, -0.8500937167847114, -1.3181702018354944, 0.20033222536547732, 1.1612598130964316, -0.2186738138875643, 0.33115390525634825, -0.6345286448078686, -0.7412318875858835, -2.351558646040225, 0.08615481531823196, 0.45824374194480244, -1.0496500683389296, -0.36240645562201956, -0.09734230253765716, -0.0578717476181413, -1.022033345690642, -0.2585792617021523, 1.5099126830829328, -2.0627459562943047, 1.8256459400474385, 1.296842282043842, -1.706581195893079, -1.5879773945479476, -1.000127238112558, 0.5022616256182031, 0.08263298137499198, 2.398254145301506, -1.890331277253525, -1.0681288526805435, 1.5836700473999195, -0.5127828374326571, 0.4710360975250005, 0.9940829673415266, 0.0012100236783406954, -1.5018055609646146, -2.2418248866082093, 0.9194480869071678, 1.4321061554456347, -1.3830354385281847, -1.5357973844547936, 0.9384135468561582, -1.8283657961417648, 0.9212259544910174, -0.23050048629874226, -0.13187329898371355, 0.15719352490146804, -1.0980452927568558, -0.36823304402904533, 0.831687572530753, -1.616752859071716, 0.04213340965789359, 1.1914864179456535, 0.06468380081686624},
    {1.5435854083938403, -0.732574925800869, 1.5111892311155508, -1.2178140591984954, -1.4054604770042212, 0.8630509305923623, 0.48365526105475065, 1.0772507163531002, -0.3495521008397425, 1.1742271332580256, -2.2591193682429704, -1.1462002853044393, 0.5999766383769336, -1.108927724463763, -0.19056698865709973, -0.8008636211571688, 0.2852171644773199, 0.26194617529930475, -0.12277823445109425, -1.668487551834851, 0.27128147591206636, 1.4193966982319497, -0.457040372637417, -2.3151632068883448, -1.548943451164307, 1.968526015933822, -2.137781428113633, -0.36714288520269117, 0.9337957304693186, -0.5756817351780731, -0.9368110048064552, 0.9611470199034023, 1.2705560680136498, 0.18683535743672683, 0.6679362450086785, -0.6835501568539777, 2.0019236256754893, -1.1120762917771585, -1.9805680060636253, -0.2888329335633859, -1.7452686184981463, -2.38228890437094, -0.5894934517312588, 0.03819742638403486, -1.3140490731982075, -0.21468085064636175, -0.01374616940983444, -1.170340726509184, 1.3223571390306588, 0.5842738927124906, 0.41384888105124384, -1.7784112060419066, -0.058206329029535056, 0.2821377897063588, -2.223592923036199, -0.7966709133793596, -0.777428633217154, -1.0951015456244049, 0.06300495738671204, -0.5864862814832408, 0.09991689480225727, 1.3201955452116458, 2.0361843279295115, -0.13799684221639497},
    {-0.7354115367469757, 0.37201877843511305, -0.5456131248785165, 0.48884958134411866, 0.2961140793247386, 0.5563500342879845, -1.3311321177237745, -1.0405216442283027, -1.1835145649745076, 0.7527679444780674, -3.537581839115828, -0.6535596083766997, 1.0222137006022554, 1.8412176736045665, -1.642209347803379, -0.10528445220983089, -1.190935171507378, 1.5615913743641097, 0.7832856764337858, 0.8679013963386508, 0.8678747420906269, 1.404600838308364, -1.4673616229449042, -1.117596309179381, -0.3709802922654633, 0.701951106049235, -1.3607705668394836, -0.13438282073344837, 0.6140908579547777, -1.157195016584543, 2.381747033621929, 3.2601856344927773, 0.2221754627793589, -1.5022840624848979, 1.0824161528124816, 0.8402158071338212, 0.9159313289541027, -1.662440356216787, -0.760416847012136, -0.5107978330291334, 1.0169053501080962, -0.47219538763697666, 1.0770375926193057, -0.061084008769509354, -0.08949366991520763, 0.25026255428958216, -0.2320942571675014, 1.1835398875802121, 1.5544940031344148, -0.03587708574442593, 0.6092988986388664, 1.5933949653941968, 0.9907379959499183, -1.0282786587243264, 0.07063464623347046, -0.16216583880889457, -0.7803580884341595, -1.0016757275319268, 0.856937677096143, 0.4825404019590037, -0.8923841441193288, -0.11956657597897995, 0.9235804096579293, -1.2597806154023483},
    {-1.098974066881337, 1.6250234339184815, -0.08658428823171256, -0.4047044125710009, 0.0036124464906950845, 1.7027209803526724, -1.1738358851441932, -0.5771518800945742, -2.442031112556411, -0.7362194289546095, -0.3942922387345779, 1.520678122449643, -0.7799766553367161, -0.11348080449212299, -1.0188727570236131, 0.9747724082950122, 1.6969556091123912, -0.4752420727083496, 0.658107093969274, 0.15580724538203242, -1.8883211668771016, -0.5494845873317393, -0.40496893000215217, -0.028629584639699703, -0.7653933258781793, 1.6891489446883226, -0.45046486492522686, 1.669140622990775, -0.045034851288580896, -0.45495720658744115, -1.4815411567086514, 0.03183519515923986, -1.5510279330720356, -1.9355393433914847, 1.5523512054967894, 1.8160675771286412, 1.4978966442363018, 0.07764217714475141, 1.799677210864759, -1.1128086509764128, -0.7383116435418788, 0.2343135723074017, 0.15704468221486234, -0.6720932365824557, 0.5037593323141003, -0.014368385724538964, 0.4511123643041504, -0.2679472346828553, 0.22928092071437886, 0.9565974216966376, 0.33879865697625844, -1.7564839108342514, -1.0659352285996242, 0.06225051672823168, 0.16357277702842327, -0.6182890013749714, 0.2679949984053693, 0.3148363112338177, 0.9305761154309815, -1.1814206759215895, 0.600702138373131, -0.6826610508582028, 1.397158993515669, 0.3533368231564056},
    {0.03144763160488102, -1.686397311140356, 0.17794888004421683, 0.37916238859308843, -0.8238986072404816, 0.31286875312501566, -1.2075789588870212, 0.46001617430460134, 0.6611744197441352, -0.18906867982272121, -2.513611010614851, 0.2636638198596808, -1.1675994619802363, 0.42920130331758327, -1.1906336627347178, 0.5271151756571418, -0.1388218751050529, -1.9756573264501336, -1.0438292929181068, 1.3466869980045157, -0.3527779223013224, -0.12137442814993349, 1.637201463362192, -0.19599339209771224, 0.04584352233440292, -0.920970566320206, 0.37825767846705766, -1.028583436153735, -1.029133692472614, -0.5137282629758847, 0.6464890941329948, 1.2872381181035655, 0.46913022452252584, -1.4328662457780927, -0.06757127072267473, -0.905776664378116, 0.4423826164872594, 0.4283808019021923, -1.0832542864579362, 2.488110382408846, 1.1999260847514899, -2.174618470670716, 0.005801983589022865, 0.6511444891686076, 2.260264886085186, 0.1365752663780354, 0.7036186880871272, -0.09718482099119789, 0.42334200924709414, 0.19442037384123734, 0.2883152887953899, -0.7855891010725281, 0.7713704522175052, -2.4038499249410465, 1.024310010120832, -0.16053693768000316, 0.7440214665324393, -0.09024400591356324, 0.4416914086741424, 0.8443190611407307, -0.9381845992023711, 0.2754141003239189, 1.2372482650017098, 1.1789924476082028},
    {-0.6842026320946636, -0.22750362317247053, 0.12808910406603435, -0.29396777515471795, -1.514122439401803, 1.9331865385938538, -1.7038065428679663, -0.20526555159159124, 2.155586921665244, 0.19686071408646416, -2.272027100711476, -0.9419113481340164, -0.3383404355534624, -0.5426731183547331, -0.2876122606509234, -0.759907704734182, 0.07849231841181149, -0.7475906633697047, -0.6127489206577973, -0.7234728203197994, 1.1448217090532553, -0.7196267126223698, 0.3756903039887519, -0.9089530467322738, 1.7653492983491788, 0.7725322351806773, 0.24177008860946814, -0.18330194123436963, -0.4415719253567972, -1.9500012843443935, -1.1113484808920913, 1.65781790085534, -0.6321347405857458, -2.146516316054805, 1.1230327341938993, -0.2101118916411156, -0.31934959257519707, -0.19943209934665831, -0.32185840714218905, 0.06308554635040457, 1.589236099572286, 1.1508442862648338, 0.03398301138342682, -0.654201998125245, 0.37979600716642653, -1.2562340022608771, -0.3798287533737365, 0.3703159076272648, -1.510793167542648, 1.1025431377244335, 1.6693244665098539, 0.9800443419479723, 0.5515901472806408, -1.0023160862609135, 0.906010082472855, -0.5637919548991651, 1.560231627350393, -0.529132425610753, 0.6902511941938012, 0.5592518209067946, -0.5608493794936145, 0.32179439113875385, 2.3035049372765184, 1.5410508387315598},
    {-0.6536094969514319, 0.6774006884346891, -1.0050165165913996, -1.0116344905992187, -0.5235291691142872, -0.5387784010896705, 0.1594881579659092, -0.7784035789646837, 1.4295179273351961, -1.4019785791325654, -1.1621438916756828, 0.6225420415897382, -0.5203839728798457, 1.2007285740583287, 0.8035573996229737, 0.966620108700228, -1.6839273785718625, -0.21500312069269897, 2.707610817270841, 1.3065902768326685, -0.13388320496938969, 0.22507268214795115, -0.24264014607059406, 1.5062134221883041, 0.43575108939592666, -1.6828639418443259, 2.7476003830059756, 0.43216503058651257, 2.1046755305726967, -0.14840279637881523, -1.9953521129092642, 2.4521981369670915, -0.7014667347521688, 0.34465294478139014, -1.9754588003130547, -0.6836188646367358, -0.07186785339133694, 0.0786628835066838, -0.9412536979970574, 1.1248404853251943, 0.7755865244292248, -0.8850094386270577, -0.5560485027619819, 1.0033328012683624, -0.4930999957406428, -0.04410364175968778, 0.06998305955142747, -0.7300456568690422, 0.6461706425241203, 0.3888984690497563, -1.9397208632254823, -0.7634738696484054, 0.7439709818317544, 1.288929616315093, -0.3052651070030262, 1.1768877545265983, -0.7887495787867208, 1.4695816320930937, 3.3818482229383044, 2.142308697346139, -2.2451631363398987, -1.505605621368429, 0.5363847638152627, -0.6340713730424806},
    {-1.1173541356726802, 0.525998830765675, -0.21120220920408012, 0.1177193827495273, 0.5516908473106737, -0.19400594680411584, 0.706163724392395, -0.8519848268440011, -0.6379335836832523, -0.4483036265762507, 0.46060109514064845, -0.2793051770213407, -0.4897727886037021, -0.24560475397194065, -0.7792894351954107, -1.0238052772913857, -0.7396278753255936, -0.40865874438829175, -0.9932148672734658, -1.7434958505387352, -0.511165365217076, -0.16978145482227416, -0.24125057153167442, -0.9122698754301823, 0.4588751383607787, -1.2411419174123928, -0.06577441681932845, 2.4340163273359954, -0.8068387617959092, 1.1457361604997596, 0.020053186201353712, 1.184174818004112, 0.5601883603371137, -0.331101926591266, 2.3680874058549755, -1.8267990173454867, 0.502115716118551, -0.4257706570449659, 0.6441909370933501, -1.0241483505192188, 0.020222029075027736, 1.101287516252991, -1.1129886734302232, 0.2259292944484243, -1.369777514277483, -0.7389277979144185, -0.5743957138105871, 0.5457644190969999, 1.3771425594406326, 1.3509524604020657, 0.6370573431245705, 1.3217378887013211, 0.38013680269085687, 1.1554847501280858, 0.3526873042602741, 0.952708040783882, 1.6553269615176625, 0.0420267357188185, 0.6763871061733822, -0.5270720051485264, 0.11165800476968957, -1.5260060079035267, -0.7947237109358886, -1.6087823788737088},
    {-0.35678301890987374, -1.1382716688594934, -0.16949526827369218, 0.4990331494132138, -0.2887710044219781, -2.070033242533869, 1.5050348945897076, -1.5110546676725465, -0.6142370901904279, -1.9278216302610374, 0.890702910151925, 1.6359906127958919, -1.8521967118233262, 0.006485140690492533, 1.1504478310240307, -0.20447624069400677, 0.813861003857779, -0.6360245479656241, -0.07660228386308815, -0.4570807447458816, -1.7258276659866705, 0.03994945893735431, 0.7217191206512596, 0.9467709659082906, -2.12151799705199, -0.06517888423180583, -0.4355621431850021, -0.8441705644225611, -1.579405237580526, -0.42134356107193077, -0.33509154648051054, 0.053066730012801135, 0.4739386043759063, 0.049756929670812855, -0.4551006559097034, 0.008547836345282757, -1.3120058783822919, -0.9666293888538817, 1.171584729183505, -0.35983542974297045, 0.5089413382742198, -2.5175522590901576, 0.8082701609908158, -0.31343569106899727, 0.4753218904223217, -2.2255525069416535, -0.3106677858013234, -0.4205614146133522, -0.9436351557819747, -1.3091398994804482, -0.173556675497637, 0.601799162756045, 0.7879850212108069, 2.3224073324734533, -0.6241025053740644, 1.2630450963126092, 0.22429674931162577, -0.393104323952137, 1.6872859070838269, 1.278385037108755, -1.4179635242664108, -0.11109244522949291, -0.8458590634666668, -0.8909560540401186},
    {0.9621820823595344, -0.9241470642857101, 1.481511159999564, -0.18507244343887297, -0.7488360997262614, -1.2099810221762703, 0.28940901290342347, 0.5464132186624778, 0.8279106588765763, -0.9314508180927241, 0.4030593460931884, -1.3001597110467429, 0.1005318810294605, -2.1511612116031853, -0.790181356114867, -0.305435015608067, -0.9284589751672608, 1.5344253804014438, -0.3418041416483334, -0.03896537092424321, 0.8086851117747217, 0.4206617322612015, -0.22197665527876087, -1.2184371999467798, -0.014390516891604949, 1.1876340480708834, 0.5062972575661008, 0.6647897369736269, 0.24527627573858346, 0.5831317177950518, -1.2711841525398488, 1.5866729973093263, -0.6291399510638107, 0.4873978946103056, 1.4140916776756183, -1.5387624870596084, -0.47402517963923996, -0.7608385874935365, 0.6931606727752934, -0.6940953507452973, -0.8668206944226203, -0.5859132531984959, -1.9090808318884676, 2.0903716562482186, -0.5986332687785904, 3.081402121888557, -1.2313782633373234, 0.4849880699985363, -0.6417470366684748, -1.4961876698480077, -0.4733349416534606, -0.13749264896256363, -1.7695792121949476, -0.40955501461193244, -0.3210357643868645, -0.923277174905509, -1.1272679147887315, 1.476006908302989, 1.5493739726670863, 0.6918304684566406, 2.4305430761052316, -0.5307183068282944, 0.6049789687748487, 0.3134531166990942},
    {-0.08044967440882128, 1.3928358297081733, 0.6286747431405103, 0.5620794272414751, -0.08576260328071578, -0.5624181788705266, 0.2836124149409008, -0.5418770157842006, 1.0112504346103477, 0.10321220722617384, 1.0287977587622454, -0.4521517269834727, 0.5917760939005873, 0.23879789527681128, -0.28030650174168426, 0.6624422707510204, 1.586075568420443, 2.03422273657483, -0.8217882299768628, 0.3106361124929584, 0.3137170915410053, 0.45064473280289186, 0.024920773488459193, -1.6850200762772098, -0.4424452189955218, 0.2703153527923645, 1.7596948098833196, -0.5386336751005634, 1.380454263731629, 0.5318007178471498, 1.1239995322702125, 0.313977697043857, 0.8206457054972103, 1.9415516061622402, -0.06390181297030788, -0.10218402059749186, -1.8733002454763301, -0.373802095252602, 0.6834681180518021, 0.24347179526438406, -0.4614346075305325, 0.9024648701550325, -0.4360594180687915, 0.3659996958437042, 0.42765222299109723, 0.33254590276042767, -1.1662062395300061, 1.2819585304413819, 0.7604485196522466, -0.9276059161608918, 2.0454760229570024, 0.4877464512914862, 0.06049554526982516, -1.5244645929704563, 0.37190370400879985, 1.7396652612188035, -0.6365977840121011, 0.34571644112762107, 1.8815774531209484, 0.4563928651094724, -1.1016319509630237, -0.577215978221714, 0.8617115294974749, -0.282073749088791},
    {1.1955074254036637, -0.24785416567799945, -0.96049792727942, -1.7007362018568473, 1.1334323493506355, 0.5234269780797531, -0.9112100643874458, 0.7685438240358465, 0.7326617553581551, -0.8917512233730329, -0.7055380295337943, 0.7906684741794904, 0.09207193772901216, 1.2202482816278695, -3.3903174065205346, 0.45942104764213104, 6.902782234636828e-05, -1.2356662434233108, 1.005384383528048, -0.3428982690715092, -2.010884905351594, 0.1618804250938341, -0.3540367274148627, -0.1693496160520003, 0.22276929960182398, -0.4694981187158672, -0.24030597599611786, 0.5491529252838436, 0.8946726405095111, -0.6230439807263286, -0.8093966291317823, -0.9178407350409923, -1.0055156929883746, 0.16759619467826178, -0.7444297153677583, -0.6047307619214497, 0.07716347554510565, -1.3199808460916211, 0.6356429235801248, -1.7279474245676045, -1.731157851748739, -0.8818745986918493, -1.5876422884869241, -1.0372839205630064, -0.7155310755118939, 0.25970051515112086, 0.6792958506087136, 0.25925782570368877, -0.6705479953549679, -1.9803784883937547, 0.4849589347761485, 0.6685274294022227, -0.779437357044197, -0.7637635707204721, 0.5982873537550132, 0.25480001974503097, -0.07743836204984571, 0.3134512595076524, -1.1890906550477718, 0.587743248311373, -0.672964139656739, -1.5657943508310066, -0.6095335751831924, -0.7605020957282987},
    {0.15241729810013818, -1.662359221000493, 1.0754745161652755, 1.2481053394048418, 0.6317169736541232, 0.6773273643794658, -0.9253117647079976, 0.027464463937561006, -1.0111751087055756, -2.1328479097350366, 0.8508945247824493, -0.28833184629761954, -2.7643348730180106, 0.5565054543980662, 0.6543962981183159, 0.17518792434905878, -1.9767278521635827, -0.150169352690746, 0.9381730640670918, 0.06977748134671852, -1.871050271381505, 0.5367462208368619, -1.866070757636568, 1.99171882491852, 0.7351060261299911, -0.7091933265326698, 0.5539023098955772, -0.8733142497232598, 0.5928044216462526, -0.9489168620481612, -0.133237834010782, 0.39485230768537977, -2.448583331943068, 0.1717002227433322, 1.4689807623227285, -1.190230884614221, 0.6354696593603562, -1.8650245901327025, -0.6069331524471211, 0.7815303473498851, -0.8162156809883531, -0.9115092334462177, -1.8975079734627096, 0.0027482378605979316, 2.553971753804492, -0.6391138292574571, -0.3754650599427928, -2.3052309717577386, -1.6722457077355501, -0.9284079356586269, -0.4115081550406528, 1.2592485436581273, -0.21935886867601453, -0.5793671857388034, -2.143893807888418, -0.158889800016333, -0.6942890062929573, 0.08666141390933782, -0.7734433442946489, 0.4516017325150983, -0.3505070230470948, -1.5169844574794162, -0.9888053487718228, 1.583640783337052},
    {0.5614050119548814, -0.16439483577602976, -0.7937100385825171, 0.3723720400588735, 0.6588759536358729, 0.11800754942558993, 0.9217074500649424, -1.5700903230810093, 0.5286661675675468, -0.09383286775082408, 1.0552027431954543, 0.5221696225943426, -1.0523281417981643, -1.6940252471911668, -1.292987158207512, 1.5112027286286764, 0.8387035898871772, -0.4135538879049908, -2.4399210267823035, 1.4305592964823655, -0.008076710696692647, -0.23199567337788385, 2.098145359302126, 0.7473406026904996, -3.2761051711203564, -0.19515949467150942, 0.32261619370351874, -0.1306485272776089, -0.1083855997415627, -0.29883970539464605, -0.13684076052681138, -0.3819375230270743, -0.7443830742229323, 0.9953330734364512, 0.5065339636393403, -0.6720556363941114, -0.8172491067467741, -0.8902155364138382, 0.020219063511142447, 0.5229969209740297, -0.1172015091481263, 1.5096786722559916, 1.4235148412373415, -1.401434206249842, 0.921099281743201, 1.4504107614581332, -1.17646378972159, -0.7624162623493134, -0.905198395557268, 1.2286663837196679, 0.4297265124335135, -0.24066517313098865, 0.3196561683662978, -0.35167379673394755, -0.85866678043412, -0.8245473537692084, -0.4819224186587822, -1.3263419669517955, -0.7409011417080312, -0.7459290018053221, -0.37316821790260984, 0.5910404488337574, -0.5735220919192932, 0.7840859692154377},
    {1.593683158216004, -0.22401690305546756, -2.0136712538663675, 2.3310907419798865, -1.2465768494895886, -0.6805215544764095, -0.19789584125401413, -0.5858085246701681, 0.09435935017740793, -0.9126103656100348, -0.43445327135197914, -1.7535999277651761, 0.3207217386460139, 0.31849054809364463, -0.8426198225387113, -0.43475968907324064, -1.2020765996641891, -0.9004790132195652, 0.30022475738209803, -0.06713252114779454, 0.5064842038398305, 0.28778494329067583, 0.7919566789097078, 1.0494970353989717, -0.42228333926154865, 3.3302374240000923, -1.6569027796740212, -1.1843490783342137, -0.39464668097720973, 0.9816016169795926, -1.3211149018791106, 1.7677000058464438, 0.9005328697782641, -2.0936543364401152, -1.7055057995677882, 0.4569845521721521, 0.7984717578679422, 1.0630502437868494, 0.9320790711872239, 2.1946733921087467, 0.08427443652501881, 0.04997681326279061, -0.20058902359708689, -1.102039133526697, -2.3075502656775195, 2.579406243604416, 1.6227715804339953, -1.446232157880982, 0.12735234490013358, 0.0730325758373193, 0.05447308463242153, -1.1188291614600476, -0.7997777152071177, 0.3075058863445832, -1.3798778092256685, 0.5240884913396754, -0.46989339204557234, 0.9187291602044408, 0.816580599327296, 0.19479997312134298, -0.9438699542277378, -1.9348030947699768, 1.3301195870311495, 1.0466539401769237},
    {-0.20344103640439515, 1.369932283719649, 1.4911423042181537, 1.0327990005657854, 0.11638532538039771, 0.22125026717701, 1.972985260063625, -0.5990064220285902, -0.02140967353832827, -0.7637708576559501, 0.24102286728975966, 1.0642313049217187, 0.1640542023168752, 0.9521728560388932, 1.4415586602039576, 0.9386769754641396, 0.26411562458956594, -2.7513299250670964, 1.6483473358383625, -1.6643269513941101, 0.32310699822054506, 0.39857802105826734, -2.003068559457049, 0.010606559277882326, -1.4493332542231396, 0.9239271250494322, -0.9011017361309414, -1.220922660463886, -0.5980260493202628, -0.3604493908760361, 1.1714646467842675, 0.40970322189532865, -0.12033241142821861, 0.6381623295332519, -0.012205579262942232, 0.12102664604900348, -0.1566836338599746, -1.1456501558851684, 1.9358672772989514, 0.7365754440353082, 1.7465151514902284, -0.8744410984672741, -0.4783452910792972, 0.7792926659757546, -0.09117302508552161, -1.3227404510378031, -1.2029023408325128, -0.4148193305262663, 0.7024420783306532, -1.0279945457725839, 0.006787333536461418, 0.1076190939375871, 0.29582311613633216, -0.0801424108886689, -1.9834480518524031, 0.1073286669557951, -0.06438522592642441, 1.2982370414554631, 0.03368185954680108, 1.1115988509078345, 0.3106013339805459, -0.02376185327651117, 0.11792942010594452, 1.8125159709865888},
    {0.6395530099230874, -0.4179557940643643, -1.3052842189582965, 0.8504639525188095, 1.7866826488711942, -0.32854198266428997, 0.08674479910656044, 0.8862122399660953, -0.9834637942509539, -0.6104484434954098, -0.8633169976145529, 0.0630294094397971, -0.7286595699852927, 0.29613562246833397, -1.9611366305714402, -2.84254299971523, 1.1299482594678545, -0.31578891522316227, 0.2863559509561132, 0.06046077178578718, -1.9994705209585824, -0.5976950578281645, 0.405088244810989, -0.002075760114367224, -1.6385906893707733, 1.9403622043706656, -2.532936561694381, 1.631404769289682, -1.3821752985846074, -0.721639063468541, -0.6999807932640163, -0.070495753315025, -1.12562788841987, -0.6999031301727138, 2.5244939549014616, -1.9697247423742956, -0.3883373259038311, 0.37179863618185915, 0.2536318659489735, 0.716923689802778, 1.1430845436357524, 0.19091133726672604, 1.8117832818474502, 0.3509353814363968, 2.136973352438636, 1.1488653805992095, -2.173027313158273, 2.0274341165010186, -1.9482786641136465, -1.8833498566536264, 1.7292170442267827, -1.4241920530751913, 2.076733268126106, -0.9692201903196125, -1.9854196442134242, 0.9840892346759047, -0.42214072660345053, -0.5717077785322099, -0.04027206625908013, -0.6923730323077126, -1.860647211196437, 1.0442367337227858, -1.149096585424441, -0.27705359461944834},
    {0.8348218410269591, -1.5835087914450328, -2.2229403507684067, 1.7179466653636308, 0.072933201709166, -0.9008271427575518, -1.0347777325271106, -1.5044245726415533, -0.24347218577792287, -0.19667993981966425, 1.119633659072226, -2.3395127499694333, 1.1469940172232207, -0.38449858181055024, 0.7442967936927007, 2.5791275114283208, 0.30654174003621565, 0.2862393367533699, 0.9442064628899791, -1.04057807824054, 0.5085429385911789, 0.5515794436717782, -1.9568412004583264, 1.4820094869661664, -0.9998927700885158, -0.33580279276972425, -0.8846744734889479, 0.4448683840152078, 0.0521275826235392, 2.448461801140473, -0.8520995465100213, 2.027096593191454, 0.25793487355921235, 2.6444829421452916, -1.516443222251467, -0.6234305689360756, 0.30330591527427775, -0.7075563287446637, -0.8379932796616815, 0.17181359588363462, 0.17429997002913658, -1.1904125597370137, -0.7328701085532571, -1.1703701708463616, -0.002869399927489379, 1.0140987851579215, 0.5996754063651326, 1.6545077951985543, -0.7531705136637683, -0.5303336320720785, -0.7936203161775633, 1.2265240543948226, -2.0608408771671436, 0.40012286324129737, -1.9222442256838446, 0.58337093524966, 0.3740606321490092, 0.012268962946326671, -0.32263772425440984, 0.1956321364214909, -0.49242699101033743, -1.5216367425235178, -0.045142018507262766, -0.19535726789567387},
    {1.0198457639774479, 1.9164931183490226, 2.442098111419229, 0.40593247836484425, -0.5649247473724242, 1.383012493268384, -0.6326107885438276, -2.152594516139644, 0.6161142905037762, -0.0020316248570399326, 3.326020691136502, 1.689580158338781, -0.6618936868228954, -1.9812275124016026, 0.4288847969943998, 0.09567511982069486, -0.04669163340536566, 1.2036099338430695, 0.05497251642645706, -2.17208785034846, 0.028070451373227036, 1.1004862691780641, -0.2443555970335853, -1.3809316359670163, -0.7633908272472583, -0.09573080545673981, 2.023687782571814, -1.5085276765177997, -0.5520206619524938, 0.47691538961937896, -0.34952832644121196, -1.0577085480097368, 2.9092775464621656, -1.354906982653112, 0.41441190440950626, 1.1959604765485377, 0.18964412088243185, -0.14088216364953482, -1.814044713359138, -0.06377209635940213, -1.8049387720026542, -2.7268718564064343, 0.439476191195086, 1.5925301431121046, -0.8108786906284894, -1.4074986578718507, -0.36930704704311323, -3.439439289171117, -2.3524168207382483, -0.0951817687158472, -0.16250457896386464, 0.32391557152486783, 0.8775050020344117, -0.9058642698570801, 0.05102027258472831, -1.9910187350820912, 0.3720853310497398, -0.3860731772821371, -0.7451541898637798, 0.5202449991804937, -0.1339121457712777, 0.3535174551187373, 0.32390195423976, 1.7928680492404316},
    {-0.17536690060419027, -0.8857609170925161, -1.007350131581931, -3.3042865699951487, 1.5515673172149818, 0.042804030572170644, -1.5405508600982378, 1.676827553749031, -0.8136474417955162, 1.2541973864685376, 0.5201910147099436, -0.9480608604008931, -0.13239727631039355, 0.49029209127948337, 0.3991932943062341, -1.3820835959214912, 1.1287533041300721, -1.2451391827966631, -0.23336969538982233, -0.31441004651130955, -0.46296892133904066, 0.8231319506833915, -0.673846965390058, -0.5858473730285224, 1.1446926998294467, -0.4681091475924083, 0.08583231770791319, -0.013717310429870021, -1.1115539370640544, -0.016553949059551522, -1.6125157540692046, -1.3709162709464624, -0.40673662288010687, 0.6293812012344795, -1.1666241365645307, -0.1747302305138926, -0.4063614965851446, 0.41948603100963183, -3.44888018967693, 1.9777729737296952, -0.24510699593444935, 0.13403523671114062, -0.13901968907501058, 0.4736486578179919, -0.32384566481696314, -0.09796786762726477, 0.7021317266007172, 0.8479771497154768, 0.2963153572627655, 1.0050701510458113, 1.459073269437541, 2.2827395264793564, -1.62837239190022, 0.9181060605710241, 0.758532327693755, 0.5021135300876619, -0.8281717814063926, 1.4644128045874496, -1.7827522121155552, -0.618095054674262, 0.008695285469125503, 0.7971046680166772, -0.6781735803937611, -0.5323394530619627},
    {0.7862151530474122, 1.0605740659650227, 1.5213164144353148, -0.4546393525001702, 0.2826479018875895, 2.458627107687839, 0.9303384897078066, -0.4760668030073649, 1.2144869540520054, -0.09777403469329024, 0.6300084550673577, 1.9242074297785778, -0.8706733822175707, -0.8930248652026417, 2.559299060443376, 1.9157748206673553, 0.6802134768766075, 0.8201396516828734, -0.27439645058043494, 2.024627874867776, -0.8072136133374833, -0.6985144449569527, 1.0565064748300796, -0.30069860024127537, 1.4117732049069311, 0.8770933113480196, -1.7183379953470543, 1.8333156432200821, -1.1227418043440993, 0.022121397100028764, -1.5068935798764984, 1.49335914556149, -0.2592519609240114, -0.562705682271612, 0.7594747329906759, 0.6419284995565377, 0.4290556980878173, -0.9980103381081424, -1.2299492764545468, 0.8885026068065146, -2.270681344645481, -1.7229142711380026, -0.9343200397128623, 0.6990901443030655, 0.7919658753502331, -0.5700642402030914, -1.9123084136745288, -2.7091303434724323, 0.3763054307932041, 0.407658090494822, 0.2390726006170992, 0.4176887891895951, -0.1967365917462195, -0.8472737478764217, 0.8561916449885209, 0.20744556468571032, 0.35644080340639367, -0.8460460025868813, -0.3502601845708542, 0.8051317071677374, -2.163495036264619, 0.7822409248758532, -0.36953409511449486, 1.7576331635027327},
    {-2.467328296731846, -0.49211877618870453, 0.9666252772493561, 0.14622839069614021, -0.5901303300533138, -0.9583390130550424, -0.09105377723675852, -0.9075731208383431, -0.0895931867180418, 0.7290532664542518, 1.8566637891814668, -0.6266819725678375, -1.6341809310401412, -0.3237624035686257, -0.5804805316034874, -1.3322030514407293, 1.2050331915366561, 0.41902768893060566, 2.0878368511038174, -0.1511825007111244, 0.7605659770601684, 0.6179769019804734, 0.48427380262681224, 1.0838235173834299, -1.571200324330872, -0.2635175135891291, -0.2576404845668152, 0.9718441132708209, 0.5147817865052765, 1.1738451084382246, 1.3128421881574988, 1.454968428612829, -0.9613736838442314, -1.5413543189476973, -1.0405964757650548, 0.3349298434566826, 2.2125571876523593, 1.7323503774444242, 0.7885911466641596, -1.7185570586977887, 0.42664075457430517, 0.8715879052415025, 0.7103436376867148, 0.0830474681790973, -0.22209617962766737, -0.09998492229447999, -2.7410396243868833, 0.8658783417729502, 2.012173343425172, -0.519727429052871, -0.37540393981297704, 0.30535826943970207, 0.86394247376195, -0.2876289518342811, -0.7271147844106176, 0.4728796904214424, -0.2780665034320756, 1.2005728415755168, -1.2698482092871322, -1.6862220264120014, -1.5393093914716385, 1.1849547115887664, 0.10295485399978528, -1.145553607573782},
    {1.1902001116219814, -1.791552851375737, 0.1783161911503218, 0.25958278152192893, 2.3817167897670433, 0.7181157192609138, -1.460828570904621, -1.3697300119327978, -0.6570593440712792, -0.40210971861682154, -0.7358450497323239, 0.04129754181621066, 2.1802102894565523, -0.9903696001887508, 2.3536688087964346, -1.1906878750271672, 0.5340201715440704, -0.43149402262195014, -1.4416691380767053, 1.3257343770996857, 0.3136257925102868, -0.002451778921141381, -0.08327336399527545, 1.4382274974532083, -1.229622080618842, 0.9896034863927243, 0.3683583540321804, -0.17634170033281404, -0.9668698670675933, 0.7509218285338952, 0.18031314752911784, 0.07057277614214595, -0.8069438702232654, 0.7601455212677249, -2.228579889541638, -0.9423094292872437, 0.4252370754879438, -1.254229703035428, -1.4357318688692375, 0.06853459322799658, 0.41186383874983246, -0.41443738964403937, -0.6530637010083347, -0.06789036263991949, -0.15338612765402046, 0.5872768788015708, -0.8148578805821479, 0.5551623674709848, 0.31627397187672435, 1.7489409992965494, 1.6588102541342276, -0.6956663456946716, 0.6812168523023214, -0.5809245919759173, 0.3435322739267513, 1.4559274926673746, 0.860629025654635, 1.466936979975994, -0.11577004331576315, -0.36682196176026144, -2.374923416387145, 1.2368345406729924, -1.194640220804672, -1.0445101124611929},
    {-0.40176791408489104, -0.7223585369069362, -1.1463432726454978, 1.7218069869620345, 0.8540005294076433, -0.10936953560622488, 1.73253826329668, -1.1574784214297966, -1.2679603640037602, 0.007120566642845489, -0.9788750499138864, -0.17932685668028478, -2.2896772780939543, 1.0595834287119628, 1.044696108723974, -0.06780477991789631, -0.5396090179212288, 1.2003240845314849, 0.16921048750712286, 0.4526270044525836, 0.5426579142485243, -0.3134569499504061, -0.5776018397086885, -0.8146007990505852, 0.2450387347398616, -1.6701053136373953, 0.6839705747740467, -0.8446747854400501, -0.43965108352873095, 1.087371264111872, -2.107525476965457, -1.279330073693682, -1.4994540687279123, 0.005343030319183705, -0.17733200627238296, 0.5686636186367527, -0.7432971793959848, -1.738472094446417, 2.419886713384256, -1.2228266469192342, 0.4937406492229637, -0.6550431125885281, 0.8726088988329741, -0.42662905451472577, -0.42308893391971875, -0.5370278600977492, 1.4277314739771254, -1.1385425002533418, 0.019771424636891164, -1.5445591478298628, 0.8815103782867494, -1.7964344963391783, -1.1812138693556122, -1.8576516309937836, 0.3925695278265533, 0.6062882382272663, -0.545302129534486, 0.8130170555284959, 2.0940671318542687, -0.6492656872690966, -0.6473501301183134, -0.6775929763109872, 0.5777375902425742, 0.8904807960667721},
    {-2.2632054941002875, 1.404902307744101, -0.721421892057951, 0.15037668048211641, 0.8558013911905696, 0.7132345584708095, 0.24308193435655137, -1.6378340822782245, 0.02882610358787871, 2.8791054462917813, -0.8687551838649149, 0.09553094190157063, 0.5380292709830257, -0.40838012070184554, -0.5972906723608393, -0.08261405189696912, -0.5199569850853965, -0.8290794197718937, 0.28636414438982194, 1.9011297431904666, 1.1242523045034987, 0.562276254340167, 0.4547709804615113, 1.4628911687633028, 0.38030407939428323, -0.6070206206646219, -0.7807885890084855, -1.6502914015839225, 2.1023175201765185, -2.4736602459822246, 2.0172059933393105, 1.3058282426696484, 0.8059176950854803, 2.6625404040143184, 2.0207338223837743, 0.6517540351792918, 0.9059132623272426, -0.8049969369994071, -1.5755092763310792, 1.3807175743592897, 0.6353589099419947, 0.6882610025270465, -0.157025869189047, 0.037329350171073056, 1.8030910113177574, 2.6438345620890757, -0.035550644348313155, -0.8615426384229723, -0.9204645160788976, -1.9874750953392717, -0.22699159303195096, -1.6929828148501587, -1.174650541399517, 0.6533451976370744, 0.21069105332247917, 1.8903228761171669, -0.651214468856611, -0.9337168622779611, -0.23511396352360361, 0.11578630608410076, -1.397973287343923, -0.8405191702800067, -0.003714563049095733, 0.17751706239528003},
    {-0.6982263858718095, 1.8518743128590256, -1.0190416288175566, -0.6739684439993464, -1.0225446359890746, -0.3708714185844573, 1.919789431902981, 1.3770596693284103, 0.7941257892502763, 0.3416484469166891, 0.6732239092668393, 1.9246664473192028, 0.9327039680704015, -0.8810953651421545, -1.0343890496419046, 1.0736668474674704, 0.06408388010998553, 0.6719364489049294, -0.5109509537240472, -1.1850472250346997, -0.4069224795573039, -0.5861976811005801, -0.04244700431832821, -1.0849382090366677, 0.6278888376194741, 0.063961928885817, 1.2061557502307667, 1.4016552919988978, -0.3796555249434255, -1.7872607529735747, 1.4484411295363204, 1.2474480276415687, -0.3776515461343773, -1.997483166529722, 0.2971285442174901, 0.02483818079608595, 0.3243533944043922, 0.7608463037381411, -0.8644359400855314, 0.48170862071103865, -1.110537351639904, 1.3325869532578307, -0.12525183500812248, -0.06760038425151102, 0.1286287832138618, -0.9190285729881416, -0.09707153120481166, -0.27230494429400465, -0.9609617536818191, -0.7222503383483836, 1.1828453931783323, 1.8851775935232378, -0.27725806609961967, 0.30277680906318005, -1.208241242798829, 0.1162529046838739, -1.0317270487151788, -0.655319785848952, 0.40287735101577116, -1.8972873865265891, 0.18459112381850962, 1.0945840806478273, 1.1121371465605276, 0.12561331951197127},
    {-0.22521374695182536, -0.01649391729854207, 1.4928487332371463, 0.5507893480363275, 0.7646751665832637, -0.5389879250062226, -0.8395446033130249, -1.135121170713181, 0.9510152932059817, -0.3605596180520681, 1.3709763531135921, 0.20556430187969185, -1.0761921119102096, -1.9068938419328478, -2.519850093931161, 0.07294567888238207, 0.2961687397190813, -1.6810762796108838, -0.1341661882310097, 0.16242945497967468, -1.0686875234561493, 0.5653007007238009, 0.40107164203331375, -0.2649019119264839, 0.2235272131578238, -0.2074180254465046, -2.426017639813296, 2.478946955357574, -0.09630979303021066, -1.1897739049614136, 2.041188158924533, 1.1647222649089353, 1.0494370870834768, -2.195842227100559, -0.1421451431187721, -0.8701886659654596, -0.3255803377402989, -0.06476968059690266, -0.2281024723447173, -0.11579638628560406, -0.9305735624376966, -0.6752393790940786, -1.3707316765615196, 0.2204583103307782, -0.65834779912673, 0.8031364376533213, -1.1916427156786487, -0.6620120249658198, -1.4815184751906527, 0.2929764362836068, 1.3225751389898115, 0.46664356669141416, 2.09790263369871, 2.2869207701891106, -0.8697540110682167, -0.9691397660472966, -0.7828636575427687, 1.6565631412767425, -0.012066880317278547, -1.3043552712138022, 1.1326633166312545, 0.17413357073405106, 0.7860701355351581, -1.8514008531748858},
    {-0.4921229445002182, 0.840220018848832, 1.0356053939442462, -0.2524894309213414, 1.5024123648992007, -0.4763630286077211, -0.38157199967047767, 0.04604534711567685, -0.26569030624092377, -0.7836145506513521, -1.3328449738165389, 0.02532424080007565, -0.2914097075227418, -0.08171987170334893, -0.6454815697979132, 1.2141334838692164, -0.1553074174908329, -0.2774076278202291, 0.703273886155337, -1.0850253790143567, 0.861340212210696, 0.6789406344212402, -1.094199802602342, 0.3344478344777651, -0.16152507137210273, -0.4293423693474943, 0.8921852581715826, 1.7231399850614917, 0.1992841149182097, 0.1201300333935813, -0.3484873051056894, 0.66331191131328, 0.7139871901238383, -1.075973052665736, 0.6154122609279419, 0.3439702918337815, -0.05047947424034692, -1.2705053457739552, -2.0192604742605456, 2.4437997997999124, 1.0415823524059775, -0.35880761713746245, -1.7875583583772132, 1.0512332202349193, 0.01622265585184488, -1.1174208871111062, -1.2192569932601751, 0.849694071761471, 0.6408414879616209, -0.48307492615915054, -0.6716752850404895, -0.3569296729311507, -1.2789368807283321, 0.5583873210601085, 2.0488796415690445, -1.045412855502235, 0.9309042664017381, 1.5384893334028564, -3.32293919201817, 0.3165962884292629, 0.5934291735932989, 1.0938599605584214, -0.5583203466513602, 0.5358460970704656},
    {0.822689804266982, -0.6303105696703196, 2.5506059966766155, -0.3044362215996321, -1.122455170393742, -0.9808998729700513, 1.0735372815133026, -0.6935874167417022, -2.178323250444457, 0.5625835437460478, 1.2952073343094173, -1.4190759627179061, -0.33471449896333094, 0.7477594821445135, -0.750734784858159, -1.5123134916111483, -0.49177800247555525, -0.23249887094263538, -0.3821185733616436, 0.44330987471791267, -0.14022503074810397, -0.2773481855934781, -2.5524256078818364, -0.9656074733466719, 0.5382947521326905, -1.056243245778641, -0.5256531391425985, -2.0639952992940382, -0.7634551121907296, 0.5944936765268047, -1.6652536504867486, -0.012078636214630662, -0.664072610532313, 1.0177275117643247, 0.5672242959053393, 0.3511204092352926, -2.090975690494086, -1.2717111669481822, -0.950152241802635, 0.6866919355384675, 1.9638501838415472, -1.3522740152044677, 1.3743462406653122, 0.5943136275462871, 0.11517525600761107, 2.3147420564829515, -0.9829069459537886, -0.32214398345087686, -0.07032302864783664, 1.6189322066411196, -0.2507897638795753, 0.4605859821983521, -0.43568181908619485, -1.4530678257825846, 0.4099334086933633, -0.03235241951026108, 0.476893988921959, -0.21883090603103061, 1.808191412258711, -0.24161445592257255, 2.176746432490945, 0.502635648297148, -2.8672408601792747, 0.6694308488970498},
    {1.103987967969924, -1.078504549048917, 0.7495927501922433, -3.003543850356219, -0.9335934815776123, -1.6635152904071755, -0.31073263861543515, -1.3571210964426164, 1.5683267061874029, -0.354973768185608, 0.5571402746844697, -0.4215719256984122, 0.5637342647764135, 0.1592431839152002, -1.4006346087131587, 0.7424671120762757, -0.16052427631313548, -1.3079390787423248, 0.15822119676905946, 1.478298169487051, -0.45873513699700974, -1.2594590439787496, -0.0022823795436722498, 1.432639797441665, 0.7146055163616725, 0.4436921587925706, -0.09808975974775154, 0.32095708317751886, -0.13560322496189947, 0.5390290426208273, -0.2328981264555451, -1.126814690807782, -0.9983377152482225, -1.203387238102962, -1.9202165798415558, -1.6565593617751753, 1.1018740015229815, -0.39738411985409505, -1.2222793395937595, -1.0696735168063558, 0.6814008219787414, 0.01880497781487235, -0.14767226282660845, 0.5168740868335935, -1.4467667017926722, -2.103176003996378, 1.9069891787089277, 0.6595869621700149, -0.03519371536890657, 1.7792540064071865, 1.8655554532361731, -0.7799273895383559, -0.28247227081605997, -0.2338447224577851, 0.12372816831905799, -0.19197323648808212, 0.21211077737781214, 0.11336169489076597, -0.9293920046033353, 0.043134092750606486, -1.8162861862422708, -0.9268825641409506, -0.275242298799461, 1.1438831860669858},
    {-1.5171934353225924, -3.1684961265346394, 0.2826682936913117, -2.388356414914652, -0.9300783496766623, -0.38104631418287793, 0.06124714300588141, -0.03510218020182847, 2.067298005282726, -0.9205604929818128, 0.52688541385413, -1.6085414096284598, 0.5763325718659696, 0.20129047856751603, -1.42804322844591, -0.2588737004100342, -1.1614828434082873, -1.2613632100253658, 1.2260288735939404, -0.2634795025975491, -0.34910122873886046, -1.5032410902742595, -0.6234661479477069, -1.283411410577075, 0.15174242069522453, -0.6729221003548755, -2.7295924294944087, 0.26527811535112505, 0.2836231656585018, -1.0152976102463696, -0.7568949356479178, -0.06025483179132888, 0.5227513067467778, 0.8364548917239025, 2.191000291727286, -0.32128483693022497, -0.6349504948896931, 0.41008665250101844, 0.341206891886977, 0.07602633401924108, 0.00438400265589701, 0.3160174574971668, 1.748535783206056, 0.6401473293579502, 1.2050952059043554, -0.8970181083189971, -2.0490938584643, 1.1754770053884023, -0.440988563091109, 2.171813969274504, -0.7966946685523965, -0.365806596714383, 1.5250927611697045, -1.2260759709362619, -0.5928389649740805, 1.5044361141691942, -1.2076488687325666, 0.579236837620944, -1.0000421116844576, -0.26926474079763313, -0.7951222230722537, 1.4959901735131766, -1.6367199836701147, -0.8746768454355276},
    {0.09444876051602948, -1.8599915529571742, 0.11446539201051784, 1.4730081671192958, 1.1138004018451018, 0.40958184095879957, -0.4562196220406876, 0.754713395919711, -1.0202722684099488, 0.5126259682404499, -1.1157738412999922, -2.2477573068560326, 0.20371423429173904, 0.7332515004685274, -2.605454165892444, 1.4536035104240141, -1.1257750042995474, -0.8085407598038445, 0.908146124194772, -0.560806860676947, -0.18132697799427525, -0.14235567709460814, -0.3451484997286302, -2.363623121164206, 0.07818568490192311, 1.7109653357111605, 0.31316173865393493, 2.2537943786802077, 0.4131482366936491, -0.11903303277487051, 1.8970843421824233, -0.761980588974218, -0.8453306923510092, 0.7188508058820746, -1.275541641688358, -0.5876064350875772, 1.1303420151907477, 1.5697036378266735, 0.5128679806079574, 1.9139970946543685, 1.0857295832671103, 0.536471923266526, 0.8796075764329109, -0.9711521592149642, 0.7126169540085888, 0.24563731338006284, 0.14572022939426424, -0.46407807774679966, -0.15681836140784414, 1.5084166881683643, -0.7349062363924129, -0.3378981779377877, 0.4602695235155455, -1.3013356587053484, -0.8841648587062682, 0.3271817786832835, 0.19829841222398528, 0.502374473444492, -0.5120791916716173, 0.914134241187238, -0.35874113256048973, 0.20520511800634395, -0.08831704123854332, -0.2215625704240805},
    {-0.4071479864405111, 0.6013168660338938, 0.63033240153471, 0.4049079438265798, 0.16189167786673048, -0.19899548564542335, -1.6900989066532044, -1.446830124228076, -0.20895472031133455, -0.22644064442846107, -1.9692922756124587, -0.8725369465870527, -0.8903705334163731, -1.5867925234953122, 0.9608530193667811, -1.022825036092078, -1.8479785913938616, -0.06749776856592506, -0.9188488537994014, -1.7569962529836174, -1.2134372044734372, 1.3975799641594764, 0.9647026525504275, -1.020133332481674, -0.7493668686633608, 1.607698268679771, -0.893163619041387, -0.6713965936619056, -1.428030877454075, 1.8627603435626703, 0.8826242608500094, -1.299301516641697, -1.0837673175174725, 0.11536423292298885, -1.830894398254838, -0.9425171217937489, 0.10132455728957447, -1.310650668223976, 2.4662129954606007, 0.11617659908971141, 0.8520287585292533, -1.9170649653677572, 1.7740077319424972, 0.1646429083536729, 2.189998596133082, 0.16522129881564904, 0.06334606052011545, -0.6798582375378384, -1.9678305853591291, 0.1310405208592514, 2.1085128136086526, -0.05655908435393191, 0.740503132889884, -0.011676164177259188, -1.1701800173912429, -1.3922171946694069, 1.0859273609971918, 0.006341739306389108, -0.35942870142741634, -0.11244934384220077, -1.2142995582467728, 0.2272256877938435, -1.503159026135466, -0.2227557194684975},
    {-2.107603699866244, 0.19259955650727587, 0.46070035234683, 0.17241192115570592, 0.6208916917890572, 0.7207748054465477, -0.3958112865339403, 0.7630659517710284, 0.13718813056781312, -1.2479608300267957, 1.2030576093651206, 1.0597868785776072, 0.7759711347059738, 0.6675866286092008, 0.6389362015256729, 0.2867454514051747, -0.6886874365664316, -0.6887861834142998, -0.8811099019774249, -1.879674916447726, 0.13154116865668444, 1.0731003281928204, -2.359613458462285, 0.9385329528950322, -2.487306401962643, -0.06885001735854358, -1.0759083581451765, -0.2978286999654156, -0.21675143465125277, -0.7009898593101278, -0.6643477236068539, 0.702072910100542, 0.9933754119692101, 0.7089484050335377, -0.9998999699004838, -0.5369179404868706, -1.7522322702259965, -1.1547191568587831, -1.6350628419599327, -1.7923909710931405, 0.5524414439336719, -1.940334181635826, -0.2507752348382464, 0.4462837793625034, -1.2752763431275718, 0.7713226999025808, -1.424543128527937, 0.6514211378429006, -0.10448206462273114, 0.010674779856914176, -1.097775191686567, 0.3127532007440311, 0.9250833851799048, -1.1964465269518352, 1.1392459340175383, -2.729881268761399, -1.3004046021059086, -0.525185962263951, 2.7434822230412843, 0.052209857722733975, 0.41798037803710664, -0.9120753961027679, 0.12686437919141724, 0.4310360153662579},
    {0.17419961768359418, 0.6693286295743318, 2.736861417807067, 1.0459602919221396, -1.5387143895482098, 1.5362103602991144, -0.5415799575629765, -0.44600819218699334, 1.3522906141414222, -1.911828495682982, 1.5424027672119733, 0.4740840395872848, -0.7775615167031975, -1.9390944530631398, 0.8519920040096935, -1.6385711714438609, 0.013845753627904479, -0.37940046666406657, 1.1783167302685704, -0.6108857194428289, 1.041558148860403, -0.9514165470279236, 1.6696786658732554, -0.38628476099665127, -0.6596384137013738, -0.4723547021256711, 0.6950892338887367, 1.966223612239222, 0.7906040501132781, -0.42335087237566943, -1.5248017466621522, 1.354624276107109, -0.6074384690031782, 1.3138800183916963, -0.9071160180504663, 0.15079051953766978, -1.4339684851097778, -0.08292926286790145, -0.20051978869513692, -0.32028136079357616, 1.8551445031698044, 1.3417871524902092, -0.5263428968550736, -1.2876248531959502, 0.47563584478410686, -0.7373241042144393, -0.08147113053748628, 1.9776135082026178, -1.5973765633301935, -0.5745597488203336, -0.9274050757755339, 0.4946345795158454, -0.5543847699468, 0.6015449736399786, -0.07173118204037666, 3.2146480200468877, -2.416769064668076, -1.2607483459945446, -0.7273966516975706, 1.096175076012698, 0.013728207367859771, -1.4620971802573668, 1.3454765853625315, 0.42306598228258185},
    {-1.4488732854915434, -1.0626376467693084, -0.7726576819917887, 0.9140310598540113, 1.1590051225914149, -1.8481479274824555, -0.24723170577874948, 2.7409611275181085, 0.12375596517692602, -0.13403743601065002, 0.8065610480259607, 1.2694203194068667, 0.8821543567270758, -0.1822030890777177, 0.2666682348219979, -1.522832107151217, 2.635465572313254, -1.0960550256221058, 0.09610369369365572, 1.9071872598135877, -0.9415451413853871, -0.3292306864186285, 1.5287722846081973, -0.24353966912715574, -1.0091957220553494, -1.7851580080233846, -1.2107682891087312, -1.317980523634352, -0.41057754565794574, -1.9717202176920525, 0.5452423191559084, 1.7997095029573376, 0.6896175129797948, 0.3664262408572167, -1.3790772685064332, -3.5506197505891084, 0.42797460094530715, -0.6914689651158039, -0.8344221860549306, -0.3163608514999555, -0.18621703535949033, -1.3438578051986823, -1.5914276660610425, 0.04735104834323137, -0.4292957787296331, -1.1874229723876486, 0.23431871090888817, 1.178199009504513, 0.8892434109776439, 1.0283645103465617, -0.8475077908116916, 0.008698097680542702, -1.3784185687009836, 1.2173328156527858, -0.35229076072162185, 1.545780176926826, -0.9836336773210878, 0.9739384860791689, -0.020059347627053047, 0.972184318699218, 1.4555393660063671, -2.7844342431880196, 1.2769921540416709, -0.42546117198257905},
    {-0.2708101096286263, -1.263341462901803, -1.9135601173005947, 1.0693653845404352, -1.45420451009313, -0.921705135488546, 1.4114203008569122, -0.477591609049525, 0.25174041875905906, 0.5114251791133508, 0.10801887239215929, -1.7630541845091636, -0.6128849780519318, 0.3900811805578007, -1.6087155805512714, -0.4597643362273524, 1.3671541813388652, 0.3773212950796327, 0.0571303702847598, 0.5842090411978481, -1.0305582725281508, -1.6133057543009819, -0.8296926514008605, -3.057367460225558, -0.23258420798072144, 1.2343760606129868, 2.8036172831423256, -0.6952208346548897, -0.3688175459951548, 1.4206530448516954, 1.444296125616998, 1.878511350434914, 0.013191175244528359, 1.0267135884543526, 0.7340688272949851, -0.3556847992352601, 0.1307630919629883, -0.489704185403872, 0.7017578303181299, 1.0397904041523942, 1.774229011850529, 0.2351783431106251, 1.8177663689724355, 0.9951622243152562, 0.9518707910069703, 0.5994757921467556, 1.63082054476123, -0.5691211345954265, 3.6303674615174684, -1.0610819563294294, -0.8720293029826737, -0.7727314710817536, -1.3914152282853347, 1.566461082989436, -1.434102770697562, 0.8020360844435445, 0.2314229259361287, -0.5388783888300235, 1.02626565972007, -0.8756485836168656, 0.07170573097270283, -1.0276219774746964, -0.6749818102342201, -0.8818148054051926},
    {-0.5440655773703548, -0.3879243152025682, -0.33695464474639103, -1.4243665272888733, 0.10830792596397446, -2.6823179044483667, 1.1973191904037175, 2.927075678679224, -1.0064440432798671, -0.36117202998568126, 1.034094696998071, -0.055353921112209166, 0.25578386346957793, -0.7995294513059229, -0.45491878706889466, 0.16334569935177862, -0.1451696628682267, 2.4389346892822816, 1.3083891233469664, 0.09835152147156102, -0.4569359944327344, -0.07970119002692327, -1.7860899309107932, 0.8037243485974781, -0.036501914198266545, -1.881970095627651, 1.5341620070906998, 0.5017293203189452, -0.8104101855156639, -1.6732744991912958, -1.6353272383506448, -0.48260743763274755, -0.012975861911809574, -0.5578991776715041, 0.569380043276041, 0.026860451677126876, 0.4965722249586171, 0.2614497152877773, 0.09130890560934059, -0.45925522485104536, 0.7956275837248324, 0.35113792343886624, 2.5094361093558724, 1.4364190775261965, -2.043659002370462, 0.19164817676190005, -0.1537168171087959, -0.3205075261493734, 0.060627011540162694, -0.4727435102980749, 0.7415728628666568, -1.8636959842406204, 0.14639716751506668, 0.1495156296849711, -1.9625500565795557, 0.5743871818479499, -0.26049161017449285, 0.7126280429317452, 0.7488038780539106, 0.49023198733128687, -0.5690539069043216, -1.0012673821264495, -0.3753924773816055, -1.633612791779983},
    {-0.7851486004947101, 1.3509375149884362, 1.807232882567321, -1.0461085048445906, -0.7981496706141484, -0.8958103919854752, 0.7685801533648836, -0.2839079425880573, -1.6621912497484763, 0.17305342050605727, 0.3771751865640007, 0.7196086136437992, 0.10414847971972432, -1.0445114769376485, -1.215267306153421, 0.720833976052134, -0.2347745658374996, 0.13505429667781316, -1.8287036284768123, 0.33330818908428805, -1.3555680108545434, 1.5229395149250013, 0.7324952109737063, 0.24830789470712022, 0.0710806167520493, -0.2167345132049161, 1.6520838738504642, -0.04675207950251493, -2.7798788899292095, 1.5424195585406453, -1.1942425589684345, -1.30292674579549, 0.5855786198746165, 0.7469124776628341, 0.24585447419483714, -0.16926606381069506, 0.8429856912988348, 1.158951440940899, -0.5557444215798438, -1.4411575531621672, -1.097833576896548, 2.0495171246338444, -1.648625735687044, 2.478005752389638, 0.3219412180902233, -0.3699554662201987, -0.4029798017742905, 1.1290485269557733, -0.31279989291699406, 0.41609158119155465, 1.29641370736535, -0.29695079157135995, -0.4352693510484287, 1.6184931705464503, -2.1841102724163557, 1.379281838140508, -0.6726312627478553, -0.6487875818445189, -1.462335622067494, -1.770954124256289, 0.38304484054842103, -0.7075196161192377, 0.7972148798790512, -1.299499754263957},
    {1.2364679302789576, 0.9025736516152204, 2.4656202989081764, 0.1808605744339373, -0.21751794255915113, 0.8194096458114009, 0.37004912490126496, -1.5627635758722191, -0.012548104885111447, 0.5623156851971448, 0.3794406201787555, 0.28987645715862936, -1.3716233455196396, 0.2979121349365143, 0.18428045970189458, 0.05570456164807485, -0.39485619133326205, 0.2583374106702822, -0.7647275337543666, 1.3329816668171663, -0.6417960176194514, 1.0398553010303702, 0.05250578569366676, 0.482656172807023, -0.2850959109638224, -0.42480788482546383, 0.6788477657866135, 1.4529271514320963, 0.733439852445676, -0.32804566482589725, -0.226384730425366, 0.48491253482193886, 2.5033314740874517, -0.6388743145064409, 0.866968142697293, 1.6326867167205428, 1.6172223692767476, -0.015516541546351058, 2.031961872928736, -1.6684070763067336, 2.7709198102456476, -0.8199224136031994, 0.17715975696154296, 2.4151600509041655, 1.5121211706622666, -1.0470238317726908, 0.0992522924085866, -0.05087626850746332, 0.5406731712356586, -1.4007343691999854, 1.3664985447203417, 1.0658770941069846, -1.428313266126273, -0.4061336460014482, -0.11795931628770062, 1.520993531142863, 1.1771237382951885, 0.0896240800766631, -0.4924395777350314, -0.371987416655212, 0.5079515901141509, 0.5806939250885951, -0.4302859460283137, -0.887040958768124},
    {0.5796236942757546, -0.46827781781404243, 0.15991261095372078, 1.4743814677847784, 1.8422660956755137, 0.6748341243418712, 0.3581673529957883, -0.7210992137980391, 0.17073895165630412, -0.5416813949832772, 0.20143703854418313, -0.9586605079736952, -0.5162006203767047, 1.100185016400988, -1.1344897537766074, 0.04153064010686151, 1.6150801463248292, 0.22805179664517053, 1.2174907159056656, -1.1883761129855843, 0.126264850201322, 2.0908738442755808, 0.06847842253692649, 1.1501434939095625, -1.8976101683742266, -1.8259887551126797, -1.481623495725421, -2.092510206516702, 0.9528007645213318, 0.435680251141149, -0.9601555424513971, -0.3671241870942425, 0.7715807739292532, 1.0835328622150135, 0.8818491538881569, -0.9286195817630801, 0.26519934101937204, -0.9281584297705513, -1.413886494194875, 0.5771750423130044, 0.09774978313410963, 0.43085923444143476, 0.4376107311013799, 0.4113416683094776, 0.6924492951375582, 1.987267549417987, -0.7787071453397735, -2.089761056186934, 0.6400337898879388, -1.4318123447462145, -0.1532004802337028, -0.2076626227811109, 0.5088433069400476, 0.1725915168261776, -0.22246746103927573, -2.301036837845417, -1.8223810034463168, 1.3711213313800255, -0.16405403229101678, 1.0231990546833776, -1.9780349103388313, -0.9187546621884137, -0.7208064236510348, 2.728058139248975},
    {1.0784554202740342, -1.3610506684696477, 1.6063281272122314, -0.7127085233162271, -0.5183252992769448, -0.12073448038084358, 0.3220705162475581, -0.6546018538720896, 1.070726729695397, 1.308599163086974, -1.313331576271838, -0.21518971115472751, -1.0664372573706307, -1.8808878113081766, -0.0058923083277332405, -0.47668618491720616, -0.3275646041648153, 0.9916742706803158, 0.6618425181046985, -2.0499435701673465, 1.5380990763196254, -0.03404573849595947, 0.13693088624973332, 1.3323499693060565, 2.1514855271382913, 0.699333569252573, 0.16159061077881104, -1.154142222806219, -0.3771628081884859, -0.6383161860994235, -0.10621528943258718, -0.27180902787688666, -1.5526162721341525, -0.38067738768799914, -0.5903238674211682, 1.1145258167632919, 1.1872853606390372, -0.1685913842773494, 1.0785903466614832, -1.6340496242706257, -2.788930976267931, -1.1447716175450617, -0.09063705126596526, -0.08031292248413716, 1.1452445687985202, -0.4688788176352764, 0.202802054298515, -0.5063145334348047, -1.2444042886451665, -1.2451586251857645, 1.610464960302564, -1.1520145724875586, -0.4844815605989567, -0.23164209059947422, 0.5579284516672578, 1.0015597582631033, 0.45187322614517256, 1.3246873284158003, 0.2875567155328408, 1.7953443656189028, 0.0596870828931315, -1.5308609283282544, -1.276075914673158, -0.8508502828712429},
    {-0.806965283285468, -0.4019519037789623, -0.5661470171821827, 1.0347817648478856, -0.9750911168975797, -0.5495694081299215, 0.82045944528055, 0.5585254713767155, -0.1134093904030531, -0.8451807329167276, 0.7282179096573301, -0.5903328468928846, 0.33100806959877027, 1.4650564857083612, -0.1123680687421296, 0.8270659240998185, -0.8572863856741458, -0.36189833429855867, 1.0038762879844698, 1.3637091082335284, 0.8767548779444722, -1.0077876766576805, 0.1960152588852233, 0.46672874179472884, -0.022186694713573162, 1.1875209837706293, -0.567212612631182, -0.06306105797520523, 0.5682522004807578, -0.03592024058784958, -0.8744247427100051, -2.0173227245299015, -1.1745900324215843, -2.4073062003175596, 0.7239555679778987, 0.5171708140886389, -0.8686920257025301, 0.012365854880584152, -0.054648828638648214, -2.688715488734849, 0.812990131348474, 0.21964429993061726, 0.37545772511556924, -0.91639038017272, -0.1876200295340588, -1.658311178648343, 0.4721292656788018, -0.7511012645371747, -0.32715985122192887, -0.47792884796313884, -0.25830644095048516, -1.2025128224050616, 0.07075037485876799, 0.5496905600391072, -1.2736796850201433, -0.8412335657612859, 0.02212164486800503, 0.5198984884802508, -0.2668319372166344, -0.3303913821692039, 1.2825862786740811, 1.510049673472242, 1.4034642081387008, 1.5925287402854276},
    {0.32030170714365325, 0.20269952318203135, -0.7631036402888223, -0.2387133335747056, -0.47828726060695903, -1.2570364692635676, -1.0935100802743676, -1.2774100104451191, -0.37179765374198925, 0.7587863133141017, -0.2933099862938912, 0.23269000882182703, -0.07335579379818562, 0.9659773490535475, 2.3644632772906995, 2.5415707867012394, -0.0713414058864629, 2.0116946070250017, -0.3697133795065022, -0.3302418624536055, 0.734499529859546, -1.878906625630303, -0.10136767023910008, 0.30680697521594796, 0.4616647951642276, 0.43926277425178506, 0.5259115182088372, 0.27573201472116965, 1.1857460820625465, 0.366698141706648, -1.435141654715315, -2.6366917468547424, 1.51735737120086, 0.7513746521540133, 0.06489669221282496, -2.0859193809181504, 0.9726381776520404, 1.403393848226644, -0.22201936375217216, -0.6901551753773071, 1.6385727182649585, 1.2635353580767226, 0.6946457869885948, -0.40607495566911966, -1.9097026111618758, 1.1435528628440002, 2.132829418291801, 0.7552355299569549, 0.4550845750251803, -2.0152451030127483, -0.30446458469105364, 0.3460986354494717, -2.3959192355980994, 0.09449293311559491, 0.24321578684181624, -2.2438564453672245, -1.5404928007747967, -1.9102680249312423, 1.3397113223174932, 0.21770271998514384, -1.3822967017761638, -1.886185922735229, -0.18064020028877792, 1.3338096455360153},
    {-2.2172415501763223, 0.6086489884868075, -2.853555053415277, 0.18664593649308145, -1.7378925074148672, 2.0916309456071893, -1.9871655796779377, 1.0595607468632289, -0.7293493539340743, 0.8990931092399866, 0.6774370900125143, -1.2854340207434332, -0.7010916198537117, 0.6373148450709629, -0.024325123453302816, 0.10875722182220379, -1.0859345049458775, 0.7303508903262788, 0.19473394416759043, -0.6094790950322202, 0.10823104927592322, -0.5676304682910377, -0.3087091517645964, 3.1346252909794554, -0.04020671385615464, 0.6906264849120778, -0.20997900601656927, -0.1925139564185559, 0.2979983067495271, 1.1171704901235149, 0.37205218112464805, 1.0449674702969969, -2.7266236766156853, 0.0222969370177885, 0.6794635810873347, -0.7315232308018701, -0.7121913011028299, 1.4826095076434591, 1.3818545612491409, 0.2033556348811868, 0.8147118060876782, 1.2425735594945184, 0.7929055890254089, 0.02628339617649085, 0.09852082803642265, -2.1503671166528378, -0.5411687816309521, 0.015478633957168364, -0.1967684604074977, -0.9528046571562528, -0.09659562327386559, 0.5601864938612137, 0.23832981580184617, 2.708534957229965, 0.6843207130660698, -0.4860751934734823, -1.5466773638265796, 0.4865324344359874, 0.026464419372043253, 2.115035455301036, 1.4880206222628665, -2.1977815942665573, 0.18386895765173653, 1.0017465700257637},
    {-1.2820936831366885, -1.9421576708187447, 0.1360812538308616, -0.7623725196189879, -0.5014735852751745, 0.44041585589235405, -1.4897271482221481, -0.23451341476999724, -0.9574205889300679, 1.1083885368328488, 0.36552905007089825, 0.3773786317885496, -0.17795166464311957, 0.13213894735646592, -0.15877346695533626, 0.3857081098891137, 1.1846303891045855, 1.6474205278854548, -0.043926457266441524, 0.3443083209417328, -0.8649903410094637, 0.31715718425291106, 0.5795400261186566, -1.3609720350337327, -0.7402351953401691, 1.5582826621504247, 0.3077894203485386, 0.5863041136366036, 0.16158263096797065, 0.0794703355723788, -0.06678512863912771, 0.08606069440448172, 0.253893920502962, -0.06288338506775303, 0.899333458712205, 0.11546151985140592, 0.4057734548166592, -1.8427294600601305, -0.24439442463851827, -1.9719525950968657, 0.07430949536311587, 1.0559068296901974, -0.766800013274586, 0.7551551474464858, -1.5273468020837133, 0.8862660279591803, 0.798564706302314, -1.5377582695149725, -0.2994308660983938, -0.2801447306540418, -1.030474355044372, 0.9096170687778709, 2.058734211591856, 1.052227568507873, -1.135447914986449, -0.09607270961128017, 2.2757556984498297, -1.398768553625247, -0.1709452620630242, -0.5380041394170445, -0.885223265247738, 1.4339297921744323, -0.21848028271864306, 1.1669211619802309},
    {1.8767079178303752, -0.5283086027899532, -0.41264163051321107, -0.17907364562977518, 0.29354436056990724, -0.08331883117008719, 0.6984550174648427, -1.4003875816005917, -0.9115027838466726, 0.3394468388151878, -0.7641939990206558, -0.5744544002350201, -0.9208240197332443, 1.893198055371352, 0.6976746750023467, -1.6629014177259291, 1.9888188945110072, -1.5838809111759278, -0.9029236811300101, -0.7866725540928238, 1.1066761201059927, -0.8479136020303184, -0.03015045135574416, 1.602879627432992, -1.0121407131455549, -0.017220988915057796, -0.09702099861739365, -1.5168404918727387, -0.8939167709383676, -1.5804965680964573, 0.35711566656390986, 0.332025369948326, 1.0331312125871097, -1.6984889518180402, 0.9726434803958763, -1.9691351411512248, -1.4443889852231393, -0.3074855217745253, -1.1837258158522737, -2.3672174295058688, 0.6290041537295967, 0.6709951128410839, 0.11156921786417591, -0.7488493378557183, -1.441130655968803, -0.008912473204492838, 0.7696013974640529, -0.10066460388175831, 0.8051831382748249, -1.0274944353910533, -0.13929069759070759, 0.5308664366128443, -0.6478332784107256, -1.4332155702155285, -0.4440313292321052, 0.9024606852354519, 0.4860367624513491, 0.2719765244512808, -1.2546969832130737, -0.3674551128217077, 1.311110549550952, -1.4993480876018959, -1.3613688155068964, 0.6964280808352091},
    {1.315886627980737, -1.4353978078546403, 0.8030813360739231, -1.2158263720262652, -0.7087443136551913, 0.719648805748423, 0.4370338458160148, -1.618855573761462, -0.2654277458803917, -0.08903789078050121, -0.011513109104597767, 0.1955736440597674, 0.5462385169528762, 2.5200672728089035, -0.06502530111066265, 0.8212259273493311, -1.7504399803053494, -1.30734166125555, 0.4777546049207065, -0.10085356897677844, 1.4569457762652769, 1.297391100245173, -0.2052089041287828, 1.4203764836179782, -1.2411340646096864, 0.7789638381671028, 1.181596784321353, 1.3210935701505055, -2.3586401900282703, 1.0425161418908602, 1.461320067886824, -0.7795620691300151, -1.643508385233634, -1.9915684696369351, -0.44190197566375405, 0.7676965603687417, -1.6496164447161707, -2.317597067160824, 1.155547701644506, -1.2618692381639232, 0.4169992811264645, -0.9469336225712114, 1.2217680260046344, -0.962373227149309, -0.7727606565410388, -0.35254229765115336, 2.029953735955854, -0.3329488634318365, -0.13676500959747767, 0.2353699646167583, 1.1138688677836197, -0.36050147077800787, 0.5290495647854012, -1.0530845413575731, 0.9686086078536945, 0.5124612808344675, 0.4603910200011952, -0.9910678058105018, -1.381871157634824, 0.5932946151049611, 1.302832633315653, 1.3652417954454195, 2.1022758628845852, 0.7911615846109895},
    {1.417765366405666, -1.2025953472410735, 0.09793163405607966, -0.8574014829575455, 0.8211463688925911, 1.1679573382613102, -0.4855199419462442, -1.7344815384348629, 0.9785237621191761, 1.6383969633758702, -0.6305090384723518, -1.1524922919006175, -2.840382014326491, 0.9712192595713456, 0.6662637978007997, 2.52247719449292, -0.25362328888899316, 2.133056146144982, 0.0187752807989889, -0.5678271285185249, -0.02927017605392502, 1.0825950084320743, -0.5165974847629431, 0.7740330491980449, 2.0652481857081275, 0.5506367180937932, -0.2366865567991108, -0.15995931822843637, -0.06728054293898558, -0.2668820687488457, -0.13048128445379384, -0.5309567286360338, -1.2741474334074478, 0.8138733295921865, -2.5260248303490944, 0.6531822515038008, 0.48387515449238205, -0.9122191752760697, 1.557421411155218, -0.40070710022504047, -0.3843021922175155, 0.5463942671808487, 0.1438902827208265, -0.6533742746819882, -0.9862298099808793, -2.4828074314590527, -1.2010839755767992, 2.714567622694056, 0.7146937438003983, 0.4008503549053401, -1.153509044548999, 0.554626464055111, -1.961485602347808, 0.8693757856325789, 1.1976112759198416, 0.04096461217509508, 0.4199901656780631, 1.1506662815034647, 0.10181420944053671, 0.6420956334346062, -1.920223280977979, 0.3931586296332305, 0.18528424088043247, -0.48477266120843854},
    {-0.24815858185732906, 0.6376425063843827, 0.679430695159241, 0.12028897340776569, 0.7418249982571798, 1.034350499041889, -0.38096863968087036, 0.22566617997975028, -0.2057848403926123, -0.10008830216606886, 1.1047742597666683, -0.44377908703522345, 0.7532437814662652, 0.05202380845255831, -1.464767683893276, -0.5517823637151861, 0.4011239394989621, -0.9640643638558409, 0.7107363059812639, 0.688827113927184, 1.9766801857259328, -1.262737841105864, -0.6281663938574026, -0.1991976340697307, -2.1388920854689886, 1.3181560293778134, 0.6413530759837838, -1.6867728581907577, -1.2768800435927439, 0.6282776970869641, -0.38470651423547714, -0.20744685661024295, -1.4290366679674589, -0.15181316492397381, 1.9751377672425228, 1.1656316719042632, -0.5804194837188272, 1.6065356087455112, -2.5790332735185113, -1.5561453245105772, -0.5655819155256407, -0.29602472719597867, 0.5118999068326086, -1.9573576819750127, 1.8493312619850133, 0.35872568275776295, -1.3827456337623905, 1.1885367177062103, 0.03697764328050982, -1.498287176590241, 2.4796988559659585, -0.12644147644448148, 0.5592346241741583, -1.38365335985555, -2.0481070341039493, 1.200166443431781, -0.14633036757561685, 0.28168520671348685, -0.30858425854254207, 0.43611712064440433, 1.2320591937016934, 2.1560744838321, -0.7489092527666307, 1.3131147324234465},
    {1.2440695026467263, 1.0042472975105086, -0.8418024178293231, 0.40815366625476507, 1.6449004018507305, -0.48865949171371764, -1.7583155140502922, -1.8185899865228192, 0.9932376695984552, 1.35442109836772, -1.3605980399372688, 0.22089995440860405, -0.6424529930412833, 0.32536958058455095, 1.9059710600122455, -0.5442609647160138, 0.2855141674324393, 1.4390806465911175, -1.293349865235756, 0.6287389210198027, 1.8636786606658946, 0.9042776956667231, 1.4385814987224939, 0.12900251850115624, -0.4550069658861993, 1.1027666850400322, 0.3760645657791081, -0.5624368279144101, -0.24446694215859935, 1.392880486782967, 0.863579168493781, -1.705800079826426, 0.9573513921729012, 1.1543321823487271, 2.3805408944074893, -0.34133428957743556, -0.764398256982558, -0.24853780141506526, 0.07762415446971162, 1.2840770990754975, 0.5844001189513828, -1.1804107508590145, 0.8631787101090732, -2.2468630760046513, 1.6251567005757661, 2.6074348744060614, -1.047716781867208, 1.2170852408893933, -0.05895639434266012, -0.706950204866062, 0.009812985576385795, -1.6181978389781366, 3.22395490075419, -1.6304979336315624, -0.7629001131605435, -2.1585878000455763, -0.05855414278746638, -0.12161519926698662, 0.19101848287932752, 0.1230659820225789, -1.2220728791019062, 0.39039031620781817, 1.6819702083617944, -1.2475705001506707},
    {0.28189859230125464, -0.2722761411141861, 1.1539776326387958, 0.25559389129979554, -2.0072035874629734, 0.566435461826773, -0.24036636912831616, 1.45138667025316, 1.721406077321578, -0.14949357588432988, 1.162271598171289, 0.5023278119065938, 0.7102741323478694, -0.05276066713467493, -0.9236555168684106, 1.4896690382498023, -1.1686583657855845, -0.35406433462492565, -0.07518284859460736, 0.46027388419197784, -0.694631959340254, 3.2671769627011895, 0.254689569579305, -0.9963500068609014, 0.6815142564514997, -0.08247412821758317, 0.06969868435452735, 1.7881010656602072, -0.23736308261691827, -1.4217655464929286, -1.4175895215051588, -1.4714192617766209, -0.2741415727940074, 0.2968059680692697, 1.3069272900111064, -0.4358630221731133, 1.8597553208424877, 0.6477618161148943, -1.2784120438837054, -0.006727976605974788, 0.7070550513485073, 0.0024609837019839253, -1.1110631303723664, -0.5603271606642152, -1.2868300258017682, 1.4720357725290978, 0.35528413539377185, -1.5503160261525302, -1.129393212595093, 1.4365005652232756, -1.1264242189089948, -1.4373971470839673, 0.8456037888675804, -0.5183205214555751, 1.0076000656658524, -2.0743675226840192, -1.4956281436228267, -0.3019338118623797, 0.8278947979504776, -1.2811177219210652, -1.589715498484917, -1.785492242418268, 1.4215145154118884, -0.2241131223623607},
    {-0.5031101038297285, -0.5432617205495055, 0.5514623183986875, -1.28988955215239, 0.25801165934016074, 0.14726818128650535, -1.3284405745388679, 0.07878812868234233, 0.666047186885883, -0.07867697340457187, 1.3338989962665682, 1.4931519551537487, 0.8278441725126399, -0.2761497808913157, -0.13147205026596434, 0.5033492541507315, -2.093983178594675, -0.48666297783872514, -1.244961589650306, 1.0540396018678815, 1.0956822924469596, -0.42641652336287533, -1.1065093640091905, -1.0541854573153135, -2.240543516729773, -0.16819052286400304, 0.7384871989845683, 0.5605154590374388, -0.5039137968607093, 1.0279321489546067, 0.8449040593312557, -0.7976819648793171, 1.2030992218047831, 1.0941744596938257, 0.669822540794841, -0.919235822337022, 0.8860473130744707, -0.3964333692409861, -0.4512917136419403, 1.3210692179586963, 1.509300949581449, -0.18440066797213642, -1.0193379857276719, 0.17172184784499347, 0.6828784858248658, -0.9336243305461188, 0.3083985131022506, -0.6646504665206694, 0.6439819411245004, -0.23306807955687164, -0.2942416982648094, 1.3001233265224923, -1.2660261747411627, 2.6841509637316676, -0.09854342015165019, -1.5880174894071906, 0.883962778202853, 0.04686993323815122, -1.8101263862998183, 1.2095794770072859, -0.7399515644831413, -0.5748498994442856, -0.7534461166407281, 1.51971430835763},
    {0.21070399633721262, 0.3679690962902656, 0.46095851764219753, 1.3326552892274754, 1.0643093903760545, 1.9681561819838538, 2.0923946523460004, -0.10928444134656534, 1.1031901595112683, 1.7042164755300913, -0.22054304346480758, 0.4357110970771151, 0.9969624070337694, -0.8097453959063532, -0.1391670452947372, 0.6175185899219076, 1.1911867534727834, -0.09195952764259052, -1.219232205730094, 0.7081695671382433, -0.1735181698920322, -1.4129589965654266, 0.1255950032055133, -0.19761724877004502, -1.0681944723781167, 0.6559033970350387, -0.8960295869567864, 1.138595260315761, -0.764908735641387, -0.4092553846512081, -0.46373559915265267, 1.0840376595742454, 1.7549130213762274, 1.0393921158879602, -1.357724443057359, 0.2865099562374804, -0.43613070986056907, 0.05087283877753235, -0.7394567664873407, 0.2897290970955231, 2.405954886733997, 1.1777178697584192, -0.8307449874627633, 1.6544179569645328, 0.7445569440642805, 0.6888385400655396, 2.4833311722299882, 0.30024754379676866, -0.07788150977414317, -0.0037719681617566624, -0.441204411867068, 0.8404022038178008, 1.3939132955342008, 2.1567030432657983, 0.2214683286311369, 1.2037185549764073, -0.4760497888045521, -0.3213596414935747, -2.380121494322879, 1.3665139928468193, -2.13962323538039, -1.0273558084963599, -0.5734420941119315, 1.954619680242044},
    {-1.4768345220392054, 0.669846020879124, 2.335558116632911, 0.663604940612291, 0.42162963911688, -0.12147798267677151, 0.09056582202535554, -2.2911986148349657, -1.4126416769936194, -0.07498186498707242, 0.7794284529274481, -1.8276660471438768, 0.448900737326273, 0.3162712958814899, -0.41638252491604777, 0.1272351588674787, 0.019354980214299274, -1.0108255414757072, 0.20191932202428933, -0.4024879179162222, -2.6554042688231982, 0.31760875487786966, -0.9520013588094415, -1.648466742205393, 0.9989903535647153, 0.6650145097887649, -0.4994897298880361, 0.06862898071606778, 0.2069712229502601, -0.46491708081582545, -0.8084552224025399, -0.021219942690169462, -1.0669666086036056, -1.2713963714862988, 0.4675482762813105, -0.7246897082300965, 0.401420450118959, 1.751755567309992, -0.9762602945759572, -0.18786128612494782, -0.6347979254226712, -0.031069684445671288, -0.6239324475510417, 0.28485525005973844, -0.6965710357905239, -0.6257396171810933, 0.3790100561514771, 1.5614009624289915, -0.05907713973582843, -0.3139939830286492, 1.5497715367080487, 1.3689463140360867, 0.9863272075606505, -0.11876735340737354, -1.5089039449772117, -0.5490274121072507, -0.5248302287808585, 0.04872779606573118, -1.9515837690981532, 0.5760937140191621, -0.4755103903242082, 0.19409202149997412, 1.1947543826566793, 1.1407152241227363},
    {-0.8656380284486017, -1.5230831760228152, 0.4623829225134134, 1.2009161297378608, 0.41192924138014586, -0.01060064298915862, 0.37468634805668916, 1.0616571263784913, 1.436891168842107, -0.7189284577185711, -1.5463654636197846, -0.8684131470358649, -0.007093716605229112, 1.490563245749574, -0.019475320848547414, 0.35096002230098183, -0.9945673875885976, -0.7134764072374097, -0.38654557548761986, -0.40587435096889346, -0.9270410967718332, -1.4562062370974425, 0.797688297112781, 1.54935295729724, 0.3510274404453027, -0.8852596243715409, -0.20248564286026874, -0.6435190240536566, -1.4569540953486757, -1.458691107026701, 0.18701156634936536, -0.479739582612728, -1.5678663754665374, -2.465723086047008, 0.9389225700620994, -1.2830919436356751, -2.393540758177679, 1.8555654683199347, -0.7342239964705445, -0.859771015196568, -1.150388594549974, -0.40674583884394555, -1.105665706930877, -1.3966881277114913, 3.3497715707422726, 1.723285625175651, -0.7430204696810951, -2.2367082790735284, -0.5256779573727787, -0.9105067467138417, -0.7545554509186957, 0.9590951391459059, -0.39237149735915616, -0.947707053607889, -4.927550340811584, -0.1892582606600257, -1.170683096753375, 0.6906771430072379, -0.5194820525929935, 0.5532760745253975, 0.354038178195802, -0.7537689827576323, 0.6600639174423879, 0.3724270506445151},
    {0.9731945292181403, 1.842770246450774, 0.7074380210835157, 1.1972605309966413, 1.8135508475385975, 0.5528653650839017, 1.138352631749641, 1.2703182301703049, 0.6685736650410464, 0.6708593358915333, -0.25266495787726245, 0.7201862675991273, 1.249064580119894, 0.6351028542942687, 1.5122660722327494, -0.4414033428156282, -0.4108612298541019, 0.6273136789066862, -2.4637748962435375, 1.2535971061310038, 1.4409505570245706, -0.9875267590921971, 0.771998701683534, 0.11147963013582096, -0.5352625273149386, 1.0839565072032267, 1.5933152659355547, -0.625967637817747, -0.22401442289008716, -0.4621285822085932, 1.7478139981187413, -0.5856983307146759, -1.8404019561805713, -0.6715934573284335, 1.2283015381749702, 0.4976853408350407, -0.15942828585072055, 1.4357028071882856, -0.4105125893032634, -0.22881540929079996, 1.8169734879786914, -1.0459707551304922, 0.1741989815460648, -0.06379576247858232, -1.2422808933403235, -0.6376755558230385, 1.2928425988628638, 0.17101377578254548, -1.9210005557337453, 0.13489610909869648, -0.7911808755326332, -0.07481008115811709, -1.8913634097192735, -0.08097512011030746, -0.6025411504943117, -1.726805199340261, 0.24089458821993298, -0.8206225200005274, -0.41753477218212076, -1.4604614620624956, 0.5977556416733552, -0.47673348963774204, 0.28866046019941805, -0.09201781695739748},
    {0.0070841004596389695, -0.7196422424652773, 1.8466032759821633, 0.5050681534355488, 2.0388585240301786, 0.2723249196456504, 0.14448722946099052, -0.4420240481026243, -0.28710256866417433, -0.33686385312078704, 2.942022522857814, 0.9723540345522249, -0.03986052245709067, -0.15535604792496244, -0.485510504177143, 1.521272347656434, -0.8432633625645991, -2.1759620248186593, -0.13356580250855218, -0.5170587827056553, -1.2596148878972935, 1.3452564094513797, -1.1169127569284387, -0.874787329720354, -0.6373559374694545, 2.126248405735892, 1.058841912567828, -0.6776042614645292, 0.8406967373250624, -0.13542864260453646, -0.10976146357068503, -1.0457495009006006, 0.8449053939633714, -0.6025434758631829, 1.8433456721862125, -0.40340685910957114, -0.5825099868620315, -1.8463670111671953, -0.601600836978513, 0.46287855969589103, -1.507776086775244, 0.6458859324410038, -0.727951813355099, 0.12157655851871707, -1.096430772025793, -0.2349829300262745, 1.5007268015097386, 0.670514358745444, 0.368507650778495, 0.029738765266716084, 1.2508625140856708, 0.9918683872954475, -0.2980509170583368, 1.7423735842864798, -0.8390987037311278, 0.5197319188892033, -0.0006845805356408824, 1.9630313834021922, -2.216653233251394, 0.15797167108450488, 0.9746371853317829, 0.8926152217475238, -0.014838760496919502, -0.210789036296791},
    {-1.2704563744758666, -0.1053793174572678, -0.6106065833482947, -1.1424118435559047, -1.8916212622055548, -0.6473285598962605, 1.1769119670311137, 0.05619428603173375, -0.9973348926628377, 2.180606291014389, -1.7264446471290815, 0.786440068250848, 0.10992740031141715, 0.29312008911546844, 0.3116078675616684, -0.06532951729849273, 1.443761450647102, -1.289119591291129, -0.20320627692540946, 0.22027543108178999, -2.1503328144537144, -2.986712243841417, -0.6041616537188869, -0.8268650261271665, -0.2179985796209598, 0.680823504014221, 1.8740645670299925, -0.8863245087823288, 0.3756573075513326, 0.9303609059660012, 1.8321391095136497, 1.124945386045636, 0.5237623253582881, 0.368149574754759, 1.0571725729728731, 1.3733216514474809, 0.9986289888556278, -1.3138543530612685, 0.18563606598738194, 0.7204902421527295, 0.40875467130948484, 0.051163261451925374, -0.0989194333826176, 2.183669593260669, 1.4941759599213649, -1.413337876393539, 1.8953029169791635, -1.229375582226359, -0.7283012366491901, -0.7264776057275664, 0.05168655351574929, 0.2560415352953936, 0.46904255043483656, -0.8528478180546637, -0.021762066974261512, 0.18046071506784472, 0.6848190637006555, -0.9295257910219177, -0.9668118087953945, 0.9032703664678339, -2.2906406436874165, 0.6729357593146342, -0.35800172273152164, 0.34229280024569975},
    {-0.641637730627508, 0.6362848510299055, -1.488580865054051, 0.6129737403371128, 0.11892998107092809, -0.02480221888343452, -0.1972864422409345, -0.30157639933651353, 0.019743724575754656, 0.5082024925639346, 1.2855288435818504, 0.2589609800923688, -2.123961566335928, 0.21301082047260195, -0.36492468065965733, 1.069132943700234, -1.2463313041626305, -1.5964417012485568, -1.7929058548421146, 1.3403228475810907, 0.1566270498625421, 0.8203585393275785, -1.328434583884139, 0.18016159133441476, 0.7242312500131762, 0.27779905073398087, 1.0428974356280005, -0.021521290458140302, 1.0740822698546508, -2.5450544653296494, 1.9384906777674706, 0.04555848492745894, -1.9826772532394297, -0.2905933104255888, 0.9049952487909376, 0.1402854575755501, -0.33410510369183477, 2.319836003879263, 0.7857967616778995, -1.2276251589264553, -1.271029848771474, 1.3946365545080983, 0.7586321273547417, -0.27635747928491555, 1.0787795418829975, 0.7513330160501548, 0.31204328676788684, -1.0888644049687197, 0.026506907633789326, -0.4708794487671321, 0.5428073402921243, 0.24832702922893007, -1.3748687442029, 0.6375219711895087, 0.3717249724498662, -0.22394846959807277, 2.276778788400598, -1.150529455955159, 1.6609136143762149, 0.6435254693517348, -0.20011414635203423, -0.1390009754182468, -1.2756326784480634, 1.7252956597497568},
    {-0.15618539613564558, -1.2042581058667938, -0.3555360788259044, 0.7227532210313707, -0.36649504206360095, -1.342962253351578, -1.3441795235159621, 1.0390342910117207, 0.06191821764953897, 1.1423539873074782, -0.8139003525650353, 0.9355285379905169, -0.5147083442518975, 1.178883710183924, 0.8327979413916906, 0.046385437909390516, -1.4719090695608728, 0.7508255069696769, 0.4313464251396154, 0.18237612703145878, -0.3574785402837712, -0.9257867903752384, 0.2316301634299865, 2.2422146422276694, 0.4441076190266382, -2.499117962354564, -1.1916112085292436, -0.31163954063414956, -1.710794905554695, -0.34512399969781526, 0.7990422007000101, 0.03699972441194306, -0.30323447436851514, -1.1820897482991093, 0.8866568417853863, 0.44415254053478836, 0.08299695461354412, 1.9114302731863346, 0.9681892067884575, 0.38554921831141264, 0.02482933626326137, -0.03014433373202956, -1.8972292671431243, -0.35684060736457984, 3.112189212055582, -1.8201828443369705, -0.5871469062531479, 0.06945151598185748, 0.3732748800413229, 0.09378331787074523, -1.6644636626452658, 1.640146551563621, -1.2985292349709223, 1.63280446891945, -1.4725431154026463, 1.015188512907842, -0.8620739308154326, -0.2920394165046549, -1.3831970224423926, -1.419655477482235, -1.828209306467118, 0.8462674761921882, -2.6163291291112647, 1.26761510035727},
    {-1.6132837481091071, 0.649498416028177, -1.099289607459601, -0.12692225478085148, -1.1975840114721188, 0.23697916066468927, -0.8130195877745742, -1.065805795479642, -0.49312926744635244, -0.7743956036166524, 1.1231881014304104, -0.466875162459232, 0.07752574050342396, -2.721654343969608, -0.5714390601414097, -0.042185941182539585, 0.810235032933716, -0.22602716233069306, 1.4869577751366745, -0.5825755270208168, 1.413526496836261, -1.579601412925621, 0.6790084338187299, 0.29819087376924586, -0.6066056701742718, -1.4008427469764049, 1.3312682260699193, 0.6230079974001667, 0.34659304261887564, 0.39924506069517646, -0.6595335861931201, -0.5704627953247566, 1.820045317905163, -0.2204471583013898, 2.8269125618693427, -0.3638538907229293, -1.4864466344498934, 1.376050982481297, -0.35507562009423216, 1.267699949009278, 0.21506110245533291, 1.0935399701476687, -1.5922095743537004, -0.47510370346554487, -0.5320792869513146, -0.22997730750321627, -1.434876624776282, -1.1954476438890413, -0.29893029448059805, -0.05749610281032222, 3.239995422720646, 1.1178593681959597, -1.1275857705730443, -1.0213678160202249, 0.5341558883134938, 0.23656179134474978, -1.1800379656651454, 1.4122343276088376, 1.2077392441281933, -1.2653629999094986, 1.2096982047168534, 1.4465545022237185, 1.2662458360902926, -0.7111804448667871},
    {0.5517182410194219, 1.3099272659146541, -1.1071809130185166, -1.066808475448229, 0.4815443613754388, 1.5998253131700901, -0.32323724898948575, -0.8744739025527128, -1.7819007137071097, 0.7086493460774026, 0.5416932433266874, 1.116467567733161, -0.13592041919582085, -0.07854875222248228, 0.7966809880559934, -0.41839182628971905, 1.9159405829862872, 2.7821361491756713, 1.3388558279396134, 0.8025575321464963, -1.5289602647954856, -1.3717521286597754, 0.824067651353768, -1.3080085111596342, -1.609561359888582, 0.258467432337814, -0.6846067305420153, -1.4330232648335663, 0.9175221485057768, -0.3172472133094615, -0.3725998430195688, 0.10092592656350448, -0.09582252279928997, -3.592695323825375, -0.3564343196968981, -0.720221730002574, -0.768558584153234, -0.21032810193197005, 1.6877535000322126, 1.4224202537069284, 0.6757250640044195, -1.5695774813431183, -0.018921149210521217, -0.011039003722873279, 1.2522508164078618, 0.11528377102803417, 0.5863816287795213, 1.8617646179814138, 2.064954293640232, -1.7246971787100043, 0.4964298473403733, 0.10566240826373259, 0.6047813788447598, 2.470384002590284, -1.3581798574348636, -0.739394609508083, -1.3150979951117086, 0.9186595376893033, -0.2143997849447384, 1.0317135036184673, -0.29870516009955345, 1.4983996806324982, 0.05134852463125474, 0.25822755588047397},
    {2.2997904992978357, -0.2241487746714754, 0.9754596048123169, 0.20411942989005263, 1.0405356857081394, -0.8325218535966709, -1.4001634693271314, -2.214568755597026, -0.9874348286430834, -0.33695780300452166, 0.541422823476103, -1.2834573787965817, 1.316087144356417, -0.7447533007740644, -2.692126991889085, 0.5840335665678642, 1.8346773202606155, -1.0206416551864272, -0.6664516822111585, 0.21172537749119164, 0.1882016425637757, 1.3281078187040816, -0.9388664477323875, 0.6729356738439584, 0.25281450308433273, 0.32356189307865346, -0.6988318483991366, 1.1896938111494315, -1.4050428298375297, -0.06801130088646956, 0.019801771194630977, 0.9833334120207163, 0.47001955323706607, 1.8453397843494377, 0.0728237233084702, 0.4685235492572902, 1.4856506716719098, -1.2437380071795716, 0.12745106767809142, -2.182208760551839, 0.01570461890760278, 0.5224642860615248, -1.3293250241604149, -0.08886043289390697, 0.15017184858598343, 0.6037984398205865, -0.18445386887727003, -0.6103689196257098, 0.6351179021890506, 0.9310446455272565, 1.9008540074311822, -0.05643459006998968, -0.9831534484695135, -2.727817162582305, -0.6197630758708843, 0.44253198208760847, -0.2127940776447371, 0.16736297016702237, 0.8708445196631964, -1.8551551143135656, 1.06826439453084, -1.1842310229293163, 1.75193185739316, -0.6951126265030912},
    {-1.8363207593815505, -1.247757469560529, -0.5744984342477728, 0.48563401512136073, -0.3923713159658068, 0.6898851355144402, -0.4558456498260709, -0.5318885351457392, 0.3263860754687148, 1.352047318737404, -1.137493525487611, 0.09060481225851123, -0.2982620318173547, 0.8503661924851966, -0.4496705637587886, 1.996568679711325, 1.82742724353814, 0.9139185919075995, 1.5508032363265492, -1.026788292914671, 0.6578476002217727, -2.019174301098928, 0.7005859181188807, 2.4636611424110044, 0.2097110079820311, 0.4807315328981017, -1.654779960194391, 2.2985206748125373, -1.9452002813307225, 1.107090264704882, -1.0795295328815369, 0.05988377094948696, 0.8609750507933639, 0.24856771675322045, -0.1562363999578695, -0.9206371747148752, 1.6765633662708144, -1.5854651280174545, 0.48659859785619214, 1.234827040916964, -0.3932057900274398, 0.14511561423567645, 2.9144787460210586, -2.0007864938867317, 1.4081806743689234, -1.3754978126545934, 0.05267256791752952, 0.24557386287567096, -0.050772291692016865, -1.319320875385883, 0.7734231569937539, -1.709297899088085, 0.37370685114320024, 0.6008106273700108, -0.832428311619731, -0.26601484004760223, -0.024826876203456257, -2.6629033946314142, -0.6140122408434542, -1.8533066474723503, -0.20332152442116327, -1.4577405808615125, 2.2807912377419024, -0.21219744621484413},
    {0.7806448201460673, -1.8750891227922502, -0.4741659061569137, -0.8883522076247121, 0.3481226517575685, -0.33618561150205595, -0.46259215875216286, 0.3558234235890702, -0.14415372862486273, -1.9383780759385871, 0.09307622101644193, 0.529581027792942, 0.2562120484080668, 0.700517221479503, -0.6579960787074004, 0.5993742639434404, -0.4131522990687685, -2.435698088382705, 0.6011650561789776, -0.7942915756376693, 0.612762765060699, -2.1522545466838023, -0.298193414429539, 0.14667299089737876, -0.7636391016892909, 0.7799111694004741, -2.5968628204678597, -2.6333469311725395, -1.1602012884604098, 0.35615976530306814, -0.10938984110493861, -0.31954082041680393, 0.13628009724417373, 0.36248279143231305, 0.5166465638672743, 0.628496922284734, 1.0532046693250203, -0.6288750173050459, 1.8117466116477952, -0.5414908230891348, 2.1520565992504874, 0.546233207942878, -1.4912331350473547, -0.03570214636278426, -0.7592224023682427, -1.0215583540196278, 1.1142709701340459, 0.24324431785463488, 0.520084501299445, 0.2213503137616695, -0.9365311530384434, 1.3611814620069007, -1.220729579065514, -0.7458200269938634, -0.144556717050086, 0.20158626248597633, -0.44155082022782804, -0.17485059036970999, -1.2287310023150104, 0.7179560585957843, 0.5453686278214278, 1.259270976371662, 0.16643556882092436, -0.27292168479950263},
    {0.7295445635605062, 0.2480121212659501, 1.2170029987551552, -0.7821549192268019, 0.38762043844848887, -0.11624130766108187, -0.08114994981489207, 1.3659548360783254, 0.030847462557280245, 2.217109550979735, -1.7219936088423393, 1.3500255420612899, 3.069209426948892, -0.2222826522623874, -0.4689106704307061, 0.4489546019188471, -0.15798442201802074, -0.30700084206238537, 0.09101995786333926, -1.568472680213186, 1.1495096275891876, -0.03960216597316696, -0.1309485382594467, -0.7909227172215165, -2.488811149048228, -0.3026744615316351, 1.4761911623606032, 0.9461362813541637, 0.7047955927975185, 0.8653744622730795, -3.0485373952675636, 0.5742697113380577, 2.557395864634066, 0.3344788835497884, -2.1454780881662545, 0.3111882170819101, -0.33128996449720444, -0.7629953961924866, -0.15959950384405397, -1.0157648686383631, -1.617965629568201, 0.01673506214504609, 0.6934873377075969, 0.702143174566519, -0.11214875520767763, -0.7687694619703325, 2.458713114632459, 0.3970015627081454, -1.4294592179417152, -0.4144814494617032, -1.9337840877151062, 1.6091650572565557, 1.606652445833469, 1.1743059426292508, -1.725403931449939, 0.11618850430845176, -1.6810770973273406, 0.4122892422287614, -0.932254112413685, 0.5591180060370573, -0.8022008855128121, -0.5933034162045968, -1.398158936144257, -0.34319806858404},
    {-3.976702297565455, -1.156564284864971, -0.702955712050655, -1.2132105388139856, -0.7247099920765566, 0.10052584253077596, 1.393672107376031, 0.9880965968730773, 0.03109160170045077, 0.30361763293289434, 1.541048623162634, 0.7420548937012847, 1.1013784079387883, -0.5143985605609098, -0.39394774538917804, 0.6802481164345787, 2.205256350276802, -0.025439179373956424, -0.08308639542829802, -0.2635315442075959, -2.3474064727699355, 0.03716900175319529, -1.7292227458661296, 1.087960136898236, 0.4445310791855214, -0.4241963119574748, -0.6520527294813638, 0.18727156480033466, -0.8481856331361339, 0.5146106402194381, 1.1887952981732361, 1.3518784697950383, 0.36595885204318257, -1.5871233761200958, -0.105469704006479, -0.05965122403688131, 0.7158436617319323, 0.783838892984975, -0.14123812659439802, -0.5098925945723555, 0.8965389469727754, 0.7779292942206909, -1.4220465204250956, 2.12688903149525, -0.741444989054015, 0.16375041866784304, -0.39587696455892235, 0.5848090127143408, 0.4383130346073853, 1.3162368313775523, 2.0551146798578634, 1.0229732081794756, 0.6579016568128335, -0.47013990481272233, -0.23282878436762314, 1.4112954278566163, 1.6966442470473713, 1.068169081747182, 0.5931640510283542, -0.4559330504540414, -0.7201932634632037, -1.5730209623994782, -2.023448692943667, 1.2833717241791094},
    {1.358713571288186, -1.7386795994441753, -0.571093814762209, 0.20429282385612121, 0.29990695483682833, -1.769237015403172, -0.8386332380281524, -1.3200631957194517, -1.558115501177397, 0.13684345030891681, 0.13548037431313542, 0.3138408378192895, 1.2511373212272414, -0.6172006724898949, -1.3284313668834002, -0.6410405492686804, 0.9084840765528664, 0.3873593257571871, 0.038194116297132964, 0.5958238347852555, 2.3148935119121625, 0.3906824142299498, 0.2279196010272196, 1.5195718958055375, 0.45251229977339286, 0.6059988161378167, 0.29659559661590873, -0.8226645576331524, -0.3511007907801728, -1.4984137018815804, 0.38641153388046806, 0.9709535951084475, 1.0069300347391485, -0.10436648593680559, 1.4013055579058462, -0.43502805003907324, 1.0586054238163725, 0.8585180726028104, -1.0742521498646442, -0.14310980786323485, 0.6689779727677718, -1.8016109904472462, 0.7415196146139413, 0.9984742168506621, -1.4565336100754516, 0.24996818461596268, -0.13556881995801384, 2.198395545867978, -1.2471893332077513, -0.8981892160382428, -2.264643399603506, -0.6711281974687466, -1.9708945414641517, -0.04570359370405515, -0.13386440163723343, -0.6709548878696763, -0.9734959708252116, -1.8461360125771338, 2.578099611804231, -1.0164624876944004, -0.8458676462479423, -2.247225980626149, 0.5038677755051649, 0.989717344613942},
    {0.5073237176038001, 2.0614962817281284, 0.5807613207619579, 1.0600833267092258, 0.38066666263187765, -1.0423852306042118, -1.15660284234136, 0.9848643110538339, 1.7330282351066233, -0.009102689332804899, -0.6725054083516356, 0.0052044267611315925, -0.007312709411825638, -0.7366897572528587, 0.040187867818297356, 0.7540904716012716, -0.8862286533523213, 0.40553334278570186, -1.4341721844992243, 1.2369791859557215, 0.9179280289463031, 1.3398222854850965, 0.847997038123483, -1.5365696158903694, 0.5450671524359463, -0.9709903661696048, -2.521086647104513, 0.4481095963006054, -1.219491743899066, -1.8706317181774665, 0.0013353028050461097, -1.1312102344763661, 1.0401249709948581, 0.9396545974182823, 1.4886750038489287, 0.7359476499669405, 0.19070608907259523, -0.643929113194566, -1.5235481066489198, 0.9054850103709168, -0.20585903731020908, 0.09911326608109948, 1.7049802796354545, 0.2992494225664314, -0.7800466257219811, -0.255357872973404, 0.6179122567490827, 0.16274004992781457, -0.5218487012308896, -0.03671844333454671, -0.18884496986999336, -0.45648003596024755, -1.3616039994977478, -1.4502384757335363, 0.48697402880601026, 0.13737729271877297, -2.505026074282763, 0.507480740513151, 1.6880838237950753, 0.1494866671966368, 0.4143275788108648, 1.2844388372875142, 0.6603086126136583, -1.0627754978237927},
    {-1.7005026434759989, -0.06191051125697527, 0.48153750863060746, 1.6459782841466124, -0.9975261544372397, 0.3768058880406977, 0.014416805484292687, 0.6746549917639588, 1.0800640123340968, 0.9075441028514647, 0.9853079554499667, 1.4021844259915521, -3.7261917298010787, -0.433410894488724, -0.17802410156374085, 0.779402713626507, 1.0891784010755923, -1.7326289933860026, -0.29558184671353455, 0.9785271675798491, 0.8008932655545725, 0.6835287125802251, -1.9074374525305917, -1.0109393266717293, -0.18133975694329071, -0.08397612608643737, -0.9150171315601031, 0.7284625240174112, -1.8316301001664475, -0.979624143309222, -0.4769431228699058, 0.048972480801263665, 1.1755830002057188, -0.5337060934914194, 1.7581308014210146, -0.45271066328707915, -0.07487206319214655, 0.023063269566382386, -1.0324050279930692, -0.8287265451646451, -0.5871069186794613, 0.6072823985944925, 0.6562692082486216, -0.710595658000304, 0.5326820997671389, -0.09880919092678267, 1.1980235841755997, -0.324105986269353, -3.255406720042838, -1.795957496683772, -0.802315609782678, 0.5288839153860028, -0.7257327968992909, -0.6271322612427846, 0.5558216193852935, 0.5076372012590209, -0.3597100761950118, 0.9353714723743959, -0.5436961941770354, 0.8495015316327678, -0.22690409719140267, 0.42015939776829636, -0.37591637862438365, -0.8775766162174796},
    {0.984637556125725, -1.9968952739010304, 2.326457548877351, -0.4923795536470255, 1.1745841200586513, -1.23505340237441, 1.4539789763577031, 0.5080568940919, -1.6400930737327684, 0.47024127385751785, 0.15297100077286738, 0.18309186333460808, 0.5168944958099638, -2.1786072992103436, -0.5810946250594993, -1.2108231121269772, 0.529834380869456, 0.9105591532277173, 1.063142538360697, 0.7578215380034706, -1.7245409996957641, -0.0801300518119217, -0.9885589430454963, -0.6566661784268608, -0.3213165444515736, 1.8473484900184922, -0.046582138219765236, 1.2066383771519384, 0.16068606533642074, -0.8076292380932357, 1.0424284046037666, -0.7749919077064239, -0.3667146182538535, 0.3754329238757859, -0.9875899678410388, -1.3214282133228668, 0.10897917892059594, -1.4254079028898985, -1.2545579961120061, 0.001772344037623262, -1.0985141738880089, 2.4326235399259577, 0.7753213942998545, 0.5653121349400076, -1.5913866758580835, -0.4615898022493627, 0.3775432023899356, 2.118397583286206, 0.08998616253345523, -1.2129820568593808, -1.6228233606327187, 0.011400121813953144, -0.4728774513906339, 0.23249310239790308, 1.0092295818104589, -1.2840738747287377, -0.10155431128072882, -0.38511927623964093, -0.5808878998530885, 0.4232641006934669, 0.13254213156828207, 0.17993273588459804, -0.4182530717556396, -1.5356100833653883},
    {1.0068730568461242, -1.173817869748194, -1.0798568812962852, 0.43772888655510994, 2.8341574877185693, -0.32484049444173363, 0.2546056278600688, 0.25239584721096164, -1.9205286645748125, -0.12223348410002008, 1.0881728922113467, 0.5612340138153187, 0.48716369086885397, -0.1647626103436036, 1.9863438049908446, -1.0426396073132604, 1.455877753257765, -0.32580401727708264, -1.7614669682741044, 0.25846918851908995, -0.9140538487092859, -1.0202552598061125, 1.3229713381779542, 0.2848790236586432, -0.7931383168322516, -1.251279439638694, 0.5651611577278617, 0.9606353898270386, -0.8704776207892395, -2.457097307580103, 0.8086125835313517, 1.9985364884149335, -0.2571043601802135, 0.7904157760316421, -0.7516971769636079, 0.4924403252508757, -0.5966672076356923, 0.025875084838751235, 2.904067128501058, -0.9790080484784626, 0.21361076158355996, 0.9305319595967112, -0.9833096629877799, -1.3831889795420145, 0.6494357270253567, 0.4211045121550817, -0.19392888646010562, 0.3984201937389738, -1.0348771146221705, 1.4292274511960432, 0.13354540856349714, -0.8556815437301245, -1.4433571641543466, -1.547683985862962, -0.6616717816526769, -0.5352582370883154, 0.41755893354599893, 0.9186824252682583, -0.3245378479289652, 0.5035611487194702, 0.09894897897575815, -2.084414644616285, -0.31321835818225807, 1.1928284597596823},
    {-0.6145262553275623, 0.3330837498187039, -0.15653077031336862, -0.24028334145394695, 0.07125321463313948, 1.4587615449717342, -0.5378361423525515, -0.5722208256063375, 1.1814510014383919, -0.3604515427243687, -1.5859177055288052, 1.0541241445363305, 0.5879550975541284, -1.0188690962586968, -0.9602884974145314, 0.3472192170462339, -0.734831619220813, 0.9794219648161557, 0.6521317158950221, 0.7880030152244687, -0.018649563116139214, -1.893328327086779, 0.12758820583290173, -1.410652156486472, -1.021562841030999, -1.3336080236473378, 1.3989951616055565, 0.8029975231297326, -0.06776156288810847, -1.2834851443396706, 1.5359691722098232, 0.6472129262889694, -2.1144578533836076, 0.6689127931672249, 0.37913666356494546, -2.8913447886061157, 1.4470886406473178, 0.060040259423422844, -2.11381625439821, 1.2131469887667772, -0.3437394634715847, 0.4033091770619978, -0.24357162367336094, 0.24371231939730303, 1.6469307214028341, 0.8975605815451206, -1.4539226031549934, -0.6214758716234023, 0.0852656560891451, -0.4171759232022341, -1.872157861510498, 0.8832218123804306, -0.18089832317464227, -0.4751023253721324, -0.876655393686868, -1.1243594408470348, 0.7606595129860877, 0.2674357345667901, 1.0058021787363731, -0.05811858549145297, 0.6137713785228023, -0.7147728759799065, -2.0938602515463813, 0.6187898617562466},
    {-0.5224945558350073, -2.411176358740959, -1.037163293661999, -0.5718468286683995, -0.4190546287952493, -0.9440378359275073, 0.9344091964175878, 0.09473422035569447, -0.3660543857777549, -0.48575192963678826, -0.20304142211109286, 0.1466645963212925, 0.5305878900553291, 1.1691704056192844, 0.7235113759146276, 0.5438501197552775, -1.928822192547417, -1.1354321117207387, 0.5479468090886311, 1.6353160282255605, -0.17899205924785444, 0.5562966612092984, -0.07227565791664758, 0.3810374683209513, 0.33023581979967864, -0.8952829978274545, 0.19613479331400432, -2.363762385961439, -1.1351690219869945, -0.5384262754450373, -0.4513655145932962, 0.45523948192764196, 1.9127331734087187, -0.47338729783851047, -0.5333044360860871, -1.451053799236391, -0.17540612675477613, -1.6081181099408572, 2.1003564615924115, 0.3652679629909957, -0.9178596443504047, 2.27207655892798, -1.229606051552747, -0.7337149762055463, -0.5118316537289604, 1.1369418272993024, -0.6002061016266664, 0.6198676829700253, 0.09605959846129578, -2.604525132040386, 0.12172030875495939, 0.6936226226037701, 1.6806691417046555, 0.9009823497246956, -0.11209633886615904, 0.31626148477116506, 0.5477766102340199, -0.19132766600967027, -1.2400233125981135, -1.3321240504584144, -1.1928615386287424, 0.9011909833593671, 0.6706206445338807, -0.05976826409912669},
    {0.8981397066938493, 0.20928725192225184, -0.24988754117819725, 0.46111418947503463, 0.4745699826312966, 0.0368038976851618, -0.16837394299471153, -0.22319389450662086, -0.9337856272653903, 2.0592278994260296, 0.5096190939245344, -0.6639656016724156, 0.5728523272974451, 0.9981862047718992, -0.6433155567048361, 1.2858405427488158, 1.4932929038817992, 0.7016335039485836, -0.3420887565063319, 2.1960347914948883, 0.3237977380697084, 1.7821764168677319, -1.1776909539551104, 1.3272446041332213, -1.4199495452256077, -1.338158656349428, -1.2069145721366472, -0.567608358813629, 0.8679526873323877, -0.14259423784629843, -0.7935377363228264, 0.8645579619320728, 1.2683235424205714, 0.8276362755277873, 0.10256364186558534, 0.5636700765213063, 1.127983538039951, 1.7019209986635644, 1.6198305508035602, -0.9505020733575438, 1.0536699139296353, 0.43742711807970347, 0.23994503131862838, -0.4603758516660663, -0.04042044041189524, -0.5706486598515756, -0.45283073529302603, -0.28450682559318563, 0.10086561286844406, 0.5651513114980313, 0.7225443608028896, 2.5466283965409318, -0.7536497164660545, -1.1000457763377933, -1.0300447114285853, -0.8379427340709046, 0.4321660299588273, -2.6715439153812337, -0.08990803114098551, 0.38401375210599936, -1.4596730865306715, 2.2753478517030405, 0.9964885693327182, 0.3890826387405935},
    {1.156022412693454, 0.23281708746405325, -0.6552266294076009, -0.32963983689778775, 0.6213483319944234, 1.7268010261971154, 0.6618249567196439, 0.8030523872976643, -1.8866387409623566, -0.7090299308312957, -1.5091706472057869, -0.7106878518957066, -0.19406585929658474, 1.197973366563777, -0.35500251981515785, -0.8194129573313462, -1.2760913187528198, 0.9453691120761362, 1.1778582086374474, -0.7258444093895031, -0.4988209537754132, -0.27012719803475127, 0.8628561692216806, 0.4594144129035433, -0.7304523778411153, 0.028980647733292675, -2.4487805434405296, -0.21185972976777345, -1.846516198018976, -0.7053858665303383, -1.080756758381337, 0.7387004275035219, -1.0857870982128925, 1.1620425823917635, 1.3963674216231732, -2.1859092711477572, -0.11339422980806872, -0.2501339671757435, -0.033678166826952884, 1.2633573945757735, 2.4200927750824643, -0.5369877115505852, 2.069672120791174, 1.387798030584567, -1.9927069376498001, -1.8002612063485357, 0.0783773897016415, -1.7195480666372644, 0.3181592096589428, -1.83493569781444, 0.5646960545889992, -0.20199555183352622, 2.5075673903673534, 0.2754482614143165, -0.5367856715700254, -0.6350434420524412, -0.15954294704931968, -0.13146706721787985, 0.7345317206032871, 1.2376320073474694, -0.06908132414363025, -0.5358858197931401, -1.4161429007705735, 2.143196923365893},
    {-0.5232864267441795, -0.09454707308372502, -1.2709391870310907, -0.6157441441079169, -0.23429356346931687, -0.4886976363235588, 0.39305523499786904, -1.2188446050389312, 1.7848045416763918, -0.1135013335432391, -0.2876134235429436, -0.09642579386442707, 2.6090160973608807, 0.9674246730300702, 1.0202525080280747, 1.0455560377212758, -0.8904366536174576, 0.6999146687578084, -0.4865995729346856, 0.48391761718656034, 1.4757041843333552, 0.9406792370534721, 1.0046712901826347, 0.2003451768254754, 1.6183391208962388, -0.49537736080428224, 1.2063788688945032, -1.825176351148352, 1.1307324773005467, 2.0442120401661703, 0.6927153495660707, 0.9693055372890234, -1.0528225879678281, -2.0541730117430217, -2.423512883943676, -0.4245134058833426, 0.13292030442563363, -0.3550233557930305, -0.9148562600496019, -0.0946847774441059, 1.055825325052789, -0.311246835371107, -1.2844459195733375, -0.24003638595699062, 0.9435979236052682, 0.22382461168238096, 0.6429709060116336, -0.609797766111905, 0.5266828416783884, 1.3972510090214487, -0.40631614256375315, -0.9137213986966771, -1.2715352797608688, -0.5842377412698964, 0.4984353932583768, -0.16794740096417862, -0.7952843236912587, 1.3972899858021681, 0.48671497472402697, 0.9597380835077042, 1.4237953746712708, -1.8627660293885036, 0.6973964823347529, -0.10149693577985254},
    {-0.5317850173026789, -1.4144058615610107, -1.5259786213814435, 0.29609226052132426, -0.8082240453595742, 3.708774906600728, 1.239335121224735, 0.8193282378093638, 2.461537169069607, 1.6045574439102557, 0.5257493799846142, -0.6641605266707632, 1.090828503667619, 0.34200203244188737, 2.972351381428597, -0.3005152410707645, -3.7854977397382195, 1.1518635017286798, -0.3854463110336398, 1.6167494270789444, -1.3164330967131086, 0.39501259451121185, 0.005101507315907687, 0.9573373256407794, -1.8296971731853702, -0.3152893477595296, -1.3187588309332978, -0.15151643803108308, -2.323536659999884, 0.023125101909224573, -0.2671049764164679, 0.9634288006447906, 0.9493653959168336, -0.25065209374981134, 0.563056414514517, -0.19834549053043682, 2.1670556285083404, 0.700068294600137, -1.7163385799093098, 1.0893318370743303, 0.37354062323253, 0.185868674498597, 0.31660915826987507, -0.9444231016217642, 0.8746788774910237, 0.39655665094770387, 0.5485172871877835, -0.44399040764074915, -2.3912707885733684, -0.4225982825985088, -0.7306050624902426, -0.7569614683311179, 0.0912930493508439, 0.1116966796367976, -2.5329995359234085, 0.5907752440489132, 0.3817717563649122, -0.2819270771870105, 0.7917602117479545, -0.7801541977586309, 0.41275725381400086, 0.5989645314886628, -2.6177205751596926, 1.2626973732678213},
    {-2.6879501790557097, -2.098018371483734, -0.07302163303807756, -1.2507369062987543, -0.2302754897760896, 1.3287435838508552, 0.45285917799985714, 0.666612094192165, 0.7299376701888218, 1.2973489403020988, 0.14909854230196173, -1.2990945643623275, -0.15562074827685146, 1.1556222227345387, -0.20351263544107123, 1.3999520008515323, -0.7609871205011346, 0.7807795587383005, -1.8358328862307283, -0.23304306174461975, -0.10952410859407567, 0.43256308544985167, 1.5401112752923511, 1.2943018485181739, -1.138344235762318, 1.1465657183938183, -1.0637842070907932, 0.2512343639807762, 0.4358744161890483, -0.6013826529512658, -0.12804798679732535, -3.5071668802490015, -0.22586778997302218, -0.8295655641978104, 0.5245672432448887, -2.1107604134388906, -0.5902810610060122, 0.1264991407652491, -1.8011475800763759, -0.18202768877412231, -1.1604191439144482, -1.0695649400677356, -0.11628225275216963, -0.40555434154457654, 2.212733802674397, 0.9791610834707464, 0.5073967423115583, 1.445118392330389, 1.6353300882904314, 0.5298673844190511, -1.0627182937536925, 0.4272831035853655, -0.2697383586080169, -0.07529438606504876, 1.460944171962591, -1.6006498451019264, 1.587693105243656, 1.700829383576859, -0.9329886287759418, 0.4965991776686413, 1.4370073483713521, 1.5427829017069572, -0.3513674863052918, 0.5373475214005248},
    {-0.5659769629554978, 0.7404520345714248, 0.3359430124214049, -1.3216238157416442, 1.022690902076096, 0.05588777037041012, 1.5259616338758655, -0.799694717013917, -1.6409594392837121, 0.3810958046975745, -1.1154405002816212, 0.04830960116751016, 1.0238509506738174, -0.030713025989517258, 1.7861591773616337, -0.5273713227356739, 0.590648410488388, 0.6962665178569128, -0.09838808435771462, 0.7120182133008389, 0.8634924193701633, -0.494339800736239, 0.19253147047580482, 2.1858147163857127, -0.5848330429598171, 0.2118403780109711, -0.9250772392817325, -0.5844208715114972, -0.08430436798511295, 0.5863481951499326, 1.7055407642979032, -1.3639530582723023, 2.674297758228117, 0.43743991591139414, -0.9861552937933546, 2.010799124752805, -0.6472885179195831, -0.8325426996771866, 0.6585425222977537, 1.7043773131726943, -1.231334869769602, 0.17309850019078016, 0.3033889653440673, 0.8046654711917582, 0.18958976260864369, 0.4254112272426302, 0.1960178400374587, -0.3993556467318132, -0.9324746252424719, 0.7325680142486902, -0.39725501942523556, -2.5357343211147403, -0.385379070125128, 0.9055166330242597, 1.2360709410367918, -1.2661098999344593, -0.24349250266067549, 0.7540702656138485, 0.6083707003305607, 1.9902485146947135, -1.7839773964522012, 2.1123328530344425, 0.16431232197880116, -0.7000345410472972},
    {0.9601496791215406, 0.06184864678869322, 1.6955456191307736, -0.25327974069904724, -1.3024926593553816, -0.007676639222345652, 1.1875467544411984, -0.7222909120289213, 0.34457622566398755, -1.5300122158522196, 0.12745853835231793, 1.417097387705155, -1.2686467517953048, 0.6753625546351799, 0.3976108875036807, -0.11949179459284866, 0.19167604796727855, -0.26129641000723053, -1.09825218347125, 1.5959979197961027, -1.2310027881674435, -0.29597272167513344, -1.4467451919112606, 2.5417974031975805, -1.123948502902756, 2.224168651923069, -0.8308066547331635, 2.0749266140044664, 2.149507694468702, 2.2231181858587536, -0.1847156105586126, -0.3711251874349883, 2.6490052299106077, 0.8359653355428917, -0.9283975381741753, 0.5939450586240238, 0.08449657954727287, -1.0834387808854418, -1.6701988503473397, -0.7667555721744544, 1.4841826006849368, 0.702462219017319, 0.1846834513273763, -0.6869406374711808, 1.5509707263870718, -2.992740762910154, -0.8372762998161773, -1.8331645229254105, 0.7090920193737591, 0.46646314848077, 0.7680582838464701, 0.09260770147759809, -1.0551302934027715, -2.0427590707650385, -0.017429727881761163, -0.020220973486628616, 0.7249407368684725, -0.5559209910934322, 1.892827193648594, -1.0670663284275053, 0.2596634358867125, 0.6907161953430415, -0.9397058100106426, -2.663483329521918}
};

static const float b1[64] = {1.4045438715803054, 1.525698053171607, 1.7571246480809348, 1.5840100114896916, 1.437775509949009, 1.8151622226748962, 0.14335102446499126, 1.5404727129955695, 2.0057783997966987, 0.372866218072084, 1.798904216866848, 1.7341459830739048, 1.979902416805613, 1.5988674020958473, 2.0419535762711463, 1.8831713722161185, 1.7310590999085336, 1.5228170899319833, 1.642703753753085, 1.1384792750329382, 1.4603856361512533, 0.8780781352310059, 1.8804887511736434, 1.7229306239933606, 1.551097370657494, 1.7560941316712873, 1.857736786918372, 1.922401243656286, 2.079040523972474, 1.120864202317339, 1.3636938738328925, 1.8486664372372899, 2.02589089482559, 1.650712443332576, 1.918612937526909, 1.5437284216771168, 1.4284958308081697, 1.6408949677481683, 1.6643618300346816, 1.7537787798398945, 1.7639351904732747, 2.009244942417095, 2.019479569859347, 1.4752752997974237, 1.5939631842632043, 1.8423993718087746, 1.4836159126946824, 1.50438176486931, 2.064673735913015, 1.899997425375739, 1.6970760460159697, 0.9626446713797734, 1.8331173339186697, 2.110911227219787, 1.6700326495927167, 1.972755591932571, 0.9635749679290285, 1.3001943677341592, 1.9801391670026356, 1.604556014963976, 1.613267591953768, 2.025887882465625, 1.768728161593987, 1.5350176829323683};

static const float w2[64][32] = {
    {-1.091602158885574, 1.1790360003171656, 0.7237656211133219, -0.6459730830116632, 0.7469009157701532, -0.19637524744407583, -0.7509937572496378, -0.37489789705442966, 0.3910842575367373, 0.04657725364618912, -1.5033761856097088, 1.4885194910720287, -0.34588554837674484, 0.24855997410523684, 2.289952562630144, 0.3465429083293518, 0.8046089756449525, 1.3725613017551972, -0.05397087467946984, 1.137776657410044, 1.9425607002301233, 1.1884012759472629, 0.2552453606853553, 2.7012547433539766, -0.7770898324267353, 0.16783520614139985, 2.304225283254002, 1.314688977310644, 0.04599816667228317, 0.4609668667118347, 1.8148126121849557, -0.081123009403954},
    {1.1782085859290141, 2.521415734786507, 0.1680781983869837, 0.39021103225328335, 1.296230111889791, 2.3276270403876196, 2.583235641164472, -1.32744067118115, -1.0942712462240922, 1.0428817696094637, -0.4030133502276562, 0.9014430656447906, 0.9788333669252252, 1.9132927119865095, 2.8414240521867136, -0.7201891412437874, 0.8820246493069027, 1.2827724988454539, 0.536935864076865, 1.5874789822479585, 1.1055517149813987, 0.2536551443915814, 2.85586686031671, 0.9174812109527054, 1.8904168403137673, -0.273258174190786, 1.8388481629524116, 0.551494424964407, -0.28448575754669486, -1.7342016428432696, 1.533668284402968, 1.56319593820067},
    {-0.4750399916891609, 1.41058596225172, 0.6224481278189579, 0.05589304841704956, 3.189693961514089, 0.6394251007933883, 0.931931844091477, 0.4691517211343808, 1.6646154713180654, 0.09798555968267042, 0.5973548942691764, 3.2040399051318746, 1.1721244276436902, 1.2943354905050124, -0.38234550502647185, 0.5941220923673272, 0.671281787073678, 2.741925748275907, 0.21828572104291585, -0.8345462185507473, -0.7876516151950115, -0.23668803279962608, 2.771063479393113, 1.1134416993169427, 2.1273453614563946, 0.5518401067647754, 2.4059562087888953, 0.9147140923542829, 0.4104892005090182, -0.1487205776057626, 0.797117691787311, 1.6420425855588974},
    {1.4996322619064564, 2.0176661262770037, -0.7039566904611325, -0.26206623517737243, 1.3082694711514549, 1.3995617972037322, 1.7635486301115058, 0.5150437509091486, 0.6649608594543575, -1.7499659173478543, -0.4302318342137675, 0.7786860354820033, 1.717135298914272, 1.3129752888916888, 0.2787451417007034, 0.6569455499336859, 0.1141424809709493, 0.09780755613652223, 1.674894715474508, 1.9775432835159938, 0.982170355014392, 1.6096722841473152, -0.26618829837006414, 2.1363023729740043, 1.2947855049625456, 1.2531620223265252, 1.889130732610967, -0.21712480154960054, 0.5242110630904028, -0.455429218346035, -0.28550623791300855, 1.6285113683431045},
    {-2.206809110277547, 1.0687315570435316, 0.19549101259247942, -1.8234444143056798, 0.36520467432999065, -0.5875416394474325, 2.2509931693688277, -0.7862749258273676, 1.7823253250199234, -1.7794197665248501, 2.038815339493212, 1.5752850824796092, -0.0032046217637661223, 2.0586555449836683, 0.7776403089933508, 1.744501874600023, 0.7958638210578544, -0.04520779341703008, 0.8854796288974155, -0.46628965976814263, -0.23558256342435138, 1.22951017912379, -0.2876687173230793, 1.846015897174026, 0.560174204791787, -0.29533146317341263, 1.5673362484592113, 2.1139330111617474, 1.9087266143135118, -0.2980086782189438, 1.3581658416933617, 0.5967762160243766},
    {-0.015974916032673796, 1.4566598695343889, 1.319588389488106, 0.8241354937334595, 2.224611373441184, 0.43821082144082063, 0.3340264331393313, -0.9193119436469263, 1.5672301541816172, -0.27925697991331355, -0.3828926486716754, 0.8966184733495208, 0.6198399936622179, 0.48991730854406956, -0.47443781622387793, 1.2001273892434559, -0.5648419931871825, -0.049122275985340746, -0.2502498209907124, -0.36832941760372134, 0.556972610052944, -1.456379431849067, 2.207030476585819, 0.9917379310560154, 1.6676064207882335, 1.371758008359831, 2.5054519455352744, 0.2067834106806399, 1.623382218734575, 0.24863252816945178, -0.018984574978923217, 1.1416755189259291},
    {-1.2606312156885886, 0.82140721273072, -0.27782249500695727, -1.4035433987423427, 1.392073815960593, 1.7951375594201486, 1.0760824572872498, 0.2682577271214813, 0.969522879331222, 1.0968334651490743, 1.3893508101881276, 1.0056546313230934, 0.7685518919178338, 0.9451703499264035, 1.0700383637159072, 0.6718069637657945, 0.5653349256661866, 0.02544385167184899, 0.7101551789570587, 0.501715722463008, 0.8207731190645969, 2.0466828130702424, -2.8331142286671707, 0.7211582535104285, 2.099934823708144, 0.452977830787293, 0.4641333375906275, -0.221055448774395, 0.5264758822841092, -0.81628705403023, 1.6249857449199676, 0.7084697291392561},
    {-1.432420910823752, 2.2599448201011403, 0.9082299729278317, 1.8634875345431967, -0.5459645073323659, 1.7987583510704326, 1.8948753145365367, 0.5912124619788454, 1.837395474536258, 0.4940385906200017, 1.8935556315893112, 1.2005868191025928, 2.365970240370399, 0.7660556634994116, 0.9112430407717745, 3.219918743088446, 0.5319759658617781, 0.2407100302788358, 0.43447876625378173, 1.331001149774967, 0.5545212987657017, -1.5914211021880582, 2.679212976731227, 0.8371357458279809, 3.122544997021209, -0.3051127376585495, 0.7885727620063142, 1.229180785013807, 0.6016601445938194, 0.786057589670696, 1.7363600338391045, 1.7513607266840874},
    {0.2381234497482608, 1.9213710040880088, 1.9040474143582538, -0.84102537367897, -0.37322515077721463, -0.465156338632569, -0.36047990603834335, -1.4592280352386215, 0.5444225145099416, -0.05468490889703681, -0.519586672356061, 2.8971519921622666, 0.8634211667873558, 1.3635262966637132, -0.40106109186055167, -1.1548896788895409, 0.8113145306331815, -1.1919619036642106, 1.4458847632096012, 1.2669790462691202, 2.04011669661493, 0.38898331176739365, 1.2710724488734826, 1.8494825856969994, 0.2585225930968788, -0.27151550058876217, 0.960365727716817, 2.994209437377736, 2.993446718204408, 1.8078300315435185, 0.18578701775432377, 1.416293663533767},
    {-0.7606686745830132, 1.9721653828260906, -0.39601896947630916, -0.8572881203036707, -0.928175237717837, -0.4796521447975984, 2.849947323882829, 0.8008244118741201, 0.7273898706680397, 1.2594922039255576, 0.377389843678322, 1.3118295111467753, 1.3649846484686672, 0.438693810455682, 1.3939308260263077, 1.2362898258739867, -0.7688682593902744, 1.9575510768246323, -0.8470470126087518, 0.8281652316073853, -0.3372945126237738, 0.648083017764289, 1.167527461030885, -1.40034961293441, 0.17414179201786475, -0.5837573809797671, 0.9370676581434103, 0.06546287059219248, 0.562442718856714, 1.8383413206692991, 1.1097590446323022, -0.9046628748420966},
    {0.6489479955102013, 3.1232204562876613, 0.5276117398684704, -0.06750117530165842, 0.7183246085959983, 3.3120328210297476, 1.4551831994081303, 0.1456873035579484, 2.7826888117907407, -0.3981741382013051, -1.153955296829615, 1.1415940111834038, -0.8898821281239283, 1.6878328236861988, 1.0866743413513267, 1.743462306882394, -0.07909285137673096, 1.0855807284421848, -0.3363337540374963, 1.0913517659417562, 0.46182833195917816, 0.4960052618136052, 1.226789766526554, 0.9892954402790036, 2.2551990311901746, -0.9498611426743099, 1.245623127689774, 2.132732925134772, 0.36566139596141295, -1.6490607568544537, 1.1063494812535024, 0.8656726909787726},
    {0.9108236868956797, 1.0860944158981978, 2.9703573805783923, -1.2732052163429275, -0.1707920883967737, 1.8675412954972204, 1.821246809762645, 0.3080603187173473, -0.4767994285253561, -1.8392098677976485, 0.5373306505947361, 4.092904779295274, 0.33145236200389927, 1.8837138516677243, 1.4084425684623234, 0.2478538979620765, -0.6665332265926996, 0.22088478591797636, -0.9028509227095104, 1.2904668021379404, 0.1415174832937724, 0.5790040863199466, -0.25059079629802905, 0.8211012189687992, 0.7150173413409162, 0.25239573648217556, 0.9826679553710626, 1.543130216027613, 2.081617638397039, 0.6658823394011968, 1.6121938400243196, 1.7659590305515536},
    {1.65471475542191, 2.595737122867937, 1.7802025623769862, -0.4598052255638905, 0.09752602819500646, 1.0040264440174762, 0.8304521050946089, -1.8125084833963507, 2.385735466438278, -0.8789819987462428, 1.1855628506541687, 1.3156540042074993, 1.5546206039671726, 0.5075288272827841, -0.2627725734390638, -0.6519225052893057, 0.5379922807371055, 1.3119842094028635, 1.5996427394611223, 0.9948668396940301, 1.601467675819499, -0.2879374647150362, -0.9120412060588929, 2.278478130961093, 0.855786722958527, -0.2074027402019322, 1.4318511875107465, 1.6693566821290675, 0.47548883068518794, 0.0882840729173579, 1.1960974803920759, 0.5791606606087051},
    {1.5972695447905183, 2.759034417862666, 2.9754767778962345, -1.3538272756422183, 1.692615705629846, 0.1995831982160188, 1.6913408729972124, -0.2019151768611505, 1.037277672247383, 0.9992000930984399, 0.8630239521278156, 1.0990280039012188, 1.3724172144826647, 0.3185493127758665, -0.27211489404566186, 0.8205548610598367, 1.9978517396324789, 0.8968272142703803, 0.2915365033642877, 1.0679140674008794, 1.2998804442021976, 0.48930610670013314, -0.8439895043817646, -0.8665861114011997, 0.38791819670376937, 1.3735504894153066, 2.026170188347368, -0.33486562624491056, 0.7170111215076431, 0.09100418501146104, 1.330750287012559, 0.5803520742847899},
    {0.4344012523867101, -0.297069944481287, 1.2855291417108143, -1.2371916787068413, 2.417042461085207, 1.5010415586450245, 0.1509687407472006, -2.7726661820075473, 3.1129469313444753, -0.42764855698952975, -0.0514945476962437, 2.244649372664692, 1.4229508686469885, 1.4653080203395312, -0.10670633912361445, -0.08436044023201582, 0.4749811539681139, 1.1797670939535105, -1.227542852380966, 1.1038990893958842, 1.1432285121728956, 0.0048947643284384555, 0.7431593181443927, 2.0746476558090885, 0.8394981052851936, -0.5210162310214752, 2.856892853192827, 2.6132631305071445, -0.3838558369128714, -0.21934739864239042, 1.308030617276814, 2.000078997702446},
    {-0.49503675881331766, 2.2135585483016302, 2.031479999318534, -0.5518594637598295, 0.9547855461058568, -1.0408172177128516, 2.035374802251163, 1.5089114733997218, 2.03333857740679, -1.049132589618806, -1.4684720215224203, -0.021757620535531035, 2.0186286527048485, 1.2745750730398595, 0.18224795109675487, 2.014153968910455, 1.4730544186025745, -0.1838958208279587, 0.926582457598356, 1.4920132591707547, -1.013904916929792, -0.5967367305761739, 1.0198612755632979, 1.558610740828003, 1.461475269829277, 0.48596214803871024, 2.881411311133499, 2.041663556268405, -0.497519335913404, 2.7096582697291476, 1.8203033438990905, 1.1156000986722914},
    {1.147446353397382, 0.5081336703794618, 0.6420198236913507, -0.6703417225616644, 1.875008597193895, 0.46984354604326245, 2.0049315596132007, 0.4726046979782906, 1.390036417727853, -0.5890848735503481, -1.1740586619656446, 2.153424999050877, 1.4535359747162195, -0.43981401738924397, -0.10416834475852578, -0.36852364090317424, -0.1940433594142462, -0.5733005926548197, 1.2815340322019615, 1.8826168679443906, 0.39459411877231426, 0.28440548361890594, -0.22226891336608853, 1.5500922831714943, 0.5856179610326183, 1.0842490025315092, 1.3994173687550298, 1.1859058802647502, 1.298857718704193, 2.241148066954592, 0.3645545486172985, 0.33376556117899236},
    {-0.590925601184003, 1.433386099086977, 0.13891518975358677, -1.4694245419696306, -0.5663539269014205, 0.04852539456997029, 0.6750725449970132, 0.6680846182415476, 0.5840692231949286, -0.24459033197447674, -0.7531210414142299, 2.0610405041912765, 2.595336658829749, 1.1323467217973329, 0.08670704343480208, 1.129940117312077, 2.5300765639355376, -0.8714475258807317, -0.8452112667038414, 0.3334376852652118, 1.6903974114369615, 0.44000414836502755, 1.8178442127584322, 0.16326382877790305, -1.3868719765150646, 0.45762945111655917, 0.8160612842187368, 0.6742822537980279, -0.21892889882788144, 0.38738235820796263, 0.6945099880843523, 2.6766444052474427},
    {1.1154037003687198, 2.572742483866908, 0.00843804002909154, -0.16158094569794113, 0.2523437929331189, 2.7131842865915, 1.8159902817953144, 0.035635239722268404, 3.1543849803851423, 2.8401258191612975, -0.04127993704083869, 2.8637815225293286, 1.493155194184881, 0.6266624083918084, 1.521967111333777, 0.8358500699369804, 1.840762040236581, 2.1418416683810086, 0.05197183737393826, 1.5237981055646561, 0.8479349051005638, 2.1329228561262052, 0.20403866866827866, -0.7444824161102532, 1.2465242306061535, -0.540633433207428, 1.2481368658728957, 1.6892948205687066, -0.949174187786145, 0.019797125177109905, -0.02165117117857716, 1.1279655029314635},
    {-0.8754994813439912, 1.371608887844365, -0.3601795101823009, 0.058012290963225695, 1.594074340333958, 2.3467920011499315, 0.9160951146686059, -1.280894118877045, 0.8818269239178658, 0.3803299411776334, 0.037591560860015714, 0.32061472898797844, 1.2951799065819634, 1.5697775179787865, -0.9224664579897272, 1.4442422405931106, 2.1274247596069102, 2.8441151594454586, 0.8111558415007222, 0.8057732473103646, 2.088774937165178, -0.12049500598530934, 0.8419080461570257, 0.09004239306513293, 0.5863883325441598, -0.35711383645168887, 0.8952279782888853, 1.6915490147700483, -0.7136783768512494, 0.501175826224757, 1.971457447557318, -0.024941154206136698},
    {-0.44315116844323577, 2.0874436360269573, 1.4205346513417, -0.33443437476100585, 0.0638074675212946, 0.42268717139582956, 0.6744503518113588, 1.1158995669459397, 0.641431234588005, -0.010065920597920558, 0.1142250842749073, 2.438785592081189, 0.5389852063906514, 1.8871697039849837, -1.8849879684220134, 1.1755065969775673, 1.6013025858306797, 0.1864534867716136, 0.9814630720288606, 1.2942821146733936, 0.788598293392896, 1.190202971881576, 0.6144408064497617, 0.9676592148486354, 2.4767943520062725, 1.0924190234445925, 0.5959897762936819, 1.786825391208186, 0.9336189908025714, -0.41115670654425857, -0.12920047862550646, 0.43045195506897693},
    {-0.9302166611199871, 1.8754309799271787, 1.582853910626246, -0.5157406569462384, 0.0886703590965575, -0.7899115304323238, 2.6579554810129524, 1.0680962874503097, 2.197924436582776, 0.4829217224487055, -0.678507935203538, -0.0527863304112842, 1.5514661513823875, 1.593568579743057, -0.24933359831919047, 0.44885773726971423, -0.05878987323410756, 0.6357832476937578, 0.28885764957771815, 1.1265550883651057, -0.7677409713058467, 0.8927123367085341, 1.255812279369243, -0.4053549596004644, 0.10360995354882517, -1.3552105630937488, 0.8740970912521778, 0.8135376054830321, 1.138575039319908, -0.42439704361180947, -0.01718749550589369, -0.8343477258133897},
    {-0.1798070024427959, 1.4858178865248506, 1.8587603537738746, -0.794195067820737, 2.0184600575843454, 0.28432035491212765, 1.2504568594422425, -0.838452182898585, 2.0366345652689883, 0.0520766586217756, -0.6415557139909508, 3.28921695826416, 2.0414912119758264, 4.1803097653585235, 1.4749838183029764, 0.17573589306971435, 2.0569726348168578, 0.5049144755337674, 0.1147769533990859, 0.6241327959528414, 1.8182548542470565, 2.487745677778153, -0.5936183096750216, 1.5209524992482395, -0.39433483975599726, -0.2367665704469586, 1.181697855533412, 1.652132465865845, 0.4835703555149991, 1.2617261632907488, 0.49745302733360697, 2.2742952788106856},
    {1.3940293795106415, -1.0752934813986057, 2.011960020441934, -0.5648525393231387, 0.944941041228367, 0.46054234469164845, 1.8222123844134257, 0.09355915100387625, 3.509356749960675, 0.20920009060175904, 0.5099708691951498, 2.530025441185891, 1.5236051397186705, 1.1700544379714108, 1.8401327652243933, 0.5805801112234458, 0.3094293963188199, 0.02038421419531401, -0.23494116098994355, 2.7367538420949096, 0.9707130770924984, 0.33198861432549875, 1.1997501697958115, -0.47436612721172977, 1.8189460026097588, -0.2860313305815718, 0.16454614126706657, 3.0497836200595536, 1.4516294884716945, -0.8873116174454352, 2.037438794245023, 1.1155446548788504},
    {-0.6048806673618654, 2.322033152870053, 2.0602656259819896, 2.281961952809351, 1.344268773315156, 0.3418815708473005, 3.9732905116273676, 0.15174250542394194, 1.5597870580055477, 0.6492565947671715, -0.06720134788265741, 0.36462767035587096, -1.3001263952564723, 1.5151518560651753, 1.4613012829683487, 0.14030240687821777, -0.08810308548822418, 1.2414682908996117, 0.5819516520128268, 0.8933528428905448, 1.4686738414449338, 0.2848627665188827, 2.069513216492541, 0.6285507470160897, -1.1814866515385565, 1.294761577781491, 2.3719992358784094, 1.0725715752563836, 0.6428359672345841, 0.45512688400657453, 0.5388075136861048, 1.259789031319577},
    {-1.6976465819170787, 3.520352001602256, 1.2622279380922925, 0.21571590206111124, 0.43252833927776985, 1.106572124398852, 1.7564442420423885, 0.40745495743210247, 1.026214124228377, 0.8389817790477125, -0.7011332027394483, 1.381046793023913, 1.3987185165056648, 2.1524591620931646, -0.24639141015263144, 1.5293869837528111, 0.8589992437969937, 1.713285740272331, 1.0685162725538377, 1.0319165068140608, 0.694892073561228, -0.02797846781061239, -1.4872196073110553, 1.1488267662597262, 0.7602233236289586, 0.14707206358046693, 0.8606731656759862, 1.8988695785450858, 0.9719414309048043, -0.3875210731540522, -0.003937729239821222, 1.8046051678543868},
    {-0.3272361488850381, 1.022112461095955, 0.152708586491393, 1.6752037714194508, 0.9655540183066894, -1.4851236782398027, 0.4654831500598909, 0.60534748457475, 2.690033854917438, -0.9616192559245021, -0.19875906769113114, -0.16184552126630836, 0.9837849076161427, 2.2271629628151564, -0.8492154179361033, 0.4388517391587466, -0.8998839946588382, -0.28053853579535976, -1.5737838865611078, 2.2074502030215184, 1.1330861511070516, 0.407657366376524, 1.281541981520816, 0.7793731140658253, -0.17781478445789517, -0.20050786624254396, 2.0328862262523426, 1.9703903446797824, 0.2401241917864087, 0.5862329935058114, 1.9495658661183088, 0.6903532283219884},
    {0.5800591250132632, 4.357551208976091, 0.2071286945338229, -1.6271618146955, 3.7203112335105994, 0.28182886459507406, 0.443534428094958, -0.4153667187917265, 0.5605493115804832, 0.9125723454101605, -1.1395971319892457, 1.5066694881602718, -0.54649761285059, 1.1249689779818381, -0.26358997803993434, 1.297640716564648, 1.131112939991125, 1.0310145484295272, -0.29896811677414387, 0.31339746694334736, 0.8877651034845323, -0.878924436476875, 2.3461742716849847, 2.8853463224071745, 0.9970221753478905, 0.25965427633209903, 3.3008619673850386, 2.724134931952224, 1.4775288777397309, -0.13176880494995857, 0.22171720901674793, 1.3157754837792535},
    {0.36487360645306766, 3.8290567842494614, 0.2830192581846546, -0.29382171958943337, 2.2949367577786304, 2.0110258875682603, 1.0207448637503789, 0.4215630797100542, 2.217772747110502, -0.09129858938113543, -0.6985317156181949, 2.1622401655734684, 1.8652077565535297, 0.8489169686188827, 0.09284152615437967, 0.5298344231478215, 1.1570304374735787, -1.8900841501356866, 0.3204156070809976, 3.037497345586342, 1.6662355405423, -0.8591294278501717, 1.5002297927219428, 2.4274912982561423, 1.591504233424108, 1.0140378967459656, 1.5802254867548426, 1.688310797560009, 1.2716600546377077, 0.6791247774013495, 3.017504908411337, 0.3332667629650258},
    {0.7718514378262664, 0.28132853863066876, 2.4013588278444296, 1.7716203901436922, 0.44685678743177354, 0.18199306422905032, 2.208731030035909, -0.872334188171906, 1.5014418475151752, 1.0376300507154244, -1.8195553704301675, 1.7649823247345573, -0.3058060939640573, 1.3405572700357373, -0.5633015962580232, -0.23384792964737247, 2.100541243828853, -0.49534348703287073, 0.9875798242307465, 1.3804947476018117, 1.85180970298729, -0.8160385460214473, 0.3568986155684535, 0.7097480130496031, -0.5809106546519592, -0.2090165158538163, 0.26266989150368164, 1.9251314371058472, 0.3777955628482107, -0.6420821050765355, -0.4768412888012135, 1.1338727664271153},
    {1.0233717652067587, 0.5399329502263617, 0.10470835215766404, -1.5834346325465989, 0.10653354170569647, 1.3510342058621403, 0.8583190225042746, -0.04206260664856734, 1.895067297333628, -0.097853124961903, 1.8976525229470576, 0.13753369746694566, 1.5584004377952243, 0.8622092408706626, 1.3284309940905492, 0.9076288900163094, 1.5103048896470896, 1.4088207939779493, -0.3007243721867424, 2.0724028685412206, 2.039299303546469, 3.9332702277703473, -0.04780930067407753, 1.240313852876775, -0.4545962574911339, 1.3190694076695806, 2.759872839442574, -0.5442615709683489, 0.6041338768652128, 0.7809424458077926, 1.4524125186821324, 0.39838728883886626},
    {0.6983134960278774, 1.3582398231926496, 2.50272432200615, -1.4875706237099087, 1.590415230622305, 0.44061049529668134, 0.9604787386148314, -0.8081235815469959, 1.6891637729271802, 1.2175861003984558, -0.455828707912228, 2.7457407651379984, 1.3237310483869498, 1.3983849681916378, 1.1618106835973416, -0.11173330537364531, 1.0164960598423785, 2.31290874035876, 0.990105792195652, 2.5022405116819786, 0.23859061286929886, 0.5857415841700746, 1.6467490306675494, 0.9580506404089659, -1.5347125130197663, 1.459682530687852, 0.744003567217318, 0.8193637050514956, 1.4172551060751741, 1.2121903233830025, 0.5292388512111592, 1.5737127969008955},
    {0.7234166931686412, 0.1680276781304538, 0.6697384389193698, -2.2231203635878285, 0.40490843746259664, -0.9827644009060502, 1.89370874633738, 0.4906633542206814, 3.079609329982979, 0.20266858168587507, 0.047014623729652, 3.04312496363899, 0.8209584570094806, 2.4418227242729844, -0.3544804582385206, 2.4047071798953894, -0.010624603571143535, 2.162720277546377, -0.26713766539898615, 2.069609050501708, -0.07129132434959118, -0.0009680135506186209, 0.3397538309898693, -0.5197643055476892, 2.1611551241954645, 1.6445693262264165, 3.526606301037861, 2.0306277686298184, 3.319066086745842, 0.09228867476739831, -0.5811300379903763, 0.006098130516136557},
    {-0.5894712974810824, 1.4899818273116394, 1.2628798820189493, 0.8296900063066796, 2.310436327787909, 0.24418577666829364, 0.1410058884072723, 1.9285685365700362, 1.0188802229437697, 1.06194213257703, -0.6736724764229086, 1.6875617470576514, 0.3980294078132617, 2.114590244212944, -0.7791001177720699, 1.9149030144892276, 1.8133769625391842, 0.8816318921388804, 0.6180544194442462, 0.14878626179846072, -0.7920152492442286, 1.5815210905676904, 1.2302198030695959, 0.3160708877696091, -0.5186183286992976, -0.6353306923153266, 2.6162132351332974, 3.002131425968039, 1.861218815578412, 0.010575950927451975, 1.8903645753726859, 1.0893055706819117},
    {0.45280986745196705, 3.598539320713784, 0.7578642550932208, 0.49737341795951306, 1.3326239698409006, 0.6174662415701995, 1.0539498454066487, -0.9222126067680813, 1.4567055312542732, 0.08491462807614901, -1.6966679195355499, 0.7041398086897014, 1.6887006219327094, -0.8391630324381353, -1.0455141352595136, 0.8279676602534068, -0.22940892291426998, 0.24663978595444674, 1.87083233433439, 1.8086209331651277, 0.6915694553260242, -0.21110478022224652, -0.10278103185650184, 4.116503641612916, 2.086078028267714, 0.07110833519201079, 3.0771562445114995, 2.78793931544221, -0.2967400281285895, 0.4497414215825252, 3.745318383166832, 1.0722529406211694},
    {1.2942260203706761, 1.1404842937514528, 2.2484701120786426, -1.4498772995109763, 1.9528434847865985, 0.7460466777821814, 1.9729527822154949, -0.22440172749995754, 1.5931970230389338, 0.5257624066599065, -0.09499136123244002, 0.30839970478193746, 2.4687564978312904, 3.1391052208500887, 0.8766059596463389, 2.3287175739611428, 1.5660414612347062, 1.3232012508177116, -1.9687479731222866, 0.7618861147905798, 1.21228844825768, 0.824779968308955, 2.9436741074719013, 1.4275267879639018, 0.7918066028297738, 0.10826236992681117, 0.8236312189440608, 1.8155567942028894, 2.89627638464678, 0.3792724810994406, -0.6872207644387041, 2.832072201904681},
    {0.9552543726899083, 0.8639643010163346, 0.2541618614401091, -1.241210947401407, 3.3373822116036447, -0.3291461007326176, 0.8483820724230474, -1.7891598753471059, 2.407342102285938, 0.3622584696911882, -1.0576884758427259, 0.8652484161799455, 0.5568275717208635, 1.3361540906880998, 1.2867285495408303, 0.045909745364860845, 0.628915520015712, 1.1483396016029046, -0.4246788663520282, 2.141315529283246, 0.7407469499696121, 0.8607422642810219, 0.4669424227273745, -0.08146797165343451, 0.9112228713923295, 1.2073352795932006, 0.6760585859462137, 1.2563240404706415, 0.8239112956688843, 0.6502994586364357, -0.03268690894600314, 1.7250225718780625},
    {0.4472017248744196, 1.738973154413728, 0.3748397843149593, -0.13625756487740892, 2.4348227640633895, 1.7270297858699761, 0.9537963073113278, -0.5660569678790658, 1.2615551794201163, -0.8680509616754768, -0.6466342106772708, 0.1278232455378997, 0.9567369404197802, -1.2027514936809396, -0.17938398499537295, 0.2306652016982466, 1.387061802386208, 0.4810606279425602, 1.1842084307389247, 1.2452700009655653, 0.30993428503457093, 2.2601538383527857, 0.8482722914101459, 0.5668046899551574, 0.9478153264844289, 0.1870097517930274, 2.074479114607765, 0.9914223465649564, 2.183025541894682, 2.1787689531162706, 1.0748195532733371, 0.71720330094754},
    {0.49356539502144453, 2.609098024842171, 0.45152598185179116, -0.4891675408098519, 2.671469884947447, 0.018149759929510317, 0.9087093885557499, -0.012167027171901339, 0.9082382511883644, -1.2695050699825807, 0.1996852810268082, 0.22851309137078704, 2.469274086668775, -0.11916430560503116, -0.12351012870855609, 0.44073270525511926, 0.32592856009851556, 1.02532745565492, 1.4697638578692094, 2.3310668260105887, 0.9992429810472766, -1.6441907837946461, 2.8010991077937506, 0.9679942438062079, -1.2839984764397732, 1.0695118377104949, 1.9532401497075385, 0.7895722210103667, 1.969869101668173, -1.0083091111268216, 0.9935363002960984, 3.3848347170467057},
    {-0.5749166716938955, 1.2124450813635017, 0.8524990359693181, -1.7226243920669397, 0.3323172058090877, 1.1657473725741145, -0.11804533128485391, 0.3641090356264762, 0.03097784916516458, 1.9473051000047534, -1.5287222367503286, 2.617784388742859, 0.947841854408763, 1.2870813286256144, 1.7414216261934319, 0.3729414771735412, -0.1695442426998632, 0.42443417340715095, 1.3066478411480706, -0.9563732019085278, 2.562337345831084, -1.9993994386480223, -0.3708606796918261, 0.7021407534595807, -0.298963455815647, 1.125369209587182, 2.8681210063663967, 1.387252075716887, 0.1724001523271844, -1.8380053042413622, 1.2746128669697558, 1.6148667085918333},
    {-0.9605381952864767, 1.5090398510620104, 2.734364978930443, 0.5901026269436217, 1.1419763198642197, 2.9745316941119166, 2.0556450098157666, -0.41733597718956816, 1.4141536811357152, 1.3109806692312227, 1.095035459401962, 0.588207451594288, 0.7444485044762152, 2.045485502104008, 0.9278200508680973, 1.6689594726312573, 0.43869564459951704, 0.7538098534614287, 2.2508544418652328, 2.0795952598111267, 1.6762036746612716, 1.9536338839713518, 1.2767444636459577, -0.3690872477781835, 0.7609543016326016, -0.6276960785517666, 1.8729906162733838, 2.5640916062256265, 0.9112279332278906, 0.9162781884772874, 1.4845791562422077, 1.524096208273911},
    {1.8136154643086473, 2.722347250204049, 0.4227096580460636, -1.611634354432117, 1.4551060894160508, 2.2397150048613086, 1.5533739522629901, -1.3339892600478227, 0.19221869635410513, -0.6512163907944947, -0.1245644357384976, 1.9933422808164802, 3.306792092258577, 2.1799832263973244, 0.770648567492809, 0.8733572732369341, 0.9115579812737055, 0.9688458406526453, -0.42607785681786003, 0.47058187746586694, 2.746597707047019, 1.032007343816852, 2.45980360825014, 0.07022248931241125, 1.3364228327186773, 0.10781280751597838, 1.9211326375582525, 0.945227535930704, 0.822274082728358, -0.7969754156465081, 2.645550814333076, 1.3952082930071559},
    {-0.06739207761603495, 1.9806666796710928, 1.2759653812053862, 1.318544632499622, 0.6991282148391256, 1.2379462187181693, 0.9394311554512402, -0.5933043158419589, 1.0399914493139293, 0.15821923618428346, -1.5569628272291254, 1.581768101026055, 1.5001703206147046, 0.3853130036456814, -0.3984897425229858, 1.2657476585991723, 1.136044569467018, 0.22993579630239755, -0.24009647851958468, 1.2620943333636536, 0.5843027888995371, 0.712086693815172, 1.6394044073169476, 1.0841833699324321, -0.1023542930156565, 1.1339048707699413, 1.0640379436430354, 2.6373085388718325, 0.24026839198059674, -0.6242388896261676, 0.9921288101042619, 1.43100353532642},
    {1.1470385977320645, 0.9651927945673036, 1.2398861328068043, 0.8888985534804343, 1.0176180308144946, 0.05554512822193399, 3.7357706992501676, -0.426538866848758, 0.925690005301368, -1.4566971965155033, -1.1695169844503261, 1.4558478409629565, 2.6060431008727116, 0.9887377175749736, 1.3626449996005365, 0.5289613626999102, 1.0914678966330735, 0.23616708632875255, 0.6871634082389014, 0.2915137687160557, 1.320982578230672, -0.2609644228793781, 1.401137314572333, 3.029665331240156, 0.6333880600250256, 0.5666246808449705, 1.6631194787517913, 0.3690974086619074, -1.706494639325257, 0.33203203956146504, 1.0469201321355313, -0.6491723029459875},
    {-0.30201011729561605, 0.7104700739797484, 1.5390551846190423, 1.5737431421970094, 3.276513500832815, 1.372678706629821, 2.8791559993421454, -0.40823838265338713, 0.9923947061183075, -1.8028192714002615, 0.3079166448468014, 0.9303815015733855, 2.20032235052805, 2.0309670524573042, -2.33568342136076, 0.9661265423233913, 2.843415183379215, -0.5913598951412771, 0.2662424546561312, -0.21541354813713096, 1.905265076975561, 1.2494217929222797, 0.9359081988227519, 0.8922788637900516, -0.6703477038388739, -1.6573505567314453, 2.224411769735293, 1.154588206500257, -0.4942424263976187, 2.5233117471059274, 2.0632202488225566, -0.929117777388944},
    {1.1753716135250378, 1.4166250846949722, 2.3799738088177613, 0.5868451586593788, 3.1412630624689006, 1.2186845922043579, 0.08434715559849801, -0.4992351276383339, 1.997253673507047, -0.7411451462971567, -0.17576164269831324, 0.6313316931416387, 1.6570579747574166, 1.0324796927428717, 0.7726291328995729, -0.0474716349595485, 2.2544185767820544, -0.9293533842710077, 0.2744974124628389, 1.2718807115392132, -0.5387623967894707, 1.5873183170861873, 1.3591045565014717, -0.7176742916033494, 1.1786679240174827, -0.3249202782651706, 1.8513640349790952, 1.0749858043273823, 1.5717588080280431, 1.0633555023170334, 0.2158490967283173, 1.3806994066838845},
    {-0.14211338536607648, -0.1427238835237859, 1.4540334494762672, -0.7706870868792183, 0.6875928384334221, 0.7054813844346856, 2.4503575584928736, -0.2438361759035984, 1.4914709313314616, 0.5537978041875699, -3.2038262849721266, 1.0677716711192573, 2.060399068711257, 0.4982044691648827, -2.5551539232058733, -0.058106702431963975, 1.2873010986746933, 0.7408910335390467, 3.289456461134362, 0.9962345351719042, 2.2808327534211013, 0.906271998441189, -0.7635252252453343, 2.512150848149723, 0.5383155253156904, 0.3235376777666763, 1.139409467384718, 0.49265616821530334, 1.3649269346881312, 0.48491193711672786, 1.1046153117081339, 1.739759066955098},
    {-0.6385888314629296, 0.24691477828443004, 1.8747830481791157, 0.6981691212396304, 1.0305483247061114, 1.1773248831291427, 0.7979793449475774, 1.173197309906987, 2.417905211447106, 1.7827495532488575, 1.3083070315009866, 2.8733963590020197, 1.4118290783699674, 1.0897429088434305, -1.511948299901088, 0.9953574443607642, 0.9377640884510079, 1.5058608335730668, -0.3974225021024338, 0.6305401399814204, -0.003871264081745925, 1.9040327519330766, 1.491096159404521, 1.4679615757587767, -0.08204462176428988, 0.0074506844015451495, 0.9706130125617499, 3.454163398773136, 1.1779596275670787, 1.1920309900206891, 1.5488354582727997, 0.7990320464284572},
    {0.24439925542277752, 1.4303606875885637, 4.089349635897298, 0.4893935820491337, 1.872918700002313, 1.3648170093714271, 0.09786666345695151, -1.3343496938267356, 1.7724845176986306, -0.09262463768635054, -2.2046288590089453, 1.6044171672907215, 1.6078081098940413, 2.9998632995808028, -0.06757918306295832, 1.5618039091644578, -0.9657555673489963, -1.1114952822492796, 0.5289581980754663, 3.0396813909793075, 2.345955704340228, 0.7480665235973418, 2.781305459582076, 1.8612666115560959, 1.7666099325021278, -0.1362751316544057, 1.8619615045761861, 2.3443631297763607, -0.15472777266393026, 0.21046841505408936, 0.7660078628064583, 2.575392451549328},
    {-0.8685243391335022, 1.399474124405925, 0.30702756571365863, -0.6563783909929932, 0.835145297568622, 0.3428535512128228, 2.090846484877916, 0.2490093250854866, 2.715666338391834, -1.540158030974031, 0.06803134108511608, 0.9131565330132898, 2.34602705078954, 1.9897270694015927, 0.19839614153340251, -0.2952047983837975, 0.34725740635778474, 2.1816781006659673, -0.04811930687130426, 3.136649990571548, 0.5706513940037385, -0.16630495501470488, 2.4123943216505603, 0.42651837139162513, -0.9131506017677516, 1.2392581256539434, 1.9879255872773018, 1.3515458772783102, 0.6887245343229138, -0.19676511979951067, 2.6080985742214238, -0.5624626906542382},
    {0.7626151327470677, 1.7784191433154501, 0.10889474411974126, -0.08936901287232482, 2.0274737763860324, -0.9033260452830354, 2.3058880109367847, -0.24578795342417314, 0.55754486926021, -1.6520304015755438, -0.8419761346971829, 1.852450378479138, 2.186967914449578, 0.8586711698294822, 0.5804651124594393, -0.24456764458452168, 2.811590431291247, 1.4143035067556002, 0.39280887222146643, -1.223405931282735, 2.141487118591346, 1.7617654081761946, 1.3451882046154093, 0.5847342381161984, 0.9759430773772756, -0.7870531061063714, 0.25067667357062146, 2.529042109385243, 0.11144548972038107, 0.2138774666192681, 2.534125024497512, 3.719187403289158},
    {0.25594919085135726, 0.6847024702670059, 2.805991161462788, -0.689782307960737, -0.12137084403519287, 3.083657857921801, 1.9494747596647226, -0.564258478225855, 0.3907355833233696, 0.5359013298354952, -1.6584105915089296, -0.6546306578537405, 3.059346572942822, 1.6797010878198804, 0.16932371766861481, 0.6214960850747814, 0.14778132191481755, 0.9033877459730203, -1.1687388845148077, 1.98240590391164, 1.1998804304468875, 1.0527454450615492, 0.5699092848615123, 0.032960394075055896, -0.46168934825997093, -0.4712204363287565, 0.46199312966785794, 0.31066121070818403, 1.8465659877916316, 2.060526801871798, 0.7241402069949714, 0.35195933367284693},
    {-1.0171610283858168, 1.965154454288737, -0.8648231783636084, -0.6027863631206468, 0.16786964929650247, -1.3112651403991764, 1.2230143378772658, -1.0363648334760005, 1.921800227874681, 0.03644930834800344, 0.0569611880450422, 0.5810665690774741, 0.8495436768704893, -0.04460987692960196, 2.1246545447903795, -0.4934462391997504, 1.7087153927956047, 0.9769178227794169, 0.2640314805714748, 1.7596553245882443, 2.139678840546263, 1.2903041500420274, 1.252012230605659, 0.06885377194021448, 0.6687424202949777, 0.33104797614731685, 2.029906687214859, 0.7182329000801743, 1.7245102492552913, 0.43093090751122415, 3.216462487639824, 0.9813816586541759},
    {-0.6186873068435579, 1.959304405551279, 2.5869091074315924, 2.3681809146991664, 2.5254445149875018, 2.850194265895549, 2.1524399970713883, 0.492068374760268, 2.1304509055149805, -0.05873549669740431, -0.40977794822943675, 1.8452827157199796, 1.939013309236505, 1.6488211331806741, 0.8105517579171216, 1.0992195867261747, 0.14860105058946912, 0.443235572498325, -1.163722196415651, 0.5778861818370521, 1.0292683515210994, 1.618692288294257, 0.8511595962751607, 1.635210812372884, -1.4948684199340063, 0.6567004367373475, 3.6651923414627383, 1.6094352032287529, 0.6037341374275342, 0.18766428188743395, 2.2876566306030726, 1.9706584611326778},
    {0.8798344513514594, 0.9410886316482759, 2.4517926639481242, 0.24759453145655075, 2.983101949636401, 0.8859242341938021, 2.3276137247056523, -1.1710728771816497, 2.2221566015214114, 1.5218754723058374, 0.48835303031867855, 1.4606499462788607, 0.6047800750323713, -0.32654402028578144, -1.2314708265369017, 1.505040302963565, 1.984210554045062, 1.0778676911445408, -1.2743691208392431, 1.675431544711984, 0.8175430491171013, -0.04482712764978016, -0.16170978080698248, 0.4175495662613467, 2.770719806881834, 2.1161150596745455, 1.744929761229693, 1.025747347721653, 1.0600129328993908, 0.7352507273867704, 2.642030888231586, 2.3924199703102302},
    {1.2202312269982125, 1.9971587065593008, 0.06478756391583071, -1.4136961284758434, 2.636054980819698, 2.2865982536065594, -0.4754088056120492, -0.044416435247537064, 1.333056349479827, 1.1307376157438955, 0.1678800503017851, 1.4833763638217436, -0.3839824550828954, 2.6279946351373056, 1.0236289184014402, 0.9496673586415849, 0.7164288286866833, 1.0364543894729696, 0.42535444814091034, 0.5856279745272667, 0.7137330692094979, -0.31688197395791134, 0.7132014976783051, 1.1042784872998794, 1.176740684953854, -0.35621671443555974, 4.873439306160641, 2.1389595709313682, 0.8825112884602271, 1.3991521259464834, 1.807427003857493, 1.7725641736922344},
    {0.38995254546003416, -0.3561159814073643, 3.8396194232701824, -0.9226033910404612, 0.7564501581199944, 1.4509566182230906, 1.2945764868413787, -0.39224455476104864, 3.5700557735207394, -0.042244433292578515, 0.7917577894558987, 0.87716982257522, -1.663090315963597, 0.13974744542800224, 1.4972619002139007, 1.3133806818937934, 2.3987396189695955, 2.4975113607720187, 0.8015665235395786, 0.480880126878875, 1.7731993759865183, 0.6686725803814264, -0.6591433394680973, 1.3345340552137233, 0.6015976283353129, -0.3065241072207035, 0.9509303098261933, 1.402453858657561, 0.07299339911979094, -0.8087562857664052, 0.4503367014644003, 0.18512457075457808},
    {-0.12415345875719429, 0.38553153416886227, 0.7527244519911901, 2.0800646196159915, 1.2674942932351185, 1.2341928953336168, 0.8045936751791221, 0.2233369269065646, 2.6891099118273174, 0.17086623835333137, -0.7309910013324014, 0.8126101826293224, 1.2162468544182274, 0.4202046555783729, 1.0139408785963446, 1.727516856336467, 1.3593724202586266, -0.49893925353170504, 1.239037283201103, -0.16485764311825457, 0.30263479614476807, -0.3376982866998655, 1.4589259328499407, 0.08838719608297553, 2.6283132353641196, 1.5271046552972278, 2.091132955450968, 1.2132004295847783, 0.8750230795690894, 0.19267440207133876, -0.7603922597536353, -0.4189291165225563},
    {1.3516547237599934, 2.1779089084044516, 0.7867201723720735, 0.20839883782935534, 0.5169111131274408, -0.09363370312787635, 0.6173673183517034, -0.32636730328273894, 1.3926338837230343, -0.07580757756780991, -0.7180804377770166, 1.021501489943004, 1.160976496680653, 1.6929584198128311, 0.16416475526735544, 1.008437975723003, 1.0137657409683183, 0.09011868244151533, 1.2970154045015323, 0.7338673237780367, 1.8554353956874825, -1.2882695533959578, 1.6119299828650036, 0.7079853960024893, -0.521506217273655, -0.10179941852652977, 0.8467652253641273, 3.7968528966779242, 2.639031469121913, 1.6674378442717905, 1.7093264273145385, 2.6697038230068864},
    {0.5001937450520233, 1.2494367374517792, -0.7676757963014229, -0.4879588454938738, 2.121182799964487, 0.7924282793099693, 0.7911612369788306, 0.8070148511861747, 3.0646731435454915, 0.6863100941469115, 0.35536108198653077, 0.35105477626015097, 2.408664061780153, 0.2038555054959947, 0.460225894964324, 1.122963279396542, 2.2117524396020904, 0.21696343385666883, -1.1234586564115676, 2.1595820074904672, 1.5768936516726795, 1.8671070383051804, -0.49334847565416, 1.3052964140182628, 1.9149677315966143, -0.1274233006392225, 1.3360341529192816, 1.5042853056276013, 0.8554736882258195, -0.2822355903335396, 2.170295136332672, 2.5775348791980646},
    {0.20628156033714234, 1.6412594890588788, 1.9316751103910261, -1.2660435535837997, -0.008565532902771796, 2.805465373069289, 2.1917409175049047, -1.0915905670669335, 0.44139390577279275, 1.430356477777367, 1.5628273318570547, 1.748265801433837, 1.4916929889964268, 2.567806644211784, 0.2989935738104958, -0.5763771778779484, -0.06344489102876817, 0.15031755673362682, 0.8630236010347295, 1.177483810187208, 2.141524660226747, -0.6251852938156721, 1.953318994239821, 1.5038133407406749, 1.0344164694439075, 0.6467802937390263, 1.3584282533899326, 0.03401081275375432, -0.21976268457558826, -0.6119272094258132, 2.4968137966400192, 2.391569776100363},
    {-0.5796654338671672, 2.0631155500360254, 2.1017603217569065, 0.7639982493518664, -0.19516693736960186, 1.9839672165336428, 2.1266315577201786, 0.3930579855163452, 2.514482189168187, -0.7618808143979913, -1.405543536050886, 3.0069489059277488, 2.792906114631361, 0.5527810558600316, -1.1081155688259756, 1.08647534236902, 0.5640876441339386, 0.8524807131326513, -0.4994653149984056, 2.894883264049161, -1.9121070374653197, -0.10778484868524336, 0.6716640190922716, 0.5200556525284439, 1.6438882725415453, -0.7679909264746082, 1.5188322451507148, 3.3838576437922745, 0.7271181585186908, 1.2616408205721221, 1.766634905770362, 1.7607233401747182},
    {0.8147571904810869, 2.1641331509373107, 1.6695246778332147, -0.3582574786919764, 2.3372123564509355, 2.2637373677079777, 1.1048672443801542, -0.2536310076668188, 1.1493282078700506, 0.21506572123717785, -0.17883076265364448, 2.519075903713346, 0.2638725285468785, 1.0235727862106008, 0.9823641851176761, 0.40224641128644945, -0.2213845550323103, 0.7339716542569025, 0.9453952400031911, 2.4407531747374254, 1.0570694061321333, -0.02162505326398929, 1.6589120539189997, 1.8950243555165394, 0.841984820586597, 0.34087875383144106, 1.0431877125339806, -0.16247415649622046, 1.7783465204265656, 0.1740642336602412, 1.6779671511842973, 1.367784880413862},
    {0.05081084673591835, 0.8864885541975775, 0.8849388978836411, 0.011315023646550406, 0.42430478982311176, -0.6787761133816922, 1.9862139216275962, 2.6468085613577554, 0.9828192974654785, -0.06643554026068095, -1.808720404340366, 1.5463335020528763, 1.2661658531615283, 1.8975108472745126, 0.19774446071645005, 2.0921275660599643, 1.0321824515970957, 1.2981070389263496, -0.3760377828728927, 1.350879186398738, 1.5571616823823229, 1.9396576248860349, 0.41484295939244015, 0.6685591469505207, 2.449491866648544, -0.842441457474363, 2.6233353489496403, -0.35458306800519224, 1.877137458310217, -0.23120321283380457, -0.35378538602424175, 0.6871401800600359}
};

static const float b2[32] = {0.623611320682654, 2.302500374061206, 2.0758088407944015, -0.21674694764882163, 1.8999917102992923, 1.318796158491183, 1.7813065735992002, -0.3574859478899417, 2.264468113427732, -0.07378353882956189, -0.439989364020094, 2.4649005182251726, 1.9514894864841608, 1.7888190694287105, 0.5387697031595814, 1.2037751872592708, 1.4580973148081682, 1.0611674594099447, 0.8239053122117505, 2.0770876140074646, 1.759703000025495, 0.9774417355665139, 1.817335618791785, 1.4901182017708383, 1.3608971792581777, 0.3175911158444838, 2.4697942183122854, 2.2917989497043885, 1.7753078025406406, 0.9132150198446604, 1.9826679715277797, 1.7944125392848451};

static const float w3[32][16] = {
    {2.0345793864778643, -1.0870035146337451, -0.3796530745395645, -0.2557624540220076, -0.7957260395074047, 0.8357769353435701, 0.08606663047973334, -0.9018745782731463, -0.1107958239540655, 0.6732304610572636, 0.9350088309324437, 1.3925755144436598, -0.43269617408170596, 1.5617197395219127, -0.2813030798960875, 1.0545929049688139},
    {0.9749520245334881, 1.5431113009518456, -1.5322167637849597, 2.3556357970323423, 0.22217641242351657, 1.420337753046139, 1.7956169556146118, -1.473760759655501, 2.6574137685646173, 3.306255202605375, 2.4622142171168337, 2.0367239776856607, 0.07192782743458054, 1.4178297222319305, 0.3039482148928056, 1.8319583586555817},
    {0.8750466116488221, -0.1295786051980961, -0.8593156254275313, 0.8096850522533461, 0.21676030656865697, 2.038287042148576, 0.5690408540005678, 0.008823024098010423, 3.0768283010851745, 2.2574293527955387, 0.6833403335377153, 1.4701372974603137, -1.5322671912117227, 2.5083083397377597, 0.5821411212355183, 0.6150138768030793},
    {-0.19617689646920553, -0.5413364707584999, -1.1709907188637685, -0.9030206371218064, -0.19056211726636588, -0.39077879953995937, -0.5287845172006186, -1.2471449399431245, -0.7482457147555391, 1.1401740537569027, -0.6612928235800299, -0.24767355682452694, -2.124959647667794, 0.34095104020541445, -0.4315590296150374, 1.255661149168619},
    {1.8965288998637946, 0.9053956418352409, 0.7524067853731791, 1.8203028006191067, -1.8029432670058623, 1.5821467741250974, 0.4065380684978212, 2.291314113371, 2.538933860630438, 2.297662064563076, 1.58686637213028, 1.2231970069765499, -1.8024861507662948, 2.9470354372820164, -0.9608447462499439, 1.4629975400876243},
    {1.3093593514046544, 0.0985146550964987, -1.776428018769636, 1.4428077557368433, -0.10959384826443776, -0.2605399942607985, 0.7839640820863544, -0.6135436252844815, 3.345893414663999, 0.5983645617255665, 1.3928983902026493, 1.1822135660888893, 0.9413915403158094, 1.1390322278966991, 0.8345232983006653, 1.7505456749587702},
    {2.0988994792654823, 0.8434881392214106, 1.3835122532177566, -0.1677475343566981, -0.8257619814597378, 1.7697259265294945, 1.006662276681754, 0.13491051662449002, 2.526508925440732, 0.43297759665555396, 1.2102298789682524, 1.315568262210573, -1.2527373508051425, 3.1568336207520042, -1.335010456500658, 2.7020077548571324},
    {-0.7805269564840344, -1.2758017562145012, -1.0505860067272499, 1.1617502636010182, 2.133746023264753, -1.02971367446483, 1.3862230784368994, 0.6391899178567958, 2.8723808188887396, -0.006840895842137128, -0.1080932132443107, -0.766021457127946, 0.7765473371852922, -1.3622620731722883, 0.5700628821766761, 0.2828483472874888},
    {1.0724182537220976, 0.895914172959823, -1.1091940352847927, 1.6567207923494978, 0.8155780721077756, 1.8663142763446408, 2.8008699671355277, -1.4039535313316367, 1.8860293008806255, 2.7667175160484985, 0.9932145515660844, 0.9818335718589886, -0.5727508540536377, 3.266281323539389, -0.39668918574075135, 3.0044751558384926},
    {0.7350737538250793, 2.969990177046324, 0.581543925777776, -0.38744883683582054, 0.462236284186183, 0.38263058710355263, -0.08506229806236074, 0.6330490793208459, -1.8138020246927424, 1.9865906510485685, 1.3375162048781022, -0.2089136175829907, -0.4061819786879381, -0.10535782737990582, -0.40362129282916803, -0.34782369397764884},
    {0.45824226408178426, 0.04058736032166854, 0.30540792214500545, 0.3036330792974111, -0.08915806822815928, -1.6492205214853715, 0.699582552084621, -0.22070390858025113, 0.34732488797571315, -0.8122464119111882, -1.9383432945239887, 0.8561759197390271, 0.8108733839107017, -0.5177600341340713, -0.947886090937559, 1.1464451147611467},
    {1.733090117626908, 1.0842761222874622, -1.403350473524574, 0.025492516648896686, -0.5407516731034023, 0.7416641484013727, 0.3907203989992877, -0.3620906298941374, 5.043633361002093, 2.2844112309647717, 2.242247831739759, 1.6765324861936006, 0.11564707214555447, 2.463428817282563, 0.3819975073720093, 2.570111793531378},
    {-0.3580708535502909, 1.811117070038537, -1.2266538836804246, 1.6571069566742136, -1.3406683483847763, 1.9567225095953977, 0.7710754504976005, -1.3913531386186022, 2.3931317147225006, 1.7873095055452395, 3.151129480821832, 0.8059075207264923, -1.6978285521336165, 1.7018597573298788, -1.0669300408676252, 1.0169970064702245},
    {1.2308196452140159, 0.9929894516470605, 0.3789414438056501, 0.950218807762766, -0.6484343356452582, 1.4563050842924588, 0.9087910019407041, -1.4796417490857927, 1.2120767359048978, 1.3023595294840293, 3.3743761754441053, 2.5150441288787677, -0.7497854707525229, 1.6876721340533452, -0.20420462323995328, 1.3273182779745003},
    {0.40512268082684194, -0.2753346741196832, 0.36045161455905783, 0.9207127094020856, -0.20356902152968998, -1.176652558196394, 0.33014453360599866, -0.43902095862988627, 1.5427724280942006, 1.6013294747683846, 1.2814914054477833, 2.009210923551302, 0.8949026656879141, 0.3602322234052588, -0.1858584658457673, 1.426209956660504},
    {1.3753948710753408, 0.5172115552553366, 0.8272187463373968, 1.0396832435650727, -0.43807943402811783, 2.3600757216543444, 0.1648353415476414, 0.04665694154723861, -0.08539992437024614, 2.679464227480219, 1.2935994365937893, 2.5430251980794853, -0.6860329747857429, 0.7107712348977702, 1.100714362813964, 0.8358460859958001},
    {0.32197942424987164, -0.9303563291179446, -0.4583033253375268, 1.377575208878519, 0.035446212365330985, 0.9051906945414111, 0.3069031335340855, 1.639975351516664, 1.7524586741761903, 3.0353074008644336, 1.0237771305648584, 1.5269622130827778, 0.4258053603420949, 1.8294825694770884, -1.0897992191868484, 0.8574204004293895},
    {-0.8681631014981397, 0.570082178791702, -0.041107057277761934, 0.536446651669395, -0.5546729077859145, 2.2138682053437213, 1.8054816558915308, 0.8791910234952963, 2.207793707588572, 0.9637642346580861, 2.5360093284471, -0.4518708552726824, -0.7258101830424487, 1.4031577942935907, 0.06027116812217759, 0.9807907490906149},
    {1.1932283297835165, 1.9802296259180119, -1.0137046185903944, 1.283527830205702, 0.06451942481771601, -0.2755307874561985, -0.13031134037469766, 0.7212034093150226, 1.561978497099845, 1.5950425718789378, 0.6552436737343081, 2.7870138669186755, 0.35406485051509473, 1.1991017864853568, -0.16071264285152448, -0.727499798360121},
    {1.446162292072543, -0.11488824503320855, -0.05018170776696667, 1.777691932197075, -0.17319014067306274, 3.1804465764078977, 1.1002572733371623, 0.7492724075315076, 3.4477938376995083, 2.0260997774006415, 2.235299493045695, 1.6021105008735095, -0.8884153847857394, 0.8498627821552521, 0.7233972411416337, 1.7670231939164178},
    {2.45973177461299, 0.43154523186616905, -0.085485417457939, 0.5736380757888515, 0.5393262654920535, 0.6671682093741247, -0.04237216469437999, -0.35852113203329533, 4.001106910488728, -0.1558007012721677, 2.848844924040566, 1.2830217415432852, -0.2591204674115292, 2.8810240836010084, 0.1571818982274572, 2.1357379885014303},
    {0.843004454158992, 2.819537939933173, 0.25934871487812056, 0.3333763236998376, -0.49094020053606346, -0.36073274931839555, 1.9368111309964124, 1.9058181930766958, 0.27355876970088705, 1.8543389883416979, 1.446559192388553, 0.5873211382619478, -0.9408029684008913, 1.0140326332097411, -0.05113338587366318, 1.7510565467586787},
    {1.8981046969730386, -0.2562043650806529, -0.7156006888541862, -1.0060763289145533, -0.930215032977539, 1.0325262393104484, 1.2074745404058, -0.8402402988831807, 2.1753918021957, 2.7132366850534515, 1.2760120664572727, 1.0630998447973254, 0.43442926361100404, 3.305845558687628, -0.5037342664048301, 1.5813599328855967},
    {0.530567680479219, 0.42499425040073874, 0.6283870401080082, 1.373531193579324, -1.6436853336533206, 0.9186150627822209, 0.3031156630018228, -1.2320983206650449, 1.4429850230390326, 2.9666396501503236, 2.0037501591665574, 1.045793193118816, 0.051284267069788524, 0.4687510212099074, 1.9889391156039, 1.522130031164712},
    {0.7602963246806443, 0.24634912572659898, 0.6473019103196518, 1.3968365653545212, -0.18108593468368334, 2.7154556586232887, 0.4115933553700932, -0.3507353711039487, 2.7485714707498183, -0.029230109398986293, 2.059976692971289, 1.6841677581298788, 2.165974603472122, 1.3008493124914355, 1.4753570122028308, -0.2164013805329354},
    {0.8273966762932154, 1.3574132419223122, -0.8461930146025218, 1.0837702454432603, 0.11773982755261686, -0.7979229145281033, 0.5555976391262768, 0.11825620664587486, -0.2998525894458204, 0.7270720637990715, 0.029345167885744025, -0.029610396131557037, -1.5235377400508734, 1.3119520214227842, -1.3319471424145726, 1.8748453408602},
    {1.2822505081278233, 0.9289317389465782, 0.4785007615436025, 0.7886735564637567, -0.2889991422214893, 3.2887180182188254, 0.6861979703527532, 0.5995374409677727, 4.54274039490453, 3.537593876335442, 2.704284329500378, 1.473041897870053, 0.07475953591696884, 2.353676663235174, -0.24427140991882343, 2.210306168735799},
    {1.4669529439276656, 1.5058893776546243, 0.25466216768817057, 1.3357172826215118, 0.5568287152147293, 1.8365112230727456, 0.7718975671412651, -0.6175152896034413, 3.616299074984055, 3.375977758241013, 1.6119939203423597, 1.1249384052648133, -0.846203725653882, 2.2334180160640216, -0.9203926905258406, 0.446931567885669},
    {2.3810553179123497, 1.464225966608862, 0.5522010435596124, 1.4075446416752353, 0.09301487487361369, 1.4299350327703253, 0.9256175222948022, -0.5813312644031453, 1.797793021149601, 2.6019204735432466, 2.0579777730987803, 2.542078655486373, 0.10500227399492951, 2.5598875207265417, 0.08010889122081079, 2.2314237455538284},
    {2.3571782778844383, -0.6415248561905788, 0.7831926022398679, 0.5665184369138883, -2.032748760959317, -0.027980224521015267, 1.6190548368835418, -0.4948346999556217, 2.369500917430932, 1.126745437147556, 0.894676284453617, 1.0864323673054792, -1.0688838966965386, 1.3321690791723395, 0.03900979452050558, -0.6488760402552507},
    {2.2538660798235792, 0.6455402822914907, -0.7484441446256183, 0.9401046287010806, -1.6752849923787605, 2.8697002197038533, 0.8982282876192482, 1.7625174181738144, 3.129223915845614, 2.1433739540372128, 1.7476588949067746, 1.191478493563956, 0.6331352418641389, 1.2894416953999221, -0.31289478506903906, 2.0809269189106705},
    {2.7864307874526486, 0.781774240129261, 0.027761466054671325, 2.4115895283045643, 0.3944974535554555, 3.3716470540465164, 2.0923988831412434, 0.5639802826871182, 2.56881762063285, 2.5327782904813763, 1.6129703315659412, 1.7741539451641417, -0.2603744465966443, 0.8998748933936134, 0.9473084860089949, 3.3243316803500558}
};

static const float b3[16] = {0.8875617867049275, 0.5358539238464998, -0.3467898201053178, 0.6752744966596851, -0.0149233706280138, 1.1979589963449015, 0.7351063011061881, -0.1973959210626966, 2.0218077515318766, 2.175166996626113, 1.3823435150373848, 1.1404663292376442, -0.1221527605868228, 1.5672508581141358, -0.18970159422717195, 1.3031301692644668};

static const float w4[16][12] = {
    {-0.6926403690629079, -2.8076078728923206, -1.4305712958817391, -0.376783578283968, -0.5660843398012763, -1.7329455955056918, 0.0772619180755353, -1.5184535287488992, -1.391051840523417, -0.180381292086911, -2.1024373596115167, -0.9791356585124612},
    {-0.8065788670757364, 0.683354473403064, 0.6055066515830797, -1.0441399703706682, -1.7324494296729918, -2.6916149757874783, -0.719349396438359, -0.5165625348330333, -0.3993568338129031, -1.1179358150316827, -2.655799586388523, -1.1961901023619348},
    {0.9406883803560459, 0.8229562396912179, -0.019981425667413386, 0.17393324384760167, -0.7550915943769412, 0.4147852659080991, -0.20787813167237595, -0.7685863603299584, -0.1382848412142505, 1.290086468115215, 0.13996317214091555, 0.11798912695760307},
    {-2.225502360288983, -1.5705026864284182, -1.0967817316117436, -0.16407106010240122, 0.23937491717962972, -0.8179286191005999, -2.2091528594073977, -3.626504203930786, 0.07549760811322805, -1.2631212511741068, -2.1233848146171015, -0.83075383860245},
    {0.8389889214540164, -1.3198318888300509, 0.7392799156845683, 2.053288887820978, -0.7967442994003666, -1.3485711595624574, 0.011112955400556781, -1.4149766030946047, -1.5073085226616587, -2.2164206166267086, -0.5953411875272303, 0.43042255905363597},
    {-0.1849685394371238, -0.8603178010835414, -1.0419809167385705, -1.890560287043614, -2.507369343892822, -2.6205476401986827, -0.717346043099876, -1.4541121159079602, -3.589179791370809, -2.3486059673206188, -1.3808474089070188, 0.3282991236087398},
    {-2.6969324663757464, 0.003375770938629052, -0.37865682095224606, -1.538515948672577, -0.5150542547423478, -1.7820988151262522, -0.6940390108759689, -0.5618525106097897, -2.7200064223554934, -1.6931727726488222, -0.2702656845320802, -0.2703958308161024},
    {-0.44721414897161654, 1.7542430673570113, 1.9509726250206192, -1.1808323469207698, 0.35799497145070847, -0.34653146073442426, -0.502288322324492, -0.9212738418433911, 0.3588218706052185, -0.5544781022627813, -0.46542882089345405, 0.8310284640355237},
    {-2.508343579940785, -0.9415051164272622, -1.9029376711826156, -2.0681601892501, -0.7131522739630383, -1.7342330172561322, -1.5038025651405231, -0.7246728930375713, -0.9797586280042643, -0.7644091220365641, -1.0381082827273325, -1.4185422518600905},
    {-1.4084303641217677, -1.034616414387023, -2.39419372346189, -2.254018959182766, -1.472621261446076, -1.7660776295492078, -1.5727787857479203, -0.7959364439471656, -2.2185803231019925, -1.2849037798375915, -1.3360508722733386, -1.047477873899724},
    {-0.29579203861889686, -3.242636666421742, -1.2703734878207356, -2.015211298947795, -1.0398908630726733, -0.2985747443243697, -1.4548399038990323, -2.642220122475648, -0.7839709096529498, -2.3633511962838054, 0.16236743912670398, -2.0304074299880295},
    {-2.3615369446185257, -0.00898059586774377, -0.9798894731476335, 0.0526401317084111, -1.5681486480059985, -0.04240005126430385, 0.23615034589017841, -1.959004827291556, -1.2178191671687664, -1.8159534850983687, -2.747394807493369, -2.3126875463866554},
    {0.08892290435523537, 0.7426280796241556, 1.0318332668115808, 0.17329212536501548, 0.5357702684638426, 0.7478166536222334, 1.0060507265693164, -0.6142880168018804, 1.1494010920212563, -1.125007628878723, 0.9175780076212008, -0.7784091668064336},
    {-0.32056680735204557, -1.6118951075735843, -1.3189969110409554, -1.990250318009775, -2.221629284594588, -1.610448445460211, -2.772923789569606, -1.1097876283775472, -0.020331946358808688, -1.3792874818244028, -0.6766853773887962, -2.6473284389991916},
    {-0.2524999259732266, -0.7829167368514653, 1.611547344503202, -1.1552999494957992, -0.9312340416868116, -0.7649902269929554, 0.4742905226733304, -1.2269200841005274, -1.170716007602237, -0.8784793147886485, 1.0146255689862471, 1.334402631024159},
    {-1.7239615130426924, -2.1123863133547816, -1.5973946793923548, 0.08211237119309146, -2.366963138364172, -0.21121562946855385, -2.478394486941021, -0.5877237594727142, -1.3169916711427094, -0.8014314580541465, -2.2001084923963945, -1.6770504510015356}
};

static const float b4[12] = {-0.8667176167753792, -0.8810586247487593, -0.9053025288605215, -1.153891128324285, -0.7982991870065992, -0.6795996782069313, -0.5690753997445593, -0.6616462092617373, -0.8034270398864539, -0.8730208176674777, -0.9177941536839531, -1.023622227863813};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
