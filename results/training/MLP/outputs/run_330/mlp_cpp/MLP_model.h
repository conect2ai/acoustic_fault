#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.41454706689449244, 0.4227713833873343, -0.20534988210698493, 0.7924582919072362, -0.20216195723185063, 0.6443854082511326, 0.43576958854589193, -0.4750472606984728, -0.4318747351556837, -0.3902629912362448, 0.6444993697666628, 0.1515145012825995, 0.8956184221616208, 0.533299903920368, 0.06478750792422329, 0.70246586778504, 0.43062662648918315, -0.10632978633042822, -0.11721417693842968, 0.02924036452770654, 0.7244454373640251, 0.20735282876327843, -0.4486507944390106, -0.24635115021749165, -0.6146795251494813, 0.38055898078697054, -0.32067403918840715, -0.42034800513428716, 0.3229655069802827, -0.21649158453504136, 0.048965476739874246, -0.09826138089806104, -0.30460077660847906, 0.3423876491105317, 0.1571591835241418, -0.6973435748150647, 0.2597112809434029, 0.6353541532008052, -0.17983524485348665, 0.8154207523577368, 0.47184992452024294, -0.020737111132749925, 0.2732457737179888, -0.4645138194737056, 0.4911536724978634, -0.11419835792617096, -0.32690168762789495, -0.06151382943046013, 0.19856333442650412, -0.40821473252470614, 0.9677329375118138, 0.7027639238056299, -0.551980741837107, 0.535701154718077, 0.6940432207617031, 0.16371600402762185, -0.5538824543182359, 0.09142295244575925, 0.43869356080207805, -0.5532635709549286, -0.32744822389570793, -0.15928838662446443, 0.07420565412032894, -0.33727049835776124},
    {-0.23711819843693277, -0.056706978748021546, -0.5072547268001388, 0.9590246925579228, -0.46739741987904343, 0.697044862569927, 0.38548504105324877, -0.962631707629872, -0.5075294168723966, -0.5916957612712671, 0.5677014363082586, -0.258892271117145, 0.819220478681031, 0.8127483107214061, -0.600952071280429, 0.6948821420652018, 0.4445239561533475, -0.47136485988671933, -0.3686216805191575, -0.08192324600646603, 0.11447191921154098, -0.45508224499361827, -0.5867696624613862, -0.3832378770204839, -0.5551854040586984, -0.2971567169597052, -0.478800830893529, -0.5992222761548737, -0.6546947652725853, -0.6830185106310578, -0.6320178380570464, -0.22584883980422543, 0.23531635582614505, 0.2018466486665665, 0.12400830354852346, -0.8685668437445789, -0.6560715290187795, 0.4357381485849504, -0.4600679052535971, 0.8798044644462368, 0.75159396080617, -0.3422684443113438, 0.1111637400900358, -0.38564797579751386, -0.07027769593392594, -0.7023905902411743, -0.5513358950051103, -0.393611533668574, -0.6731346635435699, -0.32039700642614694, 0.48372585494113596, 0.6440153135202247, -0.8506267426645729, 0.8628506255739035, 0.6093429601264776, 0.23672060019060034, -0.8217955965043169, 0.251140957215234, 0.04253298934453664, -0.8391505462817203, -0.3911064010442551, -0.5808887765373288, -0.36158809565832334, -0.58816446730849},
    {0.09570678898675725, -0.2567124207648782, -0.7819365923541304, 0.5806867024983384, -0.7528067560837527, 1.180404116370307, 0.23735333259290783, -0.5392657862163626, -0.6982759655206511, -0.45980993432909417, 0.8525633645348577, -0.23322145872657024, 0.7248541716745365, 0.42306717959623047, -0.4666859621428191, 0.8321154226856246, 0.4647252327370261, -0.5963822362563779, -0.4302946720400235, -0.2242282071880171, 0.6051394408272028, -0.4172471111693852, -0.6437228942174753, -0.3814643934333634, -0.7070429336620375, 0.051393865732283175, -0.30802471168299006, -0.7136301526055112, -0.8252089871768609, -0.5342924868563828, -0.6795535294251928, -0.2771786933699023, 0.13036073353260902, -0.17084013918668428, -0.025253019735396797, -0.7665389755572264, -0.3856302234503002, 0.21991858558467564, -0.5300017339331367, 0.7918369773417396, 0.8592159234307167, -0.3927525491564114, -0.2651034235030536, -0.5207270136253148, -0.022495295443806643, -0.30893504602590965, -0.33403977582650013, -0.15773398669284172, -0.3119356624171153, -0.3108055640461491, 0.6739236936048586, 0.6533572022009746, -0.5101911625526108, 0.5731185781150122, 0.7925330642524413, 0.369394759178699, -0.707543231601056, -0.16058113601541457, -0.3337272400237394, -0.4317528076253871, -0.36631872329700194, -0.45927448376240776, -0.24060290273064938, -0.22178169092245142},
    {-0.5280501079202512, -0.6301667471227838, -0.6652020804982214, 0.6475573751205335, -0.5974000679541905, 0.551210552594269, 0.1364737939106439, -0.6881590986213159, -0.5879886184604782, -0.6887333651720206, 0.8891393193550242, -0.6222478029459013, 0.6955306858099659, 0.34503210672126533, -0.6037596497402883, 0.5374544284825811, 0.31476776440597964, -0.37879905706077843, -0.576642145485294, -0.36690825404395677, 0.057813072934738245, -0.5204274694371864, -0.8633723268676796, -0.8199364139285914, -0.764308791595647, -0.37351567916510237, -0.7431555887333786, -0.7779365944451735, -0.5186430501284011, -0.593214371058642, -0.7806675904331493, -0.691464365498309, -0.14677295337688806, -0.31591155000919124, -0.5477108611099568, -0.8885715106153339, -0.31551895380050354, 0.23700741474370418, -0.7817277701841971, 0.8625560012848507, 0.8838859683436348, -0.7061462264665271, -0.2992322878433484, -0.945213037528793, -0.2106995072255916, -0.5505360224660629, -0.5067150922044351, -0.48870248377406944, -0.5363075471296502, -0.832189497102587, 0.803490232356203, 0.6604251742781073, -0.7612963280443195, 0.5393972503923311, 0.7841565791051521, 0.6674962706599351, -0.7686310127063778, -0.14911877523186398, -0.5776383034755687, -0.9055034059063501, -0.9127534495230458, -0.6424790232864542, -0.7533063826976829, -0.512662428786432},
    {-0.34288078425927815, -0.4373980738208355, -0.7754142643099555, 0.880263240425552, -0.8283534915882966, 0.6081744148853282, -0.04097473924801932, -0.7768734579369283, -0.9463754340333012, -0.6662544915676535, 0.7089516689222387, -0.6255720540264925, 0.6134405109332481, 0.6624714329744943, -0.5471943425765344, 0.6132282294432417, 0.147052806724791, -0.8073292075847784, -0.8226113667729936, -0.5516453019909425, 0.7082599651342518, -0.4092721542366261, -0.6815966313969108, -0.6369848058824354, -0.6159990393970125, -0.14222492782627202, -0.6706401792541236, -0.8032169544406139, -0.8332009189960106, -0.7001672483220949, -0.5308193763445586, -0.3728325476057097, 0.029993869008263695, -0.21198430883354158, -0.5878370352149286, -0.8172816692236627, -0.3396405915464401, 0.20431778571999565, -0.6358050838010402, 0.8705097045127784, 0.8548658010845611, -0.8777837261404544, -0.2955684322049796, -0.4922792507392765, -0.6629821538128702, -0.41962195737737057, -0.4987908611831026, -0.8485451173275724, -0.5311155554043876, -0.7008668283794728, 0.3036705753849479, 0.48246872513269107, -0.8780910745242905, 0.6019654132944454, 0.4490088442562113, 0.44991890991476324, -0.8519750163908714, -0.27140289253927674, -0.5933385987708589, -0.6774272997514912, -0.5429707670001174, -0.6083875945776549, -0.7020850591808019, -0.651710371517569},
    {-0.6707588860560321, -0.9337782617564299, -0.5037766708862245, 0.8465140879863142, -0.8825472268916309, 0.5411817130516964, -0.24417840270220445, -0.7088196077534035, -0.5840993870312423, -0.8181658688507746, 0.43936246862936745, -0.8432836044360603, 0.681815224716628, 0.4498833884581015, -0.5535805298431238, 0.35382192348866165, 0.4120366507383769, -0.6270779682577883, -0.9148271278124729, -0.4702966000871562, 0.4339458845232863, -1.0080082978280416, -0.5337927694591202, -0.6497471452436018, -0.7608387623813162, 0.04790312677397742, -0.6536511072123296, -0.830483239740925, -0.8712177439345044, -0.6521054126302314, -0.6829023009987268, -0.34960681090977197, 0.27031320304767875, -0.33027981406199197, -0.6531963756620107, -0.9648519377341769, -0.4897787935771461, -0.16107766865912093, -0.6531835727940036, 0.5689323971268544, 0.6154333774043632, -0.7487658643937998, -0.18186757169636988, -0.8095825434807723, -0.3772016480113642, -0.5231634670379839, -0.6305661921381694, -0.4663264467792076, -0.5332875613129102, -0.7935750869184829, 0.306431430168893, 0.4490431548063318, -0.6904417608340644, 0.5007207763846224, 0.6463973534553799, 0.22325990740610543, -0.4751433391814709, -0.12974864033675224, -0.37555713225537346, -0.4775645161570559, -0.7579253299185793, -0.6600559099162034, -0.8202730031378032, -0.8011525416102194},
    {-0.42451479715305906, -0.636594910696234, -0.5577885099219382, 0.7306738655322831, -0.625701582489798, 0.6610877039090055, -0.2107518804235077, -0.4846278572116054, -0.5261267465850183, -0.8647573245199827, 0.38164606772605764, -0.5513111074663403, 0.5294709193634011, 0.4901939219349219, -0.7675015581774994, 0.61090583648501, 0.15001846126610194, -0.9645078141499768, -0.752991117945504, -0.6951056931546205, 0.2863371174578459, -0.7163756154357881, -0.5777058406776294, -0.5582413605391793, -0.8711944751122767, -0.25829133587647973, -0.7300587184872809, -0.6557732336109522, -0.7859348715568467, -0.5862823308020231, -0.6461929831903241, -0.3333368792289314, 0.07627942122269789, -0.543394542933912, -0.5612353288008436, -0.6559472040893904, -0.7835664302458463, -0.03309889669274397, -0.6257312550074824, 0.5103242251747504, 0.5834388062029405, -0.6961571137372026, -0.40036669377868883, -0.4423493077924873, -0.3723110490723435, -0.7151039412693154, -0.3779183340910702, -0.6525379092907129, -0.6420140734906254, -0.3968461458529635, 0.4859181987813757, 0.6226493016883234, -0.6817286617798028, 0.5465492640052234, 0.3223434211844248, 0.4236671269493217, -0.6377698455746492, -0.5131973944145095, -0.7661578368828357, -0.4099679028661824, -0.812652196417305, -0.2905199318544776, -0.7560003208641747, -0.4918250740836883},
    {-0.18067552441785292, -0.4704488596016646, -0.6275634596791908, 0.7703386765287913, -0.7654704882537965, 0.6813499565568317, -0.2450823504127546, -0.6619128028333773, -0.7621447429175073, -0.715852248795147, 0.5185181614430296, -0.7034003658093502, 0.7541448496082285, 0.5626096351212001, -0.6791032580865878, 0.4519206546746118, 0.15678062922270797, -0.7501458936125844, -0.5841388481512142, -0.5322125082943793, 0.22826846494478029, -0.6304835507082147, -0.8015699587110309, -0.4903854664150494, -0.6017542397542991, -0.20992997418545237, -0.6046790239349707, -0.8467403663828957, -0.9462042736684914, -0.7929980528467804, -0.5947281713332254, -0.5998475710172096, -0.2767817014079473, -0.3116817248797269, -0.5130436904825321, -0.7852791954887308, -0.7582260854260384, -0.2957044413240142, -0.5886639272393107, 0.9499691100150356, 0.9967167202686094, -0.621266592009528, -0.28098932992971964, -1.1598473235769642, -0.18970298403709115, -0.6969503583806091, -0.6145099548607511, -0.7872624475374269, -0.652568991840786, -0.6137114389065653, 0.5361100831860233, 0.5189352989722957, -0.8017661977547142, 0.6909840625972014, 0.35870464308530803, 0.4394041756738196, -0.7196203270046289, -0.31137531149476244, -0.9814100121721937, -0.667620527898726, -0.6884674412818826, -0.9087980759118693, -0.9536038030292092, -0.6214786006509715},
    {-0.5696670988406486, -0.9785572907976509, -0.7809842350533385, 0.7279843027300963, -0.6303074216706981, 0.28835360777616575, -0.2978385964391948, -0.7968376575573596, -0.6240775279389095, -0.7735200161009509, 0.6870967518505543, -0.7628891822164227, 0.37113491402113163, 0.5719756858597671, -0.6584875741282195, 0.37034393929100773, 0.27433548442916655, -0.827732594782285, -0.7516628856189661, -0.5270962196503901, 0.5790545321204021, -1.0729633266356162, -0.48099072316100133, -0.7682784017598235, -0.7687814953020002, 0.09090744078889239, -0.7353954026545831, -0.9439229612425524, -0.46934906617433414, -0.5110548910687954, -0.8750650315979126, -0.5467800770763915, 0.07057048455876591, -0.405590676619502, -0.3874576717944304, -0.8706388605708316, -0.798664963642104, -0.26044379990989275, -0.6331567028960499, 0.5751678480829656, 0.5670863625577589, -0.8333550651654447, -0.24217323319183112, -0.8167257486741194, -0.167628478236306, -0.7023496163920343, -0.7139016838384405, -0.4179143041234323, -0.6453351947289135, -0.8369071663112029, 0.37679361118446264, 0.4283550979109684, -0.7319721226890694, 0.47347969014960384, 0.43042952169297755, 0.4628063651338776, -0.6260921398960755, -0.24204759641522894, -0.5516188465140054, -0.9339387251692977, -0.7097604537100902, -0.518229585271822, -0.5717792053925793, -0.8448647781542088},
    {-0.6661819707420387, -0.45465930968164714, -0.6320574205878745, 0.6754239996898056, -0.6838456107759977, 0.4506614926023618, -0.24372034102128004, -0.7912139513909892, -0.7084896217705922, -0.6971405733231386, 0.5120908061395073, -0.5515128004551278, 0.7355968395905751, 0.33600157567694117, -0.4713912726794093, 0.4332343333817208, 0.19701457856818183, -0.7147541633753967, -0.6379179629528144, -0.5419416045139923, 0.06556030918097368, -0.5672508642201758, -0.6986945914698259, -0.6860914814336325, -0.8425459258705772, -0.27016238666505415, -0.6868298567363503, -0.6802130259437073, -0.8627700672396074, -0.5658140368281206, -0.6523593595420041, -0.6761657367660124, -0.11821846655791411, -0.250695391563468, -0.5441003816497801, -0.7510695585195093, -0.463994394402242, 0.04425945311143991, -0.5762747757228214, 0.8829469763330576, 0.769281830366735, -0.6385695585711393, -0.20264960733049314, -0.716539849104614, -0.07891734907302636, -0.7092728289456043, -0.8388296951221317, -0.29668593527796727, -0.6035481902932679, -0.8063869917165574, 0.3269132930644685, 0.5179066701334011, -0.6619630663600895, 0.7352219175318773, 0.31151115172131966, 0.20385558301190687, -0.7911611626996233, -0.2749633214263229, -0.7490770891694061, -0.7042156052829077, -0.5941902103521131, -0.6956368071936044, -0.612114456628203, -0.8187603099492141},
    {-0.5267618349308089, -0.4226183503159399, -0.6095719541934651, 0.3040016968479059, -0.908608574544509, 0.2603652040435663, -0.1947954869543303, -0.8828620221673287, -0.8655285894981953, -0.6371548622696395, 0.5912834854737402, -0.3732281356925904, 0.23183772648309317, 0.20099628385815388, -0.6465963943184796, 0.15206087661089046, 0.3184180121098974, -0.5037876838561924, -0.6991126423605085, -0.596233701020999, 0.07359571849983397, -0.6918084958059455, -0.6107939380695471, -0.7678285490340938, -0.5908074989860501, -0.3861696824002826, -0.5705867371812523, -0.8050133561604799, -0.6667419505859548, -0.7375194121621768, -0.632816888046857, -0.655191947831915, -0.057430717692637794, -0.12017758110282958, -0.4460004123928509, -0.9558036749608175, -0.5580411087365486, 0.20315319633751303, -0.5973506321426868, 0.7881396459230637, 0.7442502430163307, -0.6848673018667616, -0.33048814207275057, -0.6622246063866686, -0.3832603384484912, -0.7089468056246139, -0.5607127736699589, -0.37370157562433537, -0.4785661276701732, -0.7672581764776706, 0.055883209082629774, 0.20274060478916048, -0.9668497245462081, 0.40782355497018874, 0.24496848215412007, 0.34742375388939095, -0.6145930970168514, -0.5885255994505568, -0.6400838753853997, -0.6712651854469966, -0.7321121684290844, -0.4873135544783695, -0.7113100965921534, -0.6845965251898041},
    {-0.730225369921193, -0.7716566158363609, -0.6005704213709414, 0.4257791154787442, -0.8391824831244173, 0.32821675821652374, -0.27789891397264327, -0.826333963711125, -0.7460625600657408, -0.36105608801031946, 0.5329861501489711, -0.49835641050777885, 0.20490752118694505, 0.37956938772084775, -0.5251200092513746, 0.30707841764719224, 0.2106526235417248, -0.6420302203595435, -0.5822966629409588, -0.6062950232580208, 0.3638621870879509, -1.022936367157781, -0.7560618520831778, -0.587533664382667, -0.4299558568600246, -0.19521198404593867, -0.6251145621016564, -0.657965612619914, -0.6520848758936927, -0.6427042739602795, -0.5509473996465922, -0.6388078589966163, -0.18840380672633317, -0.42335781064199296, -0.4980663288084912, -0.7227903435455474, -0.6146091398076129, 0.005199669886243615, -0.7121459138279516, 0.32551351171903237, 0.5146982272202733, -0.6126823875550849, -0.4348435827731417, -0.5434239278509344, -0.4836879129702387, -0.5091109715318896, -0.6386529584189432, -0.8989810132666847, -0.7103245912770784, -0.5508233541927593, 0.3601479833983829, 0.29974754129229264, -0.5626624385788866, 0.24564226259984182, 0.030507727026188012, 0.1367672071342623, -0.736135636527994, -0.6080477628073251, -0.7947254666100051, -0.6833665213831569, -0.41638897733064656, -0.5595184526571477, -0.7840690201905736, -0.7905952126952129},
    {-0.34468482684526924, -0.4231246199767765, -0.48247064460064587, 0.5103273083131229, -0.8595191312311928, 0.10895528820234053, -0.05767849041714666, -0.9001858331093113, -0.7606797438672117, -0.8941822913788019, 0.6884093923546164, -0.42777767720282944, 0.6610231063138446, 0.6199682915293404, -0.4951398302774819, 0.2798583338463263, 0.3985803619115598, -0.5205351682257973, -0.5303161738376101, -0.5994332437311448, 0.5354787339604768, -0.7088401572138577, -0.7673458885137397, -0.4983596958423277, -0.494998769372856, -0.37047689450095533, -0.8560818598795132, -0.8755754903541485, -0.5844730852793351, -0.6741760930485623, -0.6678360117949288, -0.48532177240565155, 0.10650517292595706, -0.48874400990758665, -0.5967482027446108, -0.927612175636982, -0.46688831876742437, -0.005336552464498956, -0.7602479985194108, 0.6771019924607045, 0.6941397704390057, -0.6699739769815415, -0.3041941781515731, -0.8286050703614811, -0.5775775152248276, -0.7858547463281843, -0.8354406927287186, -0.6070837671640437, -0.5617571962902768, -0.5649117961385641, 0.13153654558702615, 0.42476721744980556, -1.0922817813971633, 0.3435507856340488, 0.3987537728177857, 0.22250906958325326, -0.4012411693051682, -0.2446276939474939, -0.7100307347384437, -0.7205543467952255, -0.6410205571800716, -0.5039837063322433, -0.5221565627886422, -0.6433348684429876},
    {-0.3537847144649274, -0.69043032765806, -0.5935123191479933, 0.5046549181694373, -0.772701825923649, 0.45756697892128245, -0.17735750104874393, -0.6650530085616047, -0.3777506261038181, -0.48746850834258826, 0.6813802045238383, -0.6334388330246062, 0.3589202286031448, 0.37887765953988845, -0.8978278983027106, 0.20309550391264397, 0.2941104921118613, -0.5559334101016119, -0.538461098642712, -0.8139770443412035, 0.2806073707907174, -0.7093571413004636, -0.6798241936442374, -0.8360189387870555, -0.7808572086263463, -0.1729204522099131, -0.7125337528592489, -0.7215302643595892, -0.7978490041630373, -0.4726740763027905, -0.9636654018601021, -0.39010225163467815, -0.10815818357462015, -0.7977792258718687, -0.5089413490973805, -0.6885785050432212, -0.41130352878609455, -0.1018384802866342, -0.6379398045713051, 0.4362405431684113, 0.7085920926783121, -0.8536998354449498, -0.6489853315970241, -0.68285512774325, -0.19726995995286659, -0.7022928827867122, -0.7455997200789404, -0.7920589908555976, -0.3164077812621523, -0.875896608382767, 0.30277580405181037, 0.41239827122582695, -0.6846836154133887, 0.35688002730844176, 0.24797889352330654, 0.17717264720125947, -0.8328828809653671, -0.5011182923282899, -0.647729205443438, -0.6457522357959521, -0.8689249625645891, -0.7133068793929178, -0.5787502415259789, -0.7636548032031752},
    {-0.2552153403975767, -0.3652094615916511, -0.5826559177560157, 0.7319758004287094, -0.5997661795103019, 0.554690317527206, 0.03150964056550913, -0.7325915650764335, -0.48810430644779695, -0.6187440348607692, 0.5186979789460774, -0.6818684788500899, 0.39725731926351504, 0.3920171319581365, -0.8459109153426716, 0.6950488261814924, 0.5288963649614289, -0.7413024013173148, -0.5862325352031605, -0.6385868933992659, 0.3766011889620544, -0.6515744612164508, -0.5404098935746044, -0.5837707960088586, -0.6138737625585735, -0.09302343143157972, -0.6839543170450285, -0.729363636392919, -0.7558368999297667, -0.7354241527757236, -0.9393482791897624, -0.34324686581153935, -0.06407537429173388, 0.08378099464669245, -0.6836765359481701, -0.6962292751475484, -0.5684774065819038, -0.22769061102816487, -0.48003062158259674, 0.9619927949917925, 0.6191859236724748, -0.6833547562765152, -0.3497347491721019, -0.3760062598641909, -0.10340531875293335, -0.6392179169161104, -0.7332292756497594, -0.5876845026319105, -0.6655327989736664, -0.7871345843679887, 0.5427906510138005, 0.33985136930242166, -0.8833184284813768, 0.501574587297303, 0.33567084466163366, 0.44385203663483364, -0.5414202763351373, -0.3798291591222319, -0.3602903589162053, -1.053106594874495, -0.626040814718876, -0.5526959345777597, -0.5962864108400362, -0.5891286811594263},
    {-0.09792303799707193, -0.3583370027690531, -0.443040062283239, 0.7357113270509335, -0.6206022292407183, 0.5892475269564768, 0.02305921660427279, -0.562040423378834, -0.5616767279948838, -0.655328746735118, 0.578667188092418, -0.6851270105040793, 0.7220184517425535, 0.6706573302235745, -0.4957279363626717, 0.788786374269135, 0.47865085691391623, -0.46357440807728467, -0.485352482118467, -0.5060501623099436, 0.046291719441923306, -0.9162872248678323, -0.6772213465592799, -0.419830289747775, -0.790570239675423, 0.030822236101811177, -0.7451920035605539, -0.49950313460246504, -0.9148950799837793, -0.5223066169889483, -0.82223816593716, -0.47219485766715563, 0.11430701453353928, -0.11064896235246212, -0.5116300491907364, -0.7104066561099478, -0.4794248639872798, -0.20609852743131765, -0.6800930946463553, 0.930251775266755, 0.940850696792152, -0.7408198337762628, -0.3214795772176142, -0.5503586670765647, -0.17406988624706024, -0.7087643224371213, -0.8154448574944514, -0.7050679545566082, -0.5116188311923082, -0.565208645206507, 0.3790096229296845, 0.5165625650537463, -0.7223114745063862, 0.38202623547052755, 0.5635366925390913, 0.46825753020709776, -0.6103381757949292, -0.2991356356132343, -0.6665863251450177, -0.5174327353103558, -0.7472189333713006, -0.7183720374112234, -0.7002986760387919, -0.6553300077429525},
    {-0.33767488293527337, -0.6413529469225223, -0.7588263450863482, 0.605342135982105, -0.8026649164419456, 0.42153138358003023, 0.10678585062172344, -0.740057914716655, -0.6694739466071773, -0.6795454737322846, 0.652081101819883, -0.33692187733809503, 0.7617402462681151, 0.6738712910131658, -0.4700785745296154, 0.6965237249928614, 0.13399112082460163, -0.6330091633937632, -0.6012406320365519, -0.5437193415603682, 0.6400108864787678, -0.5516023230418271, -0.5138431987273884, -0.5934677495434312, -0.8332093243214924, -0.18800218279138545, -0.8770491933472098, -0.7159734346827594, -0.6661381104999767, -0.6962925974404142, -0.6082856783935904, -0.3144301850688571, 0.26056703709771734, -0.0395759972076154, -0.5209270755676845, -0.6776730182653091, -0.6129781626262432, -0.05920834008483699, -0.5289878108593463, 0.9090794317713382, 1.0332764507434637, -0.6420913586436212, -0.21800438663629354, -0.6857198680697808, -0.07414802755727291, -0.810923746518211, -0.7000939427931512, -0.7426712833575025, -0.4927309906429753, -0.532550585269436, 0.6040167210341228, 0.7661303781268972, -0.6982593557648753, 0.5788017080497201, 0.5907255545674241, 0.5373255601569703, -0.7409824739979192, -0.40381005986322543, -0.43299882826813507, -0.7666970195179008, -0.7149073684350876, -0.795709137688366, -0.6943209342150832, -0.6943533151902918},
    {-0.2675130902894345, -0.43203506244764256, -0.5387033673281906, 0.70814544680722, -0.811239286975155, 0.7173976850684256, 0.2301361443346408, -0.7838537593060704, -0.7351103104040078, -0.44700447087114614, 0.8345465647168172, -0.5767789952322486, 0.7795532630477336, 0.5866560731452726, -0.49820012817950654, 1.0266462725809267, 0.331399975475588, -0.5869843142077766, -0.4336452512023463, 0.08167734461021939, 0.5839481760462395, -0.5479012187657888, -0.4489844006544716, -0.5969608150221236, -0.8173718376652157, 0.1382605941549155, -0.5776478201709523, -0.3900289267074721, -0.573019726134206, -0.6484549291536001, -0.7429833478489714, -0.1406552183932652, 0.2626433370672455, 0.020205350675753953, -0.4603975547469783, -0.7594452351795101, -0.19470277445835385, 0.3518622088099935, -0.5840141493002149, 0.8725546531851592, 0.9575799625607507, -0.4603734136969366, -0.26143374744733716, -0.5887274182593262, 0.05880409281585982, -0.6299448059836782, -0.4248421085967816, -0.6653510393511902, -0.45575216454987844, -0.5509910115576779, 0.5472332480331843, 0.6896181583178517, -0.8657785952675762, 0.34925624429113106, 0.8116287344617972, 0.715048391509177, -0.6764191682164487, -0.19769294464002699, -0.2500895737313643, -0.6573510210156388, -0.6785383901641856, -0.4536099672047412, -0.5032498021875993, -0.6388006982481841},
    {-0.24582110461385398, -0.2656614595896665, -0.6191348030419489, 0.5078594283971992, -0.636154157454236, 0.6900226163465468, 0.12580690568834918, -0.5134705300141706, -0.5043858782666266, -0.6935893707771785, 0.6272215368640808, -0.24348090197503378, 0.7147256838192151, 0.7780768474485817, -0.4137239712446023, 0.7308737295890342, 0.44052537622168914, -0.4501152667878185, -0.49795895805019114, -0.3564693953163678, 0.47298930211738466, -0.7062961901371876, -0.4215520931950595, -0.463018188785709, -0.6655394027169705, 0.26367773381475157, -0.4513862308404826, -0.5705631633610525, -0.5399716335815128, -0.7785971021771962, -0.5215551732787173, -0.11774584499995795, 0.3440454441947797, -0.19906455050170274, -0.4419525157013169, -0.6584034765451934, -0.04078682398317644, 0.3129115796271502, -0.6188199518911598, 0.9167932207550038, 0.6592375751105883, -0.5609169730241697, -0.42387365943779703, -0.4268739741461741, -0.36872000845345265, -0.5395739230677731, -0.5044789647157822, -0.5303195151522215, -0.4623761582195035, -0.5646667627234688, 0.5849136516186983, 0.8951824553087087, -0.6413305424007041, 0.6388456460520476, 0.4803300629814143, 0.6021815692321646, -0.5113551199249438, -0.22627051485004232, -0.6586151436480404, -0.3255324230488056, -0.6543861134840054, -0.6008688445707662, -0.22636337212395558, -0.6884292016741141},
    {-0.13822850057113692, -0.576933655011492, -0.4917671792370807, 0.7005297207585178, -0.5808519563342724, 0.7030079256453913, 0.30484184331427605, -0.5903765025946233, -0.7690555446561329, -0.43104382766498617, 0.754530780618531, -0.515189704987867, 0.8683567488752679, 0.5245718360299608, -0.8029729658641592, 0.6179082301809717, 0.3502936864071024, -0.30516653596720467, -0.6697562518080169, -0.5489108120875347, 0.6313665866502569, -0.5862812113335233, -0.6617871554967576, -0.8506318765393567, -0.52637792026508, 0.20404370331093472, -0.3075085594091097, -1.000230021001773, -0.5833480243587185, -0.8540336496667017, -0.6049520548358116, -0.45275932438138783, 0.008904871558861497, -0.217506795360111, -0.40858799342046837, -0.6961984028008407, -0.28345961770309525, 0.2157969658084585, -0.7120130729196205, 0.482330976078127, 0.9912173323988042, -0.7236622049215125, -0.5395982024815499, -0.8375037495040749, -0.38263690422055496, -0.5570773607602887, -0.661388763687978, -0.7572434652337607, -0.25575312192038097, -0.5645271936836248, 0.2613061036409201, 0.49843363793939455, -0.7519000359894877, 0.5311650515770444, 0.6690778096921124, 0.5584150207009403, -0.5902768989208076, -0.3283343038273726, -0.21032676315746626, -0.9042790298931549, -0.7136973461531465, -0.7799644611067715, -0.4363237892691268, -0.7068558471120601},
    {-0.5685861874493965, -0.6896238216960133, -0.5510337460097863, 0.49028880434151567, -0.4830419714942349, 0.6719889453634316, 0.12195886479563561, -0.7529895488313695, -0.6456650977667511, -0.8417617180852586, 0.6087924760594747, -0.656681441728865, 0.5945391227672578, 0.6871245602813284, -0.7467158863568749, 0.6731892132007656, 0.20835495920200517, -0.4682904564627184, -0.45813257431288124, -0.4250264527731083, 0.06926296249282267, -0.5364881265553392, -0.8798674984764016, -0.6142523522547342, -0.6684308938177985, -0.16930771965438324, -0.49765552479622066, -0.7857110137523158, -0.8157703720887062, -0.42500745550009417, -0.7610191205010711, -0.43210949635265666, 0.0749376693850781, -0.28773651985466164, -0.6901729778344442, -0.7699732427659278, -0.44587857597754277, 0.08522181928278813, -0.4695141408822413, 0.7954233934519981, 0.8567951487110547, -0.7977092513498076, -0.27553306717354464, -0.7789519183034143, -0.30613735813765425, -0.589806427195428, -0.5137851404605219, -0.4733338352242996, -0.6338424151072041, -0.6031615470046443, 0.31772041870731443, 0.5279375234833809, -0.8404707731438306, 0.5272337642655135, 0.5289366401455984, 0.5519555363661403, -0.9175187539664662, -0.6294512094601558, -0.3402078574641835, -0.7414616629138414, -0.5629139345316932, -0.6048382179654574, -0.4068191268131754, -0.7950904300503234},
    {-0.2574674178534029, -0.29498561594697903, -0.5336442909476582, 0.6146680306010925, -0.6682339619666446, 0.8559360290362209, 0.17963022586373933, -0.6227030668462324, -0.7920855987570155, -0.35769250035085526, 0.7649893039259574, -0.13961055270910308, 0.7306694408107871, 0.6264683182330002, -0.6256583982429584, 0.7043613824451341, 0.45371807358011074, -0.25144746569265697, -0.46051944066239725, 0.09761845077959622, 0.4633723607995698, -0.49537116782533963, -0.4353277077671542, -0.43013409931669805, -0.7048049519739568, -0.08319873942059827, -0.635408081586339, -0.6326582812847038, -0.2848746962072909, -0.8074842256087674, -0.3862011547617055, -0.49762733049402225, 0.16728714754683988, -0.03520158222370064, -0.5931585817397143, -0.810098302227807, -0.00216344091001102, 0.26997445623038774, -0.526629111803333, 0.867913042905989, 0.679861316431317, -0.47015133559223554, -0.3130325459597045, -0.2988362484818754, -0.020401228978617514, -0.7191385441429714, -0.7834179010434315, -0.4982359827521423, -0.5180827635564978, -0.6715651728908748, 0.6481155931556026, 0.6767828589400804, -0.6822551284351474, 0.7849010164967442, 0.5751828690417713, 0.8380668136416802, -0.730304545189505, -0.3260706906853889, -0.4758857202678301, -0.6173159635519533, -0.5218253233634498, -0.7838969123834794, -0.392729173859972, -0.7443045728418872},
    {-0.19825549733410125, 0.07750031569796237, -0.7913177205204653, 0.3824438560573212, -0.6683328089210717, 0.768082334646031, 0.34426250851714973, -0.346357735731483, -0.3906728752277104, -0.40453519567617446, 0.953859871979728, -0.08283302256641922, 0.7809387532864279, 0.6069973886323147, -0.3616360421574675, 0.8712826450533224, 0.6613000448961613, -0.3538247764593854, -0.4165907027615535, -0.09621012483608417, 0.5678372786994661, -0.31915568808544137, -0.5161470881188335, -0.39941348114713904, -0.6781697757749732, 0.16962421514967865, -0.48353923251575076, -0.4701659887335833, -0.42170197515888397, -0.47038244080443287, -0.41407787934500356, -0.04986987278221377, 0.2171467403080051, 0.03431913661452039, -0.15736389576214718, -0.4190751056241952, -0.05221220487045089, 0.6075042739003085, -0.2960632940970718, 0.8445428540801094, 1.060719601180387, -0.6016428113945108, -0.06024896624494855, -0.5047045179899702, 0.20780709910368123, -0.4852494158251056, -0.5731228995407683, -0.26045436590639764, -0.4156778216623525, -0.34861852792749276, 0.5620929733568267, 0.699875978443667, -0.7260042892171732, 0.6512726380245206, 0.8944012854645135, 0.6441495629113104, -0.628774831813925, -0.03009162965705366, -0.35628192425011235, -0.7495363961392144, -0.46232163972306833, -0.7293023030998849, -0.4721542612656069, -0.18776046429633886},
    {-0.45858181570016787, -0.21939845967848562, -0.38561445392129373, 0.5057866500450551, -0.7508893945920024, 0.6808995063491009, 0.3787538272481788, -0.7527760146697273, -0.43477440085549474, -0.4478528080449104, 0.9166113207095324, -0.3476663237152713, 0.7602623557211264, 0.8810422140935561, -0.6267600801814581, 0.7127849691071901, 0.6050639329926423, -0.39311394645080633, -0.5470694085610007, -0.4604447986082585, 0.6863391549399293, -0.4470462852299819, -0.8403402768409725, -0.4506373393508138, -0.5465159784828195, -0.11966539655573905, -0.446894826060321, -0.7291204997811948, -0.4669281660189086, -0.7275769057747898, -0.6760824972849799, -0.394565321256852, 0.23169422792405772, -0.12886341085103659, -0.27168700627931663, -0.7239185004650417, -0.25644336891872505, 0.278072907836513, -0.6973516284773786, 0.8956275793888384, 0.5573184625756031, -0.3637146564656113, -0.23640139630287188, -0.8094212851534719, 0.024411631269624416, -0.5694565946245507, -0.48864918583684264, -0.4677557426249996, -0.47217629108621484, -0.6170584755792515, 0.5030878393692795, 0.4956528871301215, -0.6072745052784312, 0.6131850807902357, 0.8277992903994918, 0.8153931447357813, -0.6482555013594553, -0.1513745940646019, -0.5454946664664599, -0.819963220843752, -0.525253518650584, -0.4194077461888948, -0.2778380750276239, -0.6498609847087924},
    {-0.4461563874534827, -0.43094321571247407, -0.6444112981929848, 0.8124626252425682, -0.707425435071123, 0.6992178771551603, 0.23766885407155366, -0.6743587085971589, -0.6426742022280794, -0.6730911507975542, 1.093886280252, -0.379280099588998, 0.836859580406586, 0.6698928955151702, -0.7545229426922792, 0.5900583097629454, 0.4184402417648656, -0.4573928486153877, -0.40850745011104345, -0.4619945370578875, 0.38982558665399586, -0.3976530296285183, -0.5252078139983775, -0.6266665640044696, -0.6420148250863952, -0.22890197010181643, -0.7881450506079902, -0.7519665709487106, -0.5239102540806841, -0.8032959487507069, -0.5064572051220021, -0.37450722148641424, 0.17300048496252887, -0.16077501893835394, -0.4017211872704604, -0.6348073049126874, -0.47851089422830456, 0.1231439295633501, -0.4153873968765092, 0.7633293684426643, 0.8475755882567829, -0.5794844205095558, -0.2589273359385349, -0.8902503463994841, -0.3065364290292955, -0.5634040652938545, -0.6705025131679375, -0.41499692060145205, -0.5243861773278161, -0.5694251379084274, 0.3417693408307529, 0.7769516937716462, -0.7603493180635348, 0.6332486557297367, 0.4720065751186597, 0.3449092768065684, -0.8369798221047434, -0.37606134628919197, -0.4801240092471402, -0.7176491997433827, -0.9229615229180473, -0.6164367882190457, -0.28179173229316784, -0.7151569840194882},
    {-0.07417216400715984, -0.4332808237615033, -0.4912566498541372, 0.3700506881086296, -0.6316571054265699, 0.6592571023359088, 0.21608191007645772, -0.5268051983592741, -0.6834898697879586, -0.6901343050239839, 0.6831832187704816, -0.2623559806444435, 0.8333570605869806, 0.4630874598757423, -0.6013353210749568, 0.8223319243528604, 0.3174925090803356, -0.3795826365763253, -0.3505705288978538, -0.28345753866800727, 0.5843701244439049, -0.6596366780253492, -0.6381336742527985, -0.6183270784762124, -0.5572707616969028, 0.18422738941537428, -0.41276633512904, -0.7336552704643153, -0.5206566311960408, -0.7543001451366881, -0.6685833067926138, -0.4299752756122845, 0.4256919729136231, -0.4605911176762627, -0.55475895207914, -0.715761300767074, -0.29954347245567237, 0.19679805102264106, -0.5548525056771534, 0.9462383549803813, 0.7388673412186776, -0.5347958474195811, -0.4310535530305833, -0.6691656200292071, -0.41466248550380314, -0.312040206523136, -0.6544730133714114, -0.5058834708644869, -0.5125744529164004, -0.629785719313578, 0.2061098751688458, 0.6473453450941143, -0.5647638171683246, 0.28603016366376566, 0.3110312547504642, 0.5207284803401606, -0.5142763969790909, -0.2891762467829289, -0.5903012865695574, -0.6002723434355733, -0.713323177772857, -0.5028518527475605, -0.41473400325894344, -0.472436406342914},
    {-0.20010794314556898, -0.17159195714490924, -0.6679257926775802, 0.5804666921855641, -0.369377997499135, 0.6895571076751268, 0.2093741358589225, -0.8522286299616981, -0.5253656286254024, -0.38820577703579123, 0.9196540866016194, -0.4292167633291726, 0.8188041442483865, 0.588772699165355, -0.44562074102904736, 0.695226330704282, 0.4548578919008398, -0.5296433106473163, -0.8847323269895355, -0.3106245091147432, 0.49988472185670607, -0.4520701810919397, -0.6632260104602925, -0.6597205310521348, -0.725651325654128, -0.08433538222247629, -0.5682352722208903, -0.4933123413819926, -0.44426185809859103, -0.545143512900947, -0.814691236606182, -0.03650288023951629, 0.075230452396847, -0.1763421147653233, -0.26923181963764303, -0.6935924652363791, -0.5441912758841556, 0.289259419289331, -0.26050510629527196, 1.02808101847453, 0.7328414233528132, -0.4312216368156552, -0.28040627042510924, -0.7214843732829941, 0.03834410625400796, -0.45329981511455414, -0.596845034613127, -0.47459417207650934, -0.3217890189923814, -0.6390877563634132, 0.276856814112091, 0.7662596414369106, -0.5028266589956418, 0.7527229663697308, 0.7150023245674071, 0.762738755763023, -0.6958866753807024, -0.23743443435727316, -0.20725743819638226, -0.7902249050964804, -0.5676437114226486, -0.6958951703651503, -0.2794273830886489, -0.4886459752291925},
    {-0.17850157944226594, -0.3928878948958295, -0.7085887392440161, 0.5922317360520509, -0.7425376935079451, 0.6267620639732662, 0.09717001657223039, -0.538246025035359, -0.5227440793271552, -0.4280103612155371, 0.8758969415769695, -0.3642395103194402, 0.7820422926036755, 0.7253934207113001, -0.6453304080248561, 0.5764088872307843, 0.3496584822743859, -0.6046463461301377, -0.44955606786854835, -0.3954243173715358, 0.29399465372628186, -0.512084547431516, -0.7855983724223302, -0.6875116037365491, -0.7182379835603556, 0.15064467519480743, -0.5845778893995005, -0.8593435817874052, -0.5665068120794104, -0.7216713634688704, -0.5981771406637687, -0.4548225093694751, 0.06837523157626138, -0.04447823519299467, -0.3638641380960495, -0.565850812107743, -0.4306933177952717, 0.06931581526930596, -0.5179397881095259, 0.8538549621089323, 0.8970233032864389, -0.5649145382696239, -0.20244341820184777, -0.47427647590947, -0.14993159490083888, -0.7610308545416816, -0.6296097999674033, -0.4974697369456456, -0.5238551846569224, -0.6574569078417529, 0.4388465495723801, 0.6289790380634456, -0.8910912773347819, 0.388108857191418, 0.8236524151987661, 0.5661898926857201, -0.8409806541230398, -0.4258510362579023, -0.22903011934179748, -0.7443154601004012, -0.6570117066177265, -0.6410102361813727, -0.3615859754311767, -0.7368708945719046},
    {-0.35946179568590686, -0.2318982655454671, -0.7947611145752598, 0.6427256589712789, -0.7018408048113941, 0.4899516076489344, -0.13084921277127215, -0.5311092152845954, -0.5110195564627403, -0.5090562343690895, 0.6817592962287039, -0.41081530859049614, 0.6821954291754481, 0.7983026628526912, -0.5086280371937548, 0.7812979687336584, 0.4984060459543653, -0.5247596056396387, -0.6233707563882633, -0.1650653159593174, 0.46814281013745107, -0.737980032427548, -0.648038334363273, -0.5347333054759112, -0.7116200735020964, -0.2289070869104163, -0.6391126588053699, -0.6360536701256584, -0.6331307849522084, -0.6500370594063115, -0.5153339978340535, -0.5273110652129458, 0.18039390447771744, -0.04946257639453147, -0.34692912693306677, -1.0491548619185567, -0.2746174753644007, 0.06050294588638885, -0.6635350199744894, 0.847761295488486, 0.8406891514525014, -0.7168841613330086, -0.14931397622836837, -0.49309122275812345, -0.040066492620634296, -0.7813536465833445, -0.5739556095991724, -0.40530062825827123, -0.24962199174758984, -0.807886356709606, 0.35643438935353944, 0.748009246245635, -0.7835198741339197, 0.2717307521342611, 0.4511196445640961, 0.4989733668887833, -0.7263626315321607, -0.19437847705605837, -0.3307451189390242, -0.4634771131320512, -0.5709970042919614, -0.8064096320352947, -0.618783206279641, -0.39999104911127786},
    {-0.5269250212687216, -0.5533212851270037, -0.7071070916040979, 0.4055099742240946, -0.6029325988300334, 0.6326071045033247, 0.046157448381429086, -0.47844115291667205, -0.40883747146541216, -0.8496578339560784, 0.6300532554925488, -0.4184242514765136, 0.6568888867717696, 0.5344298317703456, -0.5332764812389523, 0.6673378507444764, 0.5430284260827712, -0.41840815559576033, -0.47440538978708174, -0.2982454545283884, 0.2119898686454013, -0.38726834861804976, -0.814498262720774, -0.6135627532039103, -0.39997631661872574, -0.14486971474882904, -0.44307676975282145, -0.7676273182941787, -0.5236718294086062, -0.8778227150937981, -0.403366231003983, -0.3258395416157586, -0.1374524264186456, -0.05390728964723128, -0.44833684535625257, -0.7464188659801674, -0.09201933422802142, 0.15330143417608993, -0.37853918860744523, 0.8386696418936733, 0.9748468902545743, -0.5400489984247969, -0.13416315645791632, -0.5484732192877144, -0.3919069940576134, -0.6527389273286596, -1.0287986671224523, -0.6325256448577204, -0.6194723912898181, -0.7521063611991303, 0.2930111404993512, 0.6671141359642746, -0.6921764296740847, 0.729491220519688, 0.6937192696165448, 0.5209737076224926, -0.6643220167612246, -0.38846513106611524, -0.35109687845827997, -0.8594155519816378, -0.7791856938566025, -0.7513316810730529, -0.3113338233754362, -0.5376767085876643},
    {0.01072462718986558, -0.18178525045415492, 0.3614713719842076, -0.10872430276430206, -0.08226529211015578, 0.1270188005661374, -0.46884204318045436, -0.025862508323780068, 0.04834565011572475, 0.1958576569426949, -0.30257660503365874, -0.0589628171383373, -0.29401851822322095, -0.12192363059097916, -0.3787449518350022, 0.029752848565830506, -0.473062104046549, 0.333334798315954, 0.09512349076418954, -0.25637005133188706, 0.2962840648276902, -0.0673855660845134, 0.5609406132596547, -0.008234614306238229, 0.20694340875829254, 0.34077735437398704, 0.2476248599110372, 0.12667709367780067, -0.09504486270581848, -0.007438022678580438, 0.05351201662146379, -0.18091655469046497, -0.16208847115730393, -0.5727308605995395, -0.18994814026570947, 0.41656259067550977, -0.06303534447725503, 0.40311810236999784, 0.49358366546818705, 0.024437289322800097, -0.24471583839823652, -0.054794924039347805, -0.649460287548811, 0.2485296314852668, -0.5347713092620292, -0.7234076486209491, 0.39615285899296016, 0.14468377400643273, -0.03574316913223313, 0.008151101914283199, -0.48726263783120444, 0.09686693896265659, 0.17415736410052624, 0.02049436297808848, -0.26410912743827014, -0.13959842113993315, -0.13239152493979792, -0.23572977059254865, 0.015197730897201072, 0.1160536176850466, 0.11845461943623858, 0.4047331084322981, -0.021580570022497685, -0.02568536328104018},
    {-0.5811206499138925, 0.3939672183257584, -0.5432807256638665, 0.29233362181977085, -0.41895771326928927, 0.3063621382888439, 0.004062555567827861, -0.551490376451199, -0.6335678070727072, -0.522132385240751, 0.48421939828840926, -0.27319302730955614, 0.7297514991100844, 0.34040716996893555, -0.13863450438799899, 0.3884407462062732, -0.1455707372666634, -0.3165179117571981, -0.12203297446716103, -0.3080367698414954, 0.655970258159572, -0.06901130169144114, -0.5027546076204763, -0.1570632357935445, -0.5806732318162943, -0.04387249115734619, -0.6320612000586407, -0.5746289607394355, -0.23986419099575187, -0.439042885985472, -0.11828734219268147, -0.11680092599875146, -0.14593930964827742, 0.009731204721883073, -0.2973392381138111, -0.6310842778443806, -0.06788830451992287, 0.4100698291937805, 0.19086776506171302, 0.5390285601363275, 0.6671195985299622, 0.14722126719547401, 0.24586935702697763, -0.22846943431128938, 0.14382750443772313, -0.7055792021802844, -0.07043831345752238, -0.07036722735038681, -0.03990945100193911, -0.3145073754679318, 0.2840232891111512, 0.4289652583357834, -0.48426935562749174, 0.9138731431353065, 0.5872044112693325, 0.4412437345417613, -0.3942008440397719, 0.26490265956113335, 0.14845960887824414, -0.4639470237694124, 0.010642627823641988, -0.23042672193411604, -0.4247461193254103, -0.43447168633983135},
    {0.3081007566018094, -0.5886303484858182, -0.026631661126321506, 0.05939464644060051, 0.14418021090075883, -0.21847502647262357, -0.31035200038370275, 0.05015201629982132, -0.17421945615732573, -0.41271579881272097, -0.4166969422005283, -0.4787761486636835, 0.026794689808319287, -0.057372805860505374, -0.16694259198347394, 0.10403302574897769, 0.07008315071649893, -0.015057536597533457, -0.09914083564866595, -0.028382117988242764, 0.3003854972792955, -0.5360540665867172, -0.01570247910489796, -0.39542306650456893, -0.06333234928531306, 0.38057957764590755, 0.2979754555851801, 0.019259982773629777, -0.2179774210607024, 0.3518958656836632, 0.2439482179805593, -0.5128790329824947, -0.38988797003465603, -0.47395593493702726, -0.40912645856232804, -0.022985891568461758, 0.2996335033481506, -0.3917130757053594, 0.028342699251219333, -0.3765341831680026, 0.13395075234641382, -0.30418979921203865, -0.6923871445283882, -0.34773153778904037, -0.36869792452666994, -0.37401845499008096, -0.3535952751027499, -0.6944682356598312, -0.35751280325468193, -0.0780287077201513, 0.1032230974967313, 0.1837536736253349, -0.40817686420223315, 0.0721496892960839, -0.14897438764612647, 0.05775160533316138, 0.5146070763690754, -0.26089063828479714, -0.3869623798843132, 0.016065118922815674, -0.26843938882915, 0.17344993876787335, -0.3148111938287657, -0.3115205200478782},
    {-0.1987710287697519, -0.4975989129010632, 0.09183421166340762, -0.2266548167908727, -0.20063303835764243, -0.4721044467621291, -0.550198961549949, -0.38917648348654355, -0.6699855526058813, -0.45265338698436497, -0.28205610712782214, -0.33586902318587375, -0.33053736020830066, -0.14095299083835083, -0.14550407303370325, -0.15467537577843174, -0.045547895213453385, -0.04851861966312739, -0.2501788383192712, -0.40676889200812544, 0.1277019876238702, -0.8869749320303716, -0.40035332000063817, -0.5567973334297599, -0.3143234544382549, 0.08351563790174847, -0.18606093595979595, -0.1128944140387146, -0.26608800885496986, -0.3934546401329912, -0.027508203763309726, -0.552708056337827, -0.6716235111140797, -0.3819791105854534, -0.4305852884366883, -0.3399314988964126, -0.18774950083756012, -0.6463958613711729, -0.1783100885782253, -0.48323185242591704, -0.13036647108409333, -0.030222970560093237, -0.31439352702046097, -0.6409226461304127, -0.6453756670797963, -0.8866966757729433, -0.7579413231121604, -0.31003429636369734, -0.4904172913951548, -0.5471185064021016, 0.17002669663072945, -0.12909831257149937, -0.28123922593082495, 0.05628646098153795, -0.1458352580939121, 0.07782429615164273, 0.04547380696795611, -0.4075346899335907, -0.23251183863027744, 0.03946161744774955, -0.3413414906821215, -0.27512217099330794, -0.025727424926623287, -0.25172406752935045},
    {-0.016879088658045112, -0.8138306891359887, -0.43619162105485654, 0.03986807027366432, -0.7346819795836896, 0.02279352200844812, -0.26260754194584407, -0.839355924841945, -0.603047049762507, -0.5597484167030149, 0.003396182041853885, -0.8099364022789736, -0.2615386767423293, 0.06804921956009176, -0.31240464576393573, 0.3590521888788776, 0.36601283819816316, -0.5606258729276838, -0.6396645972931092, -0.474328638035575, 0.4494058833110976, -0.8013901058486202, -0.5820973809760006, -0.6624379671930917, -0.40690524205163753, -0.06911716727985207, -0.6733627749135224, -0.4576056437075551, -0.6099484023909326, -0.5131475535777111, -0.4391360586408819, -0.4781955403235724, -0.4181928018575896, -0.5096203143960073, -0.32344382723722787, -0.425053983037066, -0.49549756289649616, -0.41063310176902523, -0.17775622106488656, -0.14923116212176077, -0.0146206646430986, -0.6530458879898002, -0.406156814088172, -0.6707562784689283, -0.6532914027246428, -0.590930904464824, -0.2904781728890576, -0.2780273449825709, -0.2711257732866622, -0.7367143712249201, 0.37390485450635635, 0.354480714750938, -0.6313052704599796, 0.09923390808620093, -0.09375653256005366, 0.04064020573922403, -0.33264075630323287, -0.28994925144574696, -0.5749008104699208, -0.42030971585656157, -0.6872006829780276, -0.47250192337666086, -0.37376021460098796, -0.7138969150599911},
    {-0.058384653835521, -0.6126825945843253, -0.3536163262228089, 0.13016779052267996, -0.4640836968310224, 0.10419700540171138, -0.12995668094273546, -0.4868802429169217, -0.6322806269291981, -0.629617685341348, -0.06825134278903298, -0.6169083798806096, 0.027946344509450112, 0.012413822941055882, -0.4482324893531073, 0.2046745735410299, 0.08380718582874967, -0.549961614976872, -0.28415632540615837, -0.6306459704691109, 0.15816025412499, -0.5619484580487858, -0.7134334415319186, -0.7159886067396343, -0.49086961976933924, 0.18553818850070092, -0.3924344622233037, -0.4084681407379245, -0.363179521230369, -0.3850964057631977, -0.21415132973850126, -0.6110256281452909, -0.6570925665640938, -0.25753843686820704, -0.3492443131273119, -0.6694328409348701, -0.33864888378072183, -0.18564983085265135, -0.37441945000788446, -0.0834017307203265, 0.17282083345576407, -0.7278495376647444, -0.7746977545682248, -0.5278163843930499, -0.363700207119991, -0.5134302725005365, -0.3489170530038911, -0.7390391407616361, -0.5412456599836726, -0.39959018822884346, 0.34107253722769126, 0.1755838227739664, -0.5772010888796409, 0.37329133956674654, -0.25872027702921113, -0.1698439541529308, -0.2728571344047709, -0.4519248211300655, -0.6982555247162398, -0.5235161240732534, -0.2025505866227486, -0.24777044436870432, -0.5680434578227613, -0.7361224079465205},
    {-0.19480053209778228, -0.650117510122145, -0.23059309462975836, 0.024426928743365797, -0.48685022696892516, 0.19428584428253495, -0.6912900704417414, -0.5693186539391414, -0.48667340904671236, -0.5075152311872758, -0.042442004531066814, -0.6532769829280706, -0.1353365229972824, -0.2107080132717015, -0.38301243149335273, -0.17309128702465418, 0.19150468776748708, -0.5787819550918285, -0.47375557503314614, -0.6483959336713638, 0.14993062699580634, -0.6471771309042723, -0.4627611671471205, -0.3470125903591677, -0.6193660137298798, -0.10872612030136047, -0.33465415770643825, -0.7369508861129735, -0.6105861009416397, -0.29456163700990345, -0.6482720779233949, -0.6658630643518296, -0.616852554540025, -0.8874655036909437, -0.26527585200270215, -0.562871368168455, -0.32652945860876154, -0.5569421189042837, -0.13507127975396777, -0.004702013689985381, 0.2384468277607275, -0.7230043613372363, -0.38258530817178826, -0.6659531859069988, -0.5492792348392938, -0.5536139335932196, -0.27180313344454704, -0.4434531530189178, -0.37627747898266384, -0.8131118297461579, 0.06858027074041262, 0.24767393239938543, -0.5788605053826457, 0.18508722572369615, -0.17733257699141908, -0.1594466799457283, -0.30789593982630625, -0.39505827163327784, -0.6250458850137292, -0.5539166434105517, -0.5747922824168806, 0.046768172959596635, -0.6114684800693694, -0.5767792408766877},
    {0.23657438444273118, -0.6302522870186559, -0.1429428965358821, 0.1856016803195075, -0.05721267592407393, 0.08469514584447338, -0.6775995641763886, -0.5690252508873098, -0.42856503753142583, -0.3846121781174324, -0.08785941245372787, -0.3367511229606917, 0.43026663828841494, -0.03461881685950061, -0.176448143214232, -0.06857783088586077, 0.15095801226908706, -0.3840589191033515, -0.28865411506372973, -0.49397222463078067, 0.3378709655729114, -0.3531464230800569, -0.7573791264395753, -0.4222425896055, -0.38999424947269806, -0.015474777994560188, -0.0699446787580646, -0.2572271157407344, -0.42776309597916845, -0.2089332495970675, -0.7879914530683105, -0.21778226285716598, -0.19315204416093287, -0.32058441116486386, -0.15121874318347386, -0.2846475083908493, -0.3879086602045919, -0.5099917639856445, -0.09364157263894805, 0.004495986058498119, 0.01569103432051399, -0.18319578651196974, -0.4719163448864895, -0.18637893968803512, -0.15129691070422183, -0.36535403435483127, -0.33602293859827137, -0.5969184892290706, -0.3611702244942616, -0.478741313008294, 0.26756034101429194, 0.07871186654561994, -0.641378148567979, 0.24858884467488898, -0.18880133010534142, -0.2309536278681334, -0.08901318544382965, -0.18516925374261, -0.43653133697910473, -0.19261314067993518, -0.4527128367587708, -0.075719051867652, -0.5178026659558187, -0.6529209656604518},
    {0.30210508717465717, -0.3510389651628258, -0.18007372574647346, 0.10638570076275315, -0.4939164672904213, 0.07074610585355709, -0.5057818709922111, -0.5175456708465674, -0.48376087640652254, -0.866896456307083, 0.17114177621247195, -0.44829835788013633, 0.04774440645530841, 0.3822517399036287, -0.283714321854911, 0.042556545641966044, 0.04130277879603974, -0.3400896732413258, -0.51016434687147, -0.28322673925331504, 0.29471862848911573, -0.4094448847090607, -0.3829828711040367, -0.6067097755718172, -0.4837075926440968, 0.22792174864982478, -0.39133898902766967, -0.5587114859243201, -0.2682774167573551, -0.30916315531657107, -0.5019691791384621, -0.5746422183401062, -0.36478796938211516, -0.7080172877177356, -0.32417807092820977, -0.7022065092017515, -0.25918978428069434, -0.574725552146997, -0.1966358264174156, -0.0938751489406999, 0.13659012382600377, -0.497494615900835, -0.8129014896361426, -0.2205954167623362, -0.40412860430276126, -0.3743341853315405, -0.3610937482298473, -0.42280321663162534, -0.4886230386221947, -0.5512932454438377, 0.4459536778495379, 0.03287122527745205, -0.7230044561528453, 0.2558292591534939, -0.11412322494545878, -0.13726678585336252, 0.16011814264006646, -0.02911430068259415, -0.47399005242508807, -0.35402545576611416, -0.6549466719974764, -0.11132488219446583, -0.6898532391084977, -0.5907934007989366},
    {0.029608867868212766, -0.5400765704190392, -0.23185638523738739, 0.045200876622575874, -0.77059564878565, 0.1822645972320966, -0.4499625312706169, -0.6394602665995405, -0.41594742097026155, -0.5418767128452634, -0.00016247023293872704, -0.4998483647066375, 0.19881020760677198, -0.05602202314334758, -0.7414365434421335, 0.3469230923240416, 0.2783574422647385, -0.5725341278463928, -0.540374951340839, -0.3841695296164796, 0.1706770446036605, -0.8425433271509046, -0.26258027973276793, -0.6339385431709629, -0.5355472319753432, 0.19444703323709508, -0.10633340746007175, -0.5356124021088609, -0.7065766174670606, -0.23081399595883104, -0.2874024364990074, -0.7145981270743501, -0.07574961195438867, -0.6637637793897565, -0.6716067614657084, -0.5557792955655346, -0.5944565367512933, -0.429210751743606, -0.3088690210611174, -0.04932273344463908, 0.062444423313732955, -0.44561083030100745, -0.4173803580183, -0.469969858078353, -0.5824983150064369, -0.6289221952603848, -0.07392447884540129, -0.43199427190859796, -0.6602091629264937, -0.557597971085144, -0.025090160964943285, 0.24169279724377501, -0.7910712028603334, 0.11799426539752576, -0.04623991210072669, 0.05714699345225983, -0.2853241912397189, 0.11431719514642907, -0.5301513750291262, -0.4493722633845658, -0.5337839743992473, -0.07231081723853339, -0.24995424718415482, -0.5458020556620045},
    {0.08431427631686682, -0.8591866138087344, -0.3099134002094645, -0.1363952683826411, -0.4550289648689831, 0.050428866198391625, -0.5035789475888868, -0.5914148883052746, -0.5516145814720606, -0.484003393748597, -0.28592741054367576, -0.19446915144464053, 0.12775893202968616, -0.5157121711255712, -0.3703598512158561, 0.10371300718884084, 0.19157153215240144, -0.4647228339050846, -0.44276597775994847, -0.5965073543040191, 0.020471667804983742, -0.36472810862717764, -0.5044394458434929, -0.6561225785643032, -0.845883078013274, -0.004685574969141609, -0.15138869240010128, -0.4905756993100426, -0.582561335527474, -0.42666262947313155, -0.6465317409657474, -0.6106175775096623, -0.17442580625016602, -0.7957424294812324, -0.6032095800732238, -0.6268725459169344, -0.512468132676378, -0.39706043515734274, -0.04856003919956255, -0.11251976403054889, -0.12128371198458128, -0.43619570122468715, -0.7711492338511801, -0.4246046297250191, -0.34887860647488445, -0.7410322901357558, -0.43117855036593344, -0.4435598044948783, -0.644186403291679, -0.19659563789708814, -0.20892454325039395, -0.1606190213600307, -0.5836370164683108, 0.034063323725737615, -0.3863700590472632, -0.6206190428260483, -0.055102948034152555, -0.23641202328308394, -0.3425496733639126, -0.692168430787977, -0.42062787056884876, 0.06894818302178377, -0.4076361891096758, -0.41927894456565556},
    {0.0069396214006621805, -0.594489688218519, -0.31668302675467913, 0.2683217901050619, -0.6983024495782466, -0.10152777043401195, -0.5356370166971294, -0.6206655837026278, -0.7498046575028958, -0.4614021804441346, -0.3645129285589269, -0.48485923370969114, -0.12170595961356027, -0.0722440902151253, -0.7127235052166286, 0.11888919617579827, 0.46763264048778125, -0.6504183232378328, -0.5686328425486831, -0.7394896974177929, 0.21561563854662658, -0.6120162121614197, -0.5713723846916899, -0.4959685279173607, -0.36741690950303296, 0.3166773256498694, -0.3302478145803708, -0.8005687848525831, -0.7786149862271575, -0.3101417597690232, -0.6775919873718825, -0.7489419248433695, -0.5225920505591759, -0.700895251405922, -0.6505313152277705, -0.42856965965217964, -0.4240983590417831, -0.38638729891466445, 0.05189161124902096, -0.17735629119990565, -0.4069153140800886, -0.5376502061158893, -0.8017459340656808, -0.7034127864541669, -0.7098581567870603, -0.5040966592500992, -0.5139193412682139, -0.5704499761711326, -0.5420643548855026, -0.49041628149311484, 0.13066629839447738, 0.2625283268576864, -0.5871676665359667, 0.1977753319408791, -0.2226767442294558, -0.10978243134894287, -0.15761734152237697, -0.3766474677649843, -0.3929348138534132, -0.5806092726319014, -0.7293024599316885, -0.27038289295296597, -0.33000456769766195, -0.610577718512478},
    {-0.07114383789552811, -0.6306552198753105, -0.005650777372110816, 0.09713168449552068, -0.42602618156769856, 0.15181147175204932, -0.7900284185459212, -0.5591582660416076, -0.6730066711313597, -0.6362777324654563, -0.2868433301982094, -0.48416693827843577, -0.07836883616565812, -0.032511448412500824, -0.45346429729125576, 0.1943711463613524, 0.20175260100408435, -0.7006217895087156, -0.49156107295981466, -0.474067630857003, 0.44224432086825594, -0.7803599200613608, -0.6146255090957868, -0.5760339000263057, -0.6645108721618189, 0.06290894706971098, -0.16893738474730943, -0.5954355653176554, -0.49492271986494224, -0.5701727360114681, -0.8213175448203485, -0.6544848010722033, -0.7307609716333882, -0.6971072824087619, -0.474583112150482, -0.6390002857356638, -0.5987339042313328, -0.7071967163093895, -0.04301355914010267, -0.21009498313783373, -0.026001463000381076, -0.6509537450769216, -1.074660112754918, -0.635675322552739, -0.5387176980875359, -0.601737318945368, -0.3156741917044709, -0.748055980369143, -0.751224605828655, -0.702171894208205, 0.1382274755484381, 0.10497391785472618, -0.8402423346079233, 0.32044410051541833, -0.16850947806027777, -0.21266008004989187, -0.16412696090305404, -0.04900860741110667, -0.3292879220478956, -0.5996125197240492, -0.7042331700468801, -0.3863409560225955, -0.6701100641589559, -0.4387228785789325},
    {-0.07418742428491365, -0.6763026157193024, -0.406569055493176, 0.11081714292458503, -0.6712705807612255, 0.10255448359728826, -0.5415526645128377, -0.6292860882894824, -0.6043295073597212, -0.606502606337068, -0.3074843678080988, -0.49559147996278846, -0.419447010758649, -0.29593210878848736, -0.3107651086927914, -0.1601635633880816, -0.02000959741593897, -0.5756182734936032, -0.5070689192417757, -0.46818230698495844, 0.05643476397149187, -0.43527911529256424, -0.7412347701771701, -0.4822101132304192, -0.6511911692489442, -0.06979447762429955, -0.3013108097616542, -0.46280996367171146, -0.6372825357652776, -0.44174591284085196, -0.7676570592896766, -0.7240889618571098, -0.7353592385699892, -0.19154657119766388, -0.4594652132757604, -0.5572061436797552, -0.3613472674718479, -0.4815713597079131, -0.30315749944012205, -0.3017832707841716, 0.08553444562404182, -0.8400126304810431, -0.9517681778944946, -0.49555996497648985, -0.49697552308831844, -0.6932547935624975, -0.4958896744518913, -0.5265046836347214, -0.7182174525306002, -0.8402273964926441, -0.13867644243242536, 0.08188483969450541, -0.6959637176962857, 0.08739236847225382, -0.6026207881528919, -0.2716550059040594, -0.18945053387742208, -0.5051888840467806, -0.3842654776194746, -0.4818957667743024, -0.7106318684947515, -0.1999780447526397, -0.7253244583635282, -0.7585230635796848},
    {0.6616259866238379, -0.7339521433832408, -0.17290829147128045, 0.18468011419903638, -0.5919090977164195, 0.19575855073251006, -0.8727055962688847, -0.3677174580657055, -0.307868829287133, -0.5021148364996234, -0.2780764436287313, -0.1510258007013564, 0.13840668954303015, 0.028739731015812973, -0.2769043597856025, 0.10845615181698748, 0.25787028604184803, -0.5065880059633379, -0.456386518242413, -0.14297035963026566, 0.19109176665264335, -0.7220515695923737, -0.4068680113343685, -0.5861688356797667, -0.584539206120093, 0.40929324506564524, -0.017461452508085687, -0.23555939405425763, -0.583545019428106, -0.4960352301179638, -0.6389408384994139, -0.7099413519693246, -0.5419939552685034, -0.5937961977724174, -0.5604077154247029, -0.5132124461569569, -0.3775720538665331, -0.7617756839260911, -0.20827216679201924, 0.20450653721940446, 0.30435422886277075, -0.559606299881808, -0.781915346386057, -0.35297595448897073, -0.7032830775895604, -0.8013604181590839, -0.48040910232111145, -0.3884529002468491, -0.4841219901487527, -0.48381940381341065, 0.24744621271938805, 0.22376608149234664, -0.6278670625946756, 0.25332173763567284, -0.3660198226523668, -0.39432988665541663, -0.2107350546217682, -0.308832399235796, -0.2848091590252102, -0.5241391492038895, -0.8836070570261794, 0.016513795220244303, -0.42048743137800754, -0.5834797705209998},
    {0.10130832836658875, -0.6676661934518409, 0.09233877966262403, -0.06020852215338403, -0.335636106496584, -0.11894182448397288, -0.6585419002789027, -0.4751169933034948, -0.4910705784704188, -0.39504790003169005, -0.5060243618104526, -0.7204710701702184, 0.12853637468247728, 0.008502137123317268, -0.3856900128585421, 0.03931082599796388, 0.08904353171599047, -0.391330995973462, -0.8445298908473456, -0.21850937337481302, 0.1629554909497686, -0.5676899676998369, -0.6209132799014865, -0.33218155133797306, -0.358832774386076, 0.379606271726151, -0.30077272510323205, -0.5284266823829055, -0.639714186709228, -0.18123187583119896, -0.5983887765784991, -0.6071290450446849, -0.6836093567603179, -0.7698463834346964, -0.509466134955741, -0.6353210633589842, -0.2867754545637858, -0.7531639805195574, 0.009742358618388663, 0.066092212062397, -0.07799208229683562, -0.2812759801115161, -0.6324970640706304, -0.4979094600635693, -0.6668748629921895, -0.29966190762289635, -0.45765471545463704, -0.41607359132949906, -0.7258153397545386, -0.2949888082305096, 0.06913446821001318, 0.04999640104472009, -0.614313486487259, -0.09568104192605785, 0.01302743983976906, -0.30327473525540455, -0.12560352587838147, -0.2659628732888989, -0.36241319832615027, -0.35966226207872726, -0.3842888662756147, -0.17393740771836005, -0.539610418936077, -0.7293742017331509},
    {-0.03598011361140514, -0.3433328522594078, -0.5907373878417032, -0.017777800518426746, -0.5819340631633841, -0.04197133173661568, -0.5816335480130036, -0.6082122018273671, -0.49820446240240107, -0.4992599033515572, -0.34254222578185944, -0.6790407874275414, 0.15002797748507993, 0.17003343592801987, -0.4836653540433861, -0.1343884796717744, 0.21382490200370888, -0.2808927893371531, -0.5374920680037512, -0.49260173222118536, -0.11410123537401519, -0.562521632706421, -0.7305034970058532, -0.5669282724967767, -0.34050309314056976, 0.35739480894386366, -0.17088021545727117, -0.21395409821585068, -0.27655433805690827, -0.4187797740559347, -0.5019391014721791, -0.6234542433613938, -0.5414265344472579, -0.6449605088970283, -0.4837906776125249, -0.5039985518227442, -0.21600195601977376, -0.761151634367555, -0.26168982750906467, -0.02012354238091343, -0.20226014325929662, -0.4338430901004121, -0.35767975424420384, -0.7620836748648844, -0.40505629684236016, -0.39729469996579675, -0.2741264533985183, -0.5892890049379448, -0.47743711410161754, -0.40127903557761746, 0.3559952509882979, -0.009023642989791594, -0.6072204708689037, 0.28744365776594, -0.03422121491745615, 0.0575564831433444, -0.1368829047304145, -0.4971386370292387, -0.7403905564717639, -0.40676285757282454, -0.8060276774929849, -0.13675181434814007, -0.5192973634350034, -0.5634010412602213},
    {0.2894936468605246, -0.44114170608813774, -0.4423115349798096, -0.054583742343570406, -0.7063649354592687, 0.055020411897980695, -0.23956779772878947, -0.24434684294796152, -0.2173637695161439, -0.06472111573829428, -0.016911778661894136, -0.5105867177411132, 0.3124764649439978, 0.3168805625385849, -0.29931284906351685, 0.32423011733593377, -0.05481415590147212, -0.05849099881332858, -0.3288858596469426, -0.32091348279082205, 0.052684926938394404, -0.622037080314851, -0.4103199449042027, -0.49347337818600207, -0.44157698837967835, 0.11872123369073576, -0.11022270887780233, -0.15503742345758192, -0.19864511416467065, -0.38823760813346114, 0.06363585631142331, -0.6079358814954795, -0.18400152095632136, -0.36059016137345407, 0.17514267997047822, -0.345087098142998, 0.029907761493111515, -0.6400979221517994, -0.11600556378853921, 0.07359475806148842, 0.3497754763587699, -0.5499463405319034, -0.5515193588592439, -0.4273811322838873, -0.16336694541925847, -0.2449297093590335, -0.18807302125234152, -0.35801736373956494, -0.3965068170790125, -0.398902119462551, 0.0969315072873445, 0.3394088181017215, -0.11860396140838703, 0.10805781814057862, 0.21419946066730416, 0.19634361528540548, -0.05946679908193292, -0.41325138735419487, -0.5485993891791319, -0.23897160331959777, -0.5103205104710675, -0.0849143638980943, -0.3633220708070507, -0.7188088616563836},
    {0.16381106835912648, -0.5300592617408942, 0.010617370615219177, 0.009479866017883587, -0.38264358170485474, 0.13198679154141327, -0.6604013872775086, -0.44012389647082445, -0.35256092506047143, -0.5885667466237502, -0.004515094466564027, -0.5862955453493396, 0.13483689891396491, -0.14076030302800824, -0.4140258382020624, 0.21110782095223327, 0.15995334644835502, -0.35396159186837445, -0.3190939953003938, -0.45878541962569913, 0.2002519802896826, -0.5583319669282532, -0.5523768259867607, -0.6879039980093332, -0.41342906402123125, -0.023831451257566895, 0.07787667753388774, -0.3853972223885443, -0.4039870472976256, -0.3048905433044728, -0.39833583375601117, -0.7427370355877125, -0.4575523587581079, -0.604191596223294, -0.45982707054905636, -0.25411784479898164, -0.04509324997342659, -0.3410625013024466, -0.0752764768051915, 0.0935650800080268, 0.02446117715130539, -0.44315494337189854, -0.7625742562916754, -0.3416743965214753, -0.6484154976875908, -0.51596100474836, -0.17091523882831808, -0.5220839796998477, -0.503087677082663, -0.35190203294703404, -0.02032643241765595, 0.07849993675810411, -0.19985561124813023, 0.29238299204112117, -0.20226799900331408, -0.15077106107135213, 0.09012095429904768, -0.19820403582219717, -0.5293474197875286, -0.011567644271063727, -0.29686588362164884, -0.1772914046071529, -0.510539874634895, -0.342360286285681},
    {0.2855061434882011, -0.7970041832945717, -0.1652445808675301, 0.3397137907333607, -0.6947452658012234, 0.08977145117422392, -0.854235199490226, -0.5448135937522247, -0.6422641804689301, -0.4268178780494097, -0.3525380530152112, -0.7095667250356738, 0.06732033883200876, 0.10021153685201409, -0.6689116066766512, 0.03325982609645963, 0.21162048743113315, -0.6899437139895308, -0.3710382473286697, -0.3784891385025045, 0.013131043070711149, -0.747443559264244, -0.5227486858532283, -0.6937056515311303, -0.7586732053185953, -0.036695101275717075, -0.3137314061222895, -0.2914466825752738, -0.25761695653466593, -0.22270520127812962, -0.926074663448653, -0.8241155600824033, -0.5099550896023695, -0.776308502003311, -0.7489466386459546, -0.2617759874095, -0.39170872314355226, -0.7482152890877325, -0.2846120422012575, -0.11646656814044967, 0.1666223066926304, -0.3286848291941904, -0.44465637495685845, -0.7084750233630208, -0.9004386678243752, -0.8616114409442674, -0.32606699661282323, -0.7526390981886109, -0.6344508250017566, -0.591404098457451, 0.28297915163434784, 0.15326982755189383, -0.2678581317635768, 0.2611797528157566, -0.3493886583033791, -0.38881304312251197, -0.012893736175476475, -0.4486865887730729, -0.7591920051818413, -0.2040129056716182, -0.7658156202391198, -0.12513314596771605, -0.39422712273260785, -0.7560021332771344},
    {-0.11702207410614632, -0.6433981297921574, -0.34522841322090253, 0.15871409547502513, -0.6175513992135089, -0.007322838801677037, -0.6689889300444866, -0.5700608861360688, -0.6305114506423588, -0.8809724444640523, -0.2660718170776114, -0.613754007626907, -0.1622127090166667, 0.07553531703792088, -0.43829662636565114, -0.0021019274234903695, 0.14549224019819185, -0.6776289672937986, -0.7795897786480032, -0.5637743542220911, 0.30933867026514666, -0.7989575295325889, -0.5187024887602824, -0.6422773421770432, -0.3935060146090156, -0.00014066735149291745, -0.4197778766376964, -0.6239899753911009, -0.7324887179864125, -0.3149706998094019, -0.9473472374664088, -0.829426250813699, -0.5375836513408694, -0.624996346792576, -0.7541964717139947, -0.49647257433248354, -0.33061982009405444, -0.5679831973294083, -0.6344415776978906, -0.010055954679084463, -0.0871454612720937, -0.5816432117875701, -0.9393258515283139, -0.769245563779605, -0.561786088716577, -0.74654192297267, -0.4140935534757406, -0.5743134216471036, -0.6784157138840483, -0.5772356942515118, -0.016650053173593613, -0.07286229925503275, -0.6927479645689109, 0.31739536311444044, -0.5212283895374055, 0.03726963923272932, -0.43008014071680173, -0.3309016352916249, -0.4123518111696413, -0.5262819716155072, -0.5440372123630078, -0.6738803801212148, -0.768028547829251, -0.8151868066725665},
    {0.4699612527701791, -0.827070887233043, -0.16767717113680286, 0.3647181926430076, -0.6246983429022565, 0.23274437390158628, -0.5087324038420021, -1.0265353255472836, -0.7063103404681228, -0.8743806583188097, 0.422247162341157, -0.6856411922194592, 0.3987204422803312, 0.24081803479997382, -0.39346347430894246, 0.34068065068791653, 0.38843194804384196, -0.5330642963969188, -0.6309519564270899, -0.5828380292226945, 0.6456127827043231, -0.6875621784753037, -0.5738787374650317, -0.550416046753937, -0.49772015753426396, 0.3774592427332129, 0.142009778913837, -0.1185150236926107, -0.606396487220185, -0.39862965496739433, -0.5933174705050906, -0.6512289041473007, -0.5250134436244445, -0.937160490587452, -0.5800808962674534, -0.34842921857966036, -0.3419285053173261, -0.41421275654286405, -0.13696685219605115, 0.3696682597894177, 0.5419257149217666, -0.6795368778695023, -0.5942163913317076, -0.4145498796504341, -0.4260233809075076, -0.5526687025599272, -0.04159299166403617, -0.5053950339794155, -0.7061368041767736, -0.8690351813014578, 0.30968884293216126, 0.6719772012462909, -0.4776862414908479, 0.5116793216666484, -0.1926135232139366, 0.18112872988785553, -0.06952407572805544, -0.1763207508251044, -0.5389976872180811, -0.5588427766506155, -0.6701244339230921, -0.26069079332682427, -0.5123208181803207, -0.7765366718060984},
    {0.6698675953571861, -0.29835902556261557, 0.444090886639592, 0.3595792538594795, -0.3095937715278776, 0.5259106682920236, -0.614234084329752, -0.043787951088318774, -0.3065117593352025, -0.2963576951802701, 0.3085130582849239, -0.4194042838093475, 0.5270372432488467, 0.27421973457909976, -0.20385711528325337, 0.5673825016967069, 0.5224761212682455, -0.17031096414002517, -0.2854370324835609, -0.2493542722367564, 0.658634994018051, -0.2892610132756598, -0.30022103015505724, 0.05072626190239806, -0.1480456915096933, 0.46531345824900455, 0.4883031081956326, 0.1727273715658928, -0.19256860384449273, 0.4158658128704354, -0.2675829724452692, -0.6193622803035062, -0.32031313491793906, -0.6700955604990598, -0.3587791497090316, 0.14863385435643137, 0.3220234982770869, -0.46071765074755755, 0.17233851886178392, 0.14457201046127732, 0.4676198534794477, -0.02530075826030342, -0.4153949165747683, 0.07287279722369262, -0.3891361614639687, -0.2715501643392039, 0.021504745291901377, 0.01376616039209417, -0.09944176033185555, -0.3887610891595898, 0.42966128015404126, 0.41156127210012083, -0.1250884447140835, 0.07460120397213538, 0.399350530530031, 0.3755343971225199, 0.4512823112914231, -0.13430362388061368, -0.43056024409631094, 0.32056848684553, -0.5904487018484155, 0.28138587528054526, -0.38227559002662925, -0.5805568974966153},
    {0.4569251267020133, -0.7035311331428054, 0.2538690879717708, 0.3907615285322429, -0.4182956017098367, 0.21041883465746955, -0.5402359546455395, -0.6224980008368609, -0.7520634100376725, -0.5015073251779055, -0.14003836125943728, -0.9098215087971226, 0.3181072383289676, 0.28572474699129025, -0.27181892367523736, 0.16528378816569772, 0.026205933406265702, -0.4850426079773732, -0.5688051951956293, -0.641910447829984, 0.5436442698654244, -0.7195162970438631, -0.34642501628300515, -0.5199106929521001, -0.741762649863672, 0.70525863091896, -0.1224819873492254, 0.22192139514668788, -0.6036368067593769, 0.3269532272193679, -0.3974607155642862, -0.7176920039040882, -0.6205924776533255, -0.776017434535629, -0.3222401588149951, -0.30806925899913956, 0.15271779142893493, -0.6849791815488298, -0.4054799189978003, 0.02098151172610119, 0.034702136044057905, -0.38422262215552433, -0.6217367616322703, -0.27128506740608743, -0.7757802657643904, -0.5668245627627435, -0.26318316247907303, -0.40751393566890814, -0.4132317472451532, -0.508613124364362, 0.33796834428483197, 0.06858851796030575, -0.15009072851724725, 0.09515180837897062, -0.1595245786995749, 0.2250708887665877, 0.2316630670684171, -0.2389757769161268, -0.6582882963993277, 0.2187525991263832, -0.555036037458615, -0.01272826574609505, -0.547485144496038, -0.9827964346138269},
    {0.31456630517487494, -0.7698131986573908, -0.3322445334147312, 0.323354698482504, -0.564477231908196, 0.27165481898703836, -1.0055757370053031, -0.46622716171282064, -0.6911466176318865, -0.7596448015093921, -0.13432132014751236, -0.5492451262632578, -0.17961974652345217, -0.07403858763618303, -0.4947468151234528, 0.2829844914225817, 0.4506344061652359, -0.6114348964140967, -0.31112471577518014, -0.6435937547061474, 0.10358935202056183, -0.8218943791424977, -0.5303050950624104, -0.4709026289347933, -0.5299217158392522, 0.11679082816615036, -0.2805781582440317, -0.2415942247831997, -0.7304840108835993, -0.299583407924182, -0.7522883496777294, -0.596374224946365, -0.6641865513998769, -0.6715972364348908, -0.3670674996860079, -0.3787757158314043, -0.18713424943646786, -0.5826107170349566, 0.06722773545277651, -0.05084256468619896, -0.24383314111524448, -0.3573127330280341, -1.0509435872993405, -0.6631083524408707, -0.6807992268684594, -0.6420470185883536, -0.16910074542063272, -0.38699522263724945, -0.6178061491050192, -0.5959999290314989, 0.08924762749154494, 0.14045841873386977, -0.3945707795397184, 0.3421849846589861, -0.3431502536340493, -0.22871938129422548, -0.38308129449116385, -0.3289294187267067, -0.6020297567129379, -0.1950012804735506, -0.5134724135095593, -0.22909397270909615, -0.5872934361707243, -0.6225527434516388},
    {0.05256344850428655, -0.597717824699867, 0.3655416865442019, 0.13869632461880188, -0.49792647989401684, 0.19691474659571273, -0.8071524493096666, -0.3214661783392545, -0.3614608750663989, -0.2868094294270017, -0.04870648999841179, -0.6925195130399464, -0.03116919195499193, -0.18724940128647988, -0.548293852764869, 0.23963217911429385, 0.23280733091059388, -0.3394520177168688, -0.19623661435704018, -0.27857210948224553, 0.29360294929376035, -0.7625814822319831, -0.0742760359947695, -0.24063650454120677, -0.22149186357449718, 0.36670331164672043, 0.29460507306697314, 0.08735745890568952, -0.18803897264924066, -0.12307506349087667, -0.487519512774181, -0.7750829014588958, -0.7601707969686575, -0.6800025638480206, -0.5763119975023718, -0.32391615463881085, 0.2895720370365015, -0.5750178950612458, 0.18184733152937135, -0.15386546634971515, -0.2869085365397644, -0.22511939991709096, -0.9175643500206233, -0.6390172119104064, -0.5640199857062285, -0.3865468305777356, -0.2791195587204296, -0.267238431088165, -0.5532967901105682, -0.5734663726134956, 0.2323306993552376, -0.11657989073363147, -0.4607938308493758, 0.17958211505304916, 0.06555215312992456, 0.2006743485961118, -0.0628217490655138, -0.44419394611046464, -0.49575506808573455, 0.05549013881355107, -0.8421860110118703, 0.06375719235352478, -0.5328664033378818, -0.49294375370440524},
    {0.4148039919704893, -0.8409504285779007, 0.1056279708467037, 0.5913452241295487, -0.5989165154853205, 0.3820969435634817, -0.5908343789870238, -0.36540166820537706, -0.46976031089318926, -0.52693183957977, 0.10759725639200035, -0.4100105807755463, 0.20138316792239697, 0.3395328092017455, -0.6608744576612552, 0.10433979955640427, 0.3435600975235701, -0.5285681253513547, -0.30528538778959735, -0.3881423639240572, 0.46730234384207675, -0.9434824717917084, -0.306175636292555, -0.18460555624888628, -0.37957387784003593, 0.6263178185105095, 0.3478384978957907, -0.06438092683081323, -0.25410624286798716, 0.03365560011297445, -0.5284928304328625, -0.5192847696055581, -0.5474698482574509, -0.6794166928244938, -0.31909113822771273, -0.37419391593984885, -0.06847541110472374, -0.4058033291521096, 0.24006156686832822, 0.16903496442314006, 0.06071314090100988, -0.17355989022053447, -0.7576802159910121, -0.5203796945540955, -0.7095910605190988, -0.5307090754138388, -0.01763090126754388, -0.3679999417420871, -0.26770221005690364, -0.3046530839658705, 0.37023563935462156, 0.2702669560921795, -0.7916015090216817, 0.1940294168783002, 0.29123561966703443, 0.16744699511345526, -0.48785067074561417, -0.23407790096607797, -0.39706064997543916, -0.118144066428755, -0.4941332546552737, -0.118254286987359, -0.1839309472171681, -0.6476709265926703},
    {0.45905586372545054, -0.6599674412893272, 0.11947656455749721, 0.4046900133795843, -0.561551417761978, 0.2637013594952374, -0.5497844173901775, -0.3693065866596905, -0.5068021286188231, -0.6664821604789248, -0.17484966460707665, -0.4949823903634339, -0.022378875353076512, 0.19082540540711992, -0.4747752150136186, 0.27332256244588005, 0.43021999761290497, -0.7284023737459767, -0.40034380242830003, -0.3004445010333861, 0.3663429181206363, -0.5911897264608486, -0.46874311081495634, -0.5992720202758786, -0.4723343178680952, 0.3304765974272734, 0.12181123952818596, -0.4129609458189582, -0.7195603183561884, -0.12797184568795159, -0.34391810395137506, -0.6320000493274929, -0.7832961869191041, -0.668582366712017, -0.666883846819393, -0.3799587891579229, -0.21419671612450594, -0.585357867020292, -0.15327428912603114, 0.1543635497659385, 0.3040320958663977, -0.49868386698222883, -0.8658305938186651, -0.6935107989694851, -0.5479031996578699, -0.7385882592952461, -0.10770925011592508, -0.5027753243031564, -0.6614385428758592, -0.3280933100842179, 0.3241241369307856, 0.13248003929697777, -0.432395011918979, 0.5283262774236467, 0.10155234167474177, -0.09671359300982312, -0.337594781226463, -0.5635362480299372, -0.39451759818361737, 0.024185152424587932, -0.8292218439687665, -0.43712371851821097, -0.44299530998391246, -0.5970751680208908},
    {0.6015319794574921, -0.6944397162116293, 0.18178433684549797, 0.30766022624089895, -0.5224510473241211, 0.5144055638130376, -0.6059754136152583, -0.3076834225204322, -0.6203537142177143, -0.27305196299048556, 0.10724145315101376, -0.560909007456445, 0.1996358508666004, 0.3773736785406385, -0.17510716310507313, 0.16179992715516842, 0.19930042252622165, -0.5474156164201072, -0.22171285041225464, -0.3643265074681036, 0.49871173060601676, -0.5506873801511959, -0.3674419197498519, -0.3593671572052527, -0.45290663915693574, 0.46121107848987236, 0.07492643342870134, 0.09143858908231495, -0.5205170908037469, -0.12482844956932106, -0.35903888038030074, -0.5352076165324572, -0.8122167897834957, -0.8465665287407986, -0.43844688207867355, -0.100957009870056, 0.2890187953688018, -0.4393815743674608, -0.059649047436581545, 0.27902383785703627, 0.22750570877073095, -0.3656090801893524, -0.7648958567653918, -0.5253047384848767, -0.4950807726651977, -0.5436908818579657, -0.3040505310101672, -0.3752182529942965, -0.43902397290705786, -0.44074536217583493, 0.23617016943457897, 0.42180135564384924, -0.31590838512660246, 0.3259577603498481, 0.07765582076060908, -0.06583768553159894, 0.3088721951000543, -0.3828599656289182, -0.34627305958731447, -0.0759907114274716, -0.36143686478467946, 0.05092062625870005, -0.5077240510836121, -0.5568041878739783},
    {0.503937577956344, -0.5990136936760123, 0.1627280105679031, 0.2553683451058483, -0.2821375935128893, 0.33646870781262533, -0.7332175473862007, -0.1426399171679115, -0.643742657116164, -0.3529005753911156, -0.17872857508483397, -0.7672176213632602, 0.5110227967195788, 0.10461036926908739, -0.3239073174077741, 0.32083604067053045, 0.2976814694398639, -0.35459915817942905, -0.5699048781367999, -0.26189519558281, 0.3660994465712238, -0.6889433837923389, -0.22297025015553043, -0.5383107443052945, -0.7174021111703236, 0.4629900326797994, 0.1384879343079014, -0.053176317715889876, -0.35838174664002753, 0.0878038549529882, -0.0983357920075244, -0.6652926277519654, -0.6464670035174735, -0.7702600857316874, -0.0682852139053231, -0.08183072734050667, 0.2434427043801806, -0.5419178742604593, 0.054131797596133874, 0.05216350453545103, 0.014998433250813594, -0.1715550374298328, -0.6922757545026629, -0.4242322617484631, -0.5066353981849532, -0.7457496655215294, -0.3681673475273146, -0.473395464808991, -0.40798775029520623, -0.5922157591617061, 0.4019217172250561, 0.45958469994129286, -0.5570346144906823, 0.21469581443427116, 0.21675626435388864, 0.44473651103630923, -0.11960944060985752, -0.21925152799575706, -0.5587642501057732, 0.1244065092850787, -0.5634145430570695, -0.20643870809789006, -0.11134502921747465, -0.4971190063060136},
    {-0.49328918654340687, -0.29893114213266897, 0.29154018136422916, 0.09984441849593424, -0.10523856789105476, -0.043654988842848026, 0.014327238982199633, -0.18347114183897142, -0.005014109385882848, 0.12893286925567962, 0.3554526297717698, -0.4470001998982162, 0.023273655779981427, -0.6105943786237578, -0.3416594272704698, -0.5831901163137891, -0.7130013319643131, 0.21810232795018908, 0.005416707775020999, -0.0674702805908694, 0.3086152197788878, 0.17069766912147105, 0.13324236107531384, 0.05241874122734096, 0.14298203559200034, 0.09152185632649658, 0.30515701982492915, -0.3170989839435967, 0.566640528951085, -0.30534603613682026, 0.04109619596650437, 0.3162712117474547, -0.36327209695263574, 0.5209455839059413, 0.34758104343180507, -0.03421137994896389, 0.2309879495650261, -0.07479869919110087, 0.7006797445344435, 0.37503659397578964, -0.3980071925138257, 0.07020937632228404, -0.41825988033366474, 0.2960871024906082, 0.5738455742688966, 0.19990860592748005, -0.24910290300197224, 0.47956264941341337, 0.19286705777936072, 0.35562954759950854, 0.30527034873169495, -0.2675417452313155, 0.4194982942864959, -0.37517550343891837, 0.27902677793238406, 0.606705418550457, -0.30398272697589546, 0.04221941565998302, 0.43040579042332866, -0.2551822986773554, 0.18732233419085256, -0.18314408648411062, 0.03989776956696889, 0.15130513876731574},
    {-0.588429821911394, -0.22666189974968645, -0.025111221769698825, -0.42694968571052255, -0.1294546193475902, 0.3075158310160509, 0.023085654021605763, 0.05810673808001791, -0.0388191890802165, 0.30526778000116744, 0.25745218285807886, -0.49319268008438016, 0.22116137144659043, -0.3836503338772643, -0.330997567397536, -0.48141588916194084, -0.44728089518821984, 0.1046137749587047, -0.2943638171897721, -0.35905309381327755, 0.23319266473631875, 0.3878772296990587, 0.3057384791141755, 0.41023444579091656, 0.1405388058730392, 0.25300985020205136, 0.11718505671507908, -0.1331853206102159, 0.3368276996942263, -0.2684278463510552, 0.16112566368720058, 0.3629305590132148, -0.15644110266376798, 0.7246369239194846, 0.2736027836512494, -0.05486748741870886, 0.46281866192578835, 0.039657182999503236, 0.8211301310450079, -0.038729028870699, -0.357931759502333, 0.40545200991817393, -0.1033856968049197, 0.20401197946337588, 0.4820694902796246, 0.20690718082510573, 0.08622782865989793, 0.4173023476543296, 0.25511484902138465, 0.05923440255785333, 0.5205451321503743, -0.41638815942644003, 0.12140103237756245, -0.221189772054509, 0.6202056092536496, 0.7569010308476574, -0.09973451481664909, -0.561493649632867, 0.4783045559584074, -0.22393122571747417, 0.03518698808888366, -0.17697073340574984, -0.15057779108627609, 0.12730939493421123},
    {-0.36730827205125116, -0.05333043736683234, -0.16626355939065424, -0.43545769035653215, -0.34269207626135906, 0.18344959042669387, -0.23796376358735874, 0.1717943733785822, -0.2811867674046913, 0.15796527029555973, 0.3331378503171389, -0.698070784796972, 0.2827684489085769, -0.4441672782266517, -0.5760489222944244, -0.27410896618836905, -0.6307989870938687, 0.3344738647266505, -0.49533284177093173, -0.4952322206400846, 0.5904766560132866, 0.44106497420427415, 0.34609716640603755, 0.49537405468167095, 0.29469303613293885, 0.43521539538604714, 0.3191446012949185, -0.024530070174980736, 0.25165434505860745, -0.11054557311517244, 0.1788900544461532, 0.4745496964738035, -0.41097258614529375, 0.35500283518484377, 0.6485875952208984, -0.1632458689656341, 0.40804915806480424, 0.26745947592207764, 0.8791784592683818, -0.35726185464723276, -0.5693942370483484, 0.6575823523805959, -0.16356865192116524, 0.5303704863325676, 0.22635077529055414, -0.03732559238801142, 0.6556812873478665, 0.5290039077952176, 0.6375053232958364, 0.30721240633908153, 0.2354563673262601, -0.5008135055265555, 0.1329472190440749, -0.5014370004724077, 0.9582113335238878, 0.8579452672852178, 0.027803666212736958, -0.7350599715046634, 0.35306595532688817, 0.1480184691557127, 0.37102041361093885, -0.6480884769656634, 0.359579322412005, 0.57468102006859},
    {-0.23972218664645256, -0.09073394316081089, -0.05903495362558055, -0.7126568219245193, -0.1901122554297803, -0.13361854481994367, 0.0421443399282412, 0.31658162528294403, -0.5505220066861374, 0.16472966757941948, 0.18443826633039465, -0.2996244876554646, 0.37629717497125686, -0.5703668526450384, -0.3930027677411496, -0.5054527467772373, -0.3236483681618447, 0.4908730427744448, -0.4811494246554248, -0.7054040286180391, -0.0977811120001339, -0.023890469149727724, 0.49477611996545506, 0.6960670266727516, 0.10782637625680727, 0.47652838253817026, 0.06469556266911546, -0.2899924526441357, 0.4003424669660448, -0.051239656960440846, 0.6118243375704374, 0.3912358085128666, -0.5266052328474401, 0.27702723838345944, 0.44863822336075765, -0.10108787001851442, 0.5425677678334859, 0.05900618388997389, 0.6291110868994604, 0.22582386553702904, -0.3787130443407601, 0.589148286825302, 0.11674082054801051, 0.2580722922101174, 0.4251743395048604, 0.18478503628225987, 0.33461512650514985, 0.5386881651010764, 0.4782038247488893, 0.004527233883457152, 0.36826903282584206, -0.6084933206270775, 0.22127215014923526, -0.2316650294395062, 0.4893298846762361, 0.4332120719039864, -0.34090897790558733, -0.7359334542598954, 0.38183394915018803, 0.2676769237792412, 0.4019564099962687, -0.22473428274611137, 0.47807108585870517, 0.5428253635853456},
    {-0.2453621870498427, 0.09925777294079272, -0.3068064676316063, -0.01531147291425423, -0.1716493028303037, -0.2889180300379606, -0.23028045370961298, 0.23982678152224143, -0.4282688271500466, 0.2741854976129818, -0.04208503688081209, -0.14968000348085808, 0.24238486523192176, -0.4289049833412207, -0.5571526995818226, -0.33331046330945796, 0.0038455057286563227, 0.42149867406425, -0.7587754423350218, -0.7823906244131393, -0.005291129955608135, 0.31977419086166214, 0.44369975989019705, 0.4685071928841576, 0.22059936749151263, 0.4057931184313357, 0.13213353582250498, -0.16536052596370457, 0.36863197145081494, -0.0843360990187765, -0.09198234636040353, 0.40781591090954983, -0.48433967288102264, 0.3223953855993087, 0.14032364799681651, -0.1116486926476773, 0.8743794664412544, 0.11527464170399687, 0.6946031433850023, -0.22156681903068196, -0.310818379981333, 0.38553388104493735, -0.08934695983801307, 0.21316428412193517, 0.3923217471603473, 0.10919381710254597, 0.4130475535605134, 0.2576242492015754, 0.5343773514738572, 0.22296670934367474, 0.2754643363638562, -0.052150339593277945, 0.12337162611499898, -0.42910508150443133, 0.5475632012401276, 0.45056750277602103, -0.28091875460964694, -0.6936756796742447, 0.3728359961177758, -0.13683724677213782, 0.16582220510785034, -0.6158499654449009, 0.5689664515714934, 0.4227511131355773},
    {-0.2766587378040325, -0.221268736250664, -0.13424740007899783, -0.20550778964259625, -0.41282924396458653, -0.22107615419110874, -0.15665024089509835, 0.454784753574571, -0.47812564584881256, -0.011339202856984454, 0.025771439845497332, -0.2722071576183638, 0.38480056229784343, -0.3669151203989935, -0.32721131854926233, -0.43370528204399345, -0.30486261550770943, 0.35625367803068775, -0.9055403755404776, -0.6656504032921371, -0.26397803741323606, 0.6205522667471592, 0.5904111253243396, 0.48494310110856526, 0.20854840668144545, 0.2862875125424638, 0.0345778800872018, -0.045822346085495354, 0.176042484429551, -0.37225210055542357, 0.024089537451600605, 0.1667189639472858, -0.8236738360532847, 0.11158117121757123, 0.4896480354023556, -0.18405794667996855, 0.6820791843838749, 0.024758769246972612, 0.6169134099130994, -0.07473525322534182, -0.465041489054133, 0.627617584012058, -0.032215066278788416, 0.17947451292933483, 0.11413716996944034, 0.17824088976371852, 0.11172026171668109, 0.2083749571919186, 0.5461502199606016, 0.2474308110867076, 0.26087415869794117, -0.3619576130917694, 0.34668361494782196, -0.6049742143701389, 0.4704672259298559, 0.5780391239232903, -0.3549070881770479, -0.7785025014898141, 0.3896110426332211, -0.011268537374001297, 0.47183079256550386, -0.4717772032860978, 0.4409740393175598, 0.16623975906728025},
    {-0.5138542621836684, -0.28187511809680094, 0.08013957075245233, -0.39172853478343983, -0.48022322324174105, -0.010210971253746752, -0.3461276605703536, 0.36668495236486687, -0.5175749353721809, 0.5264211420450345, -0.08654968043769405, -0.5140352971265805, 0.4396679037319728, -0.2973900434213553, -0.5275266437800167, -0.6272545128520156, -0.6117671940992057, 0.16065084505074007, -0.6493535210779567, -0.10156848365796334, -0.08716091253818367, 0.5486848671840591, 0.4575329549694559, 0.477211978044448, 0.36496201986141036, 0.46906904705308905, 0.1411481608571111, -0.15510793935763256, 0.25806171182504983, -0.2739096821989193, 0.2484027561036022, 0.33314507901086926, -0.37203384815387414, 0.5841979288784187, 0.5994394842227696, -0.033961631458652726, 0.8164380994889787, -0.08953166469020726, 0.520882738839723, -0.045319513856079935, -0.7871849182067984, 0.6989982239273695, -0.101269024887861, 0.4202954012242029, 0.4079876955458092, 0.08989914287780068, 0.2416308446947974, 0.5803451552696492, 0.5142177597844959, 0.3070966012535813, 0.3414326859787737, -0.5011419386855409, 0.49224304651126904, -0.69440021539267, 0.7589729975068356, 0.7953161106499014, -0.23551126736937553, -0.6101787120803692, 0.411673289173194, 0.1075204717415993, 0.3181291765941787, -0.528167969303093, 0.1762364006225799, 0.589814555461794},
    {-0.7374300860733114, 0.11629377610253988, -0.3393888357842752, -0.19823599382857798, -0.5052961862984121, -0.06668053072561249, -0.17771687085782492, 0.3250617000811034, -0.15205028656464556, 0.32596931749934677, 0.3505199106487997, -0.3647668487434831, 0.5954824235024113, -0.4902923307715235, -0.5456245693525827, -0.7220535928894098, -0.5129799819028247, 0.518159138918149, -0.5487815711636899, -0.6615438712654205, 0.07212389331859152, 0.3890217561816048, 0.6192372211321457, 0.630981295119109, 0.11825649324670269, 0.3339198538358762, 0.4627383409888363, 0.08302742610705198, 0.7629363523944822, -0.21340494806725308, 0.21541310492209967, 0.37852341826759506, -0.5873087493612518, 0.4492345297780677, 0.5621310518407874, 0.22329535988711832, 0.7267140970346191, -0.20954434391132865, 0.6589865477014505, 0.3893889426429221, -0.5734275904350339, 0.5995111110874155, 0.25116122018509596, 0.6354404665813741, -0.12786493926052084, -0.30534430665695034, 0.27501905731260645, 0.7683506431578708, 0.5164476740370055, 0.4575520763294563, 0.7533983557772129, -0.5544516419079205, 0.37927954581239, -0.4127611904745584, 0.47546435176275703, 0.3279334842926556, 0.00597302066056189, -0.35055420681975413, 0.5200677617670121, -0.012791795189963677, 0.46246632634059626, -0.858171532453227, 0.19174890175909395, 0.27338172610347933},
    {-0.3166225244933675, -0.4064206705827374, 0.24878022006602998, -0.4741687752877274, -0.05240423132278987, -0.21971343301959617, -0.2557794812291646, 0.10565662530885675, -0.21905425277702278, 0.6628154137281667, 0.22755404883216293, -0.310714135706014, 0.3990696899723173, -0.5277114634656523, -0.6537699139272362, -0.526512054330922, -0.5318375090925235, 0.6481546558143956, -0.37710833212422373, -0.760319473872683, 0.19645872187877958, 0.3809065868533576, 0.6853626602587585, 0.6647026807867445, 0.3094936718995492, 0.3234660259359462, 0.30694967031263803, -0.2628733836346482, 0.4226136295582754, -0.36074023777636194, 0.1594463767166668, 0.6370093410234393, -0.5884939649745304, 0.34246700806302693, 0.5537794937722755, 0.1847229842400333, 0.6335636001000915, -0.10399664833836995, 0.6620668722757229, 0.22532917111113018, -0.20152435318216194, 0.697834974990287, 0.022322387965493705, 0.579823781471523, 0.2573238355604062, 0.216967110206882, 0.2505348115126866, 0.35398339689968694, 0.4179469931019766, 0.5359715504757474, 0.37740037086046146, -0.6141148849845935, 0.5036025302264128, -0.814393547666886, 0.625244598557123, 0.8122340162030204, -0.12420883409813899, -0.6948712669088395, 0.2807937996757684, -0.381609725719267, 0.5055095054245123, -0.3410439877995924, 0.3459074581153696, 0.3183644614338297},
    {-0.1918641566652078, -0.4642935357656728, -0.19529836249153334, -0.5382725324940605, -0.233454084507693, -0.06900114074435305, -0.021862657018233735, 0.2302461032712992, -0.19273577146190082, 0.3536299009090375, 0.6023508137354658, -0.38093617883598546, 0.11433533971613992, -1.0091777689884665, -0.6409799495653834, -0.6287525976529831, -0.5352926884961771, 0.40237185799790376, -0.7307206494618805, -0.650591721503744, 0.19761552352721692, 0.25769973374269517, 0.43267813966544755, 0.5627325334606771, 0.45436661256765437, 0.12116151277029943, 0.23004168187312585, -0.2997582106680687, 0.7150360391912213, -0.5288500886407232, 0.45186547032540253, 0.40678451117060976, -0.40530881956844517, 0.4367199232153555, 0.3802703446065033, 0.11545265513979176, 0.41025822444327753, 0.27455813716331656, 0.82916830835197, 0.20385712394843525, -0.20982723118233593, 0.7046510447408535, -0.08047068282827827, 0.3170216896627101, 0.5757294563758711, 0.05933574532155844, 0.2857278003543227, 0.5270657546847328, 0.579066376005152, 0.751620060092855, 0.7363126354321217, -0.6051280767081826, 0.22235906964247348, -0.5362300794514939, 0.4966855273067917, 0.8136997110593183, -0.139641325862126, -0.61473493939267, 0.6144949408297845, -0.09025471645618875, 0.42844802705872165, -0.4740938832767822, 0.4915800646228272, 0.6096887337495717},
    {-0.14103573960370858, 0.0012849567511594821, -0.07284378162428225, -0.4659683225237463, -0.5449826117438603, -0.06401518776353604, -0.33109757397808126, 0.2567095116201834, -0.10047067046132331, 0.15145797279489712, 0.4030320798982184, -0.16796182873279847, 0.26277055304154456, -0.8809199320617577, -0.6220717284200644, -0.31804253846872094, -0.49660095489696165, 0.2884566692094331, -0.24303599273628984, -0.4424540036270641, 0.38196725479153787, 0.2834913762546361, 0.5925922576650252, 0.4859000754093041, 0.5666225339066454, 0.3124844049882307, 0.3430080298139678, -0.4693463183796919, 0.5960610844597619, -0.28343667137902, 0.2794558802803622, 0.5901069579094933, -0.31895358179233135, 0.5526055993656191, 0.3722546383566481, 0.41559593951678697, 0.7238107238185638, 0.32107253914591055, 0.5010751606661572, 0.11192958057078722, -0.6399730847216119, 0.49693220497095836, 0.11614398900042149, 0.3016144341401345, 0.4713365271713886, -0.028148697918978373, 0.2675062730491492, 0.39721202363228875, 0.4306399589769671, 0.48939125156868435, 0.5540524867329654, -0.431449619246687, 0.3602462668659569, -0.5141446020126416, 0.13016247530472203, 0.45195473877298264, -0.18573442439790444, -0.6275145211011547, 0.6598325181094914, -0.07296736408029458, 0.5028020571904442, -0.437562555001748, 0.33327446684510575, 0.5199198823816478},
    {-0.44294838431503736, 0.08056110877792814, -0.22365876283377972, -0.3987989056767178, -0.3527464666375584, -0.24055279563102452, -0.69986329736174, 0.18300488382955513, 0.10469742322169699, 0.27707755357713154, 0.6089460266650203, -0.09067593205594532, 0.3267380124108499, -0.841238989671726, -0.6037312310613153, -0.5092115729409074, -0.32440332217342277, 0.55702154473242, -0.64878167355166, -0.7340521143492315, 0.3575200194703211, 0.5157839808933786, 0.4858476342573587, 0.7311492239273206, 0.07285654306608859, 0.2604040839191195, 0.1329310565751927, -0.16257814377223134, 0.5306409674829923, -0.05239938470534643, 0.313453704048795, 0.46887471342254194, -0.8707926060350235, 0.41964202682231533, 0.6255269052401761, 0.03899051010652143, 0.4697028352876673, 0.11759049920987383, 0.47787415279097906, 0.28528445961204546, -0.45944081380122465, 0.930477442870776, -0.11577849739636373, 0.1754336318962242, 0.30493032013871435, 0.06956772072539266, 0.35814029281885223, 0.42285761009749884, 0.45120363722663304, 0.45152753673632734, 0.5530143735191142, -0.37297790765338085, 0.3074902100725162, -0.3678475529692911, 0.5382924572187681, 0.4625792152494162, -0.1011232528615388, -0.363716620092986, 0.2694002979770361, 0.07768961324520185, 0.6001630427243148, -0.34955118387632195, 0.4053741427370699, 0.24326616599587703},
    {-0.5267644410971881, -0.17380917171479482, -0.022205026402774365, -0.4202104616533291, -0.5677939960393206, 0.07692740435908169, -0.2005107146857915, 0.3667443374165224, -0.23273746647315685, 0.5162514102181706, 0.41530160347823214, -0.3192933531650977, 0.4520201558192635, -0.5474574804216562, -0.39675760094641765, -0.42096695356176095, -0.40786016534863745, 0.5625788250941716, -0.696926163528897, -0.6520772833928877, 0.08522868842503191, 0.21865931554222812, 0.4727308683622345, 0.40902202867546494, 0.022800232092201955, 0.10235885958198498, -0.16705771531627212, -0.3082965165717994, 0.5727897505070733, -0.022274500773783894, -0.0065545881614048505, 0.2639326633929014, -0.6787160333805466, 0.3937028441159827, 0.5282684969750259, -0.025676390114652975, 0.6507065369902778, 0.26692876111211944, 0.8681539194209121, 0.0769289805580502, -0.4679883886125314, 0.6617420250188929, -0.5080910520260833, 0.42511827141715813, 0.3367574982141932, 0.5647837135925649, 0.04042637771091704, 0.38253912678377805, 0.08422278205567298, 0.469037189091086, 0.530868776477088, -0.5875935453493512, 0.215651379800747, -0.6245637963514121, 0.45803477038641294, 0.5044798387153617, 0.10284125518012013, -0.524771582145502, 0.3953321746967536, -0.2638567795854474, 0.545817821562508, -0.3547175830401462, 0.4136628562771028, 0.3410709709059735},
    {-0.30708105897154675, -0.33443140209081906, 0.2868345727798457, -0.5048422386884719, -0.6321642075438135, -0.011643777935744622, 0.10567276168011629, 0.5364934099272244, 0.012281577906732215, 0.22741678955666092, 0.25184807564034456, -0.2993535786630031, 0.41330470910076744, -0.704647025720262, -0.752730018994691, -0.5324887475792418, -0.5101925010578635, 0.486353020703817, -0.21842114581771013, -0.5528213043243438, 0.13382356448577798, 0.2908614464402692, 0.6204872748787839, 0.7003594840634957, 0.0582604528066269, 0.48620062351763477, 0.1601808246889944, -0.13891928680932636, 0.40482267233985336, 0.01322714386602482, 0.039732216647420576, 0.6226910130858878, -0.576857818756, 0.41013428043557837, 0.3788738740027273, 0.08791337712913537, 0.655496559634288, -0.03911942787166847, 0.29642290729481385, 0.17583621643245137, -0.36855237553961784, 0.7890702880173195, -0.3017299480883242, 0.5000421962036572, 0.5741494694074332, 0.2194401821998109, 0.6357828964219108, 0.5584180956232162, 0.529485119479493, 0.5072157230019991, 0.5177482546973007, -0.4857256073485269, 0.36683946508410775, -0.5493952747123637, 0.6159180024495619, 0.4259435662574471, -0.10297229063238841, -0.6695958990188412, 0.30572371394549647, -0.10183121418991714, 0.5547257632363412, -0.5197798697864012, 0.29515641101761264, 0.15278679833756567},
    {-0.3900599528665152, -0.2148417596015789, -0.09229885544731063, -0.5469232135072212, -0.3711337537340216, 0.03926311710954864, -0.44682479567664235, 0.3205922492218074, -0.4856620201806677, 0.3141221727634053, 0.16729897717715772, -0.6219670565333174, 0.14293966303485917, -0.7535223911157211, -0.5320182271969291, -0.5252217189689037, -0.5715570539360965, 0.8143422105549214, -0.6186785613756325, -0.8153486416535798, 0.10546009379927564, 0.323866529560215, 0.46380976933477863, 0.4425805305739126, 0.33584795320324035, -0.06293561661235635, 0.21583404628796343, -0.5139400784406154, 0.43980610508449053, -0.5711072124821117, 0.652583644215089, 0.3898590787443947, -0.4234183423314752, 0.2196786369888749, 0.7665467169431159, -0.12258740448767332, 0.6866977942981288, 0.32633213405697664, 0.8808298985187764, 0.42982018708809694, -0.6281679882898903, 0.4344948424058848, -0.23226139048273559, 0.4029196184451826, 0.3338859568189563, 0.2930247207518968, 0.1888665937031121, 0.6248644115138948, 0.3572483764203269, 0.1327353362335632, 0.33262312406713296, -0.48850845126330805, 0.36075438838825347, -0.2811306306770986, 0.5628507545247375, 0.7476101466327724, -0.12192785301327445, -0.7340575096767863, 0.3859509110707623, -0.12081437584331448, 0.37043872617137885, -0.39508918313472374, 0.2973605071570623, 0.41760977354359735},
    {-0.3946370730233215, -0.08004525496743495, -0.1175539081385616, -0.19846651974384377, -0.5798088898643113, -0.09098343984930045, -0.28579631803462835, 0.3272212010664848, -0.5521688013078597, 0.4810466847371918, 0.3095865272502045, -0.7424099456373978, 0.2256399217935349, -0.6474754475931512, -0.49568603703216313, -0.4217082589826338, -0.41760508614662056, 0.5671860214048623, -0.5860014342640812, -0.45085133361884294, 0.03093905168128175, 0.42101546359669545, 0.5192072809344999, 0.6585427111310955, 0.4947116046255829, 0.30368068467706255, 0.3173241544014236, -0.18237678563134938, 0.44121267719193313, -0.23807095876845444, 0.31590712131355, 0.34838822046214696, -0.549892283660752, 0.49780831976779, 0.2856382640654627, 0.05172243211125426, 0.558411558651704, 0.12755062176173476, 0.43039226058509833, 0.37190724059379954, -0.27053167827850005, 0.5731189731346985, -0.21875405023369598, 0.18667431903658657, 0.6164376645338323, 0.14202812964263625, 0.3316593107761394, 0.7503477845683791, 0.31931012243646073, -0.23210437633015824, 0.4587862522393151, -0.22305645036350857, 0.6843487476067504, -0.20436138903600576, 0.7458567147711858, 0.6720054871001343, -0.29724615504361956, -0.4387520943270509, 0.362260672222809, -0.2249369566288031, 0.5182778653657852, -0.3744121748033074, 0.2527663793379119, 0.1633136920634916},
    {-0.7416849179959477, -0.11353689829426583, -0.42614923125253634, -0.4188871497456891, -0.4563644633995976, -0.20804997575310125, -0.4133447384651915, 0.1935536633089055, -0.30960032429864703, 0.48429653499402864, 0.6661196951481401, -0.6202054249288987, 0.5492779051042201, -0.2747025457370576, -0.6580450357122561, -0.3987887665782539, -0.47792312078215043, -0.004139535009880933, -0.8912111342460016, -0.5995552370017855, 0.33273632665494574, 0.45679914931508164, 0.7189898458994289, 0.2672180214004599, 0.2518302320668984, 0.06451948628241472, 0.20990377474622274, 0.014061212235308766, 0.43867629434034583, -0.26113899366342475, 0.5009593501966187, -0.032119812697429286, -0.3770014588477078, 0.4713832721906278, 0.6639154328288851, 0.34870456599778527, 0.5095924294385529, 0.289136670635012, 0.3228925039265261, 0.573213869304915, -0.31527868207111837, 0.5682604312396227, 0.1919010741280165, 0.36561078716741796, 0.8033639563121879, 0.25713290930059346, 0.3512525078100487, 0.5960794587963777, 0.31256510333188403, 0.3277461914468267, 0.42351641380133154, -0.5423161507396926, 0.4914309929733392, -0.14351026465735822, 0.596284246778102, 0.5081863379975022, -0.210610291470895, -0.970347624732017, 0.3784570549364429, -0.33527465754830893, 0.49549879743105707, -0.42432873294782514, 0.41107169526426995, 0.2872789281711223},
    {-0.525424288985175, -0.3425548005278942, -0.3497797008493015, -0.4887977108996145, -0.19563715659969252, -0.25178469001259285, -0.4237060826478332, 0.5150492794801403, -0.054207828863709416, 0.6042015867344951, 0.7230382029548624, -0.44192480767288855, 0.5783325051233306, -0.567871145001493, -0.43420932492378805, -0.435693728634103, -0.40174777420677427, 0.43881976816963864, -0.41555993933918844, -0.6364240794757106, -0.04425309961402052, 0.44593515643695636, 0.5401736812244683, 0.5537088822404335, 0.2587069286418265, 0.21354716856300268, 0.4336217767659272, -0.08275890019498847, 0.5568306098017446, -0.5525970401899365, 0.32384470041584407, 0.722893067763696, -0.43576117960930116, 0.5100227890275454, 0.8218100783507758, -0.03279523977305411, 0.3826587542461887, 0.37124923799694387, 0.6377844909144429, 0.4405575589319081, -0.4281184394667455, 0.5174303817861694, -0.2939589564259418, 0.378834110394585, 0.5019746036930034, 0.3136648132873317, 0.8231256892549625, 0.6415167123163869, 0.6094472978317118, 0.2954532658061605, 0.4208557546490917, -0.42869022449641764, 0.21538958014543313, -0.5692298649202286, 0.7395771414204969, 0.7048761306855156, -0.10065156080618576, -0.47165986478216554, 0.5824660591739055, 0.10617994069095803, 0.42382809247480774, -0.6506306065191816, 0.6832253369471909, 0.3623508640038139},
    {-0.5959475958844677, -0.4136916327080365, -0.2843755905043768, -0.576497276853898, -0.041326574049624115, -0.486246546527197, -0.28164842723654027, 0.49159188550153865, -0.2085201333039007, 0.5209679680841776, 0.3180020198049126, -0.3424476271804263, 0.5511519754845619, -0.3651600744509805, -0.8482113761387062, -0.49144045787871804, -0.45347054239373646, 0.5008530857845556, -0.5681701823581249, -0.6230867569661991, 0.25703050780213743, 0.4829196471548061, 0.7751359157931267, 0.614933382226048, 0.3920621604425798, 0.4541832527181687, 0.303863674782151, -0.016877783479297203, 0.4487921421808239, -0.1767997147572738, 0.4732114093983423, 0.26071016584801, -0.6016561200224243, 0.3560350281447775, 0.7007758731100009, 0.0036747708000926913, 0.7798368918545557, 0.45738996790082037, 0.32430379578940977, 0.3039176996078007, -0.3454213289278833, 0.47900816360680876, 0.14163974268301274, 0.21504564573550705, 0.5200335817941407, 0.025610936693399627, 0.8001829940776398, 0.5706180808854174, 0.6718091953038364, 0.265036928326269, 0.37361031035183456, -0.4589567353072324, 0.15843704900095243, -0.355684828084462, 0.2956706076654301, 0.8888201497073325, 0.17443934422458546, -0.45297809244660736, 0.7414231115155684, -0.05526542311596446, 0.35732256515728056, -0.4380994445059248, 0.5314635864043864, 0.13835720454308975},
    {-0.4481557302500869, -0.31954202229052625, 0.025947724368370853, -0.28318129946291387, -0.4310747876279426, -0.7454077653549382, -0.03499661983509597, 0.4093034593382802, -0.2191577043762582, 0.4497178861669428, 0.3902433837605087, -0.6643698508322726, 0.6296807280682792, -0.7840336882124077, -0.5259923985570789, -0.6643512385888419, -0.5378950284929312, 0.6121596239728586, -0.7697696779625918, -0.5277208858974888, 0.30150467035052186, 0.33144171559163427, 0.33428279779146014, 0.43300293226529324, 0.7045490972517667, 0.19339402648989756, 0.229821715183908, -0.13565980339419123, 0.568250873786118, -0.02863045602177013, 0.4515153575977134, 0.42057621432612086, -0.37295942599821325, 0.18837788241689604, 0.6341976148292515, 0.1890897372222737, 0.934769472267558, 0.5707273657532312, 0.9008130232596182, 0.24322401825267173, -0.8275841924574183, 0.5953126047244911, -0.02414326352425517, 0.5419600589193341, 0.6688499566814812, 0.478506902002436, 0.5112026533800447, 0.35992659452263975, 0.4175769966429169, 0.14965212250483956, 0.6197570382513145, -0.13534730721529714, 0.5908644822468498, -0.36625788406666765, 0.29708411843807786, 0.5619222714936415, -0.06382838754445483, -0.626787397041169, 0.8617854146654507, 0.035055161254292894, 0.6863755622311826, -0.41202047676030285, 0.5651193809389203, 0.6304231244059676},
    {-0.6884574865079536, -0.2029857348725553, -0.12794698819794112, -0.5643478322695524, -0.5788477132396376, -0.44627549345910644, -0.5534085897564385, 0.17390183757095287, -0.1894546842252276, 0.4472094933376048, 0.4078071167793221, -0.39597482950172413, 0.3857567427439973, -0.6907288601686187, -0.6265290522674265, -0.7529449904372263, -0.7128818638969959, 0.6271095393399004, -0.5516868006428287, -0.7981422416155011, 0.28248034879285644, 0.3884971012063227, 0.5517381330646942, 0.4712496646876755, 0.1085061951233387, 0.24892645716436376, 0.3354532606637791, -0.2894596053734967, 0.42023817660354246, -0.27110420023325577, 0.6571045844890762, 0.2479344738180802, -0.4295584451864637, 0.26468059228195817, 0.573925652700849, 0.3096504896334065, 0.806149700212011, 0.5523649254060231, 0.5123718935214624, 0.3859883927992982, -0.5869539222698084, 0.7031441285076045, 0.09346367230995305, 0.46886809298877463, 0.571230792630732, 0.19973745204737584, 0.5907524096326361, 0.6469265682506217, 0.6235447891890789, 0.04769817681039018, 0.27469323905086795, -0.4569206283023531, 0.5089971715471411, -0.7778494810341131, 0.621506961123509, 0.4078102166865716, -0.11258594107380916, -0.7527109388878416, 0.6563988876931174, -0.13902040022137993, 0.5199888578394959, -0.7251758127686798, 0.34090384235167337, 0.39510908918670173},
    {-0.4732498953387886, -0.1182974309253752, 0.00748653932834943, -0.25716073200878947, -0.45492470977154525, -0.15847245334810142, -0.38642866859794567, 0.5212505142345416, 0.041271160026524444, 0.4910620948681771, 0.6491541510764854, -0.6028136386408699, 0.6026697907899372, -0.9101798356071592, -0.47006190233389106, -0.7319970807528693, -0.3120512674010816, 0.37471769361990126, -0.5220988381156827, -0.7406176278246182, 0.34491049926673556, 0.6814607941411449, 0.6032550804346302, 0.5310364773126169, 0.4316196455753181, 0.29496248380814, 0.6102022070842104, -0.5018575818995586, 1.0075635464843076, -0.4588902599327537, 0.3564405485070406, 0.5612947387462396, -0.5516259189246079, 0.5048747245032161, 0.9230266345592075, 0.3449782434143663, 0.4855249614555489, 0.38457687007849073, 0.7039457336565081, 0.38917733996135273, -0.45604212012098694, 0.5664562483461039, -0.2518488373072393, 0.4579296330226581, 0.7370442590896604, 0.121515289345578, 0.4642114828611552, 0.8112246216509202, 0.7317413240687243, 0.25446714899975237, 0.3808049162215699, -0.5497161656194028, 0.47669460379087036, -0.7205613562563059, 0.767079884269317, 0.5527386502372266, -0.3522399096136639, -0.895179048592347, 0.5422089116405986, 0.0976214128726668, 0.5151931605469956, -0.6945057681442709, 0.4818310980480224, 0.21500940746024622},
    {-0.7128423441551884, -0.4318680386693333, 0.03265330131071157, -0.2855958717553194, -0.17814255526099065, -0.6063345078393265, -0.659808297496139, 0.36675510163993597, -0.22370375248388882, 0.20057653393021502, 0.6898714577034001, -0.5875587780392373, 0.541513409491002, -0.5708198536600909, -0.49628769386133914, -0.4827918934763358, -0.43763108388253247, 0.8997815860171906, -0.7372107754344277, -0.3996626226417291, 0.3825764769890291, 0.57099165787778, 0.3660496549530335, 0.6172831200727824, 0.6302884941791947, 0.20277195818728094, 0.4089643821000144, -0.2951672902084682, 0.6203467073744835, -0.18888212943445, 0.41980060146622816, 0.7130738513615321, -0.467485254422765, 0.2850080532376926, 0.5978739070035619, 0.14422065567707626, 0.41221336457388896, 0.6037969622829252, 0.6363262857480471, -0.06355800241607816, -0.6262921652014773, 0.7508173350969233, -0.04798471490165188, 0.41419161516362557, 0.6360224061026103, 0.07903805037305642, 0.48211240851782294, 0.34120776552970633, 0.6740751279315003, 0.4455479836993988, 0.4829466011545617, -0.3839118804859679, 0.6073875588452706, -0.6835059798496731, 0.3793185553165247, 0.6303430005629214, -0.11181478567784195, -0.6942314630688495, 0.589997611604668, 0.03953767912029111, 0.5757902086049989, -0.4843128734073781, 0.23775063362594792, 0.2290817775571904},
    {-0.6189467252016845, -0.03527928750803331, -0.25871810307314236, -0.5034621574342494, -0.39791943858424056, -0.2497698865044866, -0.5726294429499432, 0.4061311200364773, -0.33097012165547535, 0.534704629087725, 0.8289210947586766, -0.5471156742337613, 0.5524471770639927, -0.7480632046300304, -0.5781751273737871, -0.7583882279892404, -0.5765762481425855, 0.5039124975712264, -0.7486826174354465, -0.48720558275674963, 0.11290177886437197, 0.5641373659228107, 0.661613313220739, 0.7711819289154246, 0.6147579596459406, -0.016060092064877057, 0.2121162771630693, -0.19836907907666843, 0.8636186284677119, -0.241444508969491, 0.36604052030398726, 0.26319537767231876, -0.49798468921389866, 0.4858918078290068, 0.8612989457685397, 0.1731255923910714, 0.50294846609781, 0.38630166029523944, 0.5415736410147316, 0.22649829721119547, -0.7826891854068233, 0.6755439931488613, -0.27459651769258525, 0.4802312890453088, 0.6016370296439111, 0.22127994429243908, 0.7216668045394513, 0.4921843125329668, 0.5079163836876714, 0.43253420487810235, 0.5359696345519633, -0.6049034343634268, 0.2577377956840912, -0.4331776479282929, 0.4756389267154944, 0.4554622684025057, -0.3947243299867926, -0.8433810679100864, 0.6323635290783538, -0.2926917131622158, 0.6294685845281646, -0.5715634932936007, 0.3917532857769834, 0.2727323354690331},
    {-0.5200876159879122, -0.21838564545275213, -0.05969257158189728, -0.3114070576311738, -0.17476452615973428, -0.18541925524446798, -0.4236135191677495, 0.18040576249979884, -0.20602832516574088, 0.45915528433331154, 0.709342275737387, -0.6850153275330073, 0.6006603507918228, -0.5951573824769933, -0.8252058765881418, -0.37869814115205136, -0.4342843490963357, 0.44084806396606424, -0.8736607565678752, -0.4635077281167909, 0.29329907805812366, 0.17339846964553043, 0.4036009319155824, 0.5043890940043828, 0.4892113280865588, 0.06842030501078862, 0.3820280845574667, -0.3121636984500571, 0.8180264504280685, -0.22045042958419606, 0.11409276019108024, 0.4711780108902788, -0.39227763394322496, 0.5143205162501379, 0.6417390079375731, 0.21495144800938004, 0.6795047304576083, 0.4011820196730181, 0.33259620195353207, 0.2219505965253173, -0.8640834637805733, 0.4091592059566452, 0.24947754356466742, 0.30844372769939743, 0.5353322709704429, 0.3968491943296877, 0.1185111856372989, 0.4491525979142068, 0.5481688964808754, 0.28189499597167916, 0.5758487415444745, -0.5068678249656097, 0.2941787799914543, -0.572017453079443, 0.6639125165403804, 0.6854081499766478, 0.12984273838267482, -0.7899167779488725, 0.6503277182754912, -0.11314786606512778, 0.032375118917059936, -0.8322860239077376, 0.5127771188089256, 0.22035804344428586},
    {-0.6675927198188008, -0.44431995744924, -0.028904140397219856, -0.44738208839219495, -0.46215991721257677, -0.16168100475032646, -0.7089611584928611, 0.1381218717957116, -0.49361885188158316, 0.6499153455434605, 0.7738297897303493, -0.6741356183018943, 0.6482485256917419, -0.5368183286740209, -0.6718045898909571, -0.38502666953054315, -0.6311571486140458, 0.49756276691953233, -0.4936571795293634, -0.5975302936478329, 0.2842535104831097, 0.4665561922642114, 0.3017115422570418, 0.36697385437208363, 0.5257225118187453, 0.4235949822807585, 0.3286596878453926, -0.49063108661621185, 0.7505033691865391, -0.19304766754689967, 0.709588424272378, 0.7692241237396421, -0.5869478493524254, 0.3474494426409245, 0.3934617625516784, 0.2434160882888288, 0.752448194106043, 0.10063781783757776, 0.681653663845662, 0.09936454220996845, -0.5636284789625637, 0.7234470954800549, -0.1985097567148805, 0.25742299077176384, 0.5760235333872789, -0.06425567323073486, 0.4139509611777814, 0.7000692698165084, 0.38671981394632743, 0.01743210995507367, 0.8051434555757364, -0.5754161455270238, 0.16890236051793212, -0.6228343600304533, 0.4609443111631711, 0.6474654805706023, -0.2549355829540247, -0.6431506410837372, 0.6285184411549017, -0.0713888543989374, 0.9584026435395355, -0.5470370246319967, 0.29139067389894824, 0.2822571538185437},
    {-0.47878429239510933, -0.4825137312382772, -0.05475318532119841, -0.3099811217708259, -0.4124788380127394, -0.5386884209511786, -0.30266288213483933, 0.5497544464364893, -0.29390631571332937, 0.5155580209320977, 0.642370482099202, -0.32216289889647526, 0.12949560653948278, -0.7930569851333834, -0.794430952633553, -0.8396830663585022, -0.4906414497823362, 0.3767654726982888, -0.7240585176001021, -0.7080534714944583, 0.23112498569793646, 0.2299233246272538, 0.5528238160839426, 0.7110836279753067, 0.6180300016646249, 0.25883332650200314, 0.36421575209976553, -0.3167401755167463, 0.7013581703802402, 0.051161765044780476, 0.49010912428874515, 0.45009337216958667, -0.5098948501775522, 0.7951850535873715, 0.8319594730260241, 0.3581325584842024, 0.8236579042018767, 0.4669823161314387, 0.5737600905976529, 0.2719345484086003, -0.45728457776789727, 0.6931344174000152, -0.2698173228863304, 0.3034989648864713, 0.6199595008524894, 0.051732241953278524, 0.6129973347572225, 0.41633627463428013, 0.5350054263610982, 0.3246390725613404, 0.4601424182050832, -0.588258453093357, 0.13598678922122118, -0.8259703840578849, 0.33949087810459727, 0.6333883382258007, 0.21097334193933207, -0.5922230507333653, 0.7424816119794335, 0.03053478893441802, 0.36356051677086315, -0.559998361271261, 0.42904595293781683, 0.22151292899662828},
    {-0.4944041696269704, -0.4566369780886117, -0.10296572533505619, -0.5310139576092308, -0.5808805263687637, -0.22637312230438247, -0.4365978293473453, 0.7014297316376125, -0.3349311005582468, 0.6016121887618622, 0.6169874848716974, -0.6885616183797628, 0.58610965243777, -0.7256720141643487, -0.5461055411822228, -0.49597602952133524, -0.6009561373471664, 0.33477269699641665, -0.6612727259562028, -0.5610671937450683, 0.06913826987483987, 0.4343025480818099, 0.6548781042479468, 0.3801248717306176, 0.4354202350627498, 0.22600156775247918, 0.3607137986592437, -0.10987019082526504, 0.5462237209413215, -0.3628995300457495, 0.4676784972117408, 0.39106657458403127, -0.5481791432500989, 0.539683291927854, 0.5332387672236756, 0.0505705972763475, 0.7429052517396888, 0.1964953449432071, 0.5183357136185073, 0.17131649222648018, -0.7328658712611242, 0.6708384072540852, -0.24642807101280484, 0.5564355780785025, 0.686453241972931, 0.24720309903834375, 0.601943393711978, 0.6356122423888576, 0.6271941885336604, 0.19929546398930092, 0.7318027694305623, -0.4698220368365867, 0.1445848667696933, -0.34651688732950126, 0.48455274957621286, 0.796190804066649, -0.15089585003920594, -0.5287520407211062, 0.4810509648579975, -0.2580875567335925, 0.6943500352770771, -0.5498948249972048, 0.49533776041905886, 0.48559282097666984},
    {-0.7643798381501727, -0.6496375105959323, -0.18926476074474136, -0.5533491550051837, -0.36841157423312265, -0.07377296100392727, -0.4460293580461921, 0.49575168435539235, -0.08757219231498656, 0.4090823303439712, 0.5090468626846141, -0.5634461999041014, 0.4732548455663377, -0.5095686120784877, -0.7402390260629612, -0.5159198268580786, -0.40056816807878554, 0.2876169207455972, -0.5228794050931982, -0.7135078746201455, -0.11688249327969878, 0.308936178261514, 0.6574652830725654, 0.7621338910222706, 0.3603053934897797, 0.2086285465339337, 0.356448791368727, -0.2801784734288798, 0.7213328954346098, -0.24606340107699348, 0.6547114136509128, 0.7010784641913602, -0.6621435905450707, 0.26515979977520215, 0.8307524392388562, 0.16005093192436934, 0.7238024107819027, 0.4380831898645009, 0.44960533643930256, 0.3884679740453154, -0.3180377811039181, 0.6236237468708261, -0.21219236314659465, 0.47395881093727144, 0.6768945612831159, 0.3719065001834397, 0.5162164020506192, 0.5544774588780964, 0.24437435701547064, 0.2203758520309795, 0.6604819182736514, -0.5544885170886001, 0.2795630366055261, -0.30614492733431314, 0.7842451454357705, 0.8659633910766182, -0.19077069607871736, -0.7977850932918908, 0.8020921135785519, -0.15995980375985774, 0.6920353928184493, -0.5416106730123131, 0.44152323722012254, 0.33497627834840366},
    {-0.5487341818290717, -0.5101298819553431, 0.22904286726023745, -0.7167709606764736, -0.5486814183837101, -0.14399841748466444, -0.5122611824655068, 0.3285520428686764, -0.30327735752051255, 0.4847100766413569, 0.35504603986159683, -0.3595617598964287, 0.30594501796491697, -0.45572480245732555, -0.7905907472843314, -0.6915599063458825, -0.7585937180811195, 0.3179678055442767, -0.566923135503855, -0.7886084713647642, 0.34572611764672834, 0.4715858246069314, 0.6980108739616093, 0.5104260980171593, 0.34015100446837454, 0.30006887718367614, 0.5942965397599843, -0.07059745373710832, 0.6895900398259951, -0.3156942896164092, 0.6240618464902613, 0.3060334726285875, -0.47089317285947935, 0.2811045758089397, 0.6293559167766406, 0.27279967844545955, 0.3501671592289872, 0.5562119645667524, 0.8994846253560445, 0.15879370423277306, -0.6787020818882132, 0.69331167548537, 0.14472280755310588, 0.6217692884841853, 0.7379235223620628, 0.7198069787842272, 0.43100227385975703, 0.755552291140008, 0.4800167449535004, 0.27363632120124926, 0.5587840994094523, -0.3895427881236891, 0.03160092229099025, -0.6821564457483646, 0.42007774861342084, 0.6470820426228019, -0.07319905642708735, -0.8372705837025312, 0.42101170143882766, 0.02024520217554727, 0.6098418128329867, -0.5653963670798469, 0.856498853035379, 0.22577505284833152},
    {0.18542372931328766, -0.633638011850012, 0.45487404902696693, -0.056471715541471616, 0.23872535726353308, -0.2079989113152303, -0.6915716780597542, 0.17937080060471067, 0.11292964079578999, 0.2710782602358263, -0.6037565924839653, -0.04467840420287725, -0.7106975255921889, -0.27805888766427117, -0.10663589589467053, -0.033234807183725346, -0.6422663844522838, 0.2839835639856194, 0.3104278911395759, -0.09169096250536811, 0.14653787273010327, -0.018171766959269073, 0.6765278158634772, 0.26396882026502055, 0.25402062098505634, 0.48787643742549586, 0.6076642709829503, 0.6313513880929199, 0.2988595234294301, 0.19581821011384626, 0.21938671283306022, -0.15500156032628026, -0.10627246718944691, -0.510724802943331, -0.0672431997130924, 0.1771134579937264, -0.01676803331840222, -0.25656351871570715, 0.36601114052331457, -0.6403086586200216, -0.6303333166431773, 0.1926423866079098, -0.9770095124730027, 0.3107347442191859, -0.48762613658041226, -0.22485283346210877, 0.22173335526103966, 0.311749886918776, -0.08648009245960053, 0.017731947280052004, -0.3615564124307371, 0.042086237676284124, 0.3820066618297328, -0.04480258011567529, -0.5567978388813681, -0.0317118163333287, 0.4257180363024351, -0.18088347932631182, -0.24123423342713723, 0.3854875901947265, 0.2264911823622223, 0.2548589704055979, -0.014252082543792377, 0.1887928801794566},
    {0.28378470935029754, 0.05710568633934448, -0.1298862405887572, 0.26250768974993866, 0.23051158860469204, 0.222236222587506, -0.11787992874477954, 0.2550421006040066, 0.3269581489349112, -0.11893644491085088, -0.21886459398527286, 0.02882070881308393, -0.00301870246290789, 0.44069899999584766, -0.15701252407779748, 0.3568481613771685, 0.07417492152557649, 0.20241638299818795, -0.05018630588329932, 0.19474481300558405, 0.42068563467244957, 0.24648752112959743, -0.009546985340527068, -0.0032579861840837865, 0.13547587012597617, 0.2526569940416952, -0.03783343192065438, 0.2313082687531651, 0.08436850236529558, 0.16833935322016996, 0.42783849310200395, -0.011879308722208392, -0.22635422085086015, -0.2173915493463822, -0.2392554761691988, 0.365243257940704, 0.7524294493631422, 0.23057756647541539, 0.1535594743457342, 0.0015701753181959367, -0.0856444794633586, 0.08356516290452336, -0.22136799000802249, 0.5632808026776094, 0.20953135611323778, 0.1502258798565937, 0.25834029769035954, 0.0353124233727648, -0.007484530528852118, 0.3694648662480516, 0.401331495280967, 0.16443986598886356, -0.03221681178209586, 0.11973968430266585, 0.13070704708261632, 0.36383788688114804, 0.22467866643490045, 0.0006470799227122445, -0.193105538401481, 0.1894073940975478, 0.1729620889140769, 0.1829293124895997, -0.22924269178227683, -0.11723258610261547},
    {0.2797543116508382, -0.5945416998893377, -0.008302020334340458, 0.3617807529505273, -0.05575964507689129, 0.1294339873047303, -0.42138068326974465, 0.05854634653952601, -0.1842499831950925, -0.44787611258150256, -0.5378218007082356, -0.18934670601656503, -0.012257043713902852, 0.04945291216264029, 0.05247513216655506, -0.11871511911041706, 0.16363663019824753, -0.2090890433327499, -0.03554881182942833, 0.16196842914124496, 0.36242763394103455, -0.48137916591712265, 0.032702008682972586, -0.2994842939351149, -0.11697035278802763, 0.3361818798309694, 0.33064463457683446, 0.21062755381218606, -0.18181337011412663, 0.4354152784701759, 0.1286570821830837, -0.2179406289961462, -0.15039161799027154, -0.4521387167413071, -0.5769108762066893, 0.02625601606047486, -0.2749502759454506, -0.442337112725685, 0.21604594543756891, -0.3685569348825423, -0.053314735925929495, -0.47395687333109315, -0.6059340736131816, -0.48349942195387424, -0.8329220617325046, -0.4543865139695249, -0.16032645122478045, -0.29760390439685064, -0.3425561263606486, -0.23743805895878853, 0.31499270771565396, 0.30875431571760237, -0.6896668807451068, 0.3719326138884497, -0.11943804487094425, -0.11633609579843852, 0.2643334927852095, -0.2357724026257041, -0.5628012600627322, 0.05819446370507369, -0.16599167124484152, 0.23804351014284816, -0.6297253899013014, -0.353488137329492},
    {-0.10393493917448285, -0.5043181215311173, 0.3658155490470586, 0.01784088944960685, 0.1777745760038611, -0.31290009803814717, -0.33914096851084324, -0.08714339760536148, -0.49367015420166876, -0.41049706805525554, -0.20592012776483204, -0.38448831740388467, -0.2259827922753619, -0.2841623885218802, 0.1867964725368256, -0.4767779618157157, 0.05879487882991439, -0.3649968694634194, -0.010189089092747506, -0.09314688344891059, 0.3373489595536041, -0.45106372752902396, 0.3311548081540064, -0.23651398973165455, -0.015264769094093066, 0.4092216250500915, 0.06339037867957431, 0.2550145550013658, -0.3423055308317793, 0.07393653323534756, -0.008331780778448275, -0.4226466204712541, -0.385291938493619, -0.49263424223948943, -0.3095370665937702, -0.08788732321903275, -0.048253990872061774, -0.20406914237778212, -0.08199452721255421, -0.38505190061868316, -0.16624068606347983, 0.0652536564059766, -0.08226674348961223, -0.5769054680037214, -0.48016945003159267, -0.476940003313627, -0.18412323065974534, -0.29673799038583043, -0.22051201837847095, -0.38244110559144073, -0.26420059388937894, -0.10507531688930534, -0.036016133761590546, 0.13552836394803627, -0.19281551893193266, 0.019362991820354135, 0.3556289284700242, -0.31472210287039176, -0.5021252530286732, 0.16886427355399586, -0.2892236060847887, -0.2193678038461927, -0.026169815314260495, -0.18127693089947025},
    {-0.3025640593774547, -0.5580202630498858, 0.020116119685981575, 0.12954624043825788, -0.4778690131877832, 0.1484470427370286, -0.6130833933080602, -0.31929671242890073, -0.6431693216407569, -0.5557905914526506, 0.06722583898872364, -0.5540576211431665, 0.13067689514488126, 0.170399361258647, -0.2633310275071367, -0.20375560692634181, 0.3712832006755161, -0.5644079773437868, -0.48979219833867566, -0.23779704110949024, 0.5648462392978165, -0.39948331372631973, -0.3448883481200192, -0.41435012052716924, -0.5682904838828875, -0.056746290859855275, -0.17992460188963305, 0.048757633970294145, -0.3660658792574929, -0.4890027877999644, -0.012124837915274177, -0.41485746610480023, -0.8322994446607047, -0.6184518304441865, -0.3647217228197607, -0.5772404138479691, 0.23539644027972756, -0.4401580616655978, -0.09559824064828727, 0.2014901594552574, 0.09439786507523966, -0.26613193069297386, -0.2925852084961257, -0.4177479928370018, -0.4063565842519057, -0.5715477522153191, -0.04553795041315243, -0.4042197446476179, -0.35145427847530786, -0.5159742291188267, 0.08256141138143896, 0.1875428584270378, -0.22918752457000377, 0.17053574073838623, 0.12092038414225506, 0.20941548845592867, 0.06365268194721985, -0.3154141350901932, -0.4839742374819297, -0.4494687357425474, -0.599291100783283, -0.2111323116888312, -0.39237856353644, -0.5207447173806408},
    {0.24518840055769034, -0.6140639161536766, -0.01444311118214266, -0.23640189403734238, -0.5357792772262151, 0.21886286224966933, -0.341829861146866, -0.4788770931662663, -0.45858006294338993, -0.19676444315869174, -0.44127208821934977, -0.39645363155927654, -0.14736833284537085, 0.004476782757237234, -0.3252537849810186, 0.2632557136035911, 0.06428466230416043, -0.5629281436420193, -0.19560735810288749, -0.5073472029735772, 0.11786132253817913, -0.32099020241276516, -0.37713348107403644, -0.5398407211558133, -0.5617957966467436, 0.13087150446898527, -0.409519681251334, -0.349740403383917, -0.23411665541259377, -0.3359017720923738, -0.014201275509323145, -0.8434790576736682, -0.4715310988379623, -0.25693935396640144, -0.48280062977042265, -0.10631192366461323, -0.12495980059793091, -0.23173825328313075, 0.09262669548235038, 0.03769067003103479, 0.08719070693941922, -0.4765088859735502, -0.5330351814573785, -0.47982243589741697, -0.3907929394800985, -0.36136032419392833, -0.3108941306234449, -0.5543677748472299, -0.4306341439062613, -0.4115274635636583, 0.1707231599849766, 0.1267078391854625, -0.20021767940867413, 0.38461593280493717, -0.039979265527002456, -0.15024730558651303, -0.15886554042274642, -0.019186873454807265, -0.6253093489096737, -0.04684420440500714, -0.19782781584320744, -0.23089271937268296, -0.3163890521370477, -0.7606174752394228},
    {0.015153818919283184, -0.34979133712503585, 0.07320431179279596, 0.1877093710255866, -0.6086018390992095, 0.23527069114500865, -0.4265922647346012, -0.30727733051975487, -0.6774284492968291, -0.3099206867165148, -0.251151252455337, -0.44087641270684197, 0.2919058906114479, -0.35658239740639924, -0.2842659415340083, -0.05402446192473694, -0.0809142140866074, -0.3532485012217097, -0.2632857711142513, -0.6211668476565211, 0.04499502340348471, -0.3684008909753457, -0.4443302069552903, -0.13749652496425077, -0.2886180393266194, 0.04237418488196405, -0.13710119775070898, -0.4174352664784317, -0.13811138728370373, 0.1413987594627052, -0.3756328233681849, -0.5447341495638601, -0.26269213586129464, -0.7357379926530824, -0.10019766693132137, -0.2633781697967951, -0.19830395674189794, -0.5182777264949567, -0.14516351147382045, 0.05670720218919933, -0.21198167058759892, -0.3656235827979797, -0.17014418331956008, -0.5925624897413428, -0.5996315982992549, -0.1279346186544473, -0.17715555308781347, -0.4414045327325011, -0.3482021879279073, -0.49583546116403965, 0.262595593985949, 0.16926496041404807, -0.1784850490244946, 0.10562122217823318, -0.25542262925300474, -0.5086127219022165, -0.02456969206079435, -0.20418954444896592, -0.4813551220261714, -0.5606903830734121, -0.29761746722008037, 0.0034270634812461702, -0.4153362349454783, -0.4859141443499787},
    {0.39300375621252615, -0.5928498510488889, 0.04243450258081561, 0.48384584250324897, 0.04902166775152364, -0.11375809052648767, -0.46908088752033644, -0.5346126932313707, -0.4922308519462995, -0.337515829940357, -0.079692182126666, 0.01580966659915566, 0.35335114591436856, -0.09272776363764687, -0.22041500085728455, 0.03474132374074727, 0.19503103301539007, -0.2608661563064904, -0.3208961922643543, -0.3452196923573525, 0.09188872801920121, -0.1984642123785663, -0.2288079137585664, -0.32026990969408836, -0.2939321605959321, 0.09905317611513806, 0.1745765070564268, -0.23094962914071873, -0.1328149324818313, 0.21023357343436067, 0.08440759312045606, 0.10184684875070883, -0.32988195756001115, 0.0014803050723331376, -0.30841793588128646, -0.12377575664909518, -0.25349759125486326, -0.4999275367957471, 0.03802855957535081, 0.28216505394012525, 0.012175706031283963, -0.13299927943075066, -0.20556584002851877, 0.05769204380042085, -0.12635349202678842, 0.19498263633309354, -0.4304826781895524, -0.337707671776305, -0.4386971849813767, -0.05095960632386456, 0.3524338108770788, 0.2072444917005141, -0.30541392198299094, 0.12244738610587161, -0.29399623547771025, -0.19682361071890792, 0.04807316699211058, -0.1962562139097106, -0.4500451204461212, -0.3866557343639009, -0.6171020141881962, -0.0668714094558661, -0.09620936913953033, -0.26218648092616675},
    {0.41802831184178224, -0.39883987504461693, -0.08213897496462381, 0.4436454839631382, -0.562927639326978, 0.03524526043460015, -0.375261561054085, -0.4772854269028091, -0.5234602994015433, -0.4470921440919035, -0.3934588601101033, -0.45965036726611763, 0.0369064364325264, -0.10168079443844794, -0.4151743518661327, -0.2021949319318637, 0.46008451113378435, -0.34832756769934126, -0.48807474750055585, -0.1453447576736535, 0.11347970502627372, -0.12881254446151924, -0.26452183837275706, -0.6198345760251492, -0.3877552392395439, 0.23590484691212424, -0.2601056247773718, -0.16326104146722498, -0.553385318179154, 0.024782291566361622, -0.21411676606128952, 0.13584453751951023, -0.0508255851577276, -0.4842153603281692, -0.48084254018179085, -0.5837787786090114, -0.40472350966526227, -0.4342233296484161, -0.020896037731316975, -0.27744800223360805, 0.505954373572324, -0.22399340606939658, -0.34021717391654777, -0.43886315306874957, -0.8168413792402924, -0.34825144173893463, -0.4581441924673174, -0.3487402249538867, -0.2564099996992379, -0.13897579083642578, 0.4864268166526511, 0.30976426414142993, -0.5187085413421446, 0.41058408274600994, -0.11593621581203511, -0.32031260621562274, 0.07362992001527138, -0.11485253680520115, -0.509480921259889, -0.04788455978546179, -0.4562856349098943, -0.06787256348482187, -0.22903493895801746, -0.39625414668544034},
    {0.18966217189889317, -0.44815567996477806, -0.15294346872092024, 0.10760101541140236, -0.19197800737935589, 0.2012738188985726, -0.36668388070413765, -0.4198777804648872, -0.410833056709379, -0.47872900946976943, -0.16682799488386657, -0.39555370699129616, 0.2344405589835187, 0.1389781036894175, -0.45772158969095206, 0.4063883838354444, 0.12940619265181272, -0.2380534589159687, -0.3325854460154037, -0.20075345462649027, 0.17889164745139222, -0.5870941326944292, 0.057715375321788755, -0.5105425597827051, -0.5034130258077681, 0.11292241884285335, -0.16277861864362303, -0.23412222342581762, -0.2570740572094348, 0.09802161102538715, -0.4199279240572232, -0.5386893096541702, -0.050649797987473565, -0.35322152125355094, -0.6762162706420132, -0.28556055632148514, -0.2922022939447518, -0.6085064826192791, -0.02773706069143474, -0.14360127286396387, 0.29757419293175014, -0.10116244401731106, -0.34163479517404066, 0.01835973572273237, -0.28125748954839314, -0.6490866189124541, -0.19672831809604455, -0.3311224160263035, -0.24047783888021243, -0.09165533547574341, 0.3060943391766667, 0.2508409674550861, -0.49733965935855734, 0.5578956320965388, -0.2742762854964263, 0.05299901878650999, 0.3211957842713909, -0.07407880424309397, -0.38475260464710803, -0.17259504671256742, -0.660967272447044, 0.18262878875175834, -0.18872170297069568, -0.8145073394531829},
    {0.15180060914523041, -0.2573230893508522, -0.17645905678694362, 0.15766203810653698, -0.4295392903530661, 0.48091483638797167, -0.3700159035840887, -0.37613524596735276, -0.11688541939570209, -0.23124743917119647, -0.5393712895653768, -0.11746192033290583, 0.016708315212251888, -0.18758504186678437, -0.22300973216930417, -0.20340972479172673, 0.2129425335153062, -0.4570642887242567, -0.10148023226541629, -0.38227417625647553, -0.03969559022879861, -0.029598674563231817, -0.019848109592363477, -0.22143385040042657, -0.41383176880769207, 0.19061454308298498, 0.025068300216877875, 0.25077571739909865, 0.15648865658288996, -0.07693134362969961, -0.3073626170290059, -0.5300504003148472, -0.3621892384164185, -0.5687217855344984, -0.4269159381632002, -0.1760501910780628, -0.3774250702665987, -0.18038374722965478, 0.020366310655399636, -0.11515672519352944, -0.10712746057247671, -0.39931280547366915, -0.6209874774498404, -0.3183875460821939, -0.43601621065198143, -0.42547173101344754, -0.0483096557838247, -0.4333816844018932, -0.2126191020721176, -0.2607795996172493, -0.048964496522948035, -0.09974341174461676, -0.40702503249390043, -0.037532837711340694, -0.4602649932103434, -0.3117190056120334, 0.4061401302737191, 0.035005300839323274, -0.4209487158018556, -0.09465154086972687, -0.2735389708190386, 0.5000684912596842, -0.27383059990520187, 0.08994755943217624},
    {0.25885054811555275, -0.6594096832658087, 0.18587145047693604, 0.32233946346594966, -0.5184682795248904, 0.2378883431202656, -0.29520272998184877, -0.32533135805314406, -0.2466732867612301, -0.34220154251853496, -0.4999317805253236, -0.0954151365828938, -0.006033214750045946, 0.021754953930872525, -0.0655629329956927, -0.060639483570068, 0.3005772770359419, -0.5273694424822702, -0.15946118375072582, -0.4479943507487438, 0.32588067131102594, -0.7980244501272039, -0.19714271009842532, -0.5638626496243538, -0.3971673900289671, 0.614800895761977, 0.31264692758504137, -0.43147285947285924, -0.5258522220855233, -0.07456518980508171, -0.43161544959202025, -0.34832351823758545, -0.3763838800979983, -0.48604204585741717, -0.5811577836855435, -0.31582302310974075, -0.10424371238640502, -0.6282675317237768, 0.23413978315650996, 0.12249484785631273, -0.2992522378313935, -0.25079134004638426, -0.7052755882239213, -0.20082158506322134, -0.6257918717162384, -0.5656300399957789, -0.26658913090138825, -0.48245386434825654, -0.23972725337420575, -0.20871469871638448, 0.16170843112027297, 0.1953240735468779, -0.4179617461533799, 0.12653069752017618, -0.3823411563571636, -0.15690912085988942, 0.22580236163756395, -0.1676339803220295, -0.09193389269910959, -0.26185060789421427, -0.4950782176607614, -0.034575233092474345, -0.4514150693883124, -0.5030289847616912},
    {-0.012133038328436447, -0.7856548612012981, -0.056742249389116615, 0.14078174009062, -0.3353757762462804, -0.1321580059676494, -0.5182057830354447, -0.5077990977618316, -0.6463290824253619, -0.4183383423923975, -0.26791342103299026, -0.437051771222015, 0.07111053946581276, -0.14638159548933188, -0.269942617460702, 0.34521259802794935, 0.21282414054091295, -0.4141242093770505, -0.1735308414724679, -0.38542066301527955, 0.6275527889835721, -0.6211170387566242, -0.6657001028581321, -0.7346938658229104, -0.16702478227292192, 0.42316931288066006, 0.21461667160642628, 0.1221696415606631, -0.19368469906581218, -0.07570176113257404, -0.2775929907668485, -0.21142370921979298, -0.5587165792038805, -0.637102717548919, -0.3625342797483682, -0.3171154593494824, -0.11248623556620659, -0.5314756559057674, -0.016986234692243037, 0.05265901949154646, -0.2532915153675648, -0.6021748783112844, -0.6325065332777486, -0.5516154967222591, -0.6811394009681423, -0.5071092921056892, -0.31445460014573184, -0.5961913428466371, -0.3803669527311383, -0.30088758195607834, -0.015925361962768662, -0.09369537896227322, -0.2850881187858333, -0.008891585162387293, -0.32871125423975317, -0.13285373208243284, 0.14455629257459426, -0.11674919790532229, -0.38020092859496546, -0.16750826397067697, -0.3955673402315128, -0.22588962016494, -0.8067536160989605, -0.40793892343012284},
    {0.3714352299557842, -0.6126586785259299, 0.3494890160984281, -0.016022029451291327, -0.536625056175397, -0.06419842714787687, -0.5693614663702778, 0.02179963798955901, -0.43666497740377264, -0.0812011660771607, -0.38014267928707735, -0.25545184952491373, -0.09784734875319297, 0.3562364024889808, -0.13959595531466404, 0.17329970369079353, 0.15116407754530503, -0.433588866176655, -0.33092930070236726, -0.3141885391237409, 0.1632108410864403, -0.39753470025243426, -0.032692003966018936, -0.19877287824829068, -0.19179227444125596, 0.16679579667859054, 0.14120423412032176, -0.05973143563833977, -0.1902648728325483, -0.10898806447590081, 0.06163181387354662, -0.5968857624157874, -0.5164821538552669, -0.36059494075929327, -0.5120378185085352, -0.2929834878746801, -0.4126772708706919, -0.37441973756162095, -0.42645466325379605, -0.355828794845793, 0.10028917350288216, -0.4544694871743163, -0.6083229130718014, -0.06844124401325317, -0.7147552582165193, -0.13493503072134, -0.09222679121872152, -0.16933518339647935, -0.2860740984276034, -0.1269736546821555, 0.17653033052686198, -0.1696679685954008, -0.3504691603007533, 0.24916573080913104, -0.26051134078786237, -0.09153409641454846, 0.19505957530390974, -0.14196251568795606, -0.04923187025691707, 0.0038820978253123004, -0.2852538649810692, 0.0809396536066831, -0.5783186387128593, -0.5697273606968999},
    {0.5376936887168542, -0.40605156578833634, 0.42230392372925424, 0.18338176679956808, -0.07032799372004914, 0.1791466219843947, -0.5176919141295495, -0.00894943354148648, -0.27353491510120254, -0.013124907170918234, -0.3047957778159395, -0.18219458784505127, 0.14809496581331952, 0.32410665013412165, -0.2583084097722091, -0.043348946672644294, 0.2582134783340269, -0.35530423142934126, -0.2830108051625116, -0.08037174998629416, 0.3288838001927251, -0.643879331930256, -0.33503673128197886, -0.0003112054584330459, -0.3524488582870817, 0.39865802612402956, 0.5526472626157589, 0.17542718713675082, -0.46959952430972757, 0.0015652685770520898, -0.23405285771859063, -0.39562089265944084, -0.17052391807021838, -0.3504023754641644, -0.2889497141605443, 0.15687451858214307, 0.2917072634303647, -0.6760740445615313, 0.17278138751611444, 0.08721729838900237, 0.18370055076656208, -0.3120938949171763, -0.6152043954408742, -0.07934590820276906, -0.44325717023687666, -0.07678590815581247, -0.49304724493869706, -0.22515736930125113, -0.2732923264534888, -0.11241185258737635, 0.24340904140634814, 0.19559997932706122, -0.12464711365090159, 0.3581844915371513, 0.04155405723758301, 0.16858567027886043, 0.55860036415303, -0.025063246036716974, -0.061798640070712264, -0.14650575396014007, -0.165690341939286, 0.17357906768520057, -0.22365925059641142, -0.5171656679673606},
    {-0.06202664458979326, -0.6087444169959391, 0.7274493956861537, -0.18327749314749742, -0.2864784321738487, -0.28271478569011954, -0.5501790065824431, -0.22378538886105181, -0.32618817994516053, -0.5115868995412646, -0.2501642446998786, -0.2957531088445792, 0.293971476967625, 0.03417355958352642, -0.5400789733744193, 0.3017854450580031, 0.16808634008384019, -0.280809173674433, -0.418471153563974, -0.1322035754979318, 0.20828397360094558, -0.570002671598251, -0.1672013678891945, -0.10843376606499816, -0.3898289374456647, 0.6843638036338281, 0.2740914603896771, -0.028004406627828687, -0.2189869655257647, 0.4805041542498193, -0.7500045682581473, -0.4732905614906457, -0.21788714015211208, -0.5691086346936289, -0.11069130181889147, 0.03134129911064085, 0.009005171873770274, -0.6302047287144258, 0.24720363266504874, -0.09690278705189413, -0.13985422930918767, -0.5172957991993407, -0.8431051181574641, -0.09535951128647606, -0.24391757015926777, -0.03211200656303702, -0.3807274723203441, -0.6132249796231813, -0.18464805998563266, -0.23725134758456934, 0.256742359769858, -0.22233902162500255, -0.34383950598984947, 0.08150151058384926, 0.018384991603529018, -0.3417416261305827, 0.35727732021767117, -0.29785463868588047, -0.11773229848901515, -0.17557562543282784, -0.4721551478464836, -0.09261039014746335, -0.41603236885764744, -0.27927358185190393},
    {-0.07047545681415485, -0.21468387340750975, 0.07505193923080683, -0.024742244411725685, -0.3493045191095625, 0.12168053295470814, -0.6563073672264356, -0.370282448616263, -0.4284120590616587, -0.4891503391965295, -0.35878181067353637, -0.12749220429902505, 0.2320731472512371, -0.06797672846413738, -0.05542442479827065, 0.03476836416272768, 0.1744304533246968, -0.1424424875210047, -0.15716369642788564, -0.521736402764537, 0.22192148969971007, -0.39223108792198064, -0.48719385927033443, -0.5234187927002962, -0.05180014763801533, 0.4528251271981119, 0.3505911347075761, -0.0877042338595307, -0.14706405184530746, -0.1238933772292122, -0.49059012648056116, -0.6205781153618911, -0.517330707697126, -0.6539396025037107, -0.4409963020528346, -0.12650350922294384, -0.052861469032755, -0.718400271544668, -0.3094070398156977, -0.19680029304009053, -0.35113437060848296, -0.3858690345628742, -0.6113613698295556, -0.514705676757349, -0.43913799628057576, 0.0746569401570362, 0.06210438150044044, -0.30520328897322846, -0.3729407252834097, -0.0973497330439548, 0.2585555356519865, 0.07447493055202559, -0.17680044568639736, 0.027784606934736427, -0.383829149363307, -0.08185400465905299, 0.23080534941542147, -0.5435472965384601, -0.5220938273070205, -0.19978891576744442, -0.24581408325276527, -0.2442652649466685, -0.4179129652155067, -0.5589876583642978},
    {0.3047631128797299, -0.42169166047459955, 0.23844961051388608, 0.08795754266405297, -0.16851649905113758, -0.17648393963746384, -0.6347287474473845, -0.1509315256917934, -0.29663342075041116, -0.3468685054475442, -0.510275355685837, -0.7591440873354591, 0.11777307371008258, 0.08715447235438968, 0.1962976028002193, 0.2477260311974625, 0.17991482092057368, -0.25092304324630343, -0.2537010439103809, -0.2751630300536683, 0.41384021607139465, -0.16529547762081526, -0.10179496654935788, -0.4497041967878022, -0.24610365089341593, 0.6571752814612994, 0.5056715334453027, 0.20451892415060663, -0.4333296117709004, 0.426765632543211, 0.36422619429813863, -0.3082652212067451, -0.7215769437552855, -0.6648796953891017, -0.2712720660581142, -0.05953059186089814, 0.1999966351223576, -0.44759606340592006, -0.07033792526838872, -0.1323892796219022, -0.0475037485600791, -0.22573060211453036, -0.691350716264622, 0.09661819901745088, -0.48852203584950543, -0.07643097160818005, 0.06731689429553696, -0.30427543699047604, -0.25471455337914917, -0.46517468248760574, 0.2944676895788026, 0.13989385968762325, 0.004725942613645342, 0.0622217473448801, 0.03544955500009514, 0.030468853370490268, 0.48199590359578326, -0.2814086752858523, -0.4415190308973365, 0.3267306087730594, -0.2931616491710926, 0.00799294615344008, -0.3455030356303157, -0.5552851532339054},
    {0.41632851528447523, -0.25154287596995173, 0.39688260257011126, 0.005145911873508877, -0.17415942208419782, -0.11659802391465472, -0.5868081079478574, 0.12970194043411543, -0.06049180303327135, -0.2952350160634461, -0.12030358953574868, -0.3780730220492185, 0.015630564137228686, -0.11159633642579074, -0.36104455457379214, 0.19817607740403384, 0.4320315342311564, -0.04502080244995318, -0.4989820906290388, -0.1685852247005327, 0.23822162133282188, -0.48407702463452396, -0.03669905973844487, -0.19607741791901678, -0.3875014961556442, 0.3475084050503477, 0.4699459574486526, 0.20233485939248666, -0.15062159023962274, 0.3111704426139728, -0.023664390480941423, -0.37469213634764753, -0.1592403350835981, -0.5746582043380654, -0.2958980767849874, 0.04198703447192016, 0.026981310784979357, -0.44107567563520556, 0.3826457708601821, -0.09156141372300017, -0.10378994739736808, -0.07690313200729326, -0.5218337805154267, -0.10243844490232899, -0.3797242463288015, -0.19503252472185298, 0.17033542853910155, -0.46721035779542325, -0.19541102341918687, -0.2890676268938098, 0.38809691190788614, 0.36487498673999214, 0.27129766775555814, -0.2617178705844221, -0.03547183161247689, 0.05870625688564232, 0.3829367189041485, 0.0646302731603258, -0.6032634822533581, 0.3024977362245696, -0.15087513731323915, 0.060185597274452024, -0.3168847384575724, -0.5252716066219983},
    {0.21157595991117945, -0.776362661571526, 0.226396856520496, 0.05171786520507139, -0.2895488875127643, -0.07623985373943476, -0.7883266141101491, -0.3727509911561302, -0.17030717738577347, -0.23720599448821145, -0.5531460825606428, -0.6386552889548193, 0.11123961057398826, 0.10646347688134201, -0.07240151048271469, 0.12476490103122971, 0.19279670548777095, -0.5320691202013343, -0.20707581042607237, -0.297348067992032, 0.4308132117279249, -0.5840961701910088, -0.3434307692254792, -0.38790728198978797, -0.6436667425146333, 0.35516690111416815, -0.09198935398502998, -0.15312427381350915, -0.30714111836033986, 0.05361026234512624, -0.556741803051942, -0.7175452401165632, -0.45423935802974463, -0.7430451702689204, -0.40170283916451, -0.24275560450244243, -0.20057563696812014, -0.7719576232670167, 0.18095287268149646, 0.07617347119023422, 0.12152732758232124, -0.290571356222949, -0.49198067961794695, -0.54026595686105, -0.6563094036160944, -0.192645018173428, 0.0262761571335795, -0.4509320658940336, -0.6171828717789348, -0.6314123808097316, 0.5517452674286417, 0.04632241109521634, -0.18018732321804598, 0.11763416964137836, -0.5386375138667292, -0.05840618766854245, 0.24061482790775285, -0.3858215385953354, -0.34894753415026825, -0.28199085435683674, -0.5806048590727908, 0.05961979690187454, -0.37312774328372944, -0.41654793972464377},
    {0.26696933569962955, -0.7909796595699335, 0.16485042364687752, 0.08616589150026437, -0.09836776414548169, 0.14311399931046334, -1.0574425358133404, -0.3109968829653157, -0.4111989485360214, -0.5861646705170428, -0.28272379412494364, -0.6034721080895482, -0.20337960921070888, 0.12970032306025803, -0.2706173975804932, 0.19292777510881526, 0.414299538551714, -0.560399495385876, -0.5015998847192309, -0.5135303078017267, 0.364641582677546, -0.6447122436064333, -0.05274381993153702, -0.2118410363818452, -0.3780093942324798, 0.44635766981323244, 0.550082238273544, 0.17893550061053748, -0.44475516336636495, -0.0738157766597218, -0.369433619096544, -0.7606530617468555, -0.5850930929016416, -0.7012928041731594, -0.6674043092131656, -0.05783291438208099, 0.21025959581818654, -0.45930754172619936, -0.03290238883311439, -0.20274353134039935, 0.1853388807568172, -0.2169157826163802, -0.6106312035262489, -0.32850423534288814, -0.7031153087211183, -0.23022473832547413, 0.15763024436743084, -0.43014208022979245, -0.693152768605279, -0.5358016943251515, 0.3734491215655578, -0.014955012254898169, -0.07594018056021852, 0.24507724503995945, -0.2673503528838201, 0.22778088980538877, 0.31146672831356415, -0.020252489575979964, -0.5701369582506977, 0.24735678034168337, -0.1879365179080928, 0.03815403787213547, -0.46253663072707557, -0.2772700419946796},
    {0.6117174231629866, -0.714798269595616, 0.234016068534994, 0.3605865115448403, -0.17232217768816027, 0.482539813744902, -0.9071759453036988, -0.06755299504158932, -0.06886974466831589, -0.29885620219591114, -0.3768071315866496, -0.40132052631005527, 0.23681933689126902, 0.1866975522131266, -0.07753004039484888, 0.3066704080749965, 0.30045445125164877, -0.37374604673639666, -0.5753527554538231, -0.28856825580611334, 0.5507886872621683, -0.4158892960341945, 0.2292517971857991, -0.26376288634832723, -0.38187863467280647, 0.5198366133122998, 0.4297824874704446, 0.4374002123550642, -0.07838231750377664, 0.33969331826470783, 0.2520335267898629, -0.7796264580264185, -0.5200322356131429, -0.7740058721629023, -0.11758889741366467, -0.12299295241068488, 0.21513484173548328, -0.7198006540397316, 0.04108232902216985, -0.060340582855065876, 0.08663623303652966, -0.1738816942758447, -0.7992293765264491, 0.01989286514601945, -0.43394724792253264, 0.007515834101619436, 0.3167264480241506, -0.3078005642535769, -0.14376955181197035, -0.5917799466502958, 0.7138687356209431, 0.3446812291365021, -0.08641910235433517, 0.4078765499663937, -0.05567249333940182, 0.12371515503078821, 0.39111392267207246, -0.39535847536282337, -0.4150067273700331, 0.29391070519160584, -0.27624495411523753, 0.3750215102383432, -0.38024945938849736, -0.5782475201607431},
    {0.5835023424878164, -0.280985587740571, 0.6144422702582778, 0.3013656201003242, 0.09509463201535245, 0.228048605665273, -0.783858235870978, 0.7033511740065329, 0.12993417583558986, -0.1408324659956874, -0.30046080912680595, -0.30763959377427197, 0.34895462970765534, 0.049636179741988105, -0.08028618443663026, 0.6418255951517201, 0.16357476333787527, -0.17228430108514928, -0.0677213612921602, -0.07574204110019338, 0.8509847111578529, -0.2331358003757089, 0.26014227306976095, 0.1226848110158992, 0.1934467813878381, 0.6152491799658885, 0.5640082924037269, 0.7048712950671058, 0.25091695873391284, 0.6638715294688733, 0.37270349822318066, -0.3836988860178569, -0.720507385866268, -0.8657391337055553, -0.2412919104250153, 0.7341127601251766, 0.45024837383972377, -0.6708649414120141, 0.40811107167587435, -0.1733485111064672, 0.07962773132382696, 0.3875285794991547, -0.6903243878142766, 0.18617480569128578, -0.4543928446765854, 0.2462912751420312, 0.36029378039936727, -0.04003804408389785, 0.037466071691687475, -0.08275931099514086, 0.14855743583651038, -0.018412171399890164, 0.43078920265010984, -0.001735504464449933, 0.19447907363568973, 0.2549137931845641, 0.3472431644786871, -0.07565077889003886, -0.42379889022622325, 0.6108268351765012, 0.12539500809605092, 0.40304869651901376, -0.07799926374077264, -0.07877274576657124},
    {0.5662288579393523, -0.7043479423266831, 0.5922153624892965, 0.3379851698839022, 0.0839117298909388, 0.2739946266118209, -0.6721373687309438, 0.08802183744690487, -0.2278931173813561, -0.3050276744306593, -0.3099470394913146, -0.5620769905859584, 0.0831261107770698, 0.20938477041336265, -0.11826696079906819, 0.3035333255164443, 0.24033175099848922, -0.20987489172283444, -0.058577657280422565, -0.3911090884681157, 0.5222720468871213, -0.3675939460640795, 0.2422125602755458, -0.12174138301692314, 0.07363875290711037, 0.7103525207811151, 0.5956303161592101, 0.5049664090246877, -0.059131083157177536, 0.4105759313805754, 0.11007650853637663, -0.5689435106111695, -0.5592130968787183, -0.8202672617229803, 0.07922787959020701, 0.44293969422146146, 0.13984614220254765, -0.6412904765546578, -0.0025343722697616696, -0.13900723783677957, 0.03934127190226239, -0.0042188472543855556, -0.7935256228190083, 0.15534605588209796, -0.6361628750071914, 0.06880236718359546, 0.23224919800250596, -0.22954390733589142, -0.2776825812620635, -0.2027189968185935, 0.3841931895572008, 0.18357370631175754, 0.10517657013920455, 0.07831710270853925, -0.0424397445775919, 0.5308419262122855, 0.3541639458848013, -0.40779913141315816, -0.5676130281262514, 0.5101500615588366, -0.30874538292615616, 0.18740798010779852, -0.15990690829093218, -0.3332871710185146},
    {0.29187699772945436, -0.5088438599285511, 0.39425104999241756, -0.23476643339126843, -0.4359184085952692, 0.1614803551062145, -0.804340330490591, -0.5674292068259279, -0.39721197560222626, -0.6347348298528325, -0.3185983490683001, -0.7158243581909803, -0.07273059858552816, -0.21446636106698028, -0.3466411523823541, -0.016677658558624554, -0.04784326918865052, -0.3603603095784822, -0.3256926220007879, -0.5047164006339927, 0.5911430308028895, -0.5632903772473499, 0.09679855677686729, -0.30087067679359275, -0.33178234866345785, 0.4461553591223024, 0.2460297493662072, 0.09899332035226141, -0.3862818524898878, 0.12583115755593846, -0.18001814041761519, -0.6945885338971264, -0.8273806131265644, -0.659579505942692, -0.30440723576189, 0.054873271767309446, 0.3556202877677665, -0.7187544470771636, 0.016007788978064468, -0.2232061660673868, -0.16002626379911106, -0.3657552451735222, -0.5323090726653557, -0.13198577647952225, -0.49124423194399003, -0.3547657890249058, 0.1813546328447354, -0.021679871496648427, -0.47960972442982974, -0.5128156651504924, 0.009696996222098736, 0.23139633834871626, 0.11847961516292042, 0.3647584097654434, -0.2893541543713886, 0.0332895417604482, -0.004108818834013095, -0.05633110073529958, -0.4414668416051149, 0.06405001125753898, -0.47037618567056927, 0.19646685375057263, -0.2887382386497699, -0.7449949700114742},
    {0.42431614375997784, -0.4224615682236258, 0.5198217782758823, 0.15607870447591718, -0.07405593567048536, -0.1424475703309839, -0.9945546408341863, 0.05610952334926536, -0.055864854332048686, -0.22491076180901912, -0.24795688534635965, -0.47366045841579757, -0.24660569665257215, -0.05332659237767861, -0.1378076197765168, 0.12445427586527867, 0.2398953248373626, -0.5466075123890181, -0.06845762350555894, -0.22947686683650917, 0.6441329525911546, -0.6055287651014208, 0.3419614189839145, 0.279946781018728, -0.017359233977998982, 0.45575377145455576, 0.6382147288227334, 0.39496582338082564, 0.1738733305811538, 0.3540164423565199, -0.03592878938959112, -0.8334581244467075, -0.629017493905057, -0.7873784589582545, -0.020032643360922444, 0.2569136087848167, 0.3748207510049555, -0.5646132891822943, 0.45096340549330344, -0.29969078546415906, -0.5564946738901032, 0.2545579800494805, -0.9479941064043458, -0.12369492702536602, -0.3740297592479042, -0.32837287319751657, 0.1151547293765628, -0.13840220329766342, -0.057710221306349806, 0.08771251765250443, 0.021976122803322208, 0.25827881282755316, 0.00919251936000255, 0.15542864223752315, -0.15283374063843277, 0.256362594480551, 0.362341795046976, -0.21907403452745156, -0.2945268581198542, 0.15062853546458616, -0.27520138771915953, 0.24516923137174879, -0.12148646694501739, -0.20480826368923152},
    {0.4762704889155959, -0.7909126165842665, 0.6689772415122024, -0.014234718548454043, -0.04992794982771632, 0.31077287606145304, -0.7390432624179858, 0.24379325955340694, 0.12346093785011054, -0.2149744971097377, -0.39528377587554464, -0.48982608973157643, 0.10847312660462298, -0.05441644142054343, -0.20028450887894808, 0.1424995665912209, 0.4195656248426055, -0.21822619785135375, -0.3744083026647747, -0.02822338524940191, 0.45373112042653246, -0.8415260798648776, -0.052118581120836734, 0.029426863773238013, -0.004802181263200414, 0.5732627024670444, 0.8311741003757566, 0.4495384459534977, -0.17960773692292598, 0.40349492738320314, 0.3175102021591515, -0.6503732262140574, -0.48424470813795434, -0.8157242066041629, 0.062435748190908226, 0.1813436965190502, 0.426874239698635, -0.5609230198220753, 0.14353255626539582, -0.24856639493454274, -0.1753288436814862, 0.15981272290067633, -0.9498189999562924, 0.009124292205423792, -0.727617858817048, -0.11799481137499164, 0.49598519452951156, -0.16208336051683428, -0.131600719136627, -0.08206455602333675, 0.2951312999558272, 0.24481934577865208, 0.22421250874375384, 0.3049311548785887, -0.1471502376551332, 0.34682088661411575, 0.5830536951869588, -0.08632753074745206, -0.4614670199830763, 0.3713033835976915, -0.1589722893330249, 0.388174546419678, -0.16297064063654504, -0.16017235176183636},
    {0.43656566861344887, -0.7136446258737201, 0.6570927950012074, 0.4057288296398787, -0.11272296757275396, 0.28942639965085654, -0.7297113727871097, 0.06706827790307882, -0.1572062620525092, -0.4460216774973585, -0.5247342660059032, -0.6497587774842787, 0.024439413214558087, 0.03324326630755237, -0.4642448910366207, -0.028316155235782122, 0.08825749625341078, -0.54258508324501, -0.18307575312353203, -0.2903858634737602, 0.5776818553991053, -0.5055500023008537, 0.15064568364116931, 0.08049690470827155, -0.0748271750945993, 0.8774207961942027, 0.5497035534649258, 0.306340870777794, -0.27341956838569675, 0.3739950299822642, 0.25521526234127856, -0.43898277168439737, -0.7012106135589056, -0.5730954032408402, -0.3477866782545035, 0.3626528953508357, 0.4463245402393995, -0.9122516731092585, 0.007462823176690839, -0.320976514276512, -0.06624689051172501, -0.1425126987922798, -0.7894652617637854, -0.07809835956547564, -0.6993940014016312, -0.09875782285023038, 0.08198237008457342, 0.06423314752290632, -0.3733404647312643, -0.0277869113867281, 0.36164058292898393, 0.09876160036627545, 0.1482157447949911, 0.043170013010342165, 0.06178670667849616, 0.3284778712429174, 0.45457145734454196, -0.16338473705963044, -0.15863944410607667, 0.2959268719128349, -0.2001157719329675, 0.3695758467437794, -0.3688703398001988, -0.21841525087761846},
    {0.5436114439197302, -0.5078419519405085, 0.46564445236378554, 0.11724404209671582, -0.09952998513704446, 0.4923504141782478, -0.975309158356745, 0.02763582382802931, -0.030013317506561034, -0.19356103407862424, -0.35086726387150363, -0.637479152966364, -0.08758348579325226, 0.2725246671079794, -0.06153943245854954, 0.11610520148572762, 0.42090911383798546, -0.44666821475633806, -0.19258055436390126, -0.23404033828699136, 0.4022898757228312, -0.3729323631434522, 0.6166907987509156, 0.12844791451005771, 0.08887866321721366, 0.8673335049061838, 0.366166586987559, 0.6421494903090201, 0.3231134270266315, 0.23877750396782, 0.376593640109693, -0.37680189605489905, -0.7238272935286741, -0.7504493894408231, -0.1578318525621401, 0.32846608650034187, 0.20403785670952757, -0.35935768455640005, 0.3564214915210183, -0.15842979254682682, -0.4759271171404569, 0.0244840246752557, -0.6990959566633799, 0.012640933489457601, -0.22635966815552638, -0.22377378282082422, 0.5428846119949821, -0.3869664940226052, -0.12628780941964632, -0.10972657612453822, 0.0026238708426170494, 0.2000660212834877, 0.23573928691638737, 0.235558493767021, 0.12128207652232334, 0.26688921314022357, 0.5875472424211708, -0.2660012140923049, -0.37348328944172365, 0.6588429743851729, 0.07885998142585443, 0.46063571433477285, -0.11959213926131557, -0.6047526557509042},
    {0.4654528192622731, -0.5856659513759774, 0.6167679023495952, 0.13791708119458798, -0.13716282331636648, 0.6885877688927744, -0.7576343114415383, 0.2706280058873572, -0.1332509874366199, 0.20427722990943006, -0.37601618846911544, -0.7958268359550081, 0.21129809105496086, 0.31377945266785007, -0.16927650415987078, 0.2436750392918159, 0.1986985058030343, -0.538892898076067, -0.30343747841089885, -0.170201813904812, 0.4972735916680193, -0.019193677316597064, 0.11000102446242446, 0.038668040145836774, -0.16049418788527164, 0.6048705766029957, 0.6101014878715625, 0.5637990638053586, -0.06387356502568982, 0.7055769719735419, 0.3606986418456997, -0.46424250662870703, -0.6039085635628665, -0.572713421455096, -0.08059655898437117, 0.23101336966510214, 0.5296415274899899, -0.17657232563615058, 0.2672555052275993, -0.03243732767421236, -0.3289719036778761, 0.16283179006183274, -1.0062804652728394, -0.06993408581752915, -0.47572199243088054, 0.004220114403914684, 0.2295087631922187, 0.030243753044115095, -0.10860141323241865, 0.03237358127630345, 0.28021160235402304, 0.3366188628438081, 0.2340555416891821, 0.08025835137539003, 0.15528378857755717, 0.29873568959005775, 0.4241586890152543, -0.4089061939848654, -0.23051224127582046, 0.7241629176560371, -0.05605519523141841, 0.39615141872971793, 0.012162517325488531, -0.21088511318485345}
};

static const float b1[64] = {0.733946448295488, 0.8919892571632938, 0.7693879123077323, 0.7012589217376651, 0.8347331950896033, 0.907445744917115, 0.9345737042539468, 0.8637956677294094, 0.8378560079714737, 0.8147032211712035, 0.9342078515486699, 0.8256073475213345, 0.941126635591001, 0.9065137850191628, 0.828812925282439, 0.9400087277488559, 0.6745565003784769, 0.8072141523614231, 0.8748437065014565, 0.8592379105166577, 0.8179940938686583, 0.9130697505189659, 0.8834609276301717, 0.7955877607134859, 0.7791853574469877, 0.676884839468174, 0.8495370430697046, 0.8576280511858744, 0.8804411299662436, 0.8726565296628109, 0.8142115932181645, 0.8894168252698867, 0.8242222781310844, 0.8933986472776622, 0.8367761537042984, 0.8421786942834005, 0.8730490078308066, 0.8885367718726424, 0.8205666412988809, 0.9393583522700831, 0.9662651290812879, 0.8487543600947518, 0.9044678393915029, 0.7862337713905282, 0.922526738847495, 0.8111678725573064, 0.8154111196342824, 0.8716201779548297, 0.7099079700395821, 0.8393350327096771, 0.787443283776271, 0.8085340875329198, 0.852988904102068, 0.7964758041554214, 0.8419362084088805, 0.9613734751070586, 0.7434239075098442, 0.7597896856636829, 0.912585702324524, 0.821781665276802, 0.8762527768635825, 0.802856734512965, 0.888187697303509, 0.8586251479685918};

static const float w2[64][32] = {
    {0.9055253917433308, 0.667977814333764, 0.5136996136901797, 0.5615311806854182, 0.6237669946485239, 0.729721168456594, 0.8181273474585928, 0.189665414276764, 0.6706390870257078, -0.15037263433442222, 0.6994351235708965, 0.1376868800386647, 0.7168148859156924, 0.7218052538768993, 0.49595897515850945, 0.8094463464582451, 0.6708720376523755, 0.5424906760819822, 0.8019962624187235, 0.8739378225211177, 0.6092326647311319, 0.6464720414336615, 0.5609447739634776, 0.623572003657931, 0.690215540053674, 0.8656586289349624, -0.025213372045699185, 0.7321551002683092, 0.6121043220646243, 0.6298995324822958, 0.09857332093124559, -0.046193112152706606},
    {0.6514588338250875, 1.0092226507259572, 1.0267777612768663, 0.649179344222347, 1.1469567015893738, 0.5859871622213425, 0.8836323241707409, 0.040759502030592996, 0.8012388223654341, 0.1130907287236814, 0.8558460150243551, -0.10238176196453648, 0.6315285323938259, 0.6677857709003003, 0.6332327041603595, 0.9088731263541071, 0.5840390409162001, 0.6068968074302971, 0.9827565243535932, 0.8181783389545956, 1.1869964990271435, 0.6712732366115779, 0.568467640787253, 0.8353410102910055, 0.9962814257608564, 0.4945886998812059, 0.043239245034086195, 0.5780966024198121, 0.2760480332475617, 0.7259292749977303, -0.18410230635931413, -0.40742438277475274},
    {0.7109149592037711, 0.6798974015130795, 0.7540814283881075, 0.5431755693180493, 1.0035848357187422, 0.8426882059760327, 0.587358570590225, 0.39853900474479903, 0.6362567208610995, 0.4188894930925696, 0.3213391731331515, -0.025156300926303568, 0.9845033928380374, 0.35080087143883126, 0.22898973602586087, 0.6179051475408242, 0.7081946669473183, 0.8358246531625162, 0.8249554033920565, 0.9016546904022381, 0.9369703437770026, 0.7014126227871018, 0.596583227900094, 0.8301832516184794, 0.7518124998421756, 0.8249031908542782, -0.0762894896208885, 0.9635736055185401, 0.5806886219590577, 0.5421027001213478, 0.009399858648851345, 0.03087965554134829},
    {0.7906468900948432, 0.3725388750257925, 0.7215519463215695, 0.9321557636455454, 0.38309580349162536, 0.8009517357439839, 0.7399864908742179, 0.5807476090009808, 0.5929438334927424, -0.1218542867936629, 0.6381348290272301, -0.08356919058487058, 0.8536321141568579, 0.3334967449378259, 0.2220841549722554, 0.6240194721682695, 0.768271503824748, 0.7185909817506182, 0.6496299746163653, 0.6221221933797944, 0.4987980666057782, 0.601775900411331, 0.7744329252914992, 0.7855519354629179, 0.6880906125471917, 0.4082311363358798, -0.2648545690188785, 0.6571076584071885, 0.6923432423064729, 0.5954471626306481, -0.36112486333064364, -0.2009446874299822},
    {0.5588102021401874, 0.7429544925751844, 0.8563126147891784, 0.6391627346679827, 0.833204401532526, 0.6829332693910215, 0.7153580533179486, 0.33077303602796243, 0.6687670844865028, -0.109744556397308, 0.7960930042441128, -0.04085954706732434, 0.830377849257519, 0.2950123645547291, 0.33556221692396765, 0.9336455655031742, 0.5742115568550127, 0.7773769327713729, 0.7316546085586527, 1.1227862925652796, 0.5173996466769768, 0.9833452778582197, 0.7534272827664551, 1.0626327094875272, 0.9865483646010585, 0.9289251799428022, 0.00026671792483628663, 0.9378297409367837, 0.11280264005366905, 0.7263188120240819, -0.15242617228146735, 0.192381112597981},
    {0.751688132843065, 0.8928898220125454, 0.8288944344804487, 0.8608066757990102, 1.0085498470370977, 0.6749755961331726, 0.4431801330245416, 0.6655654934890962, 0.4905520403583532, -0.31142089959104224, 0.8067598402285951, -0.10984490423546062, 1.0364991166039632, 0.2638655853693232, 0.48134381389347713, 0.8097798220419027, 0.5402392340265005, 0.9731946791676461, 0.6907508577368063, 0.6432429221826248, 0.559212607295372, 1.021220919455798, 0.304305882270596, 0.822795189943039, 0.9043743961084738, 0.6060047616942091, -0.12143652235371662, 0.8533668086637495, 0.5852443888733962, 0.8042320351397513, 0.0690815328490461, 0.006000194930672228},
    {0.8027099081332186, 0.9717166129932323, 0.9212859684322215, 0.787382444484616, 1.0797048892418741, 0.5720755261101507, 0.5576491521661296, 0.4412146955117925, 0.664342390331194, -0.17880437064502613, 0.7969476112447303, -0.2079780193221156, 1.350080612827501, 0.5681260758608797, 0.7605940056064144, 0.9629348498231999, 0.8522668110764087, 0.6944809556754189, 0.6584874864213578, 0.9901705735035232, 1.2360725787434934, 0.7913126814631282, 0.9775052335622075, 0.8451747447841534, 0.6198629235659527, 0.7687700370419555, -0.45066043002794826, 0.5513250180026155, 0.376881398619046, 0.5726874299694473, -0.02307748896365106, 0.23455980271682839},
    {0.8129422962841141, 0.8436674677232316, 0.9189434630879761, 0.5995402519317231, 0.904829447285702, 0.745444018940763, 0.4243211306654297, 0.5148350911372414, 0.8524958826128487, -0.286269029318348, 0.867094157059287, -0.2250314849857587, 0.9706269335843721, 0.26624400137229065, 0.6704318596466731, 0.4268226930973495, 1.1324994804412822, 0.7436685753781217, 0.567491334551708, 0.622357288797532, 0.4764709025048525, 0.7917250321666245, 0.6670322051400183, 0.8846341377876179, 0.8347859957442003, 0.5325134902063516, -0.08961492585862568, 0.7973640208325012, 0.5656972496104316, 0.7845482198910106, -0.07495980324507416, 0.3985854439609412},
    {0.6982072436788354, 1.0132901794371816, 0.7599994644521554, 0.4798302887060801, 1.0882949027582507, 0.6127523008341401, 0.6146442643164269, 0.38284568474550845, 0.7229850946092908, -0.4814036708167533, 0.4916017631813872, -0.04387283322836904, 1.1357687220698869, 0.4306919817990333, 0.2917746217746735, 0.5289876587125933, 0.9115188056709524, 0.525769187079648, 0.8395031303516933, 0.656302477940406, 0.7558405727671053, 0.5682443587325052, 0.6423836403042107, 0.781846017334163, 0.7460569297428087, 0.8724880259005254, -0.4166256031689444, 0.7839915102214536, 0.6880684643037931, 0.7441237625718763, -0.1752440098118507, -0.051144523486996836},
    {0.8551244345531644, 0.7008401048886812, 0.6371858045217738, 0.7399811838177307, 0.8752389199191305, 0.7254434711140696, 0.5951605583904253, 0.5814539213975286, 0.4481030795444688, -0.048546193694629966, 0.8810249183657141, 0.004658857572424139, 0.729791497581671, 0.47432835429816766, 0.8570966103547326, 0.5872064300493544, 0.6931565891289495, 0.7038600328824971, 0.741411407718591, 1.0189916732008701, 0.6563314854978445, 0.6602897603283482, 0.8985048137478888, 0.7961728625976912, 1.0801147214213238, 0.443103729199344, 0.0032170648540921793, 1.0924808057226982, 0.3737364872114179, 0.8080378505513666, -0.16687512713090802, -0.1509111045668992},
    {0.7856247809629928, 1.0868185452489973, 0.6977265693383097, 0.8648633060208327, 0.6106497022064536, 0.6084285820559987, 0.5464922308332019, 0.5423857219615978, 0.7596688103678754, 0.16195659252163597, 0.8768158701002562, -0.10555509661950864, 1.2273196545105165, 0.7227949278097533, 0.5537810781581136, 1.0714840759106588, 0.8772898775151339, 0.3817314586441795, 1.1096974851818213, 0.9616697388178348, 0.9336734897206277, 0.5908396965536904, 0.84472246763864, 0.9639712797477735, 1.2048489893536218, 0.634703471546557, -0.1333209013288045, 1.0274443247795242, 0.1655869754816319, 0.7304029070966234, 0.10611276370271276, 0.16153977096996977},
    {0.7590737279428084, 0.7988600504840301, 0.5834884783173806, 0.9335763294987166, 0.8293411144829758, 0.7315764415434863, 1.0995065985005705, 0.4599092676903837, 0.7921731057493435, 0.08427202700254052, 0.8253098684848301, 0.22821306482248613, 0.7728353765995881, 0.575036435449927, 0.5413326024406777, 1.107742638870926, 0.7012522937091932, 0.4545686976667196, 0.7718737219795324, 0.7994794609031864, 1.107933033874241, 0.9608215023779093, 0.9905700405520541, 0.7232223878719448, 0.7221599386203473, 0.6256864819973198, 0.21174525218034876, 0.8238303701722967, 0.5697014939819441, 0.6293625238698778, -0.037821075088105456, 0.011924042819363427},
    {0.3632443777329748, 1.0560039029982502, 0.7692957096540712, 0.559385653635468, 0.80273827642241, 0.9228301382974652, 0.605281423990625, 0.45261051133359226, 0.7999821889231236, -0.08801681475433633, 1.2177593681151055, -0.2161807749302593, 1.0231447294977165, 0.3403709798790519, 0.5350161971634118, 0.9189286823030222, 0.7657197485721443, 0.6533560970957033, 0.9472837500070673, 0.5731933049928746, 0.65438024102876, 0.9763491656938192, 0.8620251647241096, 0.8043057248390589, 0.639101797123808, 0.8776174831281288, 0.24569386653471634, 0.8936600035911714, 0.6316870001577509, 0.5307950996499744, -0.37096619993048935, -0.10483096134607293},
    {0.6815252912603146, 0.8899631229821502, 1.1486674915591786, 0.6670186429623765, 0.5714916110213467, 1.1714786010970641, 0.7278047360490381, 0.6526641528681609, 0.591942735605634, -0.09783275926757938, 0.655946392401424, 0.14482857255036463, 0.7854388240441589, 0.27950295070790454, 0.48576108929201045, 1.1405222610679497, 0.602559730103629, 0.7456407046870289, 0.9987280223725563, 0.7595577090434256, 0.5663299994007227, 0.6280933728298327, 0.49417826725364983, 0.9898121595965166, 1.0160435250805548, 0.4603502289001792, -0.1518679034849413, 1.0482076200838875, 0.7307449989751632, 0.690238727259431, 0.005491947236079133, -0.014404537283453436},
    {0.9877508813696394, 0.8696626328565351, 0.4834550557547053, 0.8412642653410174, 0.6559757744896213, 0.7929947128890054, 0.6638996847311074, 0.6020733567074655, 0.6910285528409233, -0.037128152728674035, 0.561216464697153, 0.12079069830709212, 1.0776336896747734, 0.3411765339153233, 0.33252247328764506, 0.944682714324484, 0.8821000643703228, 1.0991352468736222, 0.8072618219561645, 0.8669461054291818, 0.3154986000576172, 0.9233757453121763, 1.0250841030273639, 0.8369117550218106, 0.914959289158526, 0.9008852401674293, 0.014464294121756883, 0.8746883483058736, 0.43379158062932766, 0.3228640752759198, -0.03688929172630072, -0.19528120665468707},
    {1.0044144441099865, 0.8365868812189653, 0.757648310448256, 0.8331771777039106, 0.6772754705884698, 0.7679546452589795, 0.8872950947438514, 0.3257178351366601, 0.5093149463829268, 0.12164298900598318, 0.7444598410099457, 0.008514004140480359, 0.8553279913368808, 0.2887961415874928, 0.43574310349004863, 0.9028239536788885, 0.727457756314955, 0.6019141785816642, 0.7781104511791537, 0.9654853313873911, 0.7134202237342699, 0.6737987197366878, 0.9392293857378774, 0.7303377193584936, 1.073100852371444, 0.7209111999285062, -0.218569443260245, 0.855750678068634, 0.3621180133832739, 0.9341479771004482, -0.26154552339055637, 0.02385997402442336},
    {0.8440696633620992, 0.6507273256489401, 0.22477189766676758, 0.46142891421893234, 0.577982931719483, 0.4705852037281285, 0.6536323812212875, 0.3870442958344868, 0.5478274512899857, 0.09539664271131133, 0.941148709449322, -0.11705811321408131, 0.5329808497504961, 0.7287128396992505, 0.5041454919107983, 0.8869664786718813, 0.9030110604348327, 0.4909077489296237, 0.43174561064391476, 0.5102395523454932, 0.5611151160445362, 0.8098620671577114, 0.8903512143199593, 0.6637558163519129, 0.725951705950467, 0.5133783281000284, -0.2211782521151772, 0.6267251627141533, 0.12885124302871603, 0.8233513160331224, -0.30387800215093613, -0.49560771331018183},
    {0.7085488744703926, 0.7512823681436122, 0.2697832436552524, 0.9883996022303417, 0.5859097091583082, 0.6297660407009206, 0.39624985372472094, 0.3456765718112177, 0.7467511399755342, -0.17151601351131424, 0.9041584595482434, 0.26600897010547747, 0.812719280650835, 0.23919539169750376, 0.35279858920739665, 0.7780483584809108, 0.7010374076204903, 0.7943676115399796, 1.3608925702190962, 0.6986047322582233, 0.9248051315749335, 0.505497740728496, 0.7750546399410981, 0.5931919235067525, 0.6746488559417742, 0.558014805053727, 0.030066536612571644, 0.8979141289523473, 0.2354646481469569, 0.6790709394676193, -0.07579816203533801, 0.04420652991611244},
    {0.9741841607371815, 0.8436498597825843, 1.135775973403806, 1.2989290117385002, 0.9009945620790696, 0.43708677897677045, 0.4306658636025389, 0.4975735284244095, 0.6758088548188418, -0.10425265677809208, 1.0087457153266683, -0.29007191806153976, 0.8836731673109007, 0.4182245932388401, 0.1749463668373767, 0.8023295703159556, 0.9406498035827566, 0.8234117923289187, 0.6635506261167303, 0.6933926509008683, 0.9327733498480527, 0.8255559771892271, 0.8572288626357394, 0.9379474565348968, 0.7204613064725136, 0.6256857559779604, 0.09901654798453309, 0.6507704399384849, 0.4823701344126792, 0.8306773739687837, 0.20732599412744582, 0.05206696656109128},
    {0.9154142394943766, 0.7824197563875068, 0.820245241254725, 0.7275081824730797, 0.9375252983326883, 0.5936912159851926, 0.5734316152358445, 0.2966597954395337, 0.9972808168843365, -0.03832322175044507, 0.7680133355787419, -0.09133195437049929, 0.6844243483447949, 0.7784295100767958, 0.7827762988745007, 1.059543798079005, 0.8837446084688103, 0.6669118088893377, 0.8020173716991593, 0.5668999790771443, 0.8181039834158176, 0.7086254167166692, 0.7337584245613534, 0.7202155748292588, 1.0061742436700067, 1.328185438120635, -0.04506308874661827, 0.7940058842447133, 0.414074257420048, 0.6683527164839114, -0.1307285777892716, -0.17680978367328903},
    {0.7271694372419695, 0.3234042051687836, 0.6702548721843735, 0.6200338817119105, 0.6965224746836819, 0.7923295338515733, 0.5357138285345018, 0.0038303075374115157, 0.8230507178375356, -0.5413046234550195, 1.0531329371961216, 0.1419539367722934, 0.5965449243473845, 0.8285532136930267, 0.5069996301961587, 1.049623314734956, 0.7307368646993748, 0.5720759513045931, 0.9532571792194051, 0.9389969413702383, 0.7742360641023881, 0.4032655064410135, 0.7251538719716156, 0.8214539607472385, 0.8393678036799306, 0.617355886611147, -0.05878901862867378, 0.8440002591335946, 0.6098941226632789, 0.6286268105352256, -0.10116238662496481, -0.27021758256709577},
    {0.8349869875991649, 0.634417289628104, 0.8407988338559357, 1.0441348971673794, 0.8909693862040277, 0.5242625466191837, 0.497184258474881, 0.07879860322171252, 0.6763521663976994, -0.29821740108397315, 0.9144487635782265, 0.17527879550880415, 0.7481922159526573, 0.42650442631747626, 0.39649650183241913, 0.6451548992888759, 0.8877708594684913, 0.5429654165634055, 0.745709419940412, 0.7041000082694119, 0.6098320465099919, 0.9918287833990906, 0.9635563800878586, 1.0094140379796954, 0.851069945370172, 0.9496760162165166, -0.11363209430212264, 0.8134536601155964, 0.014122164521105197, 1.059703934219832, 0.03686238667167347, -0.2606660630417773},
    {0.8269661262782522, 0.6904920013826191, 0.9752260169940791, 0.8776749410145497, 0.7416460816416138, 0.7272675124123947, 0.4837092745028758, 0.4726876911341309, 0.8419253148917393, 0.022404984523993074, 0.6943188256037499, -0.002806302929369656, 0.8494367405108799, 0.16427164435708952, 0.540838795312432, 1.0409818499662218, 0.8306819904350147, 0.472064739617886, 1.1089833896141326, 0.8039173139283756, 0.36966872143627416, 0.6269533032301776, 0.36481647773878734, 0.8001436872712304, 0.453786226523767, 0.6949224035993864, -0.04779559830035043, 0.5330370520093016, 0.35645801417105333, 0.6565598726390653, -0.030017012668519808, 0.1430350995439925},
    {0.6445316881924452, 0.9438618798849834, 0.8356444534027346, 0.9364750242772734, 0.6611614680578983, 0.7257852319451336, 0.7761489108572558, 0.23115776833853, 0.4757592353791564, 0.1874449520063971, 0.9890049539166202, 0.0660287213537421, 0.9147350010896927, 0.48637196235628444, 0.2541047193400853, 0.6871683616401864, 0.7812454859387936, 0.9940139427833058, 0.3338660175503138, 0.7542401685415853, 0.6591341191998356, 0.7986242561437089, 0.8154301813051291, 0.7259935014044283, 0.7833019896920895, 0.9082081986131844, -0.11879966510979358, 0.9124763546537739, 0.1742537996770167, 0.4926976372759623, -0.3308351714914586, -0.14054644266962146},
    {0.5167050302141104, 0.9419052317321234, 0.7955206417392546, 0.59994358137589, 0.6025854162585864, 0.37248494541987004, 0.5797841760944624, -0.10747560199566807, 0.6037562343909025, -0.1778292950204561, 0.8128120807027753, -0.029111956733932482, 1.0128142954956494, 0.4871516185643276, 1.017487142830984, 0.5822524203193502, 0.6005956515905992, 0.7055822164671179, 0.9965873864494368, 0.711073665022155, 0.34146341606591263, 0.9395513706338827, 0.7698165195113071, 0.869015916553547, 0.5354028945553347, 0.5371631488357425, 0.2667214157567192, 0.8198482614195549, 0.47957605681333787, 0.6845076106272272, -0.22325723272420236, -0.17403655722502656},
    {0.49176001505262623, 0.6301370021967861, 0.4692396141785357, 0.8413281163832916, 0.8762038454002045, 0.9449426260253035, 0.741138165954122, 0.5587838240194397, 0.8787011951519225, 0.009481408806241055, 0.720878168190365, -0.07653565542406295, 0.6441333420508835, 0.6591143209368687, 0.40591086265204496, 0.7733622698884055, 0.6409498882901445, 0.7900418849529847, 0.6891159992526439, 0.8222561541822428, 0.5256089226109856, 0.6850334017906029, 0.5260610118586425, 0.7664642628946813, 0.6617972662704917, 0.570863787572211, 0.3518507593315061, 0.8805576028440997, 0.39927576602878956, 0.4219865395390392, -0.052823399364476824, -0.17364231990142684},
    {0.9155502968722135, 0.9640727812369072, 0.9328779767239466, 1.0117575910394052, 0.9536054460794556, 0.8122035038997714, 0.48252164346507376, 0.3310780679093472, 0.7723712764712317, -0.2642056660708076, 0.60835958858229, -0.06480130914386603, 0.8181934330403167, 0.4185544100598461, 0.16855806817955446, 1.0933353986615053, 0.6023354494484073, 0.3359171438294972, 0.6826188201119628, 0.8195332353607704, 0.9780273793438017, 0.8046127574917735, 0.9437586183698228, 0.7209252954557458, 0.6575546918144702, 0.48605759420449407, 0.2996044088928467, 0.9513352294347107, 0.43358560932448115, 0.4291871519193209, 0.1416695959369292, -0.24146059288865224},
    {0.7098383266508497, 0.7021845266597431, 0.6724743067610516, 0.9416930124702282, 0.7556326607537319, 0.4650409204885434, 0.6694062347605334, 0.3924870307237996, 0.9929033805966312, -0.3622824763678067, 0.9817177868934827, -0.17700413889904887, 0.8658699645672614, 0.48124497542048994, 0.8065867112770317, 0.9864313758585079, 0.69618054163703, 0.590956088518133, 0.7793702018718248, 0.773380822166553, 0.6172919123915558, 0.6263644557514924, 0.8487259924976582, 0.7801939180751998, 1.0366824347145762, 0.5480309040202072, -0.2596758543848799, 0.9755400945911264, 0.13947720378779213, 0.9702400115213312, -0.284920004515213, 0.007772462677935876},
    {0.4952157225448528, 0.7288133744961379, 0.3967182012516656, 0.9117768798805597, 0.7358761411087681, 0.7202205191071037, 0.5726572249039322, 0.17558048319210795, 0.63707990673263, 0.19966370935912384, 0.7854093450345256, -0.1785742887028891, 1.077706978880285, 0.23627289279247732, 0.5291940182871274, 0.5798258578630897, 0.6971283986718596, 0.4933325902369298, 0.8895778259560753, 0.7246629654044779, 0.7684764896695351, 0.9103840869519556, 0.7828787742391962, 0.6740983830359125, 1.038231650360286, 0.544168488922098, -0.22309228060139752, 0.7227200465612695, 0.5638999199184332, 0.4699546268615034, -0.16877034956077802, 0.335102504747137},
    {0.8639658902007558, 0.6594022452421415, 0.6951824736937057, 1.0912659530227562, 0.8637469403361414, 0.733695412204306, 0.6713125569394461, 0.3296445802929597, 0.5896509525015754, -0.053856266587104, 0.8630515777833322, 0.1421338551212958, 0.8477138638906896, 0.36588381908498485, 0.569339826981093, 0.653872713336115, 0.8759702152757737, 0.5658209734744557, 0.6463533340853335, 0.9527233324783406, 0.5913503277958657, 0.6956443658713365, 0.8247910162182921, 0.6360797361754195, 1.2495994533277313, 0.7244589366444372, -0.07260296868385473, 1.0559555736385586, 0.7088530180782396, 0.8514063415476536, 0.20183047890674305, 0.17813955943582885},
    {0.9145725013318278, 0.9767096908170403, 0.7188881266898808, 0.666681870581551, 0.5880466879514964, 0.49212187224512893, 0.5614469022195894, 0.26340807924640525, 0.6941847093130994, 0.03280713698401138, 0.850135689691808, -0.06545921405685382, 0.7173365071720481, 0.5208640472469831, 0.44097100280679474, 0.803448801366553, 0.5534151877302359, 0.7583911065808824, 0.5613746051446814, 0.6178250757153813, 0.6161295993239617, 0.9816014414554688, 0.8944057698778051, 0.7819348719368953, 1.0602491192513477, 1.0066780543848473, -0.26335710468873597, 1.0730972170804618, 0.6364944022965121, 0.4178222701004812, -0.19549851902678705, -0.07215260318918625},
    {0.6474010904902822, 0.6109635409981121, 1.0387043122634925, 0.9191837929669748, 0.6862916802289575, 0.9545983410816955, 0.7671617425484665, 0.588555316504285, 0.6927739304818933, 0.010372605988049247, 0.9805389336474545, -0.236617521000184, 1.0185334996284479, 0.14997626984285428, 0.49815683695442103, 0.748955349997365, 1.2426171811695328, 0.7209302145331842, 0.8424849936409583, 0.9108555691528194, 0.7175257949748106, 0.7420250164528053, 0.8762854642636234, 0.6008171458524312, 0.5667703782237717, 0.5447649470033756, -0.177520598066771, 0.7202074677426172, 0.38388996484651117, 0.7192210537111551, 0.31042054208941416, -0.13261577188158952},
    {0.6897978274509164, 1.0150277464240023, 0.641977256360107, 0.9635143637055715, 0.8328674039573424, 0.5888176548273948, 0.9316052968307216, 0.7326236932100542, 0.9029930084707333, -0.043619158980641476, 0.7664566819429847, -0.021960305004965146, 0.5925466319552299, 0.473542896791875, 0.508781356432688, 0.6719536497140404, 1.10364269640486, 0.843828600909695, 0.5670092293007546, 0.8966301858736782, 0.7456857175213134, 0.8589200680706108, 1.2381430617415388, 0.9265802372121772, 0.9170022871981938, 0.7844743557336037, 0.0159279126891415, 0.7978906034597212, 0.5472833397071637, 0.7939398175979405, -0.13911979181204415, -0.15470356875500313},
    {1.1263569721911537, 1.0660555099219478, 1.1384312316145087, 0.8694297395030572, 0.8565472657201086, 0.5557602707138594, 0.30928562866036186, 0.5302594868360383, 0.6262496420907322, -0.008815914959199776, 0.8713571397157004, 0.20464158389350892, 0.408672174268922, 0.32670479482467396, 0.36752093427947724, 0.6771542602915841, 0.9377324700408186, 0.44160580603303734, 0.8188182777260177, 0.7002995228385993, 0.77175581640184, 0.49421990691188333, 0.7471604393868757, 0.7737177632984084, 0.9424669152656363, 0.8530137199421385, -0.02036219989856917, 0.8070893038450937, 0.5757157118887619, 0.5578421663874183, 0.0910217026803212, -0.2650813468563673},
    {0.5306163761936792, 0.7260553209509465, 0.9919790600698435, 0.6894649655838894, 0.767239725875786, 0.6720418784153268, 0.564891730109615, 0.46782724987373864, 0.6481827833046381, -0.11222046746242502, 1.2683410117960976, -0.1024611365101595, 0.7532287457194707, 0.5619968895080378, 0.3228693544105676, 0.6815016823238306, 0.7395305092526937, 0.632642300904683, 0.778116862314944, 1.0487217662745492, 0.8157771807072353, 1.0215783708442032, 0.9021167399711488, 1.066748033706207, 0.6373313985296654, 0.5514549503444768, 0.025383057469135856, 0.9256428402317569, 0.5395221038374248, 0.5213529102934652, 0.1793371331576587, -0.13827229019157644},
    {0.5259618212834137, 0.5204582549932774, 1.0280968964045658, 0.7785790001528946, 0.5010427095283779, 0.4678685362594079, 0.6354241589705527, 0.0673319159199294, 0.40646084191694853, -0.05961605181103008, 1.0363934677417068, 0.07966133950294148, 0.9178564535353091, 0.4349189079298099, 0.4859043803934555, 0.8376564587987128, 0.8655924800862457, 0.2843975741485347, 0.5883061997596186, 0.795262985750701, 0.5499314752244769, 0.6465874679097076, 0.9463337228850569, 0.590697034656728, 0.8334307722206781, 0.6708217988085112, -0.08765808713525625, 0.7545062633339618, 0.4898843306031207, 0.714728633531328, -0.16257902377369754, -0.0733230772711731},
    {0.5915992931665326, 0.9377637521541887, 0.6835534964571425, 0.5223793010058119, 0.760263943302114, 0.9822724936159485, 0.30880686079075903, 0.498892867393711, 0.6732961252229706, -0.1786598647821027, 0.5648083352394068, 0.030493276737356103, 1.137828913064526, 0.4758108891905662, 0.5974225756663769, 0.8830036329278272, 0.9191854596508946, 0.6349161944446432, 0.7625245764844962, 0.8116098114763717, 0.7155045673820907, 1.048483022631737, 0.9673778081200858, 0.5476635128887237, 0.8739820235448152, 0.5428840259144998, -0.48977314207610584, 0.8866083824094818, 0.1843733886167885, 0.7579072595936874, 0.09132696499846, -0.18610726477037004},
    {0.8259497005060421, 0.6503920885257192, 0.695605629922018, 1.126692423580006, 0.9791118585293079, 0.9552873170298364, 0.6232627725747069, 0.3492155261790609, 0.6623493578719959, -0.1985856260623666, 0.8237669695641344, -0.04601441140224014, 0.5931451643844382, 0.6197381727688496, 0.30523340960592993, 1.0697645252488046, 1.1399031258836563, 0.811155664649905, 1.0559382191804987, 0.7534796686060365, 1.1642699555299736, 1.0512278778325637, 0.837399910843845, 0.7378331953635131, 0.826836167264851, 1.039686954192829, -0.07658406021777046, 0.9486132213164074, 0.6478610842992236, 1.0884061646556036, -0.09137896656418526, 0.20555846616585363},
    {0.8690360377395916, 0.9198030597092681, 0.7836650921808209, 0.7291494243642045, 0.5486504497094579, 0.35606837868409785, 0.8171313600376253, 0.3615969841084932, 0.503569517579969, -0.009388132216244622, 0.8987987275622467, -0.20935639971511946, 0.658720210339602, 0.687444988171531, 0.9788836301754423, 0.811514644574513, 0.5852387239369529, 0.6182562770428325, 0.8859620238508713, 0.6938506871195381, 0.3596875381118534, 0.8972714080427571, 0.4286038513562603, 0.9568402790630888, 0.8762341350819938, 0.6032719945888448, -0.06474420104142009, 0.9895902838029106, 0.18624006474683455, 0.4440300151845571, 0.19805627319855199, 0.026849309999936358},
    {0.5761984003996646, 0.9023201427193612, 0.6218302618140354, 0.7414286070311518, 0.5728581154829558, 0.47577243528381435, 0.5403685962189404, 0.5545249668973748, 0.660401094686, -0.14801523248621343, 0.6349061723104398, 0.23194044208285358, 1.3025206168956551, 0.16140653291928228, 0.48875768339255676, 0.9709804623495992, 0.8695145080691267, 0.565711106488857, 0.801057266298381, 0.8146287714877083, 0.6568772462300284, 1.1065555756055852, 0.998925917337647, 0.6631600862145618, 0.8635385284840164, 0.6211351638678604, 0.008232643243550256, 1.1560040909563998, 0.7092250381961986, 0.5663798518132267, 0.09374537450361171, -0.14454892389061147},
    {1.0002103603694428, 0.9749691649474096, 0.7818892215822872, 0.59381777083921, 0.8187631096018881, 0.4966534359188138, 0.52186781935831, 0.7085893808201779, 0.8439521037701759, -0.08852187689402438, 0.6124972325492656, -0.06462158510511493, 1.0707883556371043, 0.572329015003455, 0.4062181869262942, 0.7157819375269375, 1.0424775169013858, 0.5849260294514614, 0.6271861891506187, 0.841154843985605, 0.552416571723515, 0.8304632341384732, 0.822734185725518, 0.9478366485337603, 0.8062373158954503, 0.8735665068756475, 0.13915881356296586, 0.6216189054976214, 0.5120884224502501, 0.503302592580604, -0.1853466380074464, -0.4368827394643926},
    {0.5733549465974118, 0.9399101991483041, 0.9505965007866777, 0.9894765251005098, 0.6745367996954352, 0.7798162385982487, 0.39955262619150356, 0.24153014151061417, 0.7535844061854257, -0.2542509916884806, 0.8732537816884671, -0.04721882549011861, 0.6085400255039528, 0.37692899942084324, 0.6169678402750847, 0.7402947701169857, 0.6977642390279916, 0.5207786277586008, 0.6146244310431451, 0.4833475398052193, 0.746566301019651, 0.6907929208707366, 1.2154398011519965, 1.01797597302164, 0.4857761054092956, 0.2650349571023804, 0.026631325948359822, 0.8567489712101782, 0.4654972944692802, 1.0445019664592317, -0.22542597832878544, -0.12087095925585853},
    {0.6223025999379999, 0.9328364011220144, 0.9146329869500263, 1.0454597419464096, 0.9316527440035712, 1.0685559525085975, 0.6647811793804541, 0.4110770083273999, 0.767627279404089, 0.20471810004081226, 0.8620727129196508, 0.20350593084485674, 0.6438351535258748, 0.7272366021165393, 0.4120061249293194, 0.707767731066621, 1.0207349741694811, 0.6415996795328174, 0.7811568594203245, 0.8859020901436949, 0.8190558692982509, 0.43914615536408613, 0.47096005479764547, 1.050159681529857, 0.7601115079983224, 0.442115989572557, 0.06952429475396496, 1.09707629208626, 0.4665171677310582, 0.9015735764956576, 0.026360771947653655, -0.054301446171954565},
    {0.8445845238754458, 0.8250699156607408, 0.762269605566387, 0.8529853941657263, 0.6297601336995785, 0.9484928105701436, 0.6325638358779228, 0.3100248324877386, 0.6363982007840302, 0.2570720856102967, 0.8278202918006231, 0.19724719649001918, 0.7503489193664987, 0.46299793090846936, 0.3995682509342952, 0.6829846315210073, 0.6057838509173447, 0.5591997463130143, 0.9265324076999444, 0.8148853654944241, 0.5270686770701476, 0.6557734320613865, 0.8751818019911177, 0.5751616543873956, 0.7193093761158315, 0.1825462349077512, -0.11748639469305983, 0.6272102263786704, 0.38075177713633335, 0.7429764790319666, -0.31031421784104496, -0.26024419684000794},
    {0.6253891106969913, 0.6429260354575338, 0.8119345816751112, 0.8356829168555391, 0.6935004825418484, 0.563016784367265, 0.877955673019565, 0.5370007715526711, 0.8133360063949663, -0.018573861497244232, 0.6487953042559537, -0.19017878876327446, 0.796852589042074, 0.5625424841054807, 0.3991015066322395, 0.913298578742891, 0.7442333018336231, 0.41961941785374623, 0.8232174447323944, 1.2011782843798329, 0.6838698118701247, 0.5231969168377756, 0.9639522717746245, 1.0842232792048119, 0.8737351868953438, 0.2082368992214023, 0.08652150525417995, 1.0492384323215014, 0.4421439621504978, 1.0358615870060437, -0.15651685728062645, -0.0363517635666559},
    {1.0257775306442085, 0.9143187162476906, 0.698696136784325, 0.5409967639772686, 0.8030495162143594, 0.7253346448652576, 0.6917895555978181, 0.37859653789977404, 0.5732165649079382, -0.26063445510646904, 0.7300498278060518, -0.1420625188841394, 0.5273314209776363, 0.2409355972091366, 0.48537392139477925, 0.8288213392323173, 0.7105879355828554, 0.5467072733194132, 0.6302443580935528, 0.8665573230595736, 0.8328834219001371, 0.4942877142924491, 0.7903908908172792, 1.0154314897185175, 0.8605552586341045, 0.5421578606796087, 0.16056124368695454, 0.5590053034766487, 0.6136812132980304, 0.6514679713962304, 0.13103815980841907, -0.173099143293911},
    {0.5758662553788633, 1.0908644042729705, 0.6794021228855722, 0.8916819097548966, 0.6520793020856114, 0.6598993607174499, 0.39071369696372554, 0.3992761854022978, 0.682421677035599, -0.2137390836015233, 0.8511089497711779, 0.13052647618330007, 0.7577419583201542, 0.5383858900322738, 0.6985181788327176, 0.47720877937854644, 0.5067505110897511, 0.6344651403212112, 0.6638198129380316, 0.9524105399105017, 0.6388543716155992, 0.7035888136491858, 0.4965142410400578, 0.9332808168748387, 1.11348027908961, 0.7075428808369302, -0.1274336555995498, 0.906272420834495, 0.3026701359510122, 0.8163029067014798, -0.00837872204710557, -0.008338816704387375},
    {1.0126461921560084, 0.6643345148465915, 0.8778081949760163, 0.9120582349262597, 0.8301266299857665, 0.8562895045375131, 0.6786980612477499, 0.40305832609189457, 0.613436479187174, -0.38480632671321957, 1.0402875840422283, -0.05157863280370696, 0.5203948990323797, -0.01853079762214014, 0.15729584774995434, 0.5978076271418991, 0.892180583515115, 0.5144243164412494, 0.9340156004988815, 0.7652680887527543, 0.5925739397940375, 0.7005095506334468, 0.7066756868443509, 0.9590533196565569, 0.9096850233582183, 0.7437729074817683, -0.010178446616934943, 0.6800075494980266, 0.10521522435776086, 0.4089622496293676, -0.27128461931156994, 0.037840385562041674},
    {0.8591912903557696, 0.610243885420988, 1.0019917270767598, 0.7575471814820526, 0.7228485320344049, 0.6464023046724874, 0.7258130949065544, 0.39910511193869097, 0.5801300196901772, -0.3767661307937368, 0.7580806956636749, -0.04638469524520619, 0.8274482011059867, 0.617059401528568, 0.6477700899714924, 0.6709980228041795, 0.7558645109759684, 0.6207290650400569, 0.8716941152162221, 0.505115972109381, 0.7439359360209232, 0.6297301586395705, 0.7440103325340185, 0.9219519621916091, 0.5130764959142015, 0.6671791403620309, 0.17777839772674456, 0.33418633767971495, 0.623754890302837, 1.026356944771357, -0.07992181718447339, 0.28283188731768005},
    {0.7010776585830398, 0.7734380271418556, 0.5705234879502111, 0.8529375328227622, 0.34341511071074204, 0.7120049227512041, 0.838064399441342, 0.4404717487284463, 0.4666654452071634, -0.052090890856211956, 0.9383116649668879, -0.510401567250966, 1.2192446817601257, -0.10973566898928076, 0.4473725911199677, 0.27031670074113906, 0.8793021887731357, 0.5037009441639314, 1.0729161945937498, 0.5275119902762343, 0.8156957282781818, 0.829853914956599, 0.5376249168642981, 0.6490023098380862, 0.8761876086319538, 0.5778549231598022, -0.4992546673469521, 0.7958148121913513, 0.37463646543051266, 0.6920861447408861, -0.2314974450932586, -0.005323651321227273},
    {0.4566032088123272, 0.5402248655113707, 0.6570422547062222, 0.7073522956889664, 0.9439776282811866, 0.7156407288304872, 0.518387967493178, 0.5388610642868065, 0.7375036050412198, -0.28541331793484115, 0.6799448399036638, -0.11715972028584623, 0.628204751365396, 0.8240437441174131, 0.39839982673880775, 0.7446786564871423, 0.8875943175477519, 0.6582839653665987, 0.8173535281667517, 0.6485909273398596, 0.7795826282042081, 0.6014536414313246, 0.924619532480874, 1.1538787562822008, 0.585248561781484, 0.8047856687928057, -0.09409773009031164, 1.0561522347553414, 0.39371452729676726, 0.8350976081073953, 0.18978067682591634, 0.12937885254937462},
    {0.7593564653992645, 0.5433476187488459, 0.7636355507330331, 0.5659479011877602, 0.8763450745972733, 0.7378274838518205, 0.6683499205246859, 0.5415178675696716, 0.5492945806575037, -0.02468022006000629, 0.6136563153622816, -0.5113494881136569, 0.9455630466032019, 0.31096253408849067, 0.5468034121967483, 0.586649897655219, 0.7498259276903634, 0.4845738390207537, 0.5829539754611331, 0.7609683496371461, 0.6280715741716464, 0.6922338873006341, 0.5698306519003633, 0.569539277502919, 0.8361010927604204, 0.7564466191268043, -0.0916429713679561, 0.7314959614572353, 0.3055606215616346, 0.42209289362206964, -0.06269474633856854, 0.066000373971507},
    {0.6410249248294114, 0.8319094206922721, 0.8372964974213749, 1.0982057439476556, 0.5108414910922847, 0.3787735826626995, 0.7915349996953998, 0.3239618491543256, 0.9115365371094247, 0.04539392324454169, 0.7142647916702191, -0.03711199110427364, 0.8660644632763608, 0.4191843679163519, 0.5572145314391762, 0.8256228049901891, 0.7573633181235396, 0.7670998231927028, 0.6527280820312124, 0.849413120836019, 0.41326615810060324, 0.5562732414083541, 0.5761390750687408, 0.9349625785450066, 0.8441852576071752, 0.898238713927425, -0.18349797491595238, 0.8569196491562935, 0.4537535530031454, 0.5193697872843147, -0.33920889007695465, -0.01102097402448955},
    {0.6958702978005505, 0.5737457655792044, 0.8316963846560878, 0.8128835545834248, 0.6463571154664455, 0.7170623803515969, 0.5488200228420624, 0.17502271819520443, 0.637217857984649, -0.27816959186337065, 0.8367116082132899, 0.1887682389044622, 0.5607518848417068, 0.5810114877135721, 0.4918909429633469, 1.0055513922465287, 0.6980406924170073, 0.7633218177990068, 0.7083524405260184, 1.0079948541410706, 0.731864004698154, 0.6360165464957953, 0.3119004002771447, 0.6346381392579369, 0.7098977359204732, 0.6860145459923753, 0.09542454940486335, 0.5267592515960582, 0.6306480222141049, 0.551367472465238, 0.27127507269783746, -0.34833643821285376},
    {0.5226267393850187, 0.6376202242669006, 0.697989306057267, 0.8844480677976468, 0.7496787138647121, 1.0432393893312604, 0.7749745809069988, 0.46209212616254164, 1.0250661780911248, 0.08996258733789217, 0.8142163934166382, -0.07567914787894169, 0.9195085401283248, 0.5798522467528907, 0.7754359665970514, 0.8364886103893887, 0.9812267008085812, 0.5931979166523405, 0.8521140118179469, 0.655421156892617, 0.8277938742876407, 0.9016392043656327, 0.6514197620450538, 1.2272807824905565, 0.7629094613917109, 0.5006073594130782, -0.18230921547787793, 0.6987540978389588, 0.31580019829383266, 0.5853321758454071, -0.013318206052599684, 0.29738562789250056},
    {0.6972231568901778, 0.9841138661557788, 0.9892243108397681, 0.8770166504648739, 0.9818146870784108, 0.6621087648448302, 0.9172506930093617, 0.5743943265137774, 0.4491383297798453, 0.48014355437583045, 0.8356280539965811, 0.02195606299971003, 1.0674893975202282, 0.5503724846977841, 0.7866632242806684, 1.2870000131239925, 0.8962216901959583, 0.845744083647333, 0.5798032123634238, 0.7048399827649783, 0.7706958383072695, 0.5569267722449982, 0.8102668891013503, 1.0293355643176676, 0.774767194575065, 0.9408194235197503, -0.1337981936943791, 0.7551568618092065, 0.5327359470608256, 0.7753585886800504, -0.22015192824106494, -0.3499721811815492},
    {0.7207606212277192, 0.5461465799989769, 0.8432113197750577, 0.5435082745813811, 0.706572972420498, 0.7177059357219739, 0.43398800044602587, 0.5409372722921987, 0.8145820200006716, -0.2408118106899871, 0.8673150522932654, 0.2524581742548557, 0.8725866082387472, 0.5438591467302168, 0.7745850542084068, 0.6279962847201518, 1.2138397173019255, 0.7247483329190266, 0.8505431815404274, 0.6746868283240232, 0.9523806453782361, 0.5555535551852374, 0.7780459739532692, 0.828830466107423, 0.6763077608339904, 0.643830106009215, 0.06329918853372103, 0.7726412792227304, 0.5795975555141734, 0.5186391630021209, -0.072160037895276, -0.12017076327690239},
    {0.8154465155677161, 0.7200003578093007, 0.69172299368803, 0.7479783111387673, 0.576141881997152, 0.62086231468822, 0.6688803162179029, 0.27143502800654207, 0.7870491118526478, 0.008562255400111986, 0.9932508047169252, -0.23088940849412132, 0.8175927382444544, 0.36197408831323746, 0.8416535648066603, 0.768544630475905, 0.7876379472308243, 0.326685046159782, 0.5697058495544417, 0.6891150619212981, 0.9157486365452855, 0.7909969891454691, 0.5349756175490313, 0.5893667945829714, 0.6660826767636935, 0.5953914638017817, -0.04025132989450261, 0.757464211394656, 0.44279751895058406, 0.7232108756949608, 0.03728187843258727, 0.2903949857586036},
    {0.702953087191685, 0.8798203829162058, 0.8193009975027408, 0.6964140885434663, 1.1599862589060168, 0.4452290036688258, 0.461670415659659, 0.03400743225425134, 0.7418535785458354, -0.1266380891691472, 1.0006435139144534, -0.11893184536320912, 0.8445374647848365, 0.4251086485582466, 0.5899181727287929, 0.7646996504100084, 0.8174437226123263, 0.5499063036851252, 0.9060792020465279, 0.7669668356853133, 0.7769111105605987, 0.9323700055516293, 0.6126259331186947, 0.5551283524112742, 0.7739124793135587, 0.6966344342474696, 0.1999580761020854, 1.1507752234223132, 0.5435205226423886, 0.7795975959492758, 0.017506730557131728, -0.04567601028655237},
    {0.8166326361648601, 0.9888642522988427, 1.152507523111863, 0.6476759520921562, 1.0103981622975882, 0.7065580461823248, 0.6711037042219921, 0.6127156962242108, 0.6609661139931718, -0.10312197994077525, 0.6625483309402482, -0.14278132820682202, 0.5338746884112492, 0.3721910107423695, 0.33557557925650744, 0.7583720372704843, 0.8871618513785294, 0.7882953069781055, 0.7726259219980631, 0.7735922585465848, 0.7176197676160339, 1.0103840319146635, 0.8821230177185465, 0.7739549802347491, 0.6213510938301966, 0.6411439114048838, 0.0797196781928694, 0.5255977932431529, 0.33415305625236, 0.9989026977925402, -0.08042353744230366, -0.16344494277233798},
    {0.5905278710820754, 0.7257790693337957, 0.8666935251045166, 0.8929750276891542, 0.560156218165343, 0.39088543728035685, 1.0113297563470023, 0.20096743950630638, 0.8867242315982236, -0.12036772102329688, 0.9709417929768706, -0.1660317816034633, 0.810380973674984, 0.31565199310442255, 0.6025973714205635, 0.6759285898742972, 1.0084963320722242, 0.29038874191478997, 0.800002145431515, 0.48379730177780084, 0.21349176176777657, 0.9570725848501548, 0.7986063527816571, 0.7981356162246941, 0.9107525274394568, 0.493332779231304, 0.010259741832595965, 0.9910857735203369, 0.3596068862020121, 0.5915018450347724, -0.1990578555830926, -0.2893542587301097},
    {0.8632479137339286, 0.727256420838096, 0.7847672359316278, 0.8075471081057649, 0.5363873709685979, 0.33502138310318863, 0.5540494004988238, 0.4874583698895041, 0.4893878062540955, -0.13748519462038222, 0.6555295513747673, -0.12766549792538479, 1.006537105759944, 0.7604770324693853, 0.46462783394972595, 0.7690081472092919, 0.8380822087124686, 1.116314867167822, 0.7928133281802054, 0.885506999430505, 0.9397101208100495, 0.5989679467838815, 0.9224250170255047, 0.71944542390374, 0.7113647181902627, 0.789073530062688, 0.009362305831863435, 0.5762586784133557, 0.3024689375701113, 0.5159606441459988, -0.06524410147724072, 0.09684508261662374},
    {0.6878450312095182, 0.7545838378895124, 0.5472053781772369, 0.7836500544341687, 0.9276293278729836, 0.5671252586587899, 0.45007379054778945, 0.26131733070825786, 0.716068858738462, -0.057126112783511485, 0.6497065332451604, -0.07632317035424403, 0.7751053334872889, 0.20497117318773905, 0.7168021694532154, 0.9898364497365013, 0.7569149538145005, 0.8604840567535044, 1.1048855004389802, 0.5670806645417235, 0.5424331522255473, 0.579864293508479, 0.8153576069955392, 0.6485540506389614, 0.9509631740060823, 0.6856386852060099, -0.0100548752220078, 0.6891593318834148, 0.36356515693340885, 0.6982843206587265, -0.14984322018317672, -0.22917508962673758},
    {0.8688097312561462, 0.9049285673028109, 0.7261764279593962, 0.8794801279732029, 0.6798046146776703, 0.6521453227892994, 0.796230589079099, 0.5669518516574342, 0.739630540629178, -0.08767886056549012, 0.5251984072581608, -0.3503819341760109, 0.8276529811678524, 0.6373057703615596, 0.5300869907058718, 0.6552868137170668, 0.8628484237174351, 0.617266693105579, 0.6331178071538747, 0.48100422324442, 0.4800759562977051, 0.6869837329654205, 0.5869267562205157, 0.7762952354711423, 0.8889501616401693, 0.8080525916379049, -0.03847076688249155, 0.575884778430318, 0.4067212576771812, 0.9825022471022217, 0.08122118547194647, 0.07616930625603902}
};

static const float b2[32] = {0.771089403932087, 0.7378205157626925, 0.7399397546089693, 0.7477920217069813, 0.7174626624016269, 0.6861460391752336, 0.6425030568627613, 0.5228957509573028, 0.6785006435093286, -0.069469505409442, 0.7684851327262511, -0.061742397025137986, 0.7739844720953339, 0.5139681938021028, 0.5453290054527976, 0.7744527730917681, 0.7708247391311909, 0.5903687334066376, 0.7250467592070581, 0.7246518870863725, 0.7874256095287565, 0.6847797406793822, 0.7613002823543591, 0.8090440921933044, 0.7989723641410628, 0.7081246554352723, -0.06970503925845097, 0.8159658218432603, 0.4781877793091904, 0.6814087173604776, -0.052176927781796154, -0.06352036759488619};

static const float w3[32][16] = {
    {0.03866196298490077, 0.18229896711256197, 0.9336813061003958, 0.8702088850222433, 0.4943606992150242, -0.11108819755432404, 0.7691280393381859, 0.5756067203567158, -0.041034624160632, 0.7934000449806006, 0.13288768055497985, 0.910448602036916, 0.99080198724622, -0.4036572554751346, 0.7819284632059764, -0.027095135218973793},
    {-0.3078768108415785, -0.16487302331736, 0.5336749444602552, 1.4601742982132195, 0.6477320257787534, 0.22039462512379135, 0.991575985602653, 0.4949150609450172, 0.027246470830037634, 0.7415861786235007, 0.31075191373406885, 0.5605805639631141, 1.0295929289364365, 0.2763944994818144, 1.0497389492893634, 0.11449520027332641},
    {-0.3301052711081892, -0.12423115654538765, 0.7798228326847328, 1.1355809294022252, 0.664226268848648, -0.024150452768913526, 1.1304701883500823, 0.6622418158532204, -0.540187432357893, 0.5988140358007283, -0.06706252814840999, 0.7999482794355943, 0.7543430340285805, 0.24724647585360265, 0.9847153636621248, 0.1617993888590529},
    {0.0965807897710675, -0.18157476073010861, 1.007221741730755, 1.0017741544732541, 1.5486669622873048, -0.010022978675631308, 0.566455908663039, 1.0882592427027868, 0.18128181696249165, 0.8773924733796449, 0.32491168983656243, 0.7499559060819586, 0.6293123398895214, -0.1157360832313325, 1.2092443722935198, -0.3353643018716408},
    {0.08728977802616233, -0.19516725908496532, 0.5644742712364608, 1.0843931293215263, 0.723786975302488, 0.1731578025155582, 0.9040513260042025, 1.1911005284102631, -0.3192474924101235, 0.9686548322361551, -0.16682734281819622, 0.36945935279039605, 0.8942892475007108, -0.33891582816997856, 0.5821810067825236, 0.030335117273593788},
    {-0.27365635110629544, 0.09372847024284515, 0.5079440399976016, 0.870728959258802, 0.6971351104660081, 0.16078528731360106, 0.5397045063159609, 0.811351246317134, -0.0116351360436799, 1.0261275901398146, 0.298761013870859, 1.424347536723191, 0.7112840071642734, 0.08187172384030575, 0.6592211644343416, -0.24243266364526275},
    {-0.37257873575620426, 0.10905321705414825, 1.1727624978712263, 0.6588330542191386, 0.8337168506954324, 0.18101856390524573, 0.8038056443686697, 0.5704377039639081, 0.11558947687878082, 0.44975935827639946, -0.21451457814389582, 0.729183727765245, 0.840106517665306, 0.18687517278505766, 0.6719946614847737, 0.018799738721956002},
    {0.05539636685399118, 0.22060698645668386, 0.5730963478217749, 0.9074433780043869, 0.931571726371844, 0.4671899589899248, 0.9302717634436592, 0.7996696735467825, -0.4424391735684162, 0.12795445647063178, 0.035690566085177115, 0.21204855059517594, 0.2800948702620298, -0.1374284138026242, 0.6749705334189084, -0.29461546624918283},
    {0.05063079893686992, -0.15460506381634243, 0.8528716380166069, 0.8463452157300165, 0.1380188916389399, 0.5441045482714308, 0.7541109970166362, 0.6285853904808181, -0.28764075676400813, 0.6649098430389054, 0.06998173893479158, 1.0360481614534642, 0.8410254410553796, 0.018358020683399853, 0.9507417802806428, -0.4172825693660373},
    {0.23065082944883378, -0.09620907249673145, 0.36762459492819544, -0.08207007632973783, -0.1799831354377176, 0.09428987579293084, 0.1313692942153592, -0.2836031053139002, -0.03250205752315183, -0.1479248873723253, -0.28456652789743253, -0.1844484086435491, -0.37685919692872855, 0.5206146587774871, 0.17037674773418213, -0.32554597496603416},
    {0.01827625444018812, -0.38007508588979383, 0.5519727990046491, 0.6309689882108453, 0.6576302214832868, -0.23839308608600712, 1.0875269695215204, 0.8787945608120145, -0.22915073724342266, 0.9784848596800833, -0.5287702567146209, 0.8614613261359654, 0.7588506849178457, -0.0745060580151103, 0.9987532811529845, 0.31714557168280233},
    {0.29511431506673563, -0.153190041101606, 0.33321511773766016, -0.20600609278744017, -0.19920256269326447, 0.4183995590147299, 0.16014229600209448, 0.13970211981868355, 0.06314935457287228, 0.11180118558982483, -0.22587156743566156, -0.215720785368509, -0.3599213061097467, 0.09199572169187109, 0.035440474532787085, -0.4019608023492453},
    {-0.05829018260763107, 0.008073314524169295, 0.6888959584262457, 1.1501899677497573, 0.36932897951856375, -0.030530031145742924, 1.0618681375536567, 0.8189443993306117, 0.14990782526732946, 0.825828527090694, -0.0996567346425867, 0.7606471607589215, 1.1282403258337161, -0.12268631708941091, 0.8728468515169735, -0.1258445862739214},
    {-0.06670004952880841, 0.21543421891180328, 0.6347190690241242, 0.6186014144532181, 1.3511799127937434, 0.23171311555711116, 0.6233227202995106, 0.5122476956541289, -0.06086632202368673, 1.0134356214700149, -0.009942986603252156, 0.5653110874627055, 0.12822919119336532, 0.4010402257679241, 0.4606212880573606, -0.022644293183718047},
    {0.07634896545647409, -0.11406330004947354, 0.46890518792419106, 0.7206870974610793, 0.9190230189839261, 0.24426608275797598, 0.5732393587688612, 0.516693460020931, -0.41788928938874004, 0.5099589881041937, -0.13910101931410665, 0.6521261422474065, 0.6828759358596956, -0.16203034171630043, 0.4059784605876141, 0.4511740633325114},
    {0.33433976996978976, -0.2922530927053728, 0.503201766669155, 1.237565518484299, 0.7940016586668524, -0.005486070299252908, 0.9225540217440951, 0.9545285830076164, 0.02134088710608235, 0.6633861121599764, 0.26269132193815875, 0.5644292489424816, 0.9559227317666864, -0.2267923061246817, 1.076827933118802, -0.40723264761488925},
    {-0.2251449099016673, -0.17711535693059022, 0.820560198431526, 0.9488980810205506, 1.2088612186421668, -0.11332570194175512, 0.6497521944333474, 0.878135454167202, 0.2031267058443224, 0.30540332704996215, -0.36350151851657514, 0.6586136387567665, 0.6033239155810206, -0.1546578634112395, 1.0373119061407103, 0.1361355914619133},
    {0.07506786487719855, -0.3840587203758456, 0.5535476966953014, 0.6936280044555898, 0.6709389704200186, 0.654415361378946, 0.49416781416908195, 0.7439367018628148, 0.33792566447261546, 0.5127471530961667, -0.37567905228381543, 1.075632706788204, 0.8282386046100164, 0.4478369758336889, 0.8953863919363814, 0.16826193979519108},
    {0.10621862700910842, 0.10038591311094301, 1.0879005632221572, 1.11024476972684, 0.9792852942901178, 0.28524856898717704, 0.794682359740369, 0.9299358091574801, 0.14376172160343834, 1.0522800011551503, -0.043359723018453686, 0.8662633151344146, 0.9104825446681636, -0.11889375478172551, 0.967428210191678, -0.15494814303671742},
    {-0.670630927125165, 0.09832661250629578, 0.6856854888172692, 0.6634173738446233, 0.6556500384898816, 0.3437411326659878, 1.019793694482499, 0.9754802538565139, -0.024031300539066224, 0.3909901530654947, -0.5788922424011804, 0.6145903969245368, 0.9879121098104968, 0.0962500622541349, 0.9205348762708224, 0.16752294079646574},
    {0.03974620658835783, 0.1389260555827196, 0.6458085720356023, 1.1360182892858033, 0.9546763035459673, 0.09330133712455177, 0.8888065212653361, 0.6185525426393396, -0.06067167822951803, 0.8690843245917508, -0.25671694233477893, 0.54699477616028, 0.6945431787992303, 0.2572337359927657, 0.780688165841311, -0.35917601346340444},
    {0.2128707044599368, 0.5256721797689146, 1.1402385488108375, 0.8199391086679888, 0.7818228104032167, 0.3427149897468161, 0.9082070449457132, 0.7190996408017214, 0.012089609863071052, 0.9235063541162489, -0.37543218044242105, 0.9847378818461484, 1.0137396278883197, 0.3575661706705784, 1.3289067720186654, -0.12064114784155033},
    {-0.1954882914954105, -0.3038477073705345, 0.8109190509291139, 1.1168175238200704, 0.826586107812106, 0.26797872006817014, 0.6807714369628006, 0.5558861787921663, -0.2346961183375547, 0.49941375959726875, -0.25033576821719933, 0.39014806133265933, 1.076352252486015, 0.33990977667048416, 0.6845145329830862, 0.04200437569032922},
    {0.26741132470080065, -0.015644926957847995, 0.48969053802121637, 0.9882932086458135, 1.1892953244053504, 0.0942452569911172, 0.6562952203404216, 0.5164317338876269, -0.32145868287660273, 0.6131524053915077, 0.03379154265306088, 0.9045475791248396, 0.8555790438557511, -0.26067449683402, 0.839984090310881, -0.12951706868624696},
    {0.1229913188492203, -0.1689826627902267, 0.6953255609278592, 0.955643050900076, 0.9849681470424466, 0.002680602662690659, 0.8162296140517886, 0.8738893057252082, -0.5573833785244188, 0.8498921149785618, -0.06017837898846041, 1.0055717979673457, 0.8744820749117478, -0.5919974724729505, 0.8307193515736244, -0.2469597472479054},
    {0.42194543491295905, 0.38044322078647763, 0.8243390665252964, 0.8749617322777548, 1.4152057456489793, 0.16550260597505367, 0.9123886247942737, 0.9930630913655761, -0.24717238165408684, 1.1396119363584192, 0.36573909951220057, 0.9175484867695742, 1.049759319659769, 0.03426843040635685, 0.861129236836145, -0.12246801138067269},
    {0.16887272032505263, 0.16266889341991933, 0.12713181695555495, -0.3281688711881803, 0.4251987708795501, 0.0817670468538565, -0.0953928498477522, -0.12925966434952016, -0.4425164125036946, 0.05357315785089597, -0.49985829319382863, -0.26963004171722854, 0.10289657206855436, -0.3509529440084478, 0.009593313967200482, -0.13504696469644895},
    {-0.13842404154811083, 0.3383479713646215, 1.000950406721863, 0.7763285651069823, 0.8741872736806093, -0.17551618328367768, 0.6407599066764258, 0.755215241908573, -0.049546011869467915, 0.5362471799316076, 0.1806386375364449, 0.7812469675936302, 1.0546141660415114, -0.043431613578594555, 0.9709379039901571, -0.2538024178648977},
    {-0.0025422023946238144, -0.23185732928438818, 0.476903283193978, 0.7070208312372285, 0.9919186876631357, -0.009052510518554347, 0.40922639801499205, 0.6663252018515451, 0.4532641350274687, 0.6701685586692309, 0.5272044747076748, 0.6685871749259711, 0.3695958518574667, -0.2025708727126058, 0.3935831479851705, 0.034017436476344406},
    {-0.025635869098543006, 0.46127682864743447, 0.636045905458574, 0.9344233596283587, 0.6873757257209976, -0.13507029163457987, 0.7795459933494914, 0.7865933352099468, 0.1586410336763725, 0.6094116419843508, 0.17430321580834482, 0.900576738303711, 0.6092259013461747, 0.0770118054873671, 0.661456317176731, -0.37248634536863384},
    {0.306473248387581, -0.024649452565553776, -0.25047618323931353, -0.06713201235168241, 0.310308536746975, 0.0882332753728713, 0.23192288875247075, -0.41613132133806563, -0.16720583534867076, 0.284990890130384, 0.07193418707388195, -0.3945583771390796, -0.2811618333107712, -0.02733590044583533, -0.22626532146517625, -0.16793288188797667},
    {-0.27883970258217194, -0.16651487618361932, -0.26084185418832306, 0.13345190485791408, 0.12856537737063023, 0.5621379018048309, -0.3340324491702464, -0.40414980758592045, -0.11821623216180005, -0.19210171439359341, 0.02707618754947566, -0.4779834627492559, 0.33217484446224393, -0.3463467945710281, -0.10504088251297146, -0.4197779507686174}
};

static const float b3[16] = {-0.050402365426504135, -0.03378353068960868, 0.43072697490376877, 0.5597741173953175, 0.6238349605205056, -0.0291619008324273, 0.5018899144726654, 0.5665940993556179, -0.029964861576397536, 0.5244943445530572, -0.03626438653653215, 0.4766911719980574, 0.5628644714429925, -0.014668087684193303, 0.5562458242845764, -0.0360697752058802};

static const float w4[16][12] = {
    {0.04930759830835422, 0.12717612698611097, 0.25597865878276355, -0.7216697470191306, 0.11858798285888882, 0.24860950072886032, -0.25374292870866044, -0.25228622395570804, -0.13373521858362034, 0.4719921558847282, -0.22070053890543248, 0.2860620013572932},
    {0.7042193782011309, 0.47606157509672403, -0.6908121856487084, 0.8546444836865362, -0.08725992694168472, 0.15874271697139147, -0.2744603745799516, 0.7047454038885597, -0.8287673183248807, 0.09501616728715895, 0.4304842526441129, -0.47567495274309657},
    {-0.18894247073713863, -0.30496380299104153, -0.43184126338647477, -0.253563301776706, -0.8425594904794478, -0.49295728764950186, -0.32449438006046055, -0.6132226994788815, -0.41509717318769623, -0.7884453231614911, -0.05864634722446492, -0.7861772907109984},
    {-0.7909879525157295, 0.23594097545739542, -0.509992043720509, -0.5999424426323057, -1.3063648148823124, -0.9631708961989411, -0.8893398683668307, -0.17850906538340203, -0.5178048939700571, -0.6254169796679178, -0.842636396728172, -1.0866784118197734},
    {-0.8288528797174128, -0.4463094938359481, -0.8306170851293235, -0.5259480164289844, -0.30273498727068954, -0.5615177028217095, -0.9386119697381604, -0.7061718415487444, -1.2862021088502995, -0.633325915027934, -0.8329163014745493, -0.8765752113536839},
    {0.5606924836909205, -0.2767659846094268, -0.27038151797555005, -0.5590850453645138, -0.3824826140306465, 0.11078899476741082, -0.05636202826846367, 0.11981915120211435, -0.7177669835619185, 0.26185481277952655, -0.7190887470221464, -0.16417551655436882},
    {-0.5117062777668889, -0.6809553329834771, -0.30663735484693955, -0.15106934893259868, -0.5741746730482457, -0.5357018366782605, -0.005364647023739454, -0.5144886511881203, -0.869082005647548, -0.9408099090586931, -1.0413497805238312, -0.9463345730660947},
    {-0.5496098605434455, -0.7764982902311096, -0.8096934194582379, -0.7034717976967334, -0.5202764569690642, -0.3081412125444872, -1.3656291124874316, -0.6567799107847838, -1.0591420938942337, -0.36210266267678587, -0.7255142717061969, -0.8957119266046949},
    {0.025038444070062314, 0.011013068813416179, 0.18464240920833505, -0.44957000949471876, 0.3009455688890934, 0.24234249726780746, 0.15953970768606004, -0.1497778919420334, -0.8276094912041115, 0.42331672213346966, -0.5983495850426717, -0.31822123705896227},
    {-1.0633449663000307, -0.7194413966010982, -0.4627786574349897, -1.0629328629784685, -0.8439844928878386, -0.7298184626740791, -0.6498645557144321, -1.1288935020374387, -0.4175510769707452, -0.22726367116048354, -0.33046161205320146, -0.2960525006917639},
    {0.3240859590829549, 0.687272853437078, 0.1368849329835328, 0.22044138580278796, 0.31244160684432765, 0.22493076698483327, 0.3280773665068316, -0.10326806833242272, 0.39399534628651495, 0.06095897087002574, 0.1284457140650999, -0.43073478355028505},
    {-0.390954523194524, -1.1899358069384376, -0.7459991650092506, -0.4681106202062249, -0.28048217136099945, -0.29447320871185123, -0.2755237640557305, -1.0353325482798539, 0.012770400072585984, -1.0167223424468388, -0.48424461661094576, -0.252775697394321},
    {-0.8805357852719385, -0.9793023625067604, -0.8403520811175973, -1.174835783818584, -0.6241301703621746, -0.7072397179751371, -0.49017645612422606, -1.0783207048847467, -0.5400984542682494, -0.46384247179634475, -0.012663249731669348, -0.2739664272399263},
    {0.7892510046600665, -0.938595684750175, 0.6280790689588454, -0.02828769154951536, 0.6234067724016746, -0.2277247367476169, -0.4986149876692497, 0.13041787032928787, -0.30664061731606407, 0.4552212455450405, 0.04311254898963749, -0.8022869555441949},
    {-0.6377379313449182, -1.0554300488887163, -0.901549409326458, -0.8964556418428297, -0.49529497199400846, -1.122837141126672, -0.7038761185462028, -0.05399110444067397, -0.5323288251355236, -0.8427126332607773, -1.2469171282111458, -0.3806807348018007},
    {0.3880178405875185, 0.12374385442673472, -0.46960355661833997, 0.3352104908803151, 0.8863441000715178, 0.14051270637995397, -0.49645058210209986, -0.2621134345834668, 0.017618548413332297, 0.1723959973074649, -0.12205805435255752, -0.45629853552123684}
};

static const float b4[12] = {-0.14345759718022452, -0.09265608135047047, -0.23441307058561653, -0.29250940963056876, -0.3221288187060954, -0.3375249106776821, -0.2752920823784521, -0.17737725519084468, -0.25321640306373827, -0.2566216799524554, -0.3181153800302695, -0.24209608336747368};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
