#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.8795364653546636, -4.195257808286161, 1.1616535502029748, -4.097774761575647, -1.1070934109116204, -2.7533146713587198, -2.720480879313535, -2.2216847925899614, -3.49341463358468, 0.5189480125227125, 0.2893848587194881, 0.7469399471513597, 1.0788882399144308, 0.8779556431247567, 1.9736422489521694, 1.3678175384416624},
    {0.9464250277344571, 1.0819006827321525, -1.7961689437817014, 2.572897517447709, -1.7931712385192278, 0.3711001744863889, 0.4537131689639831, 0.4911132188599637, 1.212506560820852, 0.19859440556529379, -2.0982058415296767, -0.04157913758046442, 0.2736224396407788, -0.39415156600946183, -3.7592027966676644, -3.4433278913172014},
    {1.645431873433521, 2.1233646946762024, 1.760505243579376, 1.267027203536087, 0.9459683127446109, 1.2594417078244655, 1.8828070391092, -1.0115427429453192, 3.008468229251339, 0.34731686151411617, 0.3533974973601065, 0.4974464077397002, 1.206095410896963, -2.008778350768595, -0.8127157056841217, 0.7110853866827039},
    {-0.6114419344771572, -0.25493612125833803, 1.1161569858598341, -2.0497739077055175, 0.6614466620086588, 0.8214278141708066, 0.7585818017007813, -3.3685983957262517, 0.4763933415855704, 1.0566332460411196, -1.4065780292589876, 1.1174775409886322, 0.6503194628371775, 0.2998941685017337, -0.48173456438616874, 1.6502537302793898},
    {2.1790136961817232, -0.049887554270360776, 1.2186402786581234, 2.212045670407568, 0.6687600786935011, 2.8660915217512493, 2.9276233078309373, -1.6972910852380534, 2.076116782906911, -0.1995258018597126, -0.09238323146964499, -0.3788118187244717, -0.5165529645246214, 0.7641932780240779, 1.6074923314687557, 0.5063798405291523},
    {3.088313727556649, 4.942146048690064, 0.2897300005252067, 3.816796917342082, 4.961103278472443, 3.642710492462569, 3.8944210369621786, 2.426105128299605, 3.9308424623158844, 1.0537818549075917, 2.707573245908954, 0.8434797661548153, 0.5616408665282696, 2.8375907323302068, 1.776809530474274, -0.712828796845537},
    {3.9349488315358108, 3.9451073288498586, 0.9918335131260144, 3.1253692949989436, 4.358028202753237, 3.8161449541703734, 2.9074183762663512, 1.0667626404808426, 2.565386324869175, -0.23736039448816956, 2.713724372070185, 0.9640998622074629, 2.2312889556846045, 1.5904948440410847, 2.298203018518437, -0.1286019428329165},
    {0.983208453389881, 0.07361964913750418, -0.21494453253277587, 2.4765778772324194, 1.451973966269912, 2.822841504681652, 1.7016824556680823, -0.6058525625546849, 0.2783907795240899, -0.5337242094441226, -1.9689129712103934, 1.627173754321042, -0.8468388799393863, 0.5407924919473255, -1.8830199145544722, -2.229588519927539},
    {1.2809449736224114, -1.5465500664414245, -1.4781515074376919, 1.110847677881183, -0.6740968327841493, 1.21264005464731, -0.5588582468748844, -1.9601642636352026, -1.2666123467073271, 1.436493023982656, -1.0091538500704194, 1.2691527947015198, 1.937149484485299, -1.8921683875246393, -2.800339136751998, -1.8707247407781555},
    {1.8756966087815918, 0.8428598391267216, -1.1599077882740576, 0.38641080448130716, -2.084714962301457, -1.0701863609481408, -0.91753383171063, 0.004396777405523423, -1.1309622145428853, 1.9035709460439205, 1.601329425959178, -0.6806529611379413, -0.09175452928552351, -1.1387174124524344, -0.3675683128095393, -3.3540176413544254},
    {0.6889513660307565, 1.700677937330977, -0.18246503821069932, 0.1927299279189616, 0.1383758293673415, -0.7050358560867415, 1.3158335713411282, -1.0782661568257943, 0.6823204267237438, 1.5068854190279204, -0.1406706473152058, -1.1080209834603925, -2.0965562142670207, 2.330636768619933, 0.7377454324683866, -0.18578869480167856},
    {-0.20369972258058688, 0.5615841969120705, 1.2017090509887918, -1.5020200132317436, -2.591856865286539, -2.810176090814511, -1.0521581729041907, -0.18480344284261582, -1.5015551532467692, -0.9636566478486208, -0.06217482305336355, -0.9450873716786649, 1.267923156860002, -1.5139942850516963, -1.1418219861473198, -1.6959048181685394},
    {2.469593364959695, 3.664216133224535, -1.0367452178418939, 3.7585297992458457, 1.2081900513478967, 1.938203091757366, -0.02219706725256831, 2.771252674783617, 1.8464478617814495, -1.1639479378335738, -0.3958006401214793, 0.5672606498644797, 1.0659866336166812, 0.9341303060644363, 0.5002898115109328, -2.5987975925922866},
    {-0.4730557826705605, 0.8178568657235623, -1.4153775750439626, -0.6895602416633149, 1.5314364312383522, -0.001890627834530102, -0.5093070004451333, -0.13652944829372557, -2.2747121645706176, -0.28808579749907337, -1.0281362227302175, -0.6154817476969427, 0.13806612847964522, 1.253108073831387, 0.37356633338818257, -0.5990141745055143},
    {-0.3360158406150221, 1.0830377520776484, -0.343038205029025, -0.14250867400893277, 3.2065969479236975, 0.9175194324802213, 0.24684201535147024, 0.9788281919069605, -2.320403952415534, -2.4874287118094442, 0.18246037051943279, -0.00855738623067775, -0.17642568747838544, 2.3542909402846726, 2.2468133865363655, 1.6003917646884296},
    {0.7041878086001857, 1.056690226843287, -2.670183168947914, 1.1928133487153973, 2.291019226626872, 0.597296353869019, -1.6203234490023173, 3.0175649779277496, 0.49828149088850127, -1.3866272425933277, -1.59888367392576, -0.9046642740527014, -0.6319697088285567, -0.061973892232948316, 0.6969756566677189, -1.5618302151570869},
    {1.5396161234632295, 3.4185444302858796, -0.5564658500291743, 1.6398334887500916, 2.917690389665484, 1.3828233435949242, 0.7097077726518355, 0.1332884602824046, -1.4881545992523884, -0.5858893646470968, 0.4884337493908436, 0.21423150119442205, 0.6577124917522271, 2.7979285974664756, 1.5557319921182695, -0.18492799758452105},
    {0.912967215013859, 2.218817731207846, -0.05113786328287715, -0.21755493626393382, 2.637647356642474, -1.4678108621235, 0.2989243297538127, 2.3764779365462996, -1.700487858055183, -1.2002141226157894, 1.3390077279985302, -1.401614826086927, 0.37746268944283495, 1.8761181614490168, 0.8552991535380686, 1.0145488255504422},
    {1.0758699024931304, 0.23003128333284714, -0.7197517925824541, 0.0362236477802566, -0.12485620368115573, 1.1607421454083129, -0.0562025287712203, 0.5374634205595107, -0.2816692682461037, -1.9651027749981729, -0.5960506785186059, -0.3275011203778434, 0.9378059986511051, -0.6084939101984831, -2.110466446496529, 0.3182540872867741},
    {0.4096595959747004, -0.3853350031462857, 1.1253942613020287, -1.128724243390699, -0.1010713178348208, -1.05703727032375, -0.2316534471083883, -0.6539506088675074, -1.4949673530412007, 0.42453640852182206, 1.2424850249509, 1.7131346209440768, -0.22876812752338607, 2.409755713538608, -0.16198479575568692, 1.7667336100841986},
    {-2.84060802738764, -1.9428736913565536, 2.0541961387085985, -0.42195127356442935, 2.114493167956925, -1.7540527165092978, -2.3419139680111947, -0.534577790592769, -2.3391717911801906, -1.8305176177851359, 1.2073234948612563, -0.6978763811048755, -0.2776166180915643, 2.070557437523137, 1.135924383677852, 2.4202646113937742},
    {-1.8855830995147127, -0.4339299288219778, -0.505218899677566, -1.0503475432177063, 1.5141630282320637, -1.5500580283340424, -1.3500994430559559, -0.1319863410666965, -2.8011985936321677, 0.1191323342321933, -0.04444660872160766, -1.2061275457808633, -3.009817723080288, 2.669971526456795, 0.8759785362007566, 0.08092268465416592},
    {-1.2097484582925708, 0.6959195460570851, 1.7957336168154245, 0.4459167869586799, 2.297142251052687, 0.3564954168650117, -0.5693299846279536, 0.4204282850665267, 0.43498104105627594, -0.7127903102174529, 1.894252059340299, -0.872655502507205, -0.8590114192735481, 2.106121210861275, 0.25705783358296896, 3.1016183736212994},
    {-0.5609500679373187, -2.3659421772125597, 1.9411422866538086, -0.3058950709993594, -1.1854845199686932, -3.038562417631496, -2.276005954953125, -0.6805358066750079, -0.4950311376763775, 1.3785144511322263, 0.24717711208833087, -0.21047200037207364, -2.2906560875484323, 0.2635729039734415, -0.5646016573214345, 0.4056593496517967},
    {0.5363752260405306, -0.4282237908822181, 2.3043635551028623, -1.2196470057700843, 1.0580553919077211, -1.6287724993628803, -1.6123460269036083, -1.8571881786318685, 0.08172785658078595, 1.8539147699967942, 2.4865104208509967, 0.6153081604951208, 0.1714824219606588, 2.4798383425170125, 2.9991914492231815, 2.2759870876270027},
    {-1.493259875918079, -2.805327353474966, 2.8073309963019666, -3.5948863977015266, -2.3822651701326474, -3.569256583175435, -2.4410675997070235, -3.6906787188184818, -1.4144299849771176, -0.32739876767300746, -0.22276465691865838, -1.3814668387150997, -2.489219911393994, -0.06711531066123849, 1.5196419642065315, 2.3822475339231866},
    {-2.031774247666515, -3.279900900696106, 1.4571000288460074, -4.6580023145568745, -2.3386710250996865, -5.015167792725945, -3.4525091301028463, -2.188214483544673, -2.8434693983345944, -0.11926101873811651, 0.7631781809713275, -1.4427764469040216, -3.60229218203441, 0.8334040775353497, 1.7986682748303162, 0.7529544620087334},
    {2.0662145092196145, 0.04810872057200064, 2.556657785162905, 0.9728301149735801, 0.4702078196604848, -1.5465193797355252, -0.8215119423919257, 0.0954405193719849, 1.7996809202698378, -0.335729371351443, 1.624743356683537, -0.19925097768906183, -1.1445793036465235, 0.16752872267853008, 0.8420044368432749, 1.1533181132145531},
    {-1.0929161887807268, -1.2644853133077278, 1.0572482964607182, -2.711670730784869, -1.1342417289261557, -3.5348182933564334, -0.504210917577494, -1.766528129614376, -1.5434361805987147, 0.46306510607005136, -1.505270486145405, -1.9590535455822211, -2.3912506519276304, -0.4737970367573374, 0.2652146677684346, 0.44540598303791507},
    {0.6210812738745195, -0.8259769916128389, 1.7166581833856756, 0.02113818494215432, -0.9740469362391505, -1.4858448670848223, -0.40306654933490954, -0.4038599391105098, -0.41809396231127316, -1.1982663151528, -0.5686828708553423, -2.2857778975223617, -1.3038836853168245, -1.131786555471131, 1.990124343769194, 1.6830980971197311},
    {-1.6681681528208834, -4.206777046345556, 0.8757193019831404, -4.481461590595538, -4.024208165439787, -2.035739946625757, 0.7608281582988484, -2.9143684518972184, -3.36993802676988, 1.4935838254303113, 1.8070868135918963, 0.814078605632974, 1.423743207468473, 0.5081677343253861, 2.0835646847308613, 0.769655331046529},
    {1.26859576404244, -3.2549464371191164, 0.2271216694464218, -3.8812488000958836, -4.008009848963772, -0.33607384203558927, 0.3468136697308997, -3.784463039972827, -1.254695977908951, 1.938758068110004, 1.0809974654807097, 1.9338824864891244, 1.8178823437351166, 0.9622981920150923, -0.3364784876437, 2.43344958982991},
    {-0.16933561506927905, -1.1850508917877949, 1.3584214132097516, -2.8308577276657036, -0.7053121361296061, -0.649359219378867, 0.9259747675637486, -1.980019902853648, -0.6819485095326814, 2.151821340816787, 0.25250731051011205, 0.682988461142706, 1.3843536216403682, 1.8162857067739835, -0.3240712582506572, -0.7321453263057102},
    {-0.9205996284178976, -1.9864099837651612, 2.0697226212388746, -0.6915091106021686, -1.0848383587506525, 0.42846165974177725, 0.657802775567204, 0.09405278805129465, -1.5459009403800519, 2.326719840782172, 2.309805022878789, 1.657935778214675, 1.0256262768203595, 1.293307927310027, -0.14948308178187023, 1.3469870476562087},
    {-0.8649836274625474, -3.165894338833431, 2.5294318346523523, -0.25534563346601136, -0.544951260335998, -0.6327285453473707, 0.9003535282796645, -1.762134949844538, -1.4145757417904947, 1.2406229488222884, 1.1305899801359738, -0.8097444179713245, -0.3200759056887869, 0.5023466663590168, 1.262687217842303, 1.7496086381548268},
    {1.0438119726738828, -0.3771302237270801, 0.9204445693572016, -0.9326776339202874, -0.9352293020777422, 0.05492894402969618, 1.1792313357633732, -0.30579770215692387, 0.6007584790624241, 2.0264450603414152, 1.6467042599461787, -0.013680919585942449, 0.9946687561678343, 0.46300956201011717, 0.2399879545602744, 0.046311717054293544},
    {-0.08816521436961507, 0.2941024919674152, 1.7996320739633973, -1.4994543983882997, -1.051455695255371, -1.3529618777307582, -0.6670570037643997, -0.368613900374229, -0.7552303712820795, 0.39354946564422877, 1.577097406849146, -1.9833543702672964, 1.1597112355713888, 0.5719280932231641, 0.9312979428575414, -0.5064551642453861},
    {-1.1557947373201256, -0.001407940076997849, -0.3077455413178765, 0.15517028694556717, -0.08747965887894672, 0.07256935295448223, -1.2588284467503357, -0.3350336205142829, 0.05902781674007735, 0.5086088742872112, -1.7779796712400293, 0.3764533534819798, -1.1212206911630274, -1.5523394419200336, 2.4049981003784766, 2.0245477402106413},
    {-0.22924855230255925, 0.4241598998290599, 0.5400413122425565, -2.5523912799558186, -0.512744495327739, 1.3898479569696909, 0.21415888271304295, -1.940464245332531, 0.7573814115887306, 1.4633220265387659, 0.0333259652822601, 0.848685351368452, -0.7324661313643885, 1.260155465145171, 2.126984232626951, 1.5997754438937055},
    {-0.3993401328514906, 0.7101685356623257, 1.0856745332977378, 1.3664168334992655, -1.3014576489155516, 1.255473449014486, 1.3313416206802495, 0.29133361508429256, -0.7487220781791613, 1.2616641608288393, -0.1003360553694364, 2.1511016258989226, -0.3300260690350788, -1.039444879753879, -0.3842670598900378, 1.5807765136020466},
    {-1.1535141480615771, -0.7201138271895343, 0.8343835052826675, -0.8840383563093501, -0.24788377580048346, -1.7607304585662222, -0.5589400237556033, -0.5066535272182198, -0.13757627163258243, -1.5837495739733607, -0.7253393445893132, -0.35565695197973407, 0.9194546976571963, 1.2115843180026227, 2.1813657694757653, 0.4459234759726363},
    {0.3188665164648345, -0.11062838210008888, 1.3106827575789153, -1.6739608122838145, -0.3317498557931769, -1.7115416607108824, -0.8389919110287888, -0.013024908356104167, 0.6415544655781702, -0.10505469094820101, 0.6859611652076476, -1.6367786808014368, -0.6245475308241148, 0.2656036776996278, 1.020251997940806, 0.16889858011298012},
    {-1.7574833872125015, -1.2853639340783807, 1.0212494657273985, -0.9904254503823436, -0.7620437297679833, -0.27625832051070465, -0.10591141112266463, -2.619694263362085, -1.160815823389395, 1.3267439022701382, 1.4757180088127864, -0.6491101601933975, -0.2204815892074579, 0.1898899071696891, 1.0911279264278617, 0.40971372464776096},
    {-0.8790116694010264, 0.11658250116314796, 0.3134061582168223, -1.5162090037565361, -0.982707531952616, -0.303938830343716, 0.20970655049371986, -0.240596474966677, -1.2340874644545772, 0.07578236873982665, -0.9372047301297577, 0.572300075915592, -1.206799096155087, -1.5159630652303886, -0.7143693963376546, 0.6655766390437908},
    {1.0310051261776858, -1.2717479493046575, 1.5273719690388001, 0.2832935768609529, 0.4426025611725581, -1.065305319268175, -1.9803101697351524, 1.3068740058416868, -0.6425613152553447, 0.01980676273765495, -1.327917866313646, -1.4522030071608327, 0.1724990149932779, -0.48357898387595033, 1.3679051270024958, 1.1617113466127977},
    {-0.30049572532502855, 1.379094018683909, -0.4656031943719247, -1.867928748424575, -1.4512735396589, 0.05544064747908073, -0.6303057427923316, -1.6642047469766588, -1.0601753372553668, 2.9494053598628067, 0.13366374527106037, 2.7349642966958325, -0.28482838138603983, -1.3888053960331066, -0.6654431259394394, 2.0379035000849615},
    {-0.7964693323368586, 1.3735183964635993, -0.17715755874190853, 0.4045526940572331, 0.9327233665060723, 0.13016766101159286, -0.0009433899890229241, 0.9075456336697887, 0.058608488230101764, -1.6512552493673187, -2.194229618982449, -1.4061239120362876, -0.9001158260696376, 0.47095859479944024, 0.0964752928523527, 0.776566309462282},
    {1.3488397830920955, 0.4011914851068542, 1.6838003257042171, -0.9363518579891261, -0.567789046031991, -0.1444304361800119, -0.960347817839498, -0.4676641968233663, 1.7465970825558024, 0.09818200567480481, -1.6079366953528693, 0.23999595431574175, -0.13613768749312408, 0.44900771065679757, 0.9140326765051142, -0.2430569003382625},
    {0.3187445746628186, 0.2356725812456105, 0.007328057392905502, 0.10934833000674865, 1.4418400896518446, -0.7127659527244389, -0.6921771970890985, 1.5653946704177013, 0.9962032679089933, 0.02938533587680665, 0.1448426809851212, 0.7832612200310409, 0.470496807774981, -0.3003734485191142, 0.1761533583183346, -0.6251958785826499},
    {0.4388673981134658, -0.013586219629531172, -1.3419949980798158, -0.7797283674238816, 0.6914408025371808, -0.5944656014349803, 0.2506787864904069, -0.9216189745915588, 1.6266907173931393, -0.4667780558941045, -1.0149618879935074, -2.078768869063788, 0.9102769512241702, 0.6290642665265495, -2.036965733693031, -1.9212949833859865},
    {0.7255050381506382, -0.2146707794988496, -0.7016368375822768, 0.48540782312393893, 0.2720062433531006, 1.7789318879798448, -0.050110537530792185, 0.3011003224994593, 1.8863112166716136, 0.28057186472644174, 0.30870048817982293, -0.36305627308786736, 0.919190951546704, -1.570239147609528, 0.3663310770948422, -1.1883797229412252},
    {2.2326369189725463, 1.4951789338830186, -1.3082484811933317, -1.134068495330559, 1.410945501142979, -0.2522759103448584, 0.8229107419324048, 1.730259126727046, 1.59034264785738, 0.6184653280429385, -0.5115341338468746, -1.2808803913664744, 0.8962260399574261, -0.24374296369007603, -1.7369164900245717, 0.3465617345414075},
    {0.39386317778108815, 1.035472070527939, 0.9874189458264827, 0.35907977949243863, 1.2715988782790366, 1.366877227077022, 0.3943287356328056, -0.8618558099396484, 0.06776413021170337, -0.0034032393920936247, 0.48414540220163244, 1.156403649761461, 0.4937073749139074, 0.29845815211540283, 1.3222831501302275, -0.39264858598726543},
    {0.12290269868096769, -0.07258011053486553, 1.204448251460508, -0.09618065288940755, -2.0953466777809746, -0.3168629162035593, 0.18073041601048045, -0.5500835298740872, -1.2062129675864284, -0.5059643533736564, -0.30428763886358146, 0.38560236960513505, 0.9534676933219574, -0.38456877056967786, 0.028723903008284403, 1.4441641080416954},
    {-1.762113101537595, -1.2961839366977563, 1.067445847142648, 1.2583185931443472, -1.8210470462739277, 1.3768861045506127, 0.5613058371504073, -1.9976111188230974, -0.41449651656312525, -1.3584521654827624, 0.5019933709715579, 0.5497599602179846, 0.4767268041754005, 0.16073555746029786, 1.6064620630610014, 1.9354958186128515},
    {-0.0644007618581672, 0.3534390147499423, 0.683623823594265, 0.48560318791225265, -0.9347656564718944, 0.7373567737693759, -0.3242144759844695, -1.4464488630359933, -0.5974540327117249, -1.4061094018624218, -0.22120404444399155, 0.04871862455877832, -0.14453741863723765, 0.31369208147518757, -0.18083959125306592, 0.11079260545571272},
    {1.1891262186922038, 0.23879274290543911, 1.8680168693977015, -1.1641526762234555, -0.18989901945813056, 0.33577664486846787, 0.1962781219742816, 0.8560649148496942, -0.9461744764437694, -0.033638915703601786, -0.4372654521473462, 0.060948314215481574, -0.609555726783754, -1.1594174970555373, -0.27235611716611, -0.8262751816789328},
    {0.6843653231911779, 0.7632949754504155, 0.8843844870633727, -0.1397797447176199, 0.9942726270353737, 0.7951294462353267, 0.30249799104282404, -0.6148246608843736, -0.5259177618980927, 0.21880751733608514, 1.0807566495231207, -0.636307446900713, 0.37356381461373106, 1.573222074008813, 0.9906564817093301, 0.827129032859881},
    {1.3980673054096593, -0.980604943380095, 0.8910496733273405, -3.158655291506484, -0.05771398798977015, 0.5373609231591064, -0.26643389464544565, -1.0198401714007492, 0.7918847615574349, 1.8232547862201056, -1.9567436191424947, -1.377626910981029, -0.1216186817359964, 0.39917561869728924, 0.5126687210367588, -0.43707354880215527},
    {-0.29748210461141117, 1.791551027658728, 1.0620975551309881, 1.4243820213791138, 0.4323586281029989, -0.4278677902808585, -0.4153951512946553, -0.10233246379881673, -0.7094607636959686, -1.6531321924533255, -0.3122592327621733, -0.8971228387432522, 0.12249922299394389, 0.4638635248520273, 0.3913995301761888, -0.4308832641795943},
    {0.37410186647966515, 1.3526523776179968, -0.8774356378146808, -0.6108084080601243, -0.19476957348353865, -0.6232936583342714, 0.2698508148563797, -1.1061092600249187, 1.14524105240152, -1.3938572278346955, -1.2609238931963476, -1.6617098158825447, -1.054661737651281, -0.7334853763528213, -0.13999927091436518, -1.5097198789859732},
    {1.5813064448831495, -0.6756437489518584, 0.5178593283603041, 2.2677854558684767, 0.3052877279363137, 1.73166906690097, 0.5114172800823729, 1.6228614770274032, 0.979593292945985, 0.4280424783377019, -0.7682638796620708, -0.18218045518862608, 1.045424328794943, -0.45639477146497026, 1.285812687017795, 0.5711516614184589},
    {-1.449406726508095, -2.6255198730290092, -0.3415117374190269, 1.6060606943049094, 1.3262884151097978, 0.20643171852071532, -1.2357257837305555, 1.5753383397007974, 0.12983996359356384, -1.5481004623387422, -1.2848530638044924, -1.1398550292853948, -0.7376604707283443, 0.4581746521473734, -0.03611690058694585, -1.2296678636231657},
    {-0.6449203200967746, -2.218521913261306, -1.3285084058144307, 0.15923742649104644, -1.4309832054467464, -0.39032165711464284, -0.8950258363439421, -1.450789004767449, -0.9687592501946825, -1.5351234364287487, 0.3070485109809255, -1.1110528181277983, 0.5586362047715945, -0.27191590660354376, 0.22403266475754852, 0.8398698765557974},
    {-0.21156891817764847, -1.6906949216194735, 1.0871633733423522, 0.41117890475300517, -2.0341242324288014, -0.5752164049735778, -1.7929916828429993, -1.333225963925387, -0.6450187570214283, -1.4793306098893269, 0.8650566730453231, -0.36066096272438114, -0.417151748295595, 0.6128222575791541, 2.2295695543629237, 0.9177934524288867},
    {0.867934729598555, -0.7459036519721234, 1.7733079046169058, -1.1533910403974104, -1.2095300996425777, -1.0963344158586963, -0.40202219161933733, -0.6576104774956436, -0.44016249816895525, 1.2047609109643462, 1.8594703043953615, 1.2917549551126832, -0.015923185030615412, 0.07137112351068732, 0.8080317599744865, 1.5484370818109872},
    {-0.1059582752124714, 1.0984739917809456, -1.1884280668687166, 0.5175857328114633, -0.5742155635673905, -0.1679138814412394, 1.244003644913845, 0.41668912688219306, -1.087407057569828, 2.246053078667875, 1.3466378378704802, 1.6737667754656844, 2.1744414219585955, 0.33395151482482704, -1.8397022480615148, 0.2952095290712653},
    {-1.7736947738632296, -1.1826613397467463, -0.7632494574364845, 0.473643955985943, 0.26309330982354157, 0.1126027233253424, 0.66683823659831, -0.9182326555352337, -0.34959516448615563, -0.15142698657959971, -1.5719209544442965, 0.7360413160307896, 0.4716347296971879, 0.010372198162495419, -0.0033808483377665804, -0.4303163293305464},
    {1.3646015574206471, 0.8693199881207414, 0.18234819208737596, -0.8316234403344217, -0.7320906623567953, 1.0334052130778233, -0.09244082294797054, 0.8142070672028576, -0.2666562155279475, -0.8084397139269066, -0.4874772608953424, -2.1586990270495674, 0.04092602931217806, 1.0240560137893726, -0.43115977271951506, 0.8055759005987},
    {0.9341154677255387, 0.10938014120715588, -0.025103882860999696, -0.3538779740946588, 0.0067152207499537155, 0.43849876304744906, -0.1971229996173934, -0.1628717659874868, 0.9456523423788983, 0.19027708421787157, -0.09843787963461449, -0.6258889147362038, -1.146591407034799, 0.18425373130505926, 1.379287461806635, 0.6174821921272924},
    {0.3105783586129708, -1.4937242001685715, 0.04989468183347147, 0.6429999646625771, -1.5009472151046968, 1.1641435349009939, -0.22926915399933998, -0.7626148170322453, -0.41681811948689507, 0.6303781849032947, 0.5961199567758987, 1.054769958439608, -0.21928349718400086, -0.056985060066557174, 0.8339126440389041, -0.47426700344507455},
    {-1.0079501457988267, -0.7801064046996249, 0.20996146049318698, 0.8430588695943789, -0.28685327008873784, 0.09474043691281375, -0.4046116925706366, -0.694552564495904, -0.5894785342008596, 0.8019380182917568, 0.9563676032869872, 1.5753268573297412, 0.12929079878617933, 0.514516251662916, 0.47536226328611486, 0.3052865067708087},
    {0.10548800135470765, -0.8377906696152914, 1.0307054347142879, -1.2886287443598063, 0.7291146095653143, -1.5018994941261972, -1.1818899642959284, -0.2844414102177828, -0.8931961824388993, 0.5205765033172531, -0.04767508523401491, -0.6789120759087826, -0.07708666164189082, -0.5533654660386838, 0.8144596539605685, -1.095209524774708},
    {0.8942822973583293, -0.8052882326123236, 0.7187281040016039, -0.6772649154393797, -0.8013607378000603, -1.239644784353558, -0.6261762746876125, 0.7547966604800112, -0.7387955247919787, 0.046613145631299646, 1.3532236552097916, 1.6323227532755407, 0.6989444663238757, -1.0022021302594508, 0.2935488431403447, 0.44496065083606684},
    {-0.012676814395933236, 1.0024527772207954, 0.22371118949282745, 1.4644485719575981, -0.16749335707147536, -0.3016032127016037, 0.5023748233465699, 1.12666980292148, -1.0232538891933343, -0.7622165929318094, 1.2431344228278012, 1.0985030759978949, 0.07735338267807408, -0.4923904376394163, -0.21599864760472653, 0.14810403080749374},
    {-1.4147281788532324, 1.2217731950021318, -1.4107484195310063, 0.4707479983096826, 0.19297829592293841, -0.19173972535376424, 0.15788205266996724, -0.30535502503157863, -0.39935691405551604, -1.1212313401621503, -0.4850663846453045, -1.348657034068006, 0.6107026673636738, 0.956079670552009, -1.564263839182648, 0.3106711714335854},
    {-1.702668642425874, 1.049031075272839, -0.8707800579007917, 0.07241705110033357, 0.07183417527787692, -0.9663870120617295, -0.4078259881997296, -0.0362498914058087, -0.7356743062879222, -0.8793522981953826, 0.6144143529676396, -0.3165482270076228, -0.6638253939314216, 0.21339510637954467, 0.5280461384565092, -1.3946185200460084},
    {-0.7676852640556375, -1.0806390542885527, 0.4128246439648379, -0.1708228595222847, 0.7506939298957767, -2.023888457383758, -1.0361995828032173, 1.273155679231344, -1.1944418991825398, -0.07752238318847124, -1.1719283621247008, 0.16324112089855417, -0.11040255503704181, -0.14230257729428308, -1.1338550543686956, -1.4399993078236468},
    {0.8642960824583369, 1.301614648867603, -0.29447324231962263, 0.8757946970512914, 0.6616354592972192, 0.07521107749773431, -1.007472690954734, 0.8655846806044573, -0.6450792729579448, 0.6953229659435489, 0.429493953672937, -0.4799003417969412, -0.30410442660342624, -0.9205181028342301, -0.02636926337640009, -0.16067186293275978},
    {1.6387922020694305, 0.22954211584449066, 0.12460082876123237, -2.3590974165746252, -1.318826189283736, -0.8670831516202984, -0.6267197189635481, -0.8746157580455791, 0.49810290629642123, 1.6966398712246236, 1.1060953659716941, -0.052959228449811824, 0.1480102495990021, -1.0976432945402717, 0.18498137209328225, 1.0571859191713067},
    {-0.02917074367619518, -0.9665967342579298, 1.12213668820973, -1.0385602947820878, -1.7639259640704401, 0.12114656855070342, 0.015775097339015432, -0.15357534273755705, -0.5494172879958267, 1.1051750561988656, 1.8479716928547227, 0.7159042908617581, -0.32137330076932197, 0.3931524993755334, 0.5343047206138406, 1.0960683980912451},
    {0.8729739920883726, 0.48253134968480504, -1.2934909385175273, -1.8823873124529236, -1.1283752867445447, -0.2021083730267474, -0.39970150266272014, -0.8680604783102277, -0.23829206518151486, 0.19990074789563134, -0.9308246242920453, -0.7693442356128971, -0.003307995892238332, 0.7421836999706822, -1.3906323927471187, -0.6583947580623188},
    {0.7962963286915808, 1.043412389813832, -1.3255736258219237, -0.505014744880677, -1.6941915904717542, -0.06508710483012238, -0.03619550789753931, -0.17083441921169026, -0.48745389600901295, 0.9727369933951273, 1.3657696649729325, 0.03087385149412408, 0.4967749908926078, -0.853902895131171, -0.48923945857228857, 1.4241210330924705},
    {0.9583348012732563, -0.04941349860176161, 0.5451417941774122, 0.11071430113333289, 0.33622045141489193, -1.0973002239296028, -0.40046647737983, 0.11006842883857182, 0.5371504083138183, 1.4557248012542259, 1.827985501595005, 0.23484870395775503, 0.9641513721756592, 0.5694801287116766, 0.8452934053412976, 1.085034707032723},
    {0.30767887282660783, -0.027266457252022966, -1.1752010639994994, -0.6597230986132776, -0.9156476349196941, 1.0340078434808828, 1.0019159458142148, -0.8685407610012795, 0.4063146646206759, 1.4414015527906021, -0.14445019181544075, 1.0890601336037005, 0.24559437251239802, -0.4921018689076211, 0.05901195821780289, 0.05039048973254636},
    {1.0518635086434016, 0.879581273137555, -0.05490853713221358, 0.535976464473774, 0.05677182335649831, 1.6514344586510772, 1.3880830036918017, 0.018449317401905915, 1.599181447152543, 0.9629145379379789, -0.14179003355101322, 0.3043793541549071, 1.3271699329628857, 1.060405976481989, 0.5394999699995316, 1.202035823363606},
    {-0.7957981079472544, -1.9551062111234567, -0.022457616953933033, -2.053351338578891, -0.6478603047480552, -1.9704174648138861, -1.084814188286469, -0.6890866016910585, -1.161568766851568, 0.500388143203003, -0.9813574376629455, -1.4576950234236243, -1.412218364616323, -0.9926787871201935, -0.6640077554568541, -0.880564564865847},
    {-1.4722741596421236, 0.5659042531125396, 0.8088162122223064, 0.07274092304818193, -0.46887822395776696, -0.8117956066187247, -0.8066529489192813, 0.4625911877304592, -1.861058333387561, -0.5686739004494429, 0.7873071893013789, 1.4247514027756032, 0.4625912156154929, 0.07202757272031353, 0.5823187004860148, 0.1784679400279631},
    {-1.0823657231489763, 0.09068679322069305, 1.5380870826251163, -0.22152173334390243, -0.28522942460433026, 1.0741226435279956, 1.110658395353435, -1.065952397821996, 0.5667641702067266, 1.01185939913574, -0.19835918816576512, -0.9208716984427752, 0.2993623935757662, -0.5412505770042059, 1.6976147103851216, 0.24366377752010254},
    {0.7769378656055366, -0.3098129172324279, -0.4116446751537585, -0.2393706535619804, 0.9382126656722342, -0.35464529138001233, -0.14925137812143174, 0.4308515688268849, 0.880401933700684, -1.3456376195817175, -1.4024789757678071, -1.1293668200868927, -0.6858949487543436, -0.062299636231452946, -0.15106407065084593, -1.307230949231556},
    {0.7773632542757503, -3.1091549884166376, 1.76763600879825, -3.049398622217281, -4.036189155368833, -0.9150894227981501, 1.6892064669522229, -2.4563328977030077, -1.733294119274388, 2.112891568740549, 0.5709509198226752, 2.0773326263872933, 0.08355711046798903, 1.395536788452953, 1.802524216993176, 0.13983590521615438},
    {0.8521900099000409, -2.2636921741687415, 0.43196537616899366, -3.366424731964436, -4.352864988473949, -1.1280027507313544, 0.7247931694222073, -3.9382339667798143, -2.057114153410184, 1.939799434223689, 0.4048041352900035, 0.7299809641645634, -0.3638617974972763, 2.540815482855174, -0.7412659271257351, 1.217750715636726},
    {-0.4010452810024637, -0.5590550068639748, -0.5232271165101445, -1.4986393457173819, 0.3446726863212347, -0.13847180135721715, 0.2327257530910598, -0.547973314565586, 0.4741758272641317, 1.9319443025392355, 0.8362228860345647, -0.23523266128135037, 0.4705152292458282, 0.4222550189901793, -0.4934682731006069, 0.024194563468254243},
    {0.45481659798508034, -0.6524377255788123, 1.9753644407949156, 0.4147117445124596, -0.2736204403219172, 0.35217872433716774, 1.862669739599776, 0.9620605853318194, -0.6944414456537581, 1.9482611382107624, 0.9639938096672173, 2.2777662876931375, 1.713018157123918, 1.03406823357334, -0.3826968506760963, 1.0125333417302067},
    {0.7866870928147123, -2.169476981210723, 2.3194536998723825, 1.2758348302589098, -1.1829952714174465, 0.07368100420966682, 0.6260276736560925, 0.29486772728537414, 1.0245761832445854, 0.6611505405891628, 2.2027554804187597, 1.1721935328909807, 1.3927332240422592, -0.5098019439361576, 1.4539215753298862, 1.8547169339991947},
    {0.8044890261477414, 0.7000806301481056, 0.6748782692928016, -1.485296426761541, -1.2690719492560936, 0.6133311406336495, 1.371712245766634, 0.13226205967473903, -0.5910689905500301, 2.18236386261563, 1.851140142629294, -0.221411154151618, 1.611042242391899, 1.3914824386966615, -0.6192590449632595, 0.23467106790915032},
    {-0.27374855315783225, 0.13239923134373155, 1.0683488882478323, -0.3811755338499142, -1.254339810216041, -1.1128325678324211, -0.6251369658288889, -0.5974547236397043, -1.3544462067241003, -1.4370080433094403, 0.07310901450559737, -1.9414496943353212, 0.1295537582972723, 0.9958261256808355, 0.7695316019252332, 0.5524819313378532},
    {-0.23874490027112585, -1.012518604633939, 0.1864114551079047, -0.9398027742740932, -0.2665757695522111, -1.136755964597668, -0.2546203467546065, 0.7037278981250115, -1.4380852576975565, -0.9367186519591868, -0.6737406657748501, -0.6199337227678445, -1.661626742305015, 0.05880521632495949, 0.528019721742866, 1.3862257292281959},
    {0.27697585665921215, -1.1787624116199438, 1.658570896549276, -2.1594868354044197, -0.885407258287491, -0.07352071112125785, -1.493607600800321, -2.950628827481581, -0.3063429748364209, 0.9434789940447428, -0.7954680698480145, -0.2396277537151981, -0.6721912605456137, 0.8344474087377307, 1.6617606403279632, -0.6746000541776711},
    {1.1921693552380854, 1.483570301212711, -0.08082682813686859, 0.46066380947289587, -0.361947980736289, 0.4092664361382195, 2.314650924892208, 1.290011070531795, -0.12039223784146731, 1.1555088422924518, 1.5602390231013714, 1.5364732960873404, 1.7859088737580018, 0.32425912636082915, -1.3919904749673289, -0.3527502893261519},
    {-1.2068915180348412, -1.8110319191441813, 1.8260818777761945, -1.1670799947615014, -0.8494047089044143, -1.0967715447127404, -1.4657787185743447, -1.0168693085762621, -1.3752467630799063, -1.1187878977644554, 1.4645963484839843, -0.3066434378130496, -0.9315795227426003, 0.8453129619271588, 1.3887704436239472, 0.5198392346818859},
    {1.7629213859133122, 1.5246134347350486, 0.6390370063837811, -1.7903065288287658, -0.7727700106011127, -0.7316554138334304, -0.06786697387440647, 0.4217105279380433, 0.8460617373996233, 1.539127856498662, 0.6582106763917577, -0.93907837403599, 0.2492528133533209, 0.2188281841812186, 0.0038902267030649002, 2.3082843206954524},
    {-0.9942299872431415, -2.3276699831256704, -0.2925091084464223, -0.21587487558023896, -2.56804865765412, -0.5463276311833196, -0.27397349548260164, -1.9672396103097969, -1.443899514650759, 0.7544958039718108, -0.09141728492406467, 1.0733701326674532, 0.04878001842617672, -1.4372822505443166, 1.095375415529111, 1.5603362886954708},
    {0.45536548844518115, -0.09835840914701607, 0.30005164419030184, -1.496636873519521, -0.4370207155757555, -0.8168220751478441, -1.2883836213593463, 0.8473816993606066, -1.5551470828417273, -0.1235757551277924, -1.4486373883756545, 0.7507133879923501, -2.1177359038777626, -1.8150970963134634, 0.05815148013648053, 0.8999591926820101},
    {-0.4945840489098959, 0.4837900606148357, -0.4158418254486457, -1.1407284963509425, -0.1539166335975649, 0.03149237510998314, -1.2577031201377775, 0.05120805127383527, -1.3100643366384173, 1.2078597408312404, -0.7634459035675956, -1.7515712516264397, -1.6043978092582971, 0.5612103668203133, 0.6748288104013059, -0.053182023151251374},
    {1.407077584331253, 1.2514820007663405, -0.907549516737944, -0.3241518185770425, -2.277317353430559, 0.6825229595607998, 0.7911370020656738, 0.00806080742628663, -1.0316200051132227, 2.2548897270183406, 0.823416018514186, 3.5411470924113235, -0.5689852023969587, -1.1521659120339525, -1.0573468846770286, 1.9025579713101242},
    {-1.127071969158172, -0.9937100660427325, 0.9253103956299242, -0.23389852732412983, -1.2941454123309735, 0.8910650202931832, 0.3133949222853066, -1.3059641104656035, -0.9178378399609328, 0.25391803336658675, -1.1294838368784124, -0.17307715114017308, -0.7692969693119771, 0.47619797044106704, 0.7573059764264396, 0.4700534614194133},
    {0.5117125428497008, 0.2073248694092376, 1.8591992383859046, -1.6733258262985147, -0.8083003864229737, -1.2557826668918604, -1.2724435182307454, 0.7803088815302318, -0.3535872835041245, 0.9858180704496977, -0.483217895685104, 0.7627162237585381, -1.5990789895863915, -1.3442192984704546, 1.5027952256787056, -0.4809640007989765},
    {0.22103560105569878, -0.6735298160204473, 0.3640003685551375, 0.5396391553285022, -0.6487726836297762, -1.447476478975966, 0.013607609538023662, 0.4628987497694835, -1.012672926027324, 1.8818646295716197, 0.04334928282736611, 0.5702111342763947, 0.5656365116141404, -0.5623550068446638, 0.41945456148693205, 1.4626521551454787},
    {-0.9333883691595662, -0.4034427124202668, -0.10778018177853652, -0.8710477699830966, -0.5301670260967405, -0.5195393069710144, 0.20667957454506766, -0.5588549549444394, 0.36054816831093783, -0.24232492578923676, 1.4676815502032161, 0.32616077071092586, 1.2682148880367696, 1.2238154784756103, -0.9435713073788634, 0.48257922980141793},
    {0.3841551672469799, -1.6647410664461355, -0.47800841012339074, 0.9425799053326577, 0.7300894279197815, 0.29676663027315153, 0.5642833295758268, 0.4827967823296049, 0.40056023965080334, -0.23240910035036744, -1.408595684166568, 0.38610858309532176, -0.24056442502549302, -0.14048606268556582, -1.1740447946786334, -1.0924682774789551},
    {0.8578426828767153, 0.3847913099008631, -0.513639196774814, -0.09597732313371082, 1.3045983001894201, -0.08019022219403839, 1.0013161904250887, 1.4584024569976508, 0.9468444342727773, 1.3602057084326666, -0.35867817542184177, 0.34202872355529357, 0.7970599814225457, -0.33038627383024477, -2.1821545539805105, -1.2680576094826574},
    {-0.3848651928252205, 0.47475548141455537, -0.49940589666315743, 0.655043842835381, -0.10334127038331034, 1.4814360107134885, 1.4270177119452958, 0.34999269028456487, 1.7792953639653164, 1.3975922642683567, -0.9948484201205178, 0.6328241984286144, -0.7151863053741042, 0.3872290981156334, -0.5940821550177224, -0.6627315212257603},
    {0.4295935874829275, 0.200764081497468, 0.4610981634237619, 1.6576606838012973, -1.1689985573049624, 1.4039172255905872, -0.36986151955673924, 0.5630276859551646, -0.7771549133652355, 0.660965952380769, 1.5048547444533893, 2.4846264866935615, -0.6092596022998843, -0.5298044122537008, -0.20688121748653104, 1.2314530451999535},
    {-1.7549899149010628, -1.9233540546463266, 0.7338583306092014, 0.8173774498339451, -1.1856817670307342, 0.3500559378107893, -1.0499690216992106, -2.419197013914635, -1.3492061812857334, -0.6999677716444994, 1.4170636161221002, -0.5186633752820856, -0.5515231069274, 0.484382587718688, 1.7578131792560479, 1.487525853533026},
    {-0.8595091401156206, -1.6893396368432063, -0.4370787276756771, -0.24831971843977596, -0.0337264796798747, -0.8150993844015834, 1.0817857541089066, -1.2961543407538545, 0.352533633270872, -0.6454711605918497, -1.163396756129023, -0.9738602180347963, -0.4588305393830105, -0.9215738078818679, -1.0128609778158333, 0.7689137359286037},
    {-0.20358301099140663, -1.8180326309136423, 0.7951014981044698, -0.6435723238501313, -1.2919515130488592, -0.7803030302507076, -0.764839469054847, -0.3234123604862818, 0.28678995183931455, 0.12365034820200789, -0.6801264343259851, -1.6582580928730508, -1.518700683409063, -1.2098813483562447, 1.8802305719690988, 0.5119245495914185},
    {-0.7418429300676807, -0.3591332179417211, 0.9362602947574692, -0.45112146554687477, -1.1309934303930256, -0.5598136010532818, 0.8058564022054696, -0.7449198382134633, -1.1907170985968079, 0.6002013886583608, 1.6342944481542454, 0.7968387063304078, 1.2550706506057652, -0.10861288043924236, -0.014168196437715668, -0.7543561970693062},
    {0.08464975978111222, -0.17906244193686507, -0.39383895570438393, -2.7951542801329907, 0.2238950874851992, -0.08982482769877696, 0.4257427422532085, -0.08886010632146255, 1.0973598659745305, 1.7981563604938813, -1.4274339509400464, -0.35261138947207915, -0.25979921484002716, 0.5867622820268762, -0.5929036825004872, 0.1937086131059412},
    {-1.4073233281763442, 0.784636677420266, 0.826882291893772, -0.2640508032681197, -0.47955090700725705, 0.8419533446273387, 0.04191788833301343, -0.1426169102833025, -1.1777357417020586, -0.5402924508432629, -0.09162229503774134, 0.717778544956705, 0.7358914985157493, 0.6926457381841955, -0.0024453180265872534, 0.8390139748875629}
};

static const float b1[16] = {5.076880970607226, 5.407575466601304, 5.493378591274445, 5.823411305399971, 5.8440586810003605, 5.845374012703833, 5.430058353801982, 5.538502684083508, 5.4649871246114525, 5.032976985310131, 5.455772505212422, 4.99120982035349, 4.972325880060818, 4.958589258784298, 5.292608717776082, 4.840075755704472};

static const float w2[16][12] = {
    {-2.4506797952833934, -2.2026175187774473, -3.220376385167823, -2.2690757433188478, -2.8795576930910993, -1.8447361915171712, -2.4868652229062627, -3.7100303461272195, -2.592575581295712, -2.648565966577054, -2.5090996466734063, -3.176028112915437},
    {-2.1776587733099286, -2.702405272223266, -2.77233791839602, -3.034058292810098, -2.6200366837046922, -2.7715135162602618, -2.996350493116102, -2.770284950634192, -2.553529268365468, -2.653359930769733, -3.064338323598816, -2.1718932123587327},
    {-2.651293190391968, -3.052603511701845, -2.1340063361839374, -3.118676369650131, -2.1889653750699813, -2.034301461085041, -1.9427120006245528, -2.450838360979711, -1.7612798701525167, -2.6824327944477733, -1.90106367964494, -1.4978199950710513},
    {-2.6864728967939366, -2.9968190214364117, -3.2450315098387694, -2.153406087395742, -3.009495443945282, -2.9439411087821123, -3.4219422504710884, -3.543794885528139, -2.887797044438656, -3.5607156110102482, -3.217530017007172, -3.173133676043461},
    {-3.2054531876061203, -3.057311795702795, -1.938136357348124, -3.778785616212003, -2.9905013001467142, -3.1590541132853844, -1.6268818529101827, -3.890362701690623, -3.082857844923327, -2.5103794803735244, -3.724858548908453, -3.2167161723099724},
    {-2.3314531466738324, -3.126339869511089, -3.308849736117728, -3.730929634232589, -2.1664608289391927, -2.117227324174757, -1.938942272035559, -2.0194246201522823, -3.327883855917378, -2.771943516151784, -3.3608037176319696, -3.041578619050193},
    {-3.076050878741274, -1.9991167490009543, -2.0479904018491237, -3.0131691823189004, -2.735915009923219, -2.5319724319486445, -3.0291823362479944, -3.432063473712936, -3.4613063387348917, -2.2503458997752874, -1.9124191581773995, -3.382379171029911},
    {-2.242422254139311, -2.534452824915206, -3.184129471231171, -2.4702074048019163, -2.368805003260469, -2.4931106201840065, -3.8204896878000194, -1.5644286841565818, -2.8977026582020873, -2.5080792248171013, -2.3090675021347185, -3.120654205624959},
    {-3.1867688089035213, -3.2619275873094034, -2.9141599276136643, -1.9575169443591174, -2.1098982475870725, -3.8688293649004337, -2.851133699201327, -1.9277280349823107, -2.6792792471796956, -2.4788514002883035, -2.0098113262561097, -1.8394983433687508},
    {-2.102319156730374, -2.1673025726375155, -2.2761997953531754, -1.7296685978751183, -2.669885862127831, -2.314724744587956, -2.975328016888135, -2.729948146262767, -2.4222345943690073, -3.1265664036726797, -2.1219919415173005, -2.154889905789415},
    {-2.2476097850040673, -2.719599166675284, -2.705290102779671, -3.2730203864441614, -1.9949458916525284, -3.2945613781735044, -2.414868375718232, -2.815016613524765, -3.26096832147611, -2.3536570789001057, -2.428881688133127, -3.122003307676418},
    {-3.2450985931312495, -2.136190933395862, -2.8950712842432087, -2.4360987245011847, -2.6803275596405647, -2.6324528672955787, -2.039626163889485, -2.392832899943804, -1.9580071241659356, -2.3098660360665058, -2.1526063718901853, -2.302697167752695},
    {-2.9786331152253163, -2.7622400177400546, -2.7983243618602844, -2.196691195538132, -3.0925581160524738, -1.6222098840913142, -1.8829890695117812, -1.4903435907941938, -2.7246639327488222, -2.0277811997733655, -3.3029817111043154, -0.9454167759504947},
    {-2.455814119710654, -1.8564775912599711, -2.81843808971213, -2.1269973594569342, -2.5820942968707206, -2.914827010943543, -3.530387056411428, -3.128402216803992, -1.760521508933163, -3.145515362287323, -2.3280628440421878, -3.4135046843297374},
    {-2.4590933879009587, -1.7565311689765108, -2.4554863242894798, -2.6468176581095006, -3.3429008344222524, -2.0398122375263137, -3.105645861185088, -2.5721927396366007, -3.1789870724365326, -1.617217109167916, -2.45003575753389, -2.974438513650153},
    {-2.904822735615663, -2.4322211796363353, -1.7233142946052014, -2.026263773269453, -2.0693199042703085, -2.5498056541783405, -1.87592488417963, -1.5319433133427627, -1.8324262281501602, -2.3122409704720033, -2.6461909313718603, -2.4535893984086945}
};

static const float b2[12] = {-2.896909524582919, -2.7575251902052726, -3.1325088892706536, -2.57879459072436, -2.9910752692702682, -2.947352777750221, -3.0101316917551806, -2.2323383085638118, -2.873826856068662, -3.556386079609555, -2.5266341827209153, -2.579070928740247};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
