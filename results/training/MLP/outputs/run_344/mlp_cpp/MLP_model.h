#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.595558835948475, 0.7593093435042443, 0.5745441228253728, 0.6910591642201681, -0.18010704565381558, -0.07452319604453435, 0.1688591848523435, -0.320826315985179, -0.03945503596549239, 0.6326816558500311, 0.21749912437593116, 0.2217187382700707, 0.25562875406865804, 0.1499911961713842, 0.5005025643490367, 0.705741923268433, -0.026671269975277825, 0.42602698211851986, 0.6002818258700213, 0.14810365809291662, -0.48192665776463567, 0.3065908261168383, -0.2365432060094951, 0.32798360534616317, -0.5162592649256427, 0.06369433857617428, 0.5546100410960209, 0.6503924110158769, 0.44398002551506915, 0.07423763872591821, 0.677512675440924, 0.3260476496058304, 0.6855658916546938, -0.12777755711179128, -0.28625626816924693, 0.45585565458895044, 0.19646025398894126, 0.2792647998872705, 0.6901863996913224, -0.35385263379256643, 0.4803135347536297, 0.32904799091768344, 0.6579982278765858, 0.1615247199742816, 0.40880961595172455, -0.2016672815736504, -0.33684427789824084, -0.16310066548464836, 0.7490521804632156, -0.10592621515775652, 0.22855987785508533, 0.15520526560023223, 0.5019981471110185, 0.703419769840427, 0.5973464588261422, -0.11289986113132017, -0.33900913824656403, 0.6177769453760877, 0.4262663417781274, 0.6719975151541712, 0.38504503264716294, -0.11086810543202917, 0.252081641454128, 0.8103657731165131},
    {0.2712570412208121, 0.34591973700652506, -0.5389372449798925, 0.3524839974947677, -0.635147803345849, -0.4275435310448481, -0.4560312996729759, -0.2610635010277956, -0.5911697723418402, 0.3122522640539745, 0.4191089815523048, 0.36690892703364064, 0.1493996391541574, -0.19723384697483823, 0.06413481103897892, 0.4796140689450516, 0.12944029704617646, 0.4035050752692758, 0.17983215313330425, 0.04659357000135549, -0.24934244668911362, -0.0816394005641998, -0.6869821680439532, -0.025399841476642517, -0.5997299240592383, -0.4259159305364674, 0.2199820834314432, 0.6472696339751064, -0.05494832477102081, -0.3600495083315608, 0.5608169563520733, -0.14788505782990832, 0.7147846510247851, -0.025328759326039348, -0.8571493366130782, -0.4727174305319484, -0.03980152024158471, 0.084853328967995, 0.5902951190420209, 0.0792822644645365, -0.18792098924655698, 0.005340870674452184, 0.31901288621998186, -0.40779123589455357, -0.0688059879850907, -0.13326193437983655, -0.28189116658287683, -0.2636097517829904, 0.5561402137388696, -0.3613639606250761, 0.0045360523672120096, 0.0002878340767371597, 0.34435354598922785, 0.3383623050133246, 0.4482192211303067, -0.20300073656863488, -0.38734676238516713, 0.6550537507896355, 0.39814747988302324, 0.694745661886681, 0.34925439867796765, -0.013383093116700375, -0.273734004571934, 0.43535810756113963},
    {0.49479245733562205, 1.0796443014141375, 0.10467319943326274, 0.357943721485219, -0.06297031762774347, -0.22093322746551072, 0.03883078722992721, -0.37436686312893486, -0.3720484288335953, 0.2792039867654422, 0.4598092397352785, 0.5719785455460438, 0.32251833203037994, -0.4515530681943297, 0.33602350723383945, 0.47289955478305623, 0.2123390402236295, 0.6776971913012181, 0.7878444682537993, 0.07651359434897526, -0.44696088864121486, 0.044863548091170574, -0.33562773971264587, 0.2819437123001189, -0.8956373721846035, -0.37546258372082336, 0.24984486388698016, 0.8263048241098192, 0.4079162895805485, -0.037119822638640956, 0.6161607921858633, 0.3056532983735121, 0.5730459775236834, 0.1274630452129538, -0.46472434620033987, -0.20139685037059632, 0.33581678143214816, 0.1810921752094979, 0.6195493070444267, -0.14686330248279, -0.048401732027720704, 0.1692747102832981, 0.44294962289146256, -0.0311977528369125, 0.08044626116591468, -0.3363566100577675, -0.4647695683834807, -0.5563349161987546, 0.7179161313288993, -0.16688724457491463, 0.2777715627598897, -0.3611171301445079, 0.6185212783478584, 0.5245571887432896, 0.3757828508324967, -0.14436984367725472, -0.13168568336655292, 0.8785211732797958, 0.6510438687617495, 0.4633939249871865, 0.07997515240504374, -0.3887820746614413, 0.05369359990127726, 0.5354459788617327},
    {0.5947098060271979, 0.7208220650427929, 0.07651944537794757, 0.34593847257733823, -0.5983456161401884, -0.6120567542097229, -0.520432786061755, -0.5867515894581218, -0.6608419219170215, 0.0017584000384380791, 0.4162037682233228, 0.23372006733166747, -0.04765918742424783, -0.35254801603204294, 0.2031442995906271, 0.45266784323907905, -0.5262898284075236, 0.2211236119493916, 0.5457475250864586, -0.21135972561193772, -0.7460094177033227, -0.12991786631436553, -0.4828100126976704, -0.02477317452808687, -0.5966250976654345, -0.30206973619618227, -0.25888223201754207, 0.5735597744147853, -0.0435484055853085, -0.46546549613396354, 0.486596678167152, -0.2149350975240531, 0.5713112810675767, -0.4126867434893067, -0.45380471958194907, -0.20976517161228111, 0.18654153681615254, 0.3207949089610706, 0.6311038568658431, -0.542797210683537, -0.21038877551803886, -0.03689343887049437, 0.143025516916824, -0.10155509830855437, -0.5465172572348778, -0.8054260542009456, -0.5297527481639902, -0.3522168984858267, 0.5783099271320664, -0.3300826100193752, -0.26163467256599904, -0.5098144853048966, 0.4960116294043665, 0.6874308905471896, 0.08346142295588295, -0.49728922350172444, -0.6169300721483156, 0.7032299493923957, -0.08081101349826349, 0.3824931142138965, -0.03672446945825616, -0.669871906335181, -0.3543668534951625, 0.5852825606326438},
    {0.07422017898574955, 0.5162556434232085, 0.32281140112217754, -0.300821650172688, -0.5591479867045185, -0.39357744487592694, -0.33259727116024346, -0.5508212890275991, -0.44649864950958074, -0.6294417386442236, 0.04087533194955273, -0.008799937988147143, -0.2487485049923749, -0.6223282926459732, 0.09005725531105546, 0.025832325070890883, -0.627450453386756, -0.19820279705983368, 0.3555158977856841, -0.4996023066271826, -0.7085468447469044, -0.3524833426823518, -0.34136227154188625, -0.5395797353880696, -0.6726860421970284, -0.328372773847745, -0.6008545771598158, 0.4674229345885134, -0.4455742820568566, -0.6374911952178557, 0.4870386096101944, -0.48657627716669427, 0.5803875081228014, -0.5658913570373092, -0.43184376081137393, 0.43468012814911844, -0.3189352215800699, -0.2715650114394869, 0.08900149709321643, -0.7535503880331405, -0.586413917015537, -0.30852004468137223, -0.21829378990280512, -0.4896234791282113, -0.44681992813300536, -0.6609246930417126, -0.7149688592963647, -0.632204937723561, 0.4106104867487123, -0.0861920385893602, -0.4352712261679144, -0.82166792774476, 0.15672502413907033, 0.25518945169706786, -0.4777440017675984, -0.6469966376198705, -0.7909446635349712, 0.1241612824921008, -0.12104708294912336, -0.06242334315846615, -0.17027189939241993, -0.8839687957840827, -0.6093640104524264, 0.5564621103832413},
    {-0.08958391525704235, 0.16762184832803642, 0.302355496411648, -0.1576683926528498, -0.3770859413670206, -0.28066171128997214, -0.40720729633291525, -0.8682302587348776, -0.5450436503087274, -0.578363321875039, -0.06774647009673516, -0.3685569799759558, -0.32857920882889413, -0.4476204848361578, -0.4010712074131161, -0.21869844732974256, -0.9187140447466471, -0.6429496437735349, 0.3472698304292818, -0.4413290052815839, -0.5537877082612922, -0.5193000199124194, -0.3716541234733201, -0.7956517059835798, -0.6485506816833123, -0.4786353874598075, -0.4144509538640654, 0.1540362725505054, -0.5059814270171359, -0.4219020974104947, 0.4580003498046984, -0.41297528469820644, 0.11997309193113924, -0.5281961816472853, -0.5267733175771406, 0.1308628406135662, -0.48870334443769764, -0.21936932369090448, -0.27539507048601913, -0.5821198602161358, -0.6609487714781713, -0.6299194760654122, -0.30354256879407215, -0.5862503958086874, -0.7656752320628467, -0.603669308738175, -0.6724925282010003, -0.3812683646961229, 0.34494147928765967, -0.06413304895856209, -0.5410827394445307, -0.7263342102416928, -0.21452318084592015, 0.3310199648252728, -0.5232937525829527, -0.8505046974930415, -0.9787632815374152, -0.22968360255919665, -0.21165048299356545, -0.28974662360148923, -0.4007741717988924, -0.6062885850774167, -0.7572352675767783, 0.5050007411153201},
    {-0.2967743783533384, 0.09716533818868332, 0.16124959586846152, -0.3467499440049648, -0.3407060382387026, -0.48751786042932144, -0.3875641423194876, -0.5639888828054336, -0.671170912064776, -0.5886862611365183, -0.32433262856332545, -0.24698552944116314, -0.46899006503709356, -0.5913241114292661, -0.5276336277051447, -0.17505719545048148, -0.7292407885689665, -0.2827479812257222, 0.07179187556751657, -0.5071513225230764, -0.64408821354784, -0.34537891164898626, -0.4868913208957432, -0.5702158729721272, -0.6177317638516931, -0.516908759215386, -0.6483988375718449, -0.02678099942923319, -0.6254357185079811, -0.5936278277504572, 0.3732191838844563, -0.6293119887855567, 0.27205151014308404, -0.6109515809542003, -0.41125209899872434, 0.102214609560863, -0.7525285758187721, -0.22498385595857964, -0.19793502562343415, -0.49010697835514866, -0.1797388568991966, -0.42431400708319067, -0.12942892671597536, -0.7688001124559989, -0.6881287693516442, -0.7633582011593933, -0.5253361573516712, -0.7700419319711153, 0.06450832294392457, -0.16722161317292653, -0.5728198914621178, -0.6758418181873862, -0.538598671181515, -0.19781440479283444, -0.6390473171302985, -0.8402863788633503, -0.7245464703041548, -0.400152444561663, -0.18411742921419824, -0.23306479695290586, -0.39012101681795686, -0.5364497619089311, -0.8079367512032277, 0.44781738920729486},
    {-0.060683605611985866, 0.180325321350895, 0.13836576441404597, -0.21891973253266656, -0.5054267861642283, -0.43303628712619324, -0.4991841117256935, -0.7133056022412645, -0.7946437090436151, -0.357695729911471, -0.414310757845023, -0.16604919376374433, -0.3195971104875545, -0.45751357645274526, -0.39586221307642633, -0.39703213489617095, -0.8299567662894491, -0.2725122454909069, 0.014201066069595222, -0.5834688311646843, -0.8492320211144953, -0.36552952934691624, -0.6292059766663956, -0.46149973690862267, -0.6405139510525073, -0.36726967646408887, -0.8351256324421272, 0.33036682150894686, -0.6965830672952946, -0.6523895548893077, 0.4899287314271872, -0.39094388374034367, 0.06126834302099612, -0.5963050857482003, -0.6737158538150969, -0.08598752214978825, -0.864506479716923, -0.27574268056318063, 0.20435082303428398, -0.503757139502638, -0.5579667110325578, -0.21968477947618117, -0.2369182596090349, -0.6371731816596261, -0.6851966399510475, -0.41815701489052376, -0.40921080342373245, -0.4338667593281687, 0.08582886667200026, -0.3766871445906787, -0.506056461581738, -0.8056448357766333, -0.16705128833795135, -0.11662982741238241, -0.6064918006892114, -0.7548398058310609, -0.6517304300123334, -0.31815397252378946, -0.31706376178937024, 0.07453930886012082, -0.6024907272756947, -0.5658432723968158, -0.7614730722477082, 0.13905573424882148},
    {0.11648793507540564, 0.2940317749770646, -0.09831698452528105, -0.3905295389639789, -0.774363825590688, -0.771922042689623, -0.5330260427493884, -0.5217051915298051, -0.8330665246306158, -0.39590319762144643, -0.027176726255029718, -0.2888643210850723, 0.19683134656587795, -0.6044971859647249, 0.12485479641313481, -0.02895137397601231, -0.6073151284030911, -0.05566138961983016, 0.21440694863875326, -0.42305302110075493, -0.6638737423683647, -0.14193837673934048, -0.5650094982096432, -0.605797642267432, -0.6440448832124549, -0.5602015449624572, -0.46176994025041573, 0.5528936237616527, -0.5184890608629992, -0.6095754711169372, 0.5407793489567773, -0.378349898423052, 0.3283528161239136, -0.5471735993549118, -0.48580126059370377, -0.1498158404598634, -0.6347204234229045, -0.1329042152686634, -0.097541995412582, -0.741611802585216, -0.38014547486029615, -0.07567777264847338, -0.06328064910191654, -0.49191730122421695, -0.7349703573575364, -0.8024036973571647, -0.8290564114819851, -0.4784190430373903, 0.32592036387132134, -0.3629568936212918, -0.2182297145473502, -0.7324025137070913, 0.04618799532638824, 0.3939087538767562, -0.047005302429975214, -0.44767506897664094, -0.6937934603254462, 0.3564224277263751, -0.30740028138948516, 0.16986511850673638, -0.46616657516134585, -0.6128797394176204, -0.3338531968638265, 0.06334611683811603},
    {0.15338024329481217, 0.3025723571631498, -0.21650526230249142, 0.09697918446055477, -0.6433970460104336, -0.9562474932741911, -0.5793197986073364, -0.586911568784382, -0.6301330916232837, -0.4130031724465083, -0.030502252540408805, -0.15761679042100044, 0.04865429152144405, -0.6517491333266572, 0.24652199011723538, 0.3496764471812158, -0.2617472438141103, 0.05052008483281267, 0.5215460692116822, -0.2709932557482087, -0.8176202478777256, 0.042391800048985406, -0.2966774590869757, -0.14152523569458322, -0.5627739343700532, -0.6310564157753931, -0.5197819571970729, 0.6453926392459085, -0.27220768928804645, -0.4962291935598387, 0.5663134986050223, -0.30200304041082776, 0.5206152259712314, -0.4799557543163813, -0.8165193664162205, -0.25080994862905803, -0.6350068298838104, -0.10949241019464045, -0.058260406660733184, -0.8209527070900282, -0.6919372785401213, 0.022244603854468265, -0.09887754310832714, -0.6224054115978624, -0.47642827481091715, -0.4877781790209867, -0.6003754395095207, -0.4930716764057549, 0.590151419336609, -0.3620631337078903, -0.33878052515765517, -0.7176416918151927, 0.0046709937278593535, 0.33398472401196855, -0.0103991777050487, -0.7037082394069715, -0.8120224132449402, 0.33845295746128107, 0.14449638784046231, 0.34244917087578797, -0.37312778294501775, -0.8099469568865502, -0.5682047063179753, 0.2084013863648265},
    {0.02306674718739756, -0.07078476089152075, -0.6213237883554048, -0.14124147277042315, -0.9484779452686498, -0.7945079210117989, -0.6710101035073157, -0.4326123116724848, -0.6661497052689108, -0.304415281079897, 0.04072094206462957, -0.4676098165964966, -0.5003334300240184, -0.3781056137952532, -0.39674656602091535, 0.4978018201826336, -0.5230671961700996, -0.13558405240809374, -0.35422016190941796, -0.21040541609996094, -0.41814975146782163, -0.18009162346508023, -0.6850262972910504, -0.4404153990084689, -0.3275832132433331, -0.4487505388709534, -0.44383960133618117, 0.3832837842996219, -0.3069483285801239, -0.47402593166476803, 0.133427053685079, -0.37638405071580544, 0.35716927612388905, -0.24560329512523282, -0.8162488378229759, -0.28312337928329356, -0.5434034514341536, -0.023788598108552043, -0.16027872680230804, -0.339470029081506, -0.6587453261021363, -0.12936574094102452, 0.06520974619818107, -0.6278431067909606, -0.4100844925497451, -0.7107094983968206, -0.8624289786899694, -0.255149858570436, 0.30389993481037, -0.5448279138073793, -0.5119884522698578, -0.5657844495002038, -0.5313115935979617, 0.16395522692723632, -0.1338910769267437, -0.8256043981936483, -0.5186835250196632, 0.3048038944747986, -0.3726937014087912, 0.4760960443993878, -0.23358179927024136, -0.598882190857675, -0.7205026005712647, -0.18844780504841435},
    {-0.14855660667747944, -0.16534392562584352, -0.4609919259745478, -0.3651129079675624, -0.47103984061135784, -0.5890371391071249, -0.7056025258628372, -0.6360337608552429, -0.6603436808626034, -0.4204114668704929, -0.02911359550910661, -0.37088811115425635, -0.32384497980469534, -0.6043374715917722, -0.2643920370772508, 0.3453934696576787, -0.39792762640497703, -0.3285886590581625, -0.025517565083799525, -0.4118171381545772, -0.6220894802417076, 0.19205699736603596, -0.7650722217271866, -0.4587400487991994, -0.43755915224041125, -0.7137791354122018, -0.2643560692824124, 0.0872632922526246, -0.35369306801258893, -0.7226872135275217, 0.21265276338208647, -0.11059115916336408, 0.22940715136623702, -0.4045730829999837, -0.6883362739643726, -0.5048353008871702, -0.5817772642909342, -0.3410347161112454, -0.5238794475079825, -0.5044436428519307, -0.7526503341631524, -0.3496687953253229, -0.061154922310372735, -0.5463106892002167, -0.581660855803719, -0.4481166512654336, -0.34386511157649696, -0.3602107778089246, 0.5450107370048001, -0.6105986247378735, -0.2523587033660769, -0.6319856139856637, -0.3057846446927844, -0.1533012908710443, -0.24719167934703729, -0.469682206526688, -0.6839520004061245, 0.3293034240159115, -0.48848107898962234, 0.45076912000704117, -0.38327539665697885, -0.4567009181436691, -0.5093167644463925, -0.08019530668146445},
    {0.00040282237802305974, -0.11929438635457995, -0.19087428750176444, -0.1732473446958127, -0.7926308263595977, -0.5680624025951165, -0.3484240982633664, -0.760548165845174, -0.6181072158553176, -0.43712917909656396, 0.13323082060533328, -0.2222343807476931, -0.19003571200010214, -0.6417073963489236, -0.03373859145189148, 0.4425047878601925, -0.550920115125985, -0.02204900501967959, 0.03178936272472731, -0.5114597219132452, -0.6703620725064116, -0.13546662973364432, -0.7189514146884746, -0.41008511923232505, -0.9021310404897591, -0.7357007832933757, -0.360632346623106, 0.31962486416528535, -0.5418734293411036, -0.3974466587647979, 0.2079002215087729, -0.39959115336955947, 0.12738988220059094, -0.3293689100687902, -0.8644688082628453, -0.38526698361726686, -0.5581094160719293, -0.13997948154535422, -0.27195909277360003, -0.2590229782776636, -0.6814474281326949, -0.256035254110289, 0.22102136512729387, -0.4273431515541759, -0.7708238468256506, -0.5201183159394369, -0.4310982332127723, -0.4053917424166714, 0.3675506460430684, -0.684691857589586, -0.21666262730317412, -0.41982546351424443, 0.0636437046647172, 0.10076574373037339, -0.3696862041973097, -0.7330521564225726, -0.5293532547889669, 0.5406460584072476, -0.2551799310458511, 0.4742790202559202, -0.09843274978209815, -0.5433587103472073, -0.5477794033644307, -0.07746375690699102},
    {0.15215584308294627, -0.009134785282250127, -0.5608281005041622, -0.1830801045821302, -0.8309774522249648, -0.5851794049179241, -0.6175842537902183, -0.6423053167916366, -0.7302237490015409, -0.26592107007059, 0.3305268027508668, -0.39947908770049884, -0.10864463293344588, -0.5690106923209587, 0.07675159976319101, 0.5530512015016248, -0.4632137644546472, -0.03556103505666057, 0.3187269754130214, -0.4720221940139777, -0.6049622652114203, -0.17020071258458222, -0.6112997989819016, -0.3075256197261368, -0.6418724751069851, -0.6263031831226594, -0.5733735873231839, 0.30210500522843303, -0.3112248969010201, -0.6252797545723724, 0.3071485542890398, -0.27347623065615784, 0.009678396375796433, -0.417150088451629, -0.9493465718972134, -0.301666025905412, -0.34244753576501796, 0.13173941010437643, -0.10449138920931612, -0.45492409938306544, -0.36086192333657385, -0.30383704559152275, -0.08858822488865181, -0.38970684106187786, -0.6100902884582962, -0.6280991526299512, -0.7351070111763639, -0.3297201930970374, 0.4658789988337929, -0.44011112413441283, -0.23017270578662513, -0.3451572096177474, 0.149127129307318, 0.09762552650914287, -0.4530568038142794, -0.6809814709574152, -0.4111485457402541, 0.3601717125941559, -0.42888170724381125, 0.5493631962452742, -0.3110960937832372, -0.3771575409036488, -0.22488109988046276, 0.04774096256536642},
    {0.0750962832640081, 0.05408398624207309, -0.2843432921454474, 0.009435431149636424, -0.5353799646195695, -0.7808078353373723, -0.4820528173647168, -0.3729983242288365, -0.926387738504777, -0.17890104904149148, 0.20212334644371802, -0.4804474971324178, 0.033137452034983604, -0.6388129488723119, 0.07279513205717583, 0.3814410008684806, -0.6443294574876254, -0.1756018768594139, 0.35915774712734744, -0.41124384904321354, -0.5084856489581755, -0.44785597397733834, -0.6995101759469281, -0.2452501351165157, -0.7653513423521641, -0.42280370023582553, -0.5648400026445416, 0.6687646132538575, -0.21494290548765294, -0.7424162314892887, 0.4262769709554756, -0.1401130091257467, 0.36560722677774504, -0.44610809640975735, -0.5775807787554822, -0.23695812475181938, -0.2646254763525188, -0.07063477135850252, 0.07240313502813849, -0.5984549937053464, -0.4607235322231772, 0.07933506977370583, -0.2242958374536494, -0.36927087146646176, -0.5762472991106012, -0.5753900978948476, -0.6267048614969416, -0.6131128720961523, 0.46901925354881663, -0.9610812945638059, -0.12131021565965, -0.6115456407472404, 0.12292835777889151, 0.5056272663922808, -0.2230109732128553, -0.5253410340541803, -0.4833588655750998, 0.27464442348364765, -0.44298081739621264, 0.5521762181910043, -0.1806997873809034, -0.6724663194391821, -0.5327500724577254, 0.024064445863088757},
    {0.18465870951576474, 0.5323481952710807, -0.06934887905069748, 0.0420998301770911, -0.5661343985039332, -0.5695183136168108, -0.3516128144327332, -0.7257307630410392, -0.546079312526442, -0.373003681442655, 0.20853907151802048, -0.17987988233785215, -0.23413372594287707, -0.6089060953246915, 0.2119877020904725, 0.4139388563724531, -0.6898519876850342, -0.18717746059203946, 0.22318772313416563, -0.22629172027881117, -0.6325319985897561, -0.22029841059587085, -0.659088804387472, -0.41338500988989385, -0.7894514300693257, -0.42281145644401863, -0.3145037958864239, 0.5949693024797795, -0.2971795484272127, -0.5140314666206814, 0.5351387832739436, -0.46364668195945774, 0.4912929571721507, -0.48110798445493225, -0.6439366037196014, -0.0865452834742849, -0.23784888156284759, 0.24170119161774628, 0.004644096188022595, -0.8292861491399317, -0.6334976604105413, -0.2421019736589511, -0.053777929679882645, -0.3007475592155788, -0.595241657171722, -0.5419210199917641, -0.7264308246856233, -0.41066188046880553, 0.48241737735035517, -0.46244403849139776, -0.04443073608600967, -0.6811653782497913, 0.020679947900928298, 0.45117200404709323, -0.24781401391549676, -0.6363984417136207, -0.5651072247269157, 0.2963410699700971, -0.03858950683319408, 0.1399783515862322, -0.34171831087617005, -0.6417845748546503, -0.5103054273986191, 0.4145597993646222},
    {0.5344574413473203, 0.6583059342274167, 0.0668752197492188, 0.2945487166878755, -0.525693171881087, -0.615348196209674, -0.4639990731089381, -0.5724403102686813, -0.3592725233302778, -0.17017541053195198, 0.5816495212890662, 0.17200182352246754, 0.3087528992449453, -0.6849553426884639, 0.02363399712357652, 0.6569393612834564, -0.4208994498976793, 0.46901159718663316, 0.6183517135806385, -0.23481721002977723, -0.24744135304475148, -0.2234485907454003, -0.255506673867884, 0.07241061690495151, -0.5787167302566604, -0.46839028196616295, -0.24997764304715497, 0.7366474989560063, -0.09087840867999322, -0.4958244978733882, 0.7339432733546933, 0.17215193718901192, 0.6256079437125388, -0.4941851769762801, -0.6226588773127645, -0.00257635430854196, 0.20595807103702327, 0.22083678855717734, 0.3776291384813398, -0.5141605304321428, -0.2527690253327355, 0.012347757836287882, 0.23911604259355937, -0.14384166670388782, -0.6308037509276015, -0.49935468501027536, -0.4397632973846315, -0.4459083432397937, 0.53069937701426, -0.3597756986397296, -0.1483159188124373, -0.3631161091573614, 0.4547396543831919, 0.5614142805022018, 0.2501730586333767, -0.3993676213931868, -0.698409172525606, 0.5770323530572418, -0.019834946863601106, 0.6496765699395552, -0.12113319049309854, -0.5801795991933775, -0.2995227034864908, 0.2689838745523515},
    {0.41055253385300766, 0.6444074317044138, 0.19811792413495752, 0.3051371130532095, -0.32153754772416016, -0.6139069927167505, -0.4561841501848293, -0.23981438144631326, -0.38246826091986236, 0.2175334058777284, 0.5325891164452359, 0.2968293437200582, 0.12572807873839129, -0.1702585527580871, 0.4509626579906554, 0.917049353639627, -0.18115195478707063, 0.4486255121625339, 0.48502599870745755, -0.1400455845520715, -0.3317237747606314, 0.053542476564237836, -0.7214688603892896, 0.3743732831777851, -0.7007947175256042, 0.026701166266340528, -0.18440638300028192, 0.6307560140891985, -0.025031608401114635, -0.20938758511823846, 0.5014365128464344, 0.2760706055559788, 0.5523091161715091, -0.14715862549004866, -0.6009574788366513, 0.16764739006135826, 0.15716794032145673, 0.21895244533393635, 0.3405677821144912, -0.48090551236067247, -0.05033897934921326, 0.17411300398298576, 0.6495981059867141, -0.2611871205684055, -0.43390831369174887, -0.16538181995873394, -0.4863254070914219, -0.49920218448031994, 0.8551955226255498, -0.3224696932873999, 0.2213942020893401, -0.6066449567662452, 0.7350389151629912, 0.636169802743053, 0.1533709629164185, -0.46750661713701824, -0.4504259966528454, 0.44638654935897243, 0.3284528224236126, 0.5033065330662999, 0.15328062988220273, -0.056982700908423486, -0.0008097737661599295, 0.5595841474461744},
    {0.7676342724794717, 0.6494058960494845, 0.22887980763822235, 0.3091042559981232, -0.24723370984253296, -0.3652795096676987, -0.10914100289972095, -0.2551518347653624, -0.2104875154034396, 0.10930358614394659, 0.622560884351999, 0.3255829954356567, -0.02494510633491415, -0.4683030790933693, 0.23757334349462536, 0.6125124372195484, -0.33299317630261427, 0.3098818321530291, 0.8972766259124134, 0.09583828943032008, -0.19269893929706178, 0.20403058235854468, -0.24797532448993723, 0.10847390654170212, -0.3176228763400708, -0.16464080932210423, -0.06612462017515891, 0.5951847806810365, -0.018262473603112374, -0.4056835023969981, 0.6033919713637875, 0.3018591460014911, 0.36451958736886025, -0.35861383189922663, -0.06228440835278821, 0.2060160568690825, -0.022655166726418853, 0.4115451586239875, 0.14804893963798196, -0.27936565889209536, -0.17519639858809813, 0.04616826976629269, 0.24816934223167658, 0.07625608976690244, -0.24148528222575213, -0.4165671103347166, -0.28238325003590825, -0.30464716761881233, 0.7337683833208799, 0.014297669143889653, 0.02802075519079838, -0.441993414815929, 0.6926013357647405, 0.789445374088221, 0.039115726509252366, -0.4538191951031196, -0.37014710822397073, 0.7816777844393175, 0.1712247901116796, 0.5622323191111014, 0.22985457550317645, -0.21932575764430437, -0.13979379626201724, 0.5639532939599905},
    {0.4356949252185538, 0.2929225028121805, 0.18973000285020883, 0.06974541333678995, -0.41307935343299096, -0.6267632307801178, -0.5057836051616349, -0.7903877414818659, -0.5280036656309866, -0.21328060690903128, 0.547598485027988, 0.2540596792855571, -0.036755654698002835, -0.4029453246204377, 0.299452243540609, 0.5580576736843154, -0.5319454769766093, 0.28484770461816505, 0.5315538079374021, -0.2223045970464196, -0.6854433065519789, 0.21123004436857984, -0.5289627622576172, 0.023506364948449657, -0.4950828240485789, -0.4536470075723141, -0.35591214044962766, 0.8424441579746728, 0.3402786869920274, -0.49944923375000516, 0.8471879055317582, -0.063164663974881, 0.6264644530811638, -0.23477652060536364, -0.6442415103266703, 0.11949026973620387, -0.05690289893261334, 0.5050779002294439, 0.23489674907817454, -0.4518947280149835, -0.45876213654624026, 0.018316205869109217, 0.29941807729038344, -0.06122463957112693, -0.275467125043215, -0.28878322235704684, -0.47833648573882204, -0.4603835494346686, 0.5797119570050763, -0.30288406803765044, 0.1405518845489172, -0.5355524619867386, 0.42688016711575627, 0.5276049940101575, 0.28573428688845165, -0.5382657649207471, -0.1051298087441403, 0.44634452240466127, 0.15937590906589605, 0.5222446314785069, -0.13622421424992254, -0.6748235958480266, -0.24403363392039318, 0.39132553171036766},
    {0.5502800919526006, 0.45390274495557265, 0.03861782152706153, 0.15552350121646646, -0.5310067286074217, -0.44474419093192874, -0.7651049537305505, -0.6811282500786425, -0.4221449160579944, 0.24302606346400218, 0.37559598685993706, -0.23726277638271134, 0.14661653362351798, -0.38131974387874135, 0.314601654842826, 0.8952745311569271, -0.30299597138328505, 0.27118123345042366, 0.3618921100418158, -0.18586850239320193, -0.588758643298664, 0.12389780122865961, -0.8780493075186805, 0.20594745645231502, -0.7231370020610596, -0.4305746148464146, -0.2688746425693201, 0.8357719698109101, 0.019536224711922213, -0.44977824052255366, 0.5839013180373389, -0.020278379885921138, 0.5640743265254882, -0.17928810655105182, -0.5663155247678593, -0.43842093025961454, -0.3752226755512324, 0.27472024570231407, 0.33831347570697323, -0.20613681974984488, -0.20243421536580397, 0.06415608102028611, 0.202266587978085, -0.028052837667681907, -0.22559902106174023, -0.5019443089363939, -0.27996807294209264, -0.2500819891196585, 0.5574473313273008, -0.35276121041468705, -0.01849057029027601, -0.4672058341123542, 0.4026770902139196, 0.6836871618949102, 0.33022986671595816, -0.45204679318489877, -0.7742776553851304, 0.8689672575188137, -0.028218436792467976, 0.8925853135208945, 0.13985800616876515, -0.50817505487666, -0.3111241063276975, 0.41679924694669185},
    {0.6543787016366216, 0.465493337674701, 0.11154206499291595, 0.25336653662795566, -0.44837151149815946, -0.40916226094671654, -0.3533321218581912, -0.4093308320803174, -0.3498786381768663, 0.4151332980246199, 0.5441848466901876, 0.4553514656564056, 0.07772242102049534, -0.3292903609153783, 0.13348010765806548, 0.7057048434185471, 0.0030913225684924698, 0.4806310441063376, 0.41776267548443063, 0.3035629635127369, -0.17435858214062558, 0.14995388387809594, -0.5781946409180017, 0.3669449528811937, -0.5570870964008222, -0.23213838287089633, 0.04714239512852287, 0.6558604835037707, 0.13978918102040644, -0.04530402477359105, 0.7638061810526042, 0.31127071365765224, 0.46281360867022076, -0.011225647579002344, -0.4836598273945039, 0.06345426331855447, -0.009157895726231127, 0.35317043478226967, 0.41970136568867533, -0.21175870958612641, -0.1770744989504505, 0.36059957737666937, 0.4945347354636141, 0.22907185472779729, -0.16642178762393425, 0.029587241429454264, -0.16802264182589674, -0.0273424685310777, 0.6947945185206461, -0.14628318342882854, 0.27053895594072713, -0.2240567248997147, 0.7573914450348297, 0.8398610063536637, 0.3298657681385977, -0.33557762684320575, -0.3417586097473116, 0.7159796766830963, 0.08164443639674246, 0.7397555842535587, 0.3494011422796423, -0.2620377447041053, 0.006492049693201039, 0.662858338015292},
    {0.5894893772612114, 0.5544198188396002, -0.054403706564631046, 0.3534810876939543, -0.52403746531061, -0.3276899126578281, -0.17985097897703692, -0.2061718730560563, -0.2188194750873956, 0.2696799717704108, 0.6232920040680715, 0.5056028135577564, 0.0996406560649445, -0.18594418791153702, 0.2933874116386584, 0.7068912434411185, -0.14515763798345768, 0.4654412629202756, 0.5948715007771838, 0.16155237630497077, -0.18566118962353784, 0.5645215095598818, -0.5335137106009334, 0.06266320171322054, -0.6437573438778618, 0.1603734724488015, 0.06638290968360795, 0.8609181780772839, 0.24991180165002608, -0.10343239931417675, 0.7957127245196536, 0.47710682802685905, 0.7887782430822298, -0.05762549144746223, -0.42885397448638585, 0.16270867469384798, 0.48140065228619033, 0.3333632860728604, 0.4962543600904099, -0.17930487386094165, 0.09526393498825007, 0.1632829550217325, 0.40538252077810266, 0.14764285369703506, -0.07899794930407204, 0.3113272586905111, 0.018991103357833855, -0.20694146529819898, 0.8002398112561041, -0.15003401106190628, 0.18227082812187784, -0.0319564027688086, 0.4525308642722582, 0.5818922588244083, 0.264621583449535, -0.5244363910194415, 0.05182748356413054, 0.6101315718111581, 0.5833039402874095, 0.7654467197051964, 0.22397907841131678, -0.04090471524792898, 0.32950209494018307, 0.6292561763820718},
    {0.4464575112161209, 0.636124777408559, -0.030923313607915125, 0.4227179781045463, -0.4560110269506465, -0.44192026622823205, -0.3413075410643456, -0.15369559765754676, -0.4340118922907066, 0.26247183699665694, 0.5934430097708798, 0.2753153039400945, 0.2756274121271584, -0.24552438830185092, 0.42897143914440794, 0.5715342288015778, 0.010292870722205829, 0.5477905961877589, 0.8465757193252986, 0.34396800183360005, -0.1343664212962717, 0.2945690713112002, -0.685580141659903, 0.20868127817668888, -0.5578824595358992, -0.5328734793765377, 0.12283169869497408, 0.7167659374683553, 0.3124431326996184, -0.1950538294469683, 0.693889213331939, 0.27939385357770247, 0.5208183990906132, 0.17340748942162812, -0.45005148404242384, -0.046176088651968344, 0.12926693471742623, 0.3167423937706109, 0.5522989967939824, -0.3212327432095199, -0.29281519395900385, 0.31257700752677003, 0.27371757352578713, 0.17992422943383105, -0.35915908115120865, -0.04380703716232416, -0.20653789632676547, -0.1583371895461684, 0.7490422362449619, -0.33413071389483956, -0.10479587874077184, -0.4462365929106306, 0.6363707780410784, 0.6383064766062473, 0.4979048192352206, -0.19171536532261335, -0.1721738376368329, 0.6229777633126228, 0.07531968752103847, 0.5123560215799594, 0.15255382084170277, -0.25793405479917736, 0.07911716917986007, 0.238752412014669},
    {0.4088159176335706, 0.22686185946516585, -0.2879567515781953, 0.1644271354528755, -0.7998633837051847, -0.4277692566731777, -0.30912667619074014, -0.4168398247985827, -0.39890802828253197, 0.3824883706650118, 0.7932643683548242, 0.24497899780449983, 0.1680069938702278, -0.3024403526566472, 0.2339066846291587, 0.5204355442982158, -0.14662435871372034, 0.6164041613760097, 0.4792552059725844, 0.33277797414289545, -0.11529008888490362, 0.14467489529380678, -1.1169814792463901, 0.23977303904764738, -0.4922644661405957, -0.23453359866434087, 0.041349702682160754, 0.8187361090021453, 0.1117076974858615, -0.34282201288215436, 0.6355113714893881, -0.0010618632288463472, 0.32437893644038096, -0.04293205563442666, -0.5131154671890638, -0.1768181146824729, -0.18633379420564672, 0.38229930730863676, 0.23987043107343978, 0.03435290769308377, -0.16351172935565028, -0.040598673344750036, 0.36538556530356187, 0.11889204555358958, -0.5357422065823723, -0.11346939422578334, -0.18327506427388404, -0.14493523054764287, 0.7196064879916476, -0.3636090090899652, 0.27850876871584884, -0.01414379387184214, 0.5058660609207641, 0.3502746412577285, 0.29922019119262167, -0.6071480490259787, -0.3355759190791455, 0.7583542221710095, 0.020560585700188098, 0.6562513242763721, -0.001354872741751826, -0.20334709817510763, -0.06749609081398768, 0.710280743547102},
    {0.6489980383421443, 0.6217752829901008, 0.010686481849404598, 0.16206260170848624, -0.5377595980065295, -0.6797363557998637, -0.4690398785215263, -0.25715006082167124, -0.2014375917697468, 0.06405961955844698, 0.574089276236291, 0.05796692407292166, 0.05229064553373275, -0.3694187233601668, 0.24616185530991666, 0.47993091208369365, 0.03726635485405545, 0.5274711477568039, 0.7782387474293235, 0.5152807087997139, -0.40517340675018254, 0.09101714192823478, -0.804239304294029, 0.10501210823658988, -0.7243506464820617, -0.22261785069183027, 0.050879280693704426, 0.7442886950472213, 0.16186198042809222, -0.2815503503767879, 0.7084938332171323, 0.40604857263622574, 0.46748835440505215, -0.17217545527172964, -0.5183405958935797, 0.08229583721574067, -0.009673059441247361, 0.3135025202489559, 0.371973040668952, 0.0008641884690160811, -0.1533521446751958, 0.2574435926126202, 0.32788094714206023, 0.05019604719609968, -0.4407842297110814, -0.32155051818237496, -0.2721825606642214, -0.11939335137060954, 0.7095521335446998, -0.1888565971090376, 0.3941858191697413, -0.47428175749491164, 0.6379957096865008, 0.7055931944379321, 0.3375692203723388, -0.40268061314018927, -0.61456113998354, 0.6308837441350016, 0.28765733573536884, 0.7727697237171895, 0.12483764000362518, -0.12193235192245379, -0.22787047562364585, 0.8028643565047155},
    {0.5158734127373336, 0.32165596200414437, -0.16035965715892755, 0.3318246871385827, -0.44178689245289066, -0.33032424072028505, -0.21976782694988753, -0.47617770587720737, -0.1436622981609386, 0.19008099429902212, 0.7476597437205098, 0.30844036403434527, 0.1728510754257968, -0.22473781017161695, 0.4474526146602356, 0.7712233018385681, -0.21146128131203076, 0.6719633079619967, 0.4917717990339867, 0.1290527596144175, -0.4846632838994235, 0.22943554206514227, -0.41968395476376014, 0.31498290833151876, -0.7362956830795311, -0.2705727644096508, 0.23527989794148527, 0.8304834504249744, 0.325779863574327, -0.4349242746859768, 0.5559729294193522, 0.2904894471569383, 0.6082234052555944, -0.16350331739328816, -0.4056561617295589, 0.03663235141100461, 0.04032961759959226, 0.4977206155684304, 0.5228717867969435, -0.22396730165219245, -0.1146308544893175, 0.2630749120201678, 0.6459260639482046, 0.09409711671848928, -0.051210709125181546, -0.15863189061951175, -0.06537433452179366, -0.1454026541651929, 0.8871769617894685, -0.3649572804394646, 0.025886306084365072, -0.38342244208838716, 0.5399103466756675, 0.6296571600670792, 0.5839631522317617, -0.24073770780206097, -0.3362373973986908, 0.8194898594686092, 0.17881924279403466, 0.5287892105247836, 0.1710791579961345, -0.04059821364890802, 0.1637781447932216, 0.5559456369256693},
    {0.4082964876355552, 0.6578246751460016, -0.09792572761018646, 0.0518553226328735, -0.575247978708308, -0.614242873375264, -0.3786190782807813, -0.4949718719939424, -0.23285295510790868, 0.20470750601903578, 0.6074373759870244, 0.3629780857465486, 0.14441209131758895, -0.045589839488275614, 0.5025826118503915, 0.5266600281799674, -0.2664997527173431, 0.5682472698847877, 0.5537964368002415, -0.07638593420712197, -0.3065789587653087, 0.17918558789341163, -0.6654571427316036, 0.1986832565686511, -0.6019211273023356, -0.3015816436606404, 0.05241441576296976, 0.7346505469273331, 0.03252028316612832, -0.27614429055399037, 0.7226418315543004, 0.18152234676190585, 0.6068238234625989, -0.2138827849042273, -0.5604103493484012, -0.06129765629913811, -0.10563663322612324, 0.3846242814291392, 0.5017005918652007, -0.19037770751306307, -0.38333587140583636, 0.14932062255678744, 0.5549122457786535, -0.09331262158103705, -0.5195186754051409, -0.058336380175734476, -0.2593712594726751, -0.40112344477067685, 0.6251299333195544, -0.35380009197667683, 0.12966380668067848, -0.2555610363671139, 0.5008173614650273, 0.6964832459499084, 0.21029354540977147, -0.3547236923868467, -0.35320489792942034, 0.7580918964478708, 0.13815772504871854, 0.5634927819942875, 0.09745955203599524, -0.41428365216175905, -0.03820671643128464, 0.8064218147965638},
    {0.3664565975739091, 0.7036128752614312, -0.3964163774503593, 0.28676744336969956, -0.557465587249689, -0.5113661399607976, -0.4640519329057609, -0.28850093486401107, -0.6234500336666411, -0.05139457405649118, 0.568135867228438, 0.3980776631376687, 0.18381229494327742, -0.3814747318990817, 0.47758248819027876, 0.984710049766392, -0.04645900053643473, 0.5420930733829401, 0.6808980589630355, 0.19299199514064935, -0.2863674396952806, 0.2067359216434739, -0.5110914738507943, 0.2741318882748319, -0.7471117741991052, -0.48411038237912024, 0.048541955964601105, 0.6671908715376046, 0.09091204325706315, -0.4412254872398524, 0.6329983958798227, 0.3227763066538137, 0.7806033773774259, 0.01818250282784403, -0.6219268658168943, -0.48504402528442175, -0.08519509645438958, 0.5290932109885889, 0.3513580639410561, -0.07481079423758996, -0.428914149758539, 0.30169496151813857, 0.49906895973833787, 0.06288753140667744, -0.41181809126272256, -4.6129168198396615e-05, -0.29168910142196586, -0.23111619839436184, 0.46479140774359257, -0.3845160204182206, 0.29600889114079676, -0.21628777074439695, 0.3210962644091573, 0.8409522340430267, 0.4884260994680471, -0.5669269434100598, -0.3809741340743382, 0.5648743584673016, 0.11462541754386493, 0.6719389161834975, 0.22667865355265487, 0.08361544510262943, -0.08126776953370735, 0.6340662574584043},
    {0.4346833561915847, 0.41805762946393077, -0.48383497591648933, 0.4035141283507882, -0.8842118694546687, -0.697535084769427, -0.549791929961532, -0.42641051095634785, -0.5681658025517928, 0.14349397941173242, 0.5847015071746295, 0.23933508121459365, 0.39474457436057153, -0.23885494724492418, 0.3429824847672162, 0.8153540812052926, 0.1663579394430802, 0.6175300310982572, 0.7728988652824091, -0.03063938739879196, -0.19575976343954457, 0.21444744805257482, -0.770718064969249, 0.2734906363449825, -0.8531506535918222, -0.2669874230575219, 0.09381607958956592, 1.0054870029135932, 0.2666650355941448, -0.29482652294716916, 0.4577274123965925, 0.6558682455964138, 0.4159899101829373, 0.04066611129201629, -0.5268881417674707, -0.5080893655614669, -0.08931862039781524, 0.4833917391999826, 0.5386637149855965, -0.022198435335487154, -0.40888731891825425, 0.15100988389339112, 0.5006181399512303, 0.11904644903516588, -0.28750469449701993, -0.0769204991999163, -0.024468218460747804, -0.24337453697154332, 0.5533179538777413, -0.35663762221311235, 0.3544510867667459, -0.3423230641950229, 0.6128423515006267, 0.5819570018942511, 0.5234682570936886, -0.49572528062879057, -0.5181516072135284, 0.5857285512323838, 0.14413475909422935, 0.6565729086852444, 0.26289209194249225, -0.21885036814368006, -0.28625746208567254, 0.7369055482207245},
    {0.2633894304070469, -0.2064981182612588, -0.12435787564858433, -0.312328993187011, 0.296226000375495, 0.11088295494397224, -0.023951746200427913, -0.011986546863828057, 0.008877754545580962, 0.06435393297936834, -0.39564385158801607, -0.5399124993171155, -0.43753592217053905, 0.09864740395414458, -0.29943699097513704, -0.31841249777008335, 0.17442549036072355, -0.14027644056418168, -0.06264956319779252, 0.2690135043760488, 0.02023251211015538, 0.07484509119995632, 0.36540279105023876, -0.12100727462367475, 0.3578995820627428, 0.17975108791329564, -0.3128484352881824, -0.5709338881417834, -0.1943716806554324, 0.37899830511534177, -0.13109536250447962, 0.26610770917601434, -0.4282164737837946, 0.15433241571997092, 0.17747902801475798, 0.3847685580991033, 0.13104750941047097, -0.17703470359045034, -0.26852562740058417, -0.08496089257816265, 0.24372577126056472, 0.05381357733829778, 0.047841026160778066, 0.008305760727546945, -0.12370831910203667, 0.28884007654648947, 0.1822289930905024, -0.3243116270279125, -0.4853906023205815, 0.2258946149412763, -0.1632426228081429, 0.02623010192673994, 0.002351262724618638, 0.005861467505048111, -0.11015869234057576, 0.1912664047043324, 0.40198008835635096, -0.2792522600954281, -0.10752871233280058, -0.1240533875845847, 0.06677439467159815, 0.16873905312091017, -0.18013925134254652, 0.1452702240151379},
    {0.2577520539566223, 0.2253401868235382, 0.2980000615986397, 0.3888265612350274, -0.5074470985972467, -0.163184448918605, -0.5745327069470023, -0.165165889862101, -0.37755332138459874, 0.27705994779980114, -0.030732840794562698, -0.31919687902352917, -0.08039609491411491, -0.1618708527039191, 0.029252505592329964, 0.16491501376434922, -0.3123636151216952, 0.26630429415344714, -0.10240626049187591, -0.2914788868974057, -0.28271391205614016, -0.24380586047750558, -0.16237240146237752, 0.152242604127272, -0.306464906543952, -0.1833580980459878, -0.14574527950645644, 0.32329519220183267, 0.21843299860921042, -0.21711765085684273, -0.34613363404682074, 0.10442126571086391, 0.32495661743234555, -0.3389448298027191, -0.2568055734792062, -0.31910737932809086, 0.06251187718161663, -0.126705151475021, 0.1458521075283134, -0.45010179042198234, -0.10111365903540055, -0.06473689976033002, 0.39707357912043095, -0.34210746588565444, -0.18936366335182755, -0.5154777187842247, -0.24614457590753086, -0.29987119412880253, 0.2594626700337267, -0.1720698584969005, -0.4050491506297755, -0.17930539389711805, 0.05723224177737238, 0.3395684724029766, -0.21017932758900124, -0.17146384948616483, -0.49247720950659885, 0.2929267680711161, -0.024695046066137875, -0.09113214386448582, -0.2669192968066822, -0.32867046499094893, -0.4051584323433537, 0.47649552251726596},
    {-0.014863770413726218, -0.09960791080179984, 0.6243549477035933, -0.42797981646343974, -0.0749141199946432, -0.2777824096199328, -0.33076151834137996, -0.4820293453961772, 0.1523870669256963, -0.7535662503515498, -0.4004625648290382, -0.359793342264366, -0.6209090330217683, -0.40693282513454787, -0.12998640692529112, -0.5005791324225879, -0.5339878070237154, -0.5318949963382709, -0.056905810863432535, -0.6005250099508146, -0.4326973912107783, -0.30267038585761963, -0.13313442899103625, -0.3805343274135111, -0.04871652831204322, -0.18752694422539737, -0.5119964521522471, -0.3684107181118794, -0.6726410600915322, -0.12426211273204078, -0.2067639657216446, -0.43521035871488223, -0.2580538971220803, -0.29170987175986135, 0.5464289624404065, 0.3591834210069204, -0.4847715912435226, -0.43002853552058734, -0.46507001906672335, -0.7367321804621643, -0.4867591299329259, -0.42122687070276366, -0.4855003096445908, -0.8163547530472591, -0.45138992345323314, -0.749518626461614, -0.34561720760755504, 0.1090539534566008, -0.596525650256997, 0.3365845103304076, -0.5328825739305253, -0.5119908608357008, -0.31952944220751794, 0.031266436481057876, -0.535204380939739, -0.22722295521856004, -0.25154827270667773, -0.2712186758211273, -0.29249065285528786, -0.7695284954122978, -0.4045864814496738, -0.47362801886603584, -0.30829982556460467, 0.09752574978323433},
    {-0.0683799999157703, 0.18245362137584395, 0.15578017224666155, -0.6726992297398761, -0.1733611214890181, -0.31928456004183087, -0.5573539765073843, -0.4750132315287823, -0.1432090211442623, -0.08143426187923837, -0.46135236339689173, 0.021840868763301203, -0.42338536279531264, -0.3754873229820061, -0.12862671706471077, -0.5977251062924277, -0.14395739082445902, -0.14516636834391533, -0.3630176048871438, -0.4192431470816527, -0.2830559823108829, -0.2513078181015352, -0.32790651258108594, -0.31311155887235814, -0.5144166711934856, -0.29692913152395334, -0.24176752482638128, -0.5102282458090748, -0.29359904700693, -0.5649238879091795, -0.5298043223476853, -0.2863780666254159, -0.36592898855668304, -0.5530595411389324, -0.41439615481747033, -0.2860023799416107, -0.3236761520889412, -0.02503695883522228, -0.45559335718496535, -0.3004396928563151, -0.6455313757216564, -0.13574588898151999, -0.18049704688380525, -0.4477290036296812, -0.19033763594355319, -0.49032986249105753, -0.3767733644733545, -0.146246667156622, -0.3484588552213256, -0.18841618530407356, -0.28812672104910486, -0.39805541451125914, -0.3417504106889152, -0.16591584667620185, -0.33407431734152904, -0.5501617850967859, -0.15900059537741515, -0.06461482217378532, -0.5700146510883288, -0.20967834415556205, -0.38042853633701973, -0.3046002902750286, -0.22631700240240177, -0.49391713892115524},
    {0.02048080306469779, 0.35697369202205687, 0.1606256495952286, -0.4223930756794332, -0.19392155427726335, -0.07748547966265146, -0.5071254678496171, -0.3827933759222795, -0.4885725505091624, -0.1346522292703034, 0.012821969498603333, -0.43419085408395297, -0.46240278210162683, -0.7119453497966822, -0.18753101910556466, -0.12359771166348366, -0.3768567456423143, -0.03901867702726918, -0.29244057589298983, -0.7594111913166376, -0.39180910225926324, -0.2853808581402835, -0.18829237190354503, -0.3540256021287071, -0.5684389405098972, -0.23635544545858456, -0.6054642704592106, -0.020336903239899392, -0.3233642409105758, -0.3137551407702889, -0.09626472018745007, -0.25840260152917566, 0.12743339327927802, -0.2727166382919739, -0.1842869318109166, -0.09679512717483485, -0.6577282998800282, -0.30470093293676925, -0.11831812769274146, -0.27332769054699, -0.3006347790752005, -0.0044303672274981975, -0.31730835877684554, -0.4460842269690679, -0.10977923961803789, -0.6283969766304215, -0.22400484841782678, -0.40325385311501016, 0.1022801700671359, 0.13353036396798446, -0.4163716466946316, -0.3130641145831902, -0.30222059089228276, -0.016027926485068917, -0.39727166277027337, -0.2610584997291948, -0.4811263282014696, -0.030202531906572596, -0.26080121854136173, -0.37478459813498616, -0.3912456808581152, -0.2615005898301165, -0.3975047054476059, -0.09929402397943608},
    {0.07769859127573232, 0.17191790400642065, 0.15383511290798252, -0.3861773904547394, -0.17606363690072369, -0.5739994238959977, -0.022238176324530245, -0.4072974783132645, -0.44279020383949014, -0.2496245688010208, -0.17474264778749227, -0.36311180589082453, -0.15482076586905533, -0.451853636622582, -0.34794230467502174, -0.32502360193651864, -0.5676161278953373, -0.06103007790534873, -0.16562027986499203, -0.8928381208061726, -0.3907375295885264, 0.04266666361112223, -0.35560587371143404, -0.5670467401237846, -0.3561826122371873, -0.46250355428270606, -0.4063059330392391, -0.02953846387507837, -0.30844859567809635, -0.40558460061710183, -0.11919086071505604, -0.6166521125828852, 0.09679917071038727, -0.13040217026820325, -0.11745184548001998, 0.12441522979247807, -0.40112239110825426, -0.148959253832577, -0.35494205371283283, -0.3477710895317656, -0.15306089036045323, -0.20847825853499682, 0.002697686107658695, -0.6168368381077773, -0.0016888564967891752, -0.2797226945100281, -0.7870462041663736, -0.1297698164575945, -0.25143266566660594, 0.28764566978483413, -0.36196311783332324, -0.23823205065257563, -0.04269174547891809, -0.2009667606928252, -0.394209341781445, -0.37714672900378915, -0.5569750714336029, -0.11621416628367891, -0.26038860322620827, -0.25290932850377296, -0.33490427864311395, -0.4839548728622142, -0.35036432096745235, -0.0007363419301152797},
    {-0.0639322279954156, 0.18054648118051655, 0.23165640144105068, -0.42172007920782223, -0.49943305730324533, -0.16491249711869393, -0.5199117390947969, -0.39216302992883156, -0.2878952899101002, -0.3547299949533405, -0.311891100275222, -0.519213559748191, -0.5947524011287171, -0.5016385713956789, -0.03556987734120293, -0.24071856752895376, -0.39836006736843926, -0.007733840738386487, -0.3605558784206384, -0.7374383556976091, -0.33202006024480524, -0.2809114324011429, -0.33091602622509936, -0.6037915027770046, -0.4353781889242474, -0.4542935160725086, -0.5833858571622221, -0.26061836264525085, -0.606074756841992, -0.7419022186119192, -0.14784252130025702, -0.5711050451060822, -0.03392367242690681, -0.5400991992629729, -0.27384002953928016, -0.11145319212607818, -0.19606208394988248, -0.30091978849350265, -0.3940966819892266, -0.5391790308680843, -0.3324999877502922, -0.4031764914110716, -0.35686430174415323, -0.3112235599117162, -0.3144835688893397, -0.6949864336886514, -0.5222993365376696, -0.24711094630690505, -0.31408851509270846, -0.09781489946587738, -0.6802221012487981, -0.4222800013463989, 0.02786707752455416, -0.5317999132898032, -0.26786493628723945, -0.4805251425959718, -0.21826711972044105, 0.17188136302839715, -0.2901850637335492, -0.1988098130750616, -0.3076109333193789, -0.39767337587400753, -0.68402845857041, -0.2819095121623248},
    {0.1498273912976286, 0.04209674170357466, 0.13225417359517275, -0.5289045389487469, -0.19042655124965105, -0.02285134004227504, -0.7698307968445935, -0.1611526963225669, -0.46929617184849715, -0.3597849325027252, -0.13669792852089488, -0.1550194670243238, -0.29300283814235917, -0.7163386141429471, 0.08273061806710368, -0.27533402604970325, -0.5515916447083387, 0.1686876830761459, -0.11609743795102721, -0.7080472644596724, -0.21771594699708346, -0.22085488422366592, -0.3695361609473531, -0.38925479022687626, -0.4749971213882, -0.17052847318939038, -0.2629597718136541, -0.11088710213665631, -0.37464507346699205, -0.4614458185995391, -0.07578092230710254, -0.29181787786829333, 0.01400512635342544, -0.5462866193479959, -0.0397221670331906, 0.16761434014904267, -0.19855809119698872, -0.639015005628817, 0.08809500639161472, -0.4223931930258943, -0.3290889194206973, -0.290949609024525, -0.36001413348556477, -0.14294059231368192, -0.2618441674151824, -0.3746393911309122, -0.47154925768370165, -0.05525214305996273, 0.057923014920911654, -0.12812155613804826, -0.38601431315516804, -0.3694240476831015, -0.16104227095607393, -0.27212498600909624, -0.1360555327886636, -0.26516348848199084, -0.005987464166748366, -0.012455162833273645, -0.36970388927539455, 0.02471987493416699, -0.2638459279292754, -0.31566927476388107, -0.44301606983031067, -0.06936897146869452},
    {-0.2666022142030709, 0.10394353321230729, 0.03976529480237919, -0.31515418754694247, -0.22264951524078141, -0.6029774712471825, -0.4298261606059279, -0.4010782291969135, -0.5771216058521043, -0.25730202913550876, -0.27256161268210943, -0.42548233978879213, -0.397925529694844, -0.3985118791295556, 0.10641954559553764, -0.3105555911760878, -0.7222744742126955, -0.19689621231574553, -0.09118801975868976, -0.6330362630833726, -0.39283442141719355, -0.28620658969901425, -0.44047480334335126, -0.6404666924374599, -0.7610720664166236, -0.06026194891616369, -0.5434428686065387, -0.44035416165942637, -0.6171252599515986, -0.21641068358820179, -0.14189906884058692, -0.2443269754071899, -0.28058213572401736, -0.5791655079114298, -0.14980633136297739, -0.1024865272173214, -0.22513090709450675, -0.41233958092438533, -0.38427781233010927, -0.6328253798964675, -0.41134582584080076, -0.23610900691292627, -0.0003310758099186964, -0.3345104051530807, -0.4690389156617108, -0.6045976371893746, -0.6939535925616496, -0.3936774092660686, 0.03884976692233178, 0.022730299549540388, -0.6071466132863117, -0.610771404142456, 0.1012968202031262, 0.07718392946674961, -0.20708567405077297, -0.657960263162859, -0.5258537890113845, -0.14482645363562552, -0.30474197922463997, -0.27023658821144997, -0.42388142895693587, -0.4962342696714796, -0.7275936797198361, 0.04818076597102679},
    {0.03044010743483526, 0.39734055885509656, 0.18329688825139923, -0.7635750573653519, -0.17497237854171735, -0.5487220047386628, -0.5494232136953281, -0.2986852996234111, -0.6011994918021704, -0.5425337884925825, -0.24520527796931635, -0.053349977182104776, -0.44348008299245656, -0.2964770525115697, -0.462151011373546, -0.3971952469792542, -0.5705609424210394, -0.29489417098689796, 0.032716729212294404, -0.4908885352995926, -0.46929651354277785, 0.058077717914748986, 0.003889230653482737, -0.5375414774512352, -0.2414658390014593, -0.24678401907390754, -0.560405134166501, -0.22885158826523616, -0.5400101456591128, -0.12580222868427718, 0.015659841827568584, -0.2011748864438365, -0.19484751963002625, -0.5531582691468474, -0.3160640193595548, 0.06165759461440659, -0.4918359843803973, -0.5223417951149285, -0.16716886748138604, -0.5561003315672115, -0.45486403750308274, -0.5537018122447063, -0.22562032984732128, -0.24047843408498035, -0.12420779369400668, -0.4480801413019085, -0.7137600654854956, -0.103184764450689, -0.26235778231445306, 0.24251278455154746, -0.542113127870642, -0.9483482256642983, -0.12828684369079066, 0.16691766807973743, -0.21100460345900476, -0.45139019962958027, -0.1399689655833938, -0.0976577757184915, -0.4055151398402872, -0.3691164927776487, -0.5129747206768402, -0.3917661341490644, -0.5083506501823397, 0.13964355135195397},
    {-0.134602318348921, -0.05225282059674394, 0.18630764991360593, -0.3181969009092534, -0.2678768268815583, -0.12401825088526697, -0.44195320648974806, -0.4718881006392161, -0.8602603512718004, -0.4082833770849503, -0.5228064638707075, -0.10524850747186411, -0.23211651258052743, -0.6458523406101597, -0.49828426654133295, -0.37953627825770425, -0.34501007938716927, -0.7165888777099205, -0.17998007457690535, -0.659971973384799, -0.17635242445634514, -0.2509551778738443, -0.5233603330846572, -0.40370701468556613, -0.20024381507785677, -0.5143515240404455, -0.6387859041742411, -0.555201426846185, -0.3515892616684216, -0.3236290266633795, -0.15347859059321475, -0.5746933004489954, -0.331561592686185, -0.4260858077672344, -0.3322062797124203, 0.062347343311110595, -0.7260720611015811, -0.45897409637576436, -0.17861323649618768, -0.5564138477454554, -0.5404814691260287, -0.49642158426139965, 0.06832505476592107, -0.5423894900350232, -0.32271760135470146, -0.5166355790345811, -0.4269406247596919, -0.1651804783282714, -0.43877942281436516, 0.16080552419301503, -0.40182942312391196, -0.5170898988763257, -0.3658087498384895, 0.024583538854196382, -0.3997908436027245, -0.5739269311090623, -0.3111370102492355, -0.49728535230654736, -0.13877162874018378, -0.23685271966540905, -0.6432896779426581, -0.42840510807971166, -0.4722831766060746, -0.08823024732104713},
    {-0.12151721768000122, 0.009195400711233254, 0.14668102854709433, -0.7025966837274288, -0.1593129952695814, -0.3886863443778149, -0.600015103091273, -0.4991909482250865, -0.6656325280843108, -0.4415918221179772, -0.39833695207521697, -0.4644352931990928, -0.43393078464154117, -0.5396703988926851, -0.5238133897498778, -0.4929243820347323, -0.42974314845733785, -0.2732312796709893, -0.10100710064700623, -0.4586752274141085, -0.48459985443592224, -0.2358132626432083, -0.2426044441830123, -0.3481247668456024, -0.4310960024392385, -0.20395566509975682, -0.5515503947254948, -0.5682177098842718, -0.5682511655237674, -0.489032241790536, -0.3859750812896707, -0.30056545326049566, -0.054551844045567684, -0.30186762902708925, -0.5800668721423314, 0.04765160990686889, -0.5182530406003203, -0.40115298480954503, -0.09029215823161153, -0.4033515587704856, -0.4287008400751512, -0.17662034891319198, -0.45384098551138113, -0.4524904333663011, -0.44689444749032226, -0.70655894589423, -0.6557078790235158, -0.38916886368211207, -0.31356723575066753, -0.08426321931300887, -0.5165026826309562, -0.39117493574274714, -0.34203757861076967, -0.23812509526560885, -0.4237805159532869, -0.6272846983257244, -0.4155922228312323, 0.06623871038405309, -0.5125647431564863, -0.4034980156498308, -0.47148281923204993, -0.6495050946882875, -0.56953501530594, 0.15133321089126897},
    {-0.24573810896746962, -0.15811628994695276, 0.09551097767619825, -0.35514018619544324, -0.14333296766839332, -0.2710878006184164, -0.7877784905478094, -0.44640518561089915, -0.4930760230992565, -0.36389067121327895, -0.3659714419893742, -0.14804603743734848, -0.6070995131439243, -0.5549137689037272, -0.5434677582413099, -0.5900564766601308, -0.7365671049213539, -0.2673406106599421, 0.22447431862759226, -0.4486255437244735, -0.7220220531716829, -0.48671966243057224, -0.33614540824220046, -0.5410940066091675, -0.383452126795648, -0.10383647450542258, -0.6431404109564351, -0.2546096921165236, -0.4183792186519073, -0.5696212536498021, -0.24128714759034184, -0.5158560591635046, -0.28826090471864335, -0.6908449364286479, -0.24340846227506274, -0.0002314392010337921, -0.4899074861011411, -0.35867382149455834, -0.3964709804171685, -0.3159175729610375, -0.5682847589373897, -0.10629951626007342, -0.3473168684214523, -0.7039354593071568, -0.29727620633336777, -0.7144323728157804, -0.5315712598956701, -0.0475853042531179, -0.27495831973143486, -0.16823438632434515, -0.6060186174562112, -0.7376168541530941, -0.28208109443893725, -0.2696067951531871, -0.415443654814211, -0.4678367704651456, -0.8265104512089112, -0.6191504803729487, -0.5765454873566016, -0.265041071402444, -0.4850138610085876, -0.3791993963160024, -0.7314848411464591, -0.14196196879286155},
    {-0.06997604084071388, -0.2516794585812398, 0.06769384732907371, -0.4737719151845153, -0.07606067428277782, -0.507729932720123, -0.6101520014436785, -0.6784600612270513, -0.312727470316137, -0.3664896064945401, -0.4227643938302502, -0.5113984537146178, -0.23929187945622207, -0.5756804535830344, -0.5887204470171922, -0.44341129748316566, -0.64766888826332, -0.6380480997895794, 0.2847034581478363, -0.6150354798726096, -0.4754862021802162, -0.19041299688193175, -0.37620400484245864, -0.5031490662787298, -0.5797681411088594, -0.39426116752959295, -0.5298020961552334, -0.33092598483025476, -0.6599954099668243, -0.40675673121608036, 0.045857536514658424, -0.42020001569010157, -0.2629608876327145, -0.6936700543751075, -0.40157757937262745, 0.20387629984648678, -0.6391157718402216, -0.6910025394995423, -0.42098935923477787, -0.9034786679234305, -0.4633922513291573, -0.47564906171796617, -0.40853328536382294, -0.6216669346903563, -0.38398286616524446, -0.41451461085539437, -0.6173788379669535, -0.5821597410498696, -0.4043157710496439, 0.36250970753625605, -0.4874503361476985, -0.5258207221650336, -0.23408148586768643, -0.20277798483686194, -0.3819812671147877, -0.29631763105318226, -0.46918353097794807, -0.38180351527320266, -0.13669414901670748, -0.3326021972800633, -0.5373172568227924, -0.7196733312136849, -0.528199797971431, -0.22682124190413425},
    {-0.40238479635494756, -0.016380668435987778, 0.45707074073625836, -0.002843884300592821, -0.07454621342441217, -0.39395744278227346, -0.4228851498627438, -0.6440496152388018, -0.3623254217532717, -0.34239446726603334, -0.3642995079929086, -0.3418911106466871, -0.18046252835444268, -0.6630723439069386, -0.3129653737392337, -0.21845104879921975, -0.5453429953161966, -0.552311749950065, 0.5288810358097926, -0.5472835939877695, -0.42718004799445636, -0.5115961156715096, -0.016655850220247043, -0.871753311041537, -0.1814636572014448, -0.2145880898757016, -0.36834119778684205, -0.42893465654276297, -0.6976411344164702, -0.5520614258963021, -0.19350212058583607, -0.43397335232219364, 0.006953817360099526, -0.7786143258479656, -0.13430067920910715, 0.08066924281139959, -0.1691297216650626, -0.6438073632559683, -0.3274716377805019, -0.43689066523240533, -0.2072655037940185, -0.39636236296062083, -0.3763463704722745, -0.41507944853056933, -0.3099082373343573, -0.4660502814743524, -0.6943224468740765, -0.42149324583888387, -0.11383245513611272, 0.1592494431949075, -0.8345599979260223, -0.7649258650612794, -0.19748852808636258, -0.4479890427478115, -0.47626162465631255, -0.6626747535526543, -0.5664686863580152, -0.4196514730197329, -0.3438675478151676, -0.6068733590115984, -0.4007015180883952, -0.6157811385840823, -0.3937280448179765, 0.11027175968298983},
    {-0.09935419641574174, 0.014964946780043524, 0.33839876628709337, -0.4406382894094471, 0.1029922856792068, -0.3076273735401495, -0.5045003531175206, -0.6921617741093558, -0.29521430496937545, -0.581786088408258, -0.4498911747434493, -0.6268769135714369, -0.5500089582943342, -0.6273067908975505, -0.10959507798553479, -0.21383391351290706, -0.5405647423976834, -0.2608801052725182, -0.12075434154826156, -0.4393435996623989, -0.5807458119298927, -0.3371431581773257, -0.24543799716281045, -0.5820443301880343, -0.12034873116759952, -0.6195202445417821, -0.4197417869259948, -0.5353173955698842, -0.6936280631402307, -0.2250579536146953, -0.16005032951476864, -0.7674294133705772, -0.0868324109203479, -0.7718039932351926, -0.02565326937046274, 0.22073276766205213, -0.3958081951259577, -0.5596527646973071, -0.5089609527610549, -0.4621420632181618, -0.3187149720415938, -0.424359795355676, -0.377697239195188, -0.6381595688177069, -0.3309923885198088, -0.5567957454159536, -0.6522257639011959, -0.39844400263782886, -0.45588171139671163, 0.3124920308483489, -0.4369618965828145, -0.8264932930569083, -0.12397645724788244, -0.20105988426230953, -0.47441495753220164, -0.5460829578157651, -0.5347612879354605, -0.5661664233017745, -0.484720300871446, -0.5060233458173865, -0.42497106019081116, -0.8904861752954372, -0.3395594360871006, -0.09696616437890682},
    {-0.050354769840234286, 0.052979296007867736, 0.29065323699290274, -0.45053150612623005, 0.05620356672867345, -0.2760539724439424, -0.5100097557585892, -0.7889346675674431, -0.3153238006861292, -0.5852866951513733, -0.33551744920060383, -0.06700671450894491, -0.0013173881623701968, -0.6842606486378414, -0.3349812441947322, -0.40975545245517586, -0.3422138965416787, -0.36029549845718084, -0.11336224629819641, -0.4099604321640286, -0.4765024534497466, -0.41237422059612333, -0.12000314066346786, -0.4053111774183712, -0.30161874684289286, -0.30357513695639365, -0.5739436595255362, -0.3807553194265729, -0.49512205466941395, -0.18276658044636987, -0.06873682679889766, -0.3110403826098964, -0.30350646967780454, -0.6396928671296276, 0.04042017455841335, 0.42902594047239473, -0.19360260924282888, -0.42753729649694894, -0.5453068555485747, -0.6185791954901391, -0.3675623520163169, -0.26239309957098944, -0.37368096559790065, -0.3739333396484679, -0.29352500702196277, -0.7630134435685174, -0.6321346111777554, -0.12900483515479405, -0.3772976186739864, 0.17307301468624894, -0.8635498735208238, -0.5977837067885514, 0.07614532411732569, -0.11921045641751343, -0.21717018941908509, -0.4889973329783215, -0.3972445071866538, -0.0037883362972035146, -0.08250326611195581, -0.4090649518149136, -0.4134084094500092, -0.5905796472514984, -0.30996398142290393, -0.15277356390698069},
    {0.18853087438210905, 0.15462368843145155, 0.24064712086093484, -0.13517076866753294, 0.032106279544562986, -0.26741020976906216, -0.3052690430703405, -0.2749911275235199, -0.16475643721123812, -0.12010814887493013, -0.06290755736500618, -0.021418395567929387, -0.23865060394211243, -0.194511509418556, -0.16970154794523834, 0.04449627813030955, -0.5856139575163117, 0.017211876313342884, 0.28033920158203446, -0.5540684008058182, -0.44152740134784, -0.015013788864713093, -0.25779277973658626, -0.21190318489400364, -0.34152213687549704, -0.2628379977313078, -0.2192433296395104, -0.03418054453858511, -0.09199282977578516, 0.00669076422659511, 0.10923568787715389, -0.14356010480081077, -0.2388841136352358, -0.3869841766568015, 0.03638444349890728, 0.20652766397124422, -0.0801615298467067, -0.29894719791463925, 0.05421523910493413, -0.5010617180126695, -0.2829243115271198, 0.13472061453030082, -0.24082149216944454, -0.2684454526492715, -0.33794091211017235, -0.4480872358377581, -0.47313835677651533, -0.09008775399023804, 0.2190079242268456, 0.156567462110275, -0.3182515213680794, -0.4376469250119848, 0.44516712382309703, 0.3757674070661833, -0.27515756965715393, -0.34575599500107035, -0.11619410837448278, 0.4208916115309546, 0.11232063337692295, 0.2396928266923454, -0.1181971285875421, -0.46571416216925055, 0.00678186317102916, 0.11895019379490165},
    {-0.29314053537177254, -0.31091432696843646, 0.27100994088384495, -0.563575749942888, 0.05958550097421548, -0.203963112691616, -0.5813962794934627, -0.32350904411317366, -0.2414441623312109, -0.5356533313240512, -0.09663663766157901, -0.3359269666981231, -0.27537920765709933, -0.3899135822417454, -0.5456808614270467, -0.2392478931109702, -0.4308937825456318, -0.6074259577065044, 0.14366199964784762, -0.8156270000091871, -0.24783935485309008, -0.2240665791024111, 0.038032841168576505, -0.550540832318802, -0.3494046306907836, -0.17014987652557043, -0.6158559565931914, -0.3024627111604081, -0.285352483245406, -0.5120632616791412, -0.37633096716754877, -0.6089265841568718, -0.20635944787540272, -0.47389753274336954, 0.12559509866823274, 0.2578875406590534, -0.44663776163812396, -0.5521161219174155, -0.5071610790387613, -0.6473540257027884, -0.4719031439217066, -0.23753437965248264, -0.2912347992309427, -0.500544695118705, -0.5987300387342518, -0.7304488424761676, -0.44674987498938085, -0.1933938099970187, -0.37498775491502345, 0.436474941387838, -0.5497537969395827, -0.4461749025568342, 0.07322386424893934, -0.1716910192113573, -0.5501482975539956, -0.6973165824730895, -0.27921430447505885, -0.11497967051498523, -0.27350998924985226, -0.2308477976535983, -0.5182856838202158, -0.5298714104989195, -0.46301667494410204, -0.010642794337580837},
    {-0.1482071921624244, -0.04741871107511819, 0.32415019137613077, -0.43332351234682814, 0.09945493430087202, -0.22555737758870545, -0.6226908373295342, -0.4358041611961573, -0.6904311620373527, -0.668094229039199, -0.34011150584230593, -0.08557436595828541, -0.36520310342050366, -0.48478869986206596, -0.3687094530740774, -0.5860219496383057, -0.5118535947165971, -0.45480342780094635, 0.05257905276190594, -0.6088863249303101, -0.36554513799748967, -0.5680329652246602, -0.20161850267711462, -0.32375241756492656, -0.3094995632662648, -0.5764368632172427, -0.6442971240111146, -0.46099042023784853, -0.4541485702015335, -0.36422118098074535, -0.10926739047773, -0.4276128386390884, -0.36049580933336695, -0.797653185818283, -0.25219433989382406, 0.07038007342822507, -0.4540107010014896, -0.5573802216042492, -0.29297730598809896, -0.6984075966528785, -0.4884801208732755, -0.07958807769041114, -0.48213761335423155, -0.41240341366700417, -0.5049197664846796, -0.39609189276068274, -0.3896842615420585, -0.3175436979487108, -0.37799821576049736, 0.15546302848381088, -0.5896001303647989, -0.5520827947998329, -0.14724154519684393, -0.1816215719937179, -0.4972090955774487, -0.6236363201756633, -0.4037198628427463, -0.19537305456239903, -0.6591195059315117, -0.29215672807469806, -0.18795474564746698, -0.514466380336186, -0.3083384714145904, -0.08391933220929747},
    {-0.29399646171127897, -0.09013674437515255, 0.019706789346862787, -0.7529536245077171, -0.26101608011031047, -0.5043530073072567, -0.6976430008067065, -0.5220406012155666, -0.5014075491703337, -0.5646241094404671, -0.5927015286106327, -0.4276155516215973, -0.5301683488200489, -0.6112694373188134, -0.6700162638055017, -0.33806565379205433, -0.4875687406313051, -0.6034968500355511, -0.12361687596323706, -0.6689731671906525, -0.5723590913404237, -0.38263028706198926, -0.33331102079577163, -0.5180954354529359, -0.48353435248495474, -0.4963085265947649, -0.49128815516472346, -0.43143922538990315, -0.7258438491356948, -0.4703780129474951, -0.6010437585698949, -0.2530000077968018, -0.46411740429226356, -0.5470124259067525, -0.23895921699538158, 0.24659277830677168, -0.6694190818847179, -0.3505744575845878, -0.7291041121240498, -0.5645130780709888, -0.5861129757534841, -0.5143199503694031, -0.3564442884322974, -0.5849713745081792, -0.23744477712805392, -0.38339500623571693, -0.6477853181972782, -0.5585201765351167, -0.2568095968002143, -0.04003387855385112, -0.47756715360695634, -0.8160132992492946, -0.3217456094266168, -0.2677128353814817, -0.5578055315926495, -0.6062248804035169, -0.41480046648292107, -0.4451346409501307, -0.5276237297492805, -0.6749841425100015, -0.371744341693256, -0.40386452897832975, -0.8621301557230834, -0.5052657322226548},
    {0.5200019762591442, 0.2648158652741768, 0.6640661049478255, -0.2947331657196766, 0.05864672743742936, 0.025782322036324173, -0.33054290519457685, -0.5755150729109503, -0.1499174363983799, -0.5949345567867002, 0.0019819012419339307, -0.027872111599659355, -0.5404673852633918, -0.6013308867580012, -0.12884729495311387, -0.36806547607057777, -0.6047747832472999, -0.4883381383921897, 0.3650280986924209, -0.6614015052687803, -0.5672089743047247, -0.5849532053145249, 0.046574448933600625, -0.8138392953297192, -0.3856737704689089, 0.06459133245451155, -0.5468714428153963, 0.08977163617311353, -0.653007703091072, -0.4655829285966829, 0.21849388813796577, -0.0745055328415572, 0.282370315030275, -0.532976270669628, -0.3592746551512998, 0.6100825538043877, -0.22161198141458419, -0.5810150253844366, 0.0013216989567017396, -0.7093893011616234, -0.07066090207673832, -0.028533072513982696, -0.20389352544338057, -0.5689211125944795, -0.3203719051939361, -0.6587855434065675, -0.5937400749267955, -0.387383237441881, 0.16842911880376685, 0.3662923385549627, -0.33625239822652914, -0.5654610570569651, 0.23172538736898604, 0.6346777145740075, -0.48382578472754756, -0.6664494013551111, -0.2578275099968008, -0.21101232368073003, 0.032604853538901656, -0.4887259109359576, -0.54693010820385, -0.40501196844081727, -0.4825277733115789, 0.5459609049757195},
    {0.37815651944110473, 0.40943599329452096, 0.9068101987716882, -0.4725939205686878, 0.5505509494310133, 0.42237908372722693, 0.28593745312686575, -0.3153789091074605, 0.1983429836141642, -0.5753489003862448, -0.23716160740466546, 0.1769009050811982, -0.5056721077314171, -0.7287930403447861, -0.18686415535554193, -0.6377395204404246, -0.5183579082689903, -0.8252220218730055, 0.4756144748194266, -0.5551564305336169, -0.6594779719173802, -0.5168657629820487, 0.39645567936116743, -0.3973113049782163, 0.21851908454908772, 0.24188370814531235, -0.7253876240263595, 0.10994889083273054, -0.48630755446999746, -0.4622501012241649, 0.004960691980576227, -0.2638244231921251, -0.09167520954826099, -0.5363569347863032, 0.2789873075961104, 0.44085638168583285, -0.10801121466489465, -0.4710369666150525, -0.1756715058788573, -0.5764438488143229, -0.040010875200121594, -0.2381187544364156, -0.1627112517272043, -0.36402838682744515, -0.2931251463761456, -0.5884398144434707, -0.6543807694583751, -0.3364850234063763, -0.1815770811231341, 0.33802533258864415, -0.7011661582686034, -0.7073406978902774, 0.5504836241873148, 0.17252765660823108, -0.6027037170184705, -0.41607477168051843, -0.21983887547268727, -0.45204833235877034, -0.2501602142317747, -0.5176468479390224, -0.5446341791269249, -0.8397699607015239, -0.4623567574703654, 0.47907557012772145},
    {0.013063957274121952, 0.08378470970166912, 0.6328044387477567, -0.6568434264234309, 0.037498224793009, 0.05037913586507493, -0.30456834680393663, -0.3023377378494939, 0.14391579015462935, -0.6982545359154793, -0.5599260446687694, -0.2637866460816441, -0.6592560309666144, -0.5223639120450791, -0.6154283280329491, -0.6870213466643996, -0.77081136989696, -0.4663767573534703, 0.2467866472620373, -0.8133987571337731, -0.661396804866192, -0.5448293180829101, 0.15074845483281354, -0.7452260328744428, -0.0801084477478333, -0.3269777645471564, -0.8363685589748229, -0.4887233356557024, -0.5818518791808167, -0.37956062466664486, -0.4387120721260788, -0.4989270185777247, -0.2466278038743043, -0.5465886104690489, 0.19690256638767092, 0.5384111734263661, -0.4233157047905897, -0.48862463603755896, -0.3912047871770538, -0.6725276238455471, -0.22100858611738572, -0.6076908424035324, -0.5798743213992043, -0.8575258380289241, -0.18370387428583246, -0.6049067326084935, -0.7736527846838535, -0.3360704089308783, -0.11364789827141521, 0.17322422607118867, -0.4514700723338033, -0.6966251368316057, 0.09018413483427355, 0.00391837342215493, -0.7069016726198695, -0.6090822048256819, -0.25525923194260103, -0.19687328548564786, -0.5477105035059633, -0.32059171236075884, -0.5399470000695532, -0.7359038656141552, -0.6921620173061972, 0.3129565605250939},
    {-0.11623806528909535, -0.21126627388147767, 0.1175400367539051, -0.3627436365202938, 0.0005174465723294414, -0.42756411861433197, -0.6422637858477932, -0.5526657677739131, -0.38029715755175386, -0.5275456457292786, -0.11424219361058685, -0.4360526081556872, -0.2885812288081082, -0.4435600514344604, -0.5381460707458291, -0.6044888339446834, -0.7837406190163236, -0.6175449247121053, 0.21265491273491227, -0.6188012939130432, -0.5308853834738188, -0.5319857694268187, 0.015192174717901264, -0.6493390533813678, -0.25383450831109317, -0.39704328962205027, -0.7277877643882598, -0.44444019577509, -0.6517803442759683, -0.38717119571284236, -0.2036945816382167, -0.5051775424292916, -0.2609899069316098, -0.5030982252187913, -0.032894562168041756, 0.49919856268924134, -0.30520660722267734, -0.4483063771209265, -0.3984312224653371, -0.735155398607495, -0.41827933273221574, -0.41821387555735945, -0.6055904819697185, -0.7473967380855744, -0.48751885537316814, -0.7792196201198368, -0.6548505378250576, -0.1748474898500419, -0.18503701784351112, 0.1650444849113413, -0.4840117246529505, -0.4735483160272196, -0.028435026059636263, -0.034477268057287305, -0.5297121515110125, -0.4063436922726367, -0.15105967225574926, -0.13326565935164364, -0.2946598707639507, -0.3344062662346856, -0.5379881360534797, -0.7019459748355529, -0.34787630821905224, 0.016382273216614958},
    {0.26504504999988593, 0.2861887091797553, 0.6172388622600368, -0.7453734624238587, 0.15319644755747172, 0.13980077337694732, 0.027392431182185605, -0.46464057239172296, 0.0937070068883908, -0.5422570911376582, -0.35604034907540205, -0.3928535825773798, -0.3982290786117302, -0.5992291061004685, -0.46941482422069636, -0.5560027987436489, -0.46577221339764585, -0.4902267148973684, 0.20392126166556687, -0.4724528297197431, -0.4242292159438156, -0.47193154196061277, -0.022297361644615918, -0.5810257089683869, 0.23811423639026508, 0.15086788911198604, -0.7801941131657091, -0.23461032667817694, -0.6396482053086353, -0.10018918750479648, -0.3231005611658721, -0.3627391997716544, -0.12245368973522142, -0.6538679178072789, 0.36919439383701713, 0.44711996846216795, -0.17884396228695107, -0.6578575361755905, -0.42007269562389515, -0.568964161046295, -0.4262868206271927, -0.4119780306246308, -0.5083044916112036, -0.6985706980087185, -0.35157592136721644, -0.5855702405573002, -0.4666632282113813, -0.31451514771204137, -0.301639657074263, 0.4490881379647822, -0.5048784947611017, -0.6083648748663459, 0.061220468933648485, -0.179781997601712, -0.23813073124812045, -0.29285139226586093, -0.3642551951686153, -0.5519842633164618, -0.4949020755671775, -0.6268312458891416, -0.5108406207310422, -0.6108661143936878, -0.4342823200565072, 0.14235286022529348},
    {0.3231044324621623, 0.2645552749160227, 0.7138054170511865, -0.3803440749321933, 0.16155285045141102, -0.26832328445633663, -0.35441011083742213, -0.606108547571019, -0.07159768961820348, -0.5875850582175238, -0.34540677677159576, -0.4053910861604155, -0.5843844194517138, -0.5668798218738534, -0.49011147992172616, -0.5844494488671012, -0.5139066401237902, -0.40985138347213046, 0.13791842532302317, -0.7041395200630147, -0.6010158504393422, -0.4075737481821425, -0.022909211317373127, -0.7876669325353367, 0.14715835763560997, 0.17757108401433733, -0.7524744595319324, -0.5283011862916175, -0.42230866068453815, -0.409524642862987, 0.115453938633902, -0.4102740176331345, -0.30557047908754503, -0.7549856301407782, -0.09633921516649, 0.8434672088816546, -0.34094836798097117, -0.6104502092084, -0.1642583992058725, -0.8561910040638323, -0.2781853075830434, -0.1422376073833051, -0.34814054393004296, -0.44736505395761694, -0.44136916530222914, -0.5610805765173971, -0.8036624003917137, -0.4577616704289572, -0.19439544318857618, 0.39129272838886925, -0.40066707905002263, -0.7139760396247985, 0.3398321661897947, 0.01997712606529179, -0.35706137946609273, -0.657381208964055, -0.3977391897989378, -0.2734335114727454, -0.3449475499192033, -0.6192943084745987, -0.506716917232608, -0.37371120726916646, -0.5264179988705426, 0.4653969093567653},
    {0.04326283587244556, 0.15902688048966243, 0.585391441678376, -0.5326149529119951, 0.011819722263991464, -0.19450007181842707, -0.17702656130192643, -0.5371567324578771, 0.01745116403422928, -0.7932309546765355, -0.46165886996437694, -0.08665275402850477, -0.27872128372174054, -0.6701235741134433, -0.5158068121577785, -0.5569659789882285, -0.6538786471885777, -0.613418428782256, 0.4264670215482999, -0.37172769265667605, -0.5190284254521476, -0.6655294823881783, -0.04421687920123992, -0.7406425126352261, 0.05927937964248681, -0.14632727209350463, -0.430605805783827, -0.33834421496539224, -0.4036232860140181, -0.4381403851920884, -0.21597802365422505, -0.3790089974661266, -0.2162680359053939, -0.6490824846056139, 0.21337653246470029, 0.593678216156521, -0.4317234974554555, -0.6316702852228144, -0.16486605929126924, -0.5699743407054213, -0.018564692808270205, -0.47392665453240834, -0.6255171468159372, -0.6253857629960063, -0.5210367664462822, -0.681549334017551, -0.5726174849265414, -0.2155728636918245, -0.31741432772221684, 0.2532279551038111, -0.6927552687906667, -0.3717914747000714, 0.3854297110857869, 0.19866189175640447, -0.49619339051390293, -0.5667255112636296, -0.3977016988100067, -0.3725243084966829, -0.1473506607917761, -0.5109070113890297, -0.5140869628676206, -0.3042663450040962, -0.4724645784374665, 0.3854203263685585},
    {-0.06880034077439785, 0.06698076448277303, 0.3516190687166478, -0.38153269723578187, 0.3269439630957888, -0.09103616813284605, 0.20228518182132138, -0.1909039555424165, 0.10958884328499909, -0.5848462754528441, -0.44750537146107766, -0.21667638552510862, -0.3568767163333215, -0.6529096096524953, -0.27008622518208536, -0.8473531858847014, -0.6426299121504206, -0.4700735738050887, 0.24598910732175067, -0.6613728169970986, -0.7111251250318579, -0.32023316292596204, 0.22996592301473787, -0.8428012667632775, 0.1076089096008759, -0.06580979813397485, -0.6368137534070639, -0.32936034907070016, -0.4473302243467912, -0.09657276689428604, 0.06490491888584644, -0.18872062158623396, -0.1056829271390092, -0.6176358142561572, 0.49165211519272045, 0.422598543529685, -0.2792161826081156, -0.4832821397062739, -0.29414422301677456, -0.7477363751911099, -0.27447728585146836, -0.5376402246748544, -0.5484644983025988, -0.5719593047218778, -0.31209278326553574, -0.5219310879291568, -0.6547328057799184, 0.041236619905515366, -0.045465603874651525, 0.3898015781989054, -0.6521871379434868, -0.4341383124342716, 0.2360795241163711, 0.1878082193069588, -0.6697878423557153, -0.3706905723644639, -0.14581454133654034, -0.32877231256595074, -0.11981334049330171, -0.5756627971022339, -0.4459161140758584, -0.6941968331262487, -0.6007254040482815, 0.13932771719282583},
    {0.21071873640295732, 0.3959664149132425, 0.3643361837250848, -0.6413648581670043, 0.20188259344802253, 0.082069381216029, -0.08862977930750075, -0.3236807409163542, -0.08305852498928792, -0.461426922235756, -0.3169653174755096, 0.18498634478011164, -0.3881918143861259, -0.5749458470828515, -0.2100114293509007, -0.46265084739083007, -0.693494504231436, -0.46318936549479334, 0.5679228205410782, -0.4776310794213929, -0.6314060431663758, -0.45651892839679636, 0.16453828703910361, -0.3748292110545085, -0.2984532814223278, -0.11825198035475518, -0.5801608185222695, -0.08229545157272528, -0.3593405280906431, -0.3630344748776681, 0.4243928653402849, -0.03485506331220405, -0.20805041391909307, -0.33544625654980326, 0.003969645992335066, 0.5255677482062397, -0.34657776551356045, -0.3018727109516412, 0.18046292254430427, -0.49043543598287975, 0.058603930565597324, -0.4008116113353293, -0.41067023045961604, -0.5244728071517645, -0.4496867897959644, -0.683442415483813, -0.8563744604294933, -0.2857337631814738, -0.14902685385789013, 0.2993942264431601, -0.2017245645982401, -0.5867660234101116, -0.11583373318944591, 0.3643926222158976, -0.19839959365571008, -0.170093818274688, -0.3248528604884376, 0.067643584094923, -0.15289197434284116, -0.39719228673419865, -0.3787958837442415, -0.62110440554962, -0.35825613129226824, 0.4810413470290401},
    {0.07007840656011993, 0.11797354708744888, -0.25297965972323466, 0.016904420398119346, -0.13844240758440568, 0.28259897902517606, 0.18132367971491714, 0.27188861832388805, 0.26126442469514977, 0.04159617931316861, 0.380918106764845, 0.2731180213005114, 0.3616294159174524, 0.3134450496541893, 0.2621794043959546, 0.10831981379756946, -0.032545907239857064, -0.09502026560795343, 0.09418762954672846, 0.06980533603788501, -0.3415484004293723, -0.09095824877351427, 0.18384757576631178, -0.11233464080504245, 0.1034929425402494, -0.37945252248892725, 0.04133704689203241, -0.0029104705297298035, 0.39855243420345116, -0.4216710343787412, 0.13012040792366214, -0.39270200954095863, 0.13626748046460493, 0.24046365955526597, -0.5140973530781662, -0.36608776116020325, 0.6471421270242893, 0.21841934446454578, 0.29777980848043967, 0.2820304770643499, -0.2071172056825735, 0.23983671180184812, -0.05452664881175603, 0.42390171560805884, -0.08450556687466766, 0.23431446515022417, -0.060651633724827285, -0.2153186205924804, -0.2755164206911488, -0.039894335465906296, 0.29338364761906743, -0.2424666316298569, 0.433323476096896, -0.026410345245675627, 0.2141440124408331, 0.12457936856634728, -0.5614775634472348, 0.24545740955563922, 0.38398249027006787, 0.18679463473182895, -0.6664920660551564, 0.15526110524587555, 0.17333910502211847, -0.16427033626545087},
    {0.005665087303027787, 0.4938527512693968, -0.12304479057564642, 0.3055258942233911, -0.1347221667393382, -0.04538138574742459, 0.28168976993303213, 0.21130039922512175, 0.17393221609399417, 0.34991861067380375, -0.19593337802498514, 0.7575843705964441, 0.5980683607190758, 0.6796769837240543, 0.39112824254785206, 0.15615573236197205, 0.19924787150081041, 0.10139154432790203, -0.46756309622680003, 0.28231420729794054, -0.10278330178299386, 0.6093474776746391, 0.434114153530649, 0.3190161893490668, 0.33816562615381335, -0.2794719486735474, 0.4371244572812596, 0.2876885164650755, 0.582213620166118, -0.5498616866359354, -0.19924697267833352, -0.6817254204493735, -0.09342413836248632, 0.32559603591259967, 0.010787042725951261, 0.08841356461567809, 0.6520416624780292, 0.4080583554242348, 0.07818676738412383, 0.09346193890713, -0.5007892053788179, 0.4284805595199792, -0.4805676180271734, 0.42736377116003504, -0.4033386752428842, -0.058508331435720644, -0.4018226554481491, -0.16411582298287034, -0.24445441262482995, 0.28418223244664176, 0.21916157516182586, -0.5249893204551449, 0.6577331395636258, -0.21851068223841386, 0.5009405956050184, 0.5294777924314102, -0.03300694382722005, 0.17574156700724244, 0.4038999812961689, 0.0017298788315144138, -0.6483140888445698, 0.2709500788087533, 0.38445226613922673, -0.3500018607743481},
    {-0.16270921570111865, 0.46604679477887867, -0.4039552657542778, 0.5961282646256152, -0.1882715434636079, 0.05008536952066796, 0.5206348203024983, 0.017553399251006234, 0.14599798274694528, 0.2661906982043761, 0.012686147390707099, 0.5440386907492138, 0.6431704484583121, 0.4347383819205169, 0.31906086856357535, -0.10643422864025791, 0.01316113290516171, 0.19424021483100815, -0.18347026230833205, 0.13172960698070357, -0.3293341632592351, 0.6783393384925394, 0.2613518094688974, -0.009139739537095234, 0.602555814688906, -0.5956801276743116, 0.10163666547608056, -0.06216094310306058, 0.5930533968513759, -0.16841261896580442, -0.06632936938081034, -0.5093365172727742, -0.3235998340811833, 0.08032828226293148, 0.1085790973979658, -0.19217248103514326, 0.7735856559388021, 0.4284972809039088, 0.603152494836546, -0.08176379371876322, -0.7224574439777249, 0.5520691002568378, -0.41156784274047536, 0.34391220428537495, -0.5939622942684187, -0.12926669913286554, -0.5160419039628652, -0.26397448803350976, -0.42161404109355494, 0.301546141783484, 0.4159813954673154, -0.30938812961648304, 0.503154662632052, -0.4932524984338058, 0.41188683206473775, 0.1639009978092282, -0.4266901002067348, -0.007439028247316809, 0.6662885517226794, -0.17692524250336053, -0.4415214883196056, 0.28379577993329513, 0.4855085003724367, -0.4482001563775928},
    {-0.23047683838633082, 0.6691835452276992, -0.32726801878496, 0.24650603288505657, -0.10209150817519927, 0.03448378378814269, 0.7587407328333229, -0.03598019213773925, 0.2440660398648009, 0.37154829367336434, 0.03064645552074685, 0.449999572430393, 0.43108411592914386, 0.579161232746547, 0.6102226686870855, 0.1025103273845952, -0.028054402465795256, 0.15008372654752206, -0.38156115467287344, 0.3770097375583877, -0.14911414120852773, 0.45267405113356235, 0.5638804894752121, 0.31443475006052224, 0.35864717765615406, -0.5466537856597968, 0.14101930534155976, 0.04801805103148033, 0.421422566705795, -0.41248657057155025, 0.44719825215175696, -0.6944118237475677, 0.11746438003987127, 0.39221947021005044, 0.12097020628818543, -0.3714337400298764, 0.3754038621729498, 0.25564224407810365, 0.4702822419146294, -0.17926278230464576, -0.6120430485433717, 0.21477016415807987, -0.4262834279246262, 0.26037490203468266, -0.43386122829433604, 0.2071215189151399, -0.25423843027081483, -0.42644706114619857, -0.4917170629086011, -0.017904739882794566, 0.5761272519731302, -0.148716117462658, 0.42990774087296346, -0.5773131686700663, 0.5672968491441817, -0.0035107404644105548, -0.13194359469585745, 0.03137909133752261, 0.45486471348413793, -0.0034680042633567676, -0.4937181773558408, 0.23967247820421225, 0.7347873451138455, -0.11226280095631806},
    {-0.10000179278638112, 0.38932310844790036, -0.20672920801561584, 0.13235655255063006, -0.11341836159096208, 0.19804524881680605, 0.388249410105274, 0.5646143143265199, 0.2239924852605093, 0.5836330706099544, -0.27683179741082675, 0.5928539409545722, 0.3592804598220099, 0.4386612235358884, 0.3731977593006958, -0.15920728658338903, -0.04671967134882647, 0.07814567333701372, -0.39998782769829, 0.5286583494067175, -0.08404812524590528, 0.7621650156990969, 0.3207980030938798, 0.263436115240523, 0.42569967983931073, -0.5624256245786733, 0.3483367760069116, 0.42241113111356793, 0.4602047973963086, -0.4594805233901279, 0.27461468762998437, -0.3498368281855946, 0.03929614030208733, -0.0170107681575086, 0.038167996467368424, -0.14028514575948425, 0.5098614062622957, 0.5283164982567401, 0.6038963324921202, -0.09106633382470557, -0.8151405251228337, 0.5789345898988016, -0.1303340936184256, 0.4903062613480762, -0.2658336573014078, 0.3193977133908981, -0.6141001387548042, -0.2972352791740212, -0.4113314034233483, 0.0773365715276141, 0.5894156679924072, -0.15683071818824368, 0.6196397389733516, -0.367898994650753, 0.5390120008955557, 0.03382055843430522, -0.525870659311726, 0.27936991644841774, 0.28562995711426925, 0.44632012615603894, -0.33730950271432836, 0.46365564760224265, 0.4165935562592085, -0.7071847724189971},
    {-0.3143538922138456, 0.20477022018160745, -0.1745337969346011, 0.15379305724245468, -0.17175540835578496, 0.20043076483793362, 0.344913119463572, 0.26143394742300735, 0.41750792677888326, 0.22034229839902159, -0.07806073668993055, 0.44431036037795113, 0.33489051447799423, 0.1798462593974698, 0.5340172804160795, -0.07878064618529242, -0.03526302135592345, -0.5249159260060368, -0.14113432451073615, 0.2412288060717055, -0.3399933202108426, 0.4703520289317932, 0.3352710123366989, 0.2216986485608966, 0.3532257468317769, -0.40029068488570724, 0.21317873434599513, 0.35926671448708675, 0.4748308588890965, -0.6105967791246097, 0.47840826976554174, -0.40720597235280603, -0.09137218488900066, -0.04544732383064751, -0.1308060551290446, -0.11292470717919326, 0.8762042987237153, 0.1961645522740997, 0.5523360758366106, -0.08858263613601898, -0.430846664222265, 0.45814312785693767, -0.47979018027742404, 0.3313149700797285, -0.21342351288687605, 0.16460127236441033, -0.2586973363900067, -0.1254808824238986, -0.5591834909448206, 0.0630504175605004, 0.03173464079918409, -0.33931958965816883, 0.3042655115251721, -0.4748765558310314, 0.38335521657481675, 0.1291698437992879, -0.4929162667833667, -0.0004280768461250861, 0.42134045589066094, 0.26833681971534284, -0.5848470020795336, 0.31054871727432826, 0.17790446465597018, -0.16858535460250967},
    {-0.5056860309132907, 0.43481957844835245, -0.2658937813332632, 0.2000903196432822, 0.07536782941551268, -0.037281189203660636, 0.2769193363210189, 0.42787308734156426, 0.2675857995542786, 0.25509954512445815, 0.0430267928837778, 0.49669033528781775, 0.4079568863714408, 0.07171853161962106, 0.5819007335943389, -0.0989147319775127, 0.15755621691586424, 0.11529890218498678, -0.3284754018534237, 0.23924618721838464, -0.3876644142707197, 0.543893937872067, 0.41065394036651076, 0.4505540502693015, 0.2178572315174661, -0.8024346291531145, 0.02540053104340505, 0.297508870374278, 0.39277856563676716, -0.6218869093335058, 0.3818836859265673, -0.6216428456159151, -0.12030684465024262, 0.1936446210185609, -0.16729125854229013, -0.20578180028882492, 0.5592690756617397, 0.5223608345351556, 0.2050095457311378, 0.005321618149524261, -0.5721091993956584, 0.2104901157663598, -0.48322369118442154, 0.16073184802075877, -0.5310586690410933, -0.15383621073804582, -0.46137037581116924, -0.3653270294673459, -0.5890128079012653, 0.33843510721451464, 0.36159759221153076, 0.06486407088913256, 0.3576703845176708, -0.32852735981914655, 0.44580948843040696, 0.3259138349706499, -0.40713841047021243, -0.0319659136836808, 0.5380149220294167, -0.01635152221981042, -0.5520542462758791, 0.31708306974386646, 0.4269681479357882, -0.33541197316293625},
    {-0.4814734131009386, 0.44103000887905625, -0.476507492441337, 0.2677417351033226, -0.2871411441144235, 0.4803108895625805, 0.7208161842103498, 0.2549687107811755, 0.6580067195835022, 0.2600658676538083, 0.12198326083599921, 0.5186540443973581, 0.7597475602938265, 0.5015640853722024, 0.36369904097467054, 0.1061727282387458, 0.07031172044197932, -0.02404430546473435, -0.2566482613275832, 0.49495890232502565, -0.06046209146084926, 0.6229525950659026, 0.30252267273100475, 0.37506436069270366, 0.2128168603354817, -0.5226865642298508, 0.022878110057674025, 0.2201589523710002, 0.45967782350284014, -0.3054700622506375, 0.1381505958285284, -0.5795306359261067, -0.025417699147759647, 0.5144738299425629, -0.013396748659180295, 0.003069641283871473, 0.5417300464556982, 0.4872889652687908, 0.44099982946716776, 0.10381317229414222, -0.7083191506199416, 0.7174151368777191, -0.588949582475373, 0.6076956955832902, -0.242490586680788, -0.22429853186385892, -0.26973345809674215, -0.5148909923970902, -0.5342664068604539, 0.15013743422453238, 0.2915898917972621, -0.4664727088603336, 0.3438833917515659, -0.2993036234927309, 0.04634227400070951, 0.5345417481942897, -0.3430304806489388, 0.19375202589190907, 0.6606887175903796, 0.28661286871657393, -0.7493324060123633, 0.3173649225578987, 0.5032464699723658, -0.6033486182900993},
    {-0.34276144358339633, 0.18401637905125773, -0.5314950621777669, 0.02031731716599709, -0.337951605421041, 0.31591001912466454, 0.5398845365630834, 0.17815223900123786, 0.5166604439962796, 0.5915721209773943, 0.42856429665702067, 0.49945521403525533, 0.4962214579321958, 0.71965210679741, 0.7557392807292745, -0.14241700898588877, 0.14873166386824235, 0.017235358761452706, 0.21138940962358607, 0.6947513272319011, 0.042045636953752026, 0.719955611887087, 0.3213014796429234, 0.17712960311624945, -0.09919800398100108, -0.789562012863719, -0.15053060736982338, 0.23268429932001528, 0.4670490621742637, -0.5565970774769933, 0.12879360078388222, -0.5879924891698268, 0.051548157886241355, 0.13555346321385778, 0.055440832360330004, -0.31345216585428876, 0.454089556577714, 0.5444117309706034, 0.4217910441208207, -0.29158347151812297, -0.7604785434145686, 0.37387069340408463, -0.5723757682119074, 0.11545662441195127, -0.2912937209831784, -0.10105691597098568, -0.2855731598752843, -0.2462024267346836, -0.5008788570827986, 0.41560018393192133, 0.36599559755745603, -0.3688897827871579, 0.6179659921135372, -0.5624434611987938, 0.2764268767706423, 0.5274029417572655, -0.36413649274460563, 0.25144262346268276, 0.7055425191205583, 0.11556474389505861, -0.32751738424844984, 0.35628814962183414, 0.5077424992475984, -0.314139274532951},
    {-0.32501782378000915, 0.4380994558132115, -0.3097222583178764, 0.24791285769980492, -0.0033062634058410255, 0.634731948901113, 0.29956608406814506, 0.4006708886405761, 0.6283024205627395, 0.29687267570371934, -0.030985659479301285, 0.3317182426854378, 0.7347075826119674, 0.5344470255565678, 0.5217920259755972, 0.3938345961808962, -0.27456940543934355, 0.24166355156463043, 0.11718756327037234, 0.5150361830362374, -0.32556867237952664, 0.5042807524591408, 0.5751164920206716, 0.13137130484484238, -0.19471666536918023, -0.7675109974685685, 0.022681680659467136, 0.16016123707014118, 0.8397883898043662, -0.24202198958163498, 0.08211671974118762, -0.6217782948630038, 0.16627421627728656, 0.12387966074047092, 0.08761152416226566, -0.23809421529722313, 0.8135481221204254, 0.5547719347459855, 0.46117070313185926, 0.12045794098156201, -0.4367034588375369, 0.7779448036991001, -0.18618503703149036, 0.24135369242982468, -0.7002677312613651, 0.008878461267644364, -0.029570916661814488, -0.4813272133248317, -0.38799630050642214, 0.13570176633685696, 0.6013007945696507, -0.03789253156479081, 0.4084160377032715, -0.3194214383157905, 0.30134729271974336, 0.22968345023349407, -0.5710263122135087, 0.22093386739152668, 0.3976520928916384, 0.1736740462185543, -0.583958458813081, 0.33337264002913614, 0.26993227554452176, -0.30215229694380735},
    {-0.3639433595374751, 0.31632385054271606, -0.21169804594305242, 0.16059698705566458, -0.06550022540485206, 0.5522053829527434, 0.3162960083224647, 0.6386657870827628, 0.2676043792113059, 0.3423660187400529, -0.03425204110267305, 0.5486274196823447, 0.4421834805685949, 0.3624180956725492, 0.160768663131224, 0.1067916540674178, -0.1566150339971852, 0.20329362882035068, -0.11334664694275752, 0.37325844081464193, 0.02121997792708452, 0.5624625666395633, 0.08240947859765384, 0.3782398972407712, -0.05223075322657495, -0.49290060589646717, 0.13780189124048953, 0.5692785212142619, 0.10608112084188155, -0.392831972463495, 0.12925100730225259, -0.6814111767374899, 0.10224733124003489, 0.25922730107933967, -0.2073888542658465, -0.30411540588107544, 0.5566164070083541, 0.19893026311879644, 0.36585001396645017, 0.3037492171949622, -0.5574806972147052, 0.9580757804245361, -0.37082613438004997, 0.49641250984251223, -0.21140441454645043, 0.17324068131107742, -0.16753363563057336, -0.6256884233461084, -0.35027837923379246, 0.3093663836183922, 0.5656365437514435, -0.1561455687645295, 0.2860765999348591, -0.3402903080356385, 0.4592314000834503, 0.31561183227701256, -0.4073246916474321, 0.24108235075435494, 0.6522056468776498, 0.06504052827998566, -0.572355886072201, 0.4091514296224392, 0.4177702700342607, -0.26549254279674567},
    {-0.5200166071074862, 0.5939719124300953, -0.08137223651840154, 0.42456344854536915, -0.3102272114911558, 0.40183020596164604, 0.4762614525572924, 0.5162334865155143, 0.34949361150105523, 0.38887161512303187, -0.21443017658257138, 0.4558880103419573, 0.6088357187892164, 0.5743513951949968, 0.5369141777392739, 0.07639715772545777, 0.050605125904970454, 0.2230340218850825, -0.13716163883590204, 0.22645178085040704, -0.02709266586612938, 0.6291944421889373, 0.23682490375217097, -0.046078376433112654, 0.11349376195777641, -0.7788252241531015, 0.3157598997841568, 0.20456231752026496, 0.41029685606805805, -0.3482354085207231, 0.26146215109247317, -0.5176886245012036, -0.01107316923629338, 0.5753911689415776, -0.39443879644252483, -0.3151694791983101, 0.5775752824203132, 0.2807229294281601, 0.35687964943115585, 0.07025956861649851, -0.655132950236784, 0.5743852795042675, -0.2608215664485686, 0.33611190843495997, -0.39048970895650525, -0.38550606554770867, -0.1647636295844219, -0.40701679632452537, -0.3187725160159956, 8.690629404429365e-05, 0.5350604584421027, -0.13738492024397392, 0.49991109424432006, -0.2852248908947044, 0.6714539722778539, 0.6674720183084413, -0.373715679054174, 0.09290318141944898, 0.5565695231175454, 0.0964519513961819, -0.47039619147465034, 0.4150860695381495, 0.465684966388437, -0.5388534014692962},
    {-0.4973917689435807, 0.2948865115989206, -0.37651860852097335, 0.39046760158720745, 0.12423437267589925, 0.08814849035354995, 0.32883099952001577, 0.41578046143402136, 0.5362766445811302, 0.015487113746187154, -0.09003602590312738, 0.5927699457956379, 0.42264734904009055, 0.14991563437001423, 0.675434023730273, 0.12598486305902176, -0.030889292537995182, 0.21355171869504008, -0.2600041099926133, 0.5184167023177252, -0.16568841925781108, 0.6732297875323714, 0.3716554033792508, 0.3303894405090748, 0.5212290217128003, -0.6743895803856298, 0.010603358396138232, 0.13192497418958382, 0.36416076424779986, -0.46391895772655667, 0.3414494693703725, -0.6416611262141422, 0.06699750291935863, 0.5800090287182046, 0.0354087097151517, -0.15233854977842923, 0.32565483051583327, 0.46458378699461533, 0.22513906519814764, -0.35240188659928323, -0.5213993975473921, 0.6253548269812438, -0.6970780376510926, 0.3521537529496546, -0.5374992356057539, -0.586508347898337, -0.34040309207727076, -0.46089543324021304, -0.22274128285209618, 0.2817028142841002, 0.43337957427512597, -0.20968016253457047, 0.42395433167404184, -0.26738482436247785, 0.4268102977198455, 0.8433634700705693, -0.6250416032863586, -0.16307474589684565, 0.42478152890608306, -0.17626368138315207, -0.5218344475574793, 0.19550245826734192, 0.5544956146116342, -0.3676290162518191},
    {-0.5077486359630213, 0.32517593876197376, -0.1321580059296362, -0.15663426342349485, -0.050441748849377056, 0.5234849794087131, 0.4453690513186461, 0.5179475658752223, 0.22926509679220086, 0.10833174570071859, 0.04910718466321462, 0.693408804102936, 0.5055504052165365, 0.6923956700377778, 0.6253898787433053, 0.10184326324060605, -0.18511845244348887, 0.2239587759566178, 0.16666155395850765, 0.2870042933858625, -0.3766332709655481, 0.5997252002821546, 0.08745564921615825, 0.3637077269868683, 0.267243674400469, -0.8423855454132829, 0.07700944369140406, 0.18407458861597614, 0.5948082622812074, -0.2814008029151122, 0.523391160600112, -0.587886128402782, -0.22318810099435382, 0.5603368890279705, 0.2283062263597227, -0.022612879184482362, 0.5964245573470786, 0.5051012464536326, 0.35327337010366977, 0.12351700517410598, -0.7035239769839939, 0.4240695584902618, -0.6538162718791027, 0.2787174745970988, -0.40989745930250443, -0.21849045618062682, -0.34186146177763566, -0.4366151899515084, -0.45836629776423055, 0.3868276756230332, 0.45576286123014975, -0.3004941205813414, 0.3005153456098885, -0.6760700845017427, 0.35973984810819903, 0.31000071597852624, -0.45544923585873587, 0.29413722285223415, 0.6089183843442153, -0.2541267983471257, -0.8569377358545547, -0.15796530274101495, 0.5687625651004158, -0.21987566080725876},
    {-0.2908682043417707, 0.34291339495360973, -0.2029653617203361, -0.15624961364603254, -0.08631316654884245, -0.05246027415323045, 0.3943290442605743, 0.25154462117846177, 0.711887187408531, 0.42876952535251794, -0.062143817702155206, 0.7019003921751455, 0.44061653982606497, 0.20258495982685634, 0.4511451672078084, 0.18194108579163876, -0.18129833449038432, 0.26040381490480735, -0.18063613815484578, 0.079877957002854, -0.06302160060243478, 0.7332369150005451, 0.15054888360197866, 0.24695669074895268, 0.08684282887433467, -0.687807053735435, -0.48435363345118854, 0.49971658533902125, 0.41088115707112605, -0.564504690238468, -0.023337534120602924, -0.585715949857474, 0.021362618821905533, 0.42158176267973885, 0.10730565155028653, -0.07598234422128486, 0.5687591236192748, 0.3167585554585748, 0.7499365822804163, 0.08067544146092606, -0.4733035720488106, 0.2802897309478814, -0.39338176996815927, 0.6078213755234892, -0.687792356787402, 0.2224273804427893, -0.6249360211315413, -0.35480760016646173, -0.4696676177646603, 0.20012468588816415, 0.4415858498113625, -0.3884523788622872, 0.7247623566946214, -0.5435416965971898, 0.3643037565027636, 0.5823490371203763, -0.4926076060231268, 0.33211589921502255, 0.37308772327250916, -0.11921570774179135, -0.6993611268653337, 0.3894117462960321, 0.6878179757985384, -0.22833963264428736},
    {-0.264111390179511, 0.15280620807960535, -0.2923455195272242, -0.09085691730197334, 0.09872792191350573, -0.031477356889742375, 0.26238907294415653, 0.3493791838016335, 0.7364118342018464, 0.4426839418485883, 0.1332381221439188, 0.5476141184835615, 0.3577503306249762, -0.07561267600534934, 0.3634343003843915, -0.15262184494536957, -0.32812318209274904, 0.26184147563575844, -0.14167202103474785, 0.272543341065847, -0.43150013021047, 0.5516499677481096, 0.24445963692085595, -0.09820241927532558, 0.2590191870344731, -0.8813388784472358, 0.017711415064810568, 0.4539802973370615, 0.16430981339640044, -0.6971840447466034, 0.058554567052382205, -0.6303187859044849, 0.14389171226921643, 0.2882750400703292, -0.0037595503408158547, -0.25666222849694226, 0.3427868259844569, 0.42183772332072567, 0.3856594058020253, -0.11737696560204063, -0.5551892264990599, 0.5845436058785202, -0.4483061174608548, 0.4185164876013888, -0.27215614240210256, -0.13084425643584963, -0.3352217269998576, -0.34844591292063504, -0.4290982374740112, 0.049128297894900246, 0.477550256318765, -0.3565876333791276, 0.5592000538495266, -0.11041524183682702, 0.31319352677495016, 0.5856179027815398, -0.5230922889304461, -0.0657251421292988, 0.19790561415785674, 0.06687965035982714, -0.47603693530377483, 0.3930535379984552, 0.43492360694170484, -0.7405967392336834},
    {-0.3334511194230474, 0.17530701515009262, -0.12914026320028307, 0.2712896096930461, -0.07762709969696883, 0.0772202998050257, 0.4314472778241513, 0.4895537375016829, 0.5498046168041207, 0.6331626550095093, 0.264640375061488, 0.6446967924671277, 0.5403561799081649, 0.16933214721072679, 0.30206535859026196, 0.19521590666559224, -0.40922955788372684, 0.09471044902141089, -0.28407955359049064, 0.4814665409940038, -0.0179641238220588, 0.4611518055199872, 0.13452137246838694, 0.014469476036872764, 0.06630422043354076, -0.7149181269964857, 0.17219266277719977, 0.24371622845995944, 0.5030218823688345, -0.722604269954073, 0.33139765677375776, -0.6460120728572969, 0.02360786237112876, 0.03511489183445738, 0.25127175846434785, -0.35613332271549825, 0.6056450144596823, 0.6836310023543221, 0.4613477060642065, -0.07036081314578779, -0.8729009926869212, 0.6255492702661687, -0.4810979000381663, 0.7867477511294436, -0.34403368873048507, -0.16576267877961462, -0.5639750355027277, -0.2758710521357939, -0.5025328114152655, -0.026325155312549208, 0.300357602209904, -0.38422466699131647, 0.5130672119556463, -0.31450040703386084, 0.46274706845632607, 0.6132457662968721, -0.3450926327975509, 0.3766450203671392, 0.3255822353500765, 0.08430453511980619, -0.1398468417472407, 0.4118154732157734, 0.494640665183562, -0.3006563619167895},
    {-0.2305141363590055, 0.5209177156582698, -0.2953682682193647, 0.190163387376156, 0.15079776144166473, 0.09629076952157929, 0.6724462077990709, -0.025634308413677337, 0.28787297998693295, 0.33478384985172566, 0.024663197884045973, 0.30721839834941816, 0.7207888800638642, 0.3842089509713782, 0.17488250052605678, -0.009447630027309953, -0.3456108445008385, 0.13148104255792817, -0.09663615422782723, 0.355742070143505, -0.07864036115000828, 0.23425366829718283, 0.09000132750848246, 0.015508230164498404, 0.13108745609710282, -0.7765230005301053, 0.1056630910522217, 0.17515489731910072, 0.4498550849161879, -0.6445833111933565, 0.13209282196667194, -0.838701841021035, 0.3362003666335389, -0.2289094452177055, 0.0011257603673480337, -0.3295091102514653, 0.5240007797780482, 0.79807622879001, 0.4464390219417676, 0.0750197841611567, -0.512280538161159, 0.5429592607086147, -0.45571627474198545, 0.29301145148944857, -0.7563507553522032, -0.050116168655474656, -0.6323633404067454, -0.06692574685101546, -0.2798906252406527, -0.23917515597607186, 0.5409573106099076, -0.08515237419296666, 0.6184346499271729, -0.10178550465066662, 0.34836288257641546, 0.28009032981732757, -0.03699214652587742, 0.22307130940056502, 0.6676451855415173, -0.16658669419680247, -0.42561621804450156, 0.48787643746880044, 0.8917438801484089, -0.3046071920071696},
    {-0.41402029263142226, 0.5922521618476526, -0.24397222507490463, 0.2890695923239235, 0.24940599267469304, -0.04336004094251968, 0.6231212843563486, 0.30944363315731804, 0.3487772071069631, 0.4011173020073776, 0.3779724510736897, 0.32049204275150883, 0.6899581862459393, 0.7176876072266112, 0.3500128393834656, -0.10322246717792317, -0.15984793029489827, 0.33475649585285616, -0.11341842945972624, 0.1635548802365849, -0.29087366789717795, 0.3391893654101584, 0.35937721192995664, -0.05158415823125668, 0.23005496311655588, -0.6726758735573921, -0.22309542209416902, 0.2469704074560916, 0.22514477472335265, -0.6383856728189796, 0.311261732146811, -0.5118985834203233, 0.08113855184451188, -0.04860247977218249, 0.1350758530933323, -0.13175318852307621, 0.926115253035449, 0.5169693171799836, 0.4535292324573345, -0.11154380471189163, -0.6285314019536955, 0.5071595362673668, -0.4237923469085418, 0.44244006422290155, -0.710393800300905, 0.04545961357768584, -0.5124267537895667, -0.3021393636047082, -0.4443238351473378, 0.1172695806051055, 0.6587068440036282, -0.4456193666619795, 0.5178439516014217, -0.47216299115132293, 0.5907676316929168, 0.5692252545693302, -0.5627394813085294, -0.07560428652043871, 0.6338679279647762, -0.3150110700749514, -0.5272932361800824, 0.2358232550695559, 0.604462099970469, -0.0019678609999309224},
    {-0.2688106433823292, 0.34005200906540206, -0.4991500791914879, 0.6091261359395556, -0.0375660938183062, 0.034918045141391095, 0.6488139302259359, 0.5779915314363671, 0.22852925589396567, 0.5195480119354864, -0.18016460534994086, 0.3862101930798581, 0.5703815195253151, 0.3988678726678093, 0.6360151841629219, -0.0656359356501927, -0.23631976213234607, 0.12199505027565166, -0.2929740664977623, 0.5857283312238551, -0.2661314357371154, 0.6050755093707405, 0.3484519823376766, 0.1559431780430877, 0.034722648724131784, -0.8409885033097175, -0.3458477460923972, 0.0522135345963054, 0.0773381042473802, -0.628032366404178, 0.43525645774766325, -0.6064252097002297, 0.01725170593798542, 0.6506799460525242, -0.10480629257345361, -0.22107177974757558, 0.39171093282559033, 0.7499992723833252, 0.6062664172149334, 0.40139848989878263, -0.7884918094303273, 0.9974487547675819, -0.5761617629160224, 0.5567600794048656, -0.46057839916415544, 0.15737911680505332, -0.43565887706926293, -0.566371142925023, -0.3837848062303468, 0.2156814382675891, 0.4588264036134901, -0.3957052639554931, 0.42642678172474396, -0.6251354444333463, 0.33652189241145125, 0.2991072850657747, -0.4910506314277532, 0.22788726887671368, 0.4557886749516433, 0.07893409503213124, -0.7343200960407057, 0.37347033233203586, 0.6052445294641996, -0.3113190920322406},
    {-0.2888591522438434, 0.23457774441482082, -0.40244241334982445, 0.4322775512813672, -0.09132710573131243, 0.36302148981606197, 0.5171059042538796, 0.21128646454743996, 0.40124882316131444, 0.5932109202015948, -0.08354745361628622, 0.5312716703448839, 0.3037047016439668, 0.4900809781184461, 0.5400855921412232, 0.26882718940473344, -0.1332044771230569, 0.19060389006164938, -0.1531757117723071, 0.45448723059241214, -0.23310786842380563, 0.662274947382177, -0.07995637959855076, 0.25876259227915394, -0.09353546751148527, -0.5655628700463325, -0.0033149022078807974, 0.10396163858259559, 0.34713181461010734, -0.3888276636300277, 0.3451924952880855, -0.4051029108635443, 0.16879497722647907, 0.33674992074600274, 0.13858716865341442, -0.4070355543333529, 0.3152515757946499, 0.5551044133425564, 0.5727578946395153, 0.011478562803489521, -0.6233457347196805, 0.43237804313455985, -0.358937263867043, 0.5361188554356613, -0.6281869717017775, 0.05069719841479983, -0.26054973773230033, -0.5614795866028707, -0.43229037747536486, 0.07206154415452373, 0.6998080042986534, -0.3129976576932383, 0.4286294319706643, -0.3648023137201635, 0.29318396957649523, 0.3050969645675379, -0.3838472618317654, 0.16148659860982512, 0.3953104815144357, 0.11961323552037584, -0.49651885776247534, 0.33630930357536953, 0.52789317737152, -0.08175691952047086},
    {-0.49814928783411183, 0.3424902633513672, -0.23771792589313717, 0.23080305892177666, 0.06530719569203433, 0.10960179014103977, 0.6167871364003868, 0.4488168736828014, 0.8749589097162034, 0.42720008330821213, -0.09989269683669054, 0.47108315263679207, 0.5331846090225362, 0.16948067677894585, 0.5458086873584985, 0.2570193271396028, -0.22204573206448716, 0.30912672380411016, 0.03386807620201343, 0.4865353284427113, -0.06407838766271531, 0.5242846564505476, 0.14336489968311744, 0.12318117703249466, 0.32786412853458446, -0.3092994889480228, -0.0673597092924459, 0.26900638451547043, 0.5802742066229643, -0.4640341241024283, 0.41547005374680795, -0.5006847789752238, 0.09522394619969994, 0.02309223372935037, -0.20922431802251729, -0.3148676984977637, 0.5690928946668039, 0.5416551680289662, 0.5310593786955964, 0.34775334969952515, -0.6312802460770142, 0.42438301652557564, -0.625573894251126, 0.6765749127264057, -0.6132497819113477, -0.23590476098778937, -0.46442560546456885, -0.4046492078632965, -0.5099638795206621, 0.24390175560486083, 0.4305821396033765, -0.3331845200411516, 0.46135317130151915, -0.2984392861294993, 0.5731372886009553, 0.8842975174661363, -0.19260818971156618, 0.19398825323023564, 0.31692691068694206, 0.2664024338596305, -0.6138664709080124, 0.04959879490794967, 0.5608254464616921, -0.15040980996042733},
    {-0.41251070489001984, 0.2974743793190552, -0.24877967719574764, 0.09410670977849092, -0.03526630895915247, 0.29903665420280606, 0.6974035667315731, 0.38292207111188, 0.732261991670606, 0.5674165569873794, 0.12594608738427138, 0.22637922451216805, 0.5127805865487648, 0.6589480638968338, 0.7485110096992806, 0.42254021790769697, -0.3606831745372265, 0.434016328602088, -0.027118418170254413, 0.162515165993407, -0.2685439808741077, 0.4525199925172496, 0.14761425968382774, 0.0031863227476493713, 0.13832680450705603, -0.5918406272260861, -0.1293635924619642, 0.18484677837555993, 0.549864580384183, -0.3921611915003818, 0.37000743498485045, -0.8140360004845586, 0.27399119667427513, 0.12055270640657605, -0.3024428278239551, -0.1690944482368053, 0.6041736860729797, 0.7609959055404104, 0.6910032032523434, 0.2322445136435824, -0.6661342483022015, 0.6305883023781778, -0.5074070885068841, 0.4792729040954299, -0.7193248406579184, -0.154850268236078, -0.36745280994298124, -0.597345040396228, -0.40570720282304484, 0.17564585947676722, 0.3603519480111044, -0.6560538742748042, 0.31501399358137017, -0.12895332152432726, 0.5177875846761514, 0.5672199094935848, -0.48513729713534987, 0.4518263850608195, 0.5561073125083644, 0.13320746923644458, -0.7338292995034335, 0.5087998130109826, 0.6091212439828532, -0.06511600558377534},
    {-0.2702953615976692, 0.1628218042422166, -0.2789725207351709, 0.4361240965504378, 0.018925739657203143, 0.06777799518340029, 0.4631232932027882, 0.40355806291488944, 0.3376103290539505, 0.6660135374635519, 0.05449918131816892, 0.5230202246052519, 0.43750329594294557, 0.5530659105718347, 0.5376467190962847, 0.1652549433366834, -0.0073768921858119495, 0.31486133446749176, 0.016983044400056276, 0.17741965421121383, -0.11082747978460625, 0.4121045789269705, 0.02485697530248417, -0.26445733434117386, 0.23905918370951204, -0.7084622125571184, -0.1708750688974353, 0.1698496757699208, 0.5734848762624037, -0.4998040090231807, 0.23257203612331032, -0.5884301068704212, 0.05523576995482314, 0.21478593511763946, 0.07822645924274278, -0.42468181353566553, 0.5316236991143339, 0.6027137920397952, 0.5028212289209478, 0.021304719078004037, -0.7791595097135304, 0.5915246907648917, -0.25036858494871017, 0.3461879620821524, -0.7166952263805223, -0.4764999535272211, -0.5667617237815048, -0.24753475690117585, -0.4871280825777737, 0.08261339912500208, 0.4893465277348428, -0.3944623170517288, 0.1297425774045576, -0.3493176969605788, 0.019713041833797504, 0.5564652995314563, -0.42157294962269093, 0.15381437932117295, 0.4618796512611583, -0.2975983453762987, -0.7435726980030816, 0.3245767620865206, 0.5792843768663649, -0.2662319331350157},
    {-0.368396607246865, 0.5815011143421679, -0.18668913353187455, 0.06239969287729478, 0.07363601014933782, 0.15156979962544986, 0.3943809427741461, 0.18069694406183245, 0.1972550408002065, 0.1630252244094328, 0.09908837514576238, 0.46693280701150747, 0.6370206758096946, 0.6665347914887966, 0.27224478933110874, -0.09955270142154425, -0.08141341484872736, 0.38707711491075564, -0.10423510429793974, 0.28529039425882374, -0.3659605759783909, 0.5689355405531774, -0.07585332849802244, 0.3542922169550115, -0.012369898629255987, -0.6021106566015895, -0.1366768551362336, 0.1800425494043882, 0.5552767498694905, -0.49975813875387703, 0.18279960841314338, -0.5910341715563824, 0.2553294769411452, 0.48226772173522403, -0.2350534483174618, -0.11047429029196192, 0.2863894264264251, 0.6023494895722156, 0.7948807782204311, -0.09548662917857191, -0.6484962874576253, 0.7039377214722046, -0.695454938497811, 0.48152017474362324, -0.6058848636088499, -0.4401756018580147, -0.5230484290631557, -0.2931474627285556, -0.7440178043607056, 0.36393222714413026, 0.6331264164493134, -0.17887782712122877, 0.6577772185357305, -0.10492077546650246, 0.5080001143544683, 0.6813773185719693, -0.5008164494835582, 0.29593451219818456, 0.7129206181600113, 0.003942148725372875, -0.4567592223198063, 0.26261708311240656, 0.8471347409673442, -0.36780827655784676},
    {-0.25670971258336833, 0.5151964719658491, -0.2755362722135195, 0.31611703068845165, -0.14584012300075982, 0.127728976060004, 0.6594406255324621, 0.2680600634679807, 0.4923345652486477, 0.2853765994803212, -0.13211259440047776, 0.26323232777524525, 0.38445290059835163, 0.11507021575005809, 0.6193902644447709, -0.16118857047389343, 0.09590621765442653, 0.3487871756903912, -0.4878942739673304, 0.09218104244881269, -0.3655582015359643, 0.4768148552153072, 0.13265282661877473, -0.09340747859376007, 0.11560754244292144, -0.5537796837238411, -0.47861338851015, 0.2516937436984654, 0.5624239507789378, -0.8761976293608434, 0.352289608498845, -0.37561042400322103, 0.29008749553933233, 0.2125909242787755, -0.08764436601973163, -0.23819384914709552, 0.7597630013876833, 0.39937393768205665, 0.9235473324797913, 0.2744178634851717, -0.6008200573635293, 0.6651647576357874, -0.7126542125714886, 0.7522436465344432, -0.46890960928722253, -0.19816098329010806, -0.34133847104931386, -0.28030800435994946, -0.5987990680941563, 0.08057813567100093, 0.6320007534724854, -0.5206350601807584, 0.3789394516777854, -0.47921045446694843, 0.5855317396337105, 0.6027261395968615, -0.9057377130352993, 0.07911185769174026, 0.68592623028022, -0.07979254157857256, -0.5835733283861273, 0.5085545471586729, 0.7780052633010329, -0.19709376167291687},
    {-0.3999290586627447, 0.3697709277345754, -0.10375322030979633, 0.2923034525777647, -0.1399087928216294, 0.1273591353451131, 0.5016754138610451, 0.16139758606956375, 0.6430426942458445, 0.601204614960948, 0.3541461121476864, 0.4206664340035582, 0.6750360997183213, 0.03693384401200249, 0.6912911540457386, 0.13015006692766684, -0.2243757340459876, 0.4056236353022352, -0.4380109254118105, 0.12200385499987045, -0.3131242422618511, 0.34423661968193364, 0.1624874043841338, 0.014062145962963884, 0.39829584937284385, -0.6057049096341153, -0.31405246428447275, 0.2272121922462626, 0.2391617059136704, -0.5710844617272683, 0.423690962121866, -0.3590679215837127, 0.2601120548148142, 0.19924160293426535, -0.08539746396820465, -0.07894891774738946, 0.6670150339720277, 0.6621782971739809, 0.6358404235891902, -0.2381849857379014, -0.5310950615566861, 0.39620186839936755, -0.527049315824088, 0.5087512765313417, -0.5599120555744963, -0.11416111232296633, -0.7205890096575871, -0.5478689759375281, -0.3355791811045261, 0.13633914231015884, 0.617459639699122, -0.41396994179110036, 0.5402624260913037, -0.5888552142468855, 0.7016681479119022, 0.699934971551097, -0.6210527124913936, 0.2621612078033548, 0.6800373679445152, 0.28383344811547245, -0.5445183825805313, 0.38863321254342453, 0.6391505596524456, -0.15037118710811415},
    {-0.5810212639655968, 0.5976996936947999, -0.32531055071300746, -0.010671881847153793, -0.07262637706333201, 0.19421449287085735, 0.5356022045334357, 0.05627417693439389, 0.5584191546231472, 0.3347136554067485, 0.1059411724961146, 0.4264724730445615, 0.4024435879657587, -0.056768807731526316, 0.7180309908295033, -0.27968001595577996, -0.2515747386435793, 0.13085309377061952, -0.20899883238483458, 0.32848692989318895, -0.3468123429999313, 0.6711538060315713, 0.02136202607358956, -0.12012134816900615, -0.048285504191924275, -0.6060195449093635, -0.25552765104285, 0.2736640220180117, 0.5602055350739732, -0.45966372340743955, 0.33833540715573657, -0.7179932133439242, 0.0807717574557767, 0.07121566446262258, -0.24316087933881095, -0.09356558138880441, 0.6716844075892179, 0.4116390005643351, 0.47024333540048185, 0.16390268185768048, -0.44753021103148743, 0.6408698504793869, -0.41987556991356745, 0.6437419018432498, -0.7489509262970743, 0.10247145977552256, -0.7171316015542756, -0.1945821161705012, -0.5384876895397601, 0.13905664141732937, 0.4738652217964457, -0.392170183613286, 0.46598940373293246, -0.2036387617030306, 0.2121351381577146, 0.624599019961693, -0.5337244108183646, 0.4674084913080168, 0.5657410241702009, -0.1938436573737429, -0.6525079034867071, 0.18205035134867492, 0.666214469153229, -0.24552448616300265},
    {-0.4288689615279056, 0.4425150423600993, -0.18889683216947295, -0.007026506061917867, 0.07869732026572014, 0.08677580778182102, 0.6976653266415478, 0.2611295580891225, 0.31196637296866186, 0.5195443972075272, 0.023019551374277813, 0.5783600762528688, 0.523414389800134, 0.5061171420158104, 0.37703729955469384, -0.11232674449886956, -0.45150057270497695, 0.17542934942169316, -0.2296494852158063, 0.2689544498501211, -0.48543549991829776, 0.19752865931727714, 0.06955149607660625, -0.1869140832633857, -0.17282533111208984, -0.5365247693423928, -0.27495458092833847, 0.16244559495192054, 0.48003645114808047, -0.5738624779396935, 0.44243604515340634, -0.7132332047855608, 0.07493175774496975, 0.16258754293010477, -0.06748047431284658, -0.3070503380160167, 0.35123674882618144, 0.4586011535873422, 0.48029092392022177, 0.210072280676272, -0.5978055740374415, 0.3652029338603031, -0.6012423097969708, 0.47547645071718253, -0.5808065828109896, -0.07440000481297437, -0.5487643394129441, -0.3787544662179282, -0.6340885735992792, 0.16170019473851352, 0.4136171470806477, -0.43597395291385305, 0.4221705149277204, -0.4198106151889676, 0.18994946338748908, 0.8113339883172505, -0.6096346140655073, 0.06943360227900154, 0.6372527712663031, -0.18496701036341687, -0.477943889695263, 0.15523001523956376, 0.495621112114295, -0.44332691501509414},
    {-0.8481143782271269, 0.5124008441108246, -0.1788549937857928, 0.3047811874189934, 0.031952133016697304, 0.20242581292549688, 0.4177679477278687, 0.14953923068557853, 0.49113060726398006, 0.5982509200248692, 0.057755377953137586, 0.3426268760160622, 0.5113738243472165, 0.1844797625247202, 0.40380677973587936, 0.2960265333021007, -0.2181274917565436, 0.570589738261884, -0.28564948596346573, 0.4383281778186035, -0.43292841898065343, 0.4308739657845971, 0.017974515479068556, 0.351491244363174, 0.008587565197110092, -0.6490323286208725, -0.5998101424088632, 0.20660022310911683, 0.2803885431277795, -0.4984730033804659, 0.3704570552213565, -0.7845316962782133, 0.4147223967265503, -0.026058467881155813, -0.1954230360810279, -0.13057036109169173, 0.5899676790307458, 0.6846310266779283, 0.48066010082935945, -0.158864604771908, -0.6520082420465553, 0.34211689106213033, -0.5286648942389206, 0.40227289571934355, -0.6027789692797446, -0.4029305752726556, -0.29863633390611666, -0.17738459408215276, -0.578349328251958, 0.1339697575070199, 0.5618530971548653, -0.7824338377326018, 0.38930985892616715, -0.31865496912282365, 0.3341129158484928, 0.7337499221447498, -0.4130446296759216, 0.5224777203437664, 0.5895425244416691, 0.0553925923816543, -0.8890068915309124, 0.2354265633258595, 0.4164925274981661, -0.2685756254822201},
    {0.26528277481555695, -0.4098038296618114, 0.3050153093042009, -0.5154072567648876, 0.6191225575639185, 0.4045160740117821, 0.4646679184080846, 0.20454052642732284, 0.3010385578945532, -0.42438253848581853, -0.6812795165042149, -0.31747499052634215, -0.6996314731392094, 0.035722258423114224, -0.35970275170998783, -0.7258906936448619, -0.05133160514357922, -0.4681453153862354, 0.010154739546189596, -0.13822383463751886, -0.018428458987726794, -0.0720459804730056, 0.46202685207788335, -0.31714546655970444, 0.5293967362301768, 0.1535557819099578, -0.8055691613052208, -0.6911080410869263, -0.5264091743564128, 0.4737051521530156, -0.2574703582936882, 0.10071707211403554, -0.6655107753269296, -0.32426671902657905, 0.5880124013823171, 0.48283679382221895, 0.08643014381407298, -0.2071002155773182, -0.5777231535293836, -0.3302407707942145, 0.25827717681069556, -0.21577960203875293, -0.34170972712390196, 0.04628357049325681, -0.3365785868052458, 0.14234027746650135, 0.026100399884675097, 0.36280543431667583, -0.5832595163056464, 0.27053071482878405, -0.26459126866461324, -0.2631030925491079, -0.32445729646773436, -0.03820736539636859, -0.3983243559165674, 0.022009942960174413, 0.33413670686498037, -0.22269803098789315, -0.5998107629121939, -0.3509478262585286, -0.43781901826678893, -0.11504501583128697, -0.3904550028693615, 0.13732694673820933},
    {-0.0410390652783083, -0.08722556292087817, 0.2854876050576062, 0.16395159514772406, -0.19337511147366668, 0.4348490148043978, 0.16227435690478112, -0.2429124873249667, -0.19757288777669724, -0.031227333986789556, -0.34496474663389987, -0.20592302534734833, 0.0630368584213102, -0.33643434327494526, 0.1196259165043931, -0.35778576521546784, -0.591353736229796, -0.2501221394541741, -0.3661108541002336, -0.32835138526938956, -0.17484885193556138, -0.33923430058196025, -0.032470802733332395, -0.24083259519501338, 0.23164179962536136, -0.03903507749162876, -0.42876970448987356, -0.31053661859474513, -0.2749958480820893, -0.10928077069931211, -0.3456354260736553, -0.015482702260237074, -0.3819524657296653, -0.3175678748029188, 0.17433782015089552, 0.227827530525478, -0.3550551995946209, -0.5014057135103074, -0.42030750500812813, -0.379189371335425, -0.054822848359658, -0.05170950028336592, -0.055600578199405594, -0.41381828247940194, -0.16752470571658604, -0.13892930248534266, -0.38128659589980823, -0.11414531584648202, -0.18905019988426994, 0.09819611283067377, -0.4557777137376943, -0.5200947597673999, 0.011627313532314517, -0.1302043212178977, -0.43962743257571646, 0.016298525423330712, -0.2859312719088118, -0.12734601250370978, -0.4652340988798517, -0.3235153044781531, -0.25579729408482965, -0.8308191639753901, -0.23815579923547395, 0.38546084791134916},
    {-0.06977525169369692, -0.002067178614743972, 0.5183319963049025, -0.6266642387944675, 0.10537658156998156, -0.15096306658280004, -0.15595040821606923, -0.12794525117095085, -0.04341231547666062, -0.543381298507261, -0.4431925557645598, -0.40378453883169724, -0.5457849765530925, -0.4899097280811527, -0.2819600567478799, -0.5658386215556503, -0.6610976992691967, -0.48806137364718927, 0.14699324708528, -0.36758414575801, -0.33991315330254906, -0.24381576842624292, -0.12667398801549581, -0.34990218777520377, -0.25761101831167194, -0.35700099945053837, -0.34956664571738283, -0.38414055830379784, -0.37964361809155944, -0.13893728629683544, -0.02723838152662474, -0.319461664593245, -0.38431871934611717, -0.443060723819765, 0.3384939436218552, 0.6482986990591711, -0.6836685110262293, -0.3000947058560258, -0.6886606411186821, -0.49015637599900475, -0.14658446471020373, -0.3196445273673411, -0.5012162692987407, -0.30334202358639495, -0.5429005266093488, -0.5062086796032962, -0.49440482972330874, -0.09103282790129066, -0.23168885205777964, 0.047595475926215214, -0.2463872649861708, -0.4073521345471928, -0.0662987459235585, -0.09080949154350099, -0.4675893882708817, -0.3621314045067676, -0.017832102831495923, -0.2471113980333576, -0.17569146162740812, -0.6715522803907279, -0.4740187126505972, -0.19217385192084405, -0.5143489312763903, 0.24337943524111721},
    {-0.012631543145136747, -0.22398616769221774, 0.20186031827052875, -0.6834361558072335, -0.26281636800604485, -0.004900044358123818, -0.16674628731992147, -0.3141887460944054, -0.24502542610988434, 0.08519938795227446, -0.7268317618554337, -0.3248460352476996, -0.8157265367441231, -0.33126432090613706, -0.2294082404579348, -0.5149422563992512, -0.20865521751048546, -0.08585480726216974, -0.5082932144665863, -0.693595471378407, -0.47035425957348825, -0.35582825010223923, 0.40084859294087694, -0.23174395316442775, -0.09761497935853629, -0.12203436293931333, -0.3087396777999959, -0.4462353793339197, -0.26847713331444806, -0.5325768631918514, -0.3334382223072741, -0.3221853696318962, -0.24664206316676895, -0.35713888806895766, 0.2891932523907582, -0.08238925257201399, -0.4021072933709668, -0.3649565697795493, -0.4682270252485846, -0.43566741693976796, -0.26998837128806547, -0.040406927558145705, -0.1666395972024358, -0.2865258980780383, -0.38472348020689545, -0.4618838383030305, -0.20398688753484207, -0.054705205042562634, -0.3963365177536541, 0.09103756655438684, -0.2207456016031129, -0.23928703690438782, -0.13805352830415546, -0.20879011705674788, 0.06334392834177367, -0.4689739054099618, -0.05104279808064494, -0.23580507149981556, -0.49627048339429375, -0.36872149618822164, -0.39528946456117325, -0.25627731164457035, -0.4491437064763899, -0.4042781716829527},
    {0.4566518205808936, 0.19452584756486446, 0.26176891147102693, -0.4814770947556224, -0.2360651441822815, -0.11605385941969941, -0.29001906049126835, -0.32457182050889866, -0.5103318234019254, -0.13755365261864377, -0.18993610571760275, -0.3203021540921695, -0.3442413103437015, -0.496230457556794, -0.4883036647224679, -0.17553929158503134, -0.32554045182744046, -0.11110392531912013, -0.37515526446811615, -0.45806198132721043, -0.5060237908048899, -0.02278162527257051, 0.023221168177362552, -0.39547490413066255, -0.39339999798186864, 0.09949270784951318, -0.49785173702506874, -0.0667519395850243, -0.01754374170277175, -0.17468999789454528, 0.013427203850945557, -0.35341620044876454, 0.06782820864490059, -0.3887113455038899, 0.19157658817191428, 0.3653342740975231, -0.49957990442421235, -0.18099212304349666, -0.09288691828640185, -0.33944361332392453, -0.16415737234750002, -0.14199496142435844, -0.23182395726096583, -0.49202880491122725, -0.2181327494572498, -0.4189345926567951, -0.8515158002238616, -0.19799363876342388, 0.07054864067214012, 0.18920753801618362, -0.1462825529810943, -0.6363806696195754, 0.12173649156219463, -0.1720972316012821, -0.14143177537284493, -0.3124476709229709, -0.051170072391728466, -0.13542295610684224, -0.13788193786175065, -0.12241263961809967, -0.2300889579236531, -0.3474759105072811, -0.28030402302802954, -0.3571593434578337},
    {0.22937815437377818, -0.014434664031805952, 0.3351110629978279, -0.1515780229801072, -0.1673209936308124, -0.09251990655067753, -0.028239559221244406, -0.32556424777932774, -0.17045281152433667, -0.0482673469184798, -0.17698878553951278, 0.05714670482760362, -0.5650062852056522, -0.20355173197416843, 0.050322523758515585, -0.17290165425065473, -0.5404440310829169, 0.01700813936172481, -0.19547010397052408, -0.5028679898656333, -0.3990457333685828, -0.15573261861733778, -0.28339967328160875, -0.386226954253362, -0.49085799312371575, -0.2627240643756036, -0.49068243348245255, -0.18206702081302523, -0.2166539180014231, -0.4254963057237301, -0.3272682012730864, -0.6141935002491522, -0.12355238279426088, -0.27320024230357465, 0.026923952999360862, -0.04723097808563489, -0.34610189873610464, -0.13736978600190033, -0.11671522368719003, -0.10919810371673778, 0.06081841137404918, -0.3689033510191173, -0.1271809366204478, -0.35723715555467483, -0.39504936839433097, -0.19198790308043334, -0.5849230648090545, -0.40561500232535896, 0.09334406462876704, 0.2810890129829695, -0.2504559162564035, -0.3271787563207322, 0.049623215775364674, 0.02336683429702677, -0.36229666192695653, -0.411224777057171, -0.40386179066894423, -0.07684033319718918, -0.151245214059565, -0.220226721979128, -0.32507439829176654, -0.4983792771055975, -0.24709262920680267, -0.36028699391566293},
    {-0.16825803365570666, 0.23215087851010965, 0.12722686457808577, -0.2967714166633145, -0.3754281606670476, -0.30184197026306325, -0.4641166337391519, -0.5651965945179457, -0.01843182661192284, -0.2664841629231409, -0.26296740614660746, -0.5231130263412928, -0.32863860037790293, -0.2660642562620404, -0.5182012445778303, -0.4269876344755027, -0.40422444285003156, -0.23652321320650355, -0.37905142355110066, -0.741903922168076, -0.19578475317611715, -0.18522239071104837, -0.4276819154173279, -0.4737778601381326, -0.34030271420844593, -0.47190429894478686, -0.5981183344121828, -0.2132171820576884, -0.4676685328354729, -0.596887363478285, -0.20063316301652953, -0.6330945345996537, 0.015487565481639282, -0.2641466153137965, -0.27457216596263495, -0.10273592299332053, -0.3032376664211018, -0.45931880960845894, -0.24061949514057948, -0.28742267511163655, -0.7687885843698077, -0.049130460107738194, -0.30524504052118884, -0.3683917882570715, -0.2287720590833919, -0.41268380934071724, -0.4037839253816039, -0.2799317132225436, -0.1618667985913525, -0.17460308680842385, -0.38956544748713884, -0.20406838326338672, -0.3349223649335045, -0.4588532504871272, -0.48276700334806694, -0.73800067849253, -0.2620482266164488, -0.18595016188741498, -0.39323770025309407, -0.2364590497167724, -0.5255180420594532, -0.4373234512010713, -0.3759346334495922, -0.16817424486358384},
    {0.3537969533592844, -0.10135824783255329, 0.29979029495950016, -0.22978238230274267, -0.15061697317885409, -0.06011649528738194, -0.2358227006395892, -0.290407377825619, -0.3712398626212253, -0.44410616169883393, -0.2725410935047459, 0.126730196002352, -0.26078459473819215, -0.562365173827313, -0.12976822130932097, -0.16578704637598846, -0.36746415117630155, 0.007047897105407509, -0.17656518541057048, -0.44554280276125907, -0.2041365947693187, -0.4073064703291436, -0.2027286255567764, -0.22317128268535563, -0.11294046539535181, -0.10197776068532217, -0.5914691661829846, -0.11046597575618067, -0.3607836148176561, -0.10324392355483623, -0.27659252680022933, -0.19419741379418579, -0.0707920892900525, -0.2832958669425678, -0.3652249534364282, -0.05515518670668111, -0.017499393729233554, -0.30275292119378766, -0.060269628570241165, -0.49763655562704484, -0.5166976625763432, -0.12454396039888846, -0.17093927197823777, 0.08431242091349131, -0.41483492649529874, -0.33472680530756826, -0.09003900019421582, -0.024043090437988916, -0.0005420670269779937, 0.011346869699717333, -0.44212712646264757, 0.08913710563508268, -0.1469619557911206, -0.08908193297407742, -0.13858874772143676, -0.2694962969914579, -0.06329338175761033, 0.21357520199100077, 0.0077842918997636295, -0.1699260359364914, -0.20723540859812592, -0.25746901138680367, -0.16068062579300407, -0.1512559780600511},
    {0.1847635191375227, 0.31946378994510133, 0.013125647705120175, -0.509229676946818, -0.4650324300108595, -0.4716391636762071, -0.2810456318338206, -0.529965446149347, -0.44454730941167014, -0.23842808982244398, -0.4367813152537061, -0.016452899016427196, -0.14187828516138476, -0.5541433997189457, 0.006476427707930932, -0.1321603308561779, -0.2924466778699475, -0.33956581093378, 0.2489020274832494, -0.5707809535778735, -0.1486728543061147, -0.12217495938204358, -0.09817261175903237, -0.6574148399739644, -0.6288741262992361, -0.20008215626003187, -0.43681877321293433, -0.21251743740179263, -0.5747424048754681, -0.06434662271599784, -0.05461831612105909, -0.34588370232967913, -0.05812709651464954, -0.5798016888051382, -0.19549386473290464, 0.1923044060741818, -0.41889864302473645, -0.5205023857560633, -0.18576460467444766, -0.6286633675990734, -0.04164556224862576, 0.17363637549034833, -0.1434580839584424, -0.40526635133537164, -0.27513360213130356, -0.5710923728160611, -0.7057563874912501, -0.35127882770651836, 0.03638290110134119, 0.11389256596146115, -0.5696029650614917, -0.4376106450543339, -0.2282694976106231, -0.24802187345745172, -0.20623515044195376, -0.2594167410687496, -0.2434352081668589, -0.2077423395326041, -0.16602614051795822, -0.3262698868097945, -0.3224071144242636, -0.4255655564848114, -0.4969665128001677, 0.04394209737692999},
    {0.24165958113370975, 0.44580150429303195, 0.42606139204227833, -0.5610759302836075, -0.08002451002723965, -0.21709416713185678, -0.059477599270210645, -0.5896810464497179, -0.29819471229245326, -0.5504823853316805, -0.21886585820600196, -0.1719186580731257, -0.22628938793217188, -0.4766845630271075, -0.19832144093309775, -0.49959242423601513, -0.18277828805118948, -0.5199442694208518, 0.17984095513798495, -0.5206705469950405, -0.17739877256562261, -0.23893611183705105, 0.14916520685973048, -0.24754498333522765, -0.04410816760831583, -0.020934174138041713, -0.48285049257070534, -0.17696069712999232, -0.3136838227583345, -0.28987289388747506, 0.1561085784371641, -0.21857679511133277, -0.08418923336520003, -0.4767988240075097, -0.08260158254292482, 0.49104731879264224, -0.43108478971265013, -0.46726420477920116, -0.1528235844241178, -0.7212760592149146, -0.30836549422041265, -0.40438888986958876, 0.10009122303411706, -0.7010934604803286, -0.16203578964688287, -0.4742485337673267, -0.1990105966834826, -0.0946887229970414, -0.14180047799163978, 0.33763430126636146, -0.3390883642566308, -0.46018624925007867, 0.2847193181358691, 0.2789035906742575, -0.12084121940794725, -0.4000508962019986, -0.12610773080882615, -0.29395670866518286, 0.22298522578670193, -0.23301786913698386, -0.03189636441853844, -0.5471913686240062, -0.19460388830201256, 0.2485531726893916},
    {0.1087431299869599, -0.2292078062186858, 0.2779537889245286, -0.6115542441182052, -0.30428333624510495, 0.10481734170613644, -0.45896502584395443, -0.234745301551719, -0.4390799518947355, -0.38215856533495735, -0.37747557246347013, -0.11643604228280811, -0.535030011971536, -0.30202508699819985, -0.4428023863988702, -0.5743984051464033, -0.28422021888693383, -0.43173576377692896, -0.4075049203535505, -0.5317258034604972, -0.4217895029515526, -0.09974876487683801, -0.10992819495587622, -0.48303041134019403, 0.10266436345883448, -0.4388897205252697, -0.4953115880475263, -0.3381174143305958, -0.4127643767792645, -0.10681523109031527, -0.31432703436998205, -0.3592488287619663, -0.1625396769717012, -0.3405967329951815, -0.13315071759075892, 0.0871300007574071, -0.32980793054197804, -0.1502493660117825, -0.2133209006504486, -0.3007714940637169, -0.25824664690955, -0.4676685120664754, -0.20141746007437983, -0.3675041432183488, -0.3376279150241159, -0.35102059635158805, -0.23159260128342163, -0.01110018491426266, -0.3025590483955386, 0.40445492489899726, -0.323158544193913, -0.3173840968504495, -0.3379650526463681, -0.08818125719656991, -0.4163778672666306, -0.6521936840301348, 0.07625764581012157, -0.4228729298372254, -0.20649719275298892, -0.46481348915961607, -0.42882684384708397, -0.12900345662635174, -0.2113870083460131, -0.18435473051601575},
    {0.21502568456441762, 0.13890080354930556, 0.12404657173589287, -0.6761826529006426, 0.2253676454914825, -0.11563133715634832, -0.5124724768216438, -0.5633723261689921, -0.35293673436812034, -0.2575329419149844, -0.5387611848871845, -0.252347717208444, -0.4653648645384135, -0.7043746043219844, -0.5315809569483728, -0.29532358158785565, -0.4757216726888926, -0.09961033534796938, 0.03399927317910449, -0.3967621335832666, -0.08396693167197118, -0.2413193969900847, -0.30851276415689644, -0.5276930064626271, -0.3046059211721628, -0.012785413376166871, -0.5583127199816175, -0.07155617943470417, -0.2560486399402586, -0.5906556523478118, -0.208814988901611, -0.2228484527593487, -0.13897170714471338, -0.21254900720440528, -0.18050545601604295, 0.1435045131341424, -0.2169707607611127, -0.27821660560640676, -0.3404527074797761, -0.6831486847604158, -0.5700686044901314, -0.24497731539280615, -0.4945764643981111, -0.3920249075506665, -0.6951973741109317, -0.2493815532981739, -0.20679899018276884, -0.06548108397189133, -0.31736390838313067, 0.6749579630844705, -0.5519357714500811, -0.479745952523461, -0.5245073336934795, -0.5316283070261822, -0.31170916301943313, -0.28174862001281814, -0.4009281293800341, -0.3808643663622626, -0.29019789391266393, -0.7325613127946021, -0.4189481157287258, -0.2977666600518459, -0.44706047791013076, 0.27609782312187786},
    {0.015924514923853866, -0.4445489789681252, 0.38848929069498955, -0.3265098092200248, 0.2244917910926179, -0.36318204361882755, -0.4833718789217229, -0.3536552488853236, -0.15294758176192585, -0.17750371427663203, -0.5756428061288859, -0.7038381784835676, -0.26716008137254876, -0.5825801122423695, -0.5023655926275654, -0.4266723281725594, -0.5185669456234534, -0.20289601339233823, 0.16306877007787138, -0.5208412238145883, -0.5108248775934134, -0.10520220139316157, -0.2597205787343217, -0.5259698270597963, -0.1291799133645287, 0.08802683642966436, -0.6707844907662408, -0.3411106109822102, -0.34144629785704755, -0.5619271944835666, -0.47790982800859527, -0.3970751905945486, -0.15634003031922986, -0.6367100867675746, -0.12221462437621615, 0.30515610937814414, -0.3891429526621775, -0.14344650393385833, -0.14527966516898827, -0.5008886705997658, -0.3749536808265078, -0.1177987261870282, -0.08833035573073368, -0.5763322208185766, -0.17431617222256798, -0.4672922240484601, -0.4119348670703946, -0.06267494659781248, -0.14709257361557235, 0.2502805825177997, -0.5498208724351342, -0.5591257958381071, -0.09839441468782108, -0.165135223824201, -0.6259294125305715, -0.424028299122674, -0.43075935897094103, -0.2995230331651559, -0.6015598098294612, -0.6787427215372991, -0.42838190940681653, -0.1983693938125685, -0.509590271899344, 0.007980290501038666},
    {-0.10130754450033626, -0.12023547432483776, 0.39498188168853837, -0.39990527219352456, 0.6921226511248727, -0.10264545060939434, -0.40672957057934217, -0.8041918721399117, 0.18801346936563543, -0.4949036347244318, -0.42361589376586833, -0.30561624144515226, -0.39954630676134323, -0.5142185508831316, -0.46253480054362406, -0.5880400073326407, -0.4213524432664085, -0.809245631347989, 0.05334081292919131, -0.4470411444379342, -0.38018719698390896, -0.3180730017370465, -0.009615034115436549, -0.7367833640611939, 0.016289168315411887, -0.12999453526676918, -0.5106383400640943, -0.419359320453883, -0.4666363866157647, -0.32353545722314314, -0.32862171613267577, -0.41692119643486264, -0.14333144671995487, -0.6372922035388182, -0.10259433856285133, 0.39969813822339506, -0.19655734656925533, -0.2934939339312277, -0.058431425914566376, -0.6900408241269431, 0.042118920166300255, -0.11850758231671854, -0.47724070635121013, -0.24557916709100125, -0.24633891495142043, -0.5165713325638788, -0.09956047915479665, -0.45505329410613016, -0.13566149916596673, 0.35164212792886396, -0.10443809410714525, 0.027437148931581137, 0.004569303986893421, -0.2816083584487842, -0.45077777371586114, -0.03673295225379934, -0.4896725459036876, -0.3349453678143648, -0.143131955949824, -0.11081336138292072, -0.22724924513374026, -0.49043427846824306, -0.6633928788540894, 0.09599958963717294},
    {0.20709242568028863, 0.22734601142631763, 0.5048973813120609, -0.29915046507732146, 0.2934206256404423, -0.011093273998081948, -0.27929502007311807, -0.38701530830266045, 0.14773263862180083, -0.471945497049062, -0.39679643675749676, -0.14087185600839663, -0.4073265497110637, -0.6218762329017562, -0.23677310972841092, -0.26229724789043346, -0.7877992158795519, -0.6159180579704241, 0.18544816209472018, -0.4690355026437371, -0.5742381562346744, -0.5044623208917122, 0.15129561527601068, -0.5694031135175562, 0.25489708566288477, 0.31315824679919413, -0.3756220888183539, -0.4503516076747744, -0.26723455858203093, -0.2748905987835806, -0.2164038326697142, -0.45108224496592625, -0.22553547670900906, -0.4933161430069665, 0.1201878280417141, 0.21379949874361903, -0.32237409720757293, -0.49818860075419297, -0.5218464490446598, -0.7038198870780451, 0.030846156342197426, -0.6074081166270248, -0.0201860946034972, -0.3998029817188377, -0.11755716022998021, -0.42880783127815725, -0.24389210487799734, -0.27623572864362883, -0.20303564272906918, 0.2938658789376673, -0.4193209623807669, -0.5944069555683087, -0.199509690816391, -0.12376964491694052, -0.45305574877330407, -0.23103933390457596, -0.2750404714014853, -0.36305959351596473, -0.13709761711440685, -0.6128518778809917, -0.22294407584016068, -0.509516395248286, -0.30406369000226374, 0.04563880249953918},
    {0.1131607896360875, 0.2730789193661011, 0.6084462619770266, -0.3660559877254486, 0.3940496027436133, -0.29764993845367976, -0.06178903182224307, 0.012991474594513287, 0.058547060325122025, -0.6447764239346584, -0.3143635786987661, -0.1558773150994021, -0.16908827784980213, -0.6114756458208507, -0.319963814357912, -0.43006616088933375, -0.37647207949064215, -0.42768629327213226, 0.08482687305619369, -0.35361844225725525, -0.45205847311317227, -0.6059007530211509, -0.04243721209053194, -0.14847419560483568, 0.08546272085322036, -0.2816791712022876, -0.6409000554145114, -0.6700433436118439, -0.30043734982171616, -0.2920582100060131, -0.18111722439826383, -0.15336113818547245, -0.15664019884975527, -0.5482063022762729, 0.32449674219522423, 0.47459137118547756, -0.6768417005191091, -0.45969986122327766, -0.4080338621648915, -0.7081168408575179, -0.24724361025627503, -0.6665349144789768, -0.2918550860048718, -0.5933928351138698, -0.49885534603003784, -0.41670939256852596, -0.5287865085717054, -0.29423630200892265, -0.36213119248192616, 0.2575258971549093, -0.5762417528831325, -0.4755145266242894, -0.2103955053485506, 0.23563755226107527, -0.43346704688598936, -0.42745061045046767, -0.28736289215015604, -0.3864216864462279, -0.15184580519478735, -0.505195573816066, -0.2575392180286184, -0.6584547563400981, -0.3966358523093776, 0.20042125328734323},
    {0.1414223298808149, 0.04264398097336036, 0.5422346299108973, -0.4287566808121726, 0.46612463553174077, -0.5112394568666312, -0.4623564960741432, -0.5102005903423067, -0.10112918821371492, -0.5135631385633144, -0.4449341465375874, -0.10553908683828717, -0.48223694698682223, -0.35404681957550393, -0.49321695109795316, -0.3519928996338562, -0.3060988042252446, -0.3699571397885814, 0.0807219188717971, -0.45868313806542527, -0.6686527343002739, -0.40561603462338525, 0.27746598518701565, -0.4800041406041734, 0.1136626250689314, -0.02423278105331269, -0.5486933703841306, -0.31586216190610017, -0.3380589980567244, -0.30225560943830193, -0.34241585504112726, -0.3635301914464141, -0.22453848360213857, -0.4917036406605417, 0.2715464345059917, 0.3058497106711576, -0.062312337329224005, -0.07482970057387735, -0.5077055300246082, -0.5797445670606598, -0.40335637139577835, -0.6465205884188113, -0.30380488740257106, -0.5269336274379618, 0.08133587421121383, -0.3961595886410437, -0.6190720984923412, -0.10026898608839, -0.4141483922992586, 0.31521308351638916, -0.6593430175841234, -0.33436315624868923, -0.312415111192759, -0.08895444999225073, -0.5687738774318082, -0.582092489587991, -0.23478585296027044, -0.3883030277555617, -0.3749576826883519, -0.5832599229311284, -0.2794875482921406, -0.5649412047152421, -0.21367999672506657, -0.23749728707209572},
    {-0.13285482900985676, 0.22942447774456237, 0.7817215892424472, -0.5444709618007184, 0.2815798124762981, -0.13122676317112422, -0.5172004565618102, -0.5142598657134662, 0.19942424902099287, -0.49493744017840996, -0.22772621316027924, -0.28410645072738616, -0.2608317459424755, -0.24580378419671073, -0.518952798851722, -0.32235454559009397, -0.47497630309948147, -0.4800980373325788, 0.17177057818705593, -0.5400410160736081, -0.5688548037716658, -0.24310346478062472, 0.5860927761861843, -0.7342610718592553, 0.14450750292541192, -0.09001482637272112, -0.5829550294488087, 0.0073724435773919695, -0.4030281680989343, -0.18500476982834743, -0.02097125978397662, -0.34313600682710055, -0.5511609096063507, -0.4424568810743962, 0.472141485187134, 0.6255335510304045, -0.18109824088747412, -0.33613470679318186, -0.0984879326439502, -0.6228134573871676, -0.37693468337573793, -0.3551976703485391, -0.400793475786214, -0.19240305206111158, -0.5191176930120638, -0.3250004504878885, -0.8438541962126003, -0.0874568098396083, -0.013017994442791826, 0.4280975225242541, -0.4012459005938047, -0.3238699925872136, -0.12909196757734936, 0.23970007214554823, -0.4050677479943138, -0.3659992040457494, 0.04651549264709581, -0.039225144252402096, -0.11969848573839155, -0.2938093583645441, -0.33244633128667633, -0.2181947908696316, -0.6215533206373864, 0.4139442947275733},
    {-0.11428862561166625, -0.07548460816129851, 0.6813243681930673, -0.46359887070086037, 0.21293668310969927, 0.13943075382836023, -0.3396389695249059, -0.2309152630515416, -0.1639007747660483, -0.6607317918688487, -0.10446744081827375, -0.3011974674968298, -0.46870990147736785, -0.2832648425663492, -0.2739283543934419, -0.5620466304276919, -0.6863309711135153, -0.466427467133299, 0.09969225004352113, -0.5698715547455605, -0.48931713514336755, -0.054540507533026715, 0.22708632102068255, -0.6322678166464532, 0.27156827078891693, -0.12405733420437401, -0.5065561534066424, -0.24648980256663497, -0.4924793337488028, -0.39102474682099214, -0.14835876500294887, -0.4994828624369089, -0.4021340064511797, -0.5391860717334025, 0.5030177179383536, 0.7703055203982978, -0.3456142974173202, -0.4002317221691249, -0.20084290841849234, -0.6511815895391372, -0.34289628588263915, -0.4782413539843069, -0.19790631066565406, -0.46047361468465997, -0.6195298787256163, -0.7961220808702869, -0.6095631402366062, -0.15600184289772454, -0.1714936497098133, 0.32758214122235674, -0.758503381752566, -0.7362229045356361, 0.007700240972834487, -0.1992379922268492, -0.4439763485402492, -0.49988522120493933, 0.07733516827748661, -0.3130080337253569, -0.2706076260333232, -0.508145126770319, -0.2399266159687045, -0.575525650196417, -0.35267980338596694, 0.1968973799012609},
    {-0.3455787407127413, 0.206589738981409, 0.4360188187001423, -0.3224971907913553, 0.10161880875330111, -0.024599105450821116, -0.4488457781039417, -0.15571814553365873, -0.21855527748540127, -0.5155744641235658, -0.5033646796915591, 0.1670871913057024, -0.3401956794232663, -0.5232786452745372, -0.3643189441416748, -0.5672476978226735, -0.6925372362296862, -0.6492333395897592, -0.053682798862064236, -0.6761297371565905, -0.45935640029561503, -0.326851677849521, 0.2644438914815278, -0.37604002392272384, -0.018638274138253638, -0.1834190732717378, -0.3653780858177115, -0.3547893352974808, -0.7580259888094302, -0.5275350245117326, -0.1704642139630252, -0.35967140065098585, -0.5310212806950546, -0.3466507389316388, -0.029437518994356857, 0.33575681436682336, -0.31280877730089424, -0.7403920820594642, -0.5560179379589882, -0.5103516241212731, -0.3602042193083583, -0.1300198485005662, -0.21535754406260085, -0.4262383858138249, -0.39315554575364514, -0.6585116410130587, -0.34370651731250174, -0.16278396345222276, -0.37405913030737326, 0.4223590268520089, -0.5494225674509877, -0.49223536485659264, -0.05621297379493245, -0.17570580195428043, -0.37466109523322333, -0.2158173938831367, -0.49546735120569646, -0.5702349528680336, -0.39433568489144405, -0.29575577075138415, -0.6066269022731381, -0.4360092640546858, -0.34671709292146863, -0.17991521954255804},
    {0.20406474164321944, -0.006648393493412716, 0.4822246857199374, -0.3402774332733517, 0.24437390647616156, -0.10644433846804982, -0.35189406559335296, -0.47078874815939203, 0.02621035645019852, -0.46490583180280626, -0.12883240835627466, -0.005693712804017067, -0.49047102419663324, -0.609808261754157, -0.36235331405654164, -0.48413499459481213, -0.5092093176199332, -0.6562685654942667, 0.17371430451332193, -0.8053502112399868, -0.5636490270133798, -0.5582096507141961, 0.1322592778669492, -0.6520322659284388, 0.17638758531742987, -0.14608521877078856, -0.5347976377675552, -0.291953312964323, -0.36224511480159577, -0.4595867666305139, -0.42719826935328403, -0.4102494169229305, -0.4660611861286961, -0.6230270501643006, 0.1831484110237439, 0.3684818141023256, -0.5447903693110675, -0.3174998899369357, -0.5081416473648216, -0.5734813397151832, -0.3996816158613969, -0.29722613268966364, -0.3491338615102537, -0.26240222947225816, -0.4611449731786397, -0.6185428063912087, -0.440882094599921, -0.2363672507806362, -0.3779656779953757, 0.36850282741036466, -0.4415031734309347, -0.3599294235183824, -0.14690082233517562, -0.3167792235541169, -0.2818234017585155, -0.17569017221093622, -0.6181298735507299, -0.5599157021177632, -0.3833840093314505, -0.6799046235348353, -0.4981040415667506, -0.6420145229250239, -0.22251805135409233, -0.31204277057369817},
    {0.1157716409052616, 0.5474535868379495, 0.8594153298572479, -0.5412787572651635, 0.7619089943466609, 0.5757715699428889, 0.04334367832200598, -0.5990203831160679, 0.021147798722070944, -0.8213108336162301, -0.25698547980184977, -0.10948257183248356, -0.43275507692603754, -0.4085666767621446, -0.095080110182807, -0.559581181890919, -0.613293446709756, -0.6053873493266095, 0.3122718184602324, -0.7602788223901383, -0.5333904103175718, -0.41623571852414326, 0.6299023220113267, -0.7182949265648393, 0.32541821291572026, 0.2432405395560761, -0.6720673459643633, -0.4603215430540819, -0.5567481425525334, -0.16585373557846478, -0.06675929438912356, -0.3271662168218149, -0.2260797720622081, -0.4779392468283451, 0.7482408072429734, 0.7695162337027526, -0.29648156430588457, -0.5170496816845215, -0.14166915782682893, -0.6369018055713213, 0.17175713945520363, 0.08984107513602754, -0.46587599299224214, -0.2692023670646864, 0.0011159329113585913, -0.5492815355192964, -0.44246149803363455, -0.16274780559150223, -0.18332218753121657, 0.542546181617749, -0.4818559923212697, -0.443780962563457, -0.0003763708193759972, -0.058880070729064704, -0.5830811772003645, -0.30117064329276355, -0.08288685925548459, -0.40604918025037323, -0.18878299707391052, -0.5579209250760766, -0.3254212517784314, -0.5319801900703731, -0.3882484480908424, 0.2875767607693078},
    {0.38392023787459517, 0.3368203485889085, 0.8910986293932549, -0.47204509421980817, 0.781382683005479, 0.3917088150893288, 0.44342222009776305, -0.5734910018590393, 0.41885329143044675, -0.8821779428515355, -0.7210484719496812, -0.06945619566912885, -0.4694901721274795, -0.2996172828786194, -0.3548701456069112, -0.7289944403974399, -0.7514439887545091, -0.7628846577875286, 0.3052961435069117, -0.762664219185523, -0.4962678798270111, -0.48059602452645234, 0.32083855320049454, -0.9384260975296072, 0.463400357059528, 0.48070134070071296, -0.6973301611936372, -0.39026881214238396, -0.5955635833596135, -0.044915101554136645, -0.03163587242846002, -0.4626079759349845, -0.5314138060878341, -0.6645954398054846, 0.5817373200135415, 0.969419030081932, -0.3257190236875262, -0.46650776884205186, -0.4380626628647696, -0.5458680565470411, 0.1754320077819799, -0.5227498096624509, -0.39056545046519003, -0.27914281981067807, -0.21840183080181108, -0.6446429496385412, -0.7364009499567113, -0.2583712587805457, -0.351074104468093, 0.6863169892804005, -0.5637381241600622, -0.43238299957983206, 0.3315303080174741, 0.12138856422228966, -0.9020609208449165, -0.0861513439742918, -0.19358155430487983, -0.49597481085014283, -0.3004067591303043, -0.7453871030786224, -0.3466480332527048, -0.7881681261756418, -0.2704810553463064, 0.5128284717606861},
    {0.10860982531780142, 0.10622989649461484, 0.4465985890792315, -0.6681047921222023, 0.6438572201029147, 0.17872265272107898, 0.019446942793111682, -0.2630916716579064, 0.3175418930002022, -0.7637428010095602, -0.5393447968932243, -0.28753779534522794, -0.45286829528502237, -0.6450644654581466, -0.6251803039635081, -0.4866234940700576, -0.5153383317166551, -0.4867181240651443, 0.34104712538253856, -0.5006547228089577, -0.4966557805622586, -0.6052385339674191, 0.5311196341672453, -0.6668836905658617, 0.2684967318350556, 0.12539881444773715, -0.40042798044474154, -0.5127228742587947, -0.6247883458141663, -0.25839865921506433, -0.18057531687738199, -0.3705296980460305, -0.47559221411454666, -0.6110139788679022, 0.5697288439820545, 0.7298752867393529, -0.4739639795180149, -0.4999893883873948, -0.37952284758667054, -0.7691307373923053, -0.14448989227250297, -0.4804219303616859, -0.5958393498966577, -0.5088986100170907, -0.490306331365108, -0.7150550209680313, -0.6261319672585387, -0.24472384329747146, -0.34066718035988114, 0.4973480363671284, -0.4837980759085439, -0.5793228886369818, -0.11470924979589033, 0.010383736479831492, -0.6641182269641814, -0.40296285102210805, -0.20215435133220258, -0.6236172885136728, -0.2075014966321648, -0.4646764606409214, -0.7553677533897108, -0.911097571654077, -0.36684378125233036, 0.44885036601596456},
    {0.18414021492332117, -0.1157790910252659, 0.5564875463600573, -0.46514926990711236, 0.4716075387308307, -0.3510243956516355, -0.1493228297119866, -0.467417053106144, -0.3363812410605029, -0.6099254184978758, -0.43276608214060663, -0.6356185134588833, -0.639227215322394, -0.3414872499994045, -0.35986438218008643, -0.7581262275529713, -0.430996173612731, -0.8855594633787917, 0.22521903389841919, -0.4977779990461032, -0.5879980724607262, -0.409192001630748, 0.43960237695553633, -0.6176261041259036, 0.21160802872170925, 0.07093256917938505, -0.48001913258363066, -0.6307675882709055, -0.6954890719609634, -0.14548084602930061, -0.2869358566078458, -0.41845161914711954, -0.19617710992092544, -0.6679112880064688, 0.4730727733382299, 0.7263895824595004, -0.588411621619334, -0.4687691263355998, -0.4814855621721209, -0.8457220127814806, -0.4342530464303527, -0.6212887512257617, -0.43463670331982523, -0.5213651404611476, -0.1424858638775342, -0.5872947462696422, -0.726673842654426, -0.3496405552524295, -0.41295856153657484, 0.2982485957273727, -0.49080624347402735, -0.6409175919463612, 0.16145308341949524, 0.07145560587813835, -0.18553274279557488, -0.6049595563269132, -0.134541459141493, -0.5247956151596319, -0.40049244394579153, -0.5614162240235167, -0.6900223950402249, -0.7579019618327416, -0.3564200187388054, 0.2562155624994273},
    {0.060548842482149326, 0.11186386969769699, 0.5069799811050336, -0.6002858908320926, 0.4807343885631561, 0.08821803009014256, 0.27483470692120227, -0.2488323160777761, 0.35100152415287306, -0.6985080165448967, -0.5049260797982119, -0.2737135942761217, -0.5887379880238384, -0.7640572723530402, -0.36468391196457034, -0.8485816818905271, -0.893269913662857, -0.5844819639478879, 0.36652194287719514, -0.6693465252704365, -0.29844108410679426, -0.587470289049699, 0.21094217665235296, -0.6755326654070305, 0.3425442888179259, 0.27929868594507584, -0.6682651331427053, -0.2927994436928637, -0.4297974937345529, -0.45365473528047057, -0.09855182177876536, -0.4837074470622914, -0.2693323316068203, -0.6967495815907979, 0.5472368541582342, 0.7027886738705142, -0.07147002961712898, -0.4538172570797311, -0.3092987372277755, -0.6847687167968389, -0.057457640646691566, -0.23919068265821977, -0.5729608772812084, -0.6011460468940507, -0.4805222704470328, -0.5720845992329645, -0.4814982979458369, -0.2277195280703798, -0.8102708272258866, 0.28260769624994536, -0.2507182653774242, -0.4387618184653291, 0.2608933917381515, -0.139855183499052, -0.594086319254165, -0.36557645664987737, -0.23293186253628034, -0.6657887259087784, -0.44136778892392864, -0.6381700206670871, -0.23298611034285635, -0.5142149919333359, -0.2683442745105763, 0.3851980236044512},
    {0.0067561396389769855, 0.16073578529953278, 0.6989905942560761, -0.7590867955307254, 0.4978089692482314, 0.19664630499649913, -0.07486997315935558, -0.511581078422919, 0.3925781270395774, -1.0294683122308765, -0.6510597683934178, -0.308058206960306, -0.5336360566350358, -0.43571898431710354, -0.5455977462456123, -0.8958505221748057, -0.6533586670621605, -0.48406131809924485, 0.2646948778016325, -0.4919012642963172, -0.7270257089041304, -0.44345201033137244, 0.6377749581837165, -0.7061266283700144, 0.5502688246283352, 0.18412732002082358, -0.7450020061130693, -0.27115690373360996, -0.3626932653724178, -0.1683274628553197, 0.07464378749637723, -0.48497564715717373, -0.4497644982726424, -0.7689303778252107, 0.15677785288873894, 0.42146092260824625, -0.14391005245308802, -0.637112480705159, -0.6772375548891955, -0.6907696311821494, 0.02518726771651222, -0.5030113561698035, -0.49496413642603376, -0.6607233532631261, -0.5666258578571544, -0.5850253385867368, -0.5123716312164031, -0.25356736513216227, -0.5347627269494984, 0.632418348864664, -0.46050626914331133, -0.2951331863940278, 0.32590121938795713, 0.07294218005171087, -0.6538144354836928, -0.5558218662886282, 0.12188756444075094, -0.6910183864897929, -0.2710069690882507, -0.9640126759489464, -0.4941828802947684, -0.6305932220949345, -0.3538205971619302, 0.5062328596747179},
    {0.16237247348495143, -0.009861735563202549, 0.8322278685816876, -0.36115877353160264, 0.681341875514311, -0.05162176640752803, -0.15019293818985954, -0.12422056603010351, -0.013094447020786671, -0.6693789238828326, -0.5264553509025729, -0.1664555100622241, -0.5813696024312587, -0.7740659246024727, -0.37903843602857357, -0.7604782891314911, -0.6660125369146355, -0.7653158471086351, 0.22100703769057523, -0.7624510356471524, -0.8794119935883163, -0.4691893265617037, 0.5152745807519759, -0.6582091715445954, 0.6025985144594705, 0.060621264424518144, -0.8002116656022484, -0.6698109606950172, -0.8624965931891128, -0.2215240349876617, -0.17015292755815659, -0.2690770726348049, -0.19001092889123486, -0.5460411899044485, 0.4887941538796238, 0.41065223837021264, -0.41890307234151075, -0.48551950001679944, -0.59661461008524, -0.6570466538474447, -0.13096116524677906, -0.3745794181090531, -0.5743837943348059, -0.37738743167733607, -0.3517694469816273, -0.6090117052269246, -0.33091376492977265, -0.24805793846733043, -0.5588454216574095, 0.5900008436502463, -0.469898728794154, -0.34935533189147655, 0.36359483566750644, 0.025163478916356556, -0.6867570773352007, -0.33428059844551355, -0.11919355443802396, -0.5265425722468628, -0.3812802841194104, -0.6099927757625757, -0.5240493241227879, -0.6365893466320427, -0.47796180255841075, 0.7233903816638306},
    {0.1319331081227397, 0.14589162197931638, 0.6062097891915276, -0.31545288615930883, 0.5137194574532389, 0.2091987186800614, -0.06349626713786241, -0.32524293625325656, 0.30627955424812414, -0.6664329983202272, -0.3274824707310659, -0.3791640802449369, -0.6587673985993057, -0.6717836364528594, -0.7203530138425089, -0.8488704645415008, -0.5350509590296842, -0.5091005136267788, 0.38747544047334564, -0.7538039139741636, -0.575280449687894, -0.4969687848776919, 0.5051823998408517, -0.6927264555863317, 0.19945762407582648, 0.1010598674765357, -0.6743569644320156, -0.578318152622849, -0.7219214060878945, -0.2445927425222327, -0.15527733776148525, -0.5796291110161965, -0.36429322274654025, -0.4988895396392546, 0.4275980963517991, 0.6078551814605352, -0.34049990376321426, -0.5230150968430514, -0.16365013997993408, -1.064675715175068, 0.16041873490800787, -0.28769987606413405, -0.3557893214330717, -0.5186591700830417, -0.5208455459800451, -0.5230086591723373, -0.486997995537657, -0.3178574716204376, -0.45342620589667787, 0.5765390844936689, -0.5185123892657945, -0.6378494802321376, 0.0738738594865125, 0.17190633478954453, -0.46822871037429986, -0.46848430843772554, -0.05050305765768102, -0.46808701612905923, -0.0882755430966216, -0.56451411492122, -0.39791394169699007, -0.5481132057231755, -0.5270752014245362, 0.2568650453621869},
    {0.013567674862593066, 0.3537421162488499, 0.5076487865543505, -0.29022481952530244, 0.6529411912308487, -0.15358424884877234, 0.00016555936004790687, -0.3395832680307438, 0.3170367585233923, -0.8280363408525364, -0.4898651046634223, 0.06317694012311052, -0.5338989716229402, -0.3332228204947208, -0.5562736690078105, -0.4646215881734481, -0.6433138039630851, -0.5267726696990791, 0.5130665476378795, -0.5887739769262702, -0.711808050520186, -0.4531394535345005, 0.6750941774661354, -0.6374194614827899, 0.5755048571624732, 0.27818428426512953, -0.6896047437305034, -0.6021948048489546, -0.5835436391181448, -0.29035725118495154, 0.1218854789156559, -0.5663562028723799, -0.37280233864108897, -0.48304975649324206, 0.4478912090490496, 0.5578651318678907, -0.30366856365970807, -0.6871044555690291, -0.29273005554885456, -0.6324030818106507, 0.22281626294862564, -0.5962319860987858, -0.27023416875017015, -0.45209776624978165, -0.3530688193221712, -0.67921396940833, -0.4276881405875143, -0.22304388251782187, -0.43499939883122346, 0.374763746495104, -0.5795008692329401, -0.6439552147201855, -0.10130496536646127, 0.1217082952177076, -0.5569952289384675, -0.29640124016673564, -0.14813080740998733, -0.4623590379045619, -0.2555801136025436, -0.7596460799175089, -0.5002213185392655, -0.47779106194004367, -0.4145298475207283, 0.6207172202405107}
};

static const float b1[64] = {0.5719965945443769, 0.648371566299992, 0.7528182804787884, 0.7482612026512072, 0.7850873172419666, 0.7430371904383017, 0.8112842690140354, 0.7063832170518591, 0.7477367749654363, 0.7787534939695827, 0.5873825604946501, 0.7293224987133873, 0.7865064930968163, 0.8192867946714927, 0.7126831691893014, 0.751130284043764, 0.7872039153564384, 0.728794070649145, 0.7351516303429891, 0.7659360338384031, 0.7502287160243294, 0.7274612513618489, 0.7356735003674204, 0.772223914501203, 0.7727716006550589, 0.7683279350114726, 0.7723264332400447, 0.7769665563567415, 0.7603647797156886, 0.7479412384119523, 0.6382882319007461, 0.8026548647018265, 0.5365138498284369, 0.7477101027896073, 0.794600888691286, 0.6663400298707143, 0.7690817339651276, 0.7641444360348716, 0.7866902875751396, 0.7651862307591889, 0.7877272949200537, 0.7449282090126353, 0.7138999798949578, 0.7167881332045712, 0.7809678605153798, 0.7985546930335256, 0.7933439675091882, 0.463490823590813, 0.7949440101538111, 0.5662376167904006, 0.7345968377601062, 0.7810536366213849, 0.7476710677241314, 0.7354000915427455, 0.7158283090542016, 0.7920740789511611, 0.7949418507332335, 0.6537717425906745, 0.7213367957158958, 0.7102799710757399, 0.8021162919842315, 0.7408010658583218, 0.7447360804248434, 0.7816283395102052};

static const float w2[64][32] = {
    {0.5015926006098329, 0.5113643320411878, 0.7901766339812083, -0.35818918365482977, 0.7724917995643791, 0.46577614364760006, 0.6903097261872241, 0.6212115924307299, 0.7979420013426901, 0.43708739019682014, 0.7963522504411756, 0.4113396620947136, 0.5406571381356369, 0.6091320079313882, 0.7273289941990462, 0.7209187635151639, 0.5429840537917786, 0.8310438692975844, 0.9985783465763809, 0.3221379421411908, 0.6686057481533669, 0.7367157480409824, 0.30935755739411563, 0.6565352038867158, 0.5047686392070424, 0.24674800932225138, 0.8959199162011078, 0.8392564548295386, 0.9595446416983109, 0.7628424676609146, 0.47762226524040924, 0.4849142905724895},
    {0.46583967346839616, 0.8397053603492082, 0.6542670111096829, -0.12979432782157202, 0.6536466216517776, 0.4851856382907352, 0.7865471760292625, 0.5298844175804187, 0.6168470949546314, 0.2382667161906601, 0.5506960896791621, 0.6502441536658738, 0.7039498921780658, 0.8209560800203475, 0.44615650482514013, 0.5735745242750883, 0.6650524902742614, 0.7254113766704104, 0.6778643997800449, 0.0533679603710867, 0.5995544612561869, 0.514223888271619, 0.546338701536262, 0.45456164508123714, 0.714639304056848, 0.1254453222585988, 0.9217879575078028, 0.42933497478619903, 0.6372958239711625, 0.47687072602313246, 0.8201914119995832, 0.9082149278622487},
    {0.6166422987107855, 0.5302629798047125, 0.1896255732909918, -0.019505850248904076, 0.5437548636082553, 0.7257462867582237, 0.7473104228747258, 0.6840044645699894, 0.30977228028390075, 0.4873854708310857, 0.6392437375392456, 0.9215634196372399, 0.4761322175783596, 0.7147719793429419, 0.5209639584355295, 0.605278371744795, 0.6383415338581953, 0.7279523943956289, 0.6108692683786124, 0.6085508484073529, 0.5720144501234401, 0.8601840184797077, 0.2990334831546492, 0.6945608570846454, 0.8325560521544204, -0.3259346140070774, 0.5242042523356308, 0.48780801737576956, 0.6873881091723829, 0.7980270840913418, 0.7389931488498113, 0.7878925266146765},
    {0.5654972570848108, 0.950534263685118, 0.564471332410396, -0.0741708131698486, 0.6943577333300369, 0.4695776590528376, 0.7534670781542938, 0.7367796663299412, 0.6907934281018068, 0.6373663256666793, 0.7096066327025314, 0.7681345155153043, 0.6128116969517651, 0.7132018599495025, 0.535162934672256, 0.5006790478315133, 0.3958457287168154, 0.6498692074085343, 0.7146149027621748, 0.3528387703738182, 0.7090733955937515, 0.6934018291351801, 0.5862573581779233, 0.9723870071776369, 0.9941786635657308, -0.01113790606598275, 0.5205735861345246, 0.6890255892439817, 0.8360287434561204, 0.9666974670160572, 1.1330578935570348, 0.6729422195714795},
    {0.5807859132282123, 0.3822713157292944, 0.3968729280917467, -0.17901640456176524, 0.8854861041930799, 0.5576098999872641, 0.9116875743389383, 0.3753376613182619, 0.5315624820313433, 0.6099798946251243, 0.907535789443564, 0.9829922325575857, 1.0031119113807268, 0.7864374692316237, 0.44345203286039214, 1.0257511201649876, 0.807792977233954, 0.6817793477614055, 0.49289720137922033, 0.3434932158757393, 0.8991443139663788, 0.5953358497443197, 1.009126359689601, 0.5402230761805553, 0.5059345657047181, -0.43531761094597443, 0.6633951698417011, 0.9805177370251545, 0.7034077586223799, 0.4163712925569138, 0.8394124787313131, 0.8170098495198318},
    {0.0979215257945204, 0.6538365102106376, 0.7750524395120265, -0.2230330410947187, 0.4385153137751995, 0.32863348353053506, 0.22358338531203265, 0.4115968862950953, 0.2628909670931499, 0.6441230528515577, 0.8332819362842245, 0.7276976209133968, 0.6619443923116829, 0.5326114525784514, 0.3100415383132659, 0.49961004760684746, 0.9617672118041054, 0.9355664444127062, 0.7100374897458316, 0.3653213590235116, 0.5195405115953674, 0.8180261153415253, 0.7474233381214045, 0.6388484237834815, 0.8659167466293666, -0.001753449980897558, 0.5826718212928054, 0.3616963291294561, 0.5145570575731542, 0.7769369262480614, 0.3217404379381236, 1.0052804067412622},
    {0.3097655358756456, 0.47628281284126456, 0.6252336021622337, -0.26455353213334465, 0.969280207768978, 0.6140435865783118, 0.7103828363475161, 0.21272896470182667, 0.7253650494857037, 0.8695765683069387, 0.7506835683925751, 0.9505979302463469, 0.4973790104723432, 0.7305656974339758, 0.46708315082339336, 0.8758133953643567, 0.6327394183144653, 0.584407509878881, 0.7337759182007099, 0.44488420846257104, 0.2991143187449352, 0.7359187023933896, 0.5610280369736428, 0.9245630648412678, 0.6455546641245722, -0.11847887467271531, 0.6231707509146869, 0.48952798411681975, 0.4320355920011415, 1.0691601232799415, 0.6227899395309923, 0.6336447409168231},
    {0.40293336954809444, 0.8771002879776877, 0.28299384079403084, -0.04054436966484341, 0.8825051176986222, 0.4810115295939957, 0.6257595492124468, 0.6630929591605788, 0.27706352257679095, 0.3883941190614467, 0.6529184646104017, 0.6541007191601829, 0.5284261272775239, 0.4721293156602203, 0.5863611081065428, 0.5489214146763701, 0.7023153128898151, 0.36023081754617786, 0.32421930713525077, 0.10036869974203991, 0.7918851463777354, 0.5029317312255216, 0.6815899857618805, 0.6987218055227202, 0.8568116385288385, -0.12712327463469722, 0.7141985995906116, 0.7355032278773213, 0.7629987086396529, 0.9414274801491959, 0.60960100390616, 0.8829301568474677},
    {0.33508590525424886, 0.4746042404101957, 0.535571479029397, 0.1957856850643764, 0.9293563790857073, 0.6027215511748454, 0.8398683613940718, 0.4910026767956374, 1.0144071218909505, 0.4541699153079096, 0.5014982489812273, 0.8481488602436991, 0.7791001710479883, 0.7755445962874353, 0.5147275018837433, 0.6591307208858332, 0.678417773426476, 0.7277571475378669, 0.8469818669916882, 0.5255396981845055, 0.8070411519088878, 0.36369590620687403, 0.5970242857564203, 0.8439174469626014, 0.5538027750448402, -0.08279074976712235, 0.8460388717769985, 0.5874341542735174, 0.9028417777001723, 0.8602655664382942, 0.600868708062562, 0.7180198837157716},
    {0.6170516788646411, 1.0304854193851314, 0.5932194964114635, 0.3347666411823149, 0.7117322597000578, 0.7316986823868195, 0.6430537058816866, 0.45563497626880495, 0.34629798475267026, 0.7989983729279555, 1.1446540072058111, 0.7098278740530392, 0.961282917045895, 0.8223335249291441, 0.3449982177759251, 0.6837823889431722, 0.9273302526848816, 0.6627561093496811, 0.8211500955261694, 0.49205491299449094, 0.5785889320912185, 0.8146993005089446, 0.8634200200870875, 0.5744158817003383, 1.013451415633715, -0.13750787280351373, 1.0801244329429018, 0.9143554777170405, 0.49757838164333723, 0.5291788032905278, 0.730934814375394, 0.5948664405005312},
    {0.6738164657373579, 0.6140904854267693, 0.4582775809863173, 0.11272764472849128, 0.7382519657358032, 0.7421350965688178, 0.16489820582666143, 0.1650825188458004, 0.6044699578156875, 0.5136756800317002, 0.7412016621134215, 0.8427323185839234, 0.8513570046691037, 0.4464775073989931, 0.6308396584746375, 0.5795274226618592, 0.6207742723592194, 0.8640093503159327, 0.8726292200879946, 0.3818285399017692, 0.6130116600313337, 0.34126576364671235, 0.6697463703091601, 0.7267703457672132, 0.5199360022172648, 0.09037937105777365, 0.7801065308315289, 0.9125469917498152, 0.8043048221699615, 0.5192753143514482, 0.44029831723389445, 0.7308006865730453},
    {0.5390363811299501, 0.45021919922688797, 0.49836218531332116, 0.24281662544583862, 0.7475646742417483, 0.5199694088104821, 0.5338914472300423, 0.5423543877589602, 0.630544367414243, 0.6650814821333241, 0.47992882225542455, 0.7367889571543627, 0.9775543400746676, 1.005568953666548, 0.5552509415623377, 0.35577895648984736, 0.5883381873232892, 0.841256736373063, 0.7245992890335122, 0.48209976405898974, 0.48588695393743736, 0.602288756127418, 0.7148343057332416, 0.8071850154346034, 0.6305248174921092, 0.12989538407042797, 0.8273292846332484, 0.3466861252604301, 0.5600153733483947, 0.7295271337951516, 1.184010999029178, 0.3250247115064913},
    {0.15283189406753922, 0.7381422823214602, 0.8461082703365991, 0.07664438460585554, 0.6537171451199855, 0.6109792642458016, 0.7133812373467653, 0.3494552193038524, 0.20260868185676784, 0.7944356743429563, 0.7717842220849102, 0.9342163477591541, 0.23927512565643494, 0.43341164912405755, 0.5542053045076822, 1.0303042328953007, 0.45751654172225337, 0.7077734184631087, 0.9423244564316896, 0.22844035831682202, 0.8344611707226686, 0.6812250080805586, 0.7875581974038539, 0.6345115398974361, 0.9628454130882415, -0.1730018946131578, 0.7246893581026017, 0.7067442869663936, 0.6801427586850328, 0.854791880592844, 0.8412669525150005, 0.860650800103525},
    {0.5343506250821883, 0.4952056813343343, 0.6891028531668575, -0.08896723115010442, 1.1136220981747023, 0.619282783639386, 0.7924452331667348, 0.605156745064059, 0.4442592377791249, 0.40052915374888914, 0.74307912195736, 0.8586362310618659, 0.8566406210225168, 0.5210786106146087, 0.541201338038038, 0.7656965783078022, 0.6056095443620874, 0.8369719360292235, 0.5340604170282014, 0.6983531997191257, 0.668883195758042, 0.7146626040162265, 0.889368048410402, 0.6733653382764926, 0.8280101410699374, -0.22682710559502278, 0.5028640435509407, 0.6043911876363376, 0.869729970287247, 0.8568578120975646, 0.7779670397843406, 0.5635699011416854},
    {0.7178989242536014, 0.9423901368040152, 0.4917102349720068, -0.2883775027810393, 0.9781453285779756, 0.880967219929994, 0.9308218166204981, 0.6171911160851526, 0.8254571377603346, 0.67692779450448, 0.6923666327522471, 0.4739605836458844, 0.6384908662093906, 0.6036467739921307, 0.49850593542188043, 0.8021841345710312, 0.438239695372968, 0.5360586627507431, 0.8474737999647305, 0.2767939155865602, 0.6360166925507511, 0.9041850089520369, 0.9402534234293217, 0.5966419299615703, 0.7429993724878038, -0.346871633947827, 0.9167562111026696, 0.8025013996253324, 0.7901092487997226, 0.5364064478578034, 0.8105297843308666, 0.5957632343011665},
    {0.2781166654555319, 0.2927774331466023, 0.5641144101448661, 0.021254975267549547, 0.9409478318022393, 0.7827046550279236, 0.9105194436950267, 0.43190748874405765, 0.37600959789509797, 0.517019970871791, 0.5884845452129106, 0.72704289318932, 0.5624834671743202, 0.8161957069847094, 0.5760244908763544, 0.675481683449838, 0.5668744058335461, 0.5714940435927216, 0.9020999652451894, 0.3965902519758038, 0.6060093820145203, 0.9683006963248627, 1.0223143908210337, 0.38013801878733305, 0.7825436960701074, -0.407414989332883, 0.7987751947298765, 0.4533697800664414, 0.7988181791117094, 0.21582222346104346, 0.6931903895150953, 0.602497841658278},
    {0.16599183501316622, 0.8038793677141711, 0.8821857520480343, -0.30646515006646374, 0.6764505525700557, 0.62715492396717, 1.0287136554554073, 0.33198924484958464, 0.8009618784540602, 0.8413338522402886, 0.8346142068866187, 0.770410372493394, 0.7049982554343627, 0.7776613672406196, 0.6605730731807411, 0.2958574969405453, 0.6866531623900514, 0.6544618583969884, 0.8808797835211131, 0.2766455322569733, 0.4341385706298581, 0.3262409038915662, 0.8619325523399758, 0.7880119256196394, 0.9374743038167854, -0.23062453605550162, 0.6619721291082584, 0.6125095227873205, 0.685962360188633, 1.3849700619908727, 0.8207432332911135, 0.7045249106933184},
    {0.3742114019478315, 0.7322857991375111, 0.5553110892498692, 0.1191629138422024, 0.46775612856084303, 0.8052119645326299, 0.7981359588783015, 0.516526951438438, 0.42086726264242524, 0.4396648573673115, 0.9139062124072707, 0.9326392241519817, 0.7830113510238742, 1.0046380571809816, 0.5035380836027649, 0.6119759769022289, 0.6935889445924244, 0.6542218909226772, 0.8897353343426744, 0.6426382338012078, 0.615081433139102, 0.6636448608705573, 0.6988669984511826, 0.8164079167790602, 0.8208768822600482, 0.15781862417389497, 0.43940903407559445, 0.88048776336789, 0.5445374598463801, 0.6653922965211528, 0.5921776430972189, 0.6272823766768824},
    {0.4544718934241981, 0.9077834089211688, 0.3901404902041629, -0.1199596524897391, 0.6769887491701659, 0.40386119501269957, 0.5832470592130806, 0.4907153756070486, 0.5466187773629257, 0.5668910384404053, 0.5108386133705018, 0.8643249208835186, 0.6621448291043871, 0.5715203768151984, 0.7280666441311849, 0.7033994713386712, 0.4602194298885521, 0.7762695847322099, 0.5014526823480416, 0.8319993307047417, 0.9252026571905165, 0.7694058147516067, 0.6371733229359114, 0.8809951509632276, 0.7878128823143453, -0.09798788434117518, 0.4978642973559724, 0.9595648865185622, 0.31364223501960525, 0.987872964481961, 0.6880453078362282, 0.5108262107927085},
    {0.6219537621991637, 0.4451002066871084, 0.49654808840626247, 0.015767858226030353, 0.8313670044538823, 0.5208803362003994, 0.8233699483342878, 0.3355413455263073, 0.37735381224668346, 0.7150353183644759, 0.7409765749308386, 1.1616541008142807, 0.6813765575307504, 0.5547811122614958, 0.5494892638584025, 0.7787660020680175, 0.8044019566072416, 0.8140733075719351, 0.5915643910630389, 0.40098676894102475, 0.7153322661603947, 1.0966844505639217, 0.7881323703930182, 0.4060476636706895, 0.6511192541270171, -0.11691414294795353, 1.0682404066200253, 0.6913806153037048, 0.651956131949413, 0.7573802998341415, 0.5906448086182835, 0.43012799885536296},
    {0.41555922790381333, 0.6343638729814155, 0.8267923622041594, 0.057767317314664696, 0.7942721015771614, 0.5465218292339075, 1.0126355231932962, 0.24796502556178174, 0.49021282131137195, 0.5468703578006882, 0.6661213835446977, 0.7191784649599434, 0.3798847535396362, 0.6356043458458581, 0.6573586484013391, 0.7591777944950067, 0.6472960729137094, 0.7827693700594128, 0.7662471527215521, 0.6119373066621715, 0.7049035556997348, 0.7678736882053525, 0.8881751576502456, 0.8419876313338848, 0.8614096141831905, 0.20254091552438103, 0.45271964457262054, 0.922692508709752, 1.0180783960630222, 0.9831913591812892, 0.39963358886213396, 0.796180249911134},
    {0.6446791815657759, 0.6832339190687722, 0.7700647385019398, -0.025377850623918882, 0.7868418715852791, 0.37799507326774456, 0.9939480048881275, 0.7049857353050275, 0.6270892814446958, 0.6508780861865161, 0.755729924302506, 0.739576133070306, 0.8346042102389595, 0.6326971286399248, 0.6384658544793048, 0.5561991067920059, 0.6755952707812468, 0.8473292969875249, 0.6234215476906587, 0.720310454627076, 0.8124308714026673, 0.840063129172461, 0.924128921774743, 0.5274427858627744, 0.8439701357293309, 0.04263340679870515, 0.37111140268076886, 0.9482246100051342, 0.5792879112991496, 0.48629825438131263, 0.6300301850888608, 0.7643146880354138},
    {0.5334133989217279, 0.8100097143337375, 0.6295533257204053, -0.24104857866659213, 0.7929363706952737, 0.7183526816993014, 0.42440186642998495, 0.3046619570949943, 0.555160012858692, 0.7905254524564376, 0.40719007508563326, 0.6434918400334797, 0.650899359158235, 0.8613683301878367, 0.7441320120027278, 0.5826232588814734, 0.8283388387039957, 0.8164250096091114, 0.6922818814671424, 0.23433867368082997, 0.8543148902171276, 0.7978568184870954, 0.5920640154235487, 0.650948346197901, 0.8052119723031552, -0.047741183314734155, 0.6409801434253747, 0.599545802012497, 0.5984358681034416, 0.625676886408305, 0.8994233009113014, 0.6025170429766501},
    {0.2943073517730237, 0.8428634038548979, 0.6169649997271747, -0.2799674435768261, 0.7425212454398924, 0.5508897057177654, 0.5748684663669101, 0.5469783750395502, 0.5011112737901258, 0.7671039566698037, 1.0023304752708333, 0.6807225145693754, 0.6625711916918099, 0.5952216212548335, 0.6943323083764716, 0.799586716846019, 0.6365687873969799, 0.7553156192855849, 0.8097320673255882, 0.5494470557999199, 0.6011537610958498, 0.9713380128556919, 0.927118829382911, 0.3582793863722867, 1.0445368297477533, -0.14006490921225664, 1.0723174141546912, 0.5778548331147342, 1.1860595026421068, 0.7512145772243429, 1.014397454690123, 0.7848950548926052},
    {0.4590414967377813, 0.6008471556406356, 0.5162821126269056, 0.09864730902132926, 0.7559677103441044, 0.6596220164667645, 0.5040540441510809, 0.4014083998963748, 0.422181119934329, 0.6910894663924133, 0.5371300477518589, 0.577867625584954, 0.5470631988614892, 0.7900189927114126, 0.4778194301222095, 0.7736515599824297, 0.835427472667583, 0.4403590478328092, 0.8394864400360127, 0.5526369803842741, 0.673220478594688, 0.9526612848000005, 0.8153541246992833, 0.5962110206962993, 0.7761513840727167, -0.06696972627868739, 0.790431768777228, 0.5613124605942614, 0.7936415441063669, 0.8641722954275617, 0.7362694475321837, 0.9308779038508576},
    {0.5030858997177855, 0.7915178199761209, 0.45176146383942806, -0.046609720898514145, 0.5723956378206184, 0.5009906516118258, 0.6463063821498463, 0.36721366865134103, 0.8589572264065805, 0.553170976285409, 0.5839591469617285, 0.9446007695315379, 0.7455367038888234, 0.5886939642393354, 0.2940862431295411, 0.41442650317387364, 1.0525579574993327, 0.6819824763926002, 0.3966436612343746, 0.655412197232959, 0.655388900031058, 0.7057716860428158, 0.5573035564295804, 0.7361432127577644, 0.715655312405388, -0.11005921076829943, 0.948447849664426, 0.5258757553978008, 0.6921387899846568, 0.8787776764152057, 0.6815065544929697, 0.7113546659842953},
    {0.57024165978315, 0.7428417273083391, 0.6426370765269486, 0.03651856104830968, 0.746647599360269, 0.6727221147980227, 0.571266779376975, 0.3617574874861371, 0.619696511013013, 0.7077033302355912, 0.5920249856620182, 0.5267189427739085, 0.6705679760186131, 0.991070759377712, 0.4144568509348074, 0.786783369106129, 0.8200666911849126, 0.7471545786057244, 0.7849895192498351, 0.18487850988241802, 0.6901024654363267, 0.6795053850174942, 0.7481559983282005, 0.5561236959338705, 0.8871770665858356, -0.21267180807977654, 0.561682382019617, 0.35194043895678423, 0.6698386428601792, 0.7930440126865461, 0.4404706638880203, 0.783379146532485},
    {0.33476609395897855, 0.769812732876605, 0.7241758605597379, -0.011022919999901402, 0.41343914928069225, 0.6772686536980546, 0.5485042323736793, 0.5859561037760428, 0.4011453695440892, 0.46528915922706365, 0.47309161318199916, 0.7850182373592177, 0.7745259231236079, 0.675116416560706, 0.4460458887314964, 0.8501038451707776, 0.76672187252924, 0.5116559388153065, 0.7971850238009682, 0.4049068642241059, 0.5704112031712922, 0.7599438698011128, 0.530577313275465, 0.5403494083647615, 0.7107235225484977, 0.03662513191668412, 1.047285134155011, 0.27287216806426223, 0.4913567315920148, 0.7155970714178813, 0.8761926804311269, 0.9153988129709865},
    {0.45694598570724293, 0.9079988348285701, 0.7308544403842983, 0.03133068770048193, 0.41598111423798173, 0.7177578795457769, 0.6516916685298298, 0.4759249334548365, 0.6405300244659147, 0.6715492859213215, 0.9391977608463452, 0.9809620406359829, 0.43100248616301257, 0.9980294961174774, 0.6093793928165808, 0.3826771804908724, 1.108214439534383, 0.5376343636616835, 0.6861419960335362, 0.14743239703071775, 0.5899181917211356, 0.6436346280083958, 0.8125083973113661, 0.5288232298211951, 0.7249092084243086, -0.005892171802815314, 1.1390848595790852, 0.5732333857874488, 0.5575174207548214, 0.9234342033544031, 0.6367343550434232, 0.44741214051367606},
    {0.5927622451379609, 0.5761897554331861, 0.41564614865276345, -0.04319187341708375, 0.7125433086139096, 0.7129924079123877, 0.685964409098779, 0.298728433157455, 0.17848113453383488, 0.5736487424534582, 0.6904950237897388, 0.7263809326821055, 0.684126903308105, 0.710878286412579, 0.3299594704646757, 0.6822701536345875, 0.7778414709904704, 0.6122565527983591, 0.8076861097197312, 0.40436679627629396, 0.6149575921889555, 0.677647290437638, 0.889837154989056, 0.5920217644665724, 0.8233208851949074, 0.2905715285668906, 1.1392536896894379, 0.6298321586581809, 0.8247733705023284, 0.814715171901417, 0.6232752606450561, 0.5379612196402952},
    {0.41954349539079405, 0.5584388964520022, 0.8038022280973788, 0.2782795597246175, 0.7636883875245617, 0.8273284616122495, 0.6320809453543692, 0.8396353163070102, 0.5157603796463517, 0.4831267869177467, 0.6804907390611603, 0.7767479769109078, 0.5710474191217583, 0.9378067750664426, 0.9334227379818966, 0.9986996513611107, 0.5884995569446372, 0.7579020565062785, 0.8480119209585852, 0.42065541272903967, 0.8774405624686198, 0.8722379254747781, 0.6350317432581175, 0.4312675511977206, 0.4761794769285148, -0.09696226608655675, 0.8464554713593844, 0.732183138013821, 0.8078709695166184, 0.20497529505702736, 0.7145921672169563, 0.4991570082095722},
    {0.46431800438543924, 0.4934126761950364, 0.6083626009999731, -0.13325675441895335, 0.677045346079573, 0.4653768473945801, 0.8752784079338473, 0.2908440911668661, 0.4731030216255491, 0.38976007724236883, 0.8930795544809154, 0.5950302155114436, 0.9120356200861214, 0.7425505163388126, 0.6263996590565212, 0.531786625854878, 1.0307616988359798, 0.7824777835448451, 0.866566570446709, 0.5315660279288278, 0.439608353069902, 0.3966589449089835, 0.8387899468119565, 0.6500773462342279, 0.6050397617489037, -0.1884984724539326, 0.5740266920718519, 0.6778049795461999, 0.596611085072274, 0.7241954242663259, 0.9346444612689843, 0.8789340813956882},
    {0.36484960617728457, 0.7126606615931618, 0.6121406729851159, -0.21753933155007563, 0.2854929829534434, 0.2803477082111232, 0.8334800386201839, 0.34437804431891983, 0.6889927834599159, 0.5578641820252571, 1.235086095513057, 0.48707139434401053, 0.7269921089696836, 0.6884206592635228, 0.6104518846895156, 0.42121825734977414, 0.8351097404126339, 0.4795571898301076, 0.5373491923801591, 0.5086510136227868, 0.6849640903293692, 0.3019593610152913, 0.6433572640543578, 0.8569436996531107, 0.7870617171582687, 0.004931464607284561, 0.6906899724189013, 0.539698943556219, 0.5440027449096644, 0.8643125045457547, 0.4676522723469023, 0.3650589653162901},
    {0.3668577483021361, 0.8705033143753178, 0.6331928862268181, -0.16369523436604994, 0.8970405939547021, 0.6347343249749218, 0.8659983535372812, 0.5202685659993865, 0.4910722586682166, 0.6848196443106398, 0.7394951092042092, 0.7886842197130403, 0.6433568299929839, 0.5984072360419742, 0.5652311014044581, 0.8033674784195536, 0.5503544158550201, 0.9627982366302741, 0.6906271113549673, 0.4429708692593462, 0.7122883318460206, 0.6606274651430959, 0.9028325062490866, 0.6216809485924902, 0.7609480791520108, -0.45055931107640873, 0.5496165273656476, 0.8082093395524373, 0.41174059252037726, 0.50732900075818, 0.7188231510462951, 0.6348727639705912},
    {0.2427247113349968, 0.615460226926657, 0.2971995956154008, -0.1028301740986204, 0.6923066373025072, 0.6765879189414226, 0.854359873157054, 0.6676695710299896, 0.7379093300476393, 0.76899167674109, 0.4044206976040907, 0.8107349219514225, 0.8518980650898137, 0.562203371239027, 0.5890207745068899, 0.44073962770363717, 0.8574619818548391, 0.8358430324400747, 0.8489927326915362, 0.4174239941276737, 0.33809109674097226, 0.8272613019862753, 0.6187158812680106, 0.7866252145132797, 0.3645184040292601, -0.04074368327590293, 0.7423916590177925, 0.7202142563902139, 0.4175368464545178, 1.130241578496307, 0.6698920531078987, 0.7673793718139212},
    {0.36843270182389404, 0.4797833625710372, 0.5424289757014198, -0.1676400777779724, 0.9163194685452837, 0.46481378785192023, 0.3842016521872216, 0.4999960538944953, 0.4792893889590989, 0.6346237165221115, 0.5279956346230738, 0.748251088312641, 0.5503885766472666, 0.8582727572359752, 0.4406872632854388, 0.4779688105694943, 0.4973508934995654, 0.581822281142089, 0.6976889045666418, 0.916920203230416, 0.4813756724359644, 0.7929406720885588, 0.36418392630205865, 0.6300377964891658, 0.46037276752194, -0.2200205421976574, 0.5379646855083815, 0.7654989395717179, 0.7289566023703042, 0.7156281197512203, 0.739037289639658, 0.4112719050127559},
    {0.1980568818358971, 0.5386908306564419, 0.45742914856333033, -0.2707565154330384, 0.7274550811970628, 0.760128542062951, 0.8994538600193248, 0.7598002924593665, 0.31504889732878244, 0.4326104769475857, 0.7152292792803489, 0.8229733637693158, 0.6075541470785621, 1.0232252422234636, 0.3113652770982251, 0.6821588723095372, 0.5356438770074161, 0.3646573201914257, 0.8462169351897972, 0.48391166850469536, 0.981435249381284, 0.7592451369206059, 0.7190161553900948, 0.7522851562158055, 0.8215654252054239, -0.42085575864210917, 0.6315888728934196, 0.37058878849217436, 0.6509849393863395, 0.9500920446278169, 0.5712421328355392, 0.9657163918727913},
    {0.3977713418059057, 0.5176201528435792, 0.8779415669340408, 0.0645129562389766, 0.5994745616140028, 0.9085492955069343, 0.7174374230875121, 0.47110058797688376, 0.36536505531061336, 0.3654904977675001, 0.9500424325173006, 1.0612897223430153, 1.08689348901316, 0.6565587780200007, 0.27984966146288653, 0.6771385269905011, 0.7829087580100191, 0.6606958181277648, 0.6508118569502721, 0.7806678564272453, 0.9863817248823802, 0.6821941815266022, 0.45769025049191225, 0.5388334739214681, 0.6038856295087249, -0.11619244752427518, 0.711175043785174, 0.6964217026623777, 0.3151966457571134, 0.4204858552197207, 0.9433070663200134, 0.5303066725120574},
    {0.6593685665372332, 0.907889744844383, 0.5744526565380723, -0.11875515495492044, 0.7311564055965099, 0.7793492472090803, 0.5760335647905921, 0.4960482700104482, 0.3174812990948762, 0.7103412180661868, 0.8613716952426037, 0.5815125165684607, 0.6638088273272115, 1.045588167029948, 0.5820301398550289, 0.6859308688806006, 1.1187163837120198, 0.5155329862320222, 0.789736759044404, 0.16606942800077354, 0.47475284647755506, 0.5781464375717253, 0.6934376252611298, 0.5018278838009183, 0.8397485745075873, 0.043203148410016934, 1.0250059988408713, 0.7504989808980709, 0.3016365523236408, 0.5947142338382468, 0.6530464494848549, 0.526133903668761},
    {0.13887013395810904, 0.8569426587348145, 0.726198006721025, 0.05264145370821027, 0.7117628584218288, 0.6838470809700646, 0.8773485022231731, 0.30915726378179614, 0.3726032801337445, 0.7309624322916586, 0.9437912750010142, 0.7207656684121746, 0.8736633303377934, 0.5309656902842382, 0.3036928417087632, 0.747627606392762, 0.8701762769738368, 1.0659132501446984, 0.744206605035392, 0.5706109675524506, 0.7186105663773823, 0.7673769376678828, 0.7326955128508948, 0.6698878003350033, 0.9921668126814337, 0.17428353463621718, 0.9071695636161804, 0.9882288039173702, 0.59428371481042, 0.5801061545178904, 0.8659381977608461, 0.8109521615164306},
    {0.6460344884264212, 0.822092644897106, 0.6357395384774064, 0.0011025626848209717, 0.8745717773031458, 0.5013021292248208, 0.643662497504479, 0.40868441832253666, 0.34991815643670193, 0.5279894995830304, 0.6614772709930244, 0.4341119641092822, 0.6697409366180116, 0.7817889800394865, 0.5654979958582168, 0.7630243322407753, 0.6672175652459915, 0.7812576362722835, 0.7543074095823934, 0.4712002018067096, 0.5368578070579519, 0.7782010731483312, 1.0204624567076093, 0.8041597107402737, 0.7400434997467638, 0.010198231670797133, 0.8974354698965844, 0.5700442198367968, 0.43459418027312424, 0.7101325716019303, 0.7936617983798828, 0.6065240892289103},
    {0.32895768008272935, 0.7653561897038148, 0.7410668447682227, 0.28649786590854287, 0.8433258854152123, 0.7389426571044587, 0.8215564219875605, 0.7462951522281546, 0.3730051386831007, 0.6614398260984792, 0.5089285402550394, 0.5700103910497436, 0.7198066825201349, 0.926860895322768, 0.1682636399415563, 0.8783043363008758, 0.7134804389017414, 0.5722195921101905, 0.734689439820946, 0.3576896852798651, 0.7718050470178269, 0.579401090527667, 0.8307902409630374, 0.7176593680377231, 0.4754624480319398, 0.07048951050640882, 0.8251481317909218, 0.4656316747639974, 0.29876381930371376, 0.7331826780828312, 0.5861215061675001, 0.24421867000196562},
    {0.4695339223825984, 0.8791910212192852, 0.6271579087987773, 0.019404248249730163, 0.6535225404890795, 0.5553780423760815, 0.8274767242840926, 0.7657570620398574, 0.6825033974256599, 0.6065850868803068, 0.8977237067440762, 0.6499935397103219, 0.702370126255305, 0.8539331760881247, 0.7606253851406825, 0.5166390021675942, 0.75081723631729, 0.6116458736170322, 1.1682633038856505, 0.7878499629291009, 0.8272287664362135, 0.5733104505587516, 0.7538488340869933, 0.44803623659536645, 0.5363883609901184, 0.009510710708283457, 0.7466332490671694, 0.7404827053414377, 0.5965599329716306, 0.6715118877627108, 0.449100056101138, 0.8580706227694769},
    {0.40496111062196094, 0.6354019204303873, 0.6768297970377347, -0.12380051517921552, 0.5505754694101339, 0.5714841262339523, 0.6015515923692633, 0.65298899331953, 0.20168815411775964, 0.5584506413559487, 0.8540364706640867, 0.8409775664304856, 0.8933850332027722, 0.7242635092404732, 0.49211646795111746, 0.5566187285566035, 0.689841825296157, 1.0359422292761475, 0.8178218950575349, 0.27901004187560646, 0.8624348802734338, 0.9838098930532257, 0.6016388234911657, 1.134296959752275, 0.6913275125992826, 0.05871190549709156, 0.7028153490670204, 1.0760563831294516, 0.6514277798163737, 0.7584801148633882, 0.8123186220013847, 0.600005523542186},
    {0.21167690293501334, 0.7335325275191258, 0.6056318445172928, -0.22297513531949656, 0.7889587907428999, 0.5275647957737184, 0.420343288346279, 0.5366120279338531, 0.6640713162355385, 0.7611672999213284, 1.0216105432170095, 0.44347801674083603, 0.9515305720340195, 0.8820893477334196, 0.7300834331011329, 0.5504869302270804, 0.8643839369215576, 0.7965353590541363, 0.5050516618929294, 0.4300293125189884, 0.7202359481878515, 0.5237656108627394, 0.8283714961493645, 0.5707702881032577, 0.7001509314392519, 0.11882630834662365, 0.7810191183870889, 0.5585960750761731, 0.796328760695892, 0.881111421533912, 0.745883939260394, 0.5804341779744131},
    {0.3630308001377209, 0.8316437654074762, 0.639522420623709, -0.23510657592832732, 0.8984208859055606, 0.6829933554394974, 0.8379557158624402, 0.31076012339686265, 0.5477779958118751, 0.6818606516144787, 0.4867629044155195, 0.7767999419451452, 0.5353328191729214, 0.8326485173874191, 0.5003118612733101, 0.9116398021156423, 0.8366194860767011, 0.5925960192024531, 0.9258656489038182, 0.44476310306932243, 0.6303567530860988, 0.5543945602793731, 0.5132213827324681, 0.785576001480521, 0.9813998384113434, -0.08893841284894052, 0.583602975986702, 0.8964619537564491, 0.619082184005104, 1.0061347167325831, 0.8182249589240057, 0.7586141527123297},
    {0.6775182916660686, 0.8943611943355916, 0.5900281580233543, 0.07450559569506764, 0.8372831376273662, 0.3634671640588749, 0.6882444526705971, 0.4619051331772298, 0.2766102130709004, 0.49860133821367025, 0.6693949325310947, 0.9542540663254162, 0.7057206265303048, 0.5181772411675095, 0.3420137494479816, 0.5875853647710655, 0.7404300176976494, 0.7741877475170821, 0.6262967605385071, 0.3602059673592398, 0.8487779621629998, 0.7892005449766833, 0.8238788401169713, 0.33216913438694606, 0.6103486721460915, -0.31764343679726514, 0.5084514459167, 0.9449093202648614, 0.6358225904631192, 0.7941146057788655, 0.8322130316340406, 0.8506272281878943},
    {0.5854797292260446, 0.43565900856721534, 0.7006814831888546, 0.03020896929505997, 0.602792595686798, 0.5406059558985207, 0.794668609346886, 0.4503193812650512, 0.2640697214952697, 0.8291936260433085, 0.44495694438419475, 0.5503641263369726, 0.8534298652008215, 0.5298240395345589, -0.051140123569151104, 0.525980390816704, 0.6688595595143817, 0.7531193298164552, 0.4433122533831273, 0.4613800993145934, 0.4777101825328432, 0.5519287638383962, 0.3931087942544835, 0.2684483832310991, 0.5224928933595342, 0.12986588760610673, 0.5847302490041287, 0.788637118324487, 0.4484521192536504, 0.4855621562905386, 0.8161105831476848, 0.7082706001011684},
    {0.41337930012464186, 0.09329978821646213, 0.8055646050304338, -0.05762878010345226, 0.6033912918859384, 0.6330845197174266, 0.5091198726630011, 0.8809494280641763, 0.3545778996763642, 0.7691828936914054, 0.77110035508985, 1.112279477006353, 0.6877739941254991, 0.9004179219763778, 0.42371302975982056, 0.6937907693646953, 0.8176149332974934, 0.6299016884077343, 0.6754753465558633, 0.42071708612716613, 0.1283235218138513, 0.7294393453535332, 1.048041654213657, 0.596114004034839, 0.6258493256517387, 0.12321166302137876, 0.7457110549374675, 0.5241673423774357, 0.5803045283702738, 0.684078747380072, 0.6339896344321942, 0.6660200670619119},
    {0.3109470564438834, 0.7752844068557021, 0.40867648509241566, 0.04143044625118459, 0.42792452360345556, 0.5330921025870332, 0.45394843649177496, 0.5659574417655229, 0.5663677095518943, 0.4893228035569958, 0.5444082233186864, 0.46373541739858276, 0.6963066085331044, 0.8191532612274844, 0.48125009281487424, 0.6063435399724232, 0.7335145520828239, 0.4219121246255707, 0.5969799792449112, 0.6283721533404663, 0.7538618343911095, 0.6344496319640878, 0.8656872311975609, 1.0570440546214865, 0.5506709400407971, 0.1152921437967584, 0.6014664297873201, 0.6711562526597381, 0.7633870890284737, 0.5234790605913608, 0.3861209748546027, 0.6531270902920311},
    {0.37540668028714136, 0.8105305257346104, 0.7071726122142588, -0.2586541123443023, 0.9046211813872274, 0.40814601845261367, 0.8928356945659904, 0.3225732987443159, 0.4429339824611133, 0.8098449201518797, 0.8477612660462681, 0.5242251544725811, 0.6361166985309149, 0.7037659057498733, 0.3589045476507146, 0.9360357528871938, 0.7432649431394776, 0.9496953807196402, 0.5332431480938499, 0.3597774058667737, 0.8741571886662062, 0.8190385815930963, 0.9602037718636445, 0.8278768369189407, 0.43349860034060034, -0.10545010874800202, 0.7291816194068464, 0.7207557513199887, 0.8646105512752946, 0.5991907202224276, 0.8299368142651276, 0.6128072705759451},
    {0.08663481323072791, 0.5916015788267941, 0.660388353315702, -0.18817551834503024, 0.6870156790962336, 0.9184422070215876, 0.5236756150394716, 0.3366731934930522, 0.587687644273925, 0.7359997931690302, 0.7626190690116567, 0.5838694531002443, 0.605148791863303, 0.6223474938514963, 0.5872866765778181, 0.6570774460452866, 0.6018697908095836, 0.8562994198276893, 0.6378652246358013, 0.4798999408506863, 0.6028217965270248, 0.8198809844631612, 0.5724476820362219, 0.5166442324597392, 0.7268273096101303, -0.055666683160965826, 0.9167777794838856, 0.9201923254573452, 0.507492839886043, 1.0274735369272743, 0.7428092596774484, 0.5880034124454286},
    {0.31685556964133715, 0.7639792747537798, 0.6505692078865956, -0.1985008819685852, 0.4171730851226004, 0.663650854597797, 0.579523441561517, 0.5493351695035078, 0.3634855085421671, 0.6063143659696935, 0.6501966917825776, 0.32942753253553037, 0.5120270532476718, 0.7534972262350653, 0.3021456126918811, 0.7939403807662149, 1.1302409809611869, 0.40380369796851523, 1.0717486173954605, 0.40079618680926576, 0.7266552260178297, 0.589766715495668, 0.842188822245439, 0.7067344954060887, 0.5081290357131442, 0.16773365669755386, 0.8826232169291283, 0.703053587076732, 0.43195654662859867, 0.6025061757610018, 0.7285737771089482, 0.6056992349230568},
    {0.5491552857322384, 0.6041629199968306, 0.5479253790729852, 0.03273129163628165, 0.6053696412939276, 0.9243664224411253, 1.1196129590997004, 0.3225700746930515, 0.4091248773423785, 0.8900502730846984, 0.7240801683361928, 0.9730836273856976, 0.6145993752562237, 0.6395984883270112, 0.5763967306415823, 0.5762134506288628, 0.7274210062751538, 0.6646764302106847, 0.7478359044049776, 0.5142833354096953, 0.7588272911462162, 0.8151931377644454, 0.58857260571301, 0.4653689453749411, 0.7171306663297857, 0.02289687503902499, 1.131864797637201, 0.6971760941262384, 0.9886568394738665, 0.4567352851004386, 0.8783622003838493, 0.6478085771189059},
    {0.46658011289182433, 0.8864385054001946, 0.5609721390356672, -0.017301538433155277, 0.5994623833402426, 0.7543723340467572, 0.6913166293920099, 0.47298251621664383, 0.608615491309506, 0.6590255476942, 0.6701544157255156, 0.49904195807690443, 0.44926430883426993, 0.6388358621387663, 0.4067020026859881, 0.8704000897601569, 0.7693603102925406, 1.079371916182348, 0.6458683089527999, 0.29644779244444214, 0.6590142928145838, 0.697258038948098, 0.5967296918677583, 0.3810004718217237, 0.7049459338676907, -0.3822229933144523, 0.930231739312074, 0.7395033519534595, 0.8106728400469676, 0.8328418073334009, 0.8095847494951198, 0.6932715569668018},
    {0.23589521631775145, 0.6025151124382699, 0.3182660854421416, -0.3543327076041753, 0.6412217326249595, 0.2936078284683071, 0.946839517334462, 0.8600649880212597, 0.5147732502620813, 0.38128694225682674, 0.7426670157415602, 0.6607386227252543, 0.8517814019787436, 0.6827700053034057, 0.4738938334260405, 0.5299378318986316, 1.1204672196295997, 0.7228092651352692, 0.5132853340249903, 0.7257844949563874, 0.8120700544117955, 0.8680142084399575, 0.8399559639267138, 0.8027393808467232, 0.5662616592889739, -0.05032140746428512, 0.5557148049520325, 1.08289253642969, 0.9156257282071331, 0.8200946291201584, 0.6689934491828751, 0.5783743325074038},
    {0.23452857517542125, 0.7588964734445849, 0.7647371992106161, 0.034866153914789935, 0.7609502222610891, 0.5730220353244411, 0.632241968542032, 0.628449957154126, 0.5426098994115172, 0.7943271448258264, 0.5082453920597698, 0.559650179973322, 0.8596131720614609, 0.6726725271944707, 0.6057984636979168, 0.5890685149823482, 0.8282409842543308, 0.5709002046335154, 0.5957596726521368, 0.6048885817624359, 0.6919715466492183, 0.7762186533426492, 1.0084877023986314, 0.8545628014203893, 0.7454740165346503, -0.19564796240421456, 0.892043158767992, 0.6225339355068774, 0.4816511682471031, 0.9428099163299001, 0.38618125922304325, 0.7167944514357981},
    {0.6471510812058582, 0.707848482616434, 0.417109032192916, -0.07674284412233087, 0.870459282242306, 0.423858295597024, 0.7971426752293143, 0.5731736476249152, 0.3778335420429295, 0.5509182475999661, 0.8663943349396865, 0.6334186220758246, 0.833336280590548, 0.5648427507221638, 0.8998188065092048, 0.7350426874912965, 0.9305564880221721, 0.6551389598510909, 0.6657088090731856, 0.44411456625433327, 0.6795598778588763, 0.5165755952627047, 0.6602508669480948, 0.7219464387915777, 0.5848679483003799, -0.09214623867557768, 0.7595396372526522, 0.5272120112876162, 0.699449403831489, 0.08210629947803678, 0.8987173239510271, 0.8381531811391421},
    {0.2534143251478975, 0.5381076733109489, 0.3687512699073978, -0.04885634319152675, 0.6915781843701612, 0.5560981536869387, 0.7539834623430279, 0.471380667175146, 0.19897379470490534, 0.271765637508491, 0.6468901711613594, 0.582027832871327, 0.7889415084584991, 0.5360336210393696, 0.43225642456232044, 0.6083324403237944, 1.0010308783105535, 0.8367970878793755, 0.4391725665010099, 0.5004103843329019, 0.6409499490216026, 0.3274362140300752, 0.9038638606681889, 0.5539694869444626, 0.8375820443487273, 0.39182270475032166, 0.6729334176243811, 0.6493031784070428, 0.6115506561716363, 0.7725178071551511, 0.446971602950992, 0.7338639425727251},
    {0.6185960351249292, 0.7171716556278432, 0.40462193427813986, -0.3474101474249462, 0.4146181214433438, 0.2592596694642872, 0.7094021794508659, 0.1867636379565911, 0.5297790772703352, 0.6706258323541815, 0.8146156525657121, 0.9072899993656117, 0.7351890539158908, 0.6440411930052311, 0.6441062155843947, 0.8748373661666511, 0.7527974867348465, 0.7609667321687055, 1.0295384798607479, 0.4310738300666043, 0.6367837899649793, 0.6649574303991758, 0.7105955787004036, 0.6675576746178581, 0.6286269221324321, -0.06316041343032126, 0.4149656837775153, 0.6607606843389029, 0.2328020948512392, 0.5485869601216982, 0.7707275658722764, 0.5116255394976656},
    {0.06479373139501807, 0.6349372320735879, 0.7764123602253403, -0.05316705970111084, 0.9776257254767051, 0.9936711983517801, 0.6579490750178374, 0.680159893896529, 0.37645714780181794, 0.866244283098922, 0.5530779200400194, 0.7708628249709039, 0.639883728748435, 0.7388479821852819, 0.37657261698379335, 0.7701899942741086, 1.0543969256739008, 0.7628228533562403, 0.7398870396541701, 0.7100655700251453, 0.6862054471004009, 0.587285322601653, 0.7709613897372424, 0.7533751185796768, 0.7176034317122534, 0.18065097485311582, 0.9735921559369558, 0.9570645075530749, 0.8276166289290537, 0.7840663041692385, 0.8323875172900291, 0.772503555880607},
    {0.6667448641722912, 0.7314999485543064, 0.48213431905896154, -0.20157017080613795, 0.7129888809636921, 0.5787109742803044, 0.5655368189967287, 0.36339575821839165, 0.7592771459252219, 0.6931458658425882, 0.5510120431555436, 0.6218449713324407, 0.8491918372953177, 0.8099643706858485, 0.8125058221758987, 0.2507272185537732, 0.7161131233330916, 0.891433836040679, 0.5266666092888005, 0.2795040228014906, 0.504612500600982, 0.9740931078867027, 0.8271537478992745, 0.4020867170152147, 0.894747261757963, -0.06551865354376901, 0.8987462475376998, 1.0096401204593692, 0.702927270722795, 0.8653412430184995, 0.7632323576087235, 0.48242464787527356},
    {0.6333754788319217, 0.7351683150599864, 0.5588895549193741, -0.17095465480467173, 0.9472985072620774, 0.7000367182970569, 0.65610643033961, 0.5244014889866647, 0.31664094003241855, 0.7849620341375078, 0.9207069799745635, 0.7490108969017657, 0.9579612505304465, 0.6013870046439908, 0.5307479224535937, 0.6282822784456166, 0.6319614295040418, 0.8046142252327412, 0.5933701284363015, 0.3692155094315869, 0.6381098123055635, 0.762163650611373, 0.7498582960382659, 0.6681932718690288, 0.5911320628869018, 0.15650638887364354, 0.5290485397096802, 0.7809702933035756, 0.7006957761221819, 1.0107851837470825, 1.032777633510891, 0.8366275601572898},
    {0.49686162341672246, 1.1108923181327133, 0.27125929598106613, -0.06418421303764514, 1.0783497208555235, 0.6107903980217646, 0.6544526555376066, 0.37136843429182215, 0.41240405342583447, 0.6104846139743344, 0.8336361886046411, 0.7809624608716774, 0.3659356312764234, 0.7534383777889179, 0.5964871297351544, 0.6791935224347176, 0.8026211240703233, 0.29351443176388486, 0.7457051653678213, 0.4945202436739181, 0.9589426196804143, 0.42054168181823154, 0.8552986927004389, 0.4506642841149561, 0.7599404128068815, -0.29232804488194597, 0.5612953829113042, 0.6979720813724258, 0.6759887603313846, 0.6761734071324715, 0.8585908651717958, 0.8626944404462968}
};

static const float b2[32] = {0.41228742635447324, 0.6396991920962148, 0.5996287297016697, -0.05160455740655353, 0.6725120670073005, 0.5485124879783205, 0.6961234677784519, 0.4321678856307978, 0.47792786995787734, 0.6227353752312522, 0.6553428649558461, 0.688882584797577, 0.633118147445248, 0.7006994648603968, 0.47531813957402225, 0.6450942769840325, 0.6901799974844683, 0.6538675309488267, 0.6839462576806493, 0.500731802973526, 0.684236484186864, 0.6351924520144495, 0.7015328041551345, 0.5694660393527158, 0.7115600338709299, -0.05316221150283914, 0.6973903744725455, 0.6771408749725772, 0.5630357332879418, 0.6754570998041722, 0.6801569318506774, 0.6385516266788677};

static const float w3[32][16] = {
    {0.4514151012504428, 0.5650461417549321, 0.7130098526547455, 0.4597055081372604, 0.8885372839643018, 0.1962807842530094, 0.33849902538845444, -0.34635326681462375, 0.5906807819572698, 0.04204862636797417, 0.4905166742359213, -0.013232169008841749, 0.569561409838533, -0.20842448531338964, 0.2856100977890174, -0.42528577322043226},
    {0.00484771190043402, 0.8599092025552983, 0.38243594983895596, 0.7909999265703808, 1.024735140084895, 0.5418770453585392, 0.695941101033872, 0.17069641051721068, 0.8650748156875275, -0.13577872372134311, 0.9084893470339992, 0.116455108954707, 0.7669218437762823, -0.3410646414135412, 0.16341233038103742, -0.1303340652298971},
    {-0.21876724649448198, 0.556695995302255, 0.22037796337363702, 0.482313519378183, 0.7890911101575765, -0.245050843271838, 0.7342674054936785, -0.041352414579056584, 0.6551072815741674, 0.202018933628051, 1.2703425031717357, 0.46380434553818917, 0.9237647695528168, -0.001106476054452085, 0.1695703800450491, -0.31969819923692167},
    {-0.2153265121310833, -0.03389740357422218, 0.19059762070660483, -0.21978490122253297, -0.07810588063081171, -0.24502144541994358, -0.38237956285318836, 0.1370666933775218, -0.238487838737436, -0.08615452616562692, 0.10387386205760298, -0.16505614243740074, 0.2327199389670403, -0.19337447954590153, 0.1219408901993227, 0.04158202359970101},
    {-0.18545014826435266, 0.7177840096155225, 0.5046235279259053, 0.8893703212342629, 0.9082474673798213, -0.188292402618729, 0.882409293123406, 0.13213882483472536, 0.9177831034671944, -0.13823968530132386, 0.5251006692682831, 0.0327809893603684, 1.084960403472483, 0.017648458035899085, -0.7469301050492044, 0.3204408108039895},
    {0.33576897609491674, 0.8842931157422195, 0.29532757406529997, 0.7527563305184999, 0.69880301086821, 0.4119245175256218, 0.7697886616388087, -0.26691035936512675, 0.8535771220037828, -0.2019762159020607, 0.986956630043364, 0.3851581978302729, 0.4995447770022515, -0.06056693502579752, 0.30848759742126314, -0.1899723784394429},
    {0.19726726780776696, 1.1699193572969204, 0.5602573526225814, 1.0517457694251116, 0.9771073931314758, -0.37133513849701544, 0.7416013610105158, -0.3032158812859227, 0.5639065082066156, -0.2997940841228464, 0.8414591334549094, -0.7122347798874972, 0.5767894104059925, -0.09749097261137399, -0.23475837782552395, 0.15777331914865306},
    {-0.1494017210816832, 0.2074187921360556, 0.9060815185978288, 0.7019255319225157, 0.6278424969220066, 0.21485746472636907, 0.25682668164104927, -0.13025860756653806, 0.8360561635875724, -0.3357069917002767, 0.8050638422039024, -0.17385951524244805, 0.4917947490786703, -0.06265229356629953, -0.16861970894791714, 0.1564769660707357},
    {0.14924863683727246, 0.47983912589357125, 0.5157784780193893, 0.626878783021904, 0.2808496638546595, -0.12396285328129704, 0.9417476508653866, -0.45232250059959683, 0.609255616423758, 0.19914397833060637, 0.5478384935119271, -0.17009605468120204, 0.6854604981140906, -0.040614179639846024, 0.20884073238124462, 0.12324315768036705},
    {0.013887231818734637, 0.5485612321418475, 0.7254217498526777, 0.719812368135965, 0.7992322592356503, -0.08501108722771286, 0.5920201968053355, 0.17908256222847418, 0.980407655161358, 0.24480410647933804, 0.8399163784535162, 0.17621093947151326, 0.9533577884714545, -0.2315970431164543, -0.17356217355493583, 0.378729713573002},
    {0.14094224741430328, 0.9701568907811132, 0.3750220681350516, 0.8629169176822112, 0.43245618956109644, -0.059752026621835146, 0.6256703909724851, -0.15707920124248514, 0.8879325877858113, -0.0567896563001509, 0.7404878271099973, 0.054322341278016724, 0.5733346392171289, -0.36182149604710906, -0.031379123341768136, -0.18115589827730033},
    {-0.180889502172997, 0.42450541904092176, 0.6384555155123318, 0.93661423345821, 0.9210291996719002, -0.19051346140631156, 1.0528565704407735, -0.41426384938474353, 1.2880106824250361, 0.052885646597647086, 0.9668836070467351, -0.008421175363643825, 0.6588092112864521, 0.0632587535166095, 0.05159481199003002, -0.3173176173949852},
    {-0.03141767422782171, 0.8961705966613654, 0.26682808163464783, 0.9673654092905853, 0.6600777043147337, 0.1506812055152745, 1.243437856684556, 0.1817167847434288, 0.385022315855454, 0.20031881053751507, 0.8408749992247193, 0.2702913319458579, 1.1846698888111808, 0.2788362204846189, -0.20755382736998584, -0.2198869852251568},
    {-0.26523407484285777, 0.7253456751548067, 0.3509826505342312, 1.1044887605681857, 0.8190117928893795, -0.21865411943351623, 0.7600704258166172, 0.17543307271963005, 1.0469897087213706, 0.1791351686766431, 0.6824398556601367, 0.15239855504045685, 0.929247011571994, 0.16681734270960552, -0.3434351300144119, 0.01844386698699045},
    {-0.22475166794565302, 0.579342708584674, 1.046550010769795, 0.8250708417089537, 0.6948235892921234, 0.6465409318365116, 0.4022867075389837, 0.17562959356130045, 0.47495250465526273, 0.23937069576596637, 0.5482143506821279, 0.02375606496828686, 0.6741989098714706, 0.1694126612248945, -0.34968085566265433, 0.2377863541728042},
    {-0.0534700471469876, 0.8737963947518806, 0.42107005535493036, 0.5873565535941125, 0.8164757115853498, -0.15590338511032223, 1.3184379360660483, 0.4183247153150893, 1.2297149911132241, -0.016699584172753093, 0.7568293895665605, -0.2356946615873719, 0.663734335749723, 0.20911219405464262, -0.03180414808366609, 0.211852313960672},
    {-0.07091771787557631, 0.8662635752182779, 0.4941183303429777, 0.9640116821950324, 0.6686604212216195, -0.20945601166960684, 0.8878364086947229, 0.4567230195519934, 1.1359266854347116, -0.0817263966401445, 0.6200753737358498, 0.14213701450969032, 0.8145166455131442, -0.46122011005834007, -0.1180314251087617, 0.02294459930006021},
    {0.08062057011561279, 1.2765729569977193, 0.249656376952681, 0.6681038741797829, 0.7531330448653075, -0.31571296159272594, 1.0265030531918284, 0.3907741799717728, 0.6402862724961911, -0.058532396125932286, 0.7228584684303696, -0.14182863699735304, 0.4674891324860999, 0.014305335795350798, -0.3358766396673717, -0.10480540038133235},
    {0.09200325405581573, 0.9938220630974808, 0.23743166669901872, 0.8038281672814279, 1.042470547947587, -0.09866604881976188, 0.6564083936347945, -0.05233356203099884, 1.135996378117907, 0.13816514897721524, 0.9462279554526593, -0.49675339359062165, 0.7004822023451589, 0.10267174235178957, -0.4165723253318719, 0.13301676021684206},
    {-0.15346141463115964, 0.6138915669604729, 0.6375368712820659, 0.2897249401941231, 0.7464385092143727, 0.28510693816791616, 0.8795723211199891, 0.5011877806277126, 0.13958946569580036, -0.2722459857993955, 1.0601532104865796, -0.18235038899881426, 0.6925507552540424, 0.03822459360635299, 0.0181392568981843, -0.12225142143867232},
    {-0.16557644004903188, 0.858624850383303, 0.6587648029670418, 0.8768917475157325, 0.8826782084313516, 0.2961482574793878, 0.8246667069598365, -0.05319412982275283, 0.6793591754570626, -0.16506349638494083, 0.831204496339196, -0.39228301739939897, 0.6095687851498605, 0.1848889806246388, -0.07580270111104004, 0.12455447873967163},
    {0.42493774532382295, 0.9010569074223137, 0.509516620971955, 0.6839049803665532, 0.5689969424290383, -0.08769868734819657, 1.0139442968609838, -0.2586229699126254, 1.2141044704306945, 0.10712259425341969, 0.7823083593630116, -0.14817408843694746, 0.8258819405848351, -0.4349327874266103, -0.07369974513760506, -0.44967991500210674},
    {-0.10833435477453734, 0.816772339577929, 0.19048299893982834, 0.8337607024183503, 0.4112257807295122, -0.17989219542177362, 1.1877086994188364, -0.02896920886191267, 1.0330928933562558, -0.35613578398113643, 0.7636760232746103, 0.14023464340889288, 0.8109044938141369, -0.2446208968237929, -0.1546596902135164, 0.16972071981760303},
    {0.39387627064590985, 0.9589116921230326, 0.17686672518688343, 0.66391218220556, 0.910631036560564, 0.2298279452226394, 0.615517345516772, -0.24898505180246108, 0.7389835849619184, 0.16551570374019062, 0.33024174531343103, -0.025633177538122318, 0.8831515534842475, -0.5443305663734189, 0.1693393697327363, -0.3980610828355205},
    {-0.1311741731528102, 1.0713671002922514, 0.28597219857631756, 1.1927526874565506, 0.4162177026565499, 0.011653455267995964, 0.45621990756614406, 0.2539318024568492, 0.6354022117667334, 0.07638284400841265, 0.7022150223069544, -0.03456998265094017, 0.6248246931184389, -0.21107973565031998, 0.11060409184560971, 0.17648584255528907},
    {-0.16576150411246052, -0.2975972198412919, -0.0794563657301589, -0.10220628982595185, 0.33178899180778376, 0.050639993928254474, -0.15242253436735112, 0.2628658888331921, 0.3681943763413748, 0.1834742556634679, -0.24543028016043886, -0.061653665092925684, 0.033756324350054955, 0.16089660308224923, 0.3857216450516458, -0.2763966481147951},
    {0.1334122127630246, 0.6516206560761975, 0.45544223800286404, 0.915381543228531, 0.7069692956652077, -0.14924176250387963, 0.9875745327843004, -0.4052927014612154, 0.893858436314521, -0.3666378789550846, 0.8496518155945528, -0.007953612321815802, 0.6430363631324459, -0.032363647109654024, 0.2018219156741176, 0.005678067579771964},
    {-0.37430451485779836, 0.7170624756447085, 0.5038211475121736, 0.8195599748053103, 0.5407992473977917, -0.06972657595461199, 0.6591956009301011, -0.19011520344444147, 0.9186868417220716, 0.1717257680984222, 0.5135280079659786, -0.30336774254260457, 0.7886845912385245, 0.05766703731466906, 0.0631281644422768, -0.04519772635128774},
    {-0.13044747541159066, 0.8792619441913331, 0.444407597442039, 0.5444977707624536, 0.9737376019831435, -0.018370991005391565, 0.7819438972014883, 0.09361557803975186, 0.7784137467723552, 0.1780320485159206, 1.0818607751742437, 0.11845432621174457, 0.553263809777256, -0.2973585901549728, 0.6239036014902359, -0.33790824627727806},
    {0.16206422655772212, 1.088490032274428, 0.30599503547870543, 1.223769677794853, 0.6166141742192709, -0.16797360022445884, 0.6584259022006936, -0.45708592715965096, 0.5333289601363603, -0.1042334523248006, 0.8208790817483532, -0.2669015983247396, 1.1853535157866606, 0.3824075544052006, -0.17050411684586322, -0.30149872429963853},
    {-0.24942267177298907, 0.5333504198324523, 0.5964152855759872, 0.7173830073588786, 0.8858200917600195, -0.2487877264676792, 1.0490875024970499, -0.32964540332147996, 0.7574222942901991, -0.1742023787540186, 1.0494698794206927, -0.09248250558450655, 0.6066779596810125, 0.14587349692479157, -0.02120948539851787, -0.0034190665673964195},
    {0.028809650930476938, 0.8951179873856937, 0.44261647585340247, 0.6315005920161217, 0.9734021281750875, -0.4665391066695003, 0.5676697528801175, -0.2745272973915838, 1.0491801402993552, 0.3403695487215642, 0.7596163103260871, -0.3732446396137022, 1.437786388952245, 0.08875989315098305, -0.014102886781068582, 0.18941825884458505}
};

static const float b3[16] = {-0.05330518058454182, 0.48545538448645503, 0.30203560031287335, 0.4894691465111681, 0.6176111250517302, -0.04335561902654737, 0.5306184397338151, -0.035005747078319105, 0.49334042454537613, -0.03974928207744479, 0.5478729225508078, -0.01958176700587761, 0.5283381691822414, -0.053968650864832074, -0.04128258960138791, -0.07624118726353987};

static const float w4[16][12] = {
    {-0.14574014004453326, 0.8210593992744118, -0.428556970663813, -0.18299346524007254, -0.4494401257402399, -0.019188933372866666, -0.0358618992045795, 0.08254114442370424, 0.6374275928877363, -0.11659421095875415, 0.04691700422495346, -0.4131708461449106},
    {-0.34695418117917914, -0.5266961984759382, -0.5795520095003286, -0.4844004872380961, -0.992717645915804, -0.9772366848523246, -0.3215516822325063, -0.5898205514246402, -0.5237309310526098, -0.03376445716504924, -0.9792911313345407, -0.7964334671515269},
    {-0.6805176661194584, -0.17192049658324884, -0.9427773037970185, -0.10488974009068625, -0.6865776684285734, -0.5035620963319982, -0.31412438537971793, -0.6364551351495362, -0.15705698068632568, -0.32348030293988467, -0.43413324105307693, -0.8119756100266782},
    {-1.0126429446696492, -0.9754487781369761, -0.6656732612954369, -0.34647377352589903, -0.6489293523118558, -0.05639302041339054, -0.5310398223083, -0.9381335443773882, -0.799975106065227, -1.1348353853352786, -0.6059285551149205, -0.2832573222179553},
    {-0.654275536142131, -0.6680621995681175, -0.7587923620113873, -0.5525577368619005, -0.050347655162595394, -0.4530387644031712, -0.6629178372227179, -0.5692718372388702, -0.5644477994917313, -0.6583516907402807, -0.6303824045851344, -0.7451913506883366},
    {-0.408316673119655, 0.353668508494432, -0.18175314363826356, -0.339504338518214, 0.3616973341897, 0.16064793723458887, -0.4220179217722605, 0.10815708290631296, -0.2721972446413797, -0.6951376611048524, -0.09226990005131958, 0.5337680095938654},
    {-0.21911511982866047, -0.8426881239720536, -0.6372016360328002, -0.8966691416578819, -0.5135431916308836, -0.24426165487390092, -0.5757865908553343, -0.3683455075451809, -0.5564856145672105, -1.0921140283409552, -0.17150938791845194, -0.8908132238576167},
    {-0.5478167122531814, -0.017941093060888813, -0.3935888432085612, -0.2340908893026681, -0.10090602858636666, -0.009298625316423862, -0.24614928164812563, 0.34039726334088183, 0.2048071208895442, 0.16756940883028426, 0.4142018599406074, -0.24201927421498717},
    {-0.5061430000664318, -0.5330783386446961, -0.7447215557167695, -1.2496486400895093, -0.8619583639359193, -1.058413400299977, -0.7852486265441883, -0.6581845593021164, -0.8980917004173337, -0.1522142116458314, -0.4729462524089934, -0.29606010324307414},
    {-0.24551027131201147, 0.18922692465264682, 0.06676267991712861, -0.427267215622798, 0.17966540147411356, -0.006716546515430976, -0.18493839757575742, 0.32914712426027365, 0.07835974523565262, -0.2829458670258789, -0.2012629214672183, 0.4631780952173764},
    {-0.9227662786674634, -0.5486964597157759, -0.45620855910338176, -0.5112803767420754, -0.8279397079847662, -0.807571815035129, -1.09433978196279, -0.45119450809000283, -0.6905711877893773, -0.6509245053302726, -1.058986171474468, -0.5098122055133573},
    {-0.3511635359325778, -0.1902485047631188, -0.4017840809536559, -0.03691286309732488, -0.478107866660369, -0.0803115251083407, -0.7128117285583766, 0.32526143042543126, -0.21663367406254033, 0.13253189257677367, -0.09377454747428018, 0.4112573188353239},
    {-0.6950850995566216, -0.5293591590768493, -0.35580050362479676, -0.5974806141868294, -0.38115864366896784, -0.7785806306603988, -0.5754652272449637, -0.7832413280071582, -0.5860393413680667, -0.8641164463383763, -0.5782755257612016, -0.7557766843109492},
    {0.22406663452757866, -0.04479198568111751, -0.40684954994999506, -0.35135119068716764, 0.420639878135439, 0.21445989911621066, 0.16616957493842352, 0.31315800022385626, 0.04791076980454375, 0.06550420972157489, 0.4987990354374079, 0.030368425009836702},
    {0.07737069564000269, -0.02137453911892607, 0.19853077296769706, -0.0790890846549891, 0.09408246859402107, -0.1107350089705336, -0.1006990674058672, 0.0792596879125433, -0.10488069138925044, 0.724496561476023, -0.30385526688359116, 0.7403669738430066},
    {-0.25377428982417, 0.611870553726991, 0.6138863125784139, -0.5004620545800664, 0.4946857583948116, 0.20800717345798128, -0.13901966662303908, -0.5774783935688977, -0.09003613293243255, 0.05912437078769558, -0.501222805492642, 0.39249699248561315}
};

static const float b4[12] = {-0.16825040640757022, -0.281693121515505, -0.2229133971185443, -0.30464439439975854, -0.18063011512871044, -0.22635315735751924, -0.14111302700176517, -0.2536550606478242, -0.2191932374889775, -0.19825707046685606, -0.2395259776964942, -0.172295399073415};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
